C15 (n27 VSS) capacitor c=1.62034e-18
C16 (n25 VSS) capacitor c=2.4065e-18
C17 (n21 VSS) capacitor c=2.59276e-18
C18 (n41 VSS) capacitor c=2.18324e-18
C19 (n26 VSS) capacitor c=8.39168e-17
C20 (n22 VSS) capacitor c=3.74072e-20
C21 (\3\:CK VSS) capacitor c=4.97808e-17
C22 (\1\:D VSS) capacitor c=9.16872e-17
C23 (\7\:CKbb VSS) capacitor c=9.24547e-17
C24 (\11\:CKb VSS) capacitor c=3.57187e-17
C25 (\12\:RN VSS) capacitor c=8.17093e-17
C26 (\4\:n20 VSS) capacitor c=4.69247e-17
C27 (\4\:CKb VSS) capacitor c=3.29774e-17
C28 (\22\:qbint VSS) capacitor c=1.04048e-16
C29 (\1\:CK VSS) capacitor c=3.14425e-17
C30 (\3\:D VSS) capacitor c=2.61293e-17
C31 (\9\:CKb VSS) capacitor c=4.3337e-17
C32 (\5\:CKbb VSS) capacitor c=3.83352e-17
C33 (\3\:mout VSS) capacitor c=6.81352e-17
C34 (\11\:RN VSS) capacitor c=9.60582e-17
C35 (\3\:n20 VSS) capacitor c=4.14361e-17
C36 (\3\:CKbb VSS) capacitor c=2.65076e-17
C37 (\8\:CKb VSS) capacitor c=3.07063e-17
C38 (\24\:qbint VSS) capacitor c=3.58842e-17
C39 (\3\:CKb VSS) capacitor c=3.52114e-17
C40 (\10\:n30 VSS) capacitor c=6.70896e-17
C41 (\4\:RN VSS) capacitor c=4.69958e-17
C42 (\7\:RN VSS) capacitor c=2.09183e-17
C43 (\6\:n30 VSS) capacitor c=2.53745e-17
C44 (\5\:n30 VSS) capacitor c=3.53831e-17
C45 (\1\:RN VSS) capacitor c=4.48559e-17
C46 (\4\:CK VSS) capacitor c=1.59124e-17
C47 (\2\:D VSS) capacitor c=5.31665e-17
C48 (\8\:CKbb VSS) capacitor c=7.64868e-17
C49 (\10\:CKb VSS) capacitor c=3.81517e-17
C50 (\12\:CKb VSS) capacitor c=2.21108e-17
C51 (\6\:CKbb VSS) capacitor c=3.95899e-17
C52 (\2\:mout VSS) capacitor c=7.13404e-17
C53 (\13\:RN VSS) capacitor c=2.85876e-17
C54 (\7\:CKb VSS) capacitor c=2.82601e-17
C55 (\4\:CKbb VSS) capacitor c=4.65939e-17
C56 (\2\:CKbb VSS) capacitor c=4.30031e-17
C57 (\6\:CKb VSS) capacitor c=5.03836e-17
C58 (\23\:qbint VSS) capacitor c=5.37371e-17
C59 (\2\:CKb VSS) capacitor c=2.75036e-17
C60 (\9\:RN VSS) capacitor c=2.05763e-17
C61 (\21\:CKb VSS) capacitor c=2.89478e-17
C62 (\1\:VDD VSS) capacitor c=3.46952e-17
C63 (\5\:n20 VSS) capacitor c=6.3929e-17
C64 (\16\:VDD VSS) capacitor c=1.92721e-17
C65 (\3\:n26 VSS) capacitor c=8.56186e-17
C66 (\18\:VDD VSS) capacitor c=5.87954e-17
C67 (\6\:mout VSS) capacitor c=7.30119e-17
C68 (\15\:n30 VSS) capacitor c=1.49919e-16
C69 (\20\:VDD VSS) capacitor c=3.47664e-17
C70 (\13\:CKbb VSS) capacitor c=1.30471e-16
C71 (\28\:qbint VSS) capacitor c=3.1328e-16
C72 (\3\:VDD VSS) capacitor c=9.499e-17
C73 (\17\:CKb VSS) capacitor c=6.80173e-17
C74 (\9\:n20 VSS) capacitor c=6.64563e-17
C75 (\8\:mout VSS) capacitor c=4.73962e-17
C76 (\17\:n30 VSS) capacitor c=9.97588e-17
C77 (\15\:CKbb VSS) capacitor c=7.07157e-17
C78 (\26\:qbint VSS) capacitor c=8.93605e-17
C79 (\32\:qbint VSS) capacitor c=1.05612e-16
C80 (\5\:CKb VSS) capacitor c=4.58431e-17
C81 (\2\:n20 VSS) capacitor c=2.46398e-17
C82 (\2\:CK VSS) capacitor c=3.54218e-17
C83 (\25\:qbint VSS) capacitor c=8.19394e-17
C84 (\35\:qbint VSS) capacitor c=5.4676e-17
C85 (\13\:CKb VSS) capacitor c=7.66252e-17
C86 (\14\:CKb VSS) capacitor c=7.53816e-17
C87 (\16\:RN VSS) capacitor c=1.40075e-16
C88 (\17\:RN VSS) capacitor c=1.41715e-16
C89 (\4\:mout VSS) capacitor c=8.52561e-17
C90 (\5\:mout VSS) capacitor c=8.61065e-17
C91 (\15\:CKb VSS) capacitor c=1.89088e-16
C92 (\16\:CKb VSS) capacitor c=1.64637e-16
C93 (\7\:n20 VSS) capacitor c=1.35125e-16
C94 (\8\:n20 VSS) capacitor c=9.11673e-17
C95 (\9\:CKbb VSS) capacitor c=9.89913e-17
C96 (\10\:CKbb VSS) capacitor c=1.67564e-16
C97 (\11\:CKbb VSS) capacitor c=1.77462e-16
C98 (\12\:CKbb VSS) capacitor c=1.66389e-16
C99 (\17\:CKbb VSS) capacitor c=4.03836e-17
C100 (\18\:CKbb VSS) capacitor c=6.54119e-17
C101 (\4\:D VSS) capacitor c=8.46385e-17
C102 (\19\:CKb VSS) capacitor c=1.13518e-16
C103 (\20\:CKb VSS) capacitor c=9.27916e-17
C104 (\5\:CK VSS) capacitor c=4.60985e-17
C105 (\5\:VDD VSS) capacitor c=1.88042e-17
C106 (\6\:VDD VSS) capacitor c=3.88364e-17
C107 (\8\:VDD VSS) capacitor c=5.55753e-16
Rk28 (\16\:RN \17\:RN) resistor r=1.1387 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.342 c=0
Rk50 (\3\:VSS \5\:VSS) resistor r=0.1127 c=0
Rk51 (\5\:VSS \6\:VSS) resistor r=0.4314 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.6221 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.09922 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.4127 c=0
Rk60 (\10\:VSS VSS) resistor r=0.1074 c=0
Rk55 (\9\:VSS \10\:VSS) resistor r=0.4814 c=0
Rk61 (\3\:VSS \16\:VSS) resistor r=0.2084 c=0
Rk62 (\6\:VSS \18\:VSS) resistor r=0.172 c=0
Rk63 (\8\:VSS \20\:VSS) resistor r=0.04334 c=0
Rk64 (\9\:VSS \22\:VSS) resistor r=0.2715 c=0
Rk69 (\2\:VDD \4\:VDD) resistor r=0.4343 c=0
Rk70 (\4\:VDD \5\:VDD) resistor r=0.2247 c=0
Rk71 (\5\:VDD \6\:VDD) resistor r=0.2772 c=0
Rk72 (\6\:VDD \7\:VDD) resistor r=0.5499 c=0
Rk81 (\8\:VDD VDD) resistor r=0.1024 c=0
Rk73 (\7\:VDD \8\:VDD) resistor r=0.2931 c=0
Rk82 (\5\:VDD \17\:VDD) resistor r=0.04334 c=0
Rk83 (\6\:VDD \19\:VDD) resistor r=0.2682 c=0
Rk84 (\7\:VDD \21\:VDD) resistor r=0.07151 c=0
Rk48 (\5\:CK CK) resistor r=0.2394 c=0
Rk44 (D \4\:D) resistor r=0.03877 c=0
Rk17 (\27\:qbint \28\:qbint) resistor r=0.4135 c=0
Rk16 (\25\:qbint \27\:qbint) resistor r=0.5351 c=0
Rk21 (\28\:qbint \35\:qbint) resistor r=0.3289 c=0
Rk26 (n30 \16\:n30) resistor r=0.8935 c=0
Rk27 (\16\:n30 \18\:n30) resistor r=0.4297 c=0
Rk23 (\13\:CKb \14\:CKb) resistor r=0.3079 c=0
Rk33 (\15\:CKb \16\:CKb) resistor r=1.3472 c=0
Rk45 (\18\:CKb \19\:CKb) resistor r=0.4985 c=0
Rk46 (\19\:CKb \20\:CKb) resistor r=0.5278 c=0
Rk47 (\19\:CKb \22\:CKb) resistor r=0.3024 c=0
Rk37 (\9\:CKbb \10\:CKbb) resistor r=0.7757 c=0
Rk38 (\10\:CKbb \11\:CKbb) resistor r=0.8188 c=0
Rk39 (\11\:CKbb \12\:CKbb) resistor r=0.6677 c=0
Rk40 (\12\:CKbb \14\:CKbb) resistor r=0.6165 c=0
Rk41 (\14\:CKbb \16\:CKbb) resistor r=0.3494 c=0
Rk42 (\10\:CKbb \17\:CKbb) resistor r=0.1685 c=0
Rk43 (\11\:CKbb \18\:CKbb) resistor r=0.2674 c=0
Rk29 (\4\:mout \5\:mout) resistor r=0.4754 c=0
Rk30 (\5\:mout \7\:mout) resistor r=0.2669 c=0
Rk31 (\5\:mout \9\:mout) resistor r=0.09549 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3854 c=0
Rk35 (\7\:n20 \8\:n20) resistor r=0.5859 c=0
Rk36 (\7\:n20 \10\:n20) resistor r=0.3536 c=0
Rk32 (\2\:n26 \4\:n26) resistor r=0.2663 c=0
Rl51 (\11\:RN \12\:RN) resistor r=247.643 c=0
Rl29 (RN \4\:RN) resistor r=35.772 c=0
Rl31 (RN \7\:RN) resistor r=33.8482 c=0
Rl21 (RN \1\:RN) resistor r=30.7692 c=0
Rl52 (\13\:RN \12\:RN) resistor r=172.59 c=0
Rl33 (\9\:RN RN) resistor r=32.2114 c=0
Rl63 (\2\:CK \3\:CK) resistor r=216.817 c=0
Rl62 (\1\:CK \2\:CK) resistor r=86.0004 c=0
Rl64 (\2\:CK \4\:CK) resistor r=9.6389 c=0
Rl60 (\1\:D \2\:D) resistor r=143.464 c=0
Rl61 (\2\:D \3\:D) resistor r=24.2328 c=0
Rl40 (\23\:qbint \22\:qbint) resistor r=158.356 c=0
Rl41 (\23\:qbint \24\:qbint) resistor r=26.098 c=0
Rl36 (n30 \10\:n30) resistor r=83.0007 c=0
Rl27 (n30 \6\:n30) resistor r=66.3231 c=0
Rl26 (n30 \5\:n30) resistor r=55.0028 c=0
Rl57 (\10\:CKb \11\:CKb) resistor r=39.1533 c=0
Rl56 (\9\:CKb \10\:CKb) resistor r=114.153 c=0
Rl58 (\11\:CKb \12\:CKb) resistor r=24.2328 c=0
Rl47 (\6\:CKb \8\:CKb) resistor r=30.5643 c=0
Rl38 (CKb \2\:CKb) resistor r=28.1713 c=0
Rl39 (\2\:CKb \3\:CKb) resistor r=37.1321 c=0
Rl44 (\4\:CKb \5\:CKb) resistor r=41.9892 c=0
Rl46 (\5\:CKb \7\:CKb) resistor r=40.3099 c=0
Rl45 (\5\:CKb \6\:CKb) resistor r=176.878 c=0
Rl59 (\7\:CKbb \8\:CKbb) resistor r=119.768 c=0
Rl55 (\5\:CKbb \6\:CKbb) resistor r=51.1559 c=0
Rl43 (\3\:CKbb \4\:CKbb) resistor r=45.3867 c=0
Rl42 (CKbb \2\:CKbb) resistor r=29.5379 c=0
Rl53 (mout \2\:mout) resistor r=116.106 c=0
Rl54 (\2\:mout \3\:mout) resistor r=74.2328 c=0
Rl50 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl49 (\2\:n20 \3\:n20) resistor r=117.022 c=0
Rl48 (n20 \2\:n20) resistor r=5.1171 c=0
Rz12 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz16 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz21 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz22 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz6 (\28\:qbint \32\:qbint) resistor r=75 c=0
Rz5 (\27\:qbint \26\:qbint) resistor r=75 c=0
Rz7 (\18\:n30 \17\:n30) resistor r=75 c=0
Rz11 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz10 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\9\:n20 \10\:n20) resistor r=75 c=0
Ry15 (\5\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry16 (\7\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\10\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry19 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry8 (\16\:n30 \15\:n30) resistor r=62 c=0
Ry14 (\21\:CKb \22\:CKb) resistor r=62 c=0
Ry13 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\6\:mout \7\:mout) resistor r=62 c=0
Ry12 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (n26 \2\:n26) resistor r=62 c=0
Ry11 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx9 (\16\:RN \13\:RN) resistor r=45 c=0
Rx10 (\17\:RN \9\:RN) resistor r=45 c=0
Rx21 (\4\:CK \5\:CK) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx4 (\35\:qbint qbint) resistor r=45 c=0
Rx5 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx6 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\12\:CKb \15\:CKb) resistor r=45 c=0
Rx13 (\7\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (\10\:CKb \20\:CKb) resistor r=45 c=0
Rx15 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx16 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx17 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx18 (\4\:CKbb \18\:CKbb) resistor r=45 c=0
Rx11 (\2\:mout \4\:mout) resistor r=45 c=0
Rx14 (n20 \8\:n20) resistor r=45 c=0
mn55_1__rcx (Q qbint \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=5.226e-14 ps=9.2286e-07 pd=9.4429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92881e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (16 \1\:RN \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.68e-14 ad=2.73e-14 ps=1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69e-06 sb=1.16e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_1__rcx (\32\:qbint \5\:n30 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.73e-14 ad=4.55e-14 ps=7.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=1.01e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_2__rcx (\32\:qbint \6\:n30 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.2e-14 ad=4.55e-14 ps=9.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.9e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn45_2__rcx (17 \7\:RN \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=5.2e-14 ps=1.03e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.45e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn45 (18 \4\:RN \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=1.56e-14 ps=1.03e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn46 (\26\:qbint \10\:n30 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn21 (\15\:CKbb \3\:CKb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.485e-14 ad=2.973e-14 ps=1.6e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\17\:CKb \1\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=2.03e-14 ps=7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn50 (n40 \24\:qbint \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.485e-14 ad=3.075e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=8.27167 scb=0.00612996 \
        scc=0.000112653 m=(1)
mn51 (\17\:n30 \8\:CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.075e-14 ad=9.737e-14 ps=7.1e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn40 (\17\:n30 \3\:CKbb \8\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.92e-14 ad=9.737e-14 ps=8.9e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.745e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn30 (\8\:mout \3\:n20 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.083e-14 ad=4.92e-14 ps=1.24e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=1.46e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn35 (n27 \11\:RN \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.083e-14 ad=1.23e-14 ps=1.24e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58e-06 sb=1.05e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.768e-14 ps=5.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=9.45e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn37 (\9\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=6.047e-14 ps=6.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=7.65e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn26 (\9\:n20 \9\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.047e-14 ps=8.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.25e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn25 (n21 \3\:D \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=4.92e-14 ps=6.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.27167 scb=0.00612996 \
        scc=0.000112653 m=(1)
mp45_1__rcx (\28\:qbint RN \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.878e-14 ad=6.695e-14 ps=1.36e-06 pd=1.12333e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.645e-06 sb=1.15577e-06 sd=160n \
        sca=19.0259 scb=0.0163587 scc=0.00171562 m=(3)
mp46_1__rcx (\28\:qbint n30 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.253e-14 ad=6.695e-14 ps=1.44e-06 pd=1.12333e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.85e-06 sb=9.50769e-07 sd=160n \
        sca=19.0259 scb=0.0163587 scc=0.00171562 m=(3)
mp21 (\13\:CKbb CKb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3643e-13 ad=2.63e-14 ps=2.11e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.53395e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\21\:CKb \3\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.01e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.23721e-07 sb=1.4e-07 sd=160n sca=15.9567 \
        scb=0.015497 scc=0.000381994 m=(1)
mp50 (n41 \22\:qbint \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3643e-13 ad=1.86e-14 ps=2.11e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.93548e-07 sb=1.28532e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\15\:n30 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=7.595e-14 ps=7.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.98548e-07 sb=1.18032e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\15\:n30 \4\:CKb \6\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1315e-13 ad=7.595e-14 ps=1.35e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.88548e-07 sb=8.90323e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\6\:mout \4\:n20 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.47e-14 ad=1.1315e-13 ps=1.32e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19855e-06 sb=4.80323e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (\3\:n26 \12\:RN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.47e-14 ad=8.525e-14 ps=1.32e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.73548e-07 sb=4.9e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp36 (\3\:n26 mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.75e-14 ad=8.525e-14 ps=1.54e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19355e-06 sb=1.7e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp37 (\5\:n20 \11\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=5.14e-14 ps=9e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65161e-07 sd=160n sca=21.39 \
        scb=0.0188316 scc=0.00214554 m=(1)
mp26 (\5\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.14e-14 ps=7.4e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.09435e-07 sb=4.58145e-07 sd=160n sca=16.2905 \
        scb=0.015087 scc=0.00109315 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=1.86e-14 ps=1.18e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.14435e-07 sb=3.53145e-07 sd=160n sca=16.6546 \
        scb=0.0152768 scc=0.00109326 m=(1)
ends DFFRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:34 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRX1
// View name: extracted

simulator lang=spectre

subckt DFFRX1 CK D Q QN RN VDD VSS
mp57 (\3\:QN qint \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=5.46e-14 ps=1.45e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.20705e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
mp55 (\1\:Q \6\:qbint \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=4.86e-14 ps=1.57e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24615e-07 sb=2.19808e-07 sd=160n sca=12.3498 \
        scb=0.0103223 scc=0.00031154 m=(1)
C1 (RN VSS) capacitor c=5.25167e-17
C2 (Q VSS) capacitor c=1.2268e-16
C3 (VDD VSS) capacitor c=3.10128e-16
C4 (QN VSS) capacitor c=2.0909e-17
C5 (CK VSS) capacitor c=3.9302e-17
C6 (qint VSS) capacitor c=4.61335e-17
C7 (qbint VSS) capacitor c=3.20329e-17
C8 (CKb VSS) capacitor c=3.20977e-17
C9 (n30 VSS) capacitor c=4.01357e-17
C10 (n40 VSS) capacitor c=1.78576e-18
C11 (mout VSS) capacitor c=4.81491e-17
C12 (CKbb VSS) capacitor c=6.12581e-17
C13 (n20 VSS) capacitor c=4.40124e-17
C14 (n27 VSS) capacitor c=8.3485e-19
C15 (n41 VSS) capacitor c=7.05852e-19
C16 (n26 VSS) capacitor c=6.51015e-17
C17 (\8\:CKb VSS) capacitor c=4.73849e-17
C18 (\1\:D VSS) capacitor c=7.26891e-17
C19 (\7\:CKbb VSS) capacitor c=5.2018e-17
C20 (\4\:CKb VSS) capacitor c=5.01919e-17
C21 (\6\:RN VSS) capacitor c=6.62006e-17
C22 (\2\:CKbb VSS) capacitor c=5.15011e-17
C23 (\11\:qbint VSS) capacitor c=5.66089e-17
C24 (\3\:RN VSS) capacitor c=3.68849e-17
C25 (\3\:n30 VSS) capacitor c=5.10383e-17
C26 (\3\:CK VSS) capacitor c=4.12928e-17
C27 (\6\:qbint VSS) capacitor c=6.26448e-17
C28 (\7\:qbint VSS) capacitor c=3.78821e-17
C29 (\7\:CKb VSS) capacitor c=5.97281e-17
C30 (\3\:D VSS) capacitor c=6.16188e-17
C31 (\6\:CKb VSS) capacitor c=7.75635e-17
C32 (\5\:CKbb VSS) capacitor c=3.97036e-17
C33 (\3\:mout VSS) capacitor c=5.15986e-17
C34 (\5\:RN VSS) capacitor c=7.47103e-17
C35 (\3\:n20 VSS) capacitor c=4.55869e-17
C36 (\3\:CKbb VSS) capacitor c=2.9334e-17
C37 (\3\:CKb VSS) capacitor c=8.5222e-17
C38 (\8\:qbint VSS) capacitor c=6.14692e-17
C39 (\1\:RN VSS) capacitor c=6.80842e-17
C40 (\1\:CK VSS) capacitor c=5.99813e-17
C41 (\5\:qbint VSS) capacitor c=2.69384e-17
C42 (\3\:qint VSS) capacitor c=4.00385e-17
C43 (\9\:CKb VSS) capacitor c=1.88209e-17
C44 (\2\:D VSS) capacitor c=6.95447e-17
C45 (\8\:CKbb VSS) capacitor c=4.35361e-17
C46 (\5\:CKb VSS) capacitor c=1.79468e-17
C47 (\6\:CKbb VSS) capacitor c=3.25925e-17
C48 (\2\:mout VSS) capacitor c=4.59082e-17
C49 (\7\:RN VSS) capacitor c=2.51527e-17
C50 (\2\:n20 VSS) capacitor c=4.83703e-17
C51 (\2\:CKb VSS) capacitor c=6.60925e-17
C52 (\4\:CKbb VSS) capacitor c=2.4988e-17
C53 (\10\:qbint VSS) capacitor c=6.43324e-17
C54 (\4\:RN VSS) capacitor c=2.58006e-17
C55 (\2\:RN VSS) capacitor c=5.56898e-17
C56 (\2\:n30 VSS) capacitor c=4.8656e-17
C57 (\2\:CK VSS) capacitor c=4.04319e-17
C58 (\2\:qint VSS) capacitor c=2.69077e-17
C59 (\9\:CKbb VSS) capacitor c=1.95509e-17
C60 (\1\:VDD VSS) capacitor c=3.98071e-17
C61 (\8\:n20 VSS) capacitor c=7.46681e-17
C62 (\12\:VDD VSS) capacitor c=1.61288e-17
C63 (\3\:n26 VSS) capacitor c=5.9766e-17
C64 (\14\:VDD VSS) capacitor c=2.38612e-17
C65 (\8\:mout VSS) capacitor c=6.70491e-17
C66 (\4\:n30 VSS) capacitor c=9.54193e-17
C67 (\16\:VDD VSS) capacitor c=2.68523e-17
C68 (\13\:qbint VSS) capacitor c=1.52991e-16
C69 (\18\:VDD VSS) capacitor c=1.13392e-17
C70 (\14\:CKb VSS) capacitor c=1.64616e-17
C71 (\20\:VDD VSS) capacitor c=6.09017e-18
C72 (\1\:Q VSS) capacitor c=6.19695e-17
C73 (\4\:qint VSS) capacitor c=2.95859e-17
C74 (\22\:VDD VSS) capacitor c=2.56028e-17
C75 (\3\:QN VSS) capacitor c=4.70588e-17
C76 (\3\:VDD VSS) capacitor c=3.41797e-17
C77 (\16\:CKbb VSS) capacitor c=4.47897e-17
C78 (\4\:n20 VSS) capacitor c=4.22937e-17
C79 (\6\:mout VSS) capacitor c=6.75641e-17
C80 (\8\:n30 VSS) capacitor c=6.55632e-17
C81 (\17\:qbint VSS) capacitor c=2.31289e-17
C82 (\17\:CKb VSS) capacitor c=1.23723e-16
C83 (\3\:Q VSS) capacitor c=4.47943e-17
C84 (\8\:qint VSS) capacitor c=4.06123e-17
C85 (\1\:QN VSS) capacitor c=1.88722e-17
C86 (\3\:qbint VSS) capacitor c=5.09346e-17
C87 (\4\:qbint VSS) capacitor c=2.81673e-17
C88 (\6\:qint VSS) capacitor c=3.46823e-17
C89 (\7\:qint VSS) capacitor c=3.3293e-17
C90 (\4\:CK VSS) capacitor c=5.47077e-17
C91 (\10\:RN VSS) capacitor c=3.61694e-17
C92 (\12\:qbint VSS) capacitor c=6.77411e-17
C93 (\15\:qbint VSS) capacitor c=1.69665e-16
C94 (\16\:qbint VSS) capacitor c=1.12424e-16
C95 (\6\:n30 VSS) capacitor c=9.52187e-17
C96 (\7\:n30 VSS) capacitor c=6.02374e-17
C97 (\11\:RN VSS) capacitor c=1.27882e-16
C98 (\12\:RN VSS) capacitor c=1.28226e-16
C99 (\4\:mout VSS) capacitor c=8.61292e-17
C100 (\5\:mout VSS) capacitor c=1.16458e-16
C101 (\6\:n20 VSS) capacitor c=1.06722e-16
C102 (\7\:n20 VSS) capacitor c=9.40181e-17
C103 (\4\:D VSS) capacitor c=5.13066e-17
C104 (\5\:D VSS) capacitor c=5.12868e-17
C105 (\10\:CKb VSS) capacitor c=6.00574e-17
C106 (\11\:CKb VSS) capacitor c=1.39222e-16
C107 (\12\:CKb VSS) capacitor c=2.15505e-16
C108 (\13\:CKb VSS) capacitor c=1.72548e-16
C109 (\16\:CKb VSS) capacitor c=8.54252e-17
C110 (\11\:CKbb VSS) capacitor c=6.53887e-17
C111 (\12\:CKbb VSS) capacitor c=1.37916e-16
C112 (\13\:CKbb VSS) capacitor c=1.92143e-16
C113 (\14\:CKbb VSS) capacitor c=2.04399e-16
C114 (\15\:CKbb VSS) capacitor c=1.16459e-16
C115 (\5\:VDD VSS) capacitor c=1.42265e-17
C116 (\6\:VDD VSS) capacitor c=2.66619e-17
C117 (\7\:VDD VSS) capacitor c=2.66514e-17
C118 (\8\:VDD VSS) capacitor c=7.92518e-18
C119 (\10\:VDD VSS) capacitor c=2.1553e-17
C120 (\11\:VDD VSS) capacitor c=8.58354e-18
Rk27 (D \4\:D) resistor r=0.002575 c=0
Rk29 (\4\:D \5\:D) resistor r=0.08163 c=0
Rk28 (\5\:D \6\:D) resistor r=0.002711 c=0
Rk9 (\8\:RN RN) resistor r=0.002553 c=0
Rk11 (\8\:RN \10\:RN) resistor r=0.04995 c=0
Rk10 (\9\:RN \10\:RN) resistor r=0.002553 c=0
Rk19 (\11\:RN \12\:RN) resistor r=0.789 c=0
Rk6 (\2\:Q Q) resistor r=0.4865 c=0
Rk7 (Q \4\:Q) resistor r=0.1415 c=0
Rk57 (\2\:VSS \4\:VSS) resistor r=0.4702 c=0
Rk58 (\4\:VSS \5\:VSS) resistor r=0.3537 c=0
Rk59 (\5\:VSS \6\:VSS) resistor r=0.4062 c=0
Rk60 (\6\:VSS \7\:VSS) resistor r=0.2433 c=0
Rk61 (\7\:VSS \8\:VSS) resistor r=0.1479 c=0
Rk63 (\9\:VSS VSS) resistor r=0.1175 c=0
Rk62 (\8\:VSS \9\:VSS) resistor r=0.2857 c=0
Rk64 (\5\:VSS \11\:VSS) resistor r=0.1971 c=0
Rk65 (\6\:VSS \13\:VSS) resistor r=0.2596 c=0
Rk66 (\8\:VSS \15\:VSS) resistor r=0.3681 c=0
Rk67 (\9\:VSS \17\:VSS) resistor r=0.1654 c=0
Rk42 (\2\:VDD \4\:VDD) resistor r=0.2412 c=0
Rk43 (\4\:VDD \5\:VDD) resistor r=0.1906 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.1995 c=0
Rk45 (\6\:VDD \7\:VDD) resistor r=0.3516 c=0
Rk46 (\7\:VDD \8\:VDD) resistor r=0.1995 c=0
Rk47 (\8\:VDD \9\:VDD) resistor r=0.05753 c=0
Rk48 (\9\:VDD \10\:VDD) resistor r=0.1529 c=0
Rk50 (\11\:VDD VDD) resistor r=0.1175 c=0
Rk49 (\10\:VDD \11\:VDD) resistor r=0.2807 c=0
Rk51 (\5\:VDD \13\:VDD) resistor r=0.07452 c=0
Rk52 (\6\:VDD \15\:VDD) resistor r=0.04336 c=0
Rk53 (\7\:VDD \17\:VDD) resistor r=0.04336 c=0
Rk54 (\8\:VDD \19\:VDD) resistor r=0.07452 c=0
Rk55 (\10\:VDD \21\:VDD) resistor r=0.07452 c=0
Rk56 (\11\:VDD \23\:VDD) resistor r=0.226 c=0
Rk1 (QN \2\:QN) resistor r=0.07831 c=0
Rk2 (QN \4\:QN) resistor r=0.2631 c=0
Rk8 (CK \4\:CK) resistor r=0.01859 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1283 c=0
Rk4 (\6\:qint \7\:qint) resistor r=0.1527 c=0
Rk5 (\6\:qint \9\:qint) resistor r=0.1582 c=0
Rk12 (\12\:qbint \14\:qbint) resistor r=0.4065 c=0
Rk13 (\14\:qbint \15\:qbint) resistor r=0.661 c=0
Rk14 (\15\:qbint \16\:qbint) resistor r=0.6497 c=0
Rk15 (\15\:qbint \18\:qbint) resistor r=0.05851 c=0
Rk30 (\10\:CKb \11\:CKb) resistor r=0.4135 c=0
Rk31 (\11\:CKb \12\:CKb) resistor r=0.8185 c=0
Rk32 (\12\:CKb \13\:CKb) resistor r=0.7863 c=0
Rk33 (\13\:CKb \15\:CKb) resistor r=0.04533 c=0
Rk34 (\12\:CKb \16\:CKb) resistor r=0.3496 c=0
Rk35 (\13\:CKb \18\:CKb) resistor r=0.622 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.4593 c=0
Rk17 (\6\:n30 \7\:n30) resistor r=0.2969 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.2332 c=0
Rk20 (\4\:mout \5\:mout) resistor r=0.4705 c=0
Rk21 (\5\:mout \7\:mout) resistor r=0.2339 c=0
Rk22 (\5\:mout \9\:mout) resistor r=0.2521 c=0
Rk36 (\10\:CKbb \11\:CKbb) resistor r=0.1997 c=0
Rk37 (\11\:CKbb \12\:CKbb) resistor r=0.2525 c=0
Rk38 (\12\:CKbb \13\:CKbb) resistor r=0.7801 c=0
Rk39 (\13\:CKbb \14\:CKbb) resistor r=0.9789 c=0
Rk40 (\14\:CKbb \15\:CKbb) resistor r=0.5606 c=0
Rk41 (\11\:CKbb \17\:CKbb) resistor r=0.3235 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.2043 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.4947 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.3888 c=0
Rk23 (\2\:n26 \4\:n26) resistor r=0.3398 c=0
Rl33 (\1\:D \2\:D) resistor r=71.8291 c=0
Rl34 (\2\:D \3\:D) resistor r=148.655 c=0
Rl25 (\5\:RN \6\:RN) resistor r=147.643 c=0
Rl26 (\6\:RN \7\:RN) resistor r=87.2302 c=0
Rl15 (\3\:RN \4\:RN) resistor r=87.2302 c=0
Rl14 (\2\:RN \3\:RN) resistor r=24.2328 c=0
Rl13 (\1\:RN \2\:RN) resistor r=114.617 c=0
Rl10 (\2\:CK \3\:CK) resistor r=25.981 c=0
Rl9 (\1\:CK \2\:CK) resistor r=134.615 c=0
Rl1 (qint \2\:qint) resistor r=24.2328 c=0
Rl2 (\2\:qint \3\:qint) resistor r=39.6174 c=0
Rl3 (qbint \2\:qbint) resistor r=24.5191 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=116.541 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=20.2932 c=0
Rl8 (\4\:qbint \7\:qbint) resistor r=53.0797 c=0
Rl6 (\4\:qbint \5\:qbint) resistor r=35.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=126.286 c=0
Rl18 (\9\:qbint \11\:qbint) resistor r=37.2816 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=125.981 c=0
Rl17 (\9\:qbint \10\:qbint) resistor r=0.5166 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=216.873 c=0
Rl31 (\4\:CKb \6\:CKb) resistor r=190.385 c=0
Rl36 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl30 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl21 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl22 (\2\:CKb \3\:CKb) resistor r=173.334 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=106.868 c=0
Rl11 (n30 \2\:n30) resistor r=36.9358 c=0
Rl27 (mout \2\:mout) resistor r=83.8482 c=0
Rl28 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl32 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=26.1559 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=26.098 c=0
Rl19 (CKbb \2\:CKbb) resistor r=33.8727 c=0
Rl23 (n20 \2\:n20) resistor r=24.2328 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=114.617 c=0
Rz3 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz12 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=37.5 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz10 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz11 (\3\:VDD \9\:VDD) resistor r=6.25 c=0
Rz1 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\17\:qbint \18\:qbint) resistor r=75 c=0
Rz8 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz7 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=31 c=0
Ry19 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry20 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry16 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry17 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry18 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry10 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry11 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry7 (n26 \2\:n26) resistor r=62 c=0
Ry8 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx11 (\2\:D \6\:D) resistor r=45 c=0
Rx3 (\2\:RN \9\:RN) resistor r=45 c=0
Rx7 (\7\:RN \11\:RN) resistor r=45 c=0
Rx8 (\4\:RN \12\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx4 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx5 (\2\:qbint \16\:qbint) resistor r=45 c=0
Rx12 (\9\:CKb \10\:CKb) resistor r=45 c=0
Rx13 (\5\:CKb \11\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx6 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx15 (\8\:CKbb \12\:CKbb) resistor r=45 c=0
Rx16 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx17 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx18 (CKbb \15\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
mn57 (\1\:QN \3\:qint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.71e-14 ad=3.64e-14 ps=1.6e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.56154e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn56 (\8\:qint \5\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.71e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\17\:CKb \1\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.538e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn46 (\17\:qbint n30 n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.103e-14 ps=4.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.47862e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn45 (n35 \1\:RN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=1.42069e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn50 (n40 \8\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.015e-14 ps=6.1e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.26276e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn51 (\8\:n30 \3\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.14776e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn40 (\8\:n30 \3\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=9.42759e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn30 (\6\:mout \3\:n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.14e-14 ad=2.973e-14 ps=1.45e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=6.92759e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn35 (n27 \5\:RN \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.14e-14 ad=1.233e-14 ps=1.45e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38448e-07 sb=1.06e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=1.958e-14 ps=4.6e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.68448e-07 sb=9.3e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn37 (\4\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.48448e-07 sb=7.5e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn26 (\4\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=2.32e-14 ps=4.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15345e-06 sb=5.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=1.233e-14 ps=7.5e-07 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28345e-06 sb=4.15e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn21 (\16\:CKbb \7\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.335e-14 ad=2.03e-14 ps=7.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46207e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp56 (\4\:qint \7\:qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=2.63e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.22326e-07 sd=160n sca=49.623 \
        scb=0.0330309 scc=0.00593405 m=(1)
mp20 (\14\:CKb \3\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=2.63e-14 ps=1.57e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07093e-07 sb=1.22326e-07 sd=160n sca=13.1731 \
        scb=0.0123493 scc=0.000501177 m=(1)
mp46 (\13\:qbint \3\:n30 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.545e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.48e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp45 (\13\:qbint \3\:RN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.62e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.275e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n41 \11\:qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.62e-14 ad=1.72e-14 ps=1.83e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=1.08e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp51 (\4\:n30 \2\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.44e-14 ps=5.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=9.55e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\4\:n30 CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.44e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=7.5e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\8\:mout n20 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.62e-14 ad=4.408e-14 ps=1.83e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=5e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp35 (\3\:n26 \6\:RN \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.62e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=3.05e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\3\:n26 mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.688e-14 ad=3.44e-14 ps=1.74e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp37 (\8\:n20 \4\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.63e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.42326e-07 sd=160n sca=12.9421 \
        scb=0.0117495 scc=0.000425199 m=(1)
mp26 (\8\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=4.37326e-07 sd=160n sca=13.7253 \
        scb=0.0122307 scc=0.000425663 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.508e-14 ad=1.29e-14 ps=1.58e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.32326e-07 sb=3.32326e-07 sd=160n sca=14.4668 \
        scb=0.0130588 scc=0.000428492 m=(1)
mp21 (\9\:CKbb \8\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.508e-14 ad=2.63e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.42326e-07 sb=1.22326e-07 sd=160n sca=18.1027 \
        scb=0.0191499 scc=0.000568936 m=(1)
ends DFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:35 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRX2
// View name: extracted

simulator lang=spectre

subckt DFFRX2 CK D Q QN RN VDD VSS
mp21 (\18\:CKbb CKb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=3.01e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.95e-07 sd=160n sca=31.5849 \
        scb=0.0355206 scc=0.00288112 m=(1)
mp25 (n22 \3\:D \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=1.29e-14 ps=1.75e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5e-07 sd=160n sca=24.3526 scb=0.023887 \
        scc=0.00211511 m=(1)
mp26 (\4\:n20 CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=3.95e-07 sd=160n sca=23.0263 \
        scb=0.0218192 scc=0.0020924 m=(1)
mp37 (\4\:n20 \4\:CKb \3\:n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.4e-07 sd=160n sca=21.5982 \
        scb=0.0204624 scc=0.00208846 m=(1)
mp36 (n26 mout \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=3.44e-14 ps=1.46e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.35047e-06 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp35 (n26 \5\:RN \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.14547e-06 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp30 (\5\:mout n20 \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=6.88e-14 ps=1.56e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=8.80465e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp40 (\8\:n30 \8\:CKb \5\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=3.44e-14 ps=1.2e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12791e-07 sb=8.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp51 (\8\:n30 \7\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.17791e-07 sb=6.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp50 (n41 \4\:qbint \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.078e-14 ad=1.29e-14 ps=1.75e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02279e-06 sb=5.35e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp20 (\12\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.05e-14 ad=3.01e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01058e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp56 (\7\:qint \12\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.78023e-07 sb=1.4e-07 sd=160n sca=48.6469 \
        scb=0.0430734 scc=0.00580912 m=(1)
C1 (CK VSS) capacitor c=7.27633e-17
C2 (RN VSS) capacitor c=4.064e-17
C3 (Q VSS) capacitor c=6.3874e-17
C4 (VDD VSS) capacitor c=2.93527e-16
C5 (D VSS) capacitor c=7.16748e-17
C6 (QN VSS) capacitor c=3.40047e-17
C7 (CKb VSS) capacitor c=4.89891e-17
C8 (CKbb VSS) capacitor c=5.81459e-17
C9 (n21 VSS) capacitor c=1.44146e-19
C10 (n20 VSS) capacitor c=5.4758e-17
C11 (n27 VSS) capacitor c=1.04253e-18
C12 (mout VSS) capacitor c=3.55295e-17
C13 (n30 VSS) capacitor c=4.94147e-17
C14 (qbint VSS) capacitor c=2.66285e-17
C15 (qint VSS) capacitor c=1.8184e-16
C16 (n26 VSS) capacitor c=7.92715e-17
C17 (n41 VSS) capacitor c=9.81012e-19
C18 (\12\:qbint VSS) capacitor c=4.81902e-17
C19 (\5\:qbint VSS) capacitor c=5.17415e-16
C20 (\1\:CK VSS) capacitor c=4.11234e-17
C21 (\1\:RN VSS) capacitor c=7.9408e-17
C22 (\4\:qbint VSS) capacitor c=6.44392e-17
C23 (\7\:CKbb VSS) capacitor c=6.13839e-17
C24 (\8\:CKb VSS) capacitor c=5.61247e-17
C25 (\5\:RN VSS) capacitor c=4.58904e-17
C26 (\4\:CKb VSS) capacitor c=4.19082e-17
C27 (\3\:D VSS) capacitor c=6.16209e-17
C28 (\13\:qbint VSS) capacitor c=3.30012e-17
C29 (\3\:CK VSS) capacitor c=4.58573e-17
C30 (\3\:n30 VSS) capacitor c=4.97015e-17
C31 (\2\:RN VSS) capacitor c=1.42943e-16
C32 (\3\:qbint VSS) capacitor c=5.48864e-17
C33 (\7\:CKb VSS) capacitor c=7.74229e-17
C34 (\5\:CKbb VSS) capacitor c=3.77204e-17
C35 (\3\:n20 VSS) capacitor c=4.03323e-17
C36 (\3\:RN VSS) capacitor c=1.01727e-16
C37 (\4\:mout VSS) capacitor c=7.62805e-17
C38 (\3\:CKbb VSS) capacitor c=7.39895e-17
C39 (\6\:CKb VSS) capacitor c=6.47092e-17
C40 (\1\:D VSS) capacitor c=6.99964e-17
C41 (\3\:CKb VSS) capacitor c=4.31092e-17
C42 (\14\:qbint VSS) capacitor c=2.19898e-17
C43 (\2\:CK VSS) capacitor c=3.60048e-17
C44 (\2\:n30 VSS) capacitor c=4.09643e-17
C45 (\8\:CKbb VSS) capacitor c=4.94731e-17
C46 (\9\:CKb VSS) capacitor c=2.47866e-17
C47 (\6\:CKbb VSS) capacitor c=4.48211e-17
C48 (\2\:n20 VSS) capacitor c=4.22521e-17
C49 (\4\:RN VSS) capacitor c=4.32345e-17
C50 (\3\:mout VSS) capacitor c=5.45684e-17
C51 (\4\:CKbb VSS) capacitor c=3.03556e-17
C52 (\5\:CKb VSS) capacitor c=2.02127e-17
C53 (\2\:CKbb VSS) capacitor c=4.84213e-17
C54 (\2\:D VSS) capacitor c=6.99067e-17
C55 (\2\:CKb VSS) capacitor c=1.95448e-17
C56 (\7\:qint VSS) capacitor c=1.97639e-17
C57 (\1\:VDD VSS) capacitor c=2.23966e-16
C58 (\1\:QN VSS) capacitor c=8.30422e-17
C59 (\3\:Q VSS) capacitor c=4.99756e-17
C60 (\12\:CKb VSS) capacitor c=1.26904e-16
C61 (\17\:VDD VSS) capacitor c=1.0997e-17
C62 (\23\:qbint VSS) capacitor c=2.68483e-17
C63 (\19\:VDD VSS) capacitor c=1.1169e-17
C64 (\8\:n30 VSS) capacitor c=6.36878e-17
C65 (\5\:mout VSS) capacitor c=2.60621e-17
C66 (\21\:VDD VSS) capacitor c=2.04498e-17
C67 (\23\:VDD VSS) capacitor c=1.50253e-17
C68 (\3\:n26 VSS) capacitor c=6.67824e-17
C69 (\4\:n20 VSS) capacitor c=7.98769e-17
C70 (\25\:VDD VSS) capacitor c=1.47406e-17
C71 (\18\:CKbb VSS) capacitor c=4.09409e-17
C72 (\4\:VDD VSS) capacitor c=2.25636e-17
C73 (\11\:qint VSS) capacitor c=2.16293e-17
C74 (\3\:QN VSS) capacitor c=5.35135e-17
C75 (\1\:Q VSS) capacitor c=8.38493e-17
C76 (\10\:CKb VSS) capacitor c=1.28476e-16
C77 (\18\:qbint VSS) capacitor c=1.35312e-16
C78 (\6\:n30 VSS) capacitor c=7.73847e-17
C79 (\9\:mout VSS) capacitor c=9.51675e-17
C80 (\7\:n20 VSS) capacitor c=3.53061e-17
C81 (\14\:CKbb VSS) capacitor c=1.79723e-17
C82 (\2\:qbint VSS) capacitor c=3.43949e-17
C83 (\4\:D VSS) capacitor c=4.32252e-17
C84 (\6\:RN VSS) capacitor c=9.01754e-17
C85 (\6\:n20 VSS) capacitor c=7.21603e-17
C86 (\9\:n20 VSS) capacitor c=1.13625e-16
C87 (\7\:mout VSS) capacitor c=9.59256e-17
C88 (\8\:mout VSS) capacitor c=1.09521e-16
C89 (\9\:CKbb VSS) capacitor c=1.83218e-17
C90 (\10\:CKbb VSS) capacitor c=2.00054e-16
C91 (\11\:CKbb VSS) capacitor c=1.79837e-16
C92 (\12\:CKbb VSS) capacitor c=9.4783e-17
C93 (\13\:CKbb VSS) capacitor c=3.63386e-17
C94 (\16\:CKbb VSS) capacitor c=6.68921e-17
C95 (\17\:CKbb VSS) capacitor c=2.78994e-17
C96 (\4\:n30 VSS) capacitor c=6.33006e-17
C97 (\5\:n30 VSS) capacitor c=1.05525e-16
C98 (\14\:CKb VSS) capacitor c=1.55902e-16
C99 (\15\:CKb VSS) capacitor c=1.42326e-16
C100 (\16\:CKb VSS) capacitor c=5.74096e-17
C101 (\4\:CK VSS) capacitor c=3.1183e-17
C102 (\15\:qbint VSS) capacitor c=6.10281e-17
C103 (\20\:qbint VSS) capacitor c=8.09542e-17
C104 (\21\:qbint VSS) capacitor c=5.01252e-17
C105 (\9\:qint VSS) capacitor c=1.85303e-17
C106 (\10\:qint VSS) capacitor c=2.93262e-17
C107 (\7\:VDD VSS) capacitor c=1.55655e-17
C108 (\8\:VDD VSS) capacitor c=3.1798e-17
C109 (\9\:VDD VSS) capacitor c=2.4363e-17
C110 (\11\:VDD VSS) capacitor c=1.31804e-17
C111 (\12\:VDD VSS) capacitor c=1.68346e-17
Rk43 (\1\:VSS \7\:VSS) resistor r=0.4036 c=0
Rk44 (\7\:VSS \8\:VSS) resistor r=0.4664 c=0
Rk45 (\8\:VSS \9\:VSS) resistor r=0.1378 c=0
Rk46 (\9\:VSS \10\:VSS) resistor r=0.3311 c=0
Rk48 (\11\:VSS VSS) resistor r=0.12 c=0
Rk47 (\10\:VSS \11\:VSS) resistor r=0.09999 c=0
Rk51 (\7\:VSS \17\:VSS) resistor r=0.3332 c=0
Rk52 (\8\:VSS \19\:VSS) resistor r=0.2329 c=0
Rk53 (\10\:VSS \21\:VSS) resistor r=0.3758 c=0
Rk54 (\11\:VSS \23\:VSS) resistor r=0.3487 c=0
Rk25 (\4\:CK CK) resistor r=0.05603 c=0
Rk3 (RN \6\:RN) resistor r=0.04104 c=0
Rk26 (\2\:Q Q) resistor r=0.3252 c=0
Rk27 (Q \4\:Q) resistor r=0.04214 c=0
Rk58 (\1\:VDD \7\:VDD) resistor r=0.1728 c=0
Rk59 (\7\:VDD \8\:VDD) resistor r=0.2129 c=0
Rk60 (\8\:VDD \9\:VDD) resistor r=0.4714 c=0
Rk61 (\9\:VDD \10\:VDD) resistor r=0.1479 c=0
Rk62 (\10\:VDD \11\:VDD) resistor r=0.08669 c=0
Rk64 (\12\:VDD VDD) resistor r=0.1351 c=0
Rk63 (\11\:VDD \12\:VDD) resistor r=0.3274 c=0
Rk67 (\7\:VDD \18\:VDD) resistor r=0.0744 c=0
Rk68 (\8\:VDD \20\:VDD) resistor r=0.0744 c=0
Rk69 (\9\:VDD \22\:VDD) resistor r=0.1282 c=0
Rk70 (\11\:VDD \24\:VDD) resistor r=0.04335 c=0
Rk71 (\12\:VDD \26\:VDD) resistor r=0.0744 c=0
Rk1 (\4\:D D) resistor r=0.1374 c=0
Rk28 (QN \2\:QN) resistor r=0.01693 c=0
Rk29 (\2\:QN \4\:QN) resistor r=0.3926 c=0
Rk21 (\11\:CKb \13\:CKb) resistor r=0.5029 c=0
Rk22 (\13\:CKb \14\:CKb) resistor r=0.7008 c=0
Rk23 (\14\:CKb \15\:CKb) resistor r=0.8998 c=0
Rk24 (\15\:CKb \16\:CKb) resistor r=0.3943 c=0
Rk10 (\9\:CKbb \10\:CKbb) resistor r=0.02034 c=0
Rk11 (\10\:CKbb \11\:CKbb) resistor r=1.2437 c=0
Rk12 (\10\:CKbb \12\:CKbb) resistor r=0.5668 c=0
Rk13 (\12\:CKbb \13\:CKbb) resistor r=0.3042 c=0
Rk14 (\13\:CKbb \15\:CKbb) resistor r=0.1244 c=0
Rk15 (\11\:CKbb \16\:CKbb) resistor r=0.2021 c=0
Rk16 (\12\:CKbb \17\:CKbb) resistor r=0.09051 c=0
Rk17 (\13\:CKbb \19\:CKbb) resistor r=0.2497 c=0
Rk4 (\5\:n20 \6\:n20) resistor r=0.3868 c=0
Rk5 (\6\:n20 \8\:n20) resistor r=0.1173 c=0
Rk6 (\6\:n20 \9\:n20) resistor r=0.4879 c=0
Rk7 (\6\:mout \7\:mout) resistor r=0.08144 c=0
Rk8 (\7\:mout \8\:mout) resistor r=0.5445 c=0
Rk9 (\7\:mout \10\:mout) resistor r=0.3932 c=0
Rk18 (\4\:n30 \5\:n30) resistor r=0.3267 c=0
Rk19 (\5\:n30 \7\:n30) resistor r=0.3229 c=0
Rk20 (\5\:n30 \9\:n30) resistor r=0.4154 c=0
Rk30 (\15\:qbint \5\:qbint) resistor r=0.4368 c=0
Rk32 (\5\:qbint \19\:qbint) resistor r=0.7558 c=0
Rk33 (\19\:qbint \20\:qbint) resistor r=0.5071 c=0
Rk34 (\20\:qbint \21\:qbint) resistor r=0.1814 c=0
Rk36 (\20\:qbint \24\:qbint) resistor r=0.1113 c=0
Rk37 (\8\:qint \9\:qint) resistor r=0.1587 c=0
Rk38 (\9\:qint \10\:qint) resistor r=0.1659 c=0
Rk39 (\9\:qint \12\:qint) resistor r=0.1184 c=0
Rk2 (\2\:n26 \4\:n26) resistor r=0.259 c=0
Rl27 (\1\:CK \2\:CK) resistor r=37.6365 c=0
Rl28 (\2\:CK \3\:CK) resistor r=97.2519 c=0
Rl21 (\1\:RN \2\:RN) resistor r=140.385 c=0
Rl22 (\2\:RN \3\:RN) resistor r=591.873 c=0
Rl24 (\4\:RN \5\:RN) resistor r=56.9251 c=0
Rl23 (\3\:RN \4\:RN) resistor r=91.5405 c=0
Rl5 (\2\:D \3\:D) resistor r=24.2328 c=0
Rl4 (\1\:D \2\:D) resistor r=162.26 c=0
Rl15 (\7\:CKb \8\:CKb) resistor r=184.181 c=0
Rl7 (\4\:CKb \6\:CKb) resistor r=140.385 c=0
Rl2 (CKb \3\:CKb) resistor r=151.923 c=0
Rl16 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl6 (\4\:CKb \5\:CKb) resistor r=35.7713 c=0
Rl1 (CKb \2\:CKb) resistor r=35.7713 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=31.0185 c=0
Rl14 (\5\:CKbb \6\:CKbb) resistor r=71.8456 c=0
Rl8 (\3\:CKbb \4\:CKbb) resistor r=51.1559 c=0
Rl3 (CKbb \2\:CKbb) resistor r=37.6944 c=0
Rl12 (n20 \2\:n20) resistor r=124.233 c=0
Rl13 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl9 (mout \2\:mout) resistor r=37.3411 c=0
Rl11 (\2\:mout \4\:mout) resistor r=129.649 c=0
Rl10 (\2\:mout \3\:mout) resistor r=0.6051 c=0
Rl25 (n30 \2\:n30) resistor r=103.562 c=0
Rl26 (\2\:n30 \3\:n30) resistor r=26.1559 c=0
Rl39 (\13\:qbint \12\:qbint) resistor r=100 c=0
Rl40 (\14\:qbint \13\:qbint) resistor r=29.5379 c=0
Rl20 (\2\:qbint \4\:qbint) resistor r=45.868 c=0
Rl19 (\2\:qbint \3\:qbint) resistor r=97.7911 c=0
Rl18 (\2\:qbint qbint) resistor r=4.3192 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz14 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz15 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz16 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz6 (\2\:Q \1\:Q) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=7.5 c=0
Rz18 (\10\:VDD \4\:VDD) resistor r=6.25 c=0
Rz7 (\4\:QN \3\:QN) resistor r=75 c=0
Rz5 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\9\:mout \10\:mout) resistor r=75 c=0
Rz4 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz8 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz9 (\12\:qint \11\:qint) resistor r=75 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry13 (\9\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry8 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry9 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry7 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry5 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry3 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry10 (\24\:qbint \23\:qbint) resistor r=62 c=0
Ry11 (\8\:qint \7\:qint) resistor r=62 c=0
Ry1 (n26 \2\:n26) resistor r=62 c=0
Ry2 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx13 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\4\:RN \6\:RN) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\9\:CKb \14\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \15\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx5 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (\3\:mout \8\:mout) resistor r=45 c=0
Rx9 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx14 (\15\:qbint \14\:qbint) resistor r=45 c=0
Rx16 (\21\:qbint qbint) resistor r=45 c=0
Rx18 (\10\:qint qint) resistor r=45 c=0
mn21 (\14\:CKbb \3\:CKb \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn25 (n21 \1\:D \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.088e-14 ps=5.7e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn26 (\7\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=3.118e-14 ps=4.4e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=1.975e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn37 (\7\:n20 \3\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.118e-14 ps=4.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.715e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn36 (n25 \4\:mout n27 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.61e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn35 (n27 \3\:RN \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.4e-14 ad=2.03e-14 ps=1.09e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.425e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn30 (\9\:mout \3\:n20 \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.4e-14 ad=2.32e-14 ps=1.09e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=1.14e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn40 (\6\:n30 \5\:CKbb \9\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.553e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=9.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn51 (\6\:n30 \7\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=6.45e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn50 (n40 \3\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.138e-14 ad=1.958e-14 ps=7.6e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=4.65e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn20 (\10\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=2.465e-14 ps=9.2e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.21e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn56 (\11\:qint \13\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=2.03e-14 ps=1.59e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.4e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn45 (n35 \2\:RN \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.138e-14 ad=1.23e-14 ps=7.6e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43683e-06 sb=2.45e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn46 (\18\:qbint \3\:n30 n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47463e-06 sb=1.4e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn57 (\3\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.877e-14 ad=4.16e-14 ps=1.59e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.90673e-07 sb=4.46058e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(2)
mn55 (\1\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.565e-14 ad=4.16e-14 ps=1.255e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75673e-07 sb=8.61058e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(2)
mp45 (\23\:qbint \1\:RN \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.078e-14 ad=4.96e-14 ps=1.75e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.00242e-07 sb=3.15e-07 sd=160n sca=17.9343 \
        scb=0.0166254 scc=0.0014837 m=(1)
mp46 (\23\:qbint n30 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10524e-06 sb=1.1e-07 sd=160n sca=17.9343 \
        scb=0.0166254 scc=0.0014837 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.242e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.57115e-07 sb=8.55064e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp57_1__rcx (\1\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.812e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.72115e-07 sb=4.40064e-07 sd=160n sca=26.8 \
        scb=0.0196695 scc=0.0027789 m=(2)
ends DFFRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:37 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRX4
// View name: extracted

simulator lang=spectre

subckt DFFRX4 CK D Q QN RN VDD VSS
mp20 (\15\:CKb \1\:CK \34\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.63e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22326e-07 sd=160n sca=29.2967 \
        scb=0.0344712 scc=0.00236568 m=(1)
mp21 (\15\:CKbb CKb \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.553e-14 ad=2.63e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.63488e-07 sd=160n sca=16.9238 \
        scb=0.0162651 scc=0.000960412 m=(1)
mp25 (n22 \4\:D \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.553e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42326e-07 sb=4.43488e-07 sd=160n sca=15.9472 \
        scb=0.0155426 scc=0.000959336 m=(1)
mp26 (\7\:n20 CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.47326e-07 sb=3.38488e-07 sd=160n sca=15.6925 \
        scb=0.0154666 scc=0.00095932 m=(1)
mp37 (\7\:n20 \5\:CKb \3\:n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.52326e-07 sb=1.33488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp36 (n26 mout \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=3.762e-14 ps=1.58e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp35 (n26 \1\:RN \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.762e-14 ps=1.66e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp30 (\9\:mout n20 \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.762e-14 ps=1.66e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp40 (\10\:n30 \7\:CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp51 (\10\:n30 \5\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.44e-14 ps=6.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp50 (n41 \3\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.787e-14 ad=2.365e-14 ps=1.07e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
C1 (RN VSS) capacitor c=2.13863e-16
C2 (Q VSS) capacitor c=3.04805e-17
C3 (VDD VSS) capacitor c=3.24888e-16
C4 (D VSS) capacitor c=5.70003e-17
C5 (QN VSS) capacitor c=3.61673e-17
C6 (CK VSS) capacitor c=1.97995e-17
C7 (CKb VSS) capacitor c=4.54989e-17
C8 (CKbb VSS) capacitor c=6.13514e-17
C9 (n21 VSS) capacitor c=4.54287e-19
C10 (n20 VSS) capacitor c=6.77418e-17
C11 (mout VSS) capacitor c=3.61906e-17
C12 (n30 VSS) capacitor c=1.25986e-16
C13 (n40 VSS) capacitor c=1.13137e-18
C14 (qbint VSS) capacitor c=5.49959e-17
C15 (23 VSS) capacitor c=1.67967e-18
C16 (qint VSS) capacitor c=2.50102e-16
C17 (n26 VSS) capacitor c=8.17747e-17
C18 (n41 VSS) capacitor c=5.56498e-19
C19 (\21\:qbint VSS) capacitor c=4.36485e-17
C20 (\4\:qbint VSS) capacitor c=2.63432e-16
C21 (\3\:qbint VSS) capacitor c=4.11835e-17
C22 (\5\:CKbb VSS) capacitor c=9.04489e-17
C23 (\7\:CKb VSS) capacitor c=6.65259e-17
C24 (\1\:RN VSS) capacitor c=4.92177e-17
C25 (\5\:CKb VSS) capacitor c=5.54612e-17
C26 (\4\:D VSS) capacitor c=6.85087e-17
C27 (\1\:CK VSS) capacitor c=3.27127e-17
C28 (\19\:qbint VSS) capacitor c=2.36888e-17
C29 (\9\:RN VSS) capacitor c=5.70004e-17
C30 (\5\:n30 VSS) capacitor c=4.25644e-17
C31 (\7\:n30 VSS) capacitor c=4.6114e-17
C32 (\4\:RN VSS) capacitor c=4.46887e-17
C33 (\9\:CKb VSS) capacitor c=3.85379e-17
C34 (\6\:CKbb VSS) capacitor c=9.84723e-17
C35 (\4\:n20 VSS) capacitor c=3.50265e-17
C36 (\3\:RN VSS) capacitor c=7.26425e-17
C37 (\4\:mout VSS) capacitor c=8.4082e-17
C38 (\3\:CKbb VSS) capacitor c=4.44456e-17
C39 (\4\:CKb VSS) capacitor c=7.9661e-17
C40 (\1\:D VSS) capacitor c=7.71756e-17
C41 (\3\:CKb VSS) capacitor c=4.52981e-17
C42 (\3\:CK VSS) capacitor c=2.54088e-17
C43 (\20\:qbint VSS) capacitor c=3.43701e-17
C44 (\5\:RN VSS) capacitor c=4.59791e-16
C45 (\2\:qbint VSS) capacitor c=4.18205e-17
C46 (\10\:CKb VSS) capacitor c=4.42995e-17
C47 (\8\:CKb VSS) capacitor c=2.50552e-17
C48 (\3\:n20 VSS) capacitor c=3.40269e-17
C49 (\2\:RN VSS) capacitor c=7.02915e-17
C50 (\7\:CKbb VSS) capacitor c=5.51247e-17
C51 (\3\:mout VSS) capacitor c=5.45575e-17
C52 (\4\:CKbb VSS) capacitor c=2.33279e-17
C53 (\6\:CKb VSS) capacitor c=2.36448e-17
C54 (\2\:CKbb VSS) capacitor c=4.855e-17
C55 (\3\:D VSS) capacitor c=2.81917e-17
C56 (\2\:CKb VSS) capacitor c=2.01368e-17
C57 (\2\:CK VSS) capacitor c=2.41542e-17
C58 (\16\:qint VSS) capacitor c=3.28564e-17
C59 (\1\:VDD VSS) capacitor c=4.54536e-16
C60 (\1\:Q VSS) capacitor c=1.52393e-16
C61 (\19\:VDD VSS) capacitor c=6.00666e-17
C62 (\10\:n30 VSS) capacitor c=7.63073e-17
C63 (\9\:mout VSS) capacitor c=2.91359e-17
C64 (\25\:VDD VSS) capacitor c=1.82957e-17
C65 (\28\:VDD VSS) capacitor c=1.70096e-17
C66 (\3\:n26 VSS) capacitor c=6.78229e-17
C67 (\7\:n20 VSS) capacitor c=9.45246e-17
C68 (\32\:VDD VSS) capacitor c=1.56496e-17
C69 (\15\:CKbb VSS) capacitor c=6.02253e-17
C70 (\15\:CKb VSS) capacitor c=8.79323e-17
C71 (\34\:VDD VSS) capacitor c=3.66996e-17
C72 (\3\:VDD VSS) capacitor c=4.68542e-17
C73 (\19\:qint VSS) capacitor c=4.63894e-17
C74 (\1\:QN VSS) capacitor c=9.94303e-17
C75 (\32\:qbint VSS) capacitor c=9.93349e-17
C76 (\12\:n30 VSS) capacitor c=2.88256e-17
C77 (\5\:mout VSS) capacitor c=8.87213e-17
C78 (\9\:n20 VSS) capacitor c=2.92878e-17
C79 (\12\:CKbb VSS) capacitor c=2.63128e-17
C80 (\17\:CKb VSS) capacitor c=8.24391e-17
C81 (\2\:D VSS) capacitor c=4.45544e-17
C82 (\2\:n20 VSS) capacitor c=2.77813e-17
C83 (\4\:n30 VSS) capacitor c=2.97277e-17
C84 (\4\:CK VSS) capacitor c=6.71731e-17
C85 (\5\:D VSS) capacitor c=5.71961e-17
C86 (\8\:CKbb VSS) capacitor c=5.63907e-17
C87 (\9\:CKbb VSS) capacitor c=7.31827e-17
C88 (\10\:CKbb VSS) capacitor c=1.1287e-16
C89 (\11\:CKbb VSS) capacitor c=6.44735e-17
C90 (\14\:CKbb VSS) capacitor c=4.84343e-17
C91 (\5\:n20 VSS) capacitor c=8.42529e-17
C92 (\6\:n20 VSS) capacitor c=5.29389e-17
C93 (\7\:mout VSS) capacitor c=1.05864e-16
C94 (\8\:mout VSS) capacitor c=1.09057e-16
C95 (\11\:CKb VSS) capacitor c=1.1196e-16
C96 (\12\:CKb VSS) capacitor c=1.35121e-16
C97 (\13\:CKb VSS) capacitor c=1.19758e-16
C98 (\14\:CKb VSS) capacitor c=7.19623e-17
C99 (\8\:n30 VSS) capacitor c=1.11732e-16
C100 (\9\:n30 VSS) capacitor c=1.01552e-16
C101 (\13\:RN VSS) capacitor c=7.68134e-17
C102 (\22\:qbint VSS) capacitor c=3.64782e-17
C103 (\23\:qbint VSS) capacitor c=1.98797e-16
C104 (\25\:qbint VSS) capacitor c=5.00076e-17
C105 (\4\:Q VSS) capacitor c=1.05305e-16
C106 (\5\:QN VSS) capacitor c=1.34744e-16
C107 (\30\:qbint VSS) capacitor c=1.61531e-16
C108 (\31\:qbint VSS) capacitor c=1.74137e-16
C109 (\34\:qbint VSS) capacitor c=4.69171e-17
C110 (\18\:qint VSS) capacitor c=3.28338e-17
C111 (\21\:qint VSS) capacitor c=4.018e-17
C112 (\24\:VDD VSS) capacitor c=2.56772e-17
C113 (\27\:VDD VSS) capacitor c=8.81669e-18
C114 (\31\:VDD VSS) capacitor c=2.63334e-17
Rk25 (\5\:RN RN) resistor r=1.0104 c=0
Rk27 (RN \13\:RN) resistor r=0.4493 c=0
Rk34 (\1\:Q Q) resistor r=0.02269 c=0
Rk35 (Q \4\:Q) resistor r=0.1695 c=0
Rk83 (\1\:VDD \20\:VDD) resistor r=0.3386 c=0
Rk86 (\1\:VDD \24\:VDD) resistor r=0.3726 c=0
Rk87 (\24\:VDD \26\:VDD) resistor r=0.04335 c=0
Rk88 (\24\:VDD \27\:VDD) resistor r=0.2461 c=0
Rk89 (\27\:VDD \29\:VDD) resistor r=0.04335 c=0
Rk90 (\27\:VDD \30\:VDD) resistor r=0.07916 c=0
Rk93 (\31\:VDD VDD) resistor r=0.2985 c=0
Rk91 (\30\:VDD \31\:VDD) resistor r=0.2533 c=0
Rk92 (\31\:VDD \33\:VDD) resistor r=0.0744 c=0
Rk94 (VDD \35\:VDD) resistor r=0.3591 c=0
Rk2 (D \5\:D) resistor r=0.1358 c=0
Rk41 (\5\:QN QN) resistor r=0.0313 c=0
Rk40 (\1\:QN \5\:QN) resistor r=0.2838 c=0
Rk56 (\1\:VSS \10\:VSS) resistor r=0.3541 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.47 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.2829 c=0
Rk59 (\12\:VSS \13\:VSS) resistor r=0.1504 c=0
Rk60 (\13\:VSS \14\:VSS) resistor r=0.11 c=0
Rk62 (\15\:VSS VSS) resistor r=0.01963 c=0
Rk61 (\14\:VSS \15\:VSS) resistor r=0.2706 c=0
Rk67 (\10\:VSS \25\:VSS) resistor r=0.04335 c=0
Rk68 (\11\:VSS \27\:VSS) resistor r=0.2745 c=0
Rk69 (\13\:VSS \29\:VSS) resistor r=0.3267 c=0
Rk70 (\14\:VSS \31\:VSS) resistor r=0.3389 c=0
Rk71 (\15\:VSS \33\:VSS) resistor r=0.1181 c=0
Rk1 (\4\:CK CK) resistor r=0.03605 c=0
Rk16 (\11\:CKb \12\:CKb) resistor r=0.6407 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.7242 c=0
Rk18 (\13\:CKb \14\:CKb) resistor r=0.3675 c=0
Rk19 (\14\:CKb \16\:CKb) resistor r=0.2937 c=0
Rk20 (\16\:CKb \18\:CKb) resistor r=0.4952 c=0
Rk3 (\8\:CKbb \9\:CKbb) resistor r=0.1893 c=0
Rk4 (\9\:CKbb \10\:CKbb) resistor r=0.5888 c=0
Rk5 (\10\:CKbb \11\:CKbb) resistor r=0.3129 c=0
Rk6 (\11\:CKbb \13\:CKbb) resistor r=0.1099 c=0
Rk7 (\10\:CKbb \14\:CKbb) resistor r=0.1589 c=0
Rk8 (\11\:CKbb \16\:CKbb) resistor r=0.3577 c=0
Rk10 (\5\:n20 \6\:n20) resistor r=0.3886 c=0
Rk11 (\6\:n20 \8\:n20) resistor r=0.4402 c=0
Rk12 (\6\:n20 \10\:n20) resistor r=0.09494 c=0
Rk13 (\6\:mout \7\:mout) resistor r=0.4457 c=0
Rk14 (\7\:mout \8\:mout) resistor r=0.5264 c=0
Rk15 (\7\:mout \10\:mout) resistor r=0.08508 c=0
Rk21 (\8\:n30 \9\:n30) resistor r=0.6092 c=0
Rk22 (\9\:n30 \11\:n30) resistor r=0.3959 c=0
Rk23 (\9\:n30 \13\:n30) resistor r=0.06376 c=0
Rk28 (\22\:qbint \23\:qbint) resistor r=0.249 c=0
Rk30 (\23\:qbint \25\:qbint) resistor r=0.2635 c=0
Rk44 (\30\:qbint \31\:qbint) resistor r=0.9752 c=0
Rk45 (\31\:qbint \33\:qbint) resistor r=0.907 c=0
Rk46 (\31\:qbint \34\:qbint) resistor r=0.2455 c=0
Rk47 (\17\:qint \18\:qint) resistor r=0.1135 c=0
Rk48 (\18\:qint \20\:qint) resistor r=0.303 c=0
Rk49 (\18\:qint \21\:qint) resistor r=0.2316 c=0
Rk9 (\2\:n26 \4\:n26) resistor r=0.2129 c=0
Rl35 (\5\:RN \9\:RN) resistor r=37.2302 c=0
Rl26 (\5\:RN \4\:RN) resistor r=26.9231 c=0
Rl15 (\2\:RN \1\:RN) resistor r=49.9772 c=0
Rl16 (\2\:RN \3\:RN) resistor r=97.872 c=0
Rl8 (\2\:D \4\:D) resistor r=66.0479 c=0
Rl6 (\1\:D \2\:D) resistor r=161.847 c=0
Rl7 (\2\:D \3\:D) resistor r=8.149 c=0
Rl1 (\1\:CK \2\:CK) resistor r=85.3072 c=0
Rl2 (\2\:CK \3\:CK) resistor r=60.3072 c=0
Rl9 (\4\:CKb \5\:CKb) resistor r=172.924 c=0
Rl4 (CKb \3\:CKb) resistor r=171.154 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=56.461 c=0
Rl20 (\7\:CKb \8\:CKb) resistor r=26.1559 c=0
Rl10 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl3 (CKb \2\:CKb) resistor r=35.7713 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=206.824 c=0
Rl22 (\6\:CKbb \7\:CKbb) resistor r=266.382 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=54.9442 c=0
Rl5 (CKbb \2\:CKbb) resistor r=26.1559 c=0
Rl17 (n20 \2\:n20) resistor r=126.898 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=38.4366 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=39.317 c=0
Rl12 (mout \2\:mout) resistor r=37.3411 c=0
Rl14 (\2\:mout \4\:mout) resistor r=121.957 c=0
Rl13 (\2\:mout \3\:mout) resistor r=0.6051 c=0
Rl30 (\4\:n30 n30) resistor r=85.0055 c=0
Rl31 (\4\:n30 \5\:n30) resistor r=35.772 c=0
Rl33 (\4\:n30 \7\:n30) resistor r=100.426 c=0
Rl65 (\20\:qbint \21\:qbint) resistor r=55.0021 c=0
Rl64 (\20\:qbint \19\:qbint) resistor r=36.7742 c=0
Rl25 (\2\:qbint \3\:qbint) resistor r=26.3736 c=0
Rl24 (\2\:qbint qbint) resistor r=119.231 c=0
Rz23 (\1\:VDD \3\:VDD) resistor r=4.6875 c=0
Rz24 (\30\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz18 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz19 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz20 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz21 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz4 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz1 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz2 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz3 (\5\:mout \6\:mout) resistor r=75 c=0
Rz5 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz10 (\33\:qbint \32\:qbint) resistor r=75 c=0
Rz11 (\20\:qint \19\:qint) resistor r=75 c=0
Ry23 (\20\:VDD \19\:VDD) resistor r=31 c=0
Ry25 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry27 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry28 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \3\:VSS) resistor r=3.875 c=0
Ry17 (\12\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry1 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry4 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry14 (\17\:qint \16\:qint) resistor r=20.6667 c=0
Ry2 (n26 \2\:n26) resistor r=62 c=0
Ry3 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx15 (\13\:RN \2\:RN) resistor r=45 c=0
Rx2 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\8\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx3 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx4 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx7 (\3\:mout \8\:mout) resistor r=45 c=0
Rx12 (\8\:n30 n30) resistor r=45 c=0
Rx16 (\22\:qbint \4\:qbint) resistor r=45 c=0
Rx17 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx18 (\30\:qbint \20\:qbint) resistor r=45 c=0
Rx19 (\34\:qbint \4\:qbint) resistor r=45 c=0
Rx20 (\21\:qint qint) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.52e-14 ad=2.03e-14 ps=1.34e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn21 (\12\:CKbb \3\:CKb \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn25 (n21 \1\:D \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.70414e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn26 (\9\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.62448e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn37 (\9\:n20 \3\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=2.32e-14 ps=4.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.46897e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n25 \4\:mout n27 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=1.233e-14 ps=4.1e-07 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.37034e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n27 \3\:RN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=8.7e-15 ps=8.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.29069e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\5\:mout \4\:n20 \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.843e-14 ad=2.755e-14 ps=8.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=1.05552e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\12\:n30 \6\:CKbb \5\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=3.118e-14 ps=6.7e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=8.77241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn51 (\12\:n30 \9\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=3.118e-14 ps=5.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=6.8e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn50 (n40 qbint \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.083e-14 ad=1.668e-14 ps=1.45e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=5.58621e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn45_1__rcx (22 \4\:RN \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.083e-14 ad=1.743e-14 ps=1.45e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.78049e-07 sb=1.08463e-06 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn46_1__rcx (\32\:qbint \7\:n30 22 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.743e-14 ad=3.28e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9439e-07 sb=9.99024e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn46 (\32\:qbint \5\:n30 23 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6439e-07 sb=8.64024e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn45 (23 \9\:RN \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.955e-14 ad=1.23e-14 ps=1.6e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51463e-07 sb=7.94878e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn56 (\19\:qint \19\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94519e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.268e-14 ad=4.16e-14 ps=1.4425e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27423e-06 sb=1.025e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.159e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60769e-07 sb=1.965e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp46_1__rcx (\23\:qbint n30 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18234e-06 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp45 (\23\:qbint \5\:RN \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.774e-14 ad=4.96e-14 ps=1.085e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.77339e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp56 (\16\:qint \21\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=26.0565 \
        scb=0.024857 scc=0.00213457 m=(1)
mp55 (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=6.63e-14 ps=1.11e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34718e-06 sb=1.82e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp57 (\5\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73308e-06 sb=9.6e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
ends DFFRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:38 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRXL
// View name: extracted

simulator lang=spectre

subckt DFFRXL CK D Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=3.548e-14 ps=1.47e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.27326e-07 sd=160n sca=49.8399 \
        scb=0.0334143 scc=0.00594375 m=(1)
mp56 (\5\:qint \7\:qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.73e-14 ad=2.63e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=47.1852 \
        scb=0.0292558 scc=0.00588561 m=(1)
mp55 (\4\:Q \6\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=2.63e-14 ps=2.03e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=5.25e-07 sd=160n sca=17.4239 \
        scb=0.0172882 scc=0.00131682 m=(1)
mp20 (\13\:CKb \1\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=3.44e-14 ps=2.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.87326e-07 sb=1.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp46 (\12\:qbint \3\:n30 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.44e-14 ps=1.65e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.88e-06 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp45 (\12\:qbint \3\:RN \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.265e-14 ad=3.44e-14 ps=1.75e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.675e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp50 (n41 \10\:qbint \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=3.44e-14 ps=1.75e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=1.48e-06 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp51 (\8\:n30 \2\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.275e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp40 (\8\:n30 \4\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.815e-14 ad=3.44e-14 ps=1.25e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.07e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp30 (\6\:mout \4\:n20 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.001e-13 ad=8.815e-14 ps=1.75e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.365e-06 sb=6.15e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp35 (n26 \6\:RN \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.001e-13 ad=4.408e-14 ps=1.75e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=3.5e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp36 (n26 mout \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=4.407e-14 ps=1.84e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.88e-06 sb=1e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp37 (\8\:n20 \5\:CKb \3\:n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.69651e-07 sd=160n sca=12.8114 \
        scb=0.0117123 scc=0.000425192 m=(1)
mp26 (\8\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.515e-14 ps=7.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=4.14651e-07 sd=160n sca=13.6979 \
        scb=0.0122064 scc=0.000425621 m=(1)
mp25 (n22 \1\:D \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.635e-14 ad=3.117e-14 ps=1.88e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=2.24651e-07 sd=160n sca=15.3538 \
        scb=0.0143677 scc=0.000439386 m=(1)
mp21 (\15\:CKbb \9\:CKb \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.635e-14 ad=3.01e-14 ps=1.88e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.74419e-07 sb=1.4e-07 sd=160n sca=53.5485 \
        scb=0.0463759 scc=0.00660315 m=(1)
C1 (D VSS) capacitor c=3.82572e-17
C2 (Q VSS) capacitor c=1.50252e-17
C3 (RN VSS) capacitor c=8.58391e-17
C4 (QN VSS) capacitor c=2.14014e-17
C5 (VDD VSS) capacitor c=3.65324e-16
C6 (CK VSS) capacitor c=3.08568e-17
C7 (qint VSS) capacitor c=2.14096e-17
C8 (qbint VSS) capacitor c=2.42826e-17
C9 (CKb VSS) capacitor c=2.84994e-17
C10 (n30 VSS) capacitor c=3.09923e-17
C11 (n40 VSS) capacitor c=4.97174e-18
C12 (mout VSS) capacitor c=5.02305e-17
C13 (CKbb VSS) capacitor c=5.10879e-17
C14 (n20 VSS) capacitor c=1.86289e-17
C15 (n21 VSS) capacitor c=1.3336e-18
C16 (n41 VSS) capacitor c=1.57584e-18
C17 (n26 VSS) capacitor c=5.96217e-17
C18 (n22 VSS) capacitor c=8.99794e-19
C19 (\9\:CKb VSS) capacitor c=3.45771e-17
C20 (\1\:D VSS) capacitor c=5.63406e-17
C21 (\7\:CKbb VSS) capacitor c=4.48651e-17
C22 (\5\:CKb VSS) capacitor c=4.63289e-17
C23 (\6\:RN VSS) capacitor c=6.24375e-17
C24 (\4\:n20 VSS) capacitor c=3.86933e-17
C25 (\4\:CKb VSS) capacitor c=2.96683e-17
C26 (\2\:CKbb VSS) capacitor c=4.92606e-17
C27 (\10\:qbint VSS) capacitor c=4.78737e-17
C28 (\3\:RN VSS) capacitor c=4.35281e-17
C29 (\3\:n30 VSS) capacitor c=5.05776e-17
C30 (\1\:CK VSS) capacitor c=2.79303e-17
C31 (\6\:qbint VSS) capacitor c=3.41113e-17
C32 (\7\:qbint VSS) capacitor c=3.50752e-17
C33 (\4\:qint VSS) capacitor c=3.7074e-17
C34 (\8\:CKb VSS) capacitor c=4.75721e-17
C35 (\3\:D VSS) capacitor c=3.04717e-17
C36 (\7\:CKb VSS) capacitor c=5.34228e-17
C37 (\5\:CKbb VSS) capacitor c=6.74515e-17
C38 (\3\:mout VSS) capacitor c=5.6898e-17
C39 (\5\:RN VSS) capacitor c=8.76577e-17
C40 (\3\:n20 VSS) capacitor c=3.69929e-17
C41 (\3\:CKbb VSS) capacitor c=3.68681e-17
C42 (\3\:CKb VSS) capacitor c=6.19582e-17
C43 (\8\:qbint VSS) capacitor c=5.42973e-17
C44 (\1\:RN VSS) capacitor c=5.02095e-17
C45 (\3\:CK VSS) capacitor c=4.20444e-17
C46 (\5\:qbint VSS) capacitor c=2.10229e-17
C47 (\3\:qint VSS) capacitor c=2.7225e-17
C48 (\10\:CKb VSS) capacitor c=1.5566e-17
C49 (\2\:D VSS) capacitor c=4.75488e-17
C50 (\8\:CKbb VSS) capacitor c=3.07078e-17
C51 (\6\:CKb VSS) capacitor c=1.74097e-17
C52 (\6\:CKbb VSS) capacitor c=3.31662e-17
C53 (\2\:mout VSS) capacitor c=5.71724e-17
C54 (\7\:RN VSS) capacitor c=2.5335e-17
C55 (\4\:CKbb VSS) capacitor c=4.30823e-17
C56 (\9\:qbint VSS) capacitor c=4.28396e-17
C57 (\4\:RN VSS) capacitor c=2.62146e-17
C58 (\2\:RN VSS) capacitor c=5.65253e-17
C59 (\2\:n30 VSS) capacitor c=4.55308e-17
C60 (\2\:CK VSS) capacitor c=2.67834e-17
C61 (\2\:qbint VSS) capacitor c=1.52563e-17
C62 (\15\:CKbb VSS) capacitor c=9.40398e-18
C63 (\5\:VDD VSS) capacitor c=1.2577e-17
C64 (\8\:n20 VSS) capacitor c=6.87123e-17
C65 (\3\:n26 VSS) capacitor c=6.68717e-17
C66 (\7\:VDD VSS) capacitor c=1.63641e-17
C67 (\10\:VDD VSS) capacitor c=2.52978e-17
C68 (\6\:mout VSS) capacitor c=5.55371e-17
C69 (\8\:n30 VSS) capacitor c=7.59755e-17
C70 (\13\:VDD VSS) capacitor c=2.62433e-17
C71 (\12\:qbint VSS) capacitor c=1.66667e-16
C72 (\16\:VDD VSS) capacitor c=9.04633e-18
C73 (\13\:CKb VSS) capacitor c=2.08912e-16
C74 (\20\:VDD VSS) capacitor c=4.42262e-18
C75 (\4\:Q VSS) capacitor c=1.30203e-17
C76 (\5\:qint VSS) capacitor c=3.01215e-17
C77 (\23\:VDD VSS) capacitor c=8.33723e-18
C78 (\1\:QN VSS) capacitor c=1.57166e-17
C79 (\1\:VDD VSS) capacitor c=6.4705e-17
C80 (\9\:CKbb VSS) capacitor c=3.67977e-17
C81 (\5\:n20 VSS) capacitor c=3.96239e-17
C82 (\8\:mout VSS) capacitor c=4.06471e-17
C83 (\4\:n30 VSS) capacitor c=4.46828e-17
C84 (\14\:qbint VSS) capacitor c=1.72531e-16
C85 (\11\:CKb VSS) capacitor c=8.34076e-17
C86 (\1\:Q VSS) capacitor c=8.68144e-17
C87 (\9\:qint VSS) capacitor c=4.07156e-17
C88 (\3\:QN VSS) capacitor c=4.14431e-17
C89 (\2\:qint VSS) capacitor c=1.33022e-17
C90 (\3\:qbint VSS) capacitor c=1.92875e-17
C91 (\4\:qbint VSS) capacitor c=3.68412e-17
C92 (\2\:CKb VSS) capacitor c=3.76958e-17
C93 (\2\:n20 VSS) capacitor c=2.55193e-17
C94 (\7\:qint VSS) capacitor c=3.26977e-17
C95 (\8\:qint VSS) capacitor c=3.39278e-17
C96 (\3\:Q VSS) capacitor c=5.66282e-17
C97 (\4\:CK VSS) capacitor c=8.18776e-17
C98 (\10\:RN VSS) capacitor c=5.66272e-17
C99 (\11\:qbint VSS) capacitor c=6.71849e-17
C100 (\16\:qbint VSS) capacitor c=1.24015e-16
C101 (\6\:n30 VSS) capacitor c=9.59129e-17
C102 (\7\:n30 VSS) capacitor c=5.61701e-17
C103 (\11\:RN VSS) capacitor c=1.63804e-16
C104 (\12\:RN VSS) capacitor c=1.66635e-16
C105 (\4\:mout VSS) capacitor c=7.766e-17
C106 (\5\:mout VSS) capacitor c=9.0548e-17
C107 (\7\:n20 VSS) capacitor c=1.16204e-16
C108 (\10\:n20 VSS) capacitor c=8.6783e-17
C109 (\4\:D VSS) capacitor c=6.32096e-17
C110 (\15\:CKb VSS) capacitor c=2.40526e-16
C111 (\16\:CKb VSS) capacitor c=6.31145e-17
C112 (\17\:CKb VSS) capacitor c=1.98984e-16
C113 (\18\:CKb VSS) capacitor c=7.33254e-17
C114 (\11\:CKbb VSS) capacitor c=6.0344e-17
C115 (\12\:CKbb VSS) capacitor c=1.34874e-16
C116 (\13\:CKbb VSS) capacitor c=1.84071e-16
C117 (\14\:CKbb VSS) capacitor c=1.25617e-16
C118 (\17\:CKbb VSS) capacitor c=5.81967e-17
C119 (\3\:VDD VSS) capacitor c=2.82188e-17
C120 (\9\:VDD VSS) capacitor c=3.27052e-17
C121 (\12\:VDD VSS) capacitor c=3.83665e-17
C122 (\15\:VDD VSS) capacitor c=1.70501e-17
C123 (\19\:VDD VSS) capacitor c=9.43581e-18
C124 (\22\:VDD VSS) capacitor c=9.83815e-18
Rk27 (D \4\:D) resistor r=0.01152 c=0
Rk8 (\3\:Q Q) resistor r=0.007742 c=0
Rk6 (\2\:Q \3\:Q) resistor r=0.4793 c=0
Rk7 (\3\:Q \5\:Q) resistor r=0.09901 c=0
Rk10 (\8\:RN RN) resistor r=0.008949 c=0
Rk12 (\8\:RN \10\:RN) resistor r=0.04354 c=0
Rk11 (\9\:RN \10\:RN) resistor r=0.008949 c=0
Rk19 (\11\:RN \12\:RN) resistor r=1.0469 c=0
Rk55 (\2\:VSS \3\:VSS) resistor r=0.1879 c=0
Rk56 (\3\:VSS \4\:VSS) resistor r=0.4638 c=0
Rk57 (\4\:VSS \5\:VSS) resistor r=0.06501 c=0
Rk58 (\5\:VSS \6\:VSS) resistor r=0.6341 c=0
Rk59 (\6\:VSS \7\:VSS) resistor r=0.5039 c=0
Rk60 (\3\:VSS \9\:VSS) resistor r=0.3187 c=0
Rk61 (\5\:VSS \11\:VSS) resistor r=0.1227 c=0
Rk62 (\6\:VSS \13\:VSS) resistor r=0.2443 c=0
Rk64 (\14\:VSS VSS) resistor r=0.1952 c=0
Rk63 (\7\:VSS \14\:VSS) resistor r=0.3565 c=0
Rk65 (\7\:VSS \16\:VSS) resistor r=0.3778 c=0
Rk66 (\14\:VSS \18\:VSS) resistor r=0.3692 c=0
Rk2 (\4\:QN QN) resistor r=0.07594 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk39 (\2\:VDD \3\:VDD) resistor r=0.1177 c=0
Rk40 (\3\:VDD \4\:VDD) resistor r=0.5346 c=0
Rk41 (\3\:VDD \6\:VDD) resistor r=0.07393 c=0
Rk42 (\4\:VDD \8\:VDD) resistor r=0.1203 c=0
Rk43 (\4\:VDD \9\:VDD) resistor r=0.1518 c=0
Rk44 (\9\:VDD \11\:VDD) resistor r=0.04331 c=0
Rk45 (\9\:VDD \12\:VDD) resistor r=0.5294 c=0
Rk46 (\12\:VDD \14\:VDD) resistor r=0.04331 c=0
Rk47 (\12\:VDD \15\:VDD) resistor r=0.1993 c=0
Rk48 (\15\:VDD \17\:VDD) resistor r=0.07393 c=0
Rk49 (\15\:VDD \18\:VDD) resistor r=0.3183 c=0
Rk50 (\18\:VDD \19\:VDD) resistor r=0.05498 c=0
Rk51 (\19\:VDD \21\:VDD) resistor r=0.07393 c=0
Rk54 (\22\:VDD VDD) resistor r=0.2102 c=0
Rk52 (\19\:VDD \22\:VDD) resistor r=0.2855 c=0
Rk53 (\22\:VDD \24\:VDD) resistor r=0.2243 c=0
Rk9 (CK \4\:CK) resistor r=0.01694 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1148 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1194 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1088 c=0
Rk13 (\11\:qbint \13\:qbint) resistor r=0.3623 c=0
Rk14 (\13\:qbint \15\:qbint) resistor r=0.876 c=0
Rk15 (\15\:qbint \16\:qbint) resistor r=0.9598 c=0
Rk28 (\12\:CKb \14\:CKb) resistor r=0.4396 c=0
Rk29 (\14\:CKb \15\:CKb) resistor r=1.0766 c=0
Rk30 (\15\:CKb \16\:CKb) resistor r=0.2453 c=0
Rk31 (\15\:CKb \17\:CKb) resistor r=1.0026 c=0
Rk32 (\17\:CKb \18\:CKb) resistor r=0.6634 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.2473 c=0
Rk17 (\6\:n30 \7\:n30) resistor r=0.3312 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.4824 c=0
Rk20 (\4\:mout \5\:mout) resistor r=0.4552 c=0
Rk21 (\5\:mout \7\:mout) resistor r=0.2707 c=0
Rk22 (\5\:mout \9\:mout) resistor r=0.08541 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.2997 c=0
Rk34 (\11\:CKbb \12\:CKbb) resistor r=0.3619 c=0
Rk35 (\12\:CKbb \13\:CKbb) resistor r=0.7921 c=0
Rk36 (\13\:CKbb \14\:CKbb) resistor r=0.9969 c=0
Rk37 (\11\:CKbb \16\:CKbb) resistor r=0.09567 c=0
Rk38 (\14\:CKbb \17\:CKbb) resistor r=0.2851 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.2028 c=0
Rk25 (\7\:n20 \9\:n20) resistor r=0.3899 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.5688 c=0
Rk23 (\2\:n26 \4\:n26) resistor r=0.2431 c=0
Rl35 (\1\:D \2\:D) resistor r=128.079 c=0
Rl36 (\2\:D \3\:D) resistor r=65.924 c=0
Rl27 (\5\:RN \6\:RN) resistor r=189.95 c=0
Rl28 (\6\:RN \7\:RN) resistor r=71.8456 c=0
Rl16 (\3\:RN \4\:RN) resistor r=71.8456 c=0
Rl15 (\2\:RN \3\:RN) resistor r=68.4636 c=0
Rl14 (\1\:RN \2\:RN) resistor r=93.4636 c=0
Rl10 (\1\:CK \2\:CK) resistor r=30.0021 c=0
Rl11 (\2\:CK \3\:CK) resistor r=74.2328 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl1 (qint \2\:qint) resistor r=2.0213 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=24.2328 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=101.008 c=0
Rl4 (qbint \2\:qbint) resistor r=29.0109 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=95.8353 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=23.8124 c=0
Rl9 (\4\:qbint \7\:qbint) resistor r=60.772 c=0
Rl7 (\4\:qbint \5\:qbint) resistor r=28.0797 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=131.607 c=0
Rl37 (\8\:CKb \9\:CKb) resistor r=153.412 c=0
Rl33 (\5\:CKb \7\:CKb) resistor r=190.385 c=0
Rl38 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl23 (\2\:CKb \4\:CKb) resistor r=35.772 c=0
Rl22 (\2\:CKb \3\:CKb) resistor r=146.876 c=0
Rl21 (CKb \2\:CKb) resistor r=32.3537 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=135.714 c=0
Rl12 (n30 \2\:n30) resistor r=30.7692 c=0
Rl29 (mout \2\:mout) resistor r=99.2328 c=0
Rl30 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl34 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl31 (\5\:CKbb \6\:CKbb) resistor r=26.1559 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl19 (CKbb \2\:CKbb) resistor r=53.1035 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=47.791 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=97.7911 c=0
Rl24 (n20 \2\:n20) resistor r=1.2713 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz13 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz14 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz11 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VDD \18\:VDD) resistor r=6.25 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz8 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry3 (\4\:Q \5\:Q) resistor r=62 c=0
Ry19 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry20 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry21 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry12 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry13 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry14 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry15 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry18 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry10 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry7 (n26 \2\:n26) resistor r=62 c=0
Ry8 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx11 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\2\:RN \9\:RN) resistor r=45 c=0
Rx7 (\7\:RN \11\:RN) resistor r=45 c=0
Rx8 (\4\:RN \12\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx4 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx5 (\2\:qbint \16\:qbint) resistor r=45 c=0
Rx12 (CKb \16\:CKb) resistor r=45 c=0
Rx13 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \18\:CKb) resistor r=45 c=0
Rx6 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx15 (\8\:CKbb \12\:CKbb) resistor r=45 c=0
Rx16 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx17 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx18 (CKbb \17\:CKbb) resistor r=45 c=0
Rx10 (n20 \10\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \5\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.27e-14 ad=2.03e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.72414e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn20 (\11\:CKb \3\:CK \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.27e-14 ad=3.045e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=2.1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn46 (\14\:qbint n30 n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.03e-14 ps=5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.63276e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn45 (n35 \1\:RN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=1.522e-14 ps=8.6e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=7.59828e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn50 (n40 \8\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=2.827e-14 ps=8.6e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.46552e-07 sb=1.97034e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\4\:n30 \3\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=3.552e-14 ps=6.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.86552e-07 sb=1.96207e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn40 (\4\:n30 \3\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.552e-14 ps=7.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.76552e-07 sb=1.90862e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.557e-14 ad=3.625e-14 ps=1.57e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07155e-06 sb=1.61362e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn35 (n27 \5\:RN \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.557e-14 ad=8.7e-15 ps=1.57e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42431e-06 sb=1.25e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=1.957e-14 ps=4.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52931e-06 sb=1.145e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn37 (\5\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.682e-14 ps=5.6e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69534e-06 sb=9.65e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn26 (\5\:n20 \7\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.682e-14 ps=7.3e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85397e-06 sb=7.35e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn25 (n21 \3\:D \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=3.19e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96138e-06 sb=4.7e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn21 (\9\:CKbb \8\:CKb \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97276e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
ends DFFRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:39 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSHQX1
// View name: extracted

simulator lang=spectre

subckt DFFSHQX1 CK D Q SN VDD VSS
mp55 (\1\:Q \4\:qbint \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (SN VSS) capacitor c=1.79028e-16
C2 (VDD VSS) capacitor c=2.74598e-16
C3 (D VSS) capacitor c=6.98419e-17
C4 (qbint VSS) capacitor c=9.32538e-18
C5 (n35 VSS) capacitor c=2.32911e-17
C6 (n40 VSS) capacitor c=5.19831e-18
C7 (CKb VSS) capacitor c=3.90101e-17
C8 (mout VSS) capacitor c=4.88854e-17
C9 (CKbb VSS) capacitor c=5.27099e-17
C10 (n25 VSS) capacitor c=6.01809e-20
C11 (n20 VSS) capacitor c=3.79764e-17
C12 (n30 VSS) capacitor c=1.5686e-18
C13 (n41 VSS) capacitor c=6.55337e-17
C14 (n31 VSS) capacitor c=1.65877e-18
C15 (n22 VSS) capacitor c=3.29151e-18
C16 (\3\:CK VSS) capacitor c=5.11593e-17
C17 (\3\:D VSS) capacitor c=7.73909e-17
C18 (\5\:CKbb VSS) capacitor c=9.4249e-17
C19 (\10\:CKb VSS) capacitor c=7.34942e-17
C20 (\3\:mout VSS) capacitor c=8.20868e-17
C21 (\4\:SN VSS) capacitor c=5.72225e-17
C22 (\7\:CKb VSS) capacitor c=1.19657e-17
C23 (\9\:CKb VSS) capacitor c=2.80812e-17
C24 (\3\:CKbb VSS) capacitor c=6.48421e-17
C25 (\5\:qbint VSS) capacitor c=6.1412e-17
C26 (\1\:SN VSS) capacitor c=5.5742e-17
C27 (\4\:n35 VSS) capacitor c=3.783e-17
C28 (\4\:qbint VSS) capacitor c=3.50795e-17
C29 (\1\:CK VSS) capacitor c=4.15915e-17
C30 (\1\:D VSS) capacitor c=6.04843e-17
C31 (\12\:CKb VSS) capacitor c=3.83046e-17
C32 (\7\:CKbb VSS) capacitor c=4.54153e-17
C33 (\3\:n20 VSS) capacitor c=8.2588e-17
C34 (\7\:SN VSS) capacitor c=5.73669e-17
C35 (\3\:CKb VSS) capacitor c=6.19385e-17
C36 (\4\:CKbb VSS) capacitor c=2.84468e-17
C37 (\7\:qbint VSS) capacitor c=3.13635e-17
C38 (\3\:SN VSS) capacitor c=5.27223e-17
C39 (\3\:n35 VSS) capacitor c=5.18197e-17
C40 (\3\:qbint VSS) capacitor c=2.9594e-17
C41 (\2\:CK VSS) capacitor c=4.83352e-17
C42 (\2\:D VSS) capacitor c=6.46145e-17
C43 (\13\:CKb VSS) capacitor c=4.17566e-17
C44 (\6\:CKbb VSS) capacitor c=8.05956e-17
C45 (\11\:CKb VSS) capacitor c=3.10502e-17
C46 (\2\:mout VSS) capacitor c=5.83891e-17
C47 (\2\:n20 VSS) capacitor c=4.27155e-17
C48 (\6\:SN VSS) capacitor c=6.43366e-17
C49 (\8\:CKb VSS) capacitor c=1.69174e-17
C50 (\6\:CKb VSS) capacitor c=5.26518e-17
C51 (\2\:CKb VSS) capacitor c=4.21025e-17
C52 (\6\:qbint VSS) capacitor c=5.25535e-17
C53 (\2\:SN VSS) capacitor c=6.2788e-17
C54 (\22\:CKb VSS) capacitor c=4.71864e-17
C55 (\1\:VDD VSS) capacitor c=5.38675e-17
C56 (\4\:n20 VSS) capacitor c=6.87715e-17
C57 (\11\:VDD VSS) capacitor c=7.1348e-17
C58 (\6\:mout VSS) capacitor c=1.16087e-16
C59 (\13\:VDD VSS) capacitor c=2.83739e-17
C60 (\13\:CKbb VSS) capacitor c=3.91059e-17
C61 (\8\:mout VSS) capacitor c=1.29819e-16
C62 (\5\:n35 VSS) capacitor c=6.83279e-17
C63 (\15\:VDD VSS) capacitor c=3.10687e-17
C64 (\3\:n41 VSS) capacitor c=6.63931e-17
C65 (\17\:VDD VSS) capacitor c=2.47136e-17
C66 (\12\:qbint VSS) capacitor c=7.6794e-17
C67 (\19\:VDD VSS) capacitor c=8.75231e-17
C68 (\1\:Q VSS) capacitor c=4.66596e-17
C69 (\3\:VDD VSS) capacitor c=6.27689e-17
C70 (\16\:CKb VSS) capacitor c=7.01373e-17
C71 (\8\:n20 VSS) capacitor c=7.44307e-17
C72 (\10\:mout VSS) capacitor c=4.92036e-17
C73 (\11\:CKbb VSS) capacitor c=4.72383e-17
C74 (\12\:mout VSS) capacitor c=1.05871e-16
C75 (\9\:n35 VSS) capacitor c=9.34159e-17
C76 (\14\:qbint VSS) capacitor c=1.99507e-17
C77 (\3\:Q VSS) capacitor c=4.68131e-17
C78 (\2\:qbint VSS) capacitor c=8.94893e-18
C79 (\2\:n35 VSS) capacitor c=2.78648e-17
C80 (\2\:CKbb VSS) capacitor c=5.79107e-17
C81 (\4\:CKb VSS) capacitor c=5.1749e-17
C82 (\8\:qbint VSS) capacitor c=5.9834e-17
C83 (\9\:qbint VSS) capacitor c=6.49338e-17
C84 (\11\:qbint VSS) capacitor c=4.3587e-17
C85 (\7\:n35 VSS) capacitor c=1.5561e-16
C86 (\8\:n35 VSS) capacitor c=7.28645e-17
C87 (\14\:CKb VSS) capacitor c=4.75935e-17
C88 (\15\:CKb VSS) capacitor c=5.26556e-17
C89 (\8\:SN VSS) capacitor c=9.04461e-17
C90 (\9\:SN VSS) capacitor c=2.08804e-16
C91 (\4\:mout VSS) capacitor c=5.92443e-17
C92 (\5\:mout VSS) capacitor c=8.29167e-17
C93 (\8\:CKbb VSS) capacitor c=2.07855e-16
C94 (\9\:CKbb VSS) capacitor c=1.84688e-16
C95 (\10\:CKbb VSS) capacitor c=4.35074e-17
C96 (\6\:n20 VSS) capacitor c=9.75837e-17
C97 (\7\:n20 VSS) capacitor c=7.77391e-17
C98 (\4\:D VSS) capacitor c=4.95154e-17
C99 (\18\:CKb VSS) capacitor c=1.3378e-16
C100 (\19\:CKb VSS) capacitor c=1.25758e-16
C101 (\20\:CKb VSS) capacitor c=1.69965e-16
C102 (\21\:CKb VSS) capacitor c=1.70348e-16
C103 (\5\:CK VSS) capacitor c=4.5665e-17
C104 (\6\:CK VSS) capacitor c=3.36055e-17
C105 (\5\:VDD VSS) capacitor c=1.82518e-17
C106 (\6\:VDD VSS) capacitor c=3.71918e-17
C107 (\8\:VDD VSS) capacitor c=9.08062e-18
C108 (\9\:VDD VSS) capacitor c=1.92753e-17
C109 (\10\:VDD VSS) capacitor c=1.28698e-17
Rk13 (\8\:SN SN) resistor r=0.498 c=0
Rk14 (SN \9\:SN) resistor r=1.2561 c=0
Rk1 (\2\:Q Q) resistor r=0.3426 c=0
Rk2 (Q \4\:Q) resistor r=0.07302 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.3595 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.1881 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.2472 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.516 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.05252 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.1904 c=0
Rk54 (\10\:VDD VDD) resistor r=0.1025 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.2055 c=0
Rk55 (\5\:VDD \12\:VDD) resistor r=0.3238 c=0
Rk56 (\6\:VDD \14\:VDD) resistor r=0.04337 c=0
Rk57 (\8\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk58 (\9\:VDD \18\:VDD) resistor r=0.1802 c=0
Rk59 (\10\:VDD \20\:VDD) resistor r=0.4292 c=0
Rk33 (\4\:CK \5\:CK) resistor r=0.003253 c=0
Rk34 (\6\:CK CK) resistor r=0.003253 c=0
Rk35 (\5\:CK \6\:CK) resistor r=0.03891 c=0
Rk27 (D \4\:D) resistor r=0.1626 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.5025 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.1881 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.2783 c=0
Rk39 (\6\:VSS \7\:VSS) resistor r=0.4868 c=0
Rk40 (\7\:VSS \8\:VSS) resistor r=0.2433 c=0
Rk42 (\9\:VSS VSS) resistor r=0.1025 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.2055 c=0
Rk43 (\5\:VSS \11\:VSS) resistor r=0.2566 c=0
Rk44 (\6\:VSS \13\:VSS) resistor r=0.4058 c=0
Rk45 (\8\:VSS \15\:VSS) resistor r=0.3207 c=0
Rk46 (\9\:VSS \17\:VSS) resistor r=0.2903 c=0
Rk3 (\8\:qbint \9\:qbint) resistor r=0.3023 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.05768 c=0
Rk5 (\10\:qbint \11\:qbint) resistor r=0.1493 c=0
Rk6 (\9\:qbint \13\:qbint) resistor r=0.3856 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.1097 c=0
Rk9 (\6\:n35 \7\:n35) resistor r=0.3755 c=0
Rk10 (\7\:n35 \8\:n35) resistor r=0.4153 c=0
Rk11 (\7\:n35 \10\:n35) resistor r=0.5658 c=0
Rk12 (\14\:CKb \15\:CKb) resistor r=0.1673 c=0
Rk28 (\17\:CKb \18\:CKb) resistor r=0.4323 c=0
Rk29 (\18\:CKb \19\:CKb) resistor r=0.5473 c=0
Rk30 (\19\:CKb \20\:CKb) resistor r=0.2921 c=0
Rk31 (\20\:CKb \21\:CKb) resistor r=1.1824 c=0
Rk32 (\19\:CKb \23\:CKb) resistor r=0.3103 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2393 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.3379 c=0
Rk17 (\7\:mout \9\:mout) resistor r=0.5883 c=0
Rk18 (\5\:mout \11\:mout) resistor r=0.1435 c=0
Rk19 (\9\:mout \13\:mout) resistor r=0.5175 c=0
Rk20 (\8\:CKbb \9\:CKbb) resistor r=1.3804 c=0
Rk21 (\9\:CKbb \10\:CKbb) resistor r=0.2044 c=0
Rk22 (\10\:CKbb \12\:CKbb) resistor r=0.1744 c=0
Rk23 (\9\:CKbb \14\:CKbb) resistor r=0.09496 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.2947 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.3545 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.3638 c=0
Rk8 (\2\:n41 \4\:n41) resistor r=0.334 c=0
Rl7 (\1\:SN \2\:SN) resistor r=72.2519 c=0
Rl8 (\2\:SN \3\:SN) resistor r=95.3288 c=0
Rl21 (\4\:SN \5\:SN) resistor r=114.664 c=0
Rl23 (\5\:SN \7\:SN) resistor r=42.0218 c=0
Rl22 (\5\:SN \6\:SN) resistor r=0.5166 c=0
Rl35 (\2\:CK \3\:CK) resistor r=143.406 c=0
Rl34 (\1\:CK \2\:CK) resistor r=89.5596 c=0
Rl33 (\2\:D \3\:D) resistor r=106.868 c=0
Rl32 (\1\:D \2\:D) resistor r=98.0769 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=164.05 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=28.1859 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=45.0334 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=37.3411 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl6 (\2\:n35 \4\:n35) resistor r=34.3295 c=0
Rl5 (\2\:n35 \3\:n35) resistor r=157.406 c=0
Rl4 (n35 \2\:n35) resistor r=0.5213 c=0
Rl31 (\12\:CKb \13\:CKb) resistor r=26.7711 c=0
Rl28 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl19 (\7\:CKb \8\:CKb) resistor r=52.6149 c=0
Rl11 (CKb \2\:CKb) resistor r=83.3841 c=0
Rl18 (\4\:CKb \7\:CKb) resistor r=47.4088 c=0
Rl15 (\3\:CKb \4\:CKb) resistor r=105.451 c=0
Rl20 (\5\:CKb \9\:CKb) resistor r=34.9258 c=0
Rl17 (\5\:CKb \6\:CKb) resistor r=10.3565 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=144.422 c=0
Rl27 (\2\:mout \3\:mout) resistor r=98.3706 c=0
Rl26 (mout \2\:mout) resistor r=59.6868 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=227.587 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=26.098 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=126.901 c=0
Rl14 (\2\:CKbb \4\:CKbb) resistor r=30.4507 c=0
Rl12 (CKbb \2\:CKbb) resistor r=135.005 c=0
Rl24 (n20 \2\:n20) resistor r=35.7713 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=153.871 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz15 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz3 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz8 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz5 (\12\:mout \13\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry14 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry15 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \20\:VDD) resistor r=20.6667 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry12 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=31 c=0
Ry5 (\5\:n35 \6\:n35) resistor r=31 c=0
Ry10 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=31 c=0
Ry7 (\8\:mout \9\:mout) resistor r=31 c=0
Ry8 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry3 (n41 \2\:n41) resistor r=62 c=0
Ry4 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx7 (\6\:SN \9\:SN) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx2 (qbint \11\:qbint) resistor r=45 c=0
Rx3 (n35 \8\:n35) resistor r=45 c=0
Rx4 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx13 (\13\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \20\:CKb) resistor r=45 c=0
Rx15 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx10 (CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn45 (\14\:qbint \3\:n35 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.065e-06 sd=160n sca=18.43 \
        scb=0.0187068 scc=0.00173343 m=(1)
mn50 (n42 \3\:SN \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.767e-14 ps=7.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.6e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn51 (n40 \7\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=6.8e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn52 (\9\:n35 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=3.792e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=3.7e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn40 (\9\:n35 \4\:CKbb \12\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.792e-14 ps=6.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.4e-07 sd=160n sca=18.43 \
        scb=0.0187068 scc=0.00173343 m=(1)
mn30 (n25 \7\:SN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98049e-07 sb=2.45e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn31 (\10\:mout \3\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.03049e-07 sb=1.4e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn36 (n30 mout \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=1.537e-14 ps=6.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.08293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn35 (\8\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.537e-14 ad=3.895e-14 ps=5.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=6.88293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn26 (\8\:n20 \12\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=3.895e-14 ps=6.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=4.53293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn25 (n21 \1\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.767e-14 ps=7.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2.73293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn21 (\11\:CKbb \3\:CKb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.537e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=4.5e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn20 (\16\:CKb \1\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp45 (\12\:qbint \4\:n35 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.495e-14 ps=9.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=5.5e-07 sd=160n sca=11.8286 \
        scb=0.00894943 scc=0.000118237 m=(1)
mp50 (\3\:n41 \1\:SN \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.45e-07 sd=160n sca=10.9145 \
        scb=0.00827379 scc=0.000117261 m=(1)
mp51 (\3\:n41 \5\:qbint \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp52 (\5\:n35 \3\:CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp40 (\5\:n35 \9\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.55e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp30 (\6\:mout \4\:SN \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.885e-14 ad=5.89e-14 ps=1.65e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=9.81935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp31 (\6\:mout n20 \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.89e-14 ps=9.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.67984e-07 sb=7.46935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp35 (n31 \3\:mout \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=1.86e-14 ps=9.9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.97984e-07 sb=5.16935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp36 (\4\:n20 \10\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.83e-14 ps=7.4e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.02984e-07 sb=4.11935e-07 sd=160n sca=14.1016 \
        scb=0.0129066 scc=0.000682959 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=6.83e-14 ps=7.8e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.98629e-07 sb=4.19194e-07 sd=160n sca=12.0319 \
        scb=0.00919051 scc=0.000122797 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.143e-14 ad=2.48e-14 ps=1.01e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=2.94194e-07 sd=160n sca=13.3135 \
        scb=0.0110125 scc=0.000136756 m=(1)
mp21 (\13\:CKbb \7\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.885e-14 ad=3.01e-14 ps=1.65e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09512e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp20 (\22\:CKb \3\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.143e-14 ad=3.01e-14 ps=1.01e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.28721e-07 sb=1.4e-07 sd=160n sca=21.8965 \
        scb=0.0242941 scc=0.00109947 m=(1)
ends DFFSHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:40 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSHQX2
// View name: extracted

simulator lang=spectre

subckt DFFSHQX2 CK D Q SN VDD VSS
mp55_1__rcx (\3\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (SN VSS) capacitor c=2.22322e-16
C2 (Q VSS) capacitor c=2.31257e-17
C3 (VDD VSS) capacitor c=4.267e-16
C4 (CK VSS) capacitor c=4.08442e-17
C5 (D VSS) capacitor c=6.00342e-17
C6 (qbint VSS) capacitor c=1.04003e-16
C7 (n35 VSS) capacitor c=2.45539e-17
C8 (n40 VSS) capacitor c=6.0737e-18
C9 (CKb VSS) capacitor c=3.37044e-17
C10 (mout VSS) capacitor c=8.12218e-17
C11 (CKbb VSS) capacitor c=5.57942e-17
C12 (n25 VSS) capacitor c=1.87772e-18
C13 (n20 VSS) capacitor c=3.59049e-17
C14 (n30 VSS) capacitor c=3.33501e-18
C15 (n41 VSS) capacitor c=6.83676e-17
C16 (n31 VSS) capacitor c=1.8118e-18
C17 (n22 VSS) capacitor c=6.51579e-18
C18 (\1\:CK VSS) capacitor c=5.66774e-17
C19 (\3\:D VSS) capacitor c=6.45471e-17
C20 (\5\:CKbb VSS) capacitor c=7.33483e-17
C21 (\10\:CKb VSS) capacitor c=7.21278e-17
C22 (\4\:SN VSS) capacitor c=5.74748e-17
C23 (\7\:CKb VSS) capacitor c=1.87319e-17
C24 (\9\:CKb VSS) capacitor c=3.26182e-17
C25 (\8\:qbint VSS) capacitor c=5.78777e-17
C26 (\1\:SN VSS) capacitor c=5.63304e-17
C27 (\4\:n35 VSS) capacitor c=3.55063e-17
C28 (\3\:CK VSS) capacitor c=4.08701e-17
C29 (\1\:D VSS) capacitor c=7.53921e-17
C30 (\12\:CKb VSS) capacitor c=5.34234e-17
C31 (\7\:CKbb VSS) capacitor c=3.27945e-17
C32 (\4\:mout VSS) capacitor c=4.26051e-17
C33 (\3\:n20 VSS) capacitor c=5.99792e-17
C34 (\7\:SN VSS) capacitor c=4.53385e-17
C35 (\3\:CKb VSS) capacitor c=4.43122e-17
C36 (\3\:CKbb VSS) capacitor c=2.89374e-17
C37 (\11\:qbint VSS) capacitor c=2.86877e-17
C38 (\3\:SN VSS) capacitor c=5.27854e-17
C39 (\3\:n35 VSS) capacitor c=4.72145e-17
C40 (\2\:CK VSS) capacitor c=5.25567e-17
C41 (\2\:D VSS) capacitor c=5.88892e-17
C42 (\13\:CKb VSS) capacitor c=4.48783e-17
C43 (\11\:CKb VSS) capacitor c=3.16144e-17
C44 (\6\:CKbb VSS) capacitor c=8.56551e-17
C45 (\3\:mout VSS) capacitor c=1.104e-17
C46 (\2\:n20 VSS) capacitor c=3.61957e-17
C47 (\6\:SN VSS) capacitor c=2.62333e-17
C48 (\8\:CKb VSS) capacitor c=2.06863e-17
C49 (\4\:CKbb VSS) capacitor c=5.36666e-17
C50 (\6\:CKb VSS) capacitor c=2.71481e-17
C51 (\2\:CKb VSS) capacitor c=3.90961e-17
C52 (\10\:qbint VSS) capacitor c=2.41216e-17
C53 (\2\:SN VSS) capacitor c=6.72018e-17
C54 (\6\:qbint VSS) capacitor c=7.63948e-18
C55 (\16\:CKb VSS) capacitor c=4.41316e-17
C56 (\1\:VDD VSS) capacitor c=5.87226e-17
C57 (\4\:n20 VSS) capacitor c=7.13862e-17
C58 (\5\:VDD VSS) capacitor c=7.17606e-17
C59 (\8\:mout VSS) capacitor c=1.54761e-16
C60 (\8\:VDD VSS) capacitor c=2.52813e-17
C61 (\9\:CKbb VSS) capacitor c=2.11347e-16
C62 (\10\:mout VSS) capacitor c=1.59355e-16
C63 (\5\:n35 VSS) capacitor c=6.75794e-17
C64 (\11\:VDD VSS) capacitor c=3.13227e-17
C65 (\3\:n41 VSS) capacitor c=8.24765e-17
C66 (\15\:VDD VSS) capacitor c=2.90817e-17
C67 (\17\:qbint VSS) capacitor c=7.65758e-17
C68 (\3\:Q VSS) capacitor c=1.00067e-16
C69 (\3\:VDD VSS) capacitor c=5.34849e-17
C70 (\22\:CKb VSS) capacitor c=5.74441e-17
C71 (\8\:n20 VSS) capacitor c=5.08617e-17
C72 (\6\:mout VSS) capacitor c=8.13418e-17
C73 (\13\:CKbb VSS) capacitor c=4.35135e-17
C74 (\12\:mout VSS) capacitor c=1.05131e-16
C75 (\9\:n35 VSS) capacitor c=9.65982e-17
C76 (\15\:qbint VSS) capacitor c=2.30372e-17
C77 (\1\:Q VSS) capacitor c=1.05503e-17
C78 (\2\:n35 VSS) capacitor c=2.68067e-17
C79 (\9\:qbint VSS) capacitor c=3.21948e-17
C80 (\2\:CKbb VSS) capacitor c=5.55516e-17
C81 (\4\:CKb VSS) capacitor c=5.33236e-17
C82 (\5\:CKb VSS) capacitor c=4.70433e-17
C83 (\5\:SN VSS) capacitor c=2.45237e-17
C84 (\2\:mout VSS) capacitor c=4.05393e-17
C85 (\12\:qbint VSS) capacitor c=6.227e-17
C86 (\13\:qbint VSS) capacitor c=5.18693e-17
C87 (\14\:qbint VSS) capacitor c=5.21636e-17
C88 (\7\:n35 VSS) capacitor c=1.31642e-16
C89 (\8\:n35 VSS) capacitor c=8.51515e-17
C90 (\14\:CKb VSS) capacitor c=6.74382e-17
C91 (\15\:CKb VSS) capacitor c=4.54374e-17
C92 (\8\:SN VSS) capacitor c=2.09169e-16
C93 (\9\:SN VSS) capacitor c=6.11839e-17
C94 (\5\:mout VSS) capacitor c=5.6117e-17
C95 (\8\:CKbb VSS) capacitor c=1.66534e-16
C96 (\11\:CKbb VSS) capacitor c=3.30102e-17
C97 (\12\:CKbb VSS) capacitor c=3.08895e-17
C98 (\6\:n20 VSS) capacitor c=8.86009e-17
C99 (\7\:n20 VSS) capacitor c=6.96166e-17
C100 (\4\:D VSS) capacitor c=4.5203e-17
C101 (\18\:CKb VSS) capacitor c=1.17558e-16
C102 (\19\:CKb VSS) capacitor c=1.05535e-16
C103 (\20\:CKb VSS) capacitor c=1.58056e-16
C104 (\21\:CKb VSS) capacitor c=1.64351e-16
C105 (\4\:CK VSS) capacitor c=4.1604e-17
C106 (\7\:VDD VSS) capacitor c=4.24156e-17
C107 (\10\:VDD VSS) capacitor c=3.25543e-17
C108 (\14\:VDD VSS) capacitor c=1.43395e-17
Rk12 (\8\:SN SN) resistor r=1.468 c=0
Rk13 (SN \9\:SN) resistor r=0.3577 c=0
Rk32 (\2\:VSS \4\:VSS) resistor r=0.6363 c=0
Rk33 (\4\:VSS \5\:VSS) resistor r=0.3772 c=0
Rk34 (\5\:VSS \6\:VSS) resistor r=0.8274 c=0
Rk36 (\7\:VSS VSS) resistor r=0.2855 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.05748 c=0
Rk38 (\4\:VSS \10\:VSS) resistor r=0.07147 c=0
Rk39 (\5\:VSS \12\:VSS) resistor r=0.3396 c=0
Rk40 (\7\:VSS \14\:VSS) resistor r=0.2844 c=0
Rk1 (Q \2\:Q) resistor r=0.03903 c=0
Rk2 (Q \4\:Q) resistor r=0.2582 c=0
Rk43 (\2\:VDD \4\:VDD) resistor r=0.5948 c=0
Rk44 (\4\:VDD \6\:VDD) resistor r=0.3898 c=0
Rk45 (\4\:VDD \7\:VDD) resistor r=0.323 c=0
Rk46 (\7\:VDD \9\:VDD) resistor r=0.04331 c=0
Rk47 (\7\:VDD \10\:VDD) resistor r=0.746 c=0
Rk48 (\10\:VDD \12\:VDD) resistor r=0.2029 c=0
Rk49 (\10\:VDD \13\:VDD) resistor r=0.1327 c=0
Rk52 (\14\:VDD VDD) resistor r=0.2855 c=0
Rk50 (\13\:VDD \14\:VDD) resistor r=0.05748 c=0
Rk51 (\14\:VDD \16\:VDD) resistor r=0.212 c=0
Rk31 (CK \4\:CK) resistor r=0.1342 c=0
Rk25 (D \4\:D) resistor r=0.05565 c=0
Rk3 (\12\:qbint \13\:qbint) resistor r=0.3187 c=0
Rk4 (\13\:qbint \14\:qbint) resistor r=0.2851 c=0
Rk5 (\13\:qbint \16\:qbint) resistor r=0.1395 c=0
Rk6 (\13\:qbint \18\:qbint) resistor r=0.3789 c=0
Rk8 (\6\:n35 \7\:n35) resistor r=0.3675 c=0
Rk9 (\7\:n35 \8\:n35) resistor r=0.4861 c=0
Rk10 (\7\:n35 \10\:n35) resistor r=0.4425 c=0
Rk11 (\14\:CKb \15\:CKb) resistor r=0.2033 c=0
Rk26 (\17\:CKb \18\:CKb) resistor r=0.3836 c=0
Rk27 (\18\:CKb \19\:CKb) resistor r=0.492 c=0
Rk28 (\18\:CKb \20\:CKb) resistor r=0.3508 c=0
Rk29 (\20\:CKb \21\:CKb) resistor r=1.2153 c=0
Rk30 (\19\:CKb \23\:CKb) resistor r=0.4329 c=0
Rk14 (\5\:mout \7\:mout) resistor r=0.2862 c=0
Rk15 (\7\:mout \9\:mout) resistor r=0.3329 c=0
Rk16 (\9\:mout \11\:mout) resistor r=0.8615 c=0
Rk17 (\11\:mout \13\:mout) resistor r=0.5787 c=0
Rk18 (\8\:CKbb \10\:CKbb) resistor r=1.3833 c=0
Rk19 (\10\:CKbb \11\:CKbb) resistor r=0.3115 c=0
Rk20 (\11\:CKbb \12\:CKbb) resistor r=0.03537 c=0
Rk21 (\11\:CKbb \14\:CKbb) resistor r=0.1502 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.3158 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.3777 c=0
Rk24 (\6\:n20 \9\:n20) resistor r=0.2958 c=0
Rk7 (\2\:n41 \4\:n41) resistor r=0.4205 c=0
Rl10 (\1\:SN \2\:SN) resistor r=72.2519 c=0
Rl11 (\2\:SN \3\:SN) resistor r=95.3288 c=0
Rl25 (\4\:SN \5\:SN) resistor r=95.4336 c=0
Rl27 (\5\:SN \7\:SN) resistor r=34.3295 c=0
Rl26 (\5\:SN \6\:SN) resistor r=3.5166 c=0
Rl39 (\1\:CK \2\:CK) resistor r=166.483 c=0
Rl40 (\2\:CK \3\:CK) resistor r=85.7134 c=0
Rl38 (\2\:D \3\:D) resistor r=129.944 c=0
Rl37 (\1\:D \2\:D) resistor r=85.7134 c=0
Rl5 (qbint \6\:qbint) resistor r=4.3693 c=0
Rl12 (\9\:qbint \8\:qbint) resistor r=157.406 c=0
Rl14 (\9\:qbint \11\:qbint) resistor r=34.3295 c=0
Rl13 (\9\:qbint \10\:qbint) resistor r=2.0166 c=0
Rl9 (\2\:n35 \4\:n35) resistor r=34.3295 c=0
Rl8 (\2\:n35 \3\:n35) resistor r=157.406 c=0
Rl7 (n35 \2\:n35) resistor r=1.2713 c=0
Rl36 (\12\:CKb \13\:CKb) resistor r=26.1559 c=0
Rl33 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl23 (\7\:CKb \8\:CKb) resistor r=50.6918 c=0
Rl15 (CKb \2\:CKb) resistor r=61.5157 c=0
Rl22 (\4\:CKb \7\:CKb) resistor r=35.772 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=99.2335 c=0
Rl24 (\5\:CKb \9\:CKb) resistor r=40.4702 c=0
Rl21 (\5\:CKb \6\:CKb) resistor r=3.203 c=0
Rl20 (\4\:CKb \5\:CKb) resistor r=223.952 c=0
Rl30 (mout \2\:mout) resistor r=121.957 c=0
Rl32 (\2\:mout \4\:mout) resistor r=54.6488 c=0
Rl31 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=251.466 c=0
Rl35 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl16 (CKbb \2\:CKbb) resistor r=108.849 c=0
Rl17 (\2\:CKbb \3\:CKbb) resistor r=37.6951 c=0
Rl18 (\2\:CKbb \4\:CKbb) resistor r=159.989 c=0
Rl28 (n20 \2\:n20) resistor r=52.251 c=0
Rl29 (\2\:n20 \3\:n20) resistor r=128.766 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\2\:Q \1\:Q) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz16 (\13\:VDD \3\:VDD) resistor r=6.25 c=0
Rz2 (\16\:qbint \15\:qbint) resistor r=75 c=0
Rz3 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz8 (\22\:CKb \23\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz5 (\12\:mout \13\:mout) resistor r=75 c=0
Rz6 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry11 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry12 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry14 (\6\:VDD \5\:VDD) resistor r=62 c=0
Ry15 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry16 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry2 (\18\:qbint \17\:qbint) resistor r=31 c=0
Ry5 (\5\:n35 \6\:n35) resistor r=31 c=0
Ry10 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\10\:mout \11\:mout) resistor r=31 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry3 (n41 \2\:n41) resistor r=62 c=0
Ry4 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\6\:SN \8\:SN) resistor r=45 c=0
Rx7 (\2\:SN \9\:SN) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx2 (\14\:qbint \6\:qbint) resistor r=45 c=0
Rx3 (n35 \8\:n35) resistor r=45 c=0
Rx4 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx13 (\13\:CKb \19\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \20\:CKb) resistor r=45 c=0
Rx15 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx8 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55_1__rcx (\1\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\15\:qbint \3\:n35 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn50 (n42 \3\:SN \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.15e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (n40 \11\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=5.638e-14 ps=7.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.1e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn52 (\9\:n35 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=4.202e-14 ps=9.6e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=3.9e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn40 (\9\:n35 \3\:CKbb \12\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=4.202e-14 ps=6.9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.4e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn30 (n25 \7\:SN \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.065e-14 ad=2.05e-14 ps=7.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.97073e-07 sb=2.85e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn31 (\6\:mout \3\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=2.87e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.42073e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn36 (n30 \4\:mout \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=2.358e-14 ps=1.13e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=8.98293e-07 sd=160n sca=8.01384 \
        scb=0.0056906 scc=9.46507e-05 m=(1)
mn35 (\8\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=6.458e-14 ps=6.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=7.38293e-07 sd=160n sca=8.01384 \
        scb=0.0056906 scc=9.46507e-05 m=(1)
mn26 (\8\:n20 \12\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=6.458e-14 ps=5.3e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=3.78293e-07 sd=160n sca=8.01384 \
        scb=0.0056906 scc=9.46507e-05 m=(1)
mn25 (n21 \1\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=2.73293e-07 sd=160n sca=8.01384 \
        scb=0.0056906 scc=9.46507e-05 m=(1)
mn21 (\13\:CKbb \3\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.065e-14 ad=4.422e-14 ps=7.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn20 (\22\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.4e-07 sd=160n sca=8.70265 scb=0.00681258 \
        scc=0.000126945 m=(1)
mp45 (\17\:qbint \4\:n35 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=10.8995 \
        scb=0.00872363 scc=0.000163661 m=(1)
mp50 (\3\:n41 \1\:SN \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=10.8995 \
        scb=0.00872363 scc=0.000163661 m=(1)
mp51 (\3\:n41 \8\:qbint \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.8995 \
        scb=0.00872363 scc=0.000163661 m=(1)
mp52 (\5\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.415 \
        scb=0.0153923 scc=0.00118075 m=(1)
mp40 (\5\:n35 \9\:CKb \10\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=16.415 \
        scb=0.0153923 scc=0.00118075 m=(1)
mp30 (\8\:mout \4\:SN \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1848e-13 ad=7.75e-14 ps=1.89e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.71129e-07 sb=1.06202e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp31 (\8\:mout n20 \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=7.75e-14 ps=1.07e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.66129e-07 sb=7.67016e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp35 (n31 mout \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=1.86e-14 ps=1.07e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.36129e-07 sb=4.97016e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp36 (\4\:n20 \10\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.875e-14 ps=7.4e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04113e-06 sb=3.92016e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.425e-14 ad=6.875e-14 ps=9.7e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.49839e-07 sb=4.96855e-07 sd=160n sca=11.4585 \
        scb=0.00892838 scc=0.000163733 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.605e-14 ad=5.425e-14 ps=9.6e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.69839e-07 sb=2.76855e-07 sd=160n sca=12.7952 \
        scb=0.0102782 scc=0.000168009 m=(1)
mp21 (\9\:CKbb \7\:CKb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1848e-13 ad=3.01e-14 ps=1.89e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22047e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp20 (\16\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.605e-14 ad=3.01e-14 ps=9.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98488e-07 sb=1.4e-07 sd=160n sca=16.2145 \
        scb=0.0159727 scc=0.000275565 m=(1)
ends DFFSHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:41 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSHQX4
// View name: extracted

simulator lang=spectre

subckt DFFSHQX4 CK D Q SN VDD VSS
mp55_1__rcx (Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45423e-06 sd=160n sca=22.4235 \
        scb=0.0255651 scc=0.00113526 m=(4)
C1 (SN VSS) capacitor c=1.82218e-16
C2 (Q VSS) capacitor c=2.69567e-16
C3 (VDD VSS) capacitor c=6.51843e-16
C4 (CK VSS) capacitor c=3.97026e-17
C5 (D VSS) capacitor c=8.72754e-17
C6 (qbint VSS) capacitor c=2.70345e-16
C7 (n35 VSS) capacitor c=2.18414e-16
C8 (n40 VSS) capacitor c=5.57845e-18
C9 (CKb VSS) capacitor c=3.13224e-17
C10 (mout VSS) capacitor c=5.05697e-17
C11 (CKbb VSS) capacitor c=4.08565e-17
C12 (n20 VSS) capacitor c=4.85595e-17
C13 (n30 VSS) capacitor c=4.75291e-18
C14 (n21 VSS) capacitor c=1.2771e-18
C15 (n41 VSS) capacitor c=8.21586e-17
C16 (n31 VSS) capacitor c=1.65053e-18
C17 (n22 VSS) capacitor c=3.18329e-18
C18 (\1\:CK VSS) capacitor c=2.44566e-17
C19 (\9\:CKb VSS) capacitor c=4.72683e-17
C20 (\1\:D VSS) capacitor c=5.65405e-17
C21 (\4\:CKbb VSS) capacitor c=3.72814e-17
C22 (\6\:CKb VSS) capacitor c=8.27753e-17
C23 (\4\:mout VSS) capacitor c=8.78553e-17
C24 (\4\:SN VSS) capacitor c=6.34609e-17
C25 (\4\:CKb VSS) capacitor c=4.18074e-17
C26 (\14\:qbint VSS) capacitor c=6.06824e-17
C27 (\1\:SN VSS) capacitor c=4.93381e-17
C28 (\3\:CK VSS) capacitor c=1.76411e-17
C29 (\11\:CKb VSS) capacitor c=2.53752e-17
C30 (\3\:D VSS) capacitor c=6.29423e-17
C31 (\7\:CKb VSS) capacitor c=7.43199e-17
C32 (\6\:CKbb VSS) capacitor c=7.56819e-17
C33 (\3\:n20 VSS) capacitor c=6.27775e-17
C34 (\6\:SN VSS) capacitor c=4.64925e-17
C35 (\2\:CKbb VSS) capacitor c=5.13159e-17
C36 (\16\:qbint VSS) capacitor c=2.64499e-17
C37 (\3\:SN VSS) capacitor c=4.37341e-17
C38 (\2\:CK VSS) capacitor c=1.79042e-17
C39 (\10\:CKb VSS) capacitor c=3.83579e-17
C40 (\2\:D VSS) capacitor c=5.73651e-17
C41 (\5\:CKbb VSS) capacitor c=6.0275e-17
C42 (\8\:CKb VSS) capacitor c=4.92415e-17
C43 (\5\:CKb VSS) capacitor c=3.71044e-17
C44 (\3\:mout VSS) capacitor c=2.39291e-17
C45 (\2\:n20 VSS) capacitor c=6.15729e-17
C46 (\5\:SN VSS) capacitor c=4.11569e-17
C47 (\3\:CKb VSS) capacitor c=2.54397e-17
C48 (\3\:CKbb VSS) capacitor c=1.99241e-17
C49 (\2\:CKb VSS) capacitor c=3.62967e-17
C50 (\15\:qbint VSS) capacitor c=4.46043e-17
C51 (\2\:SN VSS) capacitor c=5.37153e-17
C52 (\8\:qbint VSS) capacitor c=2.27696e-17
C53 (\1\:VDD VSS) capacitor c=3.35337e-17
C54 (\12\:CKb VSS) capacitor c=6.42658e-17
C55 (\13\:CKbb VSS) capacitor c=2.29289e-17
C56 (\7\:VDD VSS) capacitor c=4.12888e-17
C57 (\8\:n20 VSS) capacitor c=6.02003e-17
C58 (\9\:VDD VSS) capacitor c=2.38033e-17
C59 (\5\:mout VSS) capacitor c=3.56163e-17
C60 (\12\:VDD VSS) capacitor c=2.10405e-17
C61 (\14\:mout VSS) capacitor c=3.96732e-17
C62 (\8\:n35 VSS) capacitor c=9.36784e-17
C63 (\15\:VDD VSS) capacitor c=3.44289e-17
C64 (\3\:n41 VSS) capacitor c=1.0623e-16
C65 (\22\:qbint VSS) capacitor c=8.3988e-17
C66 (\3\:VDD VSS) capacitor c=6.23613e-17
C67 (\14\:CKb VSS) capacitor c=1.28202e-16
C68 (\11\:CKbb VSS) capacitor c=6.70204e-17
C69 (\4\:n20 VSS) capacitor c=7.85559e-17
C70 (\12\:mout VSS) capacitor c=1.93051e-17
C71 (\9\:mout VSS) capacitor c=7.85819e-17
C72 (\12\:n35 VSS) capacitor c=9.63784e-17
C73 (\20\:qbint VSS) capacitor c=2.60392e-17
C74 (\2\:mout VSS) capacitor c=2.60152e-17
C75 (\17\:qbint VSS) capacitor c=6.68967e-17
C76 (\18\:qbint VSS) capacitor c=5.49204e-17
C77 (\19\:qbint VSS) capacitor c=3.99434e-17
C78 (\10\:n35 VSS) capacitor c=1.49608e-16
C79 (\11\:n35 VSS) capacitor c=1.01195e-16
C80 (\7\:SN VSS) capacitor c=1.58296e-16
C81 (\8\:SN VSS) capacitor c=8.7522e-17
C82 (\7\:mout VSS) capacitor c=3.45324e-17
C83 (\8\:mout VSS) capacitor c=7.15411e-17
C84 (\11\:mout VSS) capacitor c=4.32789e-17
C85 (\16\:mout VSS) capacitor c=5.12972e-17
C86 (\6\:n20 VSS) capacitor c=1.04199e-16
C87 (\7\:n20 VSS) capacitor c=6.13937e-17
C88 (\4\:D VSS) capacitor c=4.3469e-17
C89 (\7\:CKbb VSS) capacitor c=4.12168e-17
C90 (\8\:CKbb VSS) capacitor c=2.0828e-16
C91 (\9\:CKbb VSS) capacitor c=1.95863e-16
C92 (\10\:CKbb VSS) capacitor c=1.0019e-16
C93 (\16\:CKb VSS) capacitor c=8.97159e-17
C94 (\17\:CKb VSS) capacitor c=7.46073e-17
C95 (\18\:CKb VSS) capacitor c=1.89662e-16
C96 (\19\:CKb VSS) capacitor c=2.31207e-16
C97 (\20\:CKb VSS) capacitor c=6.9008e-17
C98 (\21\:CKb VSS) capacitor c=2.74742e-17
C99 (\22\:CKb VSS) capacitor c=2.90794e-17
C100 (\4\:CK VSS) capacitor c=8.586e-17
C101 (\5\:VDD VSS) capacitor c=3.01396e-17
C102 (\11\:VDD VSS) capacitor c=4.00317e-17
C103 (\14\:VDD VSS) capacitor c=3.38997e-17
Rk15 (\7\:SN SN) resistor r=1.175 c=0
Rk16 (SN \8\:SN) resistor r=0.4637 c=0
Rk42 (\2\:VSS \4\:VSS) resistor r=0.5234 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.3836 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.3307 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.08759 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3008 c=0
Rk52 (\9\:VSS VSS) resistor r=0.0151 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.8223 c=0
Rk53 (\5\:VSS \15\:VSS) resistor r=0.2656 c=0
Rk54 (\6\:VSS \17\:VSS) resistor r=0.267 c=0
Rk55 (\8\:VSS \19\:VSS) resistor r=0.2333 c=0
Rk60 (\2\:VDD \4\:VDD) resistor r=0.5094 c=0
Rk61 (\4\:VDD \5\:VDD) resistor r=0.351 c=0
Rk62 (\5\:VDD \6\:VDD) resistor r=0.4513 c=0
Rk63 (\5\:VDD \8\:VDD) resistor r=0.3137 c=0
Rk64 (\6\:VDD \10\:VDD) resistor r=0.07149 c=0
Rk65 (\6\:VDD \11\:VDD) resistor r=0.2735 c=0
Rk66 (\11\:VDD \13\:VDD) resistor r=0.04332 c=0
Rk69 (\14\:VDD VDD) resistor r=0.2304 c=0
Rk67 (\11\:VDD \14\:VDD) resistor r=0.6082 c=0
Rk68 (\14\:VDD \16\:VDD) resistor r=0.1889 c=0
Rk41 (\4\:CK CK) resistor r=0.0524 c=0
Rk27 (D \4\:D) resistor r=0.07894 c=0
Rk7 (\17\:qbint \18\:qbint) resistor r=0.3857 c=0
Rk8 (\18\:qbint \19\:qbint) resistor r=0.1733 c=0
Rk9 (\18\:qbint \21\:qbint) resistor r=0.1278 c=0
Rk10 (\18\:qbint \23\:qbint) resistor r=0.4097 c=0
Rk12 (\9\:n35 \10\:n35) resistor r=0.3993 c=0
Rk13 (\10\:n35 \11\:n35) resistor r=0.5893 c=0
Rk14 (\10\:n35 \13\:n35) resistor r=0.4609 c=0
Rk33 (\13\:CKb \15\:CKb) resistor r=0.3993 c=0
Rk34 (\15\:CKb \16\:CKb) resistor r=0.6629 c=0
Rk35 (\16\:CKb \17\:CKb) resistor r=0.288 c=0
Rk36 (\17\:CKb \18\:CKb) resistor r=0.1012 c=0
Rk37 (\18\:CKb \19\:CKb) resistor r=1.6357 c=0
Rk38 (\19\:CKb \20\:CKb) resistor r=0.3867 c=0
Rk39 (\16\:CKb \21\:CKb) resistor r=0.05282 c=0
Rk40 (\18\:CKb \22\:CKb) resistor r=0.0961 c=0
Rk17 (\6\:mout \7\:mout) resistor r=0.1781 c=0
Rk18 (\7\:mout \8\:mout) resistor r=0.1875 c=0
Rk19 (\8\:mout \10\:mout) resistor r=0.4517 c=0
Rk20 (\7\:mout \11\:mout) resistor r=0.2354 c=0
Rk21 (\11\:mout \13\:mout) resistor r=0.0734 c=0
Rk22 (\8\:mout \15\:mout) resistor r=0.1392 c=0
Rk23 (\11\:mout \16\:mout) resistor r=0.226 c=0
Rk28 (\7\:CKbb \8\:CKbb) resistor r=0.1304 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=1.6237 c=0
Rk30 (\8\:CKbb \10\:CKbb) resistor r=0.3576 c=0
Rk31 (\10\:CKbb \12\:CKbb) resistor r=0.3589 c=0
Rk32 (\10\:CKbb \14\:CKbb) resistor r=0.02968 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.5758 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.2468 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.2607 c=0
Rk11 (\2\:n41 \4\:n41) resistor r=0.5697 c=0
Rl27 (\4\:SN \5\:SN) resistor r=113.719 c=0
Rl28 (\5\:SN \6\:SN) resistor r=29.5379 c=0
Rl19 (\1\:SN \2\:SN) resistor r=87.2302 c=0
Rl20 (\2\:SN \3\:SN) resistor r=98.7687 c=0
Rl42 (\1\:CK \2\:CK) resistor r=39.6174 c=0
Rl43 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl38 (\1\:D \2\:D) resistor r=60.3072 c=0
Rl39 (\2\:D \3\:D) resistor r=67.1242 c=0
Rl21 (\15\:qbint \14\:qbint) resistor r=158.848 c=0
Rl22 (\15\:qbint \16\:qbint) resistor r=24.2328 c=0
Rl7 (qbint \8\:qbint) resistor r=4.8851 c=0
Rl17 (n35 \6\:n35) resistor r=3.3229 c=0
Rl40 (\9\:CKb \10\:CKb) resistor r=131.461 c=0
Rl41 (\10\:CKb \11\:CKb) resistor r=31.461 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=24.2328 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=46.8184 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=30.3481 c=0
Rl23 (CKb \2\:CKb) resistor r=66.8207 c=0
Rl33 (\2\:mout \4\:mout) resistor r=82.3738 c=0
Rl31 (mout \2\:mout) resistor r=96.1317 c=0
Rl32 (\2\:mout \3\:mout) resistor r=37.675 c=0
Rl24 (CKbb \2\:CKbb) resistor r=138.462 c=0
Rl36 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl37 (\5\:CKbb \6\:CKbb) resistor r=151.11 c=0
Rl25 (CKbb \3\:CKbb) resistor r=29.5379 c=0
Rl29 (n20 \2\:n20) resistor r=30.7692 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=131.434 c=0
Rz10 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz13 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz19 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz3 (\21\:qbint \20\:qbint) resistor r=75 c=0
Rz4 (\13\:n35 \12\:n35) resistor r=75 c=0
Rz9 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz5 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz7 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry12 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry13 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry14 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry18 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry19 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry3 (\23\:qbint \22\:qbint) resistor r=31 c=0
Ry6 (\9\:n35 \8\:n35) resistor r=62 c=0
Ry11 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry4 (n41 \2\:n41) resistor r=62 c=0
Ry5 (\3\:n41 \4\:n41) resistor r=31 c=0
Rx4 (\5\:SN \7\:SN) resistor r=45 c=0
Rx5 (\2\:SN \8\:SN) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\17\:qbint \15\:qbint) resistor r=45 c=0
Rx2 (\19\:qbint \8\:qbint) resistor r=45 c=0
Rx3 (\11\:n35 \6\:n35) resistor r=45 c=0
Rx11 (\8\:CKb \17\:CKb) resistor r=45 c=0
Rx12 (\3\:CKb \19\:CKb) resistor r=45 c=0
Rx13 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \22\:CKb) resistor r=45 c=0
Rx6 (\3\:mout \16\:mout) resistor r=45 c=0
Rx9 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx10 (\3\:CKbb \9\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (Q qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.948e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72817e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn50 (n42 \3\:SN \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=3.28e-14 ps=8.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=1.01e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (n40 \16\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=7.073e-14 ps=7.3e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=8.05e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn52 (\12\:n35 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=4.715e-14 ps=1.1e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn40 (\12\:n35 \2\:CKbb \9\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=4.715e-14 ps=6.9e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (n25 \6\:SN \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=1.23e-14 ps=6.9e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn31 (\12\:mout \3\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (n30 mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.665e-14 ps=6.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.64512e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn35 (\4\:n20 \6\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=3.28e-14 ps=6.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=7.89512e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn26 (\4\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=5.84512e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn25 (n21 \3\:D \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.392e-14 ad=1.23e-14 ps=9e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=4.79512e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn45_1__rcx (\20\:qbint n35 \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.273e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.49e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn21 (\11\:CKbb \11\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.392e-14 ad=4.785e-14 ps=9e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=3.3e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn20 (\14\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp50 (\3\:n41 \1\:SN VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=4.96e-14 ps=1.04e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=3.45e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp51 (\3\:n41 \14\:qbint \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=1.4e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp52 (\8\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=6.045e-14 ps=9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.98065e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:n35 \4\:CKb \14\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.9e-14 ad=6.045e-14 ps=1.12e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.58065e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\5\:mout \4\:SN \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=4.96e-14 ps=1.8e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.32798e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp31 (\5\:mout n20 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1e-13 ad=4.96e-14 ps=2.12e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.12298e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (n31 \4\:mout \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1e-13 ad=1.86e-14 ps=2.12e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=8.17984e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\8\:n20 \6\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=1.0365e-13 ps=7.4e-07 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=7.12984e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp26 (\8\:n20 \4\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=1.0365e-13 ps=8.9e-07 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.14032e-07 sb=4.84597e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (n22 \1\:D \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=4.185e-14 ps=1.04e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09403e-06 sb=3.04597e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp45 (\22\:qbint n35 VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.135e-14 ad=5.58e-14 ps=1.07e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=8.25e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(2)
mp21 (\13\:CKbb \9\:CKb \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.465e-14 ad=3.01e-14 ps=1.04e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2536e-06 sb=1.4e-07 sd=160n sca=13.4401 \
        scb=0.0126994 scc=0.000544006 m=(1)
mp20 (\12\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=51.6924 \
        scb=0.0366725 scc=0.00607082 m=(1)
ends DFFSHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:42 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSHQX8
// View name: extracted

simulator lang=spectre

subckt DFFSHQX8 CK D Q SN VDD VSS
mp55_1__rcx (Q qbint \11\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.807e-14 ad=6.993e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.34079e-06 sd=160n \
        sca=40.5428 scb=0.0363846 scc=0.00414682 m=(7)
C1 (SN VSS) capacitor c=1.85832e-16
C2 (VDD VSS) capacitor c=3.11033e-16
C3 (CK VSS) capacitor c=4.07855e-17
C4 (D VSS) capacitor c=6.84153e-17
C5 (Q VSS) capacitor c=5.04885e-16
C6 (qbint VSS) capacitor c=3.30854e-16
C7 (n35 VSS) capacitor c=2.39635e-16
C8 (n40 VSS) capacitor c=4.3373e-18
C9 (CKb VSS) capacitor c=4.47048e-17
C10 (mout VSS) capacitor c=8.68988e-17
C11 (CKbb VSS) capacitor c=6.13674e-17
C12 (n25 VSS) capacitor c=1.85903e-18
C13 (n20 VSS) capacitor c=4.62497e-17
C14 (n30 VSS) capacitor c=2.32266e-18
C15 (n41 VSS) capacitor c=6.77725e-17
C16 (n31 VSS) capacitor c=1.69238e-18
C17 (n22 VSS) capacitor c=6.77909e-18
C18 (\4\:CK VSS) capacitor c=4.32328e-17
C19 (\4\:D VSS) capacitor c=5.50143e-17
C20 (\5\:CKbb VSS) capacitor c=7.88366e-17
C21 (\10\:CKb VSS) capacitor c=7.35145e-17
C22 (\5\:SN VSS) capacitor c=6.71427e-17
C23 (\4\:CKb VSS) capacitor c=2.00032e-17
C24 (\9\:CKb VSS) capacitor c=2.78611e-17
C25 (\23\:qbint VSS) capacitor c=6.00812e-17
C26 (\4\:SN VSS) capacitor c=5.97706e-17
C27 (\3\:CK VSS) capacitor c=5.0508e-17
C28 (\3\:D VSS) capacitor c=8.36671e-17
C29 (\12\:CKb VSS) capacitor c=5.7906e-17
C30 (\7\:CKbb VSS) capacitor c=3.3384e-17
C31 (\4\:mout VSS) capacitor c=4.34124e-17
C32 (\3\:n20 VSS) capacitor c=8.19419e-17
C33 (\8\:SN VSS) capacitor c=4.39705e-17
C34 (\8\:CKb VSS) capacitor c=4.75995e-17
C35 (\3\:CKbb VSS) capacitor c=2.96839e-17
C36 (\25\:qbint VSS) capacitor c=3.03991e-17
C37 (\3\:SN VSS) capacitor c=5.80676e-17
C38 (\1\:CK VSS) capacitor c=1.43578e-17
C39 (\1\:D VSS) capacitor c=3.11762e-17
C40 (\13\:CKb VSS) capacitor c=4.51414e-17
C41 (\11\:CKb VSS) capacitor c=3.33694e-17
C42 (\6\:CKbb VSS) capacitor c=6.95431e-17
C43 (\3\:mout VSS) capacitor c=1.69826e-17
C44 (\2\:n20 VSS) capacitor c=4.63564e-17
C45 (\7\:SN VSS) capacitor c=2.42626e-17
C46 (\3\:CKb VSS) capacitor c=1.55178e-17
C47 (\4\:CKbb VSS) capacitor c=3.72819e-17
C48 (\7\:CKb VSS) capacitor c=4.44631e-17
C49 (\2\:CKb VSS) capacitor c=5.39302e-17
C50 (\24\:qbint VSS) capacitor c=5.53918e-17
C51 (\1\:SN VSS) capacitor c=2.70349e-17
C52 (\11\:qbint VSS) capacitor c=1.03996e-17
C53 (\16\:CKb VSS) capacitor c=5.45309e-17
C54 (\1\:VDD VSS) capacitor c=3.54887e-17
C55 (\4\:n20 VSS) capacitor c=4.34487e-17
C56 (\16\:VDD VSS) capacitor c=3.9968e-17
C57 (\14\:mout VSS) capacitor c=2.20529e-17
C58 (\18\:VDD VSS) capacitor c=1.88165e-17
C59 (\13\:CKbb VSS) capacitor c=4.06009e-17
C60 (\8\:mout VSS) capacitor c=1.45038e-16
C61 (\11\:n35 VSS) capacitor c=7.48015e-17
C62 (\20\:VDD VSS) capacitor c=3.23099e-17
C63 (\3\:n41 VSS) capacitor c=8.16492e-17
C64 (\3\:VDD VSS) capacitor c=8.52306e-17
C65 (\20\:CKb VSS) capacitor c=6.30514e-17
C66 (\8\:n20 VSS) capacitor c=5.43979e-17
C67 (\12\:mout VSS) capacitor c=3.58699e-17
C68 (\10\:CKbb VSS) capacitor c=5.40019e-17
C69 (\10\:mout VSS) capacitor c=1.12135e-16
C70 (\15\:n35 VSS) capacitor c=8.39291e-17
C71 (\2\:SN VSS) capacitor c=4.52722e-17
C72 (\2\:CKbb VSS) capacitor c=5.08979e-17
C73 (\5\:CKb VSS) capacitor c=3.82173e-17
C74 (\6\:SN VSS) capacitor c=3.94948e-17
C75 (\2\:mout VSS) capacitor c=3.67171e-17
C76 (\2\:D VSS) capacitor c=4.01462e-17
C77 (\2\:CK VSS) capacitor c=5.71215e-17
C78 (\26\:qbint VSS) capacitor c=5.78477e-17
C79 (\27\:qbint VSS) capacitor c=2.39443e-16
C80 (\30\:qbint VSS) capacitor c=4.05649e-17
C81 (\13\:n35 VSS) capacitor c=1.49807e-16
C82 (\14\:n35 VSS) capacitor c=9.10821e-17
C83 (\14\:CKb VSS) capacitor c=5.41143e-17
C84 (\15\:CKb VSS) capacitor c=7.2374e-17
C85 (\9\:SN VSS) capacitor c=1.87737e-16
C86 (\10\:SN VSS) capacitor c=8.18554e-17
C87 (\5\:mout VSS) capacitor c=6.844e-17
C88 (\6\:mout VSS) capacitor c=5.3517e-17
C89 (\7\:mout VSS) capacitor c=1.1568e-16
C90 (\8\:CKbb VSS) capacitor c=1.92082e-16
C91 (\9\:CKbb VSS) capacitor c=1.95054e-16
C92 (\12\:CKbb VSS) capacitor c=4.45538e-17
C93 (\6\:n20 VSS) capacitor c=7.5159e-17
C94 (\7\:n20 VSS) capacitor c=6.03982e-17
C95 (\5\:D VSS) capacitor c=4.7375e-17
C96 (\18\:CKb VSS) capacitor c=8.92922e-17
C97 (\19\:CKb VSS) capacitor c=8.76953e-17
C98 (\22\:CKb VSS) capacitor c=1.24997e-16
C99 (\23\:CKb VSS) capacitor c=1.18026e-16
C100 (\5\:CK VSS) capacitor c=1.57313e-17
C101 (\5\:VDD VSS) capacitor c=1.95326e-17
C102 (\6\:VDD VSS) capacitor c=1.9449e-17
C103 (\8\:VDD VSS) capacitor c=1.33506e-17
C104 (\9\:VDD VSS) capacitor c=1.33436e-16
C105 (\11\:VDD VSS) capacitor c=3.57254e-16
Rk22 (\9\:SN SN) resistor r=1.3402 c=0
Rk23 (SN \10\:SN) resistor r=0.4368 c=0
Rk66 (\2\:VSS \4\:VSS) resistor r=0.2684 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.4034 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.3346 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.2119 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=0.5589 c=0
Rk77 (\10\:VSS VSS) resistor r=0.1074 c=0
Rk72 (\8\:VSS \10\:VSS) resistor r=0.2503 c=0
Rk78 (\5\:VSS \16\:VSS) resistor r=0.189 c=0
Rk79 (\6\:VSS \18\:VSS) resistor r=0.04329 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.2874 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.3909 c=0
Rk46 (\5\:VDD \6\:VDD) resistor r=0.1466 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.4125 c=0
Rk48 (\7\:VDD \8\:VDD) resistor r=0.3683 c=0
Rk49 (\8\:VDD \9\:VDD) resistor r=0.1901 c=0
Rk56 (\11\:VDD VDD) resistor r=0.1074 c=0
Rk51 (\9\:VDD \11\:VDD) resistor r=0.2653 c=0
Rk57 (\5\:VDD \17\:VDD) resistor r=0.2223 c=0
Rk58 (\6\:VDD \19\:VDD) resistor r=0.04329 c=0
Rk59 (\8\:VDD \21\:VDD) resistor r=0.2456 c=0
Rk43 (CK \5\:CK) resistor r=0.122 c=0
Rk37 (\5\:D D) resistor r=0.06086 c=0
Rk9 (\26\:qbint \27\:qbint) resistor r=0.3428 c=0
Rk12 (\27\:qbint \30\:qbint) resistor r=0.2264 c=0
Rk18 (\12\:n35 \13\:n35) resistor r=0.3856 c=0
Rk19 (\13\:n35 \14\:n35) resistor r=0.5675 c=0
Rk20 (\13\:n35 \16\:n35) resistor r=0.4287 c=0
Rk21 (\14\:CKb \15\:CKb) resistor r=0.1594 c=0
Rk38 (\17\:CKb \18\:CKb) resistor r=0.3565 c=0
Rk39 (\18\:CKb \19\:CKb) resistor r=0.3535 c=0
Rk40 (\19\:CKb \21\:CKb) resistor r=0.4129 c=0
Rk41 (\18\:CKb \22\:CKb) resistor r=0.3845 c=0
Rk42 (\22\:CKb \23\:CKb) resistor r=0.8752 c=0
Rk24 (\5\:mout \6\:mout) resistor r=0.289 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.2248 c=0
Rk26 (\7\:mout \9\:mout) resistor r=0.6607 c=0
Rk27 (\9\:mout \11\:mout) resistor r=0.6112 c=0
Rk28 (\6\:mout \13\:mout) resistor r=0.1048 c=0
Rk29 (\7\:mout \15\:mout) resistor r=0.04277 c=0
Rk30 (\8\:CKbb \9\:CKbb) resistor r=1.3642 c=0
Rk31 (\9\:CKbb \11\:CKbb) resistor r=0.3388 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=0.1426 c=0
Rk33 (\9\:CKbb \14\:CKbb) resistor r=0.1202 c=0
Rk34 (\5\:n20 \6\:n20) resistor r=0.2381 c=0
Rk35 (\6\:n20 \7\:n20) resistor r=0.3561 c=0
Rk36 (\6\:n20 \9\:n20) resistor r=0.3065 c=0
Rk17 (\2\:n41 \4\:n41) resistor r=0.4194 c=0
Rl33 (\2\:SN \4\:SN) resistor r=83.495 c=0
Rl32 (\2\:SN \3\:SN) resistor r=106.572 c=0
Rl31 (\1\:SN \2\:SN) resistor r=1.2334 c=0
Rl46 (\5\:SN \6\:SN) resistor r=141.588 c=0
Rl48 (\6\:SN \8\:SN) resistor r=34.3295 c=0
Rl47 (\6\:SN \7\:SN) resistor r=8.3038 c=0
Rl63 (\2\:CK \4\:CK) resistor r=77.7258 c=0
Rl62 (\2\:CK \3\:CK) resistor r=173.88 c=0
Rl61 (\1\:CK \2\:CK) resistor r=28.7005 c=0
Rl60 (\2\:D \4\:D) resistor r=73.8796 c=0
Rl59 (\2\:D \3\:D) resistor r=141.187 c=0
Rl58 (\1\:D \2\:D) resistor r=3.1216 c=0
Rl34 (\24\:qbint \23\:qbint) resistor r=144.613 c=0
Rl35 (\24\:qbint \25\:qbint) resistor r=24.2328 c=0
Rl10 (qbint \11\:qbint) resistor r=4.8851 c=0
Rl57 (\12\:CKb \13\:CKb) resistor r=58.8482 c=0
Rl54 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl40 (\3\:CKb \4\:CKb) resistor r=50.6918 c=0
Rl36 (CKb \2\:CKb) resistor r=106.027 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=86.5163 c=0
Rl44 (\5\:CKb \8\:CKb) resistor r=82.3738 c=0
Rl45 (\6\:CKb \9\:CKb) resistor r=28.3689 c=0
Rl43 (\6\:CKb \7\:CKb) resistor r=7.5029 c=0
Rl42 (\5\:CKb \6\:CKb) resistor r=121.743 c=0
Rl51 (mout \2\:mout) resistor r=95.0334 c=0
Rl53 (\2\:mout \4\:mout) resistor r=62.3411 c=0
Rl52 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl55 (\5\:CKbb \6\:CKbb) resistor r=228.389 c=0
Rl56 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl37 (CKbb \2\:CKbb) resistor r=105.451 c=0
Rl38 (\2\:CKbb \3\:CKbb) resistor r=48.0548 c=0
Rl39 (\2\:CKbb \4\:CKbb) resistor r=125.67 c=0
Rl49 (n20 \2\:n20) resistor r=24.2328 c=0
Rl50 (\2\:n20 \3\:n20) resistor r=166.106 c=0
Rz16 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz14 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz15 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\16\:n35 \15\:n35) resistor r=75 c=0
Rz12 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz8 (\10\:mout \11\:mout) resistor r=75 c=0
Rz9 (\12\:mout \13\:mout) resistor r=75 c=0
Rz10 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry25 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry26 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry27 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry9 (\12\:n35 \11\:n35) resistor r=31 c=0
Ry14 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry10 (\8\:mout \9\:mout) resistor r=31 c=0
Ry11 (\14\:mout \15\:mout) resistor r=62 c=0
Ry12 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry13 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry7 (n41 \2\:n41) resistor r=62 c=0
Ry8 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\7\:SN \9\:SN) resistor r=45 c=0
Rx7 (\1\:SN \10\:SN) resistor r=45 c=0
Rx16 (\1\:CK \5\:CK) resistor r=45 c=0
Rx12 (\1\:D \5\:D) resistor r=45 c=0
Rx1 (\26\:qbint \24\:qbint) resistor r=45 c=0
Rx2 (\30\:qbint \11\:qbint) resistor r=45 c=0
Rx3 (\14\:n35 n35) resistor r=45 c=0
Rx4 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx13 (\13\:CKb \19\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \22\:CKb) resistor r=45 c=0
Rx15 (\3\:CKb \23\:CKb) resistor r=45 c=0
Rx8 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55_1__rcx (Q qbint \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.791e-14 ad=4.636e-14 ps=9.9429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.33e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\27\:qbint n35 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.05e-14 ad=3.987e-14 ps=8.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18462e-07 sb=9.55865e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
mn50 (n42 \3\:SN \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.973e-14 ps=8.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=8.6e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn51 (n40 \25\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=5.432e-14 ps=7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=6.7e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn52 (\15\:n35 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=3.588e-14 ps=9.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.075e-06 sb=3.6e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn40 (\15\:n35 \3\:CKbb \10\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.588e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.295e-06 sb=1.4e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn30 (n25 \8\:SN \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.435e-14 ps=1.42e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3622e-07 sb=2.55e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn31 (\12\:mout \3\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=2.87e-14 ps=5.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5122e-07 sb=1.4e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn36 (n30 \4\:mout \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.358e-14 ps=6.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.03293e-07 sd=160n sca=7.77393 \
        scb=0.00528022 scc=7.94731e-05 m=(1)
mn35 (\8\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=6.458e-14 ps=6.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=7.43293e-07 sd=160n sca=7.77393 \
        scb=0.00528022 scc=7.94731e-05 m=(1)
mn26 (\8\:n20 \12\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.333e-14 ad=6.458e-14 ps=5.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.83293e-07 sd=160n sca=7.77393 \
        scb=0.00528022 scc=7.94731e-05 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.333e-14 ps=7.3e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.73293e-07 sd=160n sca=7.77393 \
        scb=0.00528022 scc=7.94731e-05 m=(1)
mn21 (\10\:CKbb \8\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.63e-14 ad=2.03e-14 ps=1.42e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn20 (\20\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mp45_1__rcx (\27\:qbint n35 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.08e-14 ad=5.62e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=8.67692e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(3)
mp50 (\3\:n41 \4\:SN \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=4.96e-14 ps=1.1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.20161e-07 sb=3.45e-07 sd=160n sca=12.4967 \
        scb=0.0111079 scc=0.00042389 m=(1)
mp51 (\3\:n41 \23\:qbint \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25161e-07 sb=1.4e-07 sd=160n sca=12.4967 \
        scb=0.0111079 scc=0.00042389 m=(1)
mp52 (\11\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\11\:n35 \9\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp30 (\14\:mout \5\:SN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.239e-13 ad=4.96e-14 ps=2.51e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.80887e-07 sb=1.00234e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp31 (\14\:mout n20 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.255e-14 ad=4.96e-14 ps=1.45e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85887e-07 sb=7.97339e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (n31 mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.255e-14 ad=1.86e-14 ps=1.45e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55887e-07 sb=5.27339e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \10\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.92e-14 ps=7.4e-07 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.60887e-07 sb=4.22339e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.92e-14 ps=1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.12339e-07 sb=5.04919e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp25 (n22 \4\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=5.89e-14 ps=9.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.47339e-07 sb=2.69919e-07 sd=160n sca=13.2902 \
        scb=0.0115979 scc=0.000459018 m=(1)
mp21 (\13\:CKbb \4\:CKb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.239e-13 ad=3.01e-14 ps=2.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38442e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp20 (\16\:CKb \4\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.59535e-07 sb=1.4e-07 sd=160n sca=12.5661 \
        scb=0.00990908 scc=0.000142097 m=(1)
ends DFFSHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:43 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRHQX1
// View name: extracted

simulator lang=spectre

subckt DFFSRHQX1 CK D Q RN SN VDD VSS
mp55 (\1\:Q \4\:qbint \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.38e-14 ad=5.46e-14 ps=1.14e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.91154e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
C1 (SN VSS) capacitor c=2.72964e-16
C2 (RN VSS) capacitor c=7.28237e-17
C3 (CK VSS) capacitor c=3.97628e-17
C4 (D VSS) capacitor c=6.54213e-17
C5 (VDD VSS) capacitor c=4.20451e-16
C6 (qbint VSS) capacitor c=1.96808e-17
C7 (n35 VSS) capacitor c=4.80096e-17
C8 (RNb VSS) capacitor c=1.36905e-16
C9 (n42 VSS) capacitor c=7.9225e-17
C10 (n40 VSS) capacitor c=9.23847e-17
C11 (CKb VSS) capacitor c=3.48521e-17
C12 (mout VSS) capacitor c=3.92855e-17
C13 (CKbb VSS) capacitor c=4.27884e-17
C14 (n25 VSS) capacitor c=8.32722e-17
C15 (n20 VSS) capacitor c=2.83194e-17
C16 (n30 VSS) capacitor c=2.79728e-18
C17 (n41 VSS) capacitor c=8.71827e-17
C18 (n43 VSS) capacitor c=1.70491e-18
C19 (n26 VSS) capacitor c=2.74119e-18
C20 (n31 VSS) capacitor c=3.53739e-18
C21 (n22 VSS) capacitor c=4.66065e-18
C22 (\3\:CK VSS) capacitor c=2.47438e-17
C23 (\9\:CKb VSS) capacitor c=5.75469e-17
C24 (\1\:D VSS) capacitor c=5.62034e-17
C25 (\5\:CKbb VSS) capacitor c=4.05899e-17
C26 (\5\:CKb VSS) capacitor c=5.78313e-17
C27 (\4\:SN VSS) capacitor c=6.14063e-17
C28 (\3\:n20 VSS) capacitor c=6.36224e-17
C29 (\4\:CKb VSS) capacitor c=4.1424e-17
C30 (\3\:RNb VSS) capacitor c=8.07873e-17
C31 (\6\:qbint VSS) capacitor c=1.50523e-16
C32 (\1\:SN VSS) capacitor c=5.3972e-17
C33 (\1\:RN VSS) capacitor c=3.06179e-17
C34 (\4\:qbint VSS) capacitor c=4.39177e-17
C35 (\1\:CK VSS) capacitor c=1.7919e-17
C36 (\10\:CKb VSS) capacitor c=3.71105e-17
C37 (\3\:D VSS) capacitor c=7.55065e-17
C38 (\7\:CKb VSS) capacitor c=6.33403e-17
C39 (\7\:CKbb VSS) capacitor c=6.37466e-17
C40 (\4\:mout VSS) capacitor c=3.8554e-17
C41 (\6\:SN VSS) capacitor c=5.35501e-17
C42 (\4\:n20 VSS) capacitor c=4.09095e-17
C43 (\5\:RNb VSS) capacitor c=4.68022e-17
C44 (\3\:CKbb VSS) capacitor c=3.77053e-17
C45 (\3\:CKb VSS) capacitor c=4.94994e-17
C46 (\4\:RNb VSS) capacitor c=6.35425e-17
C47 (\5\:qbint VSS) capacitor c=7.91377e-17
C48 (\3\:SN VSS) capacitor c=3.52398e-17
C49 (\3\:RN VSS) capacitor c=3.21057e-17
C50 (\3\:n35 VSS) capacitor c=3.59149e-17
C51 (\3\:qbint VSS) capacitor c=3.94658e-17
C52 (\2\:CK VSS) capacitor c=1.71585e-17
C53 (\11\:CKb VSS) capacitor c=1.7621e-17
C54 (\2\:D VSS) capacitor c=4.90693e-17
C55 (\8\:CKb VSS) capacitor c=4.45382e-17
C56 (\6\:CKbb VSS) capacitor c=5.63084e-17
C57 (\6\:CKb VSS) capacitor c=4.33615e-17
C58 (\3\:mout VSS) capacitor c=3.38972e-17
C59 (\5\:SN VSS) capacitor c=2.16993e-17
C60 (\4\:CKbb VSS) capacitor c=4.12195e-17
C61 (\2\:CKbb VSS) capacitor c=3.37275e-17
C62 (\2\:RNb VSS) capacitor c=9.07472e-17
C63 (\2\:SN VSS) capacitor c=3.17035e-17
C64 (\2\:RN VSS) capacitor c=2.80623e-17
C65 (\7\:qbint VSS) capacitor c=4.42667e-17
C66 (\2\:n35 VSS) capacitor c=3.68485e-17
C67 (\1\:VDD VSS) capacitor c=4.17504e-17
C68 (\19\:CKb VSS) capacitor c=5.49356e-17
C69 (\16\:CKbb VSS) capacitor c=2.39364e-17
C70 (\8\:VDD VSS) capacitor c=2.99345e-17
C71 (\5\:n20 VSS) capacitor c=4.52183e-17
C72 (\10\:VDD VSS) capacitor c=5.31811e-17
C73 (\12\:mout VSS) capacitor c=3.68047e-17
C74 (\12\:VDD VSS) capacitor c=4.05503e-17
C75 (\7\:mout VSS) capacitor c=1.70905e-16
C76 (\4\:n35 VSS) capacitor c=7.08566e-17
C77 (\15\:VDD VSS) capacitor c=4.8471e-17
C78 (\3\:n41 VSS) capacitor c=1.04891e-16
C79 (\18\:VDD VSS) capacitor c=7.482e-17
C80 (\7\:RNb VSS) capacitor c=2.20635e-16
C81 (\9\:qbint VSS) capacitor c=5.5022e-17
C82 (\21\:VDD VSS) capacitor c=6.61397e-17
C83 (\1\:Q VSS) capacitor c=5.42181e-17
C84 (\3\:VDD VSS) capacitor c=1.68153e-16
C85 (\17\:CKb VSS) capacitor c=9.5956e-17
C86 (\13\:CKbb VSS) capacitor c=8.25655e-17
C87 (\9\:n20 VSS) capacitor c=7.40102e-17
C88 (\14\:mout VSS) capacitor c=1.12812e-16
C89 (\3\:n25 VSS) capacitor c=7.87703e-17
C90 (\10\:mout VSS) capacitor c=1.27707e-17
C91 (\8\:n35 VSS) capacitor c=2.09486e-17
C92 (\3\:n42 VSS) capacitor c=8.02637e-17
C93 (\3\:n40 VSS) capacitor c=1.11079e-16
C94 (\9\:RNb VSS) capacitor c=8.56663e-17
C95 (\12\:qbint VSS) capacitor c=6.37138e-17
C96 (\3\:Q VSS) capacitor c=4.22675e-17
C97 (\2\:qbint VSS) capacitor c=1.33331e-17
C98 (\2\:CKb VSS) capacitor c=6.20072e-17
C99 (\2\:n20 VSS) capacitor c=2.7332e-17
C100 (\2\:mout VSS) capacitor c=4.06332e-17
C101 (\8\:qbint VSS) capacitor c=4.79979e-17
C102 (\11\:qbint VSS) capacitor c=6.53632e-17
C103 (\14\:qbint VSS) capacitor c=6.82954e-17
C104 (\4\:RN VSS) capacitor c=4.82964e-17
C105 (\6\:RNb VSS) capacitor c=1.57867e-16
C106 (\6\:n35 VSS) capacitor c=3.00162e-16
C107 (\7\:n35 VSS) capacitor c=2.96277e-16
C108 (\7\:SN VSS) capacitor c=2.95247e-16
C109 (\8\:SN VSS) capacitor c=2.49209e-17
C110 (\5\:mout VSS) capacitor c=4.11905e-17
C111 (\6\:mout VSS) capacitor c=1.35805e-16
C112 (\9\:mout VSS) capacitor c=7.21954e-17
C113 (\7\:n20 VSS) capacitor c=1.22038e-16
C114 (\8\:n20 VSS) capacitor c=1.41819e-16
C115 (\4\:D VSS) capacitor c=5.74225e-17
C116 (\8\:CKbb VSS) capacitor c=3.48417e-17
C117 (\9\:CKbb VSS) capacitor c=2.56223e-16
C118 (\10\:CKbb VSS) capacitor c=3.91518e-16
C119 (\11\:CKbb VSS) capacitor c=7.21905e-17
C120 (\12\:CKbb VSS) capacitor c=6.58366e-17
C121 (\15\:CKbb VSS) capacitor c=8.03718e-17
C122 (\12\:CKb VSS) capacitor c=1.87532e-16
C123 (\13\:CKb VSS) capacitor c=1.96475e-16
C124 (\14\:CKb VSS) capacitor c=4.17567e-17
C125 (\15\:CKb VSS) capacitor c=1.2419e-16
C126 (\16\:CKb VSS) capacitor c=8.16661e-17
C127 (\4\:CK VSS) capacitor c=8.55084e-17
C128 (\5\:VDD VSS) capacitor c=2.26122e-17
C129 (\6\:VDD VSS) capacitor c=3.43783e-17
C130 (\14\:VDD VSS) capacitor c=8.55816e-17
C131 (\20\:VDD VSS) capacitor c=2.28991e-17
Rk16 (\7\:SN SN) resistor r=2.333 c=0
Rk17 (SN \8\:SN) resistor r=0.02742 c=0
Rk43 (\2\:VSS \4\:VSS) resistor r=0.7014 c=0
Rk44 (\4\:VSS \5\:VSS) resistor r=0.1504 c=0
Rk45 (\5\:VSS \6\:VSS) resistor r=0.5192 c=0
Rk46 (\6\:VSS \7\:VSS) resistor r=0.3336 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=1.2054 c=0
Rk48 (\5\:VSS \10\:VSS) resistor r=0.2741 c=0
Rk49 (\6\:VSS \12\:VSS) resistor r=0.263 c=0
Rk51 (\13\:VSS VSS) resistor r=0.1075 c=0
Rk50 (\8\:VSS \13\:VSS) resistor r=0.4441 c=0
Rk52 (\8\:VSS \15\:VSS) resistor r=0.3018 c=0
Rk53 (\13\:VSS \17\:VSS) resistor r=0.3486 c=0
Rk7 (\4\:RN RN) resistor r=0.04987 c=0
Rk1 (\2\:Q Q) resistor r=0.3194 c=0
Rk2 (Q \4\:Q) resistor r=0.05469 c=0
Rk42 (\4\:CK CK) resistor r=0.05249 c=0
Rk28 (D \4\:D) resistor r=0.04223 c=0
Rk54 (\2\:VDD \4\:VDD) resistor r=0.6926 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.1504 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.4163 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.4365 c=0
Rk58 (\5\:VDD \9\:VDD) resistor r=0.2394 c=0
Rk59 (\6\:VDD \11\:VDD) resistor r=0.2653 c=0
Rk60 (\7\:VDD \13\:VDD) resistor r=0.224 c=0
Rk61 (\7\:VDD \14\:VDD) resistor r=0.7509 c=0
Rk62 (\14\:VDD \16\:VDD) resistor r=0.2312 c=0
Rk63 (\14\:VDD \17\:VDD) resistor r=0.4541 c=0
Rk64 (\17\:VDD \19\:VDD) resistor r=0.405 c=0
Rk67 (\20\:VDD VDD) resistor r=0.1075 c=0
Rk65 (\17\:VDD \20\:VDD) resistor r=0.4447 c=0
Rk66 (\20\:VDD \22\:VDD) resistor r=0.3578 c=0
Rk3 (\8\:qbint \10\:qbint) resistor r=0.4183 c=0
Rk4 (\10\:qbint \11\:qbint) resistor r=0.2556 c=0
Rk5 (\11\:qbint \13\:qbint) resistor r=0.2909 c=0
Rk6 (\11\:qbint \14\:qbint) resistor r=0.349 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.2994 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.3509 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.08492 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=1.2267 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.4554 c=0
Rk10 (\2\:n42 \4\:n42) resistor r=0.3862 c=0
Rk12 (\2\:n40 \4\:n40) resistor r=0.6353 c=0
Rk36 (\12\:CKb \13\:CKb) resistor r=1.214 c=0
Rk37 (\13\:CKb \14\:CKb) resistor r=0.1465 c=0
Rk38 (\13\:CKb \15\:CKb) resistor r=0.7366 c=0
Rk39 (\15\:CKb \16\:CKb) resistor r=0.4596 c=0
Rk40 (\16\:CKb \18\:CKb) resistor r=0.3808 c=0
Rk41 (\18\:CKb \20\:CKb) resistor r=0.329 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.1774 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.876 c=0
Rk21 (\8\:mout \9\:mout) resistor r=0.2977 c=0
Rk22 (\9\:mout \11\:mout) resistor r=0.06809 c=0
Rk23 (\6\:mout \13\:mout) resistor r=0.08734 c=0
Rk24 (\9\:mout \15\:mout) resistor r=0.6226 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=0.1395 c=0
Rk30 (\9\:CKbb \10\:CKbb) resistor r=2.1725 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.509 c=0
Rk32 (\9\:CKbb \12\:CKbb) resistor r=0.3496 c=0
Rk33 (\12\:CKbb \14\:CKbb) resistor r=0.3403 c=0
Rk34 (\10\:CKbb \15\:CKbb) resistor r=0.3748 c=0
Rk35 (\12\:CKbb \17\:CKbb) resistor r=0.03495 c=0
Rk18 (\2\:n25 \4\:n25) resistor r=0.4103 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.1437 c=0
Rk26 (\7\:n20 \8\:n20) resistor r=0.782 c=0
Rk27 (\7\:n20 \10\:n20) resistor r=0.3476 c=0
Rk11 (\2\:n41 \4\:n41) resistor r=0.4243 c=0
Rl25 (\4\:SN \6\:SN) resistor r=178.846 c=0
Rl24 (\4\:SN \5\:SN) resistor r=105.282 c=0
Rl8 (\1\:SN \2\:SN) resistor r=26.9231 c=0
Rl9 (\2\:SN \3\:SN) resistor r=91.7582 c=0
Rl6 (\1\:RN \2\:RN) resistor r=49.2328 c=0
Rl7 (\2\:RN \3\:RN) resistor r=87.6944 c=0
Rl38 (\2\:CK \3\:CK) resistor r=41.0521 c=0
Rl37 (\1\:CK \2\:CK) resistor r=26.9231 c=0
Rl33 (\1\:D \2\:D) resistor r=64.1533 c=0
Rl34 (\2\:D \3\:D) resistor r=106.461 c=0
Rl10 (\5\:qbint \6\:qbint) resistor r=203.412 c=0
Rl11 (\6\:qbint \7\:qbint) resistor r=324.513 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=34.3295 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=49.7141 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl4 (n35 \2\:n35) resistor r=70.3867 c=0
Rl5 (\2\:n35 \3\:n35) resistor r=24.2328 c=0
Rl20 (RNb \5\:RNb) resistor r=128.846 c=0
Rl19 (\3\:RNb \4\:RNb) resistor r=182.692 c=0
Rl17 (RNb \2\:RNb) resistor r=773.054 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=53.6412 c=0
Rl35 (\9\:CKb \10\:CKb) resistor r=196.154 c=0
Rl36 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl32 (\7\:CKb \8\:CKb) resistor r=29.5379 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=74.2328 c=0
Rl16 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=147.62 c=0
Rl14 (CKb \2\:CKb) resistor r=140.774 c=0
Rl26 (mout \2\:mout) resistor r=47.3105 c=0
Rl28 (\2\:mout \4\:mout) resistor r=128.08 c=0
Rl27 (\2\:mout \3\:mout) resistor r=71.5271 c=0
Rl30 (\5\:CKbb \6\:CKbb) resistor r=24.7951 c=0
Rl31 (\6\:CKbb \7\:CKbb) resistor r=188.004 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl12 (CKbb \2\:CKbb) resistor r=29.5379 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=55.7471 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=82.3738 c=0
Rl21 (n20 \2\:n20) resistor r=48.0022 c=0
Rz16 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz17 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz18 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz21 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz22 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz23 (\3\:VDD \17\:VDD) resistor r=6.25 c=0
Rz2 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (n42 \2\:n42) resistor r=75 c=0
Rz5 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz6 (n40 \2\:n40) resistor r=75 c=0
Rz7 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz15 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz11 (\10\:mout \11\:mout) resistor r=75 c=0
Rz12 (\14\:mout \15\:mout) resistor r=75 c=0
Rz14 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz9 (n25 \2\:n25) resistor r=75 c=0
Rz10 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\9\:n20 \10\:n20) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry13 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry14 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry19 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry2 (\9\:qbint \10\:qbint) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry7 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\12\:mout \13\:mout) resistor r=62 c=0
Ry10 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry4 (n41 \2\:n41) resistor r=62 c=0
Ry5 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\5\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\7\:qbint \8\:qbint) resistor r=45 c=0
Rx2 (qbint \14\:qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx14 (CKb \12\:CKb) resistor r=45 c=0
Rx15 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx16 (\8\:CKb \15\:CKb) resistor r=45 c=0
Rx17 (\11\:CKb \16\:CKb) resistor r=45 c=0
Rx8 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (n20 \8\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.24e-14 ad=3.64e-14 ps=8.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.83846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn45 (\12\:qbint \3\:n35 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.24e-14 ad=4.817e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.35e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (n42 \3\:SN \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=3.997e-14 ps=1.19e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35976e-07 sb=6.15e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn52 (\3\:n40 \5\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.997e-14 ad=3.28e-14 ps=8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75976e-07 sb=3.75e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn51 (\3\:n40 \4\:RNb \3\:n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=3.28e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.80976e-07 sb=1.7e-07 sd=160n sca=9.90451 \
        scb=0.00881556 scc=0.00026609 m=(1)
mn53 (\8\:n35 \3\:CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.895e-14 ps=6.9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\8\:n35 \3\:CKbb \10\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.612e-14 ad=3.895e-14 ps=8.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\14\:mout \5\:RNb \3\:n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=3.28e-14 ps=8.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.76183e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn32 (\14\:mout \4\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.57878e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn30 (n25 \6\:SN \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=5.33e-14 ps=1.08e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.27378e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn35 (n30 \4\:mout \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=4.407e-14 ps=1.08e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=8.9378e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn36 (\9\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=5.022e-14 ps=8.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=6.3378e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn26 (\9\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.022e-14 ps=5.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=3.4378e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn25 (n21 \3\:D \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.17e-14 ad=1.23e-14 ps=1.02e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=2.3878e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn22 (\9\:RNb \3\:RN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=2.03e-14 ps=1.19e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn21 (\13\:CKbb \10\:CKb \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.17e-14 ad=4.205e-14 ps=1.02e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55172e-07 sb=2.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\17\:CKb \1\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=3.407e-14 ps=6.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp45 (\9\:qbint n35 \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.38e-14 ad=3.58e-14 ps=1.14e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.15484e-07 sd=160n sca=20.482 \
        scb=0.0196227 scc=0.00140004 m=(1)
mp50 (\3\:n41 \1\:SN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=6.61e-14 ps=2.13e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.06452e-07 sb=3.44677e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp52 (n43 \6\:qbint \3\:n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.61e-14 ad=1.86e-14 ps=1.27e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75242e-07 sb=2.34839e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp51 (n43 \3\:RNb \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.865e-14 ad=1.86e-14 ps=1.33e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.80242e-07 sb=1.29839e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp53 (\4\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.9e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp40 (\4\:n35 \4\:CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.55e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp31 (n26 RNb \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=2.79e-14 ps=1.48e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.02282e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\12\:mout \3\:n20 n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.79e-14 ad=8.54e-14 ps=8e-07 pd=1.54e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=8.87823e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \4\:SN \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=8.54e-14 ps=1.29e-06 pd=1.54e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.36774e-07 sb=1.22782e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp35 (n31 mout \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=4.185e-14 ps=1.29e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16774e-07 sb=8.47823e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp36 (\5\:n20 \5\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=7.26e-14 ps=8.9e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.96774e-07 sb=6.67823e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp26 (\5\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=7.26e-14 ps=9.1e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07492e-06 sb=4.94597e-07 sd=160n sca=11.8311 \
        scb=0.0101697 scc=0.000309549 m=(1)
mp25 (n22 \1\:D \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=4.495e-14 ps=1.04e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26492e-06 sb=3.04597e-07 sd=160n sca=11.8311 \
        scb=0.0101697 scc=0.000309549 m=(1)
mp22 (\7\:RNb \1\:RN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.95e-14 ps=2.13e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83721e-07 sb=2.72326e-07 sd=160n sca=42.6522 \
        scb=0.0278545 scc=0.00553378 m=(1)
mp21 (\16\:CKbb \9\:CKb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.465e-14 ad=3.01e-14 ps=1.04e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32105e-06 sb=1.4e-07 sd=160n sca=10.4043 \
        scb=0.00779196 scc=9.84549e-05 m=(1)
mp20 (\19\:CKb \3\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=50.4517 scb=0.0345 \
        scc=0.00597688 m=(1)
ends DFFSRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:44 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRHQX2
// View name: extracted

simulator lang=spectre

subckt DFFSRHQX2 CK D Q RN SN VDD VSS
mp55 (\1\:Q qbint \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=7.41e-14 ps=1.095e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.22179e-07 sd=160n sca=32.3479 \
        scb=0.0266211 scc=0.00309587 m=(2)
C1 (SN VSS) capacitor c=2.70976e-16
C2 (RN VSS) capacitor c=4.26641e-17
C3 (VDD VSS) capacitor c=4.09282e-16
C4 (CK VSS) capacitor c=3.82141e-17
C5 (D VSS) capacitor c=6.69247e-17
C6 (Q VSS) capacitor c=4.71701e-17
C7 (qbint VSS) capacitor c=1.51426e-16
C8 (n35 VSS) capacitor c=4.75777e-17
C9 (RNb VSS) capacitor c=5.0747e-17
C10 (n42 VSS) capacitor c=7.73019e-17
C11 (n40 VSS) capacitor c=9.46141e-17
C12 (CKb VSS) capacitor c=3.99809e-17
C13 (mout VSS) capacitor c=4.62333e-17
C14 (CKbb VSS) capacitor c=3.56021e-17
C15 (n25 VSS) capacitor c=7.45713e-17
C16 (n20 VSS) capacitor c=3.23802e-17
C17 (n30 VSS) capacitor c=5.489e-18
C18 (n21 VSS) capacitor c=1.51044e-18
C19 (n41 VSS) capacitor c=9.62584e-17
C20 (n43 VSS) capacitor c=3.29651e-18
C21 (n26 VSS) capacitor c=7.09526e-18
C22 (n31 VSS) capacitor c=1.2985e-17
C23 (n22 VSS) capacitor c=1.7513e-18
C24 (\1\:CK VSS) capacitor c=2.67269e-17
C25 (\9\:CKb VSS) capacitor c=6.18073e-17
C26 (\4\:D VSS) capacitor c=6.56728e-17
C27 (\5\:CKbb VSS) capacitor c=4.74637e-17
C28 (\5\:CKb VSS) capacitor c=4.39961e-17
C29 (\4\:SN VSS) capacitor c=7.51676e-17
C30 (\4\:n20 VSS) capacitor c=5.26603e-17
C31 (\2\:RNb VSS) capacitor c=1.14699e-16
C32 (\4\:RNb VSS) capacitor c=6.58119e-17
C33 (\9\:qbint VSS) capacitor c=1.2751e-16
C34 (\1\:SN VSS) capacitor c=4.10962e-17
C35 (\3\:RN VSS) capacitor c=2.90449e-17
C36 (\3\:CK VSS) capacitor c=2.04531e-17
C37 (\10\:CKb VSS) capacitor c=4.46647e-17
C38 (\3\:D VSS) capacitor c=5.27356e-17
C39 (\7\:CKb VSS) capacitor c=5.05185e-17
C40 (\7\:CKbb VSS) capacitor c=4.85904e-17
C41 (\4\:mout VSS) capacitor c=3.48398e-17
C42 (\6\:SN VSS) capacitor c=5.79028e-17
C43 (\3\:n20 VSS) capacitor c=3.49787e-17
C44 (\4\:CKbb VSS) capacitor c=3.98769e-17
C45 (\3\:CKb VSS) capacitor c=5.93051e-17
C46 (\5\:RNb VSS) capacitor c=4.92825e-17
C47 (\8\:qbint VSS) capacitor c=6.5796e-17
C48 (\3\:SN VSS) capacitor c=3.49316e-17
C49 (\1\:RN VSS) capacitor c=2.8176e-17
C50 (\3\:n35 VSS) capacitor c=3.49361e-17
C51 (\2\:CK VSS) capacitor c=1.64555e-17
C52 (\11\:CKb VSS) capacitor c=1.73344e-17
C53 (\1\:D VSS) capacitor c=2.34538e-17
C54 (\6\:CKbb VSS) capacitor c=6.61015e-17
C55 (\8\:CKb VSS) capacitor c=4.73122e-17
C56 (\6\:CKb VSS) capacitor c=2.6862e-17
C57 (\3\:mout VSS) capacitor c=2.93676e-17
C58 (\5\:SN VSS) capacitor c=2.20043e-17
C59 (\4\:CKb VSS) capacitor c=3.70844e-17
C60 (\3\:CKbb VSS) capacitor c=4.7289e-17
C61 (\2\:CKbb VSS) capacitor c=3.22088e-17
C62 (\3\:RNb VSS) capacitor c=9.51065e-17
C63 (\2\:SN VSS) capacitor c=2.96545e-17
C64 (\2\:RN VSS) capacitor c=2.57056e-17
C65 (\10\:qbint VSS) capacitor c=5.08637e-17
C66 (\2\:n35 VSS) capacitor c=3.28837e-17
C67 (\1\:VDD VSS) capacitor c=2.95941e-17
C68 (\12\:CKb VSS) capacitor c=6.36203e-17
C69 (\8\:CKbb VSS) capacitor c=1.42126e-17
C70 (\14\:VDD VSS) capacitor c=3.98209e-17
C71 (\6\:n20 VSS) capacitor c=1.56306e-16
C72 (\16\:VDD VSS) capacitor c=4.10692e-17
C73 (\12\:mout VSS) capacitor c=3.68629e-17
C74 (\18\:VDD VSS) capacitor c=4.48011e-17
C75 (\7\:mout VSS) capacitor c=1.68814e-16
C76 (\4\:n35 VSS) capacitor c=6.67491e-17
C77 (\20\:VDD VSS) capacitor c=3.97334e-17
C78 (\3\:n41 VSS) capacitor c=1.07463e-16
C79 (\22\:VDD VSS) capacitor c=6.12829e-17
C80 (\7\:RNb VSS) capacitor c=1.8214e-16
C81 (\12\:qbint VSS) capacitor c=7.91829e-17
C82 (\1\:Q VSS) capacitor c=5.27998e-17
C83 (\3\:VDD VSS) capacitor c=1.02389e-16
C84 (\14\:CKb VSS) capacitor c=7.52755e-17
C85 (\14\:CKbb VSS) capacitor c=6.25302e-17
C86 (\8\:n20 VSS) capacitor c=8.64051e-17
C87 (\14\:mout VSS) capacitor c=1.13143e-16
C88 (\3\:n25 VSS) capacitor c=8.85635e-17
C89 (\10\:mout VSS) capacitor c=2.79694e-17
C90 (\8\:n35 VSS) capacitor c=2.38705e-17
C91 (\3\:n40 VSS) capacitor c=1.36393e-16
C92 (\3\:n42 VSS) capacitor c=8.57924e-17
C93 (\9\:RNb VSS) capacitor c=8.19062e-17
C94 (\15\:qbint VSS) capacitor c=6.61964e-17
C95 (\3\:Q VSS) capacitor c=4.14873e-17
C96 (\2\:CKb VSS) capacitor c=5.38857e-17
C97 (\2\:n20 VSS) capacitor c=1.80203e-17
C98 (\2\:mout VSS) capacitor c=2.49478e-17
C99 (\2\:D VSS) capacitor c=4.50698e-17
C100 (\11\:qbint VSS) capacitor c=5.60563e-17
C101 (\14\:qbint VSS) capacitor c=6.37639e-17
C102 (\17\:qbint VSS) capacitor c=5.7878e-17
C103 (\4\:RN VSS) capacitor c=7.33045e-17
C104 (\6\:RNb VSS) capacitor c=1.39202e-16
C105 (\6\:n35 VSS) capacitor c=3.41388e-16
C106 (\7\:n35 VSS) capacitor c=2.6828e-16
C107 (\7\:SN VSS) capacitor c=2.83433e-16
C108 (\8\:SN VSS) capacitor c=2.94189e-17
C109 (\5\:mout VSS) capacitor c=3.53323e-17
C110 (\6\:mout VSS) capacitor c=1.2752e-16
C111 (\9\:mout VSS) capacitor c=7.43289e-17
C112 (\5\:n20 VSS) capacitor c=1.50398e-16
C113 (\5\:D VSS) capacitor c=4.10588e-17
C114 (\10\:CKbb VSS) capacitor c=7.07422e-17
C115 (\11\:CKbb VSS) capacitor c=2.21241e-16
C116 (\12\:CKbb VSS) capacitor c=3.74435e-16
C117 (\13\:CKbb VSS) capacitor c=7.82378e-17
C118 (\16\:CKbb VSS) capacitor c=2.51418e-17
C119 (\17\:CKbb VSS) capacitor c=8.25472e-17
C120 (\16\:CKb VSS) capacitor c=5.40596e-17
C121 (\17\:CKb VSS) capacitor c=8.30233e-17
C122 (\18\:CKb VSS) capacitor c=1.97719e-16
C123 (\19\:CKb VSS) capacitor c=1.99318e-16
C124 (\20\:CKb VSS) capacitor c=5.22398e-17
C125 (\21\:CKb VSS) capacitor c=5.46089e-17
C126 (\5\:CK VSS) capacitor c=7.76247e-17
C127 (\5\:VDD VSS) capacitor c=2.04721e-17
C128 (\6\:VDD VSS) capacitor c=3.8778e-17
C129 (\7\:VDD VSS) capacitor c=2.21456e-17
C130 (\9\:VDD VSS) capacitor c=7.68934e-17
C131 (\10\:VDD VSS) capacitor c=3.94136e-17
C132 (\12\:VDD VSS) capacitor c=1.53001e-16
Rk17 (\7\:SN SN) resistor r=2.2141 c=0
Rk18 (SN \8\:SN) resistor r=0.09879 c=0
Rk7 (RN \4\:RN) resistor r=0.1146 c=0
Rk63 (\2\:VSS \4\:VSS) resistor r=0.7521 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.07662 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.533 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.4413 c=0
Rk67 (\7\:VSS \8\:VSS) resistor r=1.0183 c=0
Rk68 (\8\:VSS \9\:VSS) resistor r=0.1854 c=0
Rk71 (\10\:VSS VSS) resistor r=0.0698 c=0
Rk69 (\9\:VSS \10\:VSS) resistor r=0.2758 c=0
Rk72 (\5\:VSS \13\:VSS) resistor r=0.04333 c=0
Rk73 (\6\:VSS \15\:VSS) resistor r=0.265 c=0
Rk74 (\8\:VSS \17\:VSS) resistor r=0.33 c=0
Rk45 (\2\:VDD \4\:VDD) resistor r=0.8097 c=0
Rk46 (\4\:VDD \5\:VDD) resistor r=0.09262 c=0
Rk47 (\5\:VDD \6\:VDD) resistor r=0.4737 c=0
Rk48 (\6\:VDD \7\:VDD) resistor r=0.3885 c=0
Rk49 (\7\:VDD \8\:VDD) resistor r=0.09764 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.632 c=0
Rk51 (\9\:VDD \10\:VDD) resistor r=0.4938 c=0
Rk52 (\10\:VDD \11\:VDD) resistor r=0.07757 c=0
Rk55 (\12\:VDD VDD) resistor r=0.0698 c=0
Rk53 (\11\:VDD \12\:VDD) resistor r=0.2532 c=0
Rk56 (\5\:VDD \15\:VDD) resistor r=0.3466 c=0
Rk57 (\6\:VDD \17\:VDD) resistor r=0.19 c=0
Rk58 (\7\:VDD \19\:VDD) resistor r=0.1923 c=0
Rk59 (\9\:VDD \21\:VDD) resistor r=0.19 c=0
Rk60 (\10\:VDD \23\:VDD) resistor r=0.1718 c=0
Rk44 (CK \5\:CK) resistor r=0.05712 c=0
Rk27 (\5\:D D) resistor r=0.1918 c=0
Rk1 (Q \2\:Q) resistor r=0.1207 c=0
Rk2 (\2\:Q \4\:Q) resistor r=0.3721 c=0
Rk3 (\11\:qbint \13\:qbint) resistor r=0.4038 c=0
Rk4 (\13\:qbint \14\:qbint) resistor r=0.2523 c=0
Rk5 (\14\:qbint \16\:qbint) resistor r=0.2897 c=0
Rk6 (\14\:qbint \17\:qbint) resistor r=0.3486 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.2646 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.2813 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.09796 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=1.0653 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.3734 c=0
Rk10 (\2\:n42 \4\:n42) resistor r=0.3899 c=0
Rk12 (\2\:n40 \4\:n40) resistor r=0.7499 c=0
Rk35 (\13\:CKb \15\:CKb) resistor r=0.3039 c=0
Rk36 (\15\:CKb \16\:CKb) resistor r=0.3682 c=0
Rk37 (\16\:CKb \17\:CKb) resistor r=0.2592 c=0
Rk38 (\17\:CKb \18\:CKb) resistor r=0.5823 c=0
Rk39 (\18\:CKb \19\:CKb) resistor r=1.2197 c=0
Rk40 (\17\:CKb \20\:CKb) resistor r=0.2127 c=0
Rk41 (\18\:CKb \21\:CKb) resistor r=0.2339 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.1687 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.8668 c=0
Rk21 (\8\:mout \9\:mout) resistor r=0.2852 c=0
Rk22 (\9\:mout \11\:mout) resistor r=0.1572 c=0
Rk23 (\6\:mout \13\:mout) resistor r=0.08695 c=0
Rk24 (\9\:mout \15\:mout) resistor r=0.4786 c=0
Rk28 (\9\:CKbb \10\:CKbb) resistor r=0.04813 c=0
Rk29 (\10\:CKbb \11\:CKbb) resistor r=0.3166 c=0
Rk30 (\11\:CKbb \12\:CKbb) resistor r=2.069 c=0
Rk31 (\12\:CKbb \13\:CKbb) resistor r=0.4924 c=0
Rk32 (\10\:CKbb \15\:CKbb) resistor r=0.3959 c=0
Rk33 (\11\:CKbb \16\:CKbb) resistor r=0.06445 c=0
Rk34 (\12\:CKbb \17\:CKbb) resistor r=0.3648 c=0
Rk16 (\2\:n25 \4\:n25) resistor r=0.3596 c=0
Rk25 (\5\:n20 \7\:n20) resistor r=0.8727 c=0
Rk26 (\7\:n20 \9\:n20) resistor r=0.448 c=0
Rk11 (\2\:n41 \4\:n41) resistor r=0.5639 c=0
Rl28 (\4\:SN \6\:SN) resistor r=167.308 c=0
Rl27 (\4\:SN \5\:SN) resistor r=68.032 c=0
Rl11 (\1\:SN \2\:SN) resistor r=30.7692 c=0
Rl12 (\2\:SN \3\:SN) resistor r=78.022 c=0
Rl10 (\2\:RN \3\:RN) resistor r=46.985 c=0
Rl9 (\1\:RN \2\:RN) resistor r=64.6174 c=0
Rl41 (\1\:CK \2\:CK) resistor r=39.6174 c=0
Rl42 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl38 (\2\:D \4\:D) resistor r=77.7258 c=0
Rl37 (\2\:D \3\:D) resistor r=81.5719 c=0
Rl36 (\1\:D \2\:D) resistor r=1.2334 c=0
Rl13 (\8\:qbint \9\:qbint) resistor r=149.566 c=0
Rl14 (\10\:qbint \9\:qbint) resistor r=392.285 c=0
Rl7 (n35 \2\:n35) resistor r=74.2328 c=0
Rl8 (\2\:n35 \3\:n35) resistor r=24.2328 c=0
Rl20 (RNb \2\:RNb) resistor r=151.489 c=0
Rl23 (\4\:RNb \5\:RNb) resistor r=132.692 c=0
Rl21 (\2\:RNb \3\:RNb) resistor r=765.924 c=0
Rl22 (\3\:RNb \4\:RNb) resistor r=56.9251 c=0
Rl39 (\9\:CKb \10\:CKb) resistor r=164.95 c=0
Rl40 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl33 (\7\:CKb \8\:CKb) resistor r=26.098 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=33.8482 c=0
Rl17 (CKb \2\:CKb) resistor r=30.4507 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=139.928 c=0
Rl19 (\2\:CKb \4\:CKb) resistor r=154.421 c=0
Rl29 (mout \2\:mout) resistor r=47.3105 c=0
Rl31 (\2\:mout \4\:mout) resistor r=116.541 c=0
Rl30 (\2\:mout \3\:mout) resistor r=34.9887 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=24.7951 c=0
Rl35 (\6\:CKbb \7\:CKbb) resistor r=155.312 c=0
Rl16 (\3\:CKbb \4\:CKbb) resistor r=31.0981 c=0
Rl15 (CKbb \2\:CKbb) resistor r=29.4849 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=45.3874 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=76.1566 c=0
Rl24 (n20 \2\:n20) resistor r=34.9887 c=0
Rz19 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz20 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz21 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz22 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz16 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz17 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz2 (\16\:qbint \15\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (n42 \2\:n42) resistor r=75 c=0
Rz5 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz6 (n40 \2\:n40) resistor r=75 c=0
Rz7 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz15 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz11 (\10\:mout \11\:mout) resistor r=75 c=0
Rz12 (\14\:mout \15\:mout) resistor r=75 c=0
Rz14 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz9 (n25 \2\:n25) resistor r=75 c=0
Rz10 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry20 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry21 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry12 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry7 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\12\:mout \13\:mout) resistor r=62 c=0
Ry10 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry9 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry4 (n41 \2\:n41) resistor r=62 c=0
Ry5 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\5\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx18 (\2\:CK \5\:CK) resistor r=45 c=0
Rx10 (\1\:D \5\:D) resistor r=45 c=0
Rx1 (\11\:qbint \10\:qbint) resistor r=45 c=0
Rx2 (\17\:qbint qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\3\:RNb \6\:RNb) resistor r=45 c=0
Rx14 (\11\:CKb \16\:CKb) resistor r=45 c=0
Rx15 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx16 (\8\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx8 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \16\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (n20 \5\:n20) resistor r=45 c=0
mn55_1__rcx (\3\:Q qbint \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.94e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.88846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\15\:qbint \3\:n35 \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.24e-14 ad=4.818e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2.35e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (\3\:n42 \3\:SN \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.278e-14 ad=3.28e-14 ps=1.16e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.37073e-07 sb=5.5e-07 sd=160n sca=19.1238 \
        scb=0.0192529 scc=0.0018715 m=(1)
mn52 (\3\:n40 \8\:qbint \3\:n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.42073e-07 sb=3.45e-07 sd=160n sca=19.1238 \
        scb=0.0192529 scc=0.0018715 m=(1)
mn51 (\3\:n40 \5\:RNb n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47073e-07 sb=1.4e-07 sd=160n sca=19.1238 \
        scb=0.0192529 scc=0.0018715 m=(1)
mn53 (\8\:n35 \3\:CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn40 (\8\:n35 \4\:CKbb \10\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn31 (\14\:mout RNb \3\:n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=6.047e-14 ps=7.2e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.85854e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn32 (\14\:mout \3\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.047e-14 ps=8.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.57122e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (n25 \6\:SN \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=4.92e-14 ps=8.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.28622e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (n30 \4\:mout \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.662e-14 ps=8.9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.00122e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn36 (\8\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.662e-14 ad=3.28e-14 ps=1.06e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.435e-06 sb=6.3122e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn26 (\8\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=3.28e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=4.2622e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (n21 \3\:D \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.475e-14 ad=2.05e-14 ps=1.72e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.785e-06 sb=2.8122e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn22 (\9\:RNb \1\:RN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.278e-14 ad=2.03e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.7e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn21 (\14\:CKbb \10\:CKb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.475e-14 ad=3.263e-14 ps=1.72e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.86207e-07 sb=2.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\14\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=3.407e-14 ps=6.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp45 (\12\:qbint n35 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.225e-14 ad=3.58e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.15484e-07 sd=160n sca=16.8189 \
        scb=0.0155179 scc=0.00118078 m=(1)
mp50 (\3\:n41 \1\:SN \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.102e-13 ad=6.045e-14 ps=2.44e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91129e-07 sb=4.86452e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp52 (n43 \9\:qbint \3\:n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=2.17e-14 ps=1.01e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.31129e-07 sb=2.46452e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp51 (n43 \4\:RNb \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.755e-14 ad=2.17e-14 ps=1.49e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.46129e-07 sb=1.31452e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp53 (\4\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=6.045e-14 ps=1.12e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.87097e-07 sb=4.95e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\4\:n35 CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=6.045e-14 ps=1.13e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.27097e-07 sb=2.55e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp31 (n26 \2\:RNb \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=5.58e-14 ps=1.44e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.30419e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\12\:mout \4\:n20 n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=7e-14 ps=9.8e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.07919e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \4\:SN \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=7e-14 ps=1.36e-06 pd=1.32e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.74194e-07 sb=1.26774e-06 sd=160n sca=14.8314 scb=0.0138806 \
        scc=0.000865287 m=(1)
mp35 (n31 mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=7.13e-14 ps=1.36e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.59194e-07 sb=9.82742e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp36 (\6\:n20 \5\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=7.42e-14 ps=1.08e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03419e-06 sb=7.07742e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.42e-14 ps=8.5e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29621e-06 sb=4.29919e-07 sd=160n sca=14.4984 \
        scb=0.0135284 scc=0.000799873 m=(1)
mp25 (n22 \4\:D \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.565e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45621e-06 sb=2.69919e-07 sd=160n sca=14.4984 \
        scb=0.0135284 scc=0.000799873 m=(1)
mp22 (\7\:RNb \3\:RN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.102e-13 ad=2.87e-14 ps=2.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33488e-07 sb=3.48837e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp21 (\8\:CKbb \9\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83605e-06 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp20 (\12\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=5.052e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.8e-07 sd=160n sca=53.9205 \
        scb=0.0402944 scc=0.00632464 m=(1)
ends DFFSRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:45 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRHQX4
// View name: extracted

simulator lang=spectre

subckt DFFSRHQX4 CK D Q RN SN VDD VSS
mp55 (Q qbint \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.727e-14 ps=1.09e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26436e-06 sd=160n sca=23.6869 \
        scb=0.022528 scc=0.00180834 m=(4)
C1 (RN VSS) capacitor c=4.76846e-17
C2 (VDD VSS) capacitor c=4.28839e-16
C3 (D VSS) capacitor c=5.97066e-17
C4 (Q VSS) capacitor c=2.61523e-16
C5 (qbint VSS) capacitor c=2.60196e-16
C6 (n35 VSS) capacitor c=1.83936e-17
C7 (RNb VSS) capacitor c=2.52329e-17
C8 (n40 VSS) capacitor c=7.76128e-17
C9 (n42 VSS) capacitor c=1.32548e-16
C10 (CKb VSS) capacitor c=3.92168e-17
C11 (mout VSS) capacitor c=1.00022e-16
C12 (CKbb VSS) capacitor c=2.7593e-17
C13 (n25 VSS) capacitor c=5.49539e-17
C14 (n20 VSS) capacitor c=4.03733e-17
C15 (n30 VSS) capacitor c=2.00257e-18
C16 (n43 VSS) capacitor c=8.35437e-19
C17 (n41 VSS) capacitor c=9.07667e-17
C18 (n26 VSS) capacitor c=5.75359e-18
C19 (n31 VSS) capacitor c=6.28923e-18
C20 (n22 VSS) capacitor c=2.90145e-18
C21 (\1\:CK VSS) capacitor c=2.64012e-17
C22 (\9\:CKb VSS) capacitor c=5.65385e-17
C23 (\1\:D VSS) capacitor c=6.72122e-17
C24 (\5\:CKbb VSS) capacitor c=3.80915e-17
C25 (\5\:CKb VSS) capacitor c=3.601e-17
C26 (\4\:mout VSS) capacitor c=4.92966e-17
C27 (\6\:SN VSS) capacitor c=7.45625e-17
C28 (\3\:n20 VSS) capacitor c=6.37411e-17
C29 (\6\:RNb VSS) capacitor c=1.19837e-16
C30 (\3\:CKb VSS) capacitor c=4.3628e-17
C31 (\3\:CKbb VSS) capacitor c=5.10063e-17
C32 (\1\:SN VSS) capacitor c=4.93783e-17
C33 (\15\:qbint VSS) capacitor c=9.77578e-17
C34 (\2\:RNb VSS) capacitor c=5.73805e-17
C35 (\3\:RN VSS) capacitor c=4.14765e-17
C36 (\3\:CK VSS) capacitor c=2.19379e-17
C37 (\11\:CKb VSS) capacitor c=2.52134e-17
C38 (\3\:D VSS) capacitor c=5.64441e-17
C39 (\7\:CKb VSS) capacitor c=5.29246e-17
C40 (\9\:CKbb VSS) capacitor c=6.5801e-17
C41 (\5\:SN VSS) capacitor c=9.01512e-17
C42 (\4\:n20 VSS) capacitor c=3.37067e-17
C43 (\8\:RNb VSS) capacitor c=4.32389e-17
C44 (\3\:SN VSS) capacitor c=4.70152e-17
C45 (\18\:qbint VSS) capacitor c=3.10153e-17
C46 (\5\:RNb VSS) capacitor c=4.81474e-17
C47 (\1\:RN VSS) capacitor c=3.55298e-17
C48 (\2\:CK VSS) capacitor c=2.20061e-17
C49 (\10\:CKb VSS) capacitor c=4.69058e-17
C50 (\4\:D VSS) capacitor c=2.61566e-17
C51 (\6\:CKbb VSS) capacitor c=5.11154e-17
C52 (\8\:CKb VSS) capacitor c=3.17945e-17
C53 (\6\:CKb VSS) capacitor c=4.82763e-17
C54 (\8\:CKbb VSS) capacitor c=3.7634e-17
C55 (\3\:mout VSS) capacitor c=2.1777e-17
C56 (\7\:SN VSS) capacitor c=2.55215e-17
C57 (\4\:CKbb VSS) capacitor c=3.58897e-17
C58 (\4\:CKb VSS) capacitor c=4.02757e-17
C59 (\2\:CKb VSS) capacitor c=2.38615e-17
C60 (\7\:RNb VSS) capacitor c=7.5494e-17
C61 (\4\:SN VSS) capacitor c=2.01777e-17
C62 (\17\:qbint VSS) capacitor c=3.24944e-17
C63 (\4\:RNb VSS) capacitor c=3.19002e-17
C64 (\2\:RN VSS) capacitor c=3.93545e-17
C65 (\8\:qbint VSS) capacitor c=2.09935e-17
C66 (\16\:VDD VSS) capacitor c=2.5997e-17
C67 (\20\:CKb VSS) capacitor c=6.90735e-17
C68 (\16\:CKbb VSS) capacitor c=1.92062e-17
C69 (\18\:VDD VSS) capacitor c=3.0642e-17
C70 (\5\:n20 VSS) capacitor c=9.7069e-17
C71 (\20\:VDD VSS) capacitor c=5.70813e-17
C72 (\6\:mout VSS) capacitor c=1.87036e-16
C73 (\22\:VDD VSS) capacitor c=5.2675e-17
C74 (\9\:mout VSS) capacitor c=3.52769e-17
C75 (\9\:n35 VSS) capacitor c=7.63892e-17
C76 (\24\:VDD VSS) capacitor c=3.13015e-17
C77 (\3\:n41 VSS) capacitor c=7.99108e-17
C78 (\26\:VDD VSS) capacitor c=4.5812e-17
C79 (\12\:RNb VSS) capacitor c=6.00164e-17
C80 (\25\:qbint VSS) capacitor c=6.32179e-17
C81 (\1\:VDD VSS) capacitor c=8.45647e-17
C82 (\18\:CKb VSS) capacitor c=1.10322e-16
C83 (\12\:CKbb VSS) capacitor c=9.93e-17
C84 (\7\:n20 VSS) capacitor c=9.48231e-17
C85 (\14\:mout VSS) capacitor c=1.39369e-16
C86 (\3\:n25 VSS) capacitor c=6.87093e-17
C87 (\12\:mout VSS) capacitor c=1.18962e-16
C88 (\13\:n35 VSS) capacitor c=6.39083e-17
C89 (\3\:n42 VSS) capacitor c=1.29125e-16
C90 (\3\:n40 VSS) capacitor c=9.41386e-17
C91 (\9\:RNb VSS) capacitor c=5.71471e-17
C92 (\23\:qbint VSS) capacitor c=2.17745e-17
C93 (\2\:n35 VSS) capacitor c=2.01972e-16
C94 (\3\:RNb VSS) capacitor c=5.79987e-17
C95 (\16\:qbint VSS) capacitor c=2.99164e-17
C96 (\2\:SN VSS) capacitor c=3.26016e-17
C97 (\2\:CKbb VSS) capacitor c=6.33543e-17
C98 (\2\:n20 VSS) capacitor c=2.90099e-17
C99 (\2\:mout VSS) capacitor c=5.68744e-17
C100 (\7\:CKbb VSS) capacitor c=4.83129e-17
C101 (\2\:D VSS) capacitor c=4.48291e-17
C102 (\4\:RN VSS) capacitor c=4.60385e-17
C103 (\11\:RNb VSS) capacitor c=6.38908e-17
C104 (\19\:qbint VSS) capacitor c=1.62185e-16
C105 (\20\:qbint VSS) capacitor c=1.38075e-16
C106 (\21\:qbint VSS) capacitor c=3.24395e-17
C107 (\22\:qbint VSS) capacitor c=2.85038e-17
C108 (\14\:RNb VSS) capacitor c=9.76506e-17
C109 (\15\:RNb VSS) capacitor c=7.92981e-17
C110 (\11\:n35 VSS) capacitor c=2.70203e-16
C111 (\12\:n35 VSS) capacitor c=2.71347e-16
C112 (\8\:SN VSS) capacitor c=2.32282e-16
C113 (\9\:SN VSS) capacitor c=2.57514e-16
C114 (\5\:mout VSS) capacitor c=5.99315e-17
C115 (\8\:mout VSS) capacitor c=1.50113e-16
C116 (\10\:CKbb VSS) capacitor c=2.03779e-16
C117 (\11\:CKbb VSS) capacitor c=1.8654e-16
C118 (\9\:n20 VSS) capacitor c=7.09107e-17
C119 (\5\:D VSS) capacitor c=5.2635e-17
C120 (\14\:CKbb VSS) capacitor c=9.87274e-17
C121 (\15\:CKbb VSS) capacitor c=6.16533e-17
C122 (\12\:CKb VSS) capacitor c=1.09186e-16
C123 (\13\:CKb VSS) capacitor c=3.70363e-16
C124 (\14\:CKb VSS) capacitor c=3.09244e-16
C125 (\15\:CKb VSS) capacitor c=1.29688e-16
C126 (\16\:CKb VSS) capacitor c=4.43375e-17
C127 (\17\:CKb VSS) capacitor c=1.22839e-16
C128 (\4\:CK VSS) capacitor c=9.15186e-17
C129 (\3\:VDD VSS) capacitor c=9.9664e-18
C130 (\4\:VDD VSS) capacitor c=1.88625e-17
C131 (\6\:VDD VSS) capacitor c=3.63981e-17
C132 (\7\:VDD VSS) capacitor c=4.68311e-17
C133 (\9\:VDD VSS) capacitor c=4.44248e-17
C134 (\10\:VDD VSS) capacitor c=3.33196e-17
C135 (\11\:VDD VSS) capacitor c=2.87644e-16
Rk23 (\8\:SN SN) resistor r=1.8473 c=0
Rk24 (SN \9\:SN) resistor r=0.06253 c=0
Rk70 (\2\:VSS \3\:VSS) resistor r=0.07755 c=0
Rk71 (\3\:VSS \4\:VSS) resistor r=0.4209 c=0
Rk72 (\4\:VSS \5\:VSS) resistor r=0.1528 c=0
Rk73 (\5\:VSS \6\:VSS) resistor r=0.2556 c=0
Rk74 (\6\:VSS \7\:VSS) resistor r=0.9478 c=0
Rk75 (\7\:VSS \8\:VSS) resistor r=0.2521 c=0
Rk81 (\9\:VSS VSS) resistor r=0.0798 c=0
Rk76 (\8\:VSS \9\:VSS) resistor r=0.7761 c=0
Rk82 (\3\:VSS \15\:VSS) resistor r=0.2911 c=0
Rk83 (\4\:VSS \17\:VSS) resistor r=0.3201 c=0
Rk84 (\6\:VSS \19\:VSS) resistor r=0.2443 c=0
Rk85 (\8\:VSS \21\:VSS) resistor r=0.04331 c=0
Rk7 (RN \4\:RN) resistor r=0.05865 c=0
Rk46 (\2\:VDD \3\:VDD) resistor r=0.04996 c=0
Rk47 (\3\:VDD \4\:VDD) resistor r=0.4109 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.1904 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.3208 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.4736 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.4086 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.3249 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.3372 c=0
Rk59 (\11\:VDD VDD) resistor r=0.0798 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.3808 c=0
Rk60 (\3\:VDD \17\:VDD) resistor r=0.4181 c=0
Rk61 (\4\:VDD \19\:VDD) resistor r=0.2477 c=0
Rk62 (\6\:VDD \21\:VDD) resistor r=0.2656 c=0
Rk63 (\7\:VDD \23\:VDD) resistor r=0.1728 c=0
Rk64 (\9\:VDD \25\:VDD) resistor r=0.04331 c=0
Rk65 (\10\:VDD \27\:VDD) resistor r=0.1561 c=0
Rk45 (CK \4\:CK) resistor r=0.0153 c=0
Rk34 (D \5\:D) resistor r=0.08008 c=0
Rk10 (\19\:qbint \20\:qbint) resistor r=1.2162 c=0
Rk11 (\20\:qbint \21\:qbint) resistor r=0.1152 c=0
Rk12 (\21\:qbint \22\:qbint) resistor r=0.1482 c=0
Rk13 (\20\:qbint \24\:qbint) resistor r=0.06093 c=0
Rk14 (\21\:qbint \26\:qbint) resistor r=0.3308 c=0
Rk19 (\10\:n35 \11\:n35) resistor r=0.1886 c=0
Rk20 (\11\:n35 \12\:n35) resistor r=1.9986 c=0
Rk21 (\11\:n35 \14\:n35) resistor r=0.2625 c=0
Rk8 (\10\:RNb \11\:RNb) resistor r=0.1815 c=0
Rk9 (\11\:RNb \13\:RNb) resistor r=0.1938 c=0
Rk16 (\14\:RNb \15\:RNb) resistor r=0.6195 c=0
Rk17 (\2\:n40 \4\:n40) resistor r=0.623 c=0
Rk15 (\2\:n42 \4\:n42) resistor r=0.8462 c=0
Rk38 (\12\:CKb \13\:CKb) resistor r=0.8894 c=0
Rk39 (\13\:CKb \14\:CKb) resistor r=1.8388 c=0
Rk40 (\14\:CKb \15\:CKb) resistor r=0.8798 c=0
Rk41 (\14\:CKb \16\:CKb) resistor r=0.1205 c=0
Rk42 (\15\:CKb \17\:CKb) resistor r=0.3403 c=0
Rk43 (\17\:CKb \19\:CKb) resistor r=0.5888 c=0
Rk44 (\19\:CKb \21\:CKb) resistor r=0.3865 c=0
Rk25 (\5\:mout \7\:mout) resistor r=0.2798 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.9427 c=0
Rk27 (\8\:mout \10\:mout) resistor r=0.1127 c=0
Rk28 (\8\:mout \11\:mout) resistor r=0.234 c=0
Rk29 (\11\:mout \13\:mout) resistor r=0.05313 c=0
Rk30 (\11\:mout \15\:mout) resistor r=0.7334 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=1.2728 c=0
Rk35 (\13\:CKbb \14\:CKbb) resistor r=0.5601 c=0
Rk36 (\14\:CKbb \15\:CKbb) resistor r=0.42 c=0
Rk37 (\14\:CKbb \17\:CKbb) resistor r=0.07802 c=0
Rk22 (\2\:n25 \4\:n25) resistor r=0.3098 c=0
Rk32 (\6\:n20 \8\:n20) resistor r=0.5043 c=0
Rk33 (\8\:n20 \9\:n20) resistor r=0.4955 c=0
Rk18 (\2\:n41 \4\:n41) resistor r=0.2898 c=0
Rl43 (\5\:SN \6\:SN) resistor r=199.566 c=0
Rl44 (\6\:SN \7\:SN) resistor r=24.2328 c=0
Rl30 (\1\:SN \2\:SN) resistor r=51.1566 c=0
Rl31 (\2\:SN \3\:SN) resistor r=156.926 c=0
Rl32 (\2\:SN \4\:SN) resistor r=63.8348 c=0
Rl22 (\2\:RN \3\:RN) resistor r=62.6374 c=0
Rl21 (\1\:RN \2\:RN) resistor r=88.4615 c=0
Rl59 (\1\:CK \2\:CK) resistor r=71.1538 c=0
Rl60 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl54 (\1\:D \2\:D) resistor r=64.8465 c=0
Rl55 (\2\:D \3\:D) resistor r=111.048 c=0
Rl56 (\2\:D \4\:D) resistor r=4.5402 c=0
Rl7 (qbint \8\:qbint) resistor r=5.1512 c=0
Rl27 (\16\:qbint \15\:qbint) resistor r=120.868 c=0
Rl29 (\16\:qbint \18\:qbint) resistor r=34.3295 c=0
Rl28 (\16\:qbint \17\:qbint) resistor r=8.3038 c=0
Rl14 (\2\:n35 n35) resistor r=1.2713 c=0
Rl39 (\6\:RNb \8\:RNb) resistor r=119.231 c=0
Rl38 (\6\:RNb \7\:RNb) resistor r=718.744 c=0
Rl23 (RNb \2\:RNb) resistor r=29.5379 c=0
Rl24 (\2\:RNb \3\:RNb) resistor r=117.286 c=0
Rl26 (\3\:RNb \5\:RNb) resistor r=82.3738 c=0
Rl25 (\3\:RNb \4\:RNb) resistor r=138.387 c=0
Rl57 (\9\:CKb \10\:CKb) resistor r=164.56 c=0
Rl58 (\10\:CKb \11\:CKb) resistor r=26.098 c=0
Rl49 (\7\:CKb \8\:CKb) resistor r=28.079 c=0
Rl48 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl34 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl33 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl47 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl45 (mout \2\:mout) resistor r=178.126 c=0
Rl46 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=24.7951 c=0
Rl36 (\2\:CKbb \3\:CKbb) resistor r=159.159 c=0
Rl35 (CKbb \2\:CKbb) resistor r=34.2969 c=0
Rl37 (\2\:CKbb \4\:CKbb) resistor r=165.959 c=0
Rl53 (\7\:CKbb \9\:CKbb) resistor r=85.2786 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=173.363 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=5.8511 c=0
Rl41 (\2\:n20 \3\:n20) resistor r=91.7544 c=0
Rl42 (\2\:n20 \4\:n20) resistor r=25.6317 c=0
Rl40 (n20 \2\:n20) resistor r=73.9835 c=0
Rz21 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz22 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz17 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz18 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz20 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz4 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz9 (\14\:n35 \13\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz16 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz12 (\12\:mout \13\:mout) resistor r=75 c=0
Rz13 (\14\:mout \15\:mout) resistor r=75 c=0
Rz15 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz10 (n25 \2\:n25) resistor r=75 c=0
Rz11 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz14 (\7\:n20 \8\:n20) resistor r=75 c=0
Ry23 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry24 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry25 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry14 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry15 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry16 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry17 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry4 (\26\:qbint \25\:qbint) resistor r=62 c=0
Ry7 (\10\:n35 \9\:n35) resistor r=31 c=0
Ry3 (\12\:RNb \13\:RNb) resistor r=62 c=0
Ry12 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry8 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry11 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry10 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\7\:SN \8\:SN) resistor r=45 c=0
Rx9 (\4\:SN \9\:SN) resistor r=45 c=0
Rx1 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\4\:D \5\:D) resistor r=45 c=0
Rx3 (\19\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\22\:qbint \8\:qbint) resistor r=45 c=0
Rx7 (\12\:n35 n35) resistor r=45 c=0
Rx2 (\4\:RNb \11\:RNb) resistor r=45 c=0
Rx5 (\7\:RNb \14\:RNb) resistor r=45 c=0
Rx6 (RNb \15\:RNb) resistor r=45 c=0
Rx16 (\2\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx18 (\8\:CKb \15\:CKb) resistor r=45 c=0
Rx19 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (\10\:CKb \17\:CKb) resistor r=45 c=0
Rx10 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\8\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx15 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx13 (n20 \9\:n20) resistor r=45 c=0
mn55 (Q qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.076e-14 ad=4.16e-14 ps=8.425e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.1626e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn51 (\3\:n40 \5\:RNb n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=4.1e-14 ps=9.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=5.95488e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn52 (\3\:n40 \18\:qbint \3\:n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.588e-14 ad=4.1e-14 ps=7.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.50488e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn50 (\3\:n42 \3\:SN \20\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.305e-14 ad=3.588e-14 ps=1.66e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=1.30488e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn53 (\13\:n35 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.55e-14 ad=5.125e-14 ps=8.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73171e-07 sb=5.8e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\13\:n35 CKbb \12\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.68171e-07 sb=2.85e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn31 (\14\:mout \8\:RNb \3\:n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.588e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.42902e-06 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn32 (\14\:mout \4\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.115e-14 ad=3.588e-14 ps=1.17e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.20902e-06 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn30 (n25 \5\:SN \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=6.115e-14 ps=7.3e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.80122e-07 sb=1.03805e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn35 (n30 mout \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85122e-07 sb=8.33049e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn36 (\7\:n20 \9\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.97e-14 ps=5.3e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.90122e-07 sb=7.28049e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn26 (\7\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.153e-14 ad=5.97e-14 ps=6.2e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.13159e-06 sb=5.25854e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (n21 \3\:D \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.79e-14 ad=2.153e-14 ps=8.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28159e-06 sb=3.75854e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn45_1__rcx (\23\:qbint \2\:n35 \9\:VSS VSS) g45n1hvt w=(2.05e-07) \
        l=4.5e-08 nf=1 as=4.444e-14 ad=3.28e-14 ps=1.03e-06 pd=7.3e-07 \
        nrd=1.16667 nrs=1.16667 sa=9.85e-07 sb=4.37683e-07 sd=160n \
        sca=8.14041 scb=0.00590656 scc=0.000103269 m=(2)
mn22 (\9\:RNb \1\:RN \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.545e-14 ad=2.755e-14 ps=1.17e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.89655e-07 sb=1.9e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\12\:CKbb \11\:CKb \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.79e-14 ad=3.263e-14 ps=8.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50121e-06 sb=2.25e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn20 (\18\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp51 (n43 \2\:RNb \26\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0875e-13 ad=1.86e-14 ps=1.53e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=3.78065e-07 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp52 (n43 \15\:qbint \3\:n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.737e-14 ad=1.86e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=2.73065e-07 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp50 (\3\:n41 \1\:SN \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.37e-14 ad=5.737e-14 ps=1.31e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.04355e-07 sb=1.7e-07 sd=160n sca=10.6524 \
        scb=0.00831156 scc=0.000128379 m=(1)
mp53 (\9\:n35 \3\:CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.835e-14 ad=5.89e-14 ps=1.19e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.6e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\9\:n35 \3\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.25e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp31 (n26 \6\:RNb \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.6975e-13 ad=4.34e-14 ps=2.04e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.06331e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\6\:mout \3\:n20 n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=8.78306e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\6\:mout \6\:SN \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=6.73306e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (n31 \4\:mout \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=4.185e-14 ps=1.47e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.22419e-07 sb=1.05492e-06 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp36 (\5\:n20 \5\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=1.24e-13 ps=8.9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.02419e-07 sb=8.74919e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp26 (\5\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=1.24e-13 ps=8.5e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24742e-06 sb=4.29919e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp25 (n22 \1\:D \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.565e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.40742e-06 sb=2.69919e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp45 (\25\:qbint \2\:n35 \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.827e-14 ad=4.96e-14 ps=1.09e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=5.54677e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp22 (\12\:RNb \3\:RN \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=3.977e-14 ps=1.08e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=1.85e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\16\:CKbb \9\:CKb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34698e-06 sb=1.4e-07 sd=160n sca=10.6521 \
        scb=0.00815229 scc=0.000119636 m=(1)
mp20 (\20\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.4e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.51163e-07 sb=1.4e-07 sd=160n sca=52.4731 \
        scb=0.0379902 scc=0.00614793 m=(1)
ends DFFSRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:46 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRHQX8
// View name: extracted

simulator lang=spectre

subckt DFFSRHQX8 CK D Q RN SN VDD VSS
mp55_1__rcx (Q qbint \22\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87978e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (RN VSS) capacitor c=6.52512e-17
C2 (Q VSS) capacitor c=4.88028e-16
C3 (VDD VSS) capacitor c=4.59841e-16
C4 (CK VSS) capacitor c=9.66958e-17
C5 (D VSS) capacitor c=4.53719e-17
C6 (qbint VSS) capacitor c=3.84041e-16
C7 (n35 VSS) capacitor c=2.1147e-16
C8 (RNb VSS) capacitor c=1.36851e-16
C9 (n42 VSS) capacitor c=6.90802e-17
C10 (n40 VSS) capacitor c=8.87269e-17
C11 (CKb VSS) capacitor c=3.48521e-17
C12 (mout VSS) capacitor c=3.94466e-17
C13 (CKbb VSS) capacitor c=3.55075e-17
C14 (n25 VSS) capacitor c=8.34776e-17
C15 (n20 VSS) capacitor c=2.83239e-17
C16 (n30 VSS) capacitor c=1.97998e-18
C17 (n21 VSS) capacitor c=1.42395e-18
C18 (n41 VSS) capacitor c=1.0503e-16
C19 (n43 VSS) capacitor c=2.07482e-18
C20 (n26 VSS) capacitor c=2.74119e-18
C21 (n31 VSS) capacitor c=4.53202e-18
C22 (n22 VSS) capacitor c=1.71154e-18
C23 (\3\:CK VSS) capacitor c=2.78538e-17
C24 (\11\:CKb VSS) capacitor c=5.48524e-17
C25 (\4\:D VSS) capacitor c=7.35709e-17
C26 (\5\:CKbb VSS) capacitor c=3.82639e-17
C27 (\5\:CKb VSS) capacitor c=4.73427e-17
C28 (\4\:SN VSS) capacitor c=6.14196e-17
C29 (\3\:n20 VSS) capacitor c=6.36134e-17
C30 (\4\:CKb VSS) capacitor c=4.16374e-17
C31 (\3\:RNb VSS) capacitor c=7.24483e-17
C32 (\23\:qbint VSS) capacitor c=1.31372e-16
C33 (\1\:SN VSS) capacitor c=4.58467e-17
C34 (\3\:RN VSS) capacitor c=2.54671e-17
C35 (\1\:CK VSS) capacitor c=3.35983e-17
C36 (\10\:CKb VSS) capacitor c=4.74686e-17
C37 (\3\:D VSS) capacitor c=4.47448e-17
C38 (\7\:CKb VSS) capacitor c=4.70864e-17
C39 (\7\:CKbb VSS) capacitor c=7.11245e-17
C40 (\4\:mout VSS) capacitor c=4.16306e-17
C41 (\6\:SN VSS) capacitor c=5.34404e-17
C42 (\4\:n20 VSS) capacitor c=4.09095e-17
C43 (\5\:RNb VSS) capacitor c=4.74295e-17
C44 (\3\:CKbb VSS) capacitor c=3.94011e-17
C45 (\3\:CKb VSS) capacitor c=5.45581e-17
C46 (\4\:RNb VSS) capacitor c=5.72674e-17
C47 (\22\:qbint VSS) capacitor c=7.46428e-17
C48 (\3\:SN VSS) capacitor c=4.05696e-17
C49 (\1\:RN VSS) capacitor c=2.89591e-17
C50 (\2\:CK VSS) capacitor c=3.147e-17
C51 (\9\:CKb VSS) capacitor c=1.97241e-17
C52 (\1\:D VSS) capacitor c=2.3781e-17
C53 (\6\:CKbb VSS) capacitor c=6.6077e-17
C54 (\8\:CKb VSS) capacitor c=5.0284e-17
C55 (\6\:CKb VSS) capacitor c=4.93733e-17
C56 (\3\:mout VSS) capacitor c=3.38855e-17
C57 (\5\:SN VSS) capacitor c=2.16991e-17
C58 (\4\:CKbb VSS) capacitor c=4.29784e-17
C59 (\2\:CKbb VSS) capacitor c=3.26809e-17
C60 (\2\:RNb VSS) capacitor c=9.98769e-17
C61 (\2\:SN VSS) capacitor c=3.39848e-17
C62 (\2\:RN VSS) capacitor c=2.4903e-17
C63 (\24\:qbint VSS) capacitor c=5.15684e-17
C64 (\1\:VDD VSS) capacitor c=1.87466e-17
C65 (\12\:CKb VSS) capacitor c=8.25476e-17
C66 (\16\:CKbb VSS) capacitor c=1.95782e-17
C67 (\6\:VDD VSS) capacitor c=4.34607e-17
C68 (\5\:n20 VSS) capacitor c=4.13105e-17
C69 (\9\:VDD VSS) capacitor c=5.08456e-17
C70 (\12\:mout VSS) capacitor c=3.68201e-17
C71 (\13\:VDD VSS) capacitor c=4.05883e-17
C72 (\7\:mout VSS) capacitor c=1.7114e-16
C73 (\14\:n35 VSS) capacitor c=6.90249e-17
C74 (\16\:VDD VSS) capacitor c=4.44594e-17
C75 (\3\:n41 VSS) capacitor c=1.11497e-16
C76 (\20\:VDD VSS) capacitor c=6.43303e-17
C77 (\7\:RNb VSS) capacitor c=1.79148e-16
C78 (\26\:qbint VSS) capacitor c=3.36672e-16
C79 (\3\:VDD VSS) capacitor c=9.01601e-17
C80 (\14\:CKb VSS) capacitor c=8.26815e-17
C81 (\13\:CKbb VSS) capacitor c=6.40915e-17
C82 (\9\:n20 VSS) capacitor c=7.4376e-17
C83 (\14\:mout VSS) capacitor c=1.13044e-16
C84 (\3\:n25 VSS) capacitor c=8.02452e-17
C85 (\10\:mout VSS) capacitor c=1.79551e-17
C86 (\10\:n35 VSS) capacitor c=3.74663e-17
C87 (\3\:n42 VSS) capacitor c=7.39457e-17
C88 (\3\:n40 VSS) capacitor c=1.15802e-16
C89 (\9\:RNb VSS) capacitor c=8.41867e-17
C90 (\2\:CKb VSS) capacitor c=4.74683e-17
C91 (\2\:n20 VSS) capacitor c=2.7336e-17
C92 (\2\:mout VSS) capacitor c=4.06626e-17
C93 (\2\:D VSS) capacitor c=4.73527e-17
C94 (\25\:qbint VSS) capacitor c=6.44113e-17
C95 (\37\:qbint VSS) capacitor c=2.84518e-17
C96 (\4\:RN VSS) capacitor c=5.07469e-17
C97 (\6\:RNb VSS) capacitor c=1.4977e-16
C98 (\12\:n35 VSS) capacitor c=3.04232e-16
C99 (\13\:n35 VSS) capacitor c=2.61644e-16
C100 (\7\:SN VSS) capacitor c=2.89028e-16
C101 (\8\:SN VSS) capacitor c=2.87444e-16
C102 (\5\:mout VSS) capacitor c=4.12501e-17
C103 (\6\:mout VSS) capacitor c=1.35993e-16
C104 (\9\:mout VSS) capacitor c=7.23739e-17
C105 (\7\:n20 VSS) capacitor c=1.23841e-16
C106 (\8\:n20 VSS) capacitor c=1.42017e-16
C107 (\5\:D VSS) capacitor c=7.29431e-17
C108 (\8\:CKbb VSS) capacitor c=2.35771e-17
C109 (\9\:CKbb VSS) capacitor c=2.42061e-16
C110 (\10\:CKbb VSS) capacitor c=3.97635e-16
C111 (\11\:CKbb VSS) capacitor c=7.97432e-17
C112 (\12\:CKbb VSS) capacitor c=5.56382e-17
C113 (\15\:CKbb VSS) capacitor c=8.05643e-17
C114 (\16\:CKb VSS) capacitor c=5.7568e-17
C115 (\17\:CKb VSS) capacitor c=7.51173e-17
C116 (\18\:CKb VSS) capacitor c=1.79885e-16
C117 (\19\:CKb VSS) capacitor c=1.87905e-16
C118 (\20\:CKb VSS) capacitor c=5.86857e-17
C119 (\21\:CKb VSS) capacitor c=4.31305e-17
C120 (\5\:VDD VSS) capacitor c=2.7023e-17
C121 (\8\:VDD VSS) capacitor c=1.67384e-17
C122 (\12\:VDD VSS) capacitor c=6.29143e-17
C123 (\15\:VDD VSS) capacitor c=4.84582e-17
C124 (\19\:VDD VSS) capacitor c=7.46812e-17
C125 (\22\:VDD VSS) capacitor c=5.30082e-16
Rk32 (\7\:SN SN) resistor r=2.3401 c=0
Rk33 (SN \8\:SN) resistor r=0.003008 c=0
Rk60 (\2\:VSS \4\:VSS) resistor r=0.1197 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.2999 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.4505 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.06755 c=0
Rk64 (\7\:VSS \8\:VSS) resistor r=1.1364 c=0
Rk65 (\8\:VSS \9\:VSS) resistor r=0.325 c=0
Rk72 (\10\:VSS VSS) resistor r=0.1074 c=0
Rk66 (\9\:VSS \10\:VSS) resistor r=0.498 c=0
Rk73 (\5\:VSS \17\:VSS) resistor r=0.04334 c=0
Rk74 (\7\:VSS \19\:VSS) resistor r=0.2622 c=0
Rk75 (\9\:VSS \21\:VSS) resistor r=0.04334 c=0
Rk23 (\4\:RN RN) resistor r=0.04813 c=0
Rk81 (\2\:VDD \4\:VDD) resistor r=0.2856 c=0
Rk82 (\4\:VDD \5\:VDD) resistor r=0.3159 c=0
Rk83 (\5\:VDD \7\:VDD) resistor r=0.3371 c=0
Rk84 (\5\:VDD \8\:VDD) resistor r=0.4011 c=0
Rk85 (\8\:VDD \10\:VDD) resistor r=0.2641 c=0
Rk86 (\8\:VDD \11\:VDD) resistor r=0.03493 c=0
Rk87 (\11\:VDD \12\:VDD) resistor r=0.4263 c=0
Rk88 (\12\:VDD \14\:VDD) resistor r=0.1769 c=0
Rk89 (\12\:VDD \15\:VDD) resistor r=0.7222 c=0
Rk90 (\15\:VDD \17\:VDD) resistor r=0.2406 c=0
Rk91 (\15\:VDD \18\:VDD) resistor r=0.055 c=0
Rk92 (\18\:VDD \19\:VDD) resistor r=0.4063 c=0
Rk93 (\19\:VDD \21\:VDD) resistor r=0.2042 c=0
Rk105 (\22\:VDD VDD) resistor r=0.1074 c=0
Rk94 (\19\:VDD \22\:VDD) resistor r=0.4186 c=0
Rk59 (\4\:CK CK) resistor r=0.003008 c=0
Rk44 (D \5\:D) resistor r=0.02261 c=0
Rk13 (\25\:qbint \26\:qbint) resistor r=0.4906 c=0
Rk20 (\26\:qbint \37\:qbint) resistor r=0.1668 c=0
Rk29 (\11\:n35 \12\:n35) resistor r=0.1574 c=0
Rk30 (\12\:n35 \13\:n35) resistor r=2.2277 c=0
Rk31 (\12\:n35 \15\:n35) resistor r=0.2901 c=0
Rk24 (\6\:RNb \8\:RNb) resistor r=1.1055 c=0
Rk25 (\8\:RNb \10\:RNb) resistor r=0.4272 c=0
Rk26 (\2\:n42 \4\:n42) resistor r=0.3163 c=0
Rk28 (\2\:n40 \4\:n40) resistor r=0.6196 c=0
Rk52 (\13\:CKb \15\:CKb) resistor r=0.5762 c=0
Rk53 (\15\:CKb \16\:CKb) resistor r=0.305 c=0
Rk54 (\16\:CKb \17\:CKb) resistor r=0.365 c=0
Rk55 (\17\:CKb \18\:CKb) resistor r=0.4677 c=0
Rk56 (\18\:CKb \19\:CKb) resistor r=1.2105 c=0
Rk57 (\17\:CKb \20\:CKb) resistor r=0.2198 c=0
Rk58 (\18\:CKb \21\:CKb) resistor r=0.1461 c=0
Rk35 (\5\:mout \6\:mout) resistor r=0.1769 c=0
Rk36 (\6\:mout \8\:mout) resistor r=0.8735 c=0
Rk37 (\8\:mout \9\:mout) resistor r=0.2968 c=0
Rk38 (\9\:mout \11\:mout) resistor r=0.0679 c=0
Rk39 (\6\:mout \13\:mout) resistor r=0.08708 c=0
Rk40 (\9\:mout \15\:mout) resistor r=0.6207 c=0
Rk45 (\8\:CKbb \9\:CKbb) resistor r=0.06454 c=0
Rk46 (\9\:CKbb \10\:CKbb) resistor r=2.2062 c=0
Rk47 (\10\:CKbb \11\:CKbb) resistor r=0.5001 c=0
Rk48 (\9\:CKbb \12\:CKbb) resistor r=0.2822 c=0
Rk49 (\12\:CKbb \14\:CKbb) resistor r=0.3338 c=0
Rk50 (\10\:CKbb \15\:CKbb) resistor r=0.3737 c=0
Rk51 (\12\:CKbb \17\:CKbb) resistor r=0.0753 c=0
Rk34 (\2\:n25 \4\:n25) resistor r=0.4098 c=0
Rk41 (\6\:n20 \7\:n20) resistor r=0.1056 c=0
Rk42 (\7\:n20 \8\:n20) resistor r=0.7797 c=0
Rk43 (\7\:n20 \10\:n20) resistor r=0.3573 c=0
Rk27 (\2\:n41 \4\:n41) resistor r=0.4131 c=0
Rl48 (\4\:SN \6\:SN) resistor r=178.846 c=0
Rl47 (\4\:SN \5\:SN) resistor r=105.282 c=0
Rl31 (\1\:SN \2\:SN) resistor r=40.3846 c=0
Rl32 (\2\:SN \3\:SN) resistor r=101.099 c=0
Rl30 (\2\:RN \3\:RN) resistor r=58.1076 c=0
Rl29 (\1\:RN \2\:RN) resistor r=70.3867 c=0
Rl62 (\2\:CK \3\:CK) resistor r=34.0659 c=0
Rl61 (\1\:CK \2\:CK) resistor r=165.385 c=0
Rl58 (\2\:D \4\:D) resistor r=116.187 c=0
Rl57 (\2\:D \3\:D) resistor r=52.7257 c=0
Rl56 (\1\:D \2\:D) resistor r=1.2334 c=0
Rl33 (\22\:qbint \23\:qbint) resistor r=180.335 c=0
Rl34 (\24\:qbint \23\:qbint) resistor r=389.455 c=0
Rl43 (RNb \5\:RNb) resistor r=128.846 c=0
Rl42 (\3\:RNb \4\:RNb) resistor r=165.385 c=0
Rl40 (RNb \2\:RNb) resistor r=771.131 c=0
Rl41 (\2\:RNb \3\:RNb) resistor r=63.2566 c=0
Rl60 (\10\:CKb \11\:CKb) resistor r=166.873 c=0
Rl59 (\9\:CKb \10\:CKb) resistor r=36.2715 c=0
Rl55 (\7\:CKb \8\:CKb) resistor r=29.5379 c=0
Rl52 (\5\:CKb \6\:CKb) resistor r=74.2328 c=0
Rl39 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl38 (\2\:CKb \3\:CKb) resistor r=114.928 c=0
Rl37 (CKb \2\:CKb) resistor r=140.774 c=0
Rl49 (mout \2\:mout) resistor r=47.3105 c=0
Rl51 (\2\:mout \4\:mout) resistor r=128.08 c=0
Rl50 (\2\:mout \3\:mout) resistor r=71.5271 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=24.7951 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=193.774 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl35 (CKbb \2\:CKbb) resistor r=29.4849 c=0
Rl45 (\2\:n20 \3\:n20) resistor r=55.7471 c=0
Rl46 (\2\:n20 \4\:n20) resistor r=82.3738 c=0
Rl44 (n20 \2\:n20) resistor r=48.0022 c=0
Rz20 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\4\:VDD \3\:VDD) resistor r=25 c=0
Rz30 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz31 (\18\:VDD \3\:VDD) resistor r=6.25 c=0
Rz32 (\22\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz7 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz8 (n42 \2\:n42) resistor r=75 c=0
Rz9 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz10 (n40 \2\:n40) resistor r=75 c=0
Rz11 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz19 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz15 (\10\:mout \11\:mout) resistor r=75 c=0
Rz16 (\14\:mout \15\:mout) resistor r=75 c=0
Rz18 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz13 (n25 \2\:n25) resistor r=75 c=0
Rz14 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz17 (\9\:n20 \10\:n20) resistor r=75 c=0
Ry16 (\4\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry17 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry21 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry22 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry23 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry24 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry25 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry10 (\15\:n35 \14\:n35) resistor r=62 c=0
Ry7 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry15 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry11 (\7\:mout \8\:mout) resistor r=62 c=0
Ry12 (\12\:mout \13\:mout) resistor r=62 c=0
Ry14 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry13 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry8 (n41 \2\:n41) resistor r=62 c=0
Ry9 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\5\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx10 (\1\:D \5\:D) resistor r=45 c=0
Rx1 (\25\:qbint \24\:qbint) resistor r=45 c=0
Rx2 (\37\:qbint qbint) resistor r=45 c=0
Rx5 (\13\:n35 n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx14 (\9\:CKb \16\:CKb) resistor r=45 c=0
Rx15 (CKb \19\:CKb) resistor r=45 c=0
Rx16 (\8\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx8 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (n20 \8\:n20) resistor r=45 c=0
mn55_1__rcx (Q qbint \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\26\:qbint n35 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.623e-14 ad=4.81e-14 ps=8.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
mn22 (\9\:RNb \1\:RN \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.755e-14 ad=2.03e-14 ps=1.57e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.3e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn21 (\13\:CKbb \10\:CKb \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.795e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.40345e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn20 (\14\:CKb \1\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.065e-14 ad=2.03e-14 ps=1.34e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn50 (n42 \3\:SN \20\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.755e-14 ad=3.28e-14 ps=1.57e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.99878e-07 sb=5.75e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn52 (\3\:n40 \22\:qbint n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.04878e-07 sb=3.7e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn51 (\3\:n40 \4\:RNb \3\:n42 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=3.28e-14 ps=7.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.09878e-07 sb=1.65e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn53 (\10\:n35 \3\:CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=3.28e-14 ps=8.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=3.75e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\10\:n35 \3\:CKbb \10\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.485e-14 ad=3.28e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.7e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\14\:mout \5\:RNb \3\:n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=3.28e-14 ps=8.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.79963e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn32 (\14\:mout \4\:n20 n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.59463e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn30 (n25 \6\:SN \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=5.33e-14 ps=1.08e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.28963e-06 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn35 (n30 \4\:mout \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=3.177e-14 ps=1.08e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=9.09634e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn36 (\9\:n20 \7\:CKbb n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=4.51e-14 ps=7.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=7.09634e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn26 (\9\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=4.51e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=4.44634e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn25 (n21 \3\:D \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.795e-14 ad=2.357e-14 ps=1.5e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=2.84634e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mp45_1__rcx (\26\:qbint n35 \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.62e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.22308e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp22 (\7\:RNb \3\:RN \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1155e-13 ad=2.63e-14 ps=2.55e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=3.27209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\16\:CKbb \11\:CKb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79558e-06 sb=1.4e-07 sd=160n sca=15.5686 \
        scb=0.0151127 scc=0.000885455 m=(1)
mp20 (\12\:CKb \3\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.4e-07 sd=160n sca=15.5771 \
        scb=0.0149239 scc=0.000232429 m=(1)
mp50 (\3\:n41 \1\:SN \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1155e-13 ad=5.89e-14 ps=2.55e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86774e-07 sb=4.84839e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp52 (n43 \23\:qbint \3\:n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=2.325e-14 ps=1e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.21774e-07 sb=2.49839e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (n43 \3\:RNb \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.985e-14 ad=2.325e-14 ps=1.35e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41774e-07 sb=1.29839e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp53 (\14\:n35 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.9e-14 ad=5.115e-14 ps=1.12e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58065e-07 sb=4.65e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp40 (\14\:n35 \4\:CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.115e-14 ps=1.13e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.68065e-07 sb=2.55e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp31 (n26 RNb \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=2.79e-14 ps=1.48e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.17855e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\12\:mout \3\:n20 n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.79e-14 ad=8.54e-14 ps=8e-07 pd=1.54e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.04355e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \4\:SN \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=8.54e-14 ps=1.29e-06 pd=1.54e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.36774e-07 sb=1.27492e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp35 (n31 mout \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=4.185e-14 ps=1.29e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16774e-07 sb=8.94919e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp36 (\5\:n20 \5\:CKb n31 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=7.44e-14 ps=8.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.96774e-07 sb=7.14919e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp26 (\5\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.44e-14 ps=8.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28177e-06 sb=4.29919e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp25 (n22 \4\:D \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.565e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44177e-06 sb=2.69919e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
ends DFFSRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:47 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRX1
// View name: extracted

simulator lang=spectre

subckt DFFSRX1 CK D Q QN RN SN VDD VSS
mp57 (\1\:QN \4\:qint \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.4e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
mp55 (\3\:Q qbint \24\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.86e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24615e-07 sb=2.33013e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
C1 (RN VSS) capacitor c=7.5286e-17
C2 (CK VSS) capacitor c=5.14835e-17
C3 (D VSS) capacitor c=4.78905e-17
C4 (QN VSS) capacitor c=2.29657e-17
C5 (VDD VSS) capacitor c=4.47426e-16
C6 (SN VSS) capacitor c=1.64835e-17
C7 (Q VSS) capacitor c=8.01254e-17
C8 (qint VSS) capacitor c=2.1329e-17
C9 (qbint VSS) capacitor c=5.52388e-17
C10 (RNb VSS) capacitor c=4.86093e-17
C11 (n35 VSS) capacitor c=3.59062e-17
C12 (n42 VSS) capacitor c=8.10794e-17
C13 (n40 VSS) capacitor c=1.08464e-16
C14 (CKb VSS) capacitor c=7.27769e-17
C15 (mout VSS) capacitor c=6.75092e-17
C16 (CKbb VSS) capacitor c=5.37631e-17
C17 (net426 VSS) capacitor c=1.12367e-16
C18 (n20 VSS) capacitor c=5.85392e-17
C19 (n41 VSS) capacitor c=9.27777e-17
C20 (n43 VSS) capacitor c=1.58142e-18
C21 (net402 VSS) capacitor c=6.80571e-18
C22 (n31 VSS) capacitor c=3.39662e-18
C23 (n22 VSS) capacitor c=2.56124e-18
C24 (\4\:CK VSS) capacitor c=4.31344e-17
C25 (\7\:CKb VSS) capacitor c=3.18967e-17
C26 (\1\:D VSS) capacitor c=7.54601e-17
C27 (\7\:CKbb VSS) capacitor c=6.09541e-17
C28 (\5\:CKb VSS) capacitor c=5.45409e-17
C29 (\4\:SN VSS) capacitor c=4.43625e-17
C30 (\2\:CKb VSS) capacitor c=7.75091e-17
C31 (\4\:RNb VSS) capacitor c=7.0232e-17
C32 (\8\:qbint VSS) capacitor c=7.39365e-17
C33 (\1\:SN VSS) capacitor c=3.77594e-17
C34 (\3\:n35 VSS) capacitor c=3.52511e-17
C35 (\3\:RN VSS) capacitor c=3.52625e-17
C36 (\7\:qbint VSS) capacitor c=3.6557e-17
C37 (\4\:qint VSS) capacitor c=4.73574e-17
C38 (\3\:CK VSS) capacitor c=2.02971e-17
C39 (\8\:CKb VSS) capacitor c=3.67278e-17
C40 (\3\:D VSS) capacitor c=2.60564e-17
C41 (\4\:CKb VSS) capacitor c=5.34412e-17
C42 (\5\:CKbb VSS) capacitor c=6.70931e-17
C43 (\3\:mout VSS) capacitor c=5.68814e-17
C44 (\6\:SN VSS) capacitor c=5.91576e-17
C45 (\2\:n20 VSS) capacitor c=2.85283e-17
C46 (\2\:RNb VSS) capacitor c=1.08328e-16
C47 (\3\:CKbb VSS) capacitor c=4.48782e-17
C48 (\3\:RNb VSS) capacitor c=1.25258e-16
C49 (\11\:qbint VSS) capacitor c=3.23002e-17
C50 (\3\:SN VSS) capacitor c=4.01711e-17
C51 (\1\:RN VSS) capacitor c=4.09463e-17
C52 (\6\:qbint VSS) capacitor c=3.65208e-17
C53 (\4\:qbint VSS) capacitor c=2.65005e-17
C54 (\3\:qint VSS) capacitor c=3.66877e-17
C55 (\1\:CK VSS) capacitor c=1.16957e-17
C56 (\9\:CKb VSS) capacitor c=1.57471e-17
C57 (\2\:D VSS) capacitor c=4.68853e-17
C58 (\8\:CKbb VSS) capacitor c=4.16424e-17
C59 (\6\:CKb VSS) capacitor c=2.57079e-17
C60 (\6\:CKbb VSS) capacitor c=4.60525e-17
C61 (\2\:mout VSS) capacitor c=5.07454e-17
C62 (\5\:SN VSS) capacitor c=4.27768e-17
C63 (\3\:n20 VSS) capacitor c=2.94282e-17
C64 (\3\:CKb VSS) capacitor c=2.13306e-17
C65 (\4\:CKbb VSS) capacitor c=4.37822e-17
C66 (\2\:CKbb VSS) capacitor c=2.53203e-17
C67 (\5\:RNb VSS) capacitor c=2.61851e-17
C68 (\10\:qbint VSS) capacitor c=1.72751e-17
C69 (\2\:SN VSS) capacitor c=4.73915e-17
C70 (\2\:n35 VSS) capacitor c=4.53398e-17
C71 (\2\:RN VSS) capacitor c=2.96285e-17
C72 (\5\:qbint VSS) capacitor c=4.18673e-17
C73 (\1\:VDD VSS) capacitor c=2.68326e-17
C74 (\12\:CKb VSS) capacitor c=4.8745e-17
C75 (\14\:VDD VSS) capacitor c=1.39105e-17
C76 (\7\:n20 VSS) capacitor c=8.56693e-17
C77 (\16\:VDD VSS) capacitor c=2.6063e-17
C78 (\7\:mout VSS) capacitor c=1.54519e-16
C79 (\18\:VDD VSS) capacitor c=2.48879e-17
C80 (\9\:mout VSS) capacitor c=1.71301e-16
C81 (\8\:n35 VSS) capacitor c=2.0483e-17
C82 (\20\:VDD VSS) capacitor c=3.94099e-17
C83 (\3\:n41 VSS) capacitor c=1.17516e-16
C84 (\22\:VDD VSS) capacitor c=2.10735e-17
C85 (\17\:qbint VSS) capacitor c=5.14992e-17
C86 (\7\:RNb VSS) capacitor c=1.43482e-16
C87 (\24\:VDD VSS) capacitor c=5.97892e-17
C88 (\3\:Q VSS) capacitor c=2.8085e-17
C89 (\5\:qint VSS) capacitor c=3.5028e-17
C90 (\26\:VDD VSS) capacitor c=1.47221e-17
C91 (\1\:QN VSS) capacitor c=3.55638e-17
C92 (\4\:VDD VSS) capacitor c=8.28729e-17
C93 (\10\:CKb VSS) capacitor c=8.55964e-17
C94 (\11\:CKbb VSS) capacitor c=5.14088e-17
C95 (\5\:n20 VSS) capacitor c=9.06006e-17
C96 (\4\:mout VSS) capacitor c=1.03592e-16
C97 (\3\:net426 VSS) capacitor c=8.90871e-17
C98 (\11\:mout VSS) capacitor c=6.94944e-17
C99 (\4\:n35 VSS) capacitor c=6.7484e-17
C100 (\3\:n40 VSS) capacitor c=9.01267e-17
C101 (\3\:n42 VSS) capacitor c=7.56466e-17
C102 (\14\:qbint VSS) capacitor c=8.15174e-17
C103 (\9\:RNb VSS) capacitor c=6.55549e-17
C104 (\1\:Q VSS) capacitor c=8.95971e-17
C105 (\9\:qint VSS) capacitor c=2.58045e-17
C106 (\3\:QN VSS) capacitor c=2.73384e-17
C107 (\2\:qint VSS) capacitor c=7.08461e-18
C108 (\3\:qbint VSS) capacitor c=3.33689e-17
C109 (\9\:qbint VSS) capacitor c=4.29577e-17
C110 (\7\:qint VSS) capacitor c=2.85808e-17
C111 (\8\:qint VSS) capacitor c=1.97065e-17
C112 (\4\:RN VSS) capacitor c=4.81421e-17
C113 (\2\:CK VSS) capacitor c=2.41424e-17
C114 (\12\:qbint VSS) capacitor c=7.44823e-17
C115 (\13\:qbint VSS) capacitor c=7.11433e-17
C116 (\16\:qbint VSS) capacitor c=1.55093e-16
C117 (\6\:RNb VSS) capacitor c=1.59017e-16
C118 (\6\:n35 VSS) capacitor c=2.08225e-16
C119 (\7\:n35 VSS) capacitor c=1.61049e-16
C120 (\7\:SN VSS) capacitor c=2.58804e-16
C121 (\8\:SN VSS) capacitor c=3.40561e-16
C122 (\9\:SN VSS) capacitor c=1.51022e-16
C123 (\6\:mout VSS) capacitor c=1.15953e-16
C124 (\4\:n20 VSS) capacitor c=7.00915e-17
C125 (\4\:D VSS) capacitor c=5.79547e-17
C126 (\10\:CKbb VSS) capacitor c=9.53607e-17
C127 (\13\:CKbb VSS) capacitor c=8.71248e-17
C128 (\14\:CKbb VSS) capacitor c=3.20267e-17
C129 (\15\:CKbb VSS) capacitor c=2.41765e-16
C130 (\16\:CKbb VSS) capacitor c=7.54972e-17
C131 (\17\:CKbb VSS) capacitor c=2.05193e-16
C132 (\18\:CKbb VSS) capacitor c=7.03081e-17
C133 (\19\:CKbb VSS) capacitor c=3.03347e-17
C134 (\14\:CKb VSS) capacitor c=9.58625e-17
C135 (\15\:CKb VSS) capacitor c=2.13983e-16
C136 (\16\:CKb VSS) capacitor c=1.72841e-16
C137 (\5\:CK VSS) capacitor c=4.07125e-17
C138 (\3\:VDD VSS) capacitor c=1.67926e-17
C139 (\6\:VDD VSS) capacitor c=3.92476e-17
C140 (\7\:VDD VSS) capacitor c=2.84839e-17
C141 (\9\:VDD VSS) capacitor c=2.56333e-17
C142 (\10\:VDD VSS) capacitor c=3.24486e-17
C143 (\11\:VDD VSS) capacitor c=1.69377e-17
C144 (\13\:VDD VSS) capacitor c=1.16823e-17
Rk8 (\4\:RN RN) resistor r=0.03589 c=0
Rk63 (\2\:VSS \4\:VSS) resistor r=0.4432 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.3674 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.6834 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.6893 c=0
Rk67 (\7\:VSS \8\:VSS) resistor r=0.5144 c=0
Rk69 (\9\:VSS VSS) resistor r=0.2152 c=0
Rk68 (\8\:VSS \9\:VSS) resistor r=0.3358 c=0
Rk70 (\4\:VSS \11\:VSS) resistor r=0.3236 c=0
Rk71 (\5\:VSS \13\:VSS) resistor r=0.0433 c=0
Rk72 (\7\:VSS \15\:VSS) resistor r=0.286 c=0
Rk73 (\8\:VSS \17\:VSS) resistor r=0.2937 c=0
Rk74 (\9\:VSS \19\:VSS) resistor r=0.07381 c=0
Rk44 (CK \5\:CK) resistor r=0.1857 c=0
Rk31 (\4\:D D) resistor r=0.1113 c=0
Rk2 (\4\:QN QN) resistor r=0.09286 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3057 c=0
Rk45 (\2\:VDD \3\:VDD) resistor r=0.524 c=0
Rk46 (\3\:VDD \5\:VDD) resistor r=0.08506 c=0
Rk47 (\5\:VDD \6\:VDD) resistor r=0.3674 c=0
Rk48 (\6\:VDD \7\:VDD) resistor r=0.3864 c=0
Rk49 (\7\:VDD \8\:VDD) resistor r=0.2947 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.3258 c=0
Rk51 (\9\:VDD \10\:VDD) resistor r=0.3933 c=0
Rk52 (\10\:VDD \11\:VDD) resistor r=0.4509 c=0
Rk53 (\11\:VDD \12\:VDD) resistor r=0.0324 c=0
Rk55 (\13\:VDD VDD) resistor r=0.2152 c=0
Rk54 (\12\:VDD \13\:VDD) resistor r=0.3358 c=0
Rk56 (\3\:VDD \15\:VDD) resistor r=0.07381 c=0
Rk57 (\6\:VDD \17\:VDD) resistor r=0.0433 c=0
Rk58 (\7\:VDD \19\:VDD) resistor r=0.0433 c=0
Rk59 (\9\:VDD \21\:VDD) resistor r=0.2106 c=0
Rk60 (\10\:VDD \23\:VDD) resistor r=0.1606 c=0
Rk61 (\11\:VDD \25\:VDD) resistor r=0.4377 c=0
Rk62 (\13\:VDD \27\:VDD) resistor r=0.224 c=0
Rk24 (\8\:SN SN) resistor r=0.003075 c=0
Rk22 (\7\:SN \8\:SN) resistor r=1.7566 c=0
Rk23 (\8\:SN \9\:SN) resistor r=0.953 c=0
Rk6 (\2\:Q Q) resistor r=0.516 c=0
Rk7 (Q \4\:Q) resistor r=0.1147 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1297 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1193 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.09372 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.442 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1168 c=0
Rk11 (\15\:qbint \16\:qbint) resistor r=0.8819 c=0
Rk12 (\13\:qbint \18\:qbint) resistor r=0.3615 c=0
Rk13 (\6\:RNb \8\:RNb) resistor r=1.1236 c=0
Rk14 (\8\:RNb \10\:RNb) resistor r=0.3443 c=0
Rk18 (\5\:n35 \6\:n35) resistor r=0.4217 c=0
Rk19 (\6\:n35 \7\:n35) resistor r=1.0999 c=0
Rk20 (\6\:n35 \9\:n35) resistor r=0.02819 c=0
Rk15 (\2\:n42 \4\:n42) resistor r=0.5071 c=0
Rk16 (\2\:n40 \4\:n40) resistor r=0.3825 c=0
Rk40 (\11\:CKb \13\:CKb) resistor r=0.4962 c=0
Rk41 (\13\:CKb \14\:CKb) resistor r=0.1784 c=0
Rk42 (\14\:CKb \15\:CKb) resistor r=0.6457 c=0
Rk43 (\15\:CKb \16\:CKb) resistor r=1.2117 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.6022 c=0
Rk26 (\6\:mout \8\:mout) resistor r=0.4012 c=0
Rk27 (\8\:mout \10\:mout) resistor r=0.7289 c=0
Rk28 (\10\:mout \12\:mout) resistor r=0.4104 c=0
Rk32 (\10\:CKbb \12\:CKbb) resistor r=0.3313 c=0
Rk33 (\10\:CKbb \13\:CKbb) resistor r=0.3908 c=0
Rk34 (\13\:CKbb \14\:CKbb) resistor r=0.1309 c=0
Rk35 (\13\:CKbb \15\:CKbb) resistor r=0.4364 c=0
Rk36 (\15\:CKbb \16\:CKbb) resistor r=0.3354 c=0
Rk37 (\15\:CKbb \17\:CKbb) resistor r=1.3065 c=0
Rk38 (\17\:CKbb \18\:CKbb) resistor r=0.2507 c=0
Rk39 (\17\:CKbb \19\:CKbb) resistor r=0.3024 c=0
Rk21 (\2\:net426 \4\:net426) resistor r=0.6545 c=0
Rk29 (\4\:n20 \6\:n20) resistor r=0.4771 c=0
Rk30 (\6\:n20 \8\:n20) resistor r=0.4285 c=0
Rk17 (\2\:n41 \4\:n41) resistor r=0.4141 c=0
Rl11 (\2\:RN \3\:RN) resistor r=33.7903 c=0
Rl10 (\1\:RN \2\:RN) resistor r=54.9442 c=0
Rl43 (\2\:CK \4\:CK) resistor r=158.495 c=0
Rl42 (\2\:CK \3\:CK) resistor r=37.3411 c=0
Rl41 (\1\:CK \2\:CK) resistor r=1.2334 c=0
Rl37 (\1\:D \2\:D) resistor r=70.9489 c=0
Rl38 (\2\:D \3\:D) resistor r=57.6695 c=0
Rl29 (\4\:SN \5\:SN) resistor r=24.2328 c=0
Rl30 (\5\:SN \6\:SN) resistor r=76.1559 c=0
Rl14 (\1\:SN \2\:SN) resistor r=50.6918 c=0
Rl15 (\2\:SN \3\:SN) resistor r=96.8456 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=24.848 c=0
Rl4 (qbint \2\:qbint) resistor r=64.1498 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=3.9152 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=166.451 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=125.803 c=0
Rl18 (\9\:qbint \11\:qbint) resistor r=37.3411 c=0
Rl17 (\9\:qbint \10\:qbint) resistor r=1.8551 c=0
Rl23 (RNb \2\:RNb) resistor r=143.796 c=0
Rl25 (\3\:RNb \4\:RNb) resistor r=193.796 c=0
Rl24 (\2\:RNb \3\:RNb) resistor r=699.566 c=0
Rl26 (\4\:RNb \5\:RNb) resistor r=31.9251 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=49.5541 c=0
Rl12 (n35 \2\:n35) resistor r=110.771 c=0
Rl39 (\7\:CKb \8\:CKb) resistor r=94.2308 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=153.412 c=0
Rl21 (CKb \2\:CKb) resistor r=186.104 c=0
Rl40 (\7\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=50.6918 c=0
Rl22 (\2\:CKb \3\:CKb) resistor r=126.436 c=0
Rl31 (mout \2\:mout) resistor r=94.4882 c=0
Rl32 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl36 (\7\:CKbb \8\:CKbb) resistor r=35.7713 c=0
Rl33 (\5\:CKbb \6\:CKbb) resistor r=37.6944 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=93.4636 c=0
Rl19 (CKbb \2\:CKbb) resistor r=31.9251 c=0
Rl27 (n20 \2\:n20) resistor r=128.846 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=38.5707 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz23 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz24 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz25 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz26 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\4\:VDD \5\:VDD) resistor r=8.3333 c=0
Rz19 (\4\:VDD \8\:VDD) resistor r=6.25 c=0
Rz20 (\4\:VDD \12\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz5 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz10 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz6 (n42 \2\:n42) resistor r=75 c=0
Rz7 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz8 (n40 \2\:n40) resistor r=75 c=0
Rz9 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz17 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz13 (\4\:mout \5\:mout) resistor r=75 c=0
Rz14 (\11\:mout \12\:mout) resistor r=75 c=0
Rz16 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz11 (net426 \2\:net426) resistor r=75 c=0
Rz12 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry22 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry23 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry5 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry8 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry13 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry9 (\7\:mout \8\:mout) resistor r=62 c=0
Ry10 (\9\:mout \10\:mout) resistor r=62 c=0
Ry12 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry11 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\1\:CK \5\:CK) resistor r=45 c=0
Rx11 (\2\:D \4\:D) resistor r=45 c=0
Rx7 (\5\:SN \7\:SN) resistor r=45 c=0
Rx8 (\2\:SN \9\:SN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\5\:qbint \16\:qbint) resistor r=45 c=0
Rx5 (\5\:RNb \6\:RNb) resistor r=45 c=0
Rx6 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx16 (\9\:CKb \14\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \15\:CKb) resistor r=45 c=0
Rx18 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx9 (\2\:mout \6\:mout) resistor r=45 c=0
Rx12 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \16\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \18\:CKbb) resistor r=45 c=0
Rx15 (\2\:CKbb \19\:CKbb) resistor r=45 c=0
Rx10 (\3\:n20 \4\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\1\:Q \6\:qbint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.18462e-07 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(1)
mn56 (\9\:qint \4\:qbint \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\9\:RNb \1\:RN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn45 (\14\:qbint n35 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=8.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (\3\:n42 \3\:SN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=6.65e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn52 (\3\:n40 \11\:qbint \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn51 (\3\:n40 \3\:RNb n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn53 (\4\:n35 CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.61e-14 ps=8.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.6e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\4\:n35 \3\:CKbb \11\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.408e-14 ad=2.61e-14 ps=7.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2.35e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn31 (\4\:mout \2\:RNb \3\:net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=5.003e-14 ps=5.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn32 (\4\:mout \2\:n20 net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.003e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.48e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn30 (net426 \6\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=2.32e-14 ps=1.59e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.275e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn35 (n30 \3\:mout \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=8.7e-15 ps=1.59e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=1.08e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn36 (\5\:n20 \5\:CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=9.75e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn26 (\5\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.32e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=7.7e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn25 (n21 \3\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.068e-14 ad=3.263e-14 ps=1.17e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=5e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn21 (\11\:CKbb \8\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.068e-14 ad=2.03e-14 ps=1.17e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.4e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn20 (\10\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=46.9517 \
        scb=0.029008 scc=0.00588492 m=(1)
mp22 (\7\:RNb \3\:RN \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.93e-14 ps=1.1e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.17093e-07 sb=1.36279e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\17\:qbint \3\:n35 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.15e-14 ad=4.838e-14 ps=1.44e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=8.65e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp50 (\3\:n41 \1\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=5.913e-14 ps=1.44e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=6e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.913e-14 ps=5.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.8e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp51 (n43 \4\:RNb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.893e-14 ad=1.29e-14 ps=1.38e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.75e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp53 (\8\:n35 CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.48e-14 ps=7.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.52907e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\8\:n35 \2\:CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.955e-14 ad=3.48e-14 ps=1.17e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.33605e-07 sb=3.7e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp31 (net402 RNb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.755e-14 ad=5.59e-14 ps=1.62e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.50802e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp32 (\7\:mout n20 net402 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=3.44e-14 ps=9.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=1.20302e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp30 (\7\:mout \4\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=3.44e-14 ps=1.72e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=9.98023e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp35 (n31 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=2.473e-14 ps=1.72e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3686e-07 sb=8.59302e-07 sd=160n sca=16.037 \
        scb=0.0158964 scc=0.00103899 m=(1)
mp36 (\7\:n20 \5\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=6.128e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9686e-07 sb=6.99302e-07 sd=160n sca=16.037 \
        scb=0.0158964 scc=0.00103899 m=(1)
mp26 (\7\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32686e-06 sb=3.69302e-07 sd=160n sca=16.037 \
        scb=0.0158964 scc=0.00103899 m=(1)
mp25 (n22 \1\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=1.29e-14 ps=2.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43186e-06 sb=2.64302e-07 sd=160n sca=16.1489 \
        scb=0.0159203 scc=0.00103899 m=(1)
mp21 (\9\:CKbb \7\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.94e-14 ad=3.01e-14 ps=2.06e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.57791e-07 sb=1.4e-07 sd=160n sca=46.9212 \
        scb=0.0289781 scc=0.00588485 m=(1)
mp20 (\12\:CKb \4\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.3991 \
        scb=0.0236448 scc=0.00101293 m=(1)
ends DFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:48 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRX2
// View name: extracted

simulator lang=spectre

subckt DFFSRX2 CK D Q QN RN SN VDD VSS
mp20 (\19\:CKb \1\:CK \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=54.4955 scb=0.0411556 \
        scc=0.00640582 m=(1)
mp21 (\8\:CKbb \3\:CKb \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.267e-14 ad=3.01e-14 ps=9.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.57372e-06 sd=160n sca=10.9705 \
        scb=0.00777473 scc=7.78476e-05 m=(1)
mp25 (n22 \1\:D \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=3.332e-14 ps=9.2e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.30814e-06 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=6.4e-14 ps=7.4e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.10814e-06 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp36 (\4\:n20 \6\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.4e-14 ps=5.5e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.38372e-07 sb=1.16e-06 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp35 (n31 mout \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.795e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.43372e-07 sb=1.055e-06 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp30 (\11\:mout \3\:SN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.795e-14 ad=5.16e-14 ps=1.5e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13837e-06 sb=7.6e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp32 (\11\:mout n20 net402 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=5.16e-14 ps=8.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42337e-06 sb=4.75e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp31 (net402 \3\:RNb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.08e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65837e-06 sb=2.4e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp40 (\8\:n35 \8\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.267e-14 ps=7.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.3e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (\8\:n35 CKbb \3\:n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.267e-14 ps=7.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n43 RNb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.605e-13 ad=1.29e-14 ps=3.46e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=8.45e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp52 (n41 \3\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.762e-14 ps=5.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=7.4e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n41 \6\:SN \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.298e-13 ad=3.762e-14 ps=1.96e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=5.2e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp22 (\9\:RNb \1\:RN \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.65581e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp56 (\12\:qint \15\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65581e-07 sb=1.4e-07 sd=160n sca=42.2278 \
        scb=0.0332596 scc=0.00497508 m=(1)
C1 (RN VSS) capacitor c=6.20947e-17
C2 (CK VSS) capacitor c=5.7844e-17
C3 (SN VSS) capacitor c=4.40564e-17
C4 (Q VSS) capacitor c=4.23728e-17
C5 (VDD VSS) capacitor c=5.51652e-16
C6 (D VSS) capacitor c=6.20764e-17
C7 (QN VSS) capacitor c=3.9033e-17
C8 (CKb VSS) capacitor c=3.00818e-17
C9 (CKbb VSS) capacitor c=6.86995e-17
C10 (n20 VSS) capacitor c=5.90225e-17
C11 (mout VSS) capacitor c=5.94109e-17
C12 (net426 VSS) capacitor c=5.72315e-17
C13 (RNb VSS) capacitor c=1.2373e-16
C14 (n35 VSS) capacitor c=3.71177e-17
C15 (n40 VSS) capacitor c=1.15786e-16
C16 (n42 VSS) capacitor c=7.79502e-17
C17 (qbint VSS) capacitor c=3.13862e-17
C18 (qint VSS) capacitor c=1.9398e-16
C19 (n31 VSS) capacitor c=9.17517e-19
C20 (net402 VSS) capacitor c=4.04792e-18
C21 (n41 VSS) capacitor c=2.43209e-16
C22 (n43 VSS) capacitor c=1.4968e-18
C23 (\15\:qbint VSS) capacitor c=5.03067e-17
C24 (\5\:qbint VSS) capacitor c=4.58572e-16
C25 (\1\:RN VSS) capacitor c=4.80272e-17
C26 (\6\:SN VSS) capacitor c=5.73835e-17
C27 (\3\:qbint VSS) capacitor c=8.36018e-17
C28 (\8\:CKb VSS) capacitor c=3.83224e-17
C29 (\3\:RNb VSS) capacitor c=1.0298e-16
C30 (\3\:SN VSS) capacitor c=3.33621e-17
C31 (\6\:CKb VSS) capacitor c=8.19705e-17
C32 (\5\:CKbb VSS) capacitor c=3.19277e-17
C33 (\1\:D VSS) capacitor c=4.0625e-17
C34 (\3\:CKb VSS) capacitor c=5.02169e-17
C35 (\1\:CK VSS) capacitor c=2.80483e-17
C36 (\14\:qbint VSS) capacitor c=4.19265e-17
C37 (\3\:RN VSS) capacitor c=3.51153e-17
C38 (\3\:n35 VSS) capacitor c=4.07662e-17
C39 (\5\:SN VSS) capacitor c=6.08282e-17
C40 (\5\:RNb VSS) capacitor c=5.23604e-17
C41 (\10\:CKb VSS) capacitor c=4.9382e-17
C42 (\2\:CKbb VSS) capacitor c=1.29371e-16
C43 (\4\:RNb VSS) capacitor c=5.545e-17
C44 (\3\:n20 VSS) capacitor c=3.62023e-17
C45 (\1\:SN VSS) capacitor c=4.13081e-17
C46 (\3\:mout VSS) capacitor c=7.65202e-17
C47 (\3\:CKbb VSS) capacitor c=1.9205e-16
C48 (\4\:CKb VSS) capacitor c=4.03968e-17
C49 (\3\:D VSS) capacitor c=4.8944e-17
C50 (\4\:CK VSS) capacitor c=1.7933e-17
C51 (\13\:qbint VSS) capacitor c=2.544e-17
C52 (\2\:RN VSS) capacitor c=4.2469e-17
C53 (\2\:n35 VSS) capacitor c=2.77459e-17
C54 (\4\:qbint VSS) capacitor c=2.21011e-17
C55 (\7\:SN VSS) capacitor c=3.35198e-17
C56 (\6\:RNb VSS) capacitor c=3.53866e-17
C57 (\11\:CKb VSS) capacitor c=2.37896e-17
C58 (\9\:CKb VSS) capacitor c=3.45187e-17
C59 (\2\:n20 VSS) capacitor c=4.30948e-17
C60 (\4\:SN VSS) capacitor c=2.61803e-17
C61 (\2\:SN VSS) capacitor c=4.1638e-17
C62 (\2\:mout VSS) capacitor c=5.3377e-17
C63 (\7\:CKb VSS) capacitor c=2.8834e-17
C64 (\5\:CKb VSS) capacitor c=3.69304e-17
C65 (\4\:CKbb VSS) capacitor c=7.04522e-17
C66 (\2\:D VSS) capacitor c=4.41883e-17
C67 (\2\:CKb VSS) capacitor c=4.01935e-17
C68 (\3\:CK VSS) capacitor c=1.07655e-17
C69 (\12\:qint VSS) capacitor c=1.58259e-17
C70 (\3\:QN VSS) capacitor c=6.01217e-17
C71 (\3\:Q VSS) capacitor c=5.4463e-17
C72 (\9\:RNb VSS) capacitor c=2.88439e-16
C73 (\25\:qbint VSS) capacitor c=7.08854e-17
C74 (\21\:VDD VSS) capacitor c=1.94391e-17
C75 (\23\:VDD VSS) capacitor c=7.02467e-17
C76 (\3\:n41 VSS) capacitor c=2.128e-16
C77 (\8\:n35 VSS) capacitor c=3.9882e-17
C78 (\6\:mout VSS) capacitor c=9.59627e-17
C79 (\25\:VDD VSS) capacitor c=4.66294e-17
C80 (\11\:mout VSS) capacitor c=1.13498e-16
C81 (\27\:VDD VSS) capacitor c=2.70969e-17
C82 (\4\:n20 VSS) capacitor c=7.80893e-17
C83 (\29\:VDD VSS) capacitor c=3.07477e-17
C84 (\8\:CKbb VSS) capacitor c=2.62479e-17
C85 (\19\:CKb VSS) capacitor c=5.06842e-17
C86 (\31\:VDD VSS) capacitor c=1.25714e-17
C87 (\1\:VDD VSS) capacitor c=1.11872e-16
C88 (\8\:qint VSS) capacitor c=2.75384e-17
C89 (\1\:QN VSS) capacitor c=8.07523e-17
C90 (\1\:Q VSS) capacitor c=7.96359e-17
C91 (\7\:RNb VSS) capacitor c=1.00405e-16
C92 (\19\:qbint VSS) capacitor c=6.23199e-17
C93 (\3\:n42 VSS) capacitor c=8.21607e-17
C94 (\3\:n40 VSS) capacitor c=1.79021e-16
C95 (\6\:n35 VSS) capacitor c=5.18891e-17
C96 (\4\:mout VSS) capacitor c=5.58507e-17
C97 (\9\:mout VSS) capacitor c=5.00685e-17
C98 (\3\:net426 VSS) capacitor c=7.14765e-17
C99 (\7\:n20 VSS) capacitor c=1.71454e-17
C100 (\10\:CKbb VSS) capacitor c=1.0204e-16
C101 (\17\:CKb VSS) capacitor c=1.25256e-16
C102 (\2\:CK VSS) capacitor c=1.05288e-17
C103 (\2\:RNb VSS) capacitor c=1.20493e-16
C104 (\5\:CK VSS) capacitor c=3.76857e-17
C105 (\2\:qbint VSS) capacitor c=3.71255e-17
C106 (\4\:D VSS) capacitor c=8.10578e-17
C107 (\6\:CKbb VSS) capacitor c=7.62699e-17
C108 (\7\:CKbb VSS) capacitor c=1.04334e-16
C109 (\8\:SN VSS) capacitor c=4.32625e-17
C110 (\6\:n20 VSS) capacitor c=9.13297e-17
C111 (\9\:n20 VSS) capacitor c=9.32499e-17
C112 (\8\:mout VSS) capacitor c=9.08693e-17
C113 (\13\:mout VSS) capacitor c=6.86364e-17
C114 (\12\:CKb VSS) capacitor c=7.33996e-17
C115 (\13\:CKb VSS) capacitor c=3.35646e-16
C116 (\14\:CKb VSS) capacitor c=3.20623e-16
C117 (\15\:CKb VSS) capacitor c=1.31057e-16
C118 (\16\:CKb VSS) capacitor c=1.08689e-16
C119 (\9\:SN VSS) capacitor c=3.4622e-16
C120 (\10\:SN VSS) capacitor c=3.83946e-16
C121 (\4\:n35 VSS) capacitor c=2.62617e-16
C122 (\5\:n35 VSS) capacitor c=2.21173e-16
C123 (\11\:RNb VSS) capacitor c=3.55121e-16
C124 (\4\:RN VSS) capacitor c=4.87185e-17
C125 (\16\:qbint VSS) capacitor c=6.83358e-17
C126 (\21\:qbint VSS) capacitor c=5.57852e-17
C127 (\22\:qbint VSS) capacitor c=7.62801e-17
C128 (\10\:qint VSS) capacitor c=1.87448e-17
C129 (\11\:qint VSS) capacitor c=3.1864e-17
C130 (\3\:VDD VSS) capacitor c=2.33442e-16
C131 (\7\:VDD VSS) capacitor c=4.65014e-17
C132 (\8\:VDD VSS) capacitor c=5.83645e-17
C133 (\10\:VDD VSS) capacitor c=6.53917e-17
C134 (\11\:VDD VSS) capacitor c=5.76413e-17
C135 (\13\:VDD VSS) capacitor c=1.83032e-17
C136 (\14\:VDD VSS) capacitor c=7.70626e-18
Rk31 (\4\:RN RN) resistor r=0.1988 c=0
Rk50 (\1\:VSS \7\:VSS) resistor r=0.3449 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.1277 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=1.0755 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.9275 c=0
Rk54 (\10\:VSS \11\:VSS) resistor r=0.2756 c=0
Rk55 (\11\:VSS \12\:VSS) resistor r=0.1377 c=0
Rk57 (\13\:VSS VSS) resistor r=0.0497 c=0
Rk56 (\12\:VSS \13\:VSS) resistor r=0.3632 c=0
Rk60 (\8\:VSS \19\:VSS) resistor r=0.3144 c=0
Rk61 (\10\:VSS \21\:VSS) resistor r=0.3261 c=0
Rk62 (\12\:VSS \23\:VSS) resistor r=0.07381 c=0
Rk63 (\13\:VSS \25\:VSS) resistor r=0.07381 c=0
Rk1 (\5\:CK CK) resistor r=0.1912 c=0
Rk6 (SN \8\:SN) resistor r=0.008772 c=0
Rk24 (\9\:SN \10\:SN) resistor r=2.6896 c=0
Rk32 (\2\:Q Q) resistor r=0.2659 c=0
Rk33 (Q \4\:Q) resistor r=0.03518 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.02989 c=0
Rk67 (\3\:VDD \6\:VDD) resistor r=0.3609 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.1553 c=0
Rk69 (\7\:VDD \8\:VDD) resistor r=0.822 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.2255 c=0
Rk71 (\9\:VDD \10\:VDD) resistor r=0.4687 c=0
Rk72 (\10\:VDD \11\:VDD) resistor r=0.4284 c=0
Rk73 (\11\:VDD \12\:VDD) resistor r=0.3057 c=0
Rk74 (\12\:VDD \13\:VDD) resistor r=0.2004 c=0
Rk76 (\14\:VDD VDD) resistor r=0.0497 c=0
Rk75 (\13\:VDD \14\:VDD) resistor r=0.3005 c=0
Rk80 (\7\:VDD \22\:VDD) resistor r=0.1025 c=0
Rk81 (\8\:VDD \24\:VDD) resistor r=0.1526 c=0
Rk82 (\10\:VDD \26\:VDD) resistor r=0.1577 c=0
Rk83 (\11\:VDD \28\:VDD) resistor r=0.07381 c=0
Rk84 (\13\:VDD \30\:VDD) resistor r=0.2206 c=0
Rk85 (\14\:VDD \32\:VDD) resistor r=0.224 c=0
Rk2 (D \4\:D) resistor r=0.0252 c=0
Rk34 (\2\:QN QN) resistor r=0.2985 c=0
Rk35 (QN \4\:QN) resistor r=0.03435 c=0
Rk16 (\12\:CKb \13\:CKb) resistor r=0.5798 c=0
Rk17 (\13\:CKb \14\:CKb) resistor r=1.853 c=0
Rk18 (\14\:CKb \15\:CKb) resistor r=0.6747 c=0
Rk19 (\15\:CKb \16\:CKb) resistor r=0.4224 c=0
Rk20 (\16\:CKb \18\:CKb) resistor r=0.7201 c=0
Rk21 (\18\:CKb \20\:CKb) resistor r=0.2892 c=0
Rk3 (\6\:CKbb \7\:CKbb) resistor r=0.4533 c=0
Rk4 (\7\:CKbb \9\:CKbb) resistor r=0.04817 c=0
Rk5 (\7\:CKbb \11\:CKbb) resistor r=0.4927 c=0
Rk7 (\5\:n20 \6\:n20) resistor r=0.4428 c=0
Rk8 (\6\:n20 \8\:n20) resistor r=0.1009 c=0
Rk9 (\6\:n20 \9\:n20) resistor r=0.5177 c=0
Rk11 (\5\:mout \7\:mout) resistor r=0.344 c=0
Rk12 (\7\:mout \8\:mout) resistor r=0.5911 c=0
Rk13 (\8\:mout \10\:mout) resistor r=0.2427 c=0
Rk14 (\8\:mout \12\:mout) resistor r=0.3991 c=0
Rk15 (\12\:mout \13\:mout) resistor r=0.4656 c=0
Rk10 (\2\:net426 \4\:net426) resistor r=0.4959 c=0
Rk29 (\8\:RNb \10\:RNb) resistor r=0.773 c=0
Rk30 (\10\:RNb \11\:RNb) resistor r=2.2246 c=0
Rk26 (\4\:n35 \5\:n35) resistor r=1.7773 c=0
Rk27 (\5\:n35 \7\:n35) resistor r=0.2449 c=0
Rk28 (\5\:n35 \9\:n35) resistor r=0.1258 c=0
Rk22 (\2\:n40 \4\:n40) resistor r=1.2603 c=0
Rk25 (\2\:n42 \4\:n42) resistor r=0.3774 c=0
Rk36 (\16\:qbint \5\:qbint) resistor r=0.5276 c=0
Rk38 (\5\:qbint \20\:qbint) resistor r=0.5739 c=0
Rk39 (\20\:qbint \21\:qbint) resistor r=0.1409 c=0
Rk40 (\21\:qbint \22\:qbint) resistor r=0.3845 c=0
Rk43 (\21\:qbint \26\:qbint) resistor r=0.2922 c=0
Rk44 (\9\:qint \10\:qint) resistor r=0.1906 c=0
Rk45 (\10\:qint \11\:qint) resistor r=0.148 c=0
Rk46 (\10\:qint \13\:qint) resistor r=0.1376 c=0
Rk23 (\2\:n41 \4\:n41) resistor r=1.3593 c=0
Rl35 (\1\:RN \2\:RN) resistor r=110.307 c=0
Rl36 (\2\:RN \3\:RN) resistor r=29.5379 c=0
Rl1 (\1\:CK \2\:CK) resistor r=51.6372 c=0
Rl3 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl2 (\2\:CK \3\:CK) resistor r=1.2666 c=0
Rl31 (\5\:SN \6\:SN) resistor r=168.796 c=0
Rl32 (\6\:SN \7\:SN) resistor r=59.5926 c=0
Rl14 (\3\:SN \4\:SN) resistor r=52.6149 c=0
Rl13 (\2\:SN \3\:SN) resistor r=95.3867 c=0
Rl12 (\1\:SN \2\:SN) resistor r=76.1559 c=0
Rl6 (\1\:D \2\:D) resistor r=69.9225 c=0
Rl7 (\2\:D \3\:D) resistor r=129.538 c=0
Rl22 (\10\:CKb \11\:CKb) resistor r=73.7157 c=0
Rl17 (\8\:CKb \9\:CKb) resistor r=29.5379 c=0
Rl9 (\6\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl8 (\4\:CKb \5\:CKb) resistor r=35.7713 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=184.066 c=0
Rl4 (CKb \2\:CKb) resistor r=28.8462 c=0
Rl18 (CKbb \2\:CKbb) resistor r=177.977 c=0
Rl19 (\2\:CKbb \3\:CKbb) resistor r=808.747 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=28.079 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=291.428 c=0
Rl15 (n20 \2\:n20) resistor r=147.31 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl10 (mout \2\:mout) resistor r=29.5379 c=0
Rl11 (\2\:mout \3\:mout) resistor r=144.923 c=0
Rl26 (RNb \5\:RNb) resistor r=142.308 c=0
Rl25 (\3\:RNb \4\:RNb) resistor r=200 c=0
Rl23 (RNb \2\:RNb) resistor r=636.516 c=0
Rl24 (\2\:RNb \3\:RNb) resistor r=638.439 c=0
Rl27 (\2\:RNb \6\:RNb) resistor r=154.219 c=0
Rl33 (n35 \2\:n35) resistor r=24.2328 c=0
Rl34 (\2\:n35 \3\:n35) resistor r=66.5405 c=0
Rl50 (\14\:qbint \15\:qbint) resistor r=111.104 c=0
Rl49 (\13\:qbint \14\:qbint) resistor r=38.2281 c=0
Rl29 (\2\:qbint \3\:qbint) resistor r=122.587 c=0
Rl28 (\2\:qbint qbint) resistor r=24.4619 c=0
Rl30 (\2\:qbint \4\:qbint) resistor r=4.5402 c=0
Rz21 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz14 (\2\:Q \1\:Q) resistor r=75 c=0
Rz25 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz26 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz27 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz28 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz15 (\2\:QN \1\:QN) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz1 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz5 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz3 (net426 \2\:net426) resistor r=75 c=0
Rz4 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz13 (\7\:RNb \8\:RNb) resistor r=75 c=0
Rz12 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz8 (n40 \2\:n40) resistor r=75 c=0
Rz9 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz10 (n42 \2\:n42) resistor r=75 c=0
Rz11 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz16 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz17 (\9\:qint \8\:qint) resistor r=75 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry15 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry10 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry21 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry23 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry24 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry25 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry26 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry11 (\4\:QN \3\:QN) resistor r=20.6667 c=0
Ry5 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry1 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry3 (\6\:mout \7\:mout) resistor r=62 c=0
Ry4 (\11\:mout \12\:mout) resistor r=62 c=0
Ry9 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry8 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry13 (\13\:qint \12\:qint) resistor r=62 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx16 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx4 (\2\:SN \8\:SN) resistor r=45 c=0
Rx12 (\7\:SN \9\:SN) resistor r=45 c=0
Rx13 (\4\:SN \10\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\9\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx10 (\5\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx3 (\4\:CKbb \6\:CKbb) resistor r=45 c=0
Rx5 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx6 (\2\:mout \13\:mout) resistor r=45 c=0
Rx15 (\6\:RNb \11\:RNb) resistor r=45 c=0
Rx14 (\2\:n35 \4\:n35) resistor r=45 c=0
Rx17 (\16\:qbint \13\:qbint) resistor r=45 c=0
Rx18 (\22\:qbint \4\:qbint) resistor r=45 c=0
Rx21 (\11\:qint qint) resistor r=45 c=0
mn20 (\17\:CKb \4\:CK \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn21 (\10\:CKbb CKb \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.972e-14 ps=1.54e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.5e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn25 (n21 \3\:D \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=3.045e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.53793e-07 sb=1.645e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn26 (\7\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=4.132e-14 ps=7.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.08793e-07 sb=1.39e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn36 (\7\:n20 \3\:CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.38793e-07 sb=1.06e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn35 (n30 \3\:mout \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=8.7e-15 ps=7.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04379e-06 sb=9.55e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn30 (\3\:net426 \1\:SN \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.625e-14 ad=3.48e-14 ps=7.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33879e-06 sb=6.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn32 (\9\:mout \3\:n20 \3\:net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=2.755e-14 ps=7.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62379e-06 sb=3.75e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\9\:mout \4\:RNb net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85879e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn40 (\6\:n35 \2\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn53 (\6\:n35 \10\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn51 (\3\:n40 \5\:RNb n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.538e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n40 qbint \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.538e-14 ps=6.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6.25e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (\3\:n42 \5\:SN \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.065e-14 ad=2.538e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=4.05e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn22 (\7\:RNb \3\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.91e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.245e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\8\:qint \14\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.765e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.245e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint \3\:n35 \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.065e-14 ad=3.895e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91585e-07 sb=1.9e-07 sd=160n sca=15.5643 \
        scb=0.0161016 scc=0.00117276 m=(1)
mn55 (\1\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.735e-14 ad=4.16e-14 ps=1.61e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=9.36058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.663e-14 ad=4.94e-14 ps=1.6e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.06635e-07 sb=4.66058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\25\:qbint n35 \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.298e-13 ad=5.89e-14 ps=1.96e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28226e-06 sb=1.9e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.715e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.50064e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp57_1__rcx (\3\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.715e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.45064e-07 sb=4.40064e-07 sd=160n sca=26.2038 \
        scb=0.0192256 scc=0.00277832 m=(2)
ends DFFSRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:49 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRX4
// View name: extracted

simulator lang=spectre

subckt DFFSRX4 CK D Q QN RN SN VDD VSS
mp20 (\19\:CKb \1\:CK \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.0386e-06 sd=160n sca=15.9848 \
        scb=0.0156658 scc=0.000281378 m=(1)
mp25 (n22 \1\:D \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=6.988e-14 ps=1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=7.08605e-07 sd=160n sca=11.7846 \
        scb=0.00917683 scc=0.000161 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.988e-14 ad=3.76e-14 ps=1.08e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=3.38605e-07 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp36 (\5\:n20 \3\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.76e-14 ps=5.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.93372e-07 sb=3.41977e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp35 (n31 mout \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.855e-14 ad=1.29e-14 ps=1.91e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98372e-07 sb=2.36977e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp21 (\11\:CKbb \5\:CKb \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.855e-14 ad=3.01e-14 ps=1.91e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.04651e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (net402 \3\:RNb \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.015e-14 ad=1.29e-14 ps=2.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97674e-07 sb=1.15895e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\8\:mout \2\:n20 net402 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=9.353e-14 ps=5.5e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.02674e-07 sb=1.05395e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout \5\:SN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.823e-14 ad=9.353e-14 ps=1.6e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.82674e-07 sb=5.73953e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \1\:RN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.823e-14 ad=5.03e-14 ps=1.6e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12267e-06 sb=2.33953e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\12\:n35 \9\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.01e-14 ad=3.56e-14 ps=9.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86512e-07 sb=3.10814e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp53 (\12\:n35 \7\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.56e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41279e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp51 (n43 \4\:RNb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp52 (\3\:n41 qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (\3\:n41 \1\:SN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
C1 (RN VSS) capacitor c=8.2202e-17
C2 (Q VSS) capacitor c=2.22404e-17
C3 (CK VSS) capacitor c=8.03567e-17
C4 (SN VSS) capacitor c=8.09066e-17
C5 (QN VSS) capacitor c=1.61781e-17
C6 (D VSS) capacitor c=6.27755e-17
C7 (VDD VSS) capacitor c=4.79888e-16
C8 (CKb VSS) capacitor c=5.15279e-17
C9 (n21 VSS) capacitor c=1.49997e-18
C10 (n20 VSS) capacitor c=6.0871e-17
C11 (CKbb VSS) capacitor c=3.23105e-17
C12 (mout VSS) capacitor c=9.39412e-17
C13 (RNb VSS) capacitor c=2.94334e-17
C14 (net426 VSS) capacitor c=1.0975e-16
C15 (n35 VSS) capacitor c=2.01917e-16
C16 (n40 VSS) capacitor c=8.29811e-17
C17 (n42 VSS) capacitor c=7.57924e-17
C18 (qbint VSS) capacitor c=8.64333e-17
C19 (qint VSS) capacitor c=2.86495e-16
C20 (n22 VSS) capacitor c=5.52275e-18
C21 (n31 VSS) capacitor c=8.39255e-19
C22 (net402 VSS) capacitor c=9.59976e-19
C23 (n41 VSS) capacitor c=8.45559e-17
C24 (\20\:qbint VSS) capacitor c=5.07619e-17
C25 (\4\:qbint VSS) capacitor c=2.43354e-16
C26 (\1\:SN VSS) capacitor c=7.66706e-17
C27 (\4\:RNb VSS) capacitor c=7.88541e-17
C28 (\7\:CKbb VSS) capacitor c=5.63779e-17
C29 (\9\:CKb VSS) capacitor c=1.14654e-16
C30 (\1\:RN VSS) capacitor c=3.72408e-17
C31 (\5\:SN VSS) capacitor c=4.04327e-17
C32 (\2\:n20 VSS) capacitor c=1.13249e-16
C33 (\3\:RNb VSS) capacitor c=8.02669e-17
C34 (\5\:CKb VSS) capacitor c=3.16021e-17
C35 (\3\:CKb VSS) capacitor c=6.91488e-17
C36 (\3\:CKbb VSS) capacitor c=5.74856e-17
C37 (\1\:D VSS) capacitor c=2.97874e-17
C38 (\1\:CK VSS) capacitor c=4.05005e-17
C39 (\18\:qbint VSS) capacitor c=2.99247e-17
C40 (\2\:SN VSS) capacitor c=1.91778e-16
C41 (\3\:qbint VSS) capacitor c=3.95546e-17
C42 (\6\:RNb VSS) capacitor c=4.24387e-17
C43 (\8\:CKb VSS) capacitor c=6.929e-17
C44 (\5\:CKbb VSS) capacitor c=5.08948e-17
C45 (\3\:RN VSS) capacitor c=3.55493e-17
C46 (\3\:SN VSS) capacitor c=1.13771e-16
C47 (\2\:RNb VSS) capacitor c=4.85334e-17
C48 (\7\:CKb VSS) capacitor c=3.69764e-17
C49 (\2\:mout VSS) capacitor c=5.83715e-17
C50 (\3\:D VSS) capacitor c=6.89631e-17
C51 (\3\:CK VSS) capacitor c=3.00155e-17
C52 (\19\:qbint VSS) capacitor c=4.63126e-17
C53 (\10\:qbint VSS) capacitor c=1.42874e-17
C54 (\2\:qbint VSS) capacitor c=7.30678e-17
C55 (\5\:RNb VSS) capacitor c=6.17322e-17
C56 (\8\:CKbb VSS) capacitor c=2.51472e-17
C57 (\6\:CKbb VSS) capacitor c=3.80732e-17
C58 (\2\:RN VSS) capacitor c=2.54386e-17
C59 (\4\:SN VSS) capacitor c=2.99889e-17
C60 (\10\:CKb VSS) capacitor c=5.55871e-17
C61 (\3\:n20 VSS) capacitor c=3.85914e-17
C62 (\6\:CKb VSS) capacitor c=2.65772e-17
C63 (\3\:mout VSS) capacitor c=3.53534e-17
C64 (\4\:CKb VSS) capacitor c=5.48913e-17
C65 (\4\:CKbb VSS) capacitor c=3.52646e-17
C66 (\2\:CKb VSS) capacitor c=3.58937e-17
C67 (\2\:D VSS) capacitor c=4.70118e-17
C68 (\2\:CK VSS) capacitor c=3.82364e-17
C69 (\15\:qint VSS) capacitor c=4.16632e-17
C70 (\1\:VDD VSS) capacitor c=4.08073e-16
C71 (\25\:qbint VSS) capacitor c=5.99662e-17
C72 (\3\:n41 VSS) capacitor c=1.01493e-16
C73 (\23\:VDD VSS) capacitor c=2.92783e-17
C74 (\12\:n35 VSS) capacitor c=3.97261e-17
C75 (\6\:mout VSS) capacitor c=1.95906e-16
C76 (\11\:RNb VSS) capacitor c=9.69772e-17
C77 (\27\:VDD VSS) capacitor c=5.4687e-17
C78 (\8\:mout VSS) capacitor c=2.51168e-16
C79 (\30\:VDD VSS) capacitor c=2.11228e-17
C80 (\11\:CKbb VSS) capacitor c=2.82665e-16
C81 (\33\:VDD VSS) capacitor c=1.83422e-17
C82 (\5\:n20 VSS) capacitor c=1.34234e-16
C83 (\37\:VDD VSS) capacitor c=3.16431e-17
C84 (\19\:CKb VSS) capacitor c=8.57715e-17
C85 (\3\:VDD VSS) capacitor c=1.043e-16
C86 (\18\:qint VSS) capacitor c=2.94485e-17
C87 (\1\:QN VSS) capacitor c=1.10064e-16
C88 (\1\:Q VSS) capacitor c=1.16641e-16
C89 (\28\:qbint VSS) capacitor c=2.03327e-17
C90 (\3\:n42 VSS) capacitor c=8.8856e-17
C91 (\3\:n40 VSS) capacitor c=8.2003e-17
C92 (\10\:n35 VSS) capacitor c=5.89624e-17
C93 (\4\:mout VSS) capacitor c=9.74341e-17
C94 (\8\:RNb VSS) capacitor c=2.27255e-16
C95 (\12\:mout VSS) capacitor c=7.7667e-17
C96 (\3\:net426 VSS) capacitor c=1.014e-16
C97 (\16\:CKbb VSS) capacitor c=2.86135e-17
C98 (\7\:n20 VSS) capacitor c=1.29039e-16
C99 (\15\:CKb VSS) capacitor c=9.16223e-17
C100 (\2\:CKbb VSS) capacitor c=4.15344e-17
C101 (\4\:CK VSS) capacitor c=3.77748e-17
C102 (\4\:D VSS) capacitor c=4.27699e-17
C103 (\4\:n20 VSS) capacitor c=1.04804e-16
C104 (\11\:CKb VSS) capacitor c=1.61686e-16
C105 (\13\:CKb VSS) capacitor c=1.28383e-16
C106 (\14\:CKb VSS) capacitor c=9.98886e-17
C107 (\17\:CKb VSS) capacitor c=2.27241e-16
C108 (\18\:CKb VSS) capacitor c=3.66597e-17
C109 (\6\:SN VSS) capacitor c=5.25542e-17
C110 (\4\:RN VSS) capacitor c=6.25291e-17
C111 (\10\:mout VSS) capacitor c=1.68386e-16
C112 (\11\:mout VSS) capacitor c=8.37063e-17
C113 (\9\:CKbb VSS) capacitor c=2.33209e-17
C114 (\10\:CKbb VSS) capacitor c=2.5928e-16
C115 (\13\:CKbb VSS) capacitor c=5.75067e-17
C116 (\14\:CKbb VSS) capacitor c=6.86068e-17
C117 (\15\:CKbb VSS) capacitor c=9.36425e-17
C118 (\7\:RNb VSS) capacitor c=2.06705e-16
C119 (\10\:RNb VSS) capacitor c=9.91064e-17
C120 (\8\:n35 VSS) capacitor c=1.31934e-16
C121 (\9\:n35 VSS) capacitor c=1.68597e-16
C122 (\5\:Q VSS) capacitor c=1.488e-16
C123 (\6\:QN VSS) capacitor c=1.50304e-16
C124 (\21\:qbint VSS) capacitor c=2.23151e-17
C125 (\22\:qbint VSS) capacitor c=2.85278e-17
C126 (\23\:qbint VSS) capacitor c=2.13952e-16
C127 (\24\:qbint VSS) capacitor c=2.65146e-16
C128 (\27\:qbint VSS) capacitor c=2.63152e-17
C129 (\30\:qbint VSS) capacitor c=5.41392e-17
C130 (\17\:qint VSS) capacitor c=4.06316e-17
C131 (\20\:qint VSS) capacitor c=2.9967e-17
C132 (\22\:VDD VSS) capacitor c=2.66004e-17
C133 (\26\:VDD VSS) capacitor c=4.82627e-17
C134 (\29\:VDD VSS) capacitor c=4.26444e-17
C135 (\32\:VDD VSS) capacitor c=9.49924e-18
C136 (\36\:VDD VSS) capacitor c=1.58315e-17
Rk14 (\4\:RN RN) resistor r=0.04442 c=0
Rk36 (\1\:Q Q) resistor r=0.1313 c=0
Rk37 (Q \5\:Q) resistor r=0.1733 c=0
Rk63 (\1\:VSS \11\:VSS) resistor r=0.8452 c=0
Rk64 (\11\:VSS \12\:VSS) resistor r=0.1829 c=0
Rk65 (\12\:VSS \13\:VSS) resistor r=0.8717 c=0
Rk66 (\13\:VSS \14\:VSS) resistor r=0.1469 c=0
Rk68 (\15\:VSS VSS) resistor r=0.1852 c=0
Rk67 (\14\:VSS \15\:VSS) resistor r=0.3661 c=0
Rk74 (\12\:VSS \27\:VSS) resistor r=0.2079 c=0
Rk75 (\13\:VSS \29\:VSS) resistor r=0.04333 c=0
Rk76 (\15\:VSS \31\:VSS) resistor r=0.07416 c=0
Rk1 (CK \4\:CK) resistor r=0.09921 c=0
Rk13 (\6\:SN SN) resistor r=0.04669 c=0
Rk42 (\1\:QN QN) resistor r=0.09357 c=0
Rk43 (QN \6\:QN) resistor r=0.1507 c=0
Rk2 (\4\:D D) resistor r=0.06128 c=0
Rk90 (\1\:VDD \22\:VDD) resistor r=0.258 c=0
Rk91 (\22\:VDD \24\:VDD) resistor r=0.292 c=0
Rk92 (\22\:VDD \25\:VDD) resistor r=0.6094 c=0
Rk93 (\25\:VDD \26\:VDD) resistor r=0.2206 c=0
Rk94 (\26\:VDD \28\:VDD) resistor r=0.2265 c=0
Rk95 (\26\:VDD \29\:VDD) resistor r=0.6368 c=0
Rk96 (\29\:VDD \31\:VDD) resistor r=0.1029 c=0
Rk97 (\29\:VDD \32\:VDD) resistor r=0.2154 c=0
Rk98 (\32\:VDD \34\:VDD) resistor r=0.1029 c=0
Rk99 (\32\:VDD \35\:VDD) resistor r=0.1303 c=0
Rk102 (\36\:VDD VDD) resistor r=0.1752 c=0
Rk100 (\35\:VDD \36\:VDD) resistor r=0.3761 c=0
Rk101 (\36\:VDD \38\:VDD) resistor r=0.2663 c=0
Rk6 (\11\:CKb \12\:CKb) resistor r=1.4544 c=0
Rk7 (\12\:CKb \13\:CKb) resistor r=0.2229 c=0
Rk8 (\13\:CKb \14\:CKb) resistor r=0.8743 c=0
Rk9 (\14\:CKb \16\:CKb) resistor r=0.3204 c=0
Rk10 (\12\:CKb \17\:CKb) resistor r=0.06307 c=0
Rk11 (\14\:CKb \18\:CKb) resistor r=0.1315 c=0
Rk12 (\16\:CKb \20\:CKb) resistor r=0.6841 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.7409 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.6536 c=0
Rk20 (\9\:CKbb \10\:CKbb) resistor r=0.1616 c=0
Rk21 (\10\:CKbb \12\:CKbb) resistor r=1.9562 c=0
Rk22 (\12\:CKbb \13\:CKbb) resistor r=0.2799 c=0
Rk23 (\13\:CKbb \14\:CKbb) resistor r=0.375 c=0
Rk24 (\10\:CKbb \15\:CKbb) resistor r=0.4481 c=0
Rk25 (\13\:CKbb \17\:CKbb) resistor r=0.05032 c=0
Rk15 (\5\:mout \7\:mout) resistor r=0.5131 c=0
Rk16 (\7\:mout \9\:mout) resistor r=1.0096 c=0
Rk17 (\9\:mout \10\:mout) resistor r=0.917 c=0
Rk18 (\10\:mout \11\:mout) resistor r=0.5804 c=0
Rk19 (\10\:mout \13\:mout) resistor r=0.4076 c=0
Rk26 (\7\:RNb \9\:RNb) resistor r=1.3156 c=0
Rk27 (\9\:RNb \10\:RNb) resistor r=0.7596 c=0
Rk28 (\9\:RNb \12\:RNb) resistor r=0.5181 c=0
Rk5 (\2\:net426 \4\:net426) resistor r=0.6291 c=0
Rk32 (\8\:n35 \9\:n35) resistor r=0.9616 c=0
Rk33 (\9\:n35 \11\:n35) resistor r=0.2486 c=0
Rk34 (\9\:n35 \13\:n35) resistor r=0.1557 c=0
Rk29 (\2\:n40 \4\:n40) resistor r=0.3153 c=0
Rk30 (\2\:n42 \4\:n42) resistor r=0.5274 c=0
Rk46 (\21\:qbint \22\:qbint) resistor r=0.2298 c=0
Rk47 (\22\:qbint \23\:qbint) resistor r=0.1293 c=0
Rk48 (\23\:qbint \24\:qbint) resistor r=2.1178 c=0
Rk49 (\22\:qbint \26\:qbint) resistor r=0.2528 c=0
Rk50 (\23\:qbint \27\:qbint) resistor r=0.07864 c=0
Rk51 (\27\:qbint \29\:qbint) resistor r=0.07494 c=0
Rk52 (\27\:qbint \30\:qbint) resistor r=0.3191 c=0
Rk53 (\16\:qint \17\:qint) resistor r=0.187 c=0
Rk54 (\17\:qint \19\:qint) resistor r=0.3247 c=0
Rk55 (\17\:qint \20\:qint) resistor r=0.1944 c=0
Rk31 (\2\:n41 \4\:n41) resistor r=0.6339 c=0
Rl18 (\1\:RN \2\:RN) resistor r=78.079 c=0
Rl19 (\2\:RN \3\:RN) resistor r=26.1559 c=0
Rl1 (\1\:CK \2\:CK) resistor r=156.925 c=0
Rl2 (\2\:CK \3\:CK) resistor r=37.6944 c=0
Rl28 (\1\:SN \2\:SN) resistor r=234.181 c=0
Rl29 (\2\:SN \3\:SN) resistor r=978.412 c=0
Rl31 (\4\:SN \5\:SN) resistor r=80.2198 c=0
Rl30 (\3\:SN \4\:SN) resistor r=28.8462 c=0
Rl3 (\1\:D \2\:D) resistor r=96.1538 c=0
Rl4 (\2\:D \3\:D) resistor r=103.297 c=0
Rl21 (\8\:CKb \9\:CKb) resistor r=183.747 c=0
Rl22 (\9\:CKb \10\:CKb) resistor r=495.667 c=0
Rl12 (\5\:CKb \6\:CKb) resistor r=31.9251 c=0
Rl13 (\6\:CKb \7\:CKb) resistor r=72.3097 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=66.5405 c=0
Rl5 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl16 (n20 \2\:n20) resistor r=205.335 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=224.513 c=0
Rl23 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=44.9225 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=198.385 c=0
Rl7 (CKbb \2\:CKbb) resistor r=23.7402 c=0
Rl9 (\2\:CKbb \4\:CKbb) resistor r=8.9468 c=0
Rl10 (mout \2\:mout) resistor r=192.308 c=0
Rl11 (\2\:mout \3\:mout) resistor r=34.5219 c=0
Rl15 (\2\:RNb \3\:RNb) resistor r=132.692 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=171.131 c=0
Rl25 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl14 (RNb \2\:RNb) resistor r=93.7438 c=0
Rl65 (\19\:qbint \20\:qbint) resistor r=81.9251 c=0
Rl64 (\19\:qbint \18\:qbint) resistor r=54.3856 c=0
Rl43 (\4\:qbint \10\:qbint) resistor r=7.1351 c=0
Rl26 (\2\:qbint qbint) resistor r=165.18 c=0
Rl27 (\2\:qbint \3\:qbint) resistor r=42.2849 c=0
Rz26 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz27 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz28 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz30 (\1\:VDD \3\:VDD) resistor r=4.4118 c=0
Rz31 (\25\:VDD \3\:VDD) resistor r=6.25 c=0
Rz32 (\35\:VDD \3\:VDD) resistor r=6.25 c=0
Rz4 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz7 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz5 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz2 (net426 \2\:net426) resistor r=75 c=0
Rz3 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz13 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz9 (n40 \2\:n40) resistor r=75 c=0
Rz10 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (n42 \2\:n42) resistor r=75 c=0
Rz12 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (\29\:qbint \28\:qbint) resistor r=75 c=0
Rz19 (\19\:qint \18\:qint) resistor r=75 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=3.6471 c=0
Ry18 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\14\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry27 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry28 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry30 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry31 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry2 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry3 (\6\:mout \7\:mout) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\13\:n35 \12\:n35) resistor r=62 c=0
Ry14 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry15 (\16\:qint \15\:qint) resistor r=20.6667 c=0
Ry7 (n41 \2\:n41) resistor r=62 c=0
Ry8 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx9 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\4\:SN \6\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx5 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx6 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx3 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx11 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx10 (\3\:mout \11\:mout) resistor r=45 c=0
Rx14 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx15 (RNb \10\:RNb) resistor r=45 c=0
Rx16 (\8\:n35 n35) resistor r=45 c=0
Rx17 (\21\:qbint \10\:qbint) resistor r=45 c=0
Rx18 (\24\:qbint \19\:qbint) resistor r=45 c=0
Rx19 (\30\:qbint \2\:qbint) resistor r=45 c=0
Rx20 (\20\:qint qint) resistor r=45 c=0
mn20 (\15\:CKb \3\:CK \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=2.03e-14 ps=1.39e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn25 (n21 \3\:D \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.165e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn26 (\7\:n20 CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.51e-14 ps=4.1e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.06e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn36 (\7\:n20 CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=5.51e-14 ps=6.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=6.35e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn35 (n30 \2\:mout \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.222e-14 ad=2.61e-14 ps=1.4e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=4.1e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn21 (\16\:CKbb \7\:CKb \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.222e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn31 (\12\:mout \2\:RNb \3\:net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=4.278e-14 ps=6.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.065e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn32 (\12\:mout n20 net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=4.278e-14 ps=8.4e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=7.25e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn30 (net426 \3\:SN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=3.988e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=4.05e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn22 (\8\:RNb \3\:RN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn40 (\10\:n35 \5\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn53 (\10\:n35 \8\:CKb \3\:n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.85e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn51 (n40 \6\:RNb \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.103e-14 ad=2.538e-14 ps=5.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn52 (n40 \3\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.538e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn50 (n42 \2\:SN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2e-06 sd=160n sca=8.85152 scb=0.00706865 \
        scc=0.000138481 m=(1)
mn45_1__rcx (\28\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.169e-14 ad=3.28e-14 ps=9.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.77439e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(2)
mn56 (\18\:qint \18\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.455e-14 ad=5.395e-14 ps=1.255e-06 pd=9.35e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.71038e-06 sb=1.165e-06 sd=160n \
        sca=9.32128 scb=0.00786794 scc=0.000232361 m=(4)
mn55_1__rcx (\1\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.944e-14 ad=4.16e-14 ps=1.3175e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.37692e-07 sb=2e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mp45 (\25\:qbint n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.9e-14 ad=4.96e-14 ps=1.15e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.12661e-07 sb=2e-06 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(2)
mp56 (\15\:qint \20\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98256e-06 sb=1.4e-07 sd=160n sca=29.2317 \
        scb=0.0232252 scc=0.00281645 m=(1)
mp57 (\6\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=6.728e-14 ps=1.16e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.69103e-06 sb=1.015e-06 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
mp55_1__rcx (\5\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.89e-14 ad=6.923e-14 ps=1.2e-06 pd=1.135e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.25449e-07 sb=1.955e-06 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
ends DFFSRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:50 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSRXL
// View name: extracted

simulator lang=spectre

subckt DFFSRXL CK D Q QN RN SN VDD VSS
mp57 (\1\:QN \4\:qint \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.91e-14 ad=3.01e-14 ps=9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=49.8399 \
        scb=0.0334143 scc=0.00594375 m=(1)
mp56 (\9\:qint \6\:qbint \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.91e-14 ad=3.01e-14 ps=9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.8055 \
        scb=0.0288702 scc=0.00588464 m=(1)
mp55 (\1\:Q qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=4.48023e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp22 (\7\:RNb \1\:RN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.225e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.43023e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp45 (\14\:qbint \4\:n35 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.64e-14 ad=2.69e-14 ps=1.9e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25116e-07 sb=7.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (\3\:n41 \3\:SN \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.20116e-07 sb=5.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp52 (\3\:n41 \9\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25116e-07 sb=3.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n43 \4\:RNb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.217e-14 ad=1.29e-14 ps=1.38e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.30116e-07 sb=2.65e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (\9\:n35 CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\9\:n35 \2\:CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.955e-14 ad=3.44e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (net402 RNb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.475e-14 ad=1.29e-14 ps=1.74e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.67e-06 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp32 (\7\:mout \3\:n20 net402 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.977e-14 ps=5.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.565e-06 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp30 (\7\:mout \4\:SN \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1088e-13 ad=3.977e-14 ps=1.89e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.335e-06 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp35 (n31 mout \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1088e-13 ad=3.977e-14 ps=1.89e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.045e-06 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp36 (\7\:n20 \5\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=6.127e-14 ps=8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=8.15e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp26 (\7\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.042e-14 ad=6.127e-14 ps=6.2e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=4.85e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp25 (n22 \4\:D \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.705e-14 ad=2.042e-14 ps=1.86e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=3.45e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp21 (\11\:CKbb \7\:CKb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.705e-14 ad=3.01e-14 ps=1.86e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-06 sb=1.4e-07 sd=160n sca=31.995 scb=0.0254181 \
        scc=0.00399203 m=(1)
mp20 (\10\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=3.655e-14 ps=9.2e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=38.6695 \
        scb=0.0332521 scc=0.00441508 m=(1)
C1 (RN VSS) capacitor c=8.30862e-17
C2 (CK VSS) capacitor c=1.00586e-16
C3 (D VSS) capacitor c=6.83961e-17
C4 (Q VSS) capacitor c=6.35514e-17
C5 (VDD VSS) capacitor c=3.86069e-16
C6 (SN VSS) capacitor c=3.12982e-16
C7 (QN VSS) capacitor c=2.25228e-17
C8 (qint VSS) capacitor c=2.23816e-17
C9 (qbint VSS) capacitor c=5.01473e-17
C10 (RNb VSS) capacitor c=1.01541e-16
C11 (n35 VSS) capacitor c=2.42379e-17
C12 (n42 VSS) capacitor c=8.5051e-17
C13 (n40 VSS) capacitor c=8.46181e-17
C14 (CKb VSS) capacitor c=5.38311e-17
C15 (mout VSS) capacitor c=4.65146e-17
C16 (CKbb VSS) capacitor c=4.90962e-17
C17 (net426 VSS) capacitor c=1.00218e-16
C18 (n20 VSS) capacitor c=3.06596e-17
C19 (n30 VSS) capacitor c=2.7422e-18
C20 (n41 VSS) capacitor c=9.80885e-17
C21 (n43 VSS) capacitor c=1.57959e-18
C22 (net402 VSS) capacitor c=1.4968e-18
C23 (n31 VSS) capacitor c=5.50675e-18
C24 (n22 VSS) capacitor c=3.16327e-18
C25 (\1\:CK VSS) capacitor c=2.32735e-17
C26 (\7\:CKb VSS) capacitor c=5.34076e-17
C27 (\4\:D VSS) capacitor c=7.71813e-17
C28 (\7\:CKbb VSS) capacitor c=4.89532e-17
C29 (\5\:CKb VSS) capacitor c=6.19266e-17
C30 (\4\:SN VSS) capacitor c=4.03943e-17
C31 (\3\:n20 VSS) capacitor c=9.08146e-17
C32 (\2\:CKb VSS) capacitor c=5.07044e-17
C33 (\4\:RNb VSS) capacitor c=8.37342e-17
C34 (\9\:qbint VSS) capacitor c=8.16414e-17
C35 (\3\:SN VSS) capacitor c=5.03824e-17
C36 (\4\:n35 VSS) capacitor c=3.92866e-17
C37 (\1\:RN VSS) capacitor c=3.8764e-17
C38 (\6\:qbint VSS) capacitor c=3.09039e-17
C39 (\4\:qint VSS) capacitor c=3.31678e-17
C40 (\3\:CK VSS) capacitor c=2.42698e-17
C41 (\8\:CKb VSS) capacitor c=6.8258e-17
C42 (\3\:D VSS) capacitor c=3.0605e-17
C43 (\4\:CKb VSS) capacitor c=5.90228e-17
C44 (\5\:CKbb VSS) capacitor c=5.63326e-17
C45 (\3\:mout VSS) capacitor c=6.45024e-17
C46 (\7\:SN VSS) capacitor c=5.08997e-17
C47 (\2\:n20 VSS) capacitor c=3.72801e-17
C48 (\2\:RNb VSS) capacitor c=1.10585e-16
C49 (\3\:CKbb VSS) capacitor c=4.31034e-17
C50 (\3\:RNb VSS) capacitor c=1.10206e-16
C51 (\7\:qbint VSS) capacitor c=3.02669e-17
C52 (\1\:SN VSS) capacitor c=3.99228e-17
C53 (\3\:n35 VSS) capacitor c=3.83225e-17
C54 (\3\:RN VSS) capacitor c=3.58457e-17
C55 (\3\:qbint VSS) capacitor c=2.1972e-17
C56 (\5\:qbint VSS) capacitor c=2.13241e-17
C57 (\3\:qint VSS) capacitor c=2.64634e-17
C58 (\2\:CK VSS) capacitor c=1.71363e-17
C59 (\9\:CKb VSS) capacitor c=2.24468e-17
C60 (\1\:D VSS) capacitor c=2.39385e-17
C61 (\8\:CKbb VSS) capacitor c=3.88233e-17
C62 (\6\:CKb VSS) capacitor c=2.43147e-17
C63 (\6\:CKbb VSS) capacitor c=4.81093e-17
C64 (\2\:mout VSS) capacitor c=5.20175e-17
C65 (\6\:SN VSS) capacitor c=2.72343e-17
C66 (\4\:CKbb VSS) capacitor c=4.1186e-17
C67 (\3\:CKb VSS) capacitor c=3.19753e-17
C68 (\2\:CKbb VSS) capacitor c=2.62992e-17
C69 (\5\:RNb VSS) capacitor c=2.46108e-17
C70 (\8\:qbint VSS) capacitor c=5.49017e-17
C71 (\2\:SN VSS) capacitor c=6.3775e-17
C72 (\2\:RN VSS) capacitor c=4.17331e-17
C73 (\2\:qbint VSS) capacitor c=4.80846e-17
C74 (\1\:VDD VSS) capacitor c=5.01559e-17
C75 (\10\:CKb VSS) capacitor c=7.45906e-17
C76 (\11\:CKbb VSS) capacitor c=1.14178e-16
C77 (\12\:VDD VSS) capacitor c=1.14339e-17
C78 (\7\:n20 VSS) capacitor c=9.66039e-17
C79 (\14\:VDD VSS) capacitor c=1.79323e-17
C80 (\7\:mout VSS) capacitor c=1.59899e-16
C81 (\16\:VDD VSS) capacitor c=2.2796e-17
C82 (\9\:mout VSS) capacitor c=1.53963e-16
C83 (\9\:n35 VSS) capacitor c=2.28327e-17
C84 (\18\:VDD VSS) capacitor c=4.38414e-17
C85 (\3\:n41 VSS) capacitor c=1.36698e-16
C86 (\20\:VDD VSS) capacitor c=1.288e-17
C87 (\14\:qbint VSS) capacitor c=5.46563e-17
C88 (\7\:RNb VSS) capacitor c=1.13217e-16
C89 (\22\:VDD VSS) capacitor c=2.81806e-17
C90 (\1\:Q VSS) capacitor c=7.04086e-17
C91 (\9\:qint VSS) capacitor c=3.7528e-17
C92 (\25\:VDD VSS) capacitor c=3.86089e-17
C93 (\1\:QN VSS) capacitor c=2.07565e-17
C94 (\4\:VDD VSS) capacitor c=8.75316e-17
C95 (\15\:CKb VSS) capacitor c=5.97623e-17
C96 (\9\:CKbb VSS) capacitor c=7.30447e-17
C97 (\5\:n20 VSS) capacitor c=8.00119e-17
C98 (\4\:mout VSS) capacitor c=1.00865e-16
C99 (\3\:net426 VSS) capacitor c=8.70379e-17
C100 (\12\:mout VSS) capacitor c=7.52772e-17
C101 (\5\:n35 VSS) capacitor c=7.26316e-17
C102 (\3\:n40 VSS) capacitor c=8.88927e-17
C103 (\3\:n42 VSS) capacitor c=9.49039e-17
C104 (\12\:qbint VSS) capacitor c=8.08818e-17
C105 (\9\:RNb VSS) capacitor c=8.38923e-17
C106 (\3\:Q VSS) capacitor c=4.10824e-17
C107 (\7\:qint VSS) capacitor c=3.71773e-17
C108 (\3\:QN VSS) capacitor c=3.543e-17
C109 (\2\:qint VSS) capacitor c=8.04017e-18
C110 (\4\:qbint VSS) capacitor c=3.56838e-17
C111 (\2\:n35 VSS) capacitor c=2.62199e-17
C112 (\5\:SN VSS) capacitor c=1.75003e-17
C113 (\2\:D VSS) capacitor c=3.51444e-17
C114 (\5\:qint VSS) capacitor c=2.95759e-17
C115 (\6\:qint VSS) capacitor c=3.96373e-17
C116 (\4\:RN VSS) capacitor c=4.24708e-17
C117 (\10\:qbint VSS) capacitor c=8.07721e-17
C118 (\11\:qbint VSS) capacitor c=6.72658e-17
C119 (\16\:qbint VSS) capacitor c=1.16215e-16
C120 (\6\:RNb VSS) capacitor c=9.78244e-17
C121 (\7\:n35 VSS) capacitor c=1.94271e-16
C122 (\8\:n35 VSS) capacitor c=1.85594e-16
C123 (\8\:SN VSS) capacitor c=2.53892e-16
C124 (\9\:SN VSS) capacitor c=1.40818e-16
C125 (\6\:mout VSS) capacitor c=8.62345e-17
C126 (\11\:mout VSS) capacitor c=3.04527e-17
C127 (\4\:n20 VSS) capacitor c=7.89554e-17
C128 (\5\:D VSS) capacitor c=3.63337e-17
C129 (\13\:CKbb VSS) capacitor c=7.79022e-17
C130 (\14\:CKbb VSS) capacitor c=2.33319e-16
C131 (\15\:CKbb VSS) capacitor c=2.16674e-16
C132 (\16\:CKbb VSS) capacitor c=3.81223e-17
C133 (\17\:CKbb VSS) capacitor c=3.76578e-17
C134 (\18\:CKbb VSS) capacitor c=7.16821e-17
C135 (\19\:CKbb VSS) capacitor c=6.69468e-17
C136 (\12\:CKb VSS) capacitor c=9.59135e-17
C137 (\13\:CKb VSS) capacitor c=2.1868e-16
C138 (\14\:CKb VSS) capacitor c=1.67902e-16
C139 (\4\:CK VSS) capacitor c=2.27008e-17
C140 (\3\:VDD VSS) capacitor c=2.49131e-17
C141 (\6\:VDD VSS) capacitor c=2.88473e-17
C142 (\7\:VDD VSS) capacitor c=1.93195e-17
C143 (\9\:VDD VSS) capacitor c=2.26602e-17
C144 (\10\:VDD VSS) capacitor c=2.21688e-17
C145 (\24\:VDD VSS) capacitor c=1.31463e-17
Rk8 (\4\:RN RN) resistor r=0.03374 c=0
Rk46 (\4\:CK CK) resistor r=0.02402 c=0
Rk31 (\5\:D D) resistor r=0.186 c=0
Rk6 (\2\:Q Q) resistor r=0.4329 c=0
Rk7 (Q \4\:Q) resistor r=0.04556 c=0
Rk64 (\2\:VSS \4\:VSS) resistor r=0.7007 c=0
Rk65 (\4\:VSS \5\:VSS) resistor r=0.4678 c=0
Rk66 (\5\:VSS \6\:VSS) resistor r=0.5832 c=0
Rk67 (\6\:VSS \7\:VSS) resistor r=0.8224 c=0
Rk68 (\7\:VSS \8\:VSS) resistor r=0.381 c=0
Rk70 (\9\:VSS VSS) resistor r=0.1952 c=0
Rk69 (\8\:VSS \9\:VSS) resistor r=0.3565 c=0
Rk71 (\4\:VSS \11\:VSS) resistor r=0.2465 c=0
Rk72 (\5\:VSS \13\:VSS) resistor r=0.04331 c=0
Rk73 (\7\:VSS \15\:VSS) resistor r=0.2402 c=0
Rk74 (\8\:VSS \17\:VSS) resistor r=0.4333 c=0
Rk75 (\9\:VSS \19\:VSS) resistor r=0.3705 c=0
Rk47 (\2\:VDD \3\:VDD) resistor r=0.7685 c=0
Rk48 (\3\:VDD \5\:VDD) resistor r=0.03241 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.4678 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.2986 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.2822 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.5064 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.3347 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.36 c=0
Rk55 (\3\:VDD \13\:VDD) resistor r=0.07393 c=0
Rk56 (\6\:VDD \15\:VDD) resistor r=0.04331 c=0
Rk57 (\7\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk58 (\9\:VDD \19\:VDD) resistor r=0.2777 c=0
Rk59 (\10\:VDD \21\:VDD) resistor r=0.04331 c=0
Rk60 (\11\:VDD \23\:VDD) resistor r=0.2673 c=0
Rk63 (\24\:VDD VDD) resistor r=0.2102 c=0
Rk61 (\11\:VDD \24\:VDD) resistor r=0.3414 c=0
Rk62 (\24\:VDD \26\:VDD) resistor r=0.4081 c=0
Rk22 (\8\:SN SN) resistor r=1.6494 c=0
Rk23 (SN \9\:SN) resistor r=0.8257 c=0
Rk2 (\4\:QN QN) resistor r=0.08804 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1194 c=0
Rk4 (\6\:qint \8\:qint) resistor r=0.1088 c=0
Rk5 (\6\:qint \10\:qint) resistor r=0.116 c=0
Rk9 (\10\:qbint \11\:qbint) resistor r=0.3841 c=0
Rk10 (\11\:qbint \13\:qbint) resistor r=0.1237 c=0
Rk11 (\11\:qbint \15\:qbint) resistor r=0.2837 c=0
Rk12 (\13\:qbint \16\:qbint) resistor r=0.7447 c=0
Rk13 (\6\:RNb \8\:RNb) resistor r=0.6233 c=0
Rk14 (\8\:RNb \10\:RNb) resistor r=0.4444 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=0.4152 c=0
Rk19 (\7\:n35 \8\:n35) resistor r=1.1382 c=0
Rk20 (\7\:n35 \10\:n35) resistor r=0.02826 c=0
Rk15 (\2\:n42 \4\:n42) resistor r=0.421 c=0
Rk16 (\2\:n40 \4\:n40) resistor r=0.3539 c=0
Rk40 (\11\:CKb \12\:CKb) resistor r=0.2642 c=0
Rk41 (\12\:CKb \13\:CKb) resistor r=0.6136 c=0
Rk42 (\13\:CKb \14\:CKb) resistor r=1.3328 c=0
Rk43 (\11\:CKb \16\:CKb) resistor r=0.3881 c=0
Rk24 (\5\:mout \6\:mout) resistor r=0.559 c=0
Rk25 (\6\:mout \8\:mout) resistor r=0.3846 c=0
Rk26 (\8\:mout \10\:mout) resistor r=0.7091 c=0
Rk27 (\6\:mout \11\:mout) resistor r=0.1126 c=0
Rk28 (\10\:mout \13\:mout) resistor r=0.3665 c=0
Rk32 (\10\:CKbb \12\:CKbb) resistor r=0.5696 c=0
Rk33 (\12\:CKbb \13\:CKbb) resistor r=0.341 c=0
Rk34 (\13\:CKbb \14\:CKbb) resistor r=0.3743 c=0
Rk35 (\14\:CKbb \15\:CKbb) resistor r=1.3221 c=0
Rk36 (\15\:CKbb \16\:CKbb) resistor r=0.2422 c=0
Rk37 (\13\:CKbb \17\:CKbb) resistor r=0.1825 c=0
Rk38 (\14\:CKbb \18\:CKbb) resistor r=0.3233 c=0
Rk39 (\15\:CKbb \19\:CKbb) resistor r=0.2475 c=0
Rk21 (\2\:net426 \4\:net426) resistor r=0.6342 c=0
Rk29 (\4\:n20 \6\:n20) resistor r=0.5107 c=0
Rk30 (\6\:n20 \8\:n20) resistor r=0.4679 c=0
Rk17 (\2\:n41 \4\:n41) resistor r=0.5104 c=0
Rl9 (\1\:RN \2\:RN) resistor r=81.461 c=0
Rl10 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl42 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl43 (\2\:CK \3\:CK) resistor r=46.8456 c=0
Rl39 (\2\:D \4\:D) resistor r=143.11 c=0
Rl38 (\2\:D \3\:D) resistor r=46.9565 c=0
Rl37 (\1\:D \2\:D) resistor r=2.4834 c=0
Rl15 (\2\:SN \3\:SN) resistor r=50.2509 c=0
Rl14 (\1\:SN \2\:SN) resistor r=87.6944 c=0
Rl28 (\4\:SN \5\:SN) resistor r=34.3295 c=0
Rl30 (\5\:SN \7\:SN) resistor r=86.2526 c=0
Rl29 (\5\:SN \6\:SN) resistor r=5.9102 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=112.912 c=0
Rl16 (\7\:qbint \8\:qbint) resistor r=28.8462 c=0
Rl4 (qbint \2\:qbint) resistor r=147.807 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=25.1665 c=0
Rl8 (\4\:qbint \6\:qbint) resistor r=49.521 c=0
Rl7 (\4\:qbint \5\:qbint) resistor r=42.7196 c=0
Rl6 (\2\:qbint \4\:qbint) resistor r=158.001 c=0
Rl22 (RNb \2\:RNb) resistor r=211.104 c=0
Rl24 (\3\:RNb \4\:RNb) resistor r=230.335 c=0
Rl23 (\2\:RNb \3\:RNb) resistor r=666.873 c=0
Rl25 (\4\:RNb \5\:RNb) resistor r=31.9251 c=0
Rl13 (\2\:n35 \4\:n35) resistor r=43.9449 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=113.176 c=0
Rl11 (n35 \2\:n35) resistor r=0.5213 c=0
Rl40 (\7\:CKb \8\:CKb) resistor r=200 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=243.469 c=0
Rl19 (CKb \2\:CKb) resistor r=121.524 c=0
Rl41 (\7\:CKb \9\:CKb) resistor r=66.8207 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=50.6918 c=0
Rl20 (\2\:CKb \3\:CKb) resistor r=75.5311 c=0
Rl31 (mout \2\:mout) resistor r=73.7687 c=0
Rl32 (\2\:mout \3\:mout) resistor r=100.692 c=0
Rl36 (\7\:CKbb \8\:CKbb) resistor r=35.7713 c=0
Rl33 (\5\:CKbb \6\:CKbb) resistor r=93.4636 c=0
Rl21 (\3\:CKbb \4\:CKbb) resistor r=76.3887 c=0
Rl18 (CKbb \2\:CKbb) resistor r=31.9251 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=128.846 c=0
Rl26 (n20 \2\:n20) resistor r=51.4361 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz23 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz24 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz25 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz26 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz18 (\4\:VDD \5\:VDD) resistor r=8.3333 c=0
Rz19 (\4\:VDD \8\:VDD) resistor r=6.25 c=0
Rz20 (\4\:VDD \11\:VDD) resistor r=6.25 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\7\:qint \8\:qint) resistor r=75 c=0
Rz4 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz5 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz10 (\5\:n35 \6\:n35) resistor r=75 c=0
Rz6 (n42 \2\:n42) resistor r=75 c=0
Rz7 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz8 (n40 \2\:n40) resistor r=75 c=0
Rz9 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz17 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz13 (\4\:mout \5\:mout) resistor r=75 c=0
Rz14 (\12\:mout \13\:mout) resistor r=75 c=0
Rz16 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz11 (net426 \2\:net426) resistor r=75 c=0
Rz12 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry22 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry23 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry2 (\9\:qint \10\:qint) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry5 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry8 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry13 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry9 (\7\:mout \8\:mout) resistor r=62 c=0
Ry10 (\9\:mout \10\:mout) resistor r=62 c=0
Ry12 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry11 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\2\:CK \4\:CK) resistor r=45 c=0
Rx11 (\1\:D \5\:D) resistor r=45 c=0
Rx7 (\6\:SN \8\:SN) resistor r=45 c=0
Rx8 (\2\:SN \9\:SN) resistor r=45 c=0
Rx1 (qint \5\:qint) resistor r=45 c=0
Rx3 (\8\:qbint \10\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \16\:qbint) resistor r=45 c=0
Rx5 (\5\:RNb \6\:RNb) resistor r=45 c=0
Rx6 (n35 \8\:n35) resistor r=45 c=0
Rx16 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx18 (\3\:CKb \14\:CKb) resistor r=45 c=0
Rx9 (\2\:mout \11\:mout) resistor r=45 c=0
Rx12 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx13 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx14 (\6\:CKbb \18\:CKbb) resistor r=45 c=0
Rx15 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx10 (n20 \4\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn56 (\7\:qint \5\:qbint \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\9\:RNb \3\:RN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.625e-14 ps=6.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=2.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\12\:qbint \3\:n35 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=8.75e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn50 (n42 \1\:SN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.263e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=6.7e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn52 (n40 \7\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.9e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=4e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn51 (n40 \3\:RNb \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=2.9e-14 ps=6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.55e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn53 (\5\:n35 CKb \3\:n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=2.32e-14 ps=1.09e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=3.45e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn40 (\5\:n35 \3\:CKbb \12\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn31 (\4\:mout \2\:RNb \3\:net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.64e-14 ps=5.7e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.95e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn32 (\4\:mout \2\:n20 net426 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=4.64e-14 ps=6.6e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=3.3e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn30 (net426 \7\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.698e-14 ad=2.683e-14 ps=1.52e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn35 (n30 \3\:mout \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.698e-14 ad=8.7e-15 ps=1.52e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=1.045e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn36 (\5\:n20 \5\:CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=9.4e-07 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn26 (\5\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.698e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=6.4e-07 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn25 (n21 \3\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.625e-14 ps=6.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=3.45e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn21 (\9\:CKbb \8\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=1.4e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn20 (\15\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.465e-14 ps=6.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends DFFSRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:51 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSX1
// View name: extracted

simulator lang=spectre

subckt DFFSX1 CK D Q QN SN VDD VSS
mp57 (\3\:QN \4\:net331 \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=5.46e-14 ps=1.45e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.30449e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
mp55 (\3\:Q qbint \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.25321e-07 sd=160n sca=30.8891 \
        scb=0.0203192 scc=0.003361 m=(1)
C1 (CK VSS) capacitor c=1.22501e-16
C2 (QN VSS) capacitor c=2.47227e-17
C3 (VDD VSS) capacitor c=2.6578e-16
C4 (SN VSS) capacitor c=4.24398e-17
C5 (Q VSS) capacitor c=4.07919e-17
C6 (net331 VSS) capacitor c=2.00669e-17
C7 (qbint VSS) capacitor c=4.07417e-17
C8 (n35 VSS) capacitor c=1.73266e-17
C9 (n42 VSS) capacitor c=1.60102e-18
C10 (n40 VSS) capacitor c=1.86397e-16
C11 (mout VSS) capacitor c=3.7294e-17
C12 (n20 VSS) capacitor c=2.44413e-17
C13 (CKb VSS) capacitor c=2.16148e-17
C14 (CKbb VSS) capacitor c=3.60703e-17
C15 (n30 VSS) capacitor c=1.87475e-18
C16 (n21 VSS) capacitor c=4.20568e-19
C17 (n41 VSS) capacitor c=1.3175e-16
C18 (\3\:CK VSS) capacitor c=3.20954e-17
C19 (\3\:D VSS) capacitor c=4.54736e-17
C20 (\5\:CKbb VSS) capacitor c=6.33788e-17
C21 (\8\:CKb VSS) capacitor c=3.33015e-17
C22 (\5\:CKb VSS) capacitor c=6.67673e-17
C23 (\3\:CKb VSS) capacitor c=2.83361e-17
C24 (\3\:CKbb VSS) capacitor c=7.3333e-17
C25 (\2\:n20 VSS) capacitor c=4.66786e-17
C26 (\1\:SN VSS) capacitor c=3.20353e-17
C27 (\6\:SN VSS) capacitor c=2.47657e-17
C28 (\7\:qbint VSS) capacitor c=3.03025e-17
C29 (\4\:n35 VSS) capacitor c=4.57315e-17
C30 (\6\:qbint VSS) capacitor c=3.55988e-17
C31 (\4\:net331 VSS) capacitor c=4.78065e-17
C32 (\1\:CK VSS) capacitor c=3.50337e-17
C33 (\1\:D VSS) capacitor c=6.67605e-17
C34 (\10\:CKb VSS) capacitor c=5.05418e-17
C35 (\8\:CKbb VSS) capacitor c=3.33039e-17
C36 (\4\:mout VSS) capacitor c=4.45052e-17
C37 (\6\:CKb VSS) capacitor c=4.54472e-17
C38 (\2\:CKb VSS) capacitor c=3.25561e-17
C39 (\3\:n20 VSS) capacitor c=6.69876e-17
C40 (\4\:SN VSS) capacitor c=4.08588e-17
C41 (\5\:SN VSS) capacitor c=3.13677e-17
C42 (\10\:qbint VSS) capacitor c=4.1363e-17
C43 (\3\:n35 VSS) capacitor c=3.4578e-17
C44 (\5\:qbint VSS) capacitor c=3.37797e-17
C45 (\4\:qbint VSS) capacitor c=2.70521e-17
C46 (\3\:net331 VSS) capacitor c=3.90302e-17
C47 (\2\:CK VSS) capacitor c=3.46454e-17
C48 (\2\:D VSS) capacitor c=4.35315e-17
C49 (\11\:CKb VSS) capacitor c=3.41532e-17
C50 (\9\:CKb VSS) capacitor c=5.24629e-17
C51 (\7\:CKbb VSS) capacitor c=5.92415e-17
C52 (\3\:mout VSS) capacitor c=2.49689e-17
C53 (\7\:CKb VSS) capacitor c=1.94788e-17
C54 (\4\:CKbb VSS) capacitor c=4.38105e-17
C55 (\4\:CKb VSS) capacitor c=4.15014e-17
C56 (\3\:SN VSS) capacitor c=3.61627e-17
C57 (\9\:qbint VSS) capacitor c=3.80581e-17
C58 (\2\:qbint VSS) capacitor c=3.48933e-17
C59 (\20\:CKb VSS) capacitor c=7.08381e-17
C60 (\1\:VDD VSS) capacitor c=5.41854e-17
C61 (\6\:n20 VSS) capacitor c=2.22804e-16
C62 (\12\:VDD VSS) capacitor c=3.47225e-17
C63 (\13\:CKbb VSS) capacitor c=5.13024e-17
C64 (\7\:mout VSS) capacitor c=6.54982e-17
C65 (\5\:n35 VSS) capacitor c=6.02624e-17
C66 (\14\:VDD VSS) capacitor c=3.3261e-17
C67 (\14\:mout VSS) capacitor c=4.31597e-17
C68 (\16\:VDD VSS) capacitor c=1.4527e-17
C69 (\3\:n41 VSS) capacitor c=9.10695e-17
C70 (\18\:VDD VSS) capacitor c=3.46044e-17
C71 (\14\:qbint VSS) capacitor c=5.32918e-17
C72 (\20\:VDD VSS) capacitor c=5.43429e-17
C73 (\3\:Q VSS) capacitor c=8.87965e-17
C74 (\5\:net331 VSS) capacitor c=3.02788e-17
C75 (\22\:VDD VSS) capacitor c=1.74993e-17
C76 (\3\:QN VSS) capacitor c=4.50711e-17
C77 (\3\:VDD VSS) capacitor c=3.74046e-17
C78 (\18\:CKb VSS) capacitor c=8.6156e-17
C79 (\4\:n20 VSS) capacitor c=8.94727e-17
C80 (\11\:CKbb VSS) capacitor c=4.13336e-17
C81 (\5\:mout VSS) capacitor c=8.77293e-17
C82 (\9\:n35 VSS) capacitor c=4.14436e-17
C83 (\11\:mout VSS) capacitor c=7.44148e-17
C84 (\3\:n40 VSS) capacitor c=1.82125e-16
C85 (\11\:qbint VSS) capacitor c=4.97037e-17
C86 (\1\:Q VSS) capacitor c=4.34701e-17
C87 (\9\:net331 VSS) capacitor c=2.96058e-17
C88 (\1\:QN VSS) capacitor c=1.84125e-17
C89 (\2\:net331 VSS) capacitor c=1.25231e-17
C90 (\3\:qbint VSS) capacitor c=3.70196e-17
C91 (\2\:n35 VSS) capacitor c=2.40468e-17
C92 (\2\:SN VSS) capacitor c=2.33387e-17
C93 (\2\:CKbb VSS) capacitor c=4.73681e-17
C94 (\2\:mout VSS) capacitor c=3.61808e-17
C95 (\6\:CKbb VSS) capacitor c=5.85752e-17
C96 (\7\:net331 VSS) capacitor c=2.95022e-17
C97 (\8\:net331 VSS) capacitor c=3.56323e-17
C98 (\13\:qbint VSS) capacitor c=3.19036e-17
C99 (\16\:qbint VSS) capacitor c=4.39995e-17
C100 (\17\:qbint VSS) capacitor c=2.08057e-17
C101 (\7\:SN VSS) capacitor c=4.74029e-17
C102 (\7\:n35 VSS) capacitor c=2.57331e-16
C103 (\8\:n35 VSS) capacitor c=2.15254e-16
C104 (\9\:mout VSS) capacitor c=1.6462e-16
C105 (\10\:mout VSS) capacitor c=1.10869e-16
C106 (\13\:mout VSS) capacitor c=8.80239e-17
C107 (\9\:CKbb VSS) capacitor c=7.02874e-17
C108 (\10\:CKbb VSS) capacitor c=6.4365e-17
C109 (\8\:n20 VSS) capacitor c=2.13553e-16
C110 (\4\:D VSS) capacitor c=1.14269e-16
C111 (\12\:CKb VSS) capacitor c=7.36659e-17
C112 (\13\:CKb VSS) capacitor c=6.03489e-17
C113 (\14\:CKb VSS) capacitor c=7.481e-17
C114 (\15\:CKb VSS) capacitor c=7.47835e-17
C115 (\16\:CKb VSS) capacitor c=4.10096e-17
C116 (\17\:CKb VSS) capacitor c=5.62102e-17
C117 (\22\:CKb VSS) capacitor c=9.26154e-17
C118 (\5\:VDD VSS) capacitor c=2.54638e-17
C119 (\6\:VDD VSS) capacitor c=3.35984e-17
C120 (\7\:VDD VSS) capacitor c=1.45407e-17
C121 (\8\:VDD VSS) capacitor c=7.47578e-18
C122 (\10\:VDD VSS) capacitor c=1.42176e-17
C123 (\11\:VDD VSS) capacitor c=7.41206e-18
Rk39 (\2\:VSS \4\:VSS) resistor r=0.4432 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.08418 c=0
Rk41 (\5\:VSS \6\:VSS) resistor r=0.739 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.2784 c=0
Rk43 (\7\:VSS \8\:VSS) resistor r=0.1303 c=0
Rk45 (\9\:VSS VSS) resistor r=0.1175 c=0
Rk44 (\8\:VSS \9\:VSS) resistor r=0.3033 c=0
Rk46 (\5\:VSS \11\:VSS) resistor r=0.08852 c=0
Rk47 (\6\:VSS \13\:VSS) resistor r=0.0744 c=0
Rk48 (\8\:VSS \15\:VSS) resistor r=0.1282 c=0
Rk49 (\9\:VSS \17\:VSS) resistor r=0.1618 c=0
Rk30 (\4\:CK CK) resistor r=0.003169 c=0
Rk29 (D \4\:D) resistor r=0.01204 c=0
Rk1 (QN \2\:QN) resistor r=0.07525 c=0
Rk2 (QN \4\:QN) resistor r=0.2628 c=0
Rk50 (\2\:VDD \4\:VDD) resistor r=0.6639 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.08032 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.5384 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.2035 c=0
Rk54 (\7\:VDD \8\:VDD) resistor r=0.2346 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.03996 c=0
Rk56 (\9\:VDD \10\:VDD) resistor r=0.1479 c=0
Rk58 (\11\:VDD VDD) resistor r=0.1175 c=0
Rk57 (\10\:VDD \11\:VDD) resistor r=0.2857 c=0
Rk59 (\5\:VDD \13\:VDD) resistor r=0.06359 c=0
Rk60 (\6\:VDD \15\:VDD) resistor r=0.06593 c=0
Rk61 (\7\:VDD \17\:VDD) resistor r=0.06593 c=0
Rk62 (\8\:VDD \19\:VDD) resistor r=0.36 c=0
Rk63 (\10\:VDD \21\:VDD) resistor r=0.4381 c=0
Rk64 (\11\:VDD \23\:VDD) resistor r=0.2256 c=0
Rk12 (SN \7\:SN) resistor r=0.01366 c=0
Rk6 (Q \2\:Q) resistor r=0.1069 c=0
Rk7 (Q \4\:Q) resistor r=0.2629 c=0
Rk3 (\6\:net331 \7\:net331) resistor r=0.1181 c=0
Rk4 (\7\:net331 \8\:net331) resistor r=0.1198 c=0
Rk5 (\7\:net331 \10\:net331) resistor r=0.1061 c=0
Rk8 (\12\:qbint \13\:qbint) resistor r=0.2573 c=0
Rk9 (\13\:qbint \15\:qbint) resistor r=0.2542 c=0
Rk10 (\15\:qbint \16\:qbint) resistor r=0.1884 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.04496 c=0
Rk15 (\6\:n35 \7\:n35) resistor r=0.2348 c=0
Rk16 (\7\:n35 \8\:n35) resistor r=1.6377 c=0
Rk17 (\7\:n35 \10\:n35) resistor r=0.1341 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=1.1561 c=0
Rk18 (\6\:mout \8\:mout) resistor r=0.4925 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.07259 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.7369 c=0
Rk21 (\10\:mout \12\:mout) resistor r=0.2201 c=0
Rk22 (\9\:mout \13\:mout) resistor r=0.5706 c=0
Rk23 (\10\:mout \15\:mout) resistor r=0.1237 c=0
Rk27 (\5\:n20 \7\:n20) resistor r=0.4536 c=0
Rk28 (\7\:n20 \8\:n20) resistor r=1.4343 c=0
Rk31 (\12\:CKb \13\:CKb) resistor r=0.3575 c=0
Rk32 (\13\:CKb \14\:CKb) resistor r=0.376 c=0
Rk33 (\14\:CKb \15\:CKb) resistor r=0.2856 c=0
Rk34 (\15\:CKb \16\:CKb) resistor r=0.164 c=0
Rk35 (\13\:CKb \17\:CKb) resistor r=0.1666 c=0
Rk36 (\17\:CKb \19\:CKb) resistor r=0.4254 c=0
Rk37 (\19\:CKb \21\:CKb) resistor r=0.4455 c=0
Rk38 (\15\:CKb \22\:CKb) resistor r=0.4279 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.4481 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.1232 c=0
Rk26 (\10\:CKbb \14\:CKbb) resistor r=0.2133 c=0
Rk13 (\2\:n41 \4\:n41) resistor r=0.6791 c=0
Rl40 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl39 (\1\:CK \2\:CK) resistor r=71.1538 c=0
Rl38 (\2\:D \3\:D) resistor r=29.0109 c=0
Rl37 (\1\:D \2\:D) resistor r=75.6797 c=0
Rl19 (\3\:SN \6\:SN) resistor r=43.4636 c=0
Rl18 (\3\:SN \5\:SN) resistor r=66.5405 c=0
Rl15 (\1\:SN \2\:SN) resistor r=66.5412 c=0
Rl17 (\2\:SN \4\:SN) resistor r=68.4643 c=0
Rl16 (\2\:SN \3\:SN) resistor r=67.722 c=0
Rl3 (\2\:net331 \4\:net331) resistor r=49.7141 c=0
Rl2 (\2\:net331 \3\:net331) resistor r=34.3295 c=0
Rl1 (net331 \2\:net331) resistor r=0.5213 c=0
Rl4 (qbint \2\:qbint) resistor r=58.8482 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=24.2328 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=148.068 c=0
Rl12 (\7\:qbint \8\:qbint) resistor r=34.3295 c=0
Rl14 (\8\:qbint \10\:qbint) resistor r=95.868 c=0
Rl13 (\8\:qbint \9\:qbint) resistor r=0.5166 c=0
Rl11 (\2\:n35 \4\:n35) resistor r=67.0218 c=0
Rl10 (\2\:n35 \3\:n35) resistor r=36.2526 c=0
Rl9 (n35 \2\:n35) resistor r=5.915 c=0
Rl29 (mout \2\:mout) resistor r=34.3295 c=0
Rl31 (\2\:mout \4\:mout) resistor r=92.0218 c=0
Rl30 (\2\:mout \3\:mout) resistor r=1.2666 c=0
Rl21 (\2\:n20 \3\:n20) resistor r=153.412 c=0
Rl20 (n20 \2\:n20) resistor r=50.6918 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=134.615 c=0
Rl36 (\10\:CKb \11\:CKb) resistor r=26.1559 c=0
Rl32 (\8\:CKb \9\:CKb) resistor r=29.5379 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=26.1559 c=0
Rl23 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl22 (CKb \2\:CKb) resistor r=32.2712 c=0
Rl25 (\2\:CKbb \3\:CKbb) resistor r=149.543 c=0
Rl24 (CKbb \2\:CKbb) resistor r=30.4507 c=0
Rl26 (\2\:CKbb \4\:CKbb) resistor r=98.4664 c=0
Rl33 (\5\:CKbb \6\:CKbb) resistor r=114.928 c=0
Rl35 (\6\:CKbb \8\:CKbb) resistor r=30.4507 c=0
Rl34 (\6\:CKbb \7\:CKbb) resistor r=104.516 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz18 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz19 (\3\:VDD \9\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz2 (\9\:net331 \10\:net331) resistor r=75 c=0
Rz4 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz7 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz5 (n40 \2\:n40) resistor r=75 c=0
Rz6 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz8 (\5\:mout \6\:mout) resistor r=75 c=0
Rz9 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz12 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz10 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Ry13 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry14 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry2 (\5\:net331 \6\:net331) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry7 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\14\:mout \15\:mout) resistor r=62 c=0
Ry11 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry12 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx11 (\2\:CK \4\:CK) resistor r=45 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:SN \7\:SN) resistor r=45 c=0
Rx1 (net331 \8\:net331) resistor r=45 c=0
Rx2 (\9\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx5 (n35 \8\:n35) resistor r=45 c=0
Rx6 (\3\:mout \13\:mout) resistor r=45 c=0
Rx9 (n20 \8\:n20) resistor r=45 c=0
Rx12 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx14 (CKb \16\:CKb) resistor r=45 c=0
Rx15 (\11\:CKb \17\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \22\:CKb) resistor r=45 c=0
Rx7 (\7\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\4\:CKbb \10\:CKbb) resistor r=45 c=0
mn57 (\1\:QN \3\:net331 \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=3.64e-14 ps=1.6e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\1\:Q \5\:qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.505e-14 ad=3.64e-14 ps=1.51e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.41058e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn56 (\9\:net331 \4\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\11\:qbint \3\:n35 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.505e-14 ad=2.03e-14 ps=1.51e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn51 (\3\:n40 \10\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn50 (n42 \5\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.137e-14 ad=2.32e-14 ps=1.56e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.65e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (n25 \4\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.137e-14 ad=1.16e-14 ps=1.56e-06 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=2.65e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn31 (\11\:mout \3\:n20 n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=2.03e-14 ps=4.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.4e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn52 (\9\:n35 \2\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.19e-14 ps=5.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\9\:n35 CKbb \5\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.6e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn21 (\11\:CKbb \6\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.077e-14 ad=2.102e-14 ps=1.57e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.2e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn36 (n30 \4\:mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.077e-14 ad=4.422e-14 ps=1.57e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-06 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn35 (\4\:n20 \8\:CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=6.5e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn26 (\4\:n20 \10\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=4.45e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn25 (n21 \1\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.417e-14 ad=8.7e-15 ps=1.56e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=3.4e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn20 (\18\:CKb \1\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.417e-14 ad=2.03e-14 ps=1.56e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mp56 (\5\:net331 \6\:qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4e-07 sd=160n sca=49.623 \
        scb=0.0330309 scc=0.00593405 m=(1)
mp45 (\14\:qbint \4\:n35 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (\3\:n41 \7\:qbint \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.99e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3907e-07 sb=7.15e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp50 (\3\:n41 \6\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.588e-14 ad=3.44e-14 ps=1.72e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4407e-07 sb=5.1e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\14\:mout \1\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.588e-14 ad=3.548e-14 ps=1.72e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4407e-07 sb=3.1e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp31 (\14\:mout \2\:n20 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.405e-14 ad=3.548e-14 ps=1.61e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5407e-07 sb=1e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp52 (\5\:n35 \3\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.45e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp40 (\5\:n35 \3\:CKb \7\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp21 (\13\:CKbb \5\:CKb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.885e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp35 (n31 mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.885e-14 ad=4.73e-14 ps=1.77e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=9.45e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp36 (\6\:n20 \8\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=6.8e-07 sd=160n sca=19.9994 \
        scb=0.0193482 scc=0.00179465 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=4.75e-07 sd=160n sca=20.8128 \
        scb=0.0198722 scc=0.00179521 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=21.8401 \
        scb=0.0211222 scc=0.00180091 m=(1)
mp20 (\20\:CKb \3\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=26.2165 \
        scb=0.0285954 scc=0.00203663 m=(1)
ends DFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:53 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSX2
// View name: extracted

simulator lang=spectre

subckt DFFSX2 CK D Q QN SN VDD VSS
mp20 (\22\:CKb \1\:CK \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=16.7501 \
        scb=0.0170023 scc=0.000364399 m=(1)
mp25 (n22 \1\:D \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.128e-14 ps=7.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.165e-06 sd=160n sca=13.1595 \
        scb=0.0109711 scc=0.000224272 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=8.35e-07 sd=160n sca=11.5515 \
        scb=0.00958998 scc=0.000220658 m=(1)
mp36 (\5\:n20 \3\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=6.3e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp35 (n31 \3\:mout \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.517e-13 ad=1.29e-14 ps=2.02e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=5.25e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp21 (\8\:CKbb \5\:CKb \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.517e-13 ad=3.01e-14 ps=2.02e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.4e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp40 (\8\:n35 \8\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp52 (\8\:n35 \4\:CKbb \3\:n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.15e-07 sd=160n sca=16.037 \
        scb=0.0158964 scc=0.00103899 m=(1)
mp31 (\10\:mout n20 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.415e-14 ad=3.978e-14 ps=1.73e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.7e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\10\:mout \5\:SN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.465e-14 ad=3.977e-14 ps=1.83e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=5.4e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp50 (n41 \1\:SN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=4.3e-14 ps=1.83e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp51 (n41 \4\:qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.39e-14 ad=4.3e-14 ps=1.73e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp56 (\8\:net331 \12\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.158e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31384e-06 sb=1.4e-07 sd=160n sca=50.5874 \
        scb=0.0347407 scc=0.00598541 m=(1)
C1 (SN VSS) capacitor c=6.88271e-17
C2 (D VSS) capacitor c=4.66992e-17
C3 (Q VSS) capacitor c=3.86364e-17
C4 (VDD VSS) capacitor c=3.56378e-16
C5 (QN VSS) capacitor c=2.24347e-17
C6 (CK VSS) capacitor c=2.86737e-17
C7 (CKb VSS) capacitor c=4.87154e-17
C8 (n21 VSS) capacitor c=3.26191e-18
C9 (n20 VSS) capacitor c=5.78541e-17
C10 (CKbb VSS) capacitor c=4.33058e-17
C11 (mout VSS) capacitor c=8.51728e-17
C12 (n35 VSS) capacitor c=3.97321e-17
C13 (n40 VSS) capacitor c=1.73094e-16
C14 (n25 VSS) capacitor c=7.81025e-19
C15 (n42 VSS) capacitor c=5.73546e-18
C16 (qbint VSS) capacitor c=1.56407e-17
C17 (net331 VSS) capacitor c=1.37073e-16
C18 (n31 VSS) capacitor c=1.04473e-18
C19 (n41 VSS) capacitor c=1.42651e-16
C20 (\12\:qbint VSS) capacitor c=4.68134e-17
C21 (\5\:qbint VSS) capacitor c=3.64784e-16
C22 (\3\:n35 VSS) capacitor c=5.08916e-17
C23 (\4\:qbint VSS) capacitor c=3.70909e-17
C24 (\1\:SN VSS) capacitor c=2.45555e-17
C25 (\5\:SN VSS) capacitor c=3.0755e-17
C26 (\4\:CKbb VSS) capacitor c=4.99186e-17
C27 (\8\:CKb VSS) capacitor c=3.66471e-17
C28 (\5\:CKb VSS) capacitor c=5.44769e-17
C29 (\3\:mout VSS) capacitor c=7.06658e-17
C30 (\3\:CKb VSS) capacitor c=6.30272e-17
C31 (\3\:CKbb VSS) capacitor c=7.45793e-17
C32 (\1\:D VSS) capacitor c=5.04424e-17
C33 (\1\:CK VSS) capacitor c=3.20273e-17
C34 (\13\:qbint VSS) capacitor c=3.0927e-17
C35 (\5\:n35 VSS) capacitor c=4.03456e-17
C36 (\3\:qbint VSS) capacitor c=2.89223e-17
C37 (\4\:SN VSS) capacitor c=2.70533e-17
C38 (\6\:SN VSS) capacitor c=4.07998e-17
C39 (\2\:n20 VSS) capacitor c=5.00368e-17
C40 (\10\:CKb VSS) capacitor c=4.46575e-17
C41 (\7\:CKbb VSS) capacitor c=2.82796e-17
C42 (\6\:CKb VSS) capacitor c=5.95055e-17
C43 (\3\:D VSS) capacitor c=5.76639e-17
C44 (\3\:CK VSS) capacitor c=5.54813e-17
C45 (\14\:qbint VSS) capacitor c=2.58231e-17
C46 (\6\:net331 VSS) capacitor c=2.43189e-17
C47 (\4\:n35 VSS) capacitor c=4.11739e-17
C48 (\2\:SN VSS) capacitor c=1.36954e-17
C49 (\3\:n20 VSS) capacitor c=2.58938e-17
C50 (\2\:n35 VSS) capacitor c=3.55204e-17
C51 (\11\:CKb VSS) capacitor c=2.07114e-17
C52 (\9\:CKb VSS) capacitor c=4.15673e-17
C53 (\6\:CKbb VSS) capacitor c=4.15233e-17
C54 (\7\:CKb VSS) capacitor c=1.59565e-17
C55 (\2\:mout VSS) capacitor c=5.95976e-17
C56 (\2\:CKbb VSS) capacitor c=7.28928e-17
C57 (\4\:CKb VSS) capacitor c=4.384e-17
C58 (\2\:CKb VSS) capacitor c=3.26121e-17
C59 (\2\:D VSS) capacitor c=5.81796e-17
C60 (\2\:CK VSS) capacitor c=3.97265e-17
C61 (\8\:net331 VSS) capacitor c=1.52949e-17
C62 (\1\:VDD VSS) capacitor c=1.82596e-16
C63 (\3\:QN VSS) capacitor c=6.53482e-17
C64 (\3\:Q VSS) capacitor c=9.20584e-17
C65 (\19\:qbint VSS) capacitor c=5.46972e-17
C66 (\16\:VDD VSS) capacitor c=3.4014e-18
C67 (\18\:VDD VSS) capacitor c=2.17158e-17
C68 (\10\:mout VSS) capacitor c=6.73653e-17
C69 (\20\:VDD VSS) capacitor c=2.80918e-17
C70 (\3\:n41 VSS) capacitor c=1.8884e-16
C71 (\8\:n35 VSS) capacitor c=4.22578e-17
C72 (\8\:mout VSS) capacitor c=6.59718e-17
C73 (\8\:CKbb VSS) capacitor c=6.45368e-17
C74 (\22\:VDD VSS) capacitor c=2.59615e-17
C75 (\5\:n20 VSS) capacitor c=2.64801e-16
C76 (\25\:VDD VSS) capacitor c=3.68893e-17
C77 (\22\:CKb VSS) capacitor c=8.48524e-17
C78 (\3\:VDD VSS) capacitor c=1.21369e-16
C79 (\12\:net331 VSS) capacitor c=2.37366e-17
C80 (\1\:QN VSS) capacitor c=3.86739e-17
C81 (\1\:Q VSS) capacitor c=4.44855e-17
C82 (\23\:qbint VSS) capacitor c=6.70606e-18
C83 (\4\:mout VSS) capacitor c=9.0926e-17
C84 (\3\:n40 VSS) capacitor c=1.55089e-16
C85 (\10\:n35 VSS) capacitor c=5.18918e-17
C86 (\13\:mout VSS) capacitor c=9.69768e-17
C87 (\13\:CKbb VSS) capacitor c=3.77432e-17
C88 (\7\:n20 VSS) capacitor c=1.01252e-16
C89 (\17\:CKb VSS) capacitor c=8.69692e-17
C90 (\5\:CKbb VSS) capacitor c=7.05465e-17
C91 (\3\:SN VSS) capacitor c=2.97067e-17
C92 (\2\:qbint VSS) capacitor c=2.04278e-17
C93 (\4\:CK VSS) capacitor c=1.02124e-16
C94 (\4\:D VSS) capacitor c=6.4447e-17
C95 (\10\:CKbb VSS) capacitor c=5.20598e-17
C96 (\11\:CKbb VSS) capacitor c=3.15326e-17
C97 (\12\:CKbb VSS) capacitor c=4.0274e-17
C98 (\12\:CKb VSS) capacitor c=4.10306e-17
C99 (\13\:CKb VSS) capacitor c=8.86389e-17
C100 (\14\:CKb VSS) capacitor c=8.76513e-17
C101 (\15\:CKb VSS) capacitor c=8.76631e-17
C102 (\16\:CKb VSS) capacitor c=6.29776e-17
C103 (\19\:CKb VSS) capacitor c=9.21536e-17
C104 (\20\:CKb VSS) capacitor c=6.82398e-17
C105 (\21\:CKb VSS) capacitor c=3.47279e-17
C106 (\6\:n35 VSS) capacitor c=4.34479e-17
C107 (\7\:n35 VSS) capacitor c=5.42912e-17
C108 (\4\:n20 VSS) capacitor c=2.54471e-16
C109 (\6\:mout VSS) capacitor c=1.66148e-16
C110 (\7\:mout VSS) capacitor c=1.63048e-16
C111 (\12\:mout VSS) capacitor c=1.02675e-16
C112 (\7\:SN VSS) capacitor c=4.25284e-17
C113 (\12\:n35 VSS) capacitor c=1.65964e-16
C114 (\13\:n35 VSS) capacitor c=1.55217e-16
C115 (\15\:qbint VSS) capacitor c=7.93394e-17
C116 (\22\:qbint VSS) capacitor c=4.39506e-17
C117 (\25\:qbint VSS) capacitor c=5.12359e-17
C118 (\10\:net331 VSS) capacitor c=1.64324e-17
C119 (\11\:net331 VSS) capacitor c=2.98096e-17
C120 (\7\:VDD VSS) capacitor c=6.46304e-18
C121 (\9\:VDD VSS) capacitor c=9.32442e-18
C122 (\10\:VDD VSS) capacitor c=7.73065e-17
C123 (\24\:VDD VSS) capacitor c=1.15338e-17
Rk29 (SN \7\:SN) resistor r=0.1409 c=0
Rk4 (D \4\:D) resistor r=0.2249 c=0
Rk33 (Q \2\:Q) resistor r=0.04657 c=0
Rk34 (Q \4\:Q) resistor r=0.2579 c=0
Rk65 (\1\:VDD \7\:VDD) resistor r=0.323 c=0
Rk66 (\7\:VDD \8\:VDD) resistor r=0.1176 c=0
Rk67 (\8\:VDD \9\:VDD) resistor r=0.06749 c=0
Rk68 (\9\:VDD \10\:VDD) resistor r=0.2469 c=0
Rk69 (\10\:VDD \11\:VDD) resistor r=0.8863 c=0
Rk72 (\7\:VDD \17\:VDD) resistor r=0.07369 c=0
Rk73 (\9\:VDD \19\:VDD) resistor r=0.07369 c=0
Rk74 (\10\:VDD \21\:VDD) resistor r=0.04329 c=0
Rk75 (\11\:VDD \23\:VDD) resistor r=0.1199 c=0
Rk78 (\24\:VDD VDD) resistor r=0.17 c=0
Rk76 (\11\:VDD \24\:VDD) resistor r=0.3815 c=0
Rk77 (\24\:VDD \26\:VDD) resistor r=0.278 c=0
Rk35 (QN \2\:QN) resistor r=0.148 c=0
Rk36 (QN \4\:QN) resistor r=0.1439 c=0
Rk51 (\1\:VSS \7\:VSS) resistor r=0.4225 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.08755 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.9964 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.1167 c=0
Rk56 (\11\:VSS VSS) resistor r=0.1851 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.3658 c=0
Rk59 (\8\:VSS \17\:VSS) resistor r=0.1757 c=0
Rk60 (\9\:VSS \19\:VSS) resistor r=0.04329 c=0
Rk61 (\11\:VSS \21\:VSS) resistor r=0.07369 c=0
Rk3 (\4\:CK CK) resistor r=0.02399 c=0
Rk9 (\12\:CKb \13\:CKb) resistor r=0.2417 c=0
Rk10 (\13\:CKb \14\:CKb) resistor r=0.2832 c=0
Rk11 (\14\:CKb \15\:CKb) resistor r=0.4317 c=0
Rk12 (\15\:CKb \16\:CKb) resistor r=0.3932 c=0
Rk13 (\16\:CKb \18\:CKb) resistor r=0.2812 c=0
Rk14 (\13\:CKb \19\:CKb) resistor r=0.4522 c=0
Rk15 (\15\:CKb \20\:CKb) resistor r=0.4098 c=0
Rk16 (\16\:CKb \21\:CKb) resistor r=0.1506 c=0
Rk17 (\18\:CKb \23\:CKb) resistor r=0.6737 c=0
Rk21 (\4\:n20 \6\:n20) resistor r=1.9336 c=0
Rk22 (\6\:n20 \8\:n20) resistor r=0.5353 c=0
Rk5 (\9\:CKbb \10\:CKbb) resistor r=0.3033 c=0
Rk6 (\10\:CKbb \11\:CKbb) resistor r=0.05166 c=0
Rk7 (\11\:CKbb \12\:CKbb) resistor r=0.2773 c=0
Rk8 (\11\:CKbb \14\:CKbb) resistor r=0.1516 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.5134 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.8443 c=0
Rk25 (\7\:mout \9\:mout) resistor r=0.09108 c=0
Rk26 (\6\:mout \11\:mout) resistor r=0.3492 c=0
Rk27 (\7\:mout \12\:mout) resistor r=0.688 c=0
Rk28 (\9\:mout \14\:mout) resistor r=0.4996 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=0.2192 c=0
Rk19 (\7\:n35 \9\:n35) resistor r=0.1631 c=0
Rk20 (\7\:n35 \11\:n35) resistor r=0.2237 c=0
Rk32 (\12\:n35 \13\:n35) resistor r=1.2306 c=0
Rk31 (\2\:n40 \4\:n40) resistor r=1.2924 c=0
Rk37 (\15\:qbint \5\:qbint) resistor r=0.5781 c=0
Rk40 (\5\:qbint \20\:qbint) resistor r=0.2836 c=0
Rk42 (\5\:qbint \22\:qbint) resistor r=0.1755 c=0
Rk43 (\22\:qbint \24\:qbint) resistor r=0.0311 c=0
Rk44 (\22\:qbint \25\:qbint) resistor r=0.2746 c=0
Rk45 (\9\:net331 \10\:net331) resistor r=0.1307 c=0
Rk46 (\10\:net331 \11\:net331) resistor r=0.1502 c=0
Rk47 (\10\:net331 \13\:net331) resistor r=0.1258 c=0
Rk30 (\2\:n41 \4\:n41) resistor r=1.2004 c=0
Rl21 (\1\:SN \2\:SN) resistor r=38.4089 c=0
Rl24 (\2\:SN \5\:SN) resistor r=76.129 c=0
Rl23 (\3\:SN \4\:SN) resistor r=66.8341 c=0
Rl25 (\3\:SN \6\:SN) resistor r=132.899 c=0
Rl22 (\2\:SN \3\:SN) resistor r=6.662 c=0
Rl3 (\1\:D \2\:D) resistor r=156.832 c=0
Rl4 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl1 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl2 (\2\:CK \3\:CK) resistor r=168 c=0
Rl11 (\5\:CKb \6\:CKb) resistor r=223.077 c=0
Rl17 (\10\:CKb \11\:CKb) resistor r=98.7687 c=0
Rl13 (\8\:CKb \9\:CKb) resistor r=49.2328 c=0
Rl12 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=71.8456 c=0
Rl5 (CKb \2\:CKb) resistor r=37.2302 c=0
Rl19 (n20 \2\:n20) resistor r=150 c=0
Rl20 (n20 \3\:n20) resistor r=80.0021 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=266.851 c=0
Rl7 (CKbb \2\:CKbb) resistor r=54.579 c=0
Rl14 (\4\:CKbb \5\:CKbb) resistor r=153.39 c=0
Rl16 (\5\:CKbb \7\:CKbb) resistor r=30.4507 c=0
Rl15 (\5\:CKbb \6\:CKbb) resistor r=130.695 c=0
Rl10 (\2\:mout \3\:mout) resistor r=98.0541 c=0
Rl9 (mout \2\:mout) resistor r=153.641 c=0
Rl29 (\3\:n35 \4\:n35) resistor r=56.1378 c=0
Rl30 (\4\:n35 \5\:n35) resistor r=51.7711 c=0
Rl18 (n35 \2\:n35) resistor r=143.691 c=0
Rl42 (\13\:qbint \12\:qbint) resistor r=92.3077 c=0
Rl43 (\14\:qbint \13\:qbint) resistor r=48.608 c=0
Rl28 (\2\:qbint \4\:qbint) resistor r=97.7911 c=0
Rl27 (\2\:qbint \3\:qbint) resistor r=43.9449 c=0
Rl26 (\2\:qbint qbint) resistor r=5.915 c=0
Rl40 (net331 \6\:net331) resistor r=12.8462 c=0
Rz9 (\2\:Q \1\:Q) resistor r=75 c=0
Rz19 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz20 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz21 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz10 (\2\:QN \1\:QN) resistor r=75 c=0
Rz16 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz18 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz2 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz1 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz5 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz3 (\10\:n35 \11\:n35) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz12 (\13\:net331 \12\:net331) resistor r=75 c=0
Ry9 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry19 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry23 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry10 (\4\:QN \3\:QN) resistor r=20.6667 c=0
Ry13 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry14 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry2 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry4 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry1 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\10\:mout \11\:mout) resistor r=62 c=0
Ry3 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry11 (\20\:qbint \19\:qbint) resistor r=62 c=0
Ry12 (\9\:net331 \8\:net331) resistor r=62 c=0
Ry7 (n41 \2\:n41) resistor r=62 c=0
Ry8 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx13 (\2\:SN \7\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx5 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \20\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \21\:CKb) resistor r=45 c=0
Rx11 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx3 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx4 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx12 (\2\:mout \12\:mout) resistor r=45 c=0
Rx10 (\2\:n35 \6\:n35) resistor r=45 c=0
Rx14 (\4\:n35 \12\:n35) resistor r=45 c=0
Rx15 (n35 \13\:n35) resistor r=45 c=0
Rx16 (\15\:qbint \14\:qbint) resistor r=45 c=0
Rx19 (\25\:qbint qbint) resistor r=45 c=0
Rx20 (\11\:net331 \6\:net331) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.637e-14 ad=2.03e-14 ps=1.36e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn25 (n21 \3\:D \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.637e-14 ad=8.7e-15 ps=1.36e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.17e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn26 (\7\:n20 CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=8.41e-14 ps=4.1e-07 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.065e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn35 (\7\:n20 CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=8.41e-14 ps=4.1e-07 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=4.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn36 (n30 mout \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=8.7e-15 ps=1.35e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=3.35e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn21 (\13\:CKbb \6\:CKb \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.565e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn40 (\10\:n35 \7\:CKbb \13\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn52 (\10\:n35 \10\:CKb \3\:n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn31 (\4\:mout \2\:n20 n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn30 (n25 \6\:SN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.668e-14 ps=1.05e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=6.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn50 (n42 \4\:SN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.9e-14 ps=1.05e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.85e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn51 (n40 \3\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn56 (\12\:net331 \13\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=6.562e-14 ad=2.03e-14 ps=1.71e-06 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\23\:qbint \5\:n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.285e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38512e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\1\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.0593e-13 ad=5.46e-14 ps=1.69e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55288e-07 sb=1.07673e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN net331 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.231e-14 ad=4.16e-14 ps=1.745e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65288e-07 sb=4.66731e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\19\:qbint \3\:n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24129e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.925e-14 ad=7.995e-14 ps=1.25e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.94744e-07 sb=1.06987e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57_1__rcx (\3\:QN net331 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.124e-14 ad=6.24e-14 ps=1.295e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99744e-07 sb=4.64872e-07 sd=160n sca=30.8584 \
        scb=0.020306 scc=0.00336099 m=(2)
ends DFFSX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:54 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSX4
// View name: extracted

simulator lang=spectre

subckt DFFSX4 CK D Q QN SN VDD VSS
mp20 (\15\:CKb \3\:CK \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=4.837e-14 ps=1.03e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.84733e-06 sd=160n sca=25.0615 \
        scb=0.0281532 scc=0.00173703 m=(1)
mp25 (n22 \1\:D \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.44e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.50233e-06 sd=160n sca=19.0383 \
        scb=0.0183896 scc=0.00142445 m=(1)
mp26 (\8\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.29733e-06 sd=160n sca=18.2092 \
        scb=0.0178429 scc=0.00142384 m=(1)
mp36 (\8\:n20 \3\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.09233e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (n31 \3\:mout \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=9.07326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp31 (\8\:mout \3\:n20 \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=6.42326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\8\:mout \1\:SN \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=3.87326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp21 (\14\:CKbb \8\:CKb \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.71e-14 ad=2.63e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=1.22326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\10\:n35 \9\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24186e-07 sb=3.5e-07 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp52 (\10\:n35 \7\:CKbb \3\:n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.34186e-07 sb=1.4e-07 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp51 (n41 qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.255e-14 ad=3.44e-14 ps=1.37e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp50 (n41 \4\:SN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.647e-14 ad=3.44e-14 ps=1.15e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
C1 (SN VSS) capacitor c=1.61656e-16
C2 (Q VSS) capacitor c=2.53199e-17
C3 (D VSS) capacitor c=6.20526e-17
C4 (QN VSS) capacitor c=1.26179e-17
C5 (VDD VSS) capacitor c=3.7661e-16
C6 (CKb VSS) capacitor c=4.80763e-17
C7 (n20 VSS) capacitor c=4.31262e-17
C8 (n30 VSS) capacitor c=2.74938e-18
C9 (CKbb VSS) capacitor c=2.80653e-17
C10 (mout VSS) capacitor c=4.82387e-17
C11 (n25 VSS) capacitor c=3.61404e-18
C12 (n35 VSS) capacitor c=1.80801e-16
C13 (n40 VSS) capacitor c=1.87763e-18
C14 (qbint VSS) capacitor c=5.44642e-17
C15 (net331 VSS) capacitor c=2.68121e-16
C16 (n22 VSS) capacitor c=3.00795e-18
C17 (n41 VSS) capacitor c=9.56637e-17
C18 (\20\:qbint VSS) capacitor c=4.4716e-17
C19 (\4\:qbint VSS) capacitor c=2.50711e-16
C20 (\4\:SN VSS) capacitor c=4.28001e-17
C21 (\7\:CKbb VSS) capacitor c=4.76929e-17
C22 (\9\:CKb VSS) capacitor c=3.87009e-17
C23 (\8\:CKb VSS) capacitor c=4.44114e-17
C24 (\1\:SN VSS) capacitor c=6.60852e-17
C25 (\3\:n20 VSS) capacitor c=4.01723e-17
C26 (\3\:mout VSS) capacitor c=5.7818e-17
C27 (\3\:CKb VSS) capacitor c=4.93022e-17
C28 (\3\:CKbb VSS) capacitor c=7.76138e-17
C29 (\1\:D VSS) capacitor c=3.1159e-17
C30 (\3\:CK VSS) capacitor c=2.09056e-17
C31 (\18\:qbint VSS) capacitor c=2.80148e-17
C32 (\6\:SN VSS) capacitor c=6.75225e-17
C33 (\3\:qbint VSS) capacitor c=3.92661e-17
C34 (\5\:CKb VSS) capacitor c=7.98918e-17
C35 (\4\:CKbb VSS) capacitor c=4.22763e-17
C36 (\6\:CKb VSS) capacitor c=6.57967e-17
C37 (\2\:SN VSS) capacitor c=3.4709e-17
C38 (\3\:D VSS) capacitor c=6.69805e-17
C39 (\1\:CK VSS) capacitor c=4.60208e-17
C40 (\19\:qbint VSS) capacitor c=4.1617e-17
C41 (\6\:n35 VSS) capacitor c=1.05376e-17
C42 (\5\:SN VSS) capacitor c=6.41586e-17
C43 (\2\:qbint VSS) capacitor c=4.92227e-17
C44 (\6\:CKbb VSS) capacitor c=2.72448e-17
C45 (\10\:CKb VSS) capacitor c=1.61872e-17
C46 (\3\:SN VSS) capacitor c=2.06198e-17
C47 (\2\:n20 VSS) capacitor c=4.63214e-17
C48 (\2\:mout VSS) capacitor c=5.70587e-17
C49 (\2\:CKbb VSS) capacitor c=6.81264e-17
C50 (\4\:CKb VSS) capacitor c=2.33503e-17
C51 (\2\:CKb VSS) capacitor c=5.07811e-17
C52 (\2\:D VSS) capacitor c=5.02414e-17
C53 (\2\:CK VSS) capacitor c=3.9862e-17
C54 (\20\:net331 VSS) capacitor c=3.06606e-17
C55 (\1\:VDD VSS) capacitor c=4.50973e-16
C56 (\1\:Q VSS) capacitor c=1.5989e-16
C57 (\27\:qbint VSS) capacitor c=6.55567e-17
C58 (\26\:VDD VSS) capacitor c=1.93944e-17
C59 (\3\:n41 VSS) capacitor c=8.01478e-17
C60 (\10\:n35 VSS) capacitor c=4.77662e-17
C61 (\6\:mout VSS) capacitor c=1.37522e-16
C62 (\14\:CKbb VSS) capacitor c=4.19808e-17
C63 (\28\:VDD VSS) capacitor c=2.42317e-17
C64 (\8\:mout VSS) capacitor c=9.97639e-17
C65 (\30\:VDD VSS) capacitor c=2.05798e-17
C66 (\8\:n20 VSS) capacitor c=2.89628e-17
C67 (\32\:VDD VSS) capacitor c=5.22489e-17
C68 (\15\:CKb VSS) capacitor c=5.65607e-17
C69 (\3\:VDD VSS) capacitor c=7.31603e-17
C70 (\16\:net331 VSS) capacitor c=3.33321e-17
C71 (\1\:QN VSS) capacitor c=8.73462e-17
C72 (\29\:qbint VSS) capacitor c=2.06954e-17
C73 (\12\:n35 VSS) capacitor c=8.77201e-17
C74 (\4\:mout VSS) capacitor c=1.2753e-16
C75 (\12\:CKbb VSS) capacitor c=2.22356e-17
C76 (\11\:mout VSS) capacitor c=3.06091e-17
C77 (\6\:n20 VSS) capacitor c=7.28213e-17
C78 (\17\:CKb VSS) capacitor c=1.933e-17
C79 (\5\:CKbb VSS) capacitor c=3.15235e-17
C80 (\7\:CKb VSS) capacitor c=5.09209e-17
C81 (\4\:CK VSS) capacitor c=6.43401e-17
C82 (\5\:CK VSS) capacitor c=5.16264e-17
C83 (\4\:D VSS) capacitor c=6.28157e-17
C84 (\4\:n20 VSS) capacitor c=5.60763e-17
C85 (\5\:n20 VSS) capacitor c=7.74768e-17
C86 (\11\:CKb VSS) capacitor c=1.04833e-16
C87 (\12\:CKb VSS) capacitor c=1.44974e-16
C88 (\13\:CKb VSS) capacitor c=1.55248e-16
C89 (\14\:CKb VSS) capacitor c=9.82358e-17
C90 (\8\:CKbb VSS) capacitor c=4.16166e-17
C91 (\9\:CKbb VSS) capacitor c=2.83473e-17
C92 (\10\:CKbb VSS) capacitor c=1.1159e-16
C93 (\11\:CKbb VSS) capacitor c=1.28092e-16
C94 (\10\:mout VSS) capacitor c=5.72782e-17
C95 (\13\:mout VSS) capacitor c=3.63018e-17
C96 (\7\:SN VSS) capacitor c=6.97404e-17
C97 (\8\:SN VSS) capacitor c=1.47328e-16
C98 (\8\:n35 VSS) capacitor c=1.25044e-16
C99 (\9\:n35 VSS) capacitor c=1.58729e-16
C100 (\4\:Q VSS) capacitor c=1.09579e-16
C101 (\5\:QN VSS) capacitor c=1.72877e-16
C102 (\21\:qbint VSS) capacitor c=2.25381e-16
C103 (\22\:qbint VSS) capacitor c=1.85102e-16
C104 (\23\:qbint VSS) capacitor c=3.03812e-17
C105 (\24\:qbint VSS) capacitor c=4.32722e-17
C106 (\25\:qbint VSS) capacitor c=5.78195e-17
C107 (\26\:qbint VSS) capacitor c=3.3016e-17
C108 (\18\:net331 VSS) capacitor c=4.04509e-17
C109 (\19\:net331 VSS) capacitor c=4.89001e-17
C110 (\11\:VDD VSS) capacitor c=2.8387e-17
C111 (\12\:VDD VSS) capacitor c=4.2812e-17
C112 (\13\:VDD VSS) capacitor c=1.19887e-17
C113 (\15\:VDD VSS) capacitor c=2.09147e-17
Rk23 (\7\:SN SN) resistor r=0.3441 c=0
Rk24 (SN \8\:SN) resistor r=1.2331 c=0
Rk30 (\1\:Q Q) resistor r=0.07275 c=0
Rk31 (Q \4\:Q) resistor r=0.1621 c=0
Rk4 (\4\:D D) resistor r=0.04146 c=0
Rk36 (\1\:QN QN) resistor r=0.04298 c=0
Rk37 (QN \5\:QN) resistor r=0.1878 c=0
Rk55 (\1\:VSS \9\:VSS) resistor r=0.7369 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.3647 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.09913 c=0
Rk59 (\12\:VSS VSS) resistor r=0.1851 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.3658 c=0
Rk65 (\9\:VSS \24\:VSS) resistor r=0.127 c=0
Rk66 (\10\:VSS \26\:VSS) resistor r=0.04329 c=0
Rk67 (\12\:VSS \28\:VSS) resistor r=0.1762 c=0
Rk74 (\1\:VDD \10\:VDD) resistor r=0.05245 c=0
Rk75 (\10\:VDD \11\:VDD) resistor r=0.1753 c=0
Rk76 (\11\:VDD \12\:VDD) resistor r=0.6831 c=0
Rk77 (\12\:VDD \13\:VDD) resistor r=0.2594 c=0
Rk78 (\13\:VDD \14\:VDD) resistor r=0.08253 c=0
Rk80 (\15\:VDD VDD) resistor r=0.2177 c=0
Rk79 (\14\:VDD \15\:VDD) resistor r=0.3332 c=0
Rk86 (\11\:VDD \27\:VDD) resistor r=0.1024 c=0
Rk87 (\12\:VDD \29\:VDD) resistor r=0.04329 c=0
Rk88 (\13\:VDD \31\:VDD) resistor r=0.07369 c=0
Rk89 (\15\:VDD \33\:VDD) resistor r=0.3502 c=0
Rk1 (CK \4\:CK) resistor r=0.001952 c=0
Rk3 (\4\:CK \5\:CK) resistor r=0.02435 c=0
Rk2 (\5\:CK \6\:CK) resistor r=0.002019 c=0
Rk8 (\11\:CKb \12\:CKb) resistor r=0.7005 c=0
Rk9 (\12\:CKb \13\:CKb) resistor r=0.6671 c=0
Rk10 (\13\:CKb \14\:CKb) resistor r=0.499 c=0
Rk11 (\14\:CKb \16\:CKb) resistor r=0.6031 c=0
Rk12 (\14\:CKb \18\:CKb) resistor r=0.097 c=0
Rk5 (\4\:n20 \5\:n20) resistor r=0.3443 c=0
Rk6 (\5\:n20 \7\:n20) resistor r=0.4427 c=0
Rk7 (\5\:n20 \9\:n20) resistor r=0.1307 c=0
Rk13 (\8\:CKbb \9\:CKbb) resistor r=0.1202 c=0
Rk14 (\9\:CKbb \10\:CKbb) resistor r=0.2222 c=0
Rk15 (\10\:CKbb \11\:CKbb) resistor r=1.0275 c=0
Rk16 (\9\:CKbb \13\:CKbb) resistor r=0.1155 c=0
Rk17 (\10\:CKbb \15\:CKbb) resistor r=0.1664 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.7392 c=0
Rk19 (\7\:mout \9\:mout) resistor r=0.6137 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.3339 c=0
Rk21 (\10\:mout \12\:mout) resistor r=0.07479 c=0
Rk22 (\10\:mout \13\:mout) resistor r=0.1825 c=0
Rk26 (\8\:n35 \9\:n35) resistor r=0.8385 c=0
Rk27 (\9\:n35 \11\:n35) resistor r=0.2583 c=0
Rk28 (\9\:n35 \13\:n35) resistor r=0.4121 c=0
Rk40 (\21\:qbint \22\:qbint) resistor r=1.8272 c=0
Rk41 (\22\:qbint \23\:qbint) resistor r=0.09741 c=0
Rk42 (\23\:qbint \24\:qbint) resistor r=0.1601 c=0
Rk43 (\24\:qbint \25\:qbint) resistor r=0.3388 c=0
Rk44 (\22\:qbint \26\:qbint) resistor r=0.1025 c=0
Rk45 (\23\:qbint \28\:qbint) resistor r=0.28 c=0
Rk46 (\24\:qbint \30\:qbint) resistor r=0.06442 c=0
Rk47 (\17\:net331 \18\:net331) resistor r=0.3792 c=0
Rk48 (\18\:net331 \19\:net331) resistor r=0.271 c=0
Rk49 (\18\:net331 \21\:net331) resistor r=0.097 c=0
Rk25 (\2\:n41 \4\:n41) resistor r=0.3958 c=0
Rl13 (\1\:SN \2\:SN) resistor r=151.489 c=0
Rl25 (\4\:SN \5\:SN) resistor r=69.208 c=0
Rl26 (\5\:SN \6\:SN) resistor r=95.9489 c=0
Rl14 (\2\:SN \3\:SN) resistor r=24.2328 c=0
Rl3 (\1\:D \2\:D) resistor r=50.6918 c=0
Rl4 (\2\:D \3\:D) resistor r=164.153 c=0
Rl2 (\2\:CK \3\:CK) resistor r=26.3736 c=0
Rl1 (\1\:CK \2\:CK) resistor r=190.385 c=0
