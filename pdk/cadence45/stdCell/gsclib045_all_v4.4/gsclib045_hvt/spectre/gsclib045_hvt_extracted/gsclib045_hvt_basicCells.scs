        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn25 (\4\:Db \10\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn21 (\10\:CKbb \11\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.025e-14 ad=2.03e-14 ps=1.39e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn20 (\22\:CKb \3\:CK \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.63793e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn11 (n0 \1\:D \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.755e-14 ps=1.35e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01034e-07 sb=1.035e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.36034e-07 sb=8e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn14 (Db \3\:SE n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.41034e-07 sb=5.95e-07 sd=160n sca=10.2779 scb=0.00944477 \
        scc=0.000275883 m=(1)
mn13 (n2 \1\:SI \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=8.7e-15 ps=8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.46034e-07 sb=4.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\8\:SEb \5\:SE \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.755e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14603e-06 sb=1.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp56 (\5\:net573 \7\:qbint \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9828 \
        scb=0.0290392 scc=0.00588499 m=(1)
mp22 (\10\:RNb \1\:RN \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp45 (\16\:qbint \4\:n35 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp50 (\3\:n11 \1\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=3.44e-14 ps=1.78e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.75e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp52 (\3\:n11 \8\:qbint n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.7e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp51 (n9 \2\:RNb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.777e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.65e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp53 (\9\:n35 \5\:CKbb n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.762e-14 ps=1.06e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.6e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\9\:n35 \5\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (n5 \5\:RNb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=3.762e-14 ps=2.18e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59302e-07 sb=9.68605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp32 (\10\:mout n20 n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.79302e-07 sb=7.48605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp30 (\10\:mout \5\:SN \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.84302e-07 sb=5.43605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp35 (n7 mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.675e-14 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.63953e-07 sb=4.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp36 (\9\:n20 \7\:CKb n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.68953e-07 sb=3.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp25 (\9\:n20 CKbb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.73953e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp21 (\7\:CKbb \8\:CKb \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.65e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp20 (\14\:CKb \1\:CK \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.73e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26977e-07 sb=1.32e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp11 (n1 \4\:D \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.623e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.31977e-07 sb=1.115e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp12 (\6\:Db \1\:SE n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.44e-14 ps=8.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91977e-07 sb=8.55e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp14 (\6\:Db SEb n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.96977e-07 sb=6.5e-07 sd=160n sca=10.7789 \
        scb=0.00808417 scc=0.000111767 m=(1)
mp13 (n3 \3\:SI \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.548e-14 ps=9.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00698e-06 sb=4.4e-07 sd=160n sca=11.6546 \
        scb=0.0086845 scc=0.000112508 m=(1)
mp10 (\4\:SEb \7\:SE \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.30698e-06 sb=1.4e-07 sd=160n sca=16.2189 \
        scb=0.016045 scc=0.000282872 m=(1)
ends SDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:56 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRX2
// View name: extracted

simulator lang=spectre

subckt SDFFSRX2 CK D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.33372e-06 sd=160n sca=15.5538 \
        scb=0.0148381 scc=0.000219117 m=(1)
mp13 (n3 \1\:SI \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.02e-14 ps=7.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.12872e-06 sd=160n sca=11.9632 \
        scb=0.00880681 scc=7.89905e-05 m=(1)
mp14 (\9\:Db \3\:SEb n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=5.405e-14 ps=9.9e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.03721e-07 sd=160n sca=10.3677 \
        scb=0.00742953 scc=7.53776e-05 m=(1)
mp12 (\9\:Db \6\:SE n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.405e-14 ps=5.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.95814e-07 sb=6.8e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (n1 \1\:D \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=1.29e-14 ps=1.21e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.00814e-07 sb=5.75e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp20 (\16\:CKb \1\:CK \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33581e-06 sb=1.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp21 (\12\:CKbb \7\:CKb \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.565e-14 ad=2.63e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\7\:n20 CKbb \7\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.63e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.2414e-06 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp36 (\7\:n20 CKb n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.77326e-07 sb=9.86395e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp35 (n7 \3\:mout \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.745e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.82326e-07 sb=8.81395e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp30 (\13\:mout \3\:SN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.745e-14 ad=7.74e-14 ps=1.7e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.96512e-07 sb=6.8e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp32 (\13\:mout \3\:n20 n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.74e-14 ps=5.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10151e-06 sb=2.75e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp31 (n5 \4\:RNb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.775e-14 ad=1.29e-14 ps=1.29e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20651e-06 sb=1.7e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\8\:n35 \8\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (\8\:n35 \5\:CKbb \3\:n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n9 \2\:RNb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.765e-14 ad=2.0102e-13 ps=1.48e-06 pd=2.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.72e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp52 (n11 \3\:qbint n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.0102e-13 ad=3.763e-14 ps=2.3e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=7.4e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n11 \6\:SN \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.267e-13 ad=3.763e-14 ps=1.94e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=5.2e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp22 (\9\:RNb \1\:RN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09523e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp56 (\11\:net573 \11\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.11558e-06 sb=1.4e-07 sd=160n \
        sca=41.2633 scb=0.0315497 scc=0.00492372 m=(1)
C1 (D VSS) capacitor c=3.73808e-17
C2 (RN VSS) capacitor c=8.39913e-17
C3 (SN VSS) capacitor c=7.37355e-17
C4 (Q VSS) capacitor c=1.72562e-17
C5 (SI VSS) capacitor c=1.15588e-16
C6 (QN VSS) capacitor c=3.69025e-17
C7 (VDD VSS) capacitor c=6.45308e-16
C8 (CK VSS) capacitor c=5.18385e-17
C9 (SEb VSS) capacitor c=5.40503e-17
C10 (n2 VSS) capacitor c=1.45178e-18
C11 (Db VSS) capacitor c=9.66745e-17
C12 (n0 VSS) capacitor c=2.62602e-18
C13 (CKb VSS) capacitor c=6.00254e-17
C14 (CKbb VSS) capacitor c=3.60113e-17
C15 (n20 VSS) capacitor c=4.95733e-17
C16 (n6 VSS) capacitor c=2.29239e-18
C17 (mout VSS) capacitor c=5.70737e-17
C18 (n4 VSS) capacitor c=6.3555e-17
C19 (RNb VSS) capacitor c=1.04377e-16
C20 (n35 VSS) capacitor c=4.38144e-17
C21 (n10 VSS) capacitor c=1.15867e-16
C22 (n8 VSS) capacitor c=8.59808e-17
C23 (qbint VSS) capacitor c=3.21556e-17
C24 (net573 VSS) capacitor c=1.65389e-16
C25 (n7 VSS) capacitor c=1.61783e-18
C26 (n5 VSS) capacitor c=8.79766e-19
C27 (n11 VSS) capacitor c=2.27586e-16
C28 (n9 VSS) capacitor c=3.51749e-17
C29 (\11\:qbint VSS) capacitor c=6.23694e-17
C30 (\5\:qbint VSS) capacitor c=4.15511e-16
C31 (\1\:RN VSS) capacitor c=3.8042e-17
C32 (\3\:n35 VSS) capacitor c=3.62457e-17
C33 (\6\:SN VSS) capacitor c=6.05843e-17
C34 (\3\:qbint VSS) capacitor c=6.25437e-17
C35 (\2\:RNb VSS) capacitor c=1.00561e-16
C36 (\5\:CKbb VSS) capacitor c=7.06731e-17
C37 (\8\:CKb VSS) capacitor c=3.85932e-17
C38 (\4\:RNb VSS) capacitor c=1.49963e-16
C39 (\3\:n20 VSS) capacitor c=7.2864e-17
C40 (\3\:SN VSS) capacitor c=3.61546e-17
C41 (\3\:mout VSS) capacitor c=5.99079e-17
C42 (\7\:CKb VSS) capacitor c=2.61775e-17
C43 (\1\:CK VSS) capacitor c=4.50318e-17
C44 (\1\:D VSS) capacitor c=8.11875e-17
C45 (\6\:SE VSS) capacitor c=6.3598e-17
C46 (\3\:SEb VSS) capacitor c=4.29327e-17
C47 (\1\:SI VSS) capacitor c=4.66291e-17
C48 (\1\:SE VSS) capacitor c=5.84887e-17
C49 (\12\:qbint VSS) capacitor c=2.36183e-17
C50 (\3\:RN VSS) capacitor c=4.74355e-17
C51 (\5\:SN VSS) capacitor c=8.55261e-17
C52 (\10\:CKb VSS) capacitor c=4.77723e-17
C53 (\6\:CKbb VSS) capacitor c=9.83268e-17
C54 (\6\:RNb VSS) capacitor c=6.71917e-17
C55 (\1\:SN VSS) capacitor c=2.84306e-17
C56 (\3\:CKbb VSS) capacitor c=5.35365e-17
C57 (\5\:CKb VSS) capacitor c=3.62922e-17
C58 (\6\:CKb VSS) capacitor c=1.43435e-17
C59 (\3\:CK VSS) capacitor c=2.04394e-17
C60 (\3\:D VSS) capacitor c=2.49951e-17
C61 (\4\:SE VSS) capacitor c=4.19704e-17
C62 (\3\:SI VSS) capacitor c=4.55644e-17
C63 (\3\:SE VSS) capacitor c=2.37718e-17
C64 (\13\:qbint VSS) capacitor c=1.88704e-17
C65 (\2\:RN VSS) capacitor c=3.11771e-17
C66 (\2\:n35 VSS) capacitor c=3.51231e-17
C67 (\4\:qbint VSS) capacitor c=2.79948e-17
C68 (\7\:SN VSS) capacitor c=3.01527e-17
C69 (\5\:RNb VSS) capacitor c=3.38457e-17
C70 (\11\:CKb VSS) capacitor c=3.35285e-17
C71 (\9\:CKb VSS) capacitor c=3.58685e-17
C72 (\2\:n20 VSS) capacitor c=4.67909e-17
C73 (\7\:CKbb VSS) capacitor c=6.67059e-17
C74 (\4\:SN VSS) capacitor c=2.33122e-17
C75 (\2\:SN VSS) capacitor c=3.62868e-17
C76 (\2\:mout VSS) capacitor c=6.291e-17
C77 (\2\:CKb VSS) capacitor c=5.51665e-17
C78 (\4\:CKbb VSS) capacitor c=2.29007e-17
C79 (\2\:CKbb VSS) capacitor c=3.45275e-17
C80 (\4\:CKb VSS) capacitor c=2.26373e-17
C81 (\2\:CK VSS) capacitor c=3.91178e-17
C82 (\2\:D VSS) capacitor c=4.60507e-17
C83 (\7\:SE VSS) capacitor c=4.42834e-17
C84 (\2\:SEb VSS) capacitor c=6.6701e-17
C85 (\5\:SE VSS) capacitor c=5.11969e-17
C86 (\2\:SI VSS) capacitor c=5.78919e-17
C87 (\2\:SE VSS) capacitor c=5.16533e-17
C88 (\11\:net573 VSS) capacitor c=1.75078e-17
C89 (\1\:VDD VSS) capacitor c=2.14752e-16
C90 (\1\:QN VSS) capacitor c=7.94382e-17
C91 (\3\:Q VSS) capacitor c=7.7413e-17
C92 (\9\:RNb VSS) capacitor c=2.96135e-16
C93 (\23\:qbint VSS) capacitor c=8.62017e-17
C94 (\21\:VDD VSS) capacitor c=1.70387e-17
C95 (\23\:VDD VSS) capacitor c=3.34421e-17
C96 (\3\:n11 VSS) capacitor c=2.01024e-16
C97 (\8\:n35 VSS) capacitor c=4.01624e-17
C98 (\6\:mout VSS) capacitor c=7.48635e-17
C99 (\25\:VDD VSS) capacitor c=3.60057e-17
C100 (\13\:mout VSS) capacitor c=3.85164e-17
C101 (\27\:VDD VSS) capacitor c=1.22802e-17
C102 (\7\:n20 VSS) capacitor c=8.75458e-17
C103 (\7\:Db VSS) capacitor c=2.99936e-17
C104 (\12\:CKbb VSS) capacitor c=5.65669e-17
C105 (\29\:VDD VSS) capacitor c=2.30647e-17
C106 (\16\:CKb VSS) capacitor c=6.37261e-17
C107 (\31\:VDD VSS) capacitor c=4.57189e-17
C108 (\9\:Db VSS) capacitor c=1.99223e-17
C109 (\33\:VDD VSS) capacitor c=2.81183e-17
C110 (\8\:SEb VSS) capacitor c=1.39768e-17
C111 (\4\:VDD VSS) capacitor c=9.44484e-17
C112 (\7\:net573 VSS) capacitor c=1.89005e-17
C113 (\4\:QN VSS) capacitor c=2.88312e-17
C114 (\1\:Q VSS) capacitor c=8.03561e-17
C115 (\7\:RNb VSS) capacitor c=1.229e-16
C116 (\17\:qbint VSS) capacitor c=6.19653e-17
C117 (\3\:n10 VSS) capacitor c=1.82853e-16
C118 (\3\:n8 VSS) capacitor c=7.89496e-17
C119 (\6\:n35 VSS) capacitor c=4.7697e-17
C120 (\4\:mout VSS) capacitor c=5.929e-17
C121 (\11\:mout VSS) capacitor c=4.61742e-17
C122 (\3\:n4 VSS) capacitor c=8.10863e-17
C123 (\5\:n20 VSS) capacitor c=1.54916e-16
C124 (\10\:CKbb VSS) capacitor c=9.59486e-17
C125 (\14\:CKb VSS) capacitor c=5.70406e-17
C126 (\5\:Db VSS) capacitor c=1.15781e-16
C127 (\6\:SEb VSS) capacitor c=7.04519e-17
C128 (\3\:CKb VSS) capacitor c=4.37378e-17
C129 (\4\:SEb VSS) capacitor c=1.06409e-16
C130 (\5\:SEb VSS) capacitor c=9.77102e-17
C131 (\8\:SE VSS) capacitor c=1.62601e-16
C132 (\9\:SE VSS) capacitor c=1.33121e-16
C133 (\10\:SE VSS) capacitor c=2.52746e-17
C134 (\11\:SE VSS) capacitor c=6.63155e-17
C135 (\4\:D VSS) capacitor c=6.73441e-17
C136 (\3\:RNb VSS) capacitor c=8.1512e-17
C137 (\4\:CK VSS) capacitor c=6.33623e-17
C138 (\2\:qbint VSS) capacitor c=4.05568e-17
C139 (\12\:CKb VSS) capacitor c=3.33041e-17
C140 (\13\:CKb VSS) capacitor c=7.73331e-17
C141 (\3\:Db VSS) capacitor c=1.88858e-16
C142 (\4\:Db VSS) capacitor c=2.20145e-16
C143 (\8\:SN VSS) capacitor c=5.13986e-17
C144 (\8\:CKbb VSS) capacitor c=9.58154e-17
C145 (\9\:CKbb VSS) capacitor c=7.01371e-17
C146 (\14\:CKbb VSS) capacitor c=7.3121e-17
C147 (\15\:CKbb VSS) capacitor c=1.05001e-16
C148 (\4\:n20 VSS) capacitor c=1.11726e-16
C149 (\8\:mout VSS) capacitor c=8.19913e-17
C150 (\9\:mout VSS) capacitor c=6.10499e-17
C151 (\10\:mout VSS) capacitor c=6.17096e-17
C152 (\18\:CKb VSS) capacitor c=7.73716e-17
C153 (\19\:CKb VSS) capacitor c=3.35884e-16
C154 (\20\:CKb VSS) capacitor c=2.62694e-16
C155 (\9\:SN VSS) capacitor c=3.16426e-16
C156 (\10\:SN VSS) capacitor c=3.14773e-16
C157 (\4\:n35 VSS) capacitor c=2.59361e-16
C158 (\5\:n35 VSS) capacitor c=2.17818e-16
C159 (\11\:RNb VSS) capacitor c=3.35517e-16
C160 (\4\:RN VSS) capacitor c=3.32846e-17
C161 (\3\:QN VSS) capacitor c=2.89955e-17
C162 (\14\:qbint VSS) capacitor c=8.3272e-17
C163 (\19\:qbint VSS) capacitor c=7.2653e-17
C164 (\20\:qbint VSS) capacitor c=7.76452e-17
C165 (\9\:net573 VSS) capacitor c=3.33296e-17
C166 (\10\:net573 VSS) capacitor c=3.42701e-17
C167 (\7\:VDD VSS) capacitor c=4.27638e-17
C168 (\9\:VDD VSS) capacitor c=4.87262e-17
C169 (\10\:VDD VSS) capacitor c=5.02041e-17
C170 (\12\:VDD VSS) capacitor c=2.39913e-17
C171 (\13\:VDD VSS) capacitor c=4.60586e-17
C172 (\14\:VDD VSS) capacitor c=2.25461e-17
C173 (\16\:VDD VSS) capacitor c=2.20317e-17
Rk9 (D \4\:D) resistor r=0.113 c=0
Rk45 (\4\:RN RN) resistor r=0.04718 c=0
Rk19 (\8\:SN SN) resistor r=0.09513 c=0
Rk38 (\9\:SN \10\:SN) resistor r=2.4258 c=0
Rk47 (\4\:Q Q) resistor r=0.02395 c=0
Rk46 (\2\:Q \4\:Q) resistor r=0.3149 c=0
Rk65 (\1\:VSS \7\:VSS) resistor r=0.3924 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.5591 c=0
Rk67 (\8\:VSS \9\:VSS) resistor r=1.2038 c=0
Rk68 (\9\:VSS \10\:VSS) resistor r=0.1192 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.6181 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.3758 c=0
Rk71 (\12\:VSS \13\:VSS) resistor r=0.08758 c=0
Rk73 (\14\:VSS VSS) resistor r=0.1425 c=0
Rk72 (\13\:VSS \14\:VSS) resistor r=0.4086 c=0
Rk76 (\7\:VSS \20\:VSS) resistor r=0.3207 c=0
Rk77 (\10\:VSS \22\:VSS) resistor r=0.04331 c=0
Rk78 (\11\:VSS \24\:VSS) resistor r=0.3646 c=0
Rk79 (\12\:VSS \26\:VSS) resistor r=0.2546 c=0
Rk80 (\14\:VSS \28\:VSS) resistor r=0.2456 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.1035 c=0
Rk6 (\9\:SE \10\:SE) resistor r=0.08682 c=0
Rk8 (\11\:SE SE) resistor r=0.003332 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.2808 c=0
Rk1 (SI \4\:SI) resistor r=0.004474 c=0
Rk49 (\3\:QN QN) resistor r=0.1123 c=0
Rk48 (\2\:QN \3\:QN) resistor r=0.313 c=0
Rk50 (\3\:QN \5\:QN) resistor r=0.07591 c=0
Rk84 (\1\:VDD \7\:VDD) resistor r=0.4861 c=0
Rk85 (\7\:VDD \8\:VDD) resistor r=0.4813 c=0
Rk86 (\8\:VDD \9\:VDD) resistor r=0.2531 c=0
Rk87 (\9\:VDD \10\:VDD) resistor r=0.6943 c=0
Rk88 (\10\:VDD \11\:VDD) resistor r=0.2556 c=0
Rk89 (\11\:VDD \12\:VDD) resistor r=0.1628 c=0
Rk90 (\12\:VDD \13\:VDD) resistor r=0.5328 c=0
Rk91 (\13\:VDD \14\:VDD) resistor r=0.3698 c=0
Rk92 (\14\:VDD \15\:VDD) resistor r=0.1352 c=0
Rk94 (\16\:VDD VDD) resistor r=0.1701 c=0
Rk93 (\15\:VDD \16\:VDD) resistor r=0.381 c=0
Rk97 (\7\:VDD \22\:VDD) resistor r=0.1026 c=0
Rk98 (\9\:VDD \24\:VDD) resistor r=0.1528 c=0
Rk99 (\10\:VDD \26\:VDD) resistor r=0.1528 c=0
Rk100 (\12\:VDD \28\:VDD) resistor r=0.07393 c=0
Rk101 (\13\:VDD \30\:VDD) resistor r=0.04331 c=0
Rk102 (\14\:VDD \32\:VDD) resistor r=0.2313 c=0
Rk103 (\16\:VDD \34\:VDD) resistor r=0.1942 c=0
Rk10 (CK \4\:CK) resistor r=0.1441 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.6909 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.6223 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04795 c=0
Rk14 (\2\:Db \3\:Db) resistor r=0.4897 c=0
Rk15 (\3\:Db \4\:Db) resistor r=1.3038 c=0
Rk16 (\4\:Db \6\:Db) resistor r=0.659 c=0
Rk17 (\3\:Db \8\:Db) resistor r=0.02078 c=0
Rk18 (\4\:Db \10\:Db) resistor r=0.104 c=0
Rk11 (\12\:CKb \13\:CKb) resistor r=0.2395 c=0
Rk12 (\13\:CKb \15\:CKb) resistor r=0.3468 c=0
Rk13 (\13\:CKb \17\:CKb) resistor r=0.3414 c=0
Rk34 (\18\:CKb \19\:CKb) resistor r=0.5865 c=0
Rk35 (\19\:CKb \20\:CKb) resistor r=1.9267 c=0
Rk20 (\8\:CKbb \9\:CKbb) resistor r=0.4919 c=0
Rk21 (\9\:CKbb \11\:CKbb) resistor r=0.4177 c=0
Rk22 (\11\:CKbb \13\:CKbb) resistor r=0.2974 c=0
Rk23 (\9\:CKbb \14\:CKbb) resistor r=0.09434 c=0
Rk24 (\14\:CKbb \15\:CKbb) resistor r=0.6992 c=0
Rk25 (\4\:n20 \6\:n20) resistor r=0.866 c=0
Rk26 (\6\:n20 \8\:n20) resistor r=0.4885 c=0
Rk28 (\5\:mout \7\:mout) resistor r=0.3297 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3395 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.4478 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.2513 c=0
Rk32 (\8\:mout \12\:mout) resistor r=0.2652 c=0
Rk33 (\9\:mout \14\:mout) resistor r=0.08669 c=0
Rk27 (\2\:n4 \4\:n4) resistor r=0.4641 c=0
Rk43 (\8\:RNb \10\:RNb) resistor r=0.7754 c=0
Rk44 (\10\:RNb \11\:RNb) resistor r=2.0913 c=0
Rk40 (\4\:n35 \5\:n35) resistor r=1.7333 c=0
Rk41 (\5\:n35 \7\:n35) resistor r=0.2304 c=0
Rk42 (\5\:n35 \9\:n35) resistor r=0.126 c=0
Rk37 (\2\:n10 \4\:n10) resistor r=1.2491 c=0
Rk39 (\2\:n8 \4\:n8) resistor r=0.382 c=0
Rk51 (\14\:qbint \5\:qbint) resistor r=0.6163 c=0
Rk53 (\5\:qbint \18\:qbint) resistor r=0.5127 c=0
Rk54 (\18\:qbint \19\:qbint) resistor r=0.1495 c=0
Rk55 (\19\:qbint \20\:qbint) resistor r=0.3442 c=0
Rk58 (\19\:qbint \24\:qbint) resistor r=0.3679 c=0
Rk59 (\8\:net573 \9\:net573) resistor r=0.2324 c=0
Rk60 (\9\:net573 \10\:net573) resistor r=0.1482 c=0
Rk61 (\9\:net573 \12\:net573) resistor r=0.1545 c=0
Rk36 (\2\:n11 \4\:n11) resistor r=1.2651 c=0
Rl9 (\1\:D \2\:D) resistor r=189.617 c=0
Rl10 (\2\:D \3\:D) resistor r=55.0021 c=0
Rl44 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl45 (\2\:RN \3\:RN) resistor r=110.307 c=0
Rl40 (\5\:SN \6\:SN) resistor r=207.258 c=0
Rl41 (\6\:SN \7\:SN) resistor r=59.5926 c=0
Rl25 (\3\:SN \4\:SN) resistor r=50.6918 c=0
Rl24 (\2\:SN \3\:SN) resistor r=112.333 c=0
Rl23 (\1\:SN \2\:SN) resistor r=36.5385 c=0
Rl8 (\6\:SE \7\:SE) resistor r=71.8456 c=0
Rl5 (\4\:SE \5\:SE) resistor r=29.5379 c=0
Rl1 (\1\:SE \2\:SE) resistor r=226.923 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl3 (\1\:SI \2\:SI) resistor r=131.461 c=0
Rl4 (\2\:SI \3\:SI) resistor r=133.384 c=0
Rl11 (\1\:CK \2\:CK) resistor r=209.615 c=0
Rl12 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=131.925 c=0
Rl6 (SEb \2\:SEb) resistor r=164.939 c=0
Rl31 (\10\:CKb \11\:CKb) resistor r=81.408 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl15 (CKb \2\:CKb) resistor r=74.2328 c=0
Rl20 (\4\:CKb \7\:CKb) resistor r=32.4874 c=0
Rl19 (\4\:CKb \6\:CKb) resistor r=24.7951 c=0
Rl18 (\3\:CKb \5\:CKb) resistor r=76.6046 c=0
Rl16 (\2\:CKb \3\:CKb) resistor r=111.505 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=173.466 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=170.285 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=445.667 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=61.106 c=0
Rl13 (CKbb \2\:CKbb) resistor r=31.461 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=110.771 c=0
Rl26 (n20 \2\:n20) resistor r=69.7702 c=0
Rl22 (\2\:mout \3\:mout) resistor r=59.1695 c=0
Rl21 (mout \2\:mout) resistor r=120.387 c=0
Rl32 (RNb \2\:RNb) resistor r=505.335 c=0
Rl36 (\4\:RNb \6\:RNb) resistor r=266.873 c=0
Rl33 (\2\:RNb \3\:RNb) resistor r=255.747 c=0
Rl34 (\3\:RNb \4\:RNb) resistor r=649.978 c=0
Rl35 (\3\:RNb \5\:RNb) resistor r=154.219 c=0
Rl43 (\2\:n35 \3\:n35) resistor r=24.2328 c=0
Rl42 (n35 \2\:n35) resistor r=84.3311 c=0
Rl55 (\12\:qbint \11\:qbint) resistor r=141.873 c=0
Rl56 (\13\:qbint \12\:qbint) resistor r=29.5379 c=0
Rl38 (\2\:qbint \3\:qbint) resistor r=149.075 c=0
Rl37 (\2\:qbint qbint) resistor r=24.4619 c=0
Rl39 (\2\:qbint \4\:qbint) resistor r=4.5402 c=0
Rz17 (\2\:Q \1\:Q) resistor r=75 c=0
Rz24 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz25 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz26 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz27 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz28 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz18 (\5\:QN \4\:QN) resistor r=75 c=0
Rz29 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz30 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Rz31 (\11\:VDD \4\:VDD) resistor r=6.25 c=0
Rz32 (\15\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\5\:Db \6\:Db) resistor r=75 c=0
Rz2 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz5 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz9 (\4\:mout \5\:mout) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz7 (n4 \2\:n4) resistor r=75 c=0
Rz8 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz16 (\7\:RNb \8\:RNb) resistor r=75 c=0
Rz15 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz11 (n10 \2\:n10) resistor r=75 c=0
Rz12 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz13 (n8 \2\:n8) resistor r=75 c=0
Rz14 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz19 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz20 (\8\:net573 \7\:net573) resistor r=75 c=0
Ry13 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry18 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry19 (\9\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry20 (\13\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry14 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry24 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry26 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry27 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry28 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry29 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry30 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry4 (\9\:Db \10\:Db) resistor r=62 c=0
Ry2 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry5 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry7 (\6\:mout \7\:mout) resistor r=62 c=0
Ry8 (\13\:mout \14\:mout) resistor r=62 c=0
Ry12 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry11 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry15 (\24\:qbint \23\:qbint) resistor r=31 c=0
Ry16 (\12\:net573 \11\:net573) resistor r=62 c=0
Ry9 (n11 \2\:n11) resistor r=62 c=0
Ry10 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx22 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\7\:SN \9\:SN) resistor r=45 c=0
Rx19 (\4\:SN \10\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SE \11\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\11\:CKb \18\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\2\:CKbb \8\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\7\:CKbb \15\:CKbb) resistor r=45 c=0
Rx13 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx14 (\2\:mout \10\:mout) resistor r=45 c=0
Rx21 (\5\:RNb \11\:RNb) resistor r=45 c=0
Rx20 (\2\:n35 \4\:n35) resistor r=45 c=0
Rx23 (\14\:qbint \13\:qbint) resistor r=45 c=0
Rx24 (\20\:qbint \4\:qbint) resistor r=45 c=0
Rx27 (\10\:net573 net573) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.465e-14 ps=7.2e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.52e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn13 (n2 \3\:SI \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.682e-14 ps=7.2e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.26e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn14 (\5\:Db \4\:SE n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.03e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn12 (\5\:Db SEb n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=8.25e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn11 (n0 \3\:D \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=3.625e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=5.3e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn20 (\14\:CKb \3\:CK \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn21 (\10\:CKbb \6\:CKb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.683e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (Db \5\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=2.61e-14 ps=8.2e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.64e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.843e-14 ps=5.6e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.33e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n6 mout \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=1.958e-14 ps=1.44e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.15e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\3\:n4 \1\:SN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=7.177e-14 ps=1.44e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.85e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn32 (\11\:mout n20 \3\:n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.177e-14 ad=2.32e-14 ps=1.28e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\6\:n35 \6\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn53 (\6\:n35 \10\:CKb n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.538e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 qbint n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.538e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=5.75e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n8 \5\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.7e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn22 (\7\:RNb \3\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.91e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\7\:net573 \12\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\17\:qbint n35 \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=3.383e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.73902e-07 sb=1.65e-07 sd=160n sca=15.5643 \
        scb=0.0161016 scc=0.00117276 m=(1)
mn55 (\1\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.735e-14 ad=5.85e-14 ps=1.61e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.16606e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\4\:QN net573 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.273e-14 ad=7.41e-14 ps=1.6e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.71635e-07 sb=6.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\23\:qbint \3\:n35 \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.267e-13 ad=6.2e-14 ps=1.94e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1925e-06 sb=2e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.885e-14 ad=8.775e-14 ps=1.16e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=9.88846e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp57_1__rcx (\1\:QN net573 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.154e-14 ad=6.24e-14 ps=1.185e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.70064e-07 sb=4.53846e-07 sd=160n sca=25.9986 \
        scb=0.0191329 scc=0.00277829 m=(2)
ends SDFFSRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:57 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRX4
// View name: extracted

simulator lang=spectre

subckt SDFFSRX4 CK D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \40\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=15.5148 \
        scb=0.0148294 scc=0.000239375 m=(1)
mp13 (n3 \1\:SI \40\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.21e-06 sd=160n sca=12.345 \
        scb=0.00962119 scc=0.000140637 m=(1)
mp14 (\8\:Db \3\:SEb n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=6.558e-14 ps=7.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1e-06 sd=160n sca=11.205 scb=0.00858508 \
        scc=0.000138179 m=(1)
mp12 (\8\:Db \6\:SE n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=6.558e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=6.5e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp11 (n1 \1\:D \38\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=5.2e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp20 (\18\:CKb \1\:CK \38\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.773e-14 ps=7.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.15e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp25 (\5\:n20 \3\:CKbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=3.44e-14 ps=1.11e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=6.25814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\5\:n20 \3\:CKb n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.20814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (n7 mout \36\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0065e-13 ad=1.29e-14 ps=1.89e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=3.15814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp21 (\10\:CKbb \5\:CKb \36\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0065e-13 ad=3.01e-14 ps=1.89e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.42558e-07 sb=1.4e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp31 (n5 RNb \34\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6688e-13 ad=1.612e-14 ps=2.38e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=8.69767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp32 (\8\:mout \2\:n20 n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=6.127e-14 ps=5.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=7.49767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp30 (\8\:mout \5\:SN \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.88e-14 ad=6.127e-14 ps=1.6e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=4.19767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp22 (\11\:RNb \1\:RN \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.88e-14 ad=5.03e-14 ps=1.6e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.47674e-07 sb=2.33953e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\12\:n35 \9\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.01e-14 ad=3.5e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86512e-07 sb=3.27907e-07 sd=160n sca=16.925 \
        scb=0.0168124 scc=0.00121732 m=(1)
mp53 (\12\:n35 \6\:CKbb n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.5e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.66395e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp51 (n9 \4\:RNb \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp52 (\3\:n11 qbint n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (\3\:n11 \1\:SN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
C1 (D VSS) capacitor c=6.47126e-17
C2 (RN VSS) capacitor c=7.98717e-17
C3 (Q VSS) capacitor c=1.75431e-17
C4 (SN VSS) capacitor c=7.47654e-17
C5 (QN VSS) capacitor c=1.8028e-17
C6 (VDD VSS) capacitor c=5.87314e-16
C7 (SI VSS) capacitor c=7.83216e-17
C8 (CK VSS) capacitor c=4.61829e-17
C9 (SEb VSS) capacitor c=6.13197e-17
C10 (n2 VSS) capacitor c=8.64555e-20
C11 (Db VSS) capacitor c=7.13328e-17
C12 (n0 VSS) capacitor c=1.50135e-18
C13 (CKb VSS) capacitor c=2.8534e-17
C14 (n20 VSS) capacitor c=9.01128e-17
C15 (n6 VSS) capacitor c=1.8925e-18
C16 (CKbb VSS) capacitor c=3.299e-17
C17 (mout VSS) capacitor c=8.59081e-17
C18 (RNb VSS) capacitor c=8.24333e-17
C19 (n4 VSS) capacitor c=9.53292e-17
C20 (n35 VSS) capacitor c=2.12923e-16
C21 (n10 VSS) capacitor c=8.26487e-17
C22 (n8 VSS) capacitor c=7.54969e-17
C23 (qbint VSS) capacitor c=8.66333e-17
C24 (net573 VSS) capacitor c=2.80456e-16
C25 (n1 VSS) capacitor c=1.86763e-18
C26 (n5 VSS) capacitor c=1.10865e-18
C27 (n11 VSS) capacitor c=9.03641e-17
C28 (\21\:qbint VSS) capacitor c=5.13449e-17
C29 (\4\:qbint VSS) capacitor c=2.48073e-16
C30 (\1\:SN VSS) capacitor c=8.94368e-17
C31 (\4\:RNb VSS) capacitor c=8.34771e-17
C32 (\6\:CKbb VSS) capacitor c=5.84584e-17
C33 (\9\:CKb VSS) capacitor c=1.21728e-16
C34 (\1\:RN VSS) capacitor c=4.66033e-17
C35 (\5\:SN VSS) capacitor c=4.84643e-17
C36 (\2\:n20 VSS) capacitor c=9.89269e-17
C37 (\5\:CKb VSS) capacitor c=2.88682e-17
C38 (\3\:CKb VSS) capacitor c=6.83865e-17
C39 (\3\:CKbb VSS) capacitor c=4.67164e-17
C40 (\1\:CK VSS) capacitor c=5.09382e-17
C41 (\1\:D VSS) capacitor c=7.73654e-17
C42 (\6\:SE VSS) capacitor c=4.71885e-17
C43 (\3\:SEb VSS) capacitor c=2.83864e-17
C44 (\1\:SI VSS) capacitor c=4.51495e-17
C45 (\1\:SE VSS) capacitor c=5.41024e-17
C46 (\19\:qbint VSS) capacitor c=3.37985e-17
C47 (\2\:SN VSS) capacitor c=2.00123e-16
C48 (\3\:qbint VSS) capacitor c=3.92385e-17
C49 (\6\:RNb VSS) capacitor c=4.07571e-17
C50 (\8\:CKb VSS) capacitor c=6.693e-17
C51 (\4\:CKbb VSS) capacitor c=4.86265e-17
C52 (\3\:RN VSS) capacitor c=3.67868e-17
C53 (\3\:SN VSS) capacitor c=1.22264e-16
C54 (\2\:RNb VSS) capacitor c=4.53172e-17
C55 (\7\:CKb VSS) capacitor c=3.54795e-17
C56 (\2\:mout VSS) capacitor c=5.07878e-17
C57 (\3\:CK VSS) capacitor c=2.70386e-17
C58 (\3\:D VSS) capacitor c=2.80018e-17
C59 (\4\:SE VSS) capacitor c=6.11444e-17
C60 (\3\:SI VSS) capacitor c=7.87672e-17
C61 (\3\:SE VSS) capacitor c=2.88987e-17
C62 (\20\:qbint VSS) capacitor c=4.40252e-17
C63 (\2\:qbint VSS) capacitor c=7.23633e-17
C64 (\5\:RNb VSS) capacitor c=6.40138e-17
C65 (\7\:CKbb VSS) capacitor c=2.24803e-17
C66 (\5\:CKbb VSS) capacitor c=3.77907e-17
C67 (\2\:RN VSS) capacitor c=2.46575e-17
C68 (\4\:SN VSS) capacitor c=3.41355e-17
C69 (\10\:CKb VSS) capacitor c=7.8452e-17
C70 (\3\:RNb VSS) capacitor c=3.07551e-17
C71 (\3\:n20 VSS) capacitor c=4.10364e-17
C72 (\6\:CKb VSS) capacitor c=2.13086e-17
C73 (\3\:mout VSS) capacitor c=2.77845e-17
C74 (\2\:CKbb VSS) capacitor c=6.08127e-17
C75 (\4\:CKb VSS) capacitor c=4.6794e-17
C76 (\2\:CKb VSS) capacitor c=1.82448e-17
C77 (\2\:CK VSS) capacitor c=4.07587e-17
C78 (\2\:D VSS) capacitor c=5.25546e-17
C79 (\7\:SE VSS) capacitor c=4.96192e-17
C80 (\2\:SEb VSS) capacitor c=7.41219e-17
C81 (\5\:SE VSS) capacitor c=4.00298e-17
C82 (\2\:SI VSS) capacitor c=5.76156e-17
C83 (\2\:SE VSS) capacitor c=4.56347e-17
C84 (\18\:net573 VSS) capacitor c=4.09896e-17
C85 (\1\:VDD VSS) capacitor c=4.50279e-16
C86 (\1\:Q VSS) capacitor c=1.40503e-16
C87 (\27\:qbint VSS) capacitor c=6.64658e-17
C88 (\3\:n11 VSS) capacitor c=1.05736e-16
C89 (\30\:VDD VSS) capacitor c=2.81394e-17
C90 (\12\:n35 VSS) capacitor c=3.83319e-17
C91 (\6\:mout VSS) capacitor c=1.83151e-16
C92 (\11\:RNb VSS) capacitor c=9.65107e-17
C93 (\32\:VDD VSS) capacitor c=5.65917e-17
C94 (\8\:mout VSS) capacitor c=2.31861e-16
C95 (\34\:VDD VSS) capacitor c=3.18871e-17
C96 (\10\:CKbb VSS) capacitor c=2.7098e-16
C97 (\36\:VDD VSS) capacitor c=1.8904e-17
C98 (\5\:n20 VSS) capacitor c=1.56903e-16
C99 (\3\:Db VSS) capacitor c=1.83906e-16
C100 (\18\:CKb VSS) capacitor c=1.13013e-16
C101 (\38\:VDD VSS) capacitor c=4.87805e-17
C102 (\8\:Db VSS) capacitor c=1.07916e-17
C103 (\40\:VDD VSS) capacitor c=3.13265e-17
C104 (\8\:SEb VSS) capacitor c=1.3121e-17
C105 (\4\:VDD VSS) capacitor c=1.0602e-16
C106 (\14\:net573 VSS) capacitor c=3.33286e-17
C107 (\1\:QN VSS) capacitor c=1.22724e-16
C108 (\30\:qbint VSS) capacitor c=2.03054e-17
C109 (\3\:n8 VSS) capacitor c=8.93313e-17
C110 (\3\:n10 VSS) capacitor c=8.22515e-17
C111 (\10\:n35 VSS) capacitor c=5.78543e-17
C112 (\4\:mout VSS) capacitor c=9.86529e-17
C113 (\8\:RNb VSS) capacitor c=2.24807e-16
C114 (\12\:mout VSS) capacitor c=1.1216e-16
C115 (\3\:n4 VSS) capacitor c=1.02414e-16
C116 (\12\:CKbb VSS) capacitor c=9.53369e-17
C117 (\7\:n20 VSS) capacitor c=1.09188e-16
C118 (\15\:CKb VSS) capacitor c=1.2546e-16
C119 (\6\:Db VSS) capacitor c=1.03454e-16
C120 (\6\:SEb VSS) capacitor c=6.9215e-17
C121 (\4\:SI VSS) capacitor c=4.89767e-17
C122 (\4\:SEb VSS) capacitor c=6.54929e-17
C123 (\5\:SEb VSS) capacitor c=1.09989e-16
C124 (\8\:SE VSS) capacitor c=1.59115e-16
C125 (\9\:SE VSS) capacitor c=1.32191e-16
C126 (\10\:SE VSS) capacitor c=4.02131e-17
C127 (\4\:D VSS) capacitor c=5.69131e-17
C128 (\4\:CK VSS) capacitor c=6.32623e-17
C129 (\5\:Db VSS) capacitor c=1.82492e-16
C130 (\4\:n20 VSS) capacitor c=1.24408e-16
C131 (\11\:CKb VSS) capacitor c=1.48713e-16
C132 (\12\:CKb VSS) capacitor c=1.79878e-16
C133 (\13\:CKb VSS) capacitor c=1.25929e-16
C134 (\14\:CKb VSS) capacitor c=9.25965e-17
C135 (\17\:CKb VSS) capacitor c=4.09334e-17
C136 (\6\:SN VSS) capacitor c=3.72309e-17
C137 (\4\:RN VSS) capacitor c=3.64745e-17
C138 (\10\:mout VSS) capacitor c=1.90449e-16
C139 (\11\:mout VSS) capacitor c=6.32541e-17
C140 (\8\:CKbb VSS) capacitor c=2.33412e-17
C141 (\9\:CKbb VSS) capacitor c=2.43018e-16
C142 (\14\:CKbb VSS) capacitor c=7.62986e-17
C143 (\15\:CKbb VSS) capacitor c=9.24151e-17
C144 (\7\:RNb VSS) capacitor c=2.12362e-16
C145 (\10\:RNb VSS) capacitor c=1.12586e-16
C146 (\8\:n35 VSS) capacitor c=1.36384e-16
C147 (\9\:n35 VSS) capacitor c=1.71312e-16
C148 (\4\:Q VSS) capacitor c=1.2259e-16
C149 (\5\:QN VSS) capacitor c=1.57907e-16
C150 (\22\:qbint VSS) capacitor c=1.59736e-17
C151 (\23\:qbint VSS) capacitor c=2.81253e-17
C152 (\24\:qbint VSS) capacitor c=2.03405e-16
C153 (\25\:qbint VSS) capacitor c=2.77365e-17
C154 (\26\:qbint VSS) capacitor c=5.44385e-17
C155 (\29\:qbint VSS) capacitor c=2.52662e-16
C156 (\16\:net573 VSS) capacitor c=4.78841e-17
C157 (\17\:net573 VSS) capacitor c=2.89879e-17
C158 (\10\:VDD VSS) capacitor c=9.46126e-18
C159 (\12\:VDD VSS) capacitor c=6.42547e-17
C160 (\14\:VDD VSS) capacitor c=9.45367e-18
C161 (\15\:VDD VSS) capacitor c=4.60909e-17
C162 (\16\:VDD VSS) capacitor c=3.43971e-17
C163 (\18\:VDD VSS) capacitor c=1.96367e-17
Rk8 (D \4\:D) resistor r=0.1227 c=0
Rk24 (RN \4\:RN) resistor r=0.1816 c=0
Rk45 (\1\:Q Q) resistor r=0.03643 c=0
Rk46 (Q \4\:Q) resistor r=0.2361 c=0
Rk23 (\6\:SN SN) resistor r=0.1618 c=0
Rk51 (\1\:QN QN) resistor r=0.2277 c=0
Rk52 (QN \5\:QN) resistor r=0.001585 c=0
Rk95 (\1\:VDD \10\:VDD) resistor r=0.258 c=0
Rk96 (\10\:VDD \11\:VDD) resistor r=0.08759 c=0
Rk97 (\11\:VDD \12\:VDD) resistor r=0.7698 c=0
Rk98 (\12\:VDD \13\:VDD) resistor r=0.4337 c=0
Rk99 (\13\:VDD \14\:VDD) resistor r=0.1167 c=0
Rk100 (\14\:VDD \15\:VDD) resistor r=0.241 c=0
Rk101 (\15\:VDD \16\:VDD) resistor r=0.7787 c=0
Rk102 (\16\:VDD \17\:VDD) resistor r=0.06251 c=0
Rk104 (\18\:VDD VDD) resistor r=0.1801 c=0
Rk103 (\17\:VDD \18\:VDD) resistor r=0.371 c=0
Rk111 (\10\:VDD \31\:VDD) resistor r=0.2915 c=0
Rk112 (\12\:VDD \33\:VDD) resistor r=0.2251 c=0
Rk113 (\14\:VDD \35\:VDD) resistor r=0.04332 c=0
Rk114 (\15\:VDD \37\:VDD) resistor r=0.04332 c=0
Rk115 (\16\:VDD \39\:VDD) resistor r=0.2548 c=0
Rk116 (\18\:VDD \41\:VDD) resistor r=0.2547 c=0
Rk6 (SE \9\:SE) resistor r=0.004389 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.0585 c=0
Rk7 (\9\:SE \10\:SE) resistor r=0.2531 c=0
Rk1 (\4\:SI SI) resistor r=0.154 c=0
Rk72 (\1\:VSS \10\:VSS) resistor r=0.2983 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.7623 c=0
Rk74 (\11\:VSS \12\:VSS) resistor r=0.4413 c=0
Rk75 (\12\:VSS \13\:VSS) resistor r=0.335 c=0
Rk76 (\13\:VSS \14\:VSS) resistor r=0.8264 c=0
Rk77 (\14\:VSS \15\:VSS) resistor r=0.03994 c=0
Rk79 (\16\:VSS VSS) resistor r=0.1801 c=0
Rk78 (\15\:VSS \16\:VSS) resistor r=0.371 c=0
Rk85 (\11\:VSS \28\:VSS) resistor r=0.1556 c=0
Rk86 (\13\:VSS \30\:VSS) resistor r=0.04332 c=0
Rk87 (\14\:VSS \32\:VSS) resistor r=0.275 c=0
Rk88 (\16\:VSS \34\:VSS) resistor r=0.2826 c=0
Rk9 (CK \4\:CK) resistor r=0.1328 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.4067 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.7053 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04804 c=0
Rk10 (\2\:Db \4\:Db) resistor r=0.3929 c=0
Rk11 (\4\:Db \5\:Db) resistor r=1.1804 c=0
Rk12 (\5\:Db \7\:Db) resistor r=0.5105 c=0
Rk13 (\5\:Db \9\:Db) resistor r=0.05432 c=0
Rk17 (\11\:CKb \12\:CKb) resistor r=1.2898 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.235 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.7351 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.526 c=0
Rk21 (\12\:CKb \17\:CKb) resistor r=0.1029 c=0
Rk22 (\16\:CKb \19\:CKb) resistor r=0.9206 c=0
Rk14 (\4\:n20 \6\:n20) resistor r=0.8652 c=0
Rk15 (\6\:n20 \8\:n20) resistor r=0.5988 c=0
Rk30 (\8\:CKbb \9\:CKbb) resistor r=0.1614 c=0
Rk31 (\9\:CKbb \11\:CKbb) resistor r=1.8079 c=0
Rk32 (\11\:CKbb \13\:CKbb) resistor r=0.308 c=0
Rk33 (\13\:CKbb \14\:CKbb) resistor r=0.4624 c=0
Rk34 (\9\:CKbb \15\:CKbb) resistor r=0.4432 c=0
Rk25 (\5\:mout \7\:mout) resistor r=0.5107 c=0
Rk26 (\7\:mout \9\:mout) resistor r=0.8841 c=0
Rk27 (\9\:mout \10\:mout) resistor r=0.8944 c=0
Rk28 (\10\:mout \11\:mout) resistor r=0.4681 c=0
Rk29 (\10\:mout \13\:mout) resistor r=0.6601 c=0
Rk35 (\7\:RNb \9\:RNb) resistor r=1.3897 c=0
Rk36 (\9\:RNb \10\:RNb) resistor r=0.7552 c=0
Rk37 (\9\:RNb \12\:RNb) resistor r=0.545 c=0
Rk16 (\2\:n4 \4\:n4) resistor r=0.6124 c=0
Rk41 (\8\:n35 \9\:n35) resistor r=0.9744 c=0
Rk42 (\9\:n35 \11\:n35) resistor r=0.2554 c=0
Rk43 (\9\:n35 \13\:n35) resistor r=0.1429 c=0
Rk38 (\2\:n10 \4\:n10) resistor r=0.3151 c=0
Rk39 (\2\:n8 \4\:n8) resistor r=0.53 c=0
Rk56 (\22\:qbint \23\:qbint) resistor r=0.2428 c=0
Rk57 (\23\:qbint \24\:qbint) resistor r=0.1091 c=0
Rk58 (\24\:qbint \25\:qbint) resistor r=0.08522 c=0
Rk59 (\25\:qbint \26\:qbint) resistor r=0.322 c=0
Rk60 (\23\:qbint \28\:qbint) resistor r=0.2748 c=0
Rk61 (\24\:qbint \29\:qbint) resistor r=1.9955 c=0
Rk62 (\25\:qbint \31\:qbint) resistor r=0.07481 c=0
Rk63 (\15\:net573 \16\:net573) resistor r=0.4161 c=0
Rk64 (\16\:net573 \17\:net573) resistor r=0.2032 c=0
Rk65 (\16\:net573 \19\:net573) resistor r=0.183 c=0
Rk40 (\2\:n11 \4\:n11) resistor r=0.6739 c=0
Rl9 (\1\:D \2\:D) resistor r=180.769 c=0
Rl10 (\2\:D \3\:D) resistor r=39.8352 c=0
Rl25 (\1\:RN \2\:RN) resistor r=95.3867 c=0
Rl26 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl35 (\1\:SN \2\:SN) resistor r=253.412 c=0
Rl36 (\2\:SN \3\:SN) resistor r=980.335 c=0
Rl38 (\4\:SN \5\:SN) resistor r=120.387 c=0
Rl37 (\3\:SN \4\:SN) resistor r=37.6944 c=0
Rl8 (\6\:SE \7\:SE) resistor r=66.5405 c=0
Rl5 (\4\:SE \5\:SE) resistor r=41.5405 c=0
Rl1 (\1\:SE \2\:SE) resistor r=179.538 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.1533 c=0
Rl3 (\1\:SI \2\:SI) resistor r=69.9225 c=0
Rl4 (\2\:SI \3\:SI) resistor r=148.769 c=0
Rl11 (\1\:CK \2\:CK) resistor r=164.153 c=0
Rl12 (\2\:CK \3\:CK) resistor r=54.5379 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl6 (SEb \2\:SEb) resistor r=249.554 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=189.516 c=0
Rl30 (\9\:CKb \10\:CKb) resistor r=483.694 c=0
Rl19 (\5\:CKb \6\:CKb) resistor r=29.5379 c=0
Rl20 (\6\:CKb \7\:CKb) resistor r=58.3841 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=56.461 c=0
Rl23 (n20 \2\:n20) resistor r=201.489 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=224.513 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=41.5405 c=0
Rl27 (\4\:CKbb \5\:CKbb) resistor r=41.0764 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=137.708 c=0
Rl15 (CKbb \2\:CKbb) resistor r=26.098 c=0
Rl17 (mout \2\:mout) resistor r=153.846 c=0
Rl18 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl21 (RNb \2\:RNb) resistor r=186.538 c=0
Rl31 (\4\:RNb \5\:RNb) resistor r=192.285 c=0
Rl32 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl22 (\2\:RNb \3\:RNb) resistor r=40.8889 c=0
Rl72 (\20\:qbint \21\:qbint) resistor r=91.5405 c=0
Rl71 (\20\:qbint \19\:qbint) resistor r=94.5067 c=0
Rl33 (\2\:qbint qbint) resistor r=165.18 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=42.7285 c=0
Rz33 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz34 (\11\:VDD \4\:VDD) resistor r=6.25 c=0
Rz35 (\13\:VDD \4\:VDD) resistor r=6.25 c=0
Rz36 (\17\:VDD \4\:VDD) resistor r=6.25 c=0
Rz29 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\6\:Db \7\:Db) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz4 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\12\:mout \13\:mout) resistor r=75 c=0
Rz11 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz16 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz12 (n10 \2\:n10) resistor r=75 c=0
Rz13 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz14 (n8 \2\:n8) resistor r=75 c=0
Rz15 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz21 (\31\:qbint \30\:qbint) resistor r=75 c=0
Rz22 (\15\:net573 \14\:net573) resistor r=75 c=0
Ry31 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry32 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry33 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry34 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry35 (\39\:VDD \38\:VDD) resistor r=62 c=0
Ry36 (\41\:VDD \40\:VDD) resistor r=62 c=0
Ry20 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry21 (\10\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry22 (\12\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry23 (\15\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\8\:Db \9\:Db) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry4 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry12 (\13\:n35 \12\:n35) resistor r=62 c=0
Ry18 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry19 (\19\:net573 \18\:net573) resistor r=20.6667 c=0
Ry10 (n11 \2\:n11) resistor r=62 c=0
Ry11 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:RN \4\:RN) resistor r=45 c=0
Rx13 (\4\:SN \6\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \9\:SE) resistor r=45 c=0
Rx5 (\2\:SE \10\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx9 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx16 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx17 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx18 (\5\:CKbb \15\:CKbb) resistor r=45 c=0
Rx15 (\3\:mout \11\:mout) resistor r=45 c=0
Rx19 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx20 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx21 (\8\:n35 n35) resistor r=45 c=0
Rx22 (\22\:qbint \4\:qbint) resistor r=45 c=0
Rx23 (\26\:qbint \2\:qbint) resistor r=45 c=0
Rx24 (\29\:qbint \20\:qbint) resistor r=45 c=0
Rx25 (\17\:net573 net573) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (n2 \3\:SI \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.035e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (\6\:Db \4\:SE n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (\6\:Db SEb n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=3.335e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (n0 \3\:D \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.755e-14 ps=7.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=4.2e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn20 (\15\:CKb \3\:CK \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.03e-14 ps=7.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn25 (Db CKb \7\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=2.03e-14 ps=9.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 CKbb n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=4.785e-14 ps=5.6e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n6 \2\:mout \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.135e-14 ad=1.957e-14 ps=1.7e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=4.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\12\:CKbb \7\:CKb \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.135e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \2\:RNb \3\:n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.712e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=9.3e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn32 (\12\:mout n20 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=7.25e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn30 (n4 \3\:SN \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.837e-14 ad=2.9e-14 ps=1.14e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=4.8e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn22 (\8\:RNb \3\:RN \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.837e-14 ad=2.03e-14 ps=1.14e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn40 (\10\:n35 \4\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn53 (\10\:n35 \8\:CKb \3\:n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.697e-14 ad=2.755e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn51 (n10 \6\:RNb \3\:n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=2.61e-14 ps=5.8e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn52 (n10 \3\:qbint n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2e-06 sd=160n sca=8.85152 scb=0.00706865 \
        scc=0.000138481 m=(1)
mn50 (n8 \2\:SN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn45_1__rcx (\30\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.169e-14 ad=3.28e-14 ps=9.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.80976e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(2)
mn56 (\14\:net573 \19\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.71e-14 ad=3.64e-14 ps=1.19e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn57_1__rcx (\1\:QN net573 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.268e-14 ad=4.16e-14 ps=1.3175e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71038e-06 sb=1.195e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.944e-14 ad=4.16e-14 ps=1.3175e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.40481e-07 sb=2e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mp45_1__rcx (\27\:qbint n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=4.96e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.84919e-07 sb=2e-06 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(2)
mp56 (\18\:net573 \21\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=27.206 \
        scb=0.0201058 scc=0.00278017 m=(1)
mp57_1__rcx (\5\:QN net573 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66731e-06 sb=9.6e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.595e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.43141e-07 sb=1.82e-06 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
ends SDFFSRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:58 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRXL
// View name: extracted

simulator lang=spectre

subckt SDFFSRXL CK D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN net573 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=49.954 \
        scb=0.0336165 scc=0.00594928 m=(1)
mp56 (\4\:net573 \6\:qbint \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=3.45e-07 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp22 (\10\:RNb \3\:RN \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp45 (\15\:qbint n35 \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.01e-14 ps=1.73e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.4e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp50 (\3\:n11 \1\:SN \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.75e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp52 (\3\:n11 \7\:qbint n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.7e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp51 (n9 \2\:RNb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0857e-13 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.65e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp53 (\8\:n35 \5\:CKbb n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.987e-14 ad=3.762e-14 ps=1.08e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=3.6e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp40 (\8\:n35 \5\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.4e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp31 (n5 \4\:RNb \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0383e-13 ad=3.977e-14 ps=2.11e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03558e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp32 (\10\:mout \4\:n20 n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=3.44e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=8.05581e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp30 (\10\:mout \4\:SN \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.55e-14 ad=3.44e-14 ps=1.72e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=6.00581e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp35 (n7 mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.55e-14 ad=1.29e-14 ps=1.72e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.82209e-07 sb=4.5e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\9\:n20 \6\:CKb n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.87209e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\9\:n20 \6\:CKbb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19221e-06 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\7\:CKbb \8\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.835e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp20 (\21\:CKb \1\:CK \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.155e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp11 (n1 \1\:D \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.5e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp12 (\6\:Db \1\:SE n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.655e-14 ps=8.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=6.95e-07 sd=160n sca=10.8061 \
        scb=0.00831024 scc=0.000128411 m=(1)
mp14 (\6\:Db SEb n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=3.655e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=4.8e-07 sd=160n sca=11.5709 \
        scb=0.00874068 scc=0.000128764 m=(1)
mp13 (n3 \1\:SI \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.935e-14 ps=7.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=3.45e-07 sd=160n sca=12.5323 \
        scb=0.0098256 scc=0.000132754 m=(1)
mp10 (\4\:SEb \5\:SE \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.4e-07 sd=160n sca=16.3619 \
        scb=0.0163088 scc=0.000299525 m=(1)
C1 (QN VSS) capacitor c=1.78862e-17
C2 (CK VSS) capacitor c=6.76016e-17
C3 (SN VSS) capacitor c=3.01394e-16
C4 (SI VSS) capacitor c=9.05018e-17
C5 (VDD VSS) capacitor c=5.18142e-16
C6 (RN VSS) capacitor c=1.34753e-16
C7 (D VSS) capacitor c=3.0396e-17
C8 (Q VSS) capacitor c=4.6388e-17
C9 (net573 VSS) capacitor c=3.02467e-17
C10 (qbint VSS) capacitor c=4.6896e-17
C11 (RNb VSS) capacitor c=5.32295e-17
C12 (n35 VSS) capacitor c=4.42777e-17
C13 (n8 VSS) capacitor c=9.43719e-17
C14 (n10 VSS) capacitor c=7.13756e-17
C15 (CKb VSS) capacitor c=4.45034e-17
C16 (mout VSS) capacitor c=6.38945e-17
C17 (CKbb VSS) capacitor c=4.15633e-17
C18 (n4 VSS) capacitor c=7.06836e-17
C19 (n20 VSS) capacitor c=2.58566e-17
C20 (Db VSS) capacitor c=5.38274e-17
C21 (n0 VSS) capacitor c=5.49257e-18
C22 (SEb VSS) capacitor c=4.48508e-17
C23 (n11 VSS) capacitor c=1.17713e-16
C24 (n9 VSS) capacitor c=1.57439e-18
C25 (n5 VSS) capacitor c=2.74777e-18
C26 (n1 VSS) capacitor c=5.46877e-18
C27 (\5\:SE VSS) capacitor c=5.13366e-17
C28 (\1\:SI VSS) capacitor c=6.08635e-17
C29 (\1\:SE VSS) capacitor c=4.46046e-17
C30 (\1\:D VSS) capacitor c=4.4469e-17
C31 (\1\:CK VSS) capacitor c=2.64647e-17
C32 (\8\:CKb VSS) capacitor c=2.2591e-17
C33 (\6\:CKbb VSS) capacitor c=3.89638e-17
C34 (\6\:CKb VSS) capacitor c=6.99494e-17
C35 (\4\:SN VSS) capacitor c=5.25137e-17
C36 (\4\:n20 VSS) capacitor c=5.38014e-17
C37 (\4\:RNb VSS) capacitor c=6.67384e-17
C38 (\5\:CKb VSS) capacitor c=3.60709e-17
C39 (\5\:CKbb VSS) capacitor c=7.4193e-17
C40 (\2\:RNb VSS) capacitor c=8.82675e-17
C41 (\7\:qbint VSS) capacitor c=9.49651e-17
C42 (\1\:SN VSS) capacitor c=4.2763e-17
C43 (\3\:RN VSS) capacitor c=3.25423e-17
C44 (\6\:qbint VSS) capacitor c=2.70518e-17
C45 (\7\:SE VSS) capacitor c=2.76376e-17
C46 (\3\:SI VSS) capacitor c=6.83593e-17
C47 (\3\:SE VSS) capacitor c=6.73081e-17
C48 (\3\:SEb VSS) capacitor c=7.34901e-17
C49 (\3\:D VSS) capacitor c=4.19081e-17
C50 (\3\:CK VSS) capacitor c=4.82426e-17
C51 (\11\:CKb VSS) capacitor c=2.34647e-17
C52 (\10\:CKb VSS) capacitor c=5.45941e-17
C53 (\3\:CKbb VSS) capacitor c=1.63653e-16
C54 (\3\:mout VSS) capacitor c=6.71347e-17
C55 (\6\:SN VSS) capacitor c=7.34685e-17
C56 (\3\:n20 VSS) capacitor c=3.88531e-17
C57 (\6\:RNb VSS) capacitor c=4.90845e-17
C58 (\4\:CKbb VSS) capacitor c=1.06372e-16
C59 (\8\:qbint VSS) capacitor c=4.55797e-17
C60 (\3\:SN VSS) capacitor c=5.97268e-17
C61 (\3\:n35 VSS) capacitor c=3.27737e-17
C62 (\1\:RN VSS) capacitor c=4.45942e-17
C63 (\5\:qbint VSS) capacitor c=1.67095e-17
C64 (\4\:qbint VSS) capacitor c=3.52581e-17
C65 (\3\:net573 VSS) capacitor c=3.84588e-17
C66 (\6\:SE VSS) capacitor c=4.49727e-17
C67 (\2\:SI VSS) capacitor c=6.60001e-17
C68 (\4\:SE VSS) capacitor c=4.93053e-17
C69 (\2\:SEb VSS) capacitor c=7.54387e-17
C70 (\2\:SE VSS) capacitor c=4.54464e-17
C71 (\2\:D VSS) capacitor c=4.54149e-17
C72 (\2\:CK VSS) capacitor c=3.58351e-17
C73 (\9\:CKb VSS) capacitor c=4.4452e-17
C74 (\7\:CKb VSS) capacitor c=2.90574e-17
C75 (\2\:mout VSS) capacitor c=5.54167e-17
C76 (\5\:SN VSS) capacitor c=3.28352e-17
C77 (\3\:CKb VSS) capacitor c=3.79305e-17
C78 (\5\:RNb VSS) capacitor c=2.18917e-17
C79 (\4\:CKb VSS) capacitor c=3.64278e-17
C80 (\2\:CKb VSS) capacitor c=3.3476e-17
C81 (\3\:RNb VSS) capacitor c=2.53533e-17
C82 (\9\:qbint VSS) capacitor c=2.75482e-17
C83 (\2\:SN VSS) capacitor c=4.07021e-17
C84 (\2\:n35 VSS) capacitor c=2.7325e-17
C85 (\2\:RN VSS) capacitor c=3.70964e-17
C86 (\2\:qbint VSS) capacitor c=3.98325e-17
C87 (\2\:net573 VSS) capacitor c=2.82053e-17
C88 (\4\:SEb VSS) capacitor c=1.21994e-17
C89 (\9\:VDD VSS) capacitor c=3.34885e-17
C90 (\6\:Db VSS) capacitor c=9.24599e-17
C91 (\11\:VDD VSS) capacitor c=4.17829e-17
C92 (\21\:CKb VSS) capacitor c=6.99786e-17
C93 (\13\:VDD VSS) capacitor c=3.80007e-17
C94 (\7\:CKbb VSS) capacitor c=4.99911e-17
C95 (\8\:Db VSS) capacitor c=8.11227e-17
C96 (\9\:n20 VSS) capacitor c=4.57607e-17
C97 (\15\:VDD VSS) capacitor c=1.3735e-17
C98 (\10\:mout VSS) capacitor c=3.62816e-17
C99 (\17\:VDD VSS) capacitor c=2.41136e-17
C100 (\8\:mout VSS) capacitor c=7.27074e-17
C101 (\8\:n35 VSS) capacitor c=4.8242e-17
C102 (\20\:VDD VSS) capacitor c=2.4503e-17
C103 (\3\:n11 VSS) capacitor c=1.10446e-16
C104 (\23\:VDD VSS) capacitor c=1.24221e-17
C105 (\15\:qbint VSS) capacitor c=5.86906e-17
C106 (\10\:RNb VSS) capacitor c=3.25075e-17
C107 (\26\:VDD VSS) capacitor c=3.19539e-17
C108 (\1\:Q VSS) capacitor c=6.11596e-17
C109 (\4\:net573 VSS) capacitor c=3.0512e-17
C110 (\29\:VDD VSS) capacitor c=3.72838e-17
C111 (\1\:QN VSS) capacitor c=2.83577e-17
C112 (\1\:VDD VSS) capacitor c=1.09541e-16
C113 (\8\:SEb VSS) capacitor c=7.05458e-17
C114 (\14\:CKb VSS) capacitor c=4.60253e-17
C115 (\10\:CKbb VSS) capacitor c=6.00262e-17
C116 (\4\:Db VSS) capacitor c=1.75685e-16
C117 (\5\:n20 VSS) capacitor c=2.64333e-17
C118 (\12\:mout VSS) capacitor c=3.04683e-17
C119 (\3\:n4 VSS) capacitor c=7.69115e-17
C120 (\14\:mout VSS) capacitor c=4.4623e-17
C121 (\4\:n35 VSS) capacitor c=4.13101e-17
C122 (\3\:n8 VSS) capacitor c=8.17739e-17
C123 (\3\:n10 VSS) capacitor c=8.46242e-17
C124 (\12\:qbint VSS) capacitor c=4.98633e-17
C125 (\12\:RNb VSS) capacitor c=8.85207e-17
C126 (\3\:Q VSS) capacitor c=3.80042e-17
C127 (\8\:net573 VSS) capacitor c=3.17542e-17
C128 (\4\:QN VSS) capacitor c=2.07436e-17
C129 (\3\:qbint VSS) capacitor c=3.38382e-17
C130 (\2\:n20 VSS) capacitor c=2.46342e-17
C131 (\3\:QN VSS) capacitor c=3.49599e-17
C132 (\2\:CKbb VSS) capacitor c=4.35372e-17
C133 (\6\:net573 VSS) capacitor c=3.79287e-17
C134 (\7\:net573 VSS) capacitor c=3.00838e-17
C135 (\10\:qbint VSS) capacitor c=6.22136e-17
C136 (\11\:qbint VSS) capacitor c=9.92114e-17
C137 (\14\:qbint VSS) capacitor c=1.26251e-16
C138 (\6\:n35 VSS) capacitor c=1.71618e-16
C139 (\7\:n35 VSS) capacitor c=1.54363e-16
C140 (\12\:CKb VSS) capacitor c=1.13224e-16
C141 (\13\:CKb VSS) capacitor c=6.34978e-17
C142 (\7\:RNb VSS) capacitor c=1.44453e-16
C143 (\8\:RNb VSS) capacitor c=2.19415e-16
C144 (\9\:RNb VSS) capacitor c=1.07891e-16
C145 (\7\:SN VSS) capacitor c=2.61365e-16
C146 (\8\:SN VSS) capacitor c=2.99462e-17
C147 (\4\:mout VSS) capacitor c=4.49264e-17
C148 (\5\:mout VSS) capacitor c=4.93374e-17
C149 (\6\:mout VSS) capacitor c=5.97245e-17
C150 (\7\:mout VSS) capacitor c=5.55689e-17
C151 (\7\:n20 VSS) capacitor c=5.64323e-17
C152 (\8\:n20 VSS) capacitor c=8.54522e-17
C153 (\9\:CKbb VSS) capacitor c=4.54232e-17
C154 (\16\:CKb VSS) capacitor c=4.54004e-17
C155 (\17\:CKb VSS) capacitor c=1.23411e-16
C156 (\18\:CKb VSS) capacitor c=1.51904e-16
C157 (\19\:CKb VSS) capacitor c=1.51284e-16
C158 (\20\:CKb VSS) capacitor c=2.29076e-17
C159 (\23\:CKb VSS) capacitor c=1.92389e-17
C160 (\4\:CK VSS) capacitor c=5.09082e-17
C161 (\4\:D VSS) capacitor c=8.56648e-17
C162 (\3\:Db VSS) capacitor c=2.08452e-16
C163 (\8\:SE VSS) capacitor c=7.82859e-17
C164 (\9\:SE VSS) capacitor c=5.10941e-17
C165 (\10\:SE VSS) capacitor c=6.56771e-17
C166 (\6\:SEb VSS) capacitor c=7.98095e-17
C167 (\7\:SEb VSS) capacitor c=5.89282e-17
C168 (\3\:VDD VSS) capacitor c=2.15558e-17
C169 (\4\:VDD VSS) capacitor c=2.1004e-17
C170 (\6\:VDD VSS) capacitor c=2.57372e-17
C171 (\7\:VDD VSS) capacitor c=6.33097e-17
C172 (\19\:VDD VSS) capacitor c=3.56798e-17
C173 (\22\:VDD VSS) capacitor c=2.93587e-17
C174 (\28\:VDD VSS) capacitor c=1.17986e-17
Rk2 (\3\:QN QN) resistor r=0.02903 c=0
Rk1 (\2\:QN \3\:QN) resistor r=0.2 c=0
Rk3 (\3\:QN \5\:QN) resistor r=0.1282 c=0
Rk47 (\4\:CK CK) resistor r=0.1889 c=0
Rk55 (\8\:SE SE) resistor r=0.2644 c=0
Rk54 (\8\:SE \9\:SE) resistor r=0.3108 c=0
Rk56 (SE \10\:SE) resistor r=0.002257 c=0
Rk26 (\7\:SN SN) resistor r=1.978 c=0
Rk27 (SN \8\:SN) resistor r=0.09842 c=0
Rk53 (\4\:SI SI) resistor r=0.001898 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.1152 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.4209 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.1653 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.1929 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.5012 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.5101 c=0
Rk66 (\3\:VDD \10\:VDD) resistor r=0.251 c=0
Rk67 (\4\:VDD \12\:VDD) resistor r=0.2463 c=0
Rk68 (\6\:VDD \14\:VDD) resistor r=0.1999 c=0
Rk69 (\7\:VDD \16\:VDD) resistor r=0.07393 c=0
Rk70 (\8\:VDD \18\:VDD) resistor r=0.07147 c=0
Rk71 (\8\:VDD \19\:VDD) resistor r=0.4813 c=0
Rk72 (\19\:VDD \21\:VDD) resistor r=0.1026 c=0
Rk73 (\19\:VDD \22\:VDD) resistor r=0.3206 c=0
Rk74 (\22\:VDD \24\:VDD) resistor r=0.07393 c=0
Rk75 (\22\:VDD \25\:VDD) resistor r=0.4011 c=0
Rk76 (\25\:VDD \27\:VDD) resistor r=0.3119 c=0
Rk79 (\28\:VDD VDD) resistor r=0.1927 c=0
Rk77 (\25\:VDD \28\:VDD) resistor r=0.359 c=0
Rk78 (\28\:VDD \30\:VDD) resistor r=0.4181 c=0
Rk9 (\4\:RN RN) resistor r=0.003663 c=0
Rk48 (D \4\:D) resistor r=0.0781 c=0
Rk7 (\2\:Q Q) resistor r=0.3967 c=0
Rk8 (Q \4\:Q) resistor r=0.04807 c=0
Rk80 (\2\:VSS \3\:VSS) resistor r=0.1152 c=0
Rk81 (\3\:VSS \4\:VSS) resistor r=0.4059 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.1804 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.2095 c=0
Rk84 (\6\:VSS \7\:VSS) resistor r=0.4977 c=0
Rk85 (\7\:VSS \8\:VSS) resistor r=0.4938 c=0
Rk86 (\8\:VSS \9\:VSS) resistor r=0.8014 c=0
Rk87 (\9\:VSS \10\:VSS) resistor r=0.4001 c=0
Rk88 (\3\:VSS \12\:VSS) resistor r=0.2896 c=0
Rk89 (\4\:VSS \14\:VSS) resistor r=0.2196 c=0
Rk90 (\6\:VSS \16\:VSS) resistor r=0.04331 c=0
Rk91 (\7\:VSS \18\:VSS) resistor r=0.3557 c=0
Rk92 (\9\:VSS \20\:VSS) resistor r=0.04331 c=0
Rk94 (\21\:VSS VSS) resistor r=0.2077 c=0
Rk93 (\10\:VSS \21\:VSS) resistor r=0.3439 c=0
Rk95 (\10\:VSS \23\:VSS) resistor r=0.4377 c=0
Rk96 (\21\:VSS \25\:VSS) resistor r=0.07393 c=0
Rk4 (\5\:net573 \6\:net573) resistor r=0.1238 c=0
Rk5 (\6\:net573 \7\:net573) resistor r=0.1344 c=0
Rk6 (\6\:net573 \9\:net573) resistor r=0.1959 c=0
Rk10 (\10\:qbint \11\:qbint) resistor r=0.368 c=0
Rk11 (\11\:qbint \13\:qbint) resistor r=0.09138 c=0
Rk12 (\11\:qbint \14\:qbint) resistor r=0.8183 c=0
Rk13 (\13\:qbint \16\:qbint) resistor r=0.4607 c=0
Rk21 (\7\:RNb \8\:RNb) resistor r=1.0519 c=0
Rk22 (\8\:RNb \9\:RNb) resistor r=0.6756 c=0
Rk23 (\9\:RNb \11\:RNb) resistor r=0.07287 c=0
Rk24 (\9\:RNb \13\:RNb) resistor r=0.4963 c=0
Rk17 (\5\:n35 \6\:n35) resistor r=0.1803 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=1.1324 c=0
Rk19 (\6\:n35 \9\:n35) resistor r=0.1634 c=0
Rk14 (\2\:n8 \4\:n8) resistor r=0.6111 c=0
Rk16 (\2\:n10 \4\:n10) resistor r=0.301 c=0
Rk20 (\12\:CKb \13\:CKb) resistor r=0.6571 c=0
Rk40 (\15\:CKb \16\:CKb) resistor r=0.3345 c=0
Rk41 (\16\:CKb \17\:CKb) resistor r=0.3365 c=0
Rk42 (\17\:CKb \18\:CKb) resistor r=0.6509 c=0
Rk43 (\18\:CKb \19\:CKb) resistor r=1.0248 c=0
Rk44 (\16\:CKb \20\:CKb) resistor r=0.08669 c=0
Rk45 (\17\:CKb \22\:CKb) resistor r=0.3751 c=0
Rk46 (\18\:CKb \23\:CKb) resistor r=0.02283 c=0
Rk28 (\4\:mout \5\:mout) resistor r=0.2592 c=0
Rk29 (\5\:mout \6\:mout) resistor r=0.2896 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.3064 c=0
Rk31 (\7\:mout \9\:mout) resistor r=0.3617 c=0
Rk32 (\5\:mout \11\:mout) resistor r=0.08669 c=0
Rk33 (\6\:mout \13\:mout) resistor r=0.1031 c=0
Rk34 (\7\:mout \15\:mout) resistor r=0.16 c=0
Rk38 (\8\:CKbb \9\:CKbb) resistor r=0.1237 c=0
Rk39 (\9\:CKbb \11\:CKbb) resistor r=0.183 c=0
Rk25 (\2\:n4 \4\:n4) resistor r=0.4889 c=0
Rk35 (\6\:n20 \7\:n20) resistor r=0.1311 c=0
Rk36 (\7\:n20 \8\:n20) resistor r=0.4162 c=0
Rk37 (\7\:n20 \10\:n20) resistor r=0.269 c=0
Rk49 (\2\:Db \3\:Db) resistor r=0.2394 c=0
Rk50 (\3\:Db \5\:Db) resistor r=1.2106 c=0
Rk51 (\3\:Db \7\:Db) resistor r=0.6628 c=0
Rk52 (\5\:Db \9\:Db) resistor r=0.4296 c=0
Rk57 (\5\:SEb \6\:SEb) resistor r=0.04795 c=0
Rk58 (\6\:SEb \7\:SEb) resistor r=0.3966 c=0
Rk59 (\6\:SEb \9\:SEb) resistor r=0.614 c=0
Rk15 (\2\:n11 \4\:n11) resistor r=0.4173 c=0
Rl39 (\1\:CK \2\:CK) resistor r=30.1196 c=0
Rl40 (\2\:CK \3\:CK) resistor r=134.41 c=0
Rl49 (\5\:SE \6\:SE) resistor r=176.156 c=0
Rl50 (\6\:SE \7\:SE) resistor r=28.079 c=0
Rl46 (\3\:SE \4\:SE) resistor r=26.098 c=0
Rl43 (\1\:SE \2\:SE) resistor r=67.9995 c=0
Rl27 (\4\:SN \6\:SN) resistor r=140.385 c=0
Rl26 (\4\:SN \5\:SN) resistor r=52.1723 c=0
Rl12 (\1\:SN \2\:SN) resistor r=33.3841 c=0
Rl13 (\2\:SN \3\:SN) resistor r=102.615 c=0
Rl47 (\1\:SI \2\:SI) resistor r=104.538 c=0
Rl48 (\2\:SI \3\:SI) resistor r=102.615 c=0
Rl9 (\2\:RN \3\:RN) resistor r=29.9451 c=0
Rl8 (\1\:RN \2\:RN) resistor r=128.846 c=0
Rl41 (\1\:D \2\:D) resistor r=91.5405 c=0
Rl42 (\2\:D \3\:D) resistor r=112.694 c=0
Rl1 (net573 \2\:net573) resistor r=35.7713 c=0
Rl2 (\2\:net573 \3\:net573) resistor r=80.0021 c=0
Rl14 (\7\:qbint \8\:qbint) resistor r=161.538 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=38.5707 c=0
Rl3 (qbint \2\:qbint) resistor r=122.872 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.4837 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=80.0028 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=175.837 c=0
Rl22 (\4\:RNb \6\:RNb) resistor r=140.385 c=0
Rl16 (RNb \2\:RNb) resistor r=264.95 c=0
Rl21 (\4\:RNb \5\:RNb) resistor r=111.052 c=0
Rl17 (\2\:RNb \3\:RNb) resistor r=43.4636 c=0
Rl10 (n35 \2\:n35) resistor r=102.615 c=0
Rl11 (\2\:n35 \3\:n35) resistor r=33.3841 c=0
Rl36 (\8\:CKb \9\:CKb) resistor r=57.4874 c=0
Rl38 (\9\:CKb \11\:CKb) resistor r=42.2956 c=0
Rl37 (\9\:CKb \10\:CKb) resistor r=184.593 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=66.5405 c=0
Rl20 (\4\:CKb \5\:CKb) resistor r=49.5131 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=117.979 c=0
Rl18 (CKb \2\:CKb) resistor r=83.8482 c=0
Rl28 (mout \2\:mout) resistor r=55.6115 c=0
Rl29 (\2\:mout \3\:mout) resistor r=89.8988 c=0
Rl34 (\4\:CKbb \5\:CKbb) resistor r=152.977 c=0
Rl33 (\3\:CKbb \4\:CKbb) resistor r=705.335 c=0
Rl35 (\2\:CKbb \6\:CKbb) resistor r=55.0028 c=0
Rl32 (\2\:CKbb \3\:CKbb) resistor r=170.415 c=0
Rl31 (CKbb \2\:CKbb) resistor r=75.3733 c=0
Rl25 (\2\:n20 \4\:n20) resistor r=95.868 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=36.2526 c=0
Rl23 (n20 \2\:n20) resistor r=2.0213 c=0
Rl44 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl45 (\2\:SEb \3\:SEb) resistor r=227.18 c=0
Rz1 (\4\:QN \5\:QN) resistor r=75 c=0
Rz21 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz22 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz23 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz24 (\1\:VDD \25\:VDD) resistor r=6.25 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz27 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz28 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz31 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz2 (\8\:net573 \9\:net573) resistor r=75 c=0
Rz4 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (n8 \2\:n8) resistor r=75 c=0
Rz6 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz7 (n10 \2\:n10) resistor r=75 c=0
Rz8 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz17 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz16 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (n4 \2\:n4) resistor r=75 c=0
Rz12 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry17 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry18 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry19 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry20 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry21 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry22 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry23 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry24 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry25 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry27 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry28 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:net573 \5\:net573) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry13 (\21\:CKb \22\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry12 (\7\:CKbb \8\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry5 (n11 \2\:n11) resistor r=62 c=0
Ry6 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx21 (\4\:SE \8\:SE) resistor r=45 c=0
Rx22 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx20 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:net573 \7\:net573) resistor r=45 c=0
Rx3 (\9\:qbint \10\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \14\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx15 (\3\:CKb \19\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\7\:CKb \23\:CKb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx14 (CKbb \9\:CKbb) resistor r=45 c=0
Rx13 (n20 \8\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\4\:QN \3\:net573 \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn56 (\8\:net573 \4\:qbint \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn55 (\3\:Q \5\:qbint \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.102e-14 ps=7.2e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=4.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn22 (\12\:RNb \1\:RN \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.262e-14 ps=7.2e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\12\:qbint \3\:n35 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.27e-14 ad=2.03e-14 ps=1.41e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n8 \3\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.8e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \8\:qbint n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.437e-14 ps=6.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.75e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=5.437e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.55e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn53 (\4\:n35 CKb n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\4\:n35 \4\:CKbb \14\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.697e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \6\:RNb \3\:n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.682e-14 ps=5.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.135e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn32 (\12\:mout \3\:n20 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=9.05e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (n4 \6\:SN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=7e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn35 (n6 \3\:mout \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=8.7e-15 ps=6.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=4.65e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.537e-14 ps=4.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=3.6e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn25 (\4\:Db \10\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn21 (\10\:CKbb \11\:CKb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.085e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn20 (\14\:CKb \3\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.855e-14 ad=3.987e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.87931e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn11 (n0 \3\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.855e-14 ad=3.625e-14 ps=1.13e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01034e-07 sb=9.5e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.96034e-07 sb=6.55e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn14 (Db \3\:SE n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.01034e-07 sb=4.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn13 (n2 \3\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.06034e-07 sb=3.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn10 (\8\:SEb \7\:SE \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11103e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
ends SDFFSRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:59 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSX1
// View name: extracted

simulator lang=spectre

subckt SDFFSX1 CK D Q QN SE SI SN VDD VSS
mp57 (\3\:QN net492 \25\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.5844 \
        scb=0.0271174 scc=0.00348165 m=(1)
mp55 (\3\:Q qbint \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
C1 (QN VSS) capacitor c=4.85633e-17
C2 (SE VSS) capacitor c=2.76632e-17
C3 (SN VSS) capacitor c=2.4792e-17
C4 (Q VSS) capacitor c=4.41187e-17
C5 (SI VSS) capacitor c=5.34796e-17
C6 (VDD VSS) capacitor c=4.42897e-16
C7 (D VSS) capacitor c=6.77682e-17
C8 (net492 VSS) capacitor c=3.25785e-17
C9 (qbint VSS) capacitor c=2.68515e-17
C10 (n35 VSS) capacitor c=4.34022e-17
C11 (net518 VSS) capacitor c=2.03266e-18
C12 (CKb VSS) capacitor c=1.7001e-17
C13 (mout VSS) capacitor c=7.6104e-17
C14 (CKbb VSS) capacitor c=3.55676e-17
C15 (net442 VSS) capacitor c=2.03427e-18
C16 (n20 VSS) capacitor c=3.65443e-17
C17 (net478 VSS) capacitor c=3.30288e-18
C18 (Db VSS) capacitor c=9.38948e-17
C19 (net494 VSS) capacitor c=8.1769e-18
C20 (SEb VSS) capacitor c=3.41555e-17
C21 (net506 VSS) capacitor c=1.52608e-20
C22 (net405 VSS) capacitor c=7.16811e-17
C23 (\7\:SE VSS) capacitor c=5.38233e-17
C24 (\3\:SI VSS) capacitor c=5.05263e-17
C25 (\1\:SE VSS) capacitor c=4.38756e-17
C26 (\1\:D VSS) capacitor c=5.75849e-17
C27 (\1\:CK VSS) capacitor c=7.21717e-17
C28 (\5\:CKbb VSS) capacitor c=4.45745e-17
C29 (\7\:CKb VSS) capacitor c=7.38706e-17
C30 (\4\:SN VSS) capacitor c=8.0898e-17
C31 (\2\:CKb VSS) capacitor c=4.85088e-17
C32 (\4\:CKb VSS) capacitor c=1.1109e-16
C33 (\4\:CKbb VSS) capacitor c=6.62181e-17
C34 (\7\:qbint VSS) capacitor c=6.30751e-17
C35 (\3\:SN VSS) capacitor c=5.35785e-17
C36 (\3\:n35 VSS) capacitor c=3.78019e-17
C37 (\6\:qbint VSS) capacitor c=1.73213e-17
C38 (\5\:SE VSS) capacitor c=3.30566e-17
C39 (\1\:SI VSS) capacitor c=8.04732e-17
C40 (\3\:SE VSS) capacitor c=6.57789e-17
C41 (\3\:SEb VSS) capacitor c=6.41928e-17
C42 (\4\:D VSS) capacitor c=3.09878e-17
C43 (\3\:CK VSS) capacitor c=2.50835e-17
C44 (\9\:CKb VSS) capacitor c=3.94039e-17
C45 (\7\:CKbb VSS) capacitor c=2.99513e-17
C46 (\4\:mout VSS) capacitor c=3.07657e-17
C47 (\3\:n20 VSS) capacitor c=5.94784e-17
C48 (\5\:SN VSS) capacitor c=4.31214e-17
C49 (\6\:CKb VSS) capacitor c=3.52346e-17
C50 (\3\:CKbb VSS) capacitor c=3.20094e-17
C51 (\5\:CKb VSS) capacitor c=1.1234e-16
C52 (\9\:qbint VSS) capacitor c=3.93795e-17
C53 (\1\:SN VSS) capacitor c=6.00336e-17
C54 (\5\:qbint VSS) capacitor c=1.85269e-17
C55 (\4\:qbint VSS) capacitor c=1.7588e-17
C56 (\3\:net492 VSS) capacitor c=2.233e-17
C57 (\6\:SE VSS) capacitor c=5.6425e-17
C58 (\2\:SI VSS) capacitor c=7.46052e-17
C59 (\4\:SE VSS) capacitor c=5.65527e-17
C60 (\2\:SEb VSS) capacitor c=6.87443e-17
C61 (\2\:SE VSS) capacitor c=4.51363e-17
C62 (\3\:D VSS) capacitor c=2.06349e-17
C63 (\2\:CK VSS) capacitor c=5.12343e-17
C64 (\10\:CKb VSS) capacitor c=2.02728e-17
C65 (\8\:CKb VSS) capacitor c=2.68339e-17
C66 (\6\:CKbb VSS) capacitor c=5.79845e-17
C67 (\3\:mout VSS) capacitor c=1.7763e-17
C68 (\2\:n20 VSS) capacitor c=4.41353e-17
C69 (\6\:SN VSS) capacitor c=2.42018e-17
C70 (\8\:qbint VSS) capacitor c=6.10942e-17
C71 (\2\:SN VSS) capacitor c=7.75423e-17
C72 (\2\:n35 VSS) capacitor c=5.39574e-17
C73 (\2\:qbint VSS) capacitor c=1.19862e-17
C74 (\2\:net492 VSS) capacitor c=1.79567e-17
C75 (\8\:SEb VSS) capacitor c=1.51781e-17
C76 (\1\:VDD VSS) capacitor c=4.64672e-17
C77 (\8\:Db VSS) capacitor c=4.26463e-17
C78 (\13\:VDD VSS) capacitor c=4.0741e-17
C79 (\11\:CKb VSS) capacitor c=8.1628e-17
C80 (\4\:Db VSS) capacitor c=1.33702e-16
C81 (\8\:n20 VSS) capacitor c=2.41164e-17
C82 (\15\:VDD VSS) capacitor c=1.21598e-17
C83 (\7\:mout VSS) capacitor c=1.10291e-16
C84 (\17\:VDD VSS) capacitor c=1.60511e-17
C85 (\8\:CKbb VSS) capacitor c=4.29339e-17
C86 (\11\:mout VSS) capacitor c=1.27976e-16
C87 (\4\:n35 VSS) capacitor c=4.22472e-17
C88 (\19\:VDD VSS) capacitor c=3.25086e-17
C89 (\3\:net405 VSS) capacitor c=8.24481e-17
C90 (\21\:VDD VSS) capacitor c=1.53185e-17
C91 (\14\:qbint VSS) capacitor c=5.18087e-17
C92 (\3\:Q VSS) capacitor c=4.03106e-17
C93 (\23\:VDD VSS) capacitor c=8.13269e-17
C94 (\4\:net492 VSS) capacitor c=5.48791e-17
C95 (\3\:QN VSS) capacitor c=7.89681e-17
C96 (\25\:VDD VSS) capacitor c=5.39873e-17
C97 (\3\:VDD VSS) capacitor c=7.38747e-17
C98 (\4\:SEb VSS) capacitor c=5.86398e-17
C99 (\17\:CKb VSS) capacitor c=7.64495e-17
C100 (\6\:Db VSS) capacitor c=6.92717e-17
C101 (\4\:n20 VSS) capacitor c=6.13737e-17
C102 (\9\:mout VSS) capacitor c=3.41445e-17
C103 (\13\:CKbb VSS) capacitor c=3.06337e-17
C104 (\13\:mout VSS) capacitor c=1.05459e-16
C105 (\8\:n35 VSS) capacitor c=7.44378e-17
C106 (\12\:qbint VSS) capacitor c=7.6772e-17
C107 (\1\:Q VSS) capacitor c=6.85671e-17
C108 (\6\:net492 VSS) capacitor c=9.36717e-17
C109 (\1\:QN VSS) capacitor c=5.13801e-17
C110 (\3\:qbint VSS) capacitor c=6.94434e-18
C111 (\2\:CKbb VSS) capacitor c=2.70326e-17
C112 (\3\:CKb VSS) capacitor c=5.04857e-17
C113 (\2\:mout VSS) capacitor c=3.91255e-17
C114 (\2\:D VSS) capacitor c=4.0258e-17
C115 (\8\:net492 VSS) capacitor c=7.62223e-17
C116 (\10\:qbint VSS) capacitor c=7.28496e-17
C117 (\11\:qbint VSS) capacitor c=5.47709e-17
C118 (\16\:qbint VSS) capacitor c=1.11438e-16
C119 (\6\:n35 VSS) capacitor c=1.30236e-16
C120 (\7\:n35 VSS) capacitor c=1.01037e-16
C121 (\7\:SN VSS) capacitor c=6.99845e-17
C122 (\8\:SN VSS) capacitor c=1.56703e-16
C123 (\9\:SN VSS) capacitor c=1.51963e-16
C124 (\5\:mout VSS) capacitor c=6.75255e-17
C125 (\6\:mout VSS) capacitor c=4.84768e-17
C126 (\10\:CKbb VSS) capacitor c=1.40588e-16
C127 (\11\:CKbb VSS) capacitor c=5.98938e-17
C128 (\12\:CKbb VSS) capacitor c=1.63051e-16
C129 (\6\:n20 VSS) capacitor c=7.60433e-17
C130 (\7\:n20 VSS) capacitor c=6.44585e-17
C131 (\4\:CK VSS) capacitor c=3.65807e-17
C132 (\6\:CK VSS) capacitor c=7.0808e-17
C133 (\13\:CKb VSS) capacitor c=1.00166e-16
C134 (\14\:CKb VSS) capacitor c=8.43951e-17
C135 (\15\:CKb VSS) capacitor c=1.03693e-16
C136 (\16\:CKb VSS) capacitor c=1.24106e-16
C137 (\5\:D VSS) capacitor c=3.26844e-17
C138 (\3\:Db VSS) capacitor c=1.42136e-16
C139 (\4\:SI VSS) capacitor c=8.42165e-17
C140 (\8\:SE VSS) capacitor c=4.11505e-17
C141 (\9\:SE VSS) capacitor c=5.3872e-17
C142 (\10\:SE VSS) capacitor c=6.98365e-17
C143 (\6\:SEb VSS) capacitor c=8.71388e-17
C144 (\7\:SEb VSS) capacitor c=4.67955e-17
C145 (\5\:VDD VSS) capacitor c=3.62206e-17
C146 (\6\:VDD VSS) capacitor c=5.04602e-17
C147 (\8\:VDD VSS) capacitor c=3.58924e-17
C148 (\9\:VDD VSS) capacitor c=1.82797e-17
C149 (\11\:VDD VSS) capacitor c=9.79641e-18
C150 (\12\:VDD VSS) capacitor c=9.82019e-18
Rk1 (\2\:QN QN) resistor r=0.03635 c=0
Rk2 (QN \4\:QN) resistor r=0.2589 c=0
Rk30 (\4\:CK \5\:CK) resistor r=0.002015 c=0
Rk31 (CK \6\:CK) resistor r=0.001948 c=0
Rk32 (\4\:CK \6\:CK) resistor r=0.02971 c=0
Rk44 (\8\:SE SE) resistor r=0.1311 c=0
Rk45 (SE \9\:SE) resistor r=0.06361 c=0
Rk46 (\9\:SE \10\:SE) resistor r=0.3431 c=0
Rk16 (\8\:SN SN) resistor r=0.02617 c=0
Rk15 (\7\:SN \8\:SN) resistor r=0.283 c=0
Rk17 (\8\:SN \9\:SN) resistor r=1.1609 c=0
Rk5 (\2\:Q Q) resistor r=0.2831 c=0
Rk6 (Q \4\:Q) resistor r=0.02993 c=0
Rk43 (SI \4\:SI) resistor r=0.1108 c=0
Rk66 (\2\:VDD \4\:VDD) resistor r=0.5769 c=0
Rk67 (\4\:VDD \5\:VDD) resistor r=0.08249 c=0
Rk68 (\5\:VDD \6\:VDD) resistor r=0.819 c=0
Rk69 (\6\:VDD \7\:VDD) resistor r=0.2507 c=0
Rk70 (\7\:VDD \8\:VDD) resistor r=0.7124 c=0
Rk71 (\8\:VDD \9\:VDD) resistor r=0.1976 c=0
Rk72 (\9\:VDD \10\:VDD) resistor r=0.293 c=0
Rk73 (\10\:VDD \11\:VDD) resistor r=0.1476 c=0
Rk75 (\12\:VDD VDD) resistor r=0.07222 c=0
Rk74 (\11\:VDD \12\:VDD) resistor r=0.3304 c=0
Rk76 (\5\:VDD \14\:VDD) resistor r=0.2448 c=0
Rk77 (\6\:VDD \16\:VDD) resistor r=0.07334 c=0
Rk78 (\7\:VDD \18\:VDD) resistor r=0.07141 c=0
Rk79 (\8\:VDD \20\:VDD) resistor r=0.2048 c=0
Rk80 (\9\:VDD \22\:VDD) resistor r=0.2094 c=0
Rk81 (\11\:VDD \24\:VDD) resistor r=0.4029 c=0
Rk82 (\12\:VDD \26\:VDD) resistor r=0.3992 c=0
Rk38 (\5\:D D) resistor r=0.1597 c=0
Rk50 (\2\:VSS \4\:VSS) resistor r=0.5792 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.2053 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.6837 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.2629 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.1677 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.7137 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.3205 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.1476 c=0
Rk59 (\12\:VSS VSS) resistor r=0.05719 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.3454 c=0
Rk60 (\5\:VSS \14\:VSS) resistor r=0.2181 c=0
Rk61 (\6\:VSS \16\:VSS) resistor r=0.1895 c=0
Rk62 (\8\:VSS \18\:VSS) resistor r=0.1219 c=0
Rk63 (\9\:VSS \20\:VSS) resistor r=0.3303 c=0
Rk64 (\11\:VSS \22\:VSS) resistor r=0.2956 c=0
Rk65 (\12\:VSS \24\:VSS) resistor r=0.07334 c=0
Rk3 (\5\:net492 \7\:net492) resistor r=0.2864 c=0
Rk4 (\7\:net492 \8\:net492) resistor r=0.6045 c=0
Rk7 (\10\:qbint \11\:qbint) resistor r=0.3563 c=0
Rk8 (\11\:qbint \13\:qbint) resistor r=0.1822 c=0
Rk9 (\11\:qbint \15\:qbint) resistor r=0.3855 c=0
Rk10 (\13\:qbint \16\:qbint) resistor r=0.8134 c=0
Rk12 (\5\:n35 \6\:n35) resistor r=0.1972 c=0
Rk13 (\6\:n35 \7\:n35) resistor r=0.5928 c=0
Rk14 (\6\:n35 \9\:n35) resistor r=0.3511 c=0
Rk33 (\12\:CKb \13\:CKb) resistor r=0.5836 c=0
Rk34 (\13\:CKb \14\:CKb) resistor r=0.2416 c=0
Rk35 (\14\:CKb \15\:CKb) resistor r=0.6821 c=0
Rk36 (\13\:CKb \16\:CKb) resistor r=0.4519 c=0
Rk37 (\16\:CKb \18\:CKb) resistor r=0.5856 c=0
Rk18 (\5\:mout \6\:mout) resistor r=0.2656 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.2503 c=0
Rk20 (\6\:mout \10\:mout) resistor r=0.09662 c=0
Rk21 (\8\:mout \12\:mout) resistor r=0.7557 c=0
Rk22 (\12\:mout \14\:mout) resistor r=0.5767 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.1723 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.3743 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=1.1436 c=0
Rk26 (\11\:CKbb \14\:CKbb) resistor r=0.1073 c=0
Rk27 (\5\:n20 \6\:n20) resistor r=0.3448 c=0
Rk28 (\6\:n20 \7\:n20) resistor r=0.3477 c=0
Rk29 (\6\:n20 \9\:n20) resistor r=0.09725 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.7577 c=0
Rk40 (\3\:Db \5\:Db) resistor r=0.6966 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.4248 c=0
Rk42 (\3\:Db \9\:Db) resistor r=0.2444 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.5398 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.3964 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.0873 c=0
Rk11 (\2\:net405 \4\:net405) resistor r=0.3375 c=0
Rl33 (\1\:CK \2\:CK) resistor r=286.796 c=0
Rl34 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl45 (\6\:SE \7\:SE) resistor r=185.714 c=0
Rl44 (\5\:SE \6\:SE) resistor r=67.3077 c=0
Rl41 (\3\:SE \4\:SE) resistor r=66.0764 c=0
Rl38 (\1\:SE \2\:SE) resistor r=87.2302 c=0
Rl22 (\4\:SN \5\:SN) resistor r=170.72 c=0
Rl23 (\5\:SN \6\:SN) resistor r=35.6938 c=0
Rl11 (\2\:SN \3\:SN) resistor r=120.33 c=0
Rl10 (\1\:SN \2\:SN) resistor r=92.3077 c=0
Rl43 (\2\:SI \3\:SI) resistor r=97.2527 c=0
Rl42 (\1\:SI \2\:SI) resistor r=155.769 c=0
Rl35 (\1\:D \2\:D) resistor r=145.387 c=0
Rl37 (\2\:D \4\:D) resistor r=128.08 c=0
Rl36 (\2\:D \3\:D) resistor r=34.9887 c=0
Rl1 (net492 \2\:net492) resistor r=31.9251 c=0
Rl2 (\2\:net492 \3\:net492) resistor r=31.9251 c=0
Rl12 (\7\:qbint \8\:qbint) resistor r=178.021 c=0
Rl13 (\8\:qbint \9\:qbint) resistor r=26.098 c=0
Rl3 (qbint \2\:qbint) resistor r=39.6174 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.2328 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=51.1361 c=0
Rl9 (\2\:n35 \3\:n35) resistor r=81.0888 c=0
Rl8 (n35 \2\:n35) resistor r=151.156 c=0
Rl20 (\4\:CKb \5\:CKb) resistor r=557.258 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=29.5379 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=60.3072 c=0
Rl17 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=155.747 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=178.824 c=0
Rl21 (\3\:CKb \6\:CKb) resistor r=82.3738 c=0
Rl26 (mout \2\:mout) resistor r=98.8796 c=0
Rl28 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl27 (\2\:mout \3\:mout) resistor r=5.013 c=0
Rl30 (\5\:CKbb \6\:CKbb) resistor r=134.593 c=0
Rl31 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl16 (\2\:CKbb \4\:CKbb) resistor r=116.916 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=51.9908 c=0
Rl14 (CKbb \2\:CKbb) resistor r=80.5242 c=0
Rl24 (n20 \2\:n20) resistor r=29.5379 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=156.027 c=0
Rl39 (SEb \2\:SEb) resistor r=26.9231 c=0
Rl40 (\2\:SEb \3\:SEb) resistor r=226.374 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz21 (\3\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz22 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz23 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz14 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz15 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz19 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz20 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\6\:net492 \7\:net492) resistor r=75 c=0
Rz4 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz5 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\13\:mout \14\:mout) resistor r=75 c=0
Rz8 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz9 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\6\:Db \7\:Db) resistor r=75 c=0
Rz13 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry21 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry22 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry23 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry25 (\23\:VDD \24\:VDD) resistor r=20.6667 c=0
Ry26 (\25\:VDD \26\:VDD) resistor r=20.6667 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry17 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:net492 \5\:net492) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry7 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\8\:Db \9\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\2\:CK \5\:CK) resistor r=45 c=0
Rx17 (\6\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SN \7\:SN) resistor r=45 c=0
Rx6 (\6\:SN \9\:SN) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:net492 \8\:net492) resistor r=45 c=0
Rx2 (\8\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\6\:CKbb \12\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\1\:QN \3\:net492 \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.26e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\1\:Q \5\:qbint \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=6.63e-14 ps=9e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=2.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\6\:net492 \4\:qbint \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\12\:qbint n35 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.85e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn50 (net521 \1\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.8e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (net518 \9\:qbint net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.915e-14 ps=4.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.75e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn52 (\8\:n35 \5\:CKb net518 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.538e-14 ps=8.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.6e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\8\:n35 \3\:CKbb \13\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.538e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\13\:CKbb \6\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.328e-14 ad=3.698e-14 ps=1.68e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (net442 \5\:SN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.328e-14 ad=1.668e-14 ps=1.68e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=3e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn31 (\9\:mout \3\:n20 net442 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net478 \4\:mout \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.325e-14 ad=1.668e-14 ps=9.4e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.1e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn36 (\4\:n20 \7\:CKbb net478 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=3.625e-14 ps=5.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=5.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn25 (\6\:Db \9\:CKb \4\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.698e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\17\:CKb \3\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.308e-14 ad=2.03e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.535e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (net494 \4\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.308e-14 ad=4.713e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.055e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=6.85e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=4.8e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn13 (net506 \1\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=3.75e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.7e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mp56 (\4\:net492 \6\:qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=46.2776 \
        scb=0.0284965 scc=0.00588421 m=(1)
mp45 (\14\:qbint \3\:n35 \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=5.65e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp50 (\3\:net405 \3\:SN \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=3.6e-07 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \7\:qbint \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.333e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.55e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\4\:n35 \4\:CKbb net405 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n35 \4\:CKb \11\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\8\:CKbb \2\:CKb \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.53e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\7\:mout \4\:SN \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=4.73e-14 ps=1.83e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.265e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (\7\:mout n20 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1028e-13 ad=4.73e-14 ps=1.88e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp35 (net417 mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1028e-13 ad=1.29e-14 ps=1.88e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\8\:n20 \7\:CKb net417 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=6.05e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp25 (\8\:n20 \5\:CKbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=3.44e-14 ps=1.23e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=4e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp20 (\11\:CKb \1\:CK \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp11 (net433 \1\:D \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.7e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp12 (\8\:Db \1\:SE net433 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=4.085e-14 ps=7.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.6e-07 sd=160n sca=10.5126 \
        scb=0.0080107 scc=0.000111754 m=(1)
mp14 (\8\:Db SEb net441 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.085e-14 ps=7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5.25e-07 sd=160n sca=11.1923 \
        scb=0.00829854 scc=0.000111894 m=(1)
mp13 (net441 \3\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=3.45e-07 sd=160n sca=12.3417 \
        scb=0.00949694 scc=0.000115721 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=16.0492 \
        scb=0.0157507 scc=0.000268603 m=(1)
ends SDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:00 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSX2
// View name: extracted

simulator lang=spectre

subckt SDFFSX2 CK D Q QN SE SI SN VDD VSS
mp55_1__rcx (\1\:Q qbint \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.775e-14 ad=6.24e-14 ps=1.725e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.42756e-07 sb=4.80256e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57 (\1\:QN net492 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.17308e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (CK VSS) capacitor c=5.83761e-17
C2 (SE VSS) capacitor c=2.16001e-17
C3 (SN VSS) capacitor c=2.60985e-17
C4 (SI VSS) capacitor c=4.36893e-17
C5 (VDD VSS) capacitor c=5.37608e-16
C6 (D VSS) capacitor c=2.12373e-17
C7 (net492 VSS) capacitor c=1.14392e-16
C8 (qbint VSS) capacitor c=1.36894e-16
C9 (n35 VSS) capacitor c=4.88598e-17
C10 (net518 VSS) capacitor c=1.69034e-18
C11 (CKb VSS) capacitor c=1.77655e-17
C12 (mout VSS) capacitor c=7.29857e-17
C13 (CKbb VSS) capacitor c=6.85968e-17
C14 (net442 VSS) capacitor c=3.88814e-19
C15 (n20 VSS) capacitor c=3.47936e-17
C16 (net478 VSS) capacitor c=1.91044e-18
C17 (Db VSS) capacitor c=9.66311e-17
C18 (net494 VSS) capacitor c=5.97955e-18
C19 (SEb VSS) capacitor c=5.59324e-17
C20 (net405 VSS) capacitor c=7.166e-17
C21 (net417 VSS) capacitor c=1.07651e-18
C22 (net433 VSS) capacitor c=5.51944e-18
C23 (\5\:SE VSS) capacitor c=6.22232e-17
C24 (\1\:SI VSS) capacitor c=5.8399e-17
C25 (\1\:SE VSS) capacitor c=3.74977e-17
C26 (\1\:D VSS) capacitor c=6.08091e-17
C27 (\1\:CK VSS) capacitor c=5.31256e-17
C28 (\5\:CKbb VSS) capacitor c=5.99236e-17
C29 (\7\:CKb VSS) capacitor c=8.80483e-17
C30 (\4\:SN VSS) capacitor c=7.50563e-17
C31 (\2\:CKb VSS) capacitor c=4.22912e-17
C32 (\4\:CKb VSS) capacitor c=1.16186e-16
C33 (\11\:qbint VSS) capacitor c=6.74633e-17
C34 (\3\:SN VSS) capacitor c=6.10531e-17
C35 (\10\:qbint VSS) capacitor c=2.62124e-17
C36 (\7\:SE VSS) capacitor c=3.19611e-17
C37 (\3\:SI VSS) capacitor c=1.03546e-16
C38 (\3\:SE VSS) capacitor c=6.51604e-17
C39 (\3\:SEb VSS) capacitor c=5.46817e-17
C40 (\3\:D VSS) capacitor c=2.25906e-17
C41 (\4\:CK VSS) capacitor c=2.77228e-17
C42 (\9\:CKb VSS) capacitor c=3.42582e-17
C43 (\7\:CKbb VSS) capacitor c=3.87324e-17
C44 (\4\:mout VSS) capacitor c=3.89096e-17
C45 (\3\:n20 VSS) capacitor c=7.36157e-17
C46 (\5\:SN VSS) capacitor c=6.10561e-17
C47 (\6\:CKb VSS) capacitor c=2.94784e-17
C48 (\3\:CKbb VSS) capacitor c=2.75888e-17
C49 (\5\:CKb VSS) capacitor c=1.08554e-16
C50 (\13\:qbint VSS) capacitor c=4.17037e-17
C51 (\1\:SN VSS) capacitor c=4.99032e-17
C52 (\3\:n35 VSS) capacitor c=4.47767e-17
C53 (\5\:qbint VSS) capacitor c=2.17543e-17
C54 (\6\:SE VSS) capacitor c=5.591e-17
C55 (\2\:SI VSS) capacitor c=7.81502e-17
C56 (\4\:SE VSS) capacitor c=5.18859e-17
C57 (\2\:SEb VSS) capacitor c=7.97591e-17
C58 (\2\:SE VSS) capacitor c=3.32239e-17
C59 (\2\:D VSS) capacitor c=4.7814e-17
C60 (\3\:CK VSS) capacitor c=1.81633e-17
C61 (\10\:CKb VSS) capacitor c=2.39e-17
C62 (\6\:CKbb VSS) capacitor c=5.37574e-17
C63 (\8\:CKb VSS) capacitor c=3.07495e-17
C64 (\3\:mout VSS) capacitor c=1.17646e-17
C65 (\2\:n20 VSS) capacitor c=4.06591e-17
C66 (\6\:SN VSS) capacitor c=1.84206e-17
C67 (\4\:CKbb VSS) capacitor c=4.35853e-17
C68 (\12\:qbint VSS) capacitor c=6.61543e-17
C69 (\2\:SN VSS) capacitor c=6.46177e-17
C70 (\4\:n35 VSS) capacitor c=3.00951e-17
C71 (\7\:qbint VSS) capacitor c=2.30224e-17
C72 (\6\:net492 VSS) capacitor c=1.10325e-17
C73 (\8\:SEb VSS) capacitor c=1.41268e-17
C74 (\1\:VDD VSS) capacitor c=5.44226e-17
C75 (\7\:Db VSS) capacitor c=4.63494e-17
C76 (\8\:VDD VSS) capacitor c=3.75903e-17
C77 (\11\:CKb VSS) capacitor c=8.37801e-17
C78 (\5\:Db VSS) capacitor c=2.63528e-17
C79 (\8\:n20 VSS) capacitor c=5.42413e-17
C80 (\10\:VDD VSS) capacitor c=9.01111e-17
C81 (\8\:mout VSS) capacitor c=1.23739e-16
C82 (\12\:VDD VSS) capacitor c=1.64401e-17
C83 (\12\:CKbb VSS) capacitor c=4.21232e-17
C84 (\10\:mout VSS) capacitor c=1.28943e-16
C85 (\5\:n35 VSS) capacitor c=3.69398e-17
C86 (\15\:VDD VSS) capacitor c=3.24337e-17
C87 (\3\:net405 VSS) capacitor c=8.10949e-17
C88 (\18\:VDD VSS) capacitor c=1.46833e-17
C89 (\14\:qbint VSS) capacitor c=3.4567e-17
C90 (\1\:Q VSS) capacitor c=5.28707e-17
C91 (\8\:net492 VSS) capacitor c=1.73206e-17
C92 (\1\:QN VSS) capacitor c=7.66362e-17
C93 (\3\:VDD VSS) capacitor c=7.78325e-17
C94 (\4\:SEb VSS) capacitor c=6.84974e-17
C95 (\17\:CKb VSS) capacitor c=9.15538e-17
C96 (\9\:Db VSS) capacitor c=9.37404e-17
C97 (\4\:n20 VSS) capacitor c=7.13973e-17
C98 (\6\:mout VSS) capacitor c=8.47918e-17
C99 (\8\:CKbb VSS) capacitor c=2.99353e-17
C100 (\12\:mout VSS) capacitor c=9.70995e-17
C101 (\9\:n35 VSS) capacitor c=7.85714e-17
C102 (\19\:qbint VSS) capacitor c=1.53645e-17
C103 (\3\:Q VSS) capacitor c=5.83127e-17
C104 (\12\:net492 VSS) capacitor c=1.8755e-17
C105 (\3\:QN VSS) capacitor c=3.21551e-17
C106 (\4\:qbint VSS) capacitor c=1.14326e-17
C107 (\2\:n35 VSS) capacitor c=2.57383e-17
C108 (\2\:CKbb VSS) capacitor c=2.89322e-17
C109 (\3\:CKb VSS) capacitor c=5.26222e-17
C110 (\2\:mout VSS) capacitor c=4.06495e-17
C111 (\2\:CK VSS) capacitor c=4.90982e-17
C112 (\10\:net492 VSS) capacitor c=1.39992e-17
C113 (\11\:net492 VSS) capacitor c=1.9433e-17
C114 (\16\:qbint VSS) capacitor c=2.31947e-17
C115 (\17\:qbint VSS) capacitor c=3.82987e-17
C116 (\18\:qbint VSS) capacitor c=3.27207e-17
C117 (\21\:qbint VSS) capacitor c=8.6046e-17
C118 (\7\:n35 VSS) capacitor c=1.35931e-16
C119 (\8\:n35 VSS) capacitor c=1.27064e-16
C120 (\7\:SN VSS) capacitor c=6.45354e-17
C121 (\8\:SN VSS) capacitor c=1.74936e-16
C122 (\9\:SN VSS) capacitor c=1.91026e-16
C123 (\5\:mout VSS) capacitor c=6.6731e-17
C124 (\10\:CKbb VSS) capacitor c=5.01693e-17
C125 (\11\:CKbb VSS) capacitor c=1.58876e-16
C126 (\14\:CKbb VSS) capacitor c=1.64134e-16
C127 (\6\:n20 VSS) capacitor c=8.02463e-17
C128 (\7\:n20 VSS) capacitor c=7.70499e-17
C129 (\5\:CK VSS) capacitor c=4.68703e-17
C130 (\13\:CKb VSS) capacitor c=8.62477e-17
C131 (\14\:CKb VSS) capacitor c=1.71364e-16
C132 (\15\:CKb VSS) capacitor c=1.64052e-16
C133 (\16\:CKb VSS) capacitor c=1.61815e-16
C134 (\4\:D VSS) capacitor c=7.13834e-17
C135 (\3\:Db VSS) capacitor c=1.5057e-16
C136 (\4\:Db VSS) capacitor c=1.5275e-16
C137 (\8\:SE VSS) capacitor c=6.54159e-17
C138 (\9\:SE VSS) capacitor c=7.57366e-17
C139 (\10\:SE VSS) capacitor c=3.05262e-17
C140 (\4\:SI VSS) capacitor c=7.75598e-17
C141 (\6\:SEb VSS) capacitor c=1.13414e-16
C142 (\7\:SEb VSS) capacitor c=7.49357e-17
C143 (\5\:VDD VSS) capacitor c=4.03059e-17
C144 (\6\:VDD VSS) capacitor c=4.38944e-17
C145 (\14\:VDD VSS) capacitor c=3.66525e-17
C146 (\17\:VDD VSS) capacitor c=1.27622e-17
C147 (\20\:VDD VSS) capacitor c=2.71959e-17
Rk6 (\2\:Q Q) resistor r=0.2622 c=0
Rk7 (Q \4\:Q) resistor r=0.04331 c=0
Rk31 (\5\:CK CK) resistor r=0.1901 c=0
Rk44 (\8\:SE SE) resistor r=0.09661 c=0
Rk43 (\8\:SE \9\:SE) resistor r=0.4184 c=0
Rk45 (SE \10\:SE) resistor r=0.09784 c=0
Rk18 (\8\:SN SN) resistor r=0.02622 c=0
Rk17 (\7\:SN \8\:SN) resistor r=0.2841 c=0
Rk19 (\8\:SN \9\:SN) resistor r=1.3825 c=0
Rk46 (SI \4\:SI) resistor r=0.1468 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.5271 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.2304 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.6138 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.258 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.1728 c=0
Rk75 (\8\:VSS \9\:VSS) resistor r=0.7241 c=0
Rk79 (\10\:VSS VSS) resistor r=0.1826 c=0
Rk76 (\9\:VSS \10\:VSS) resistor r=0.2453 c=0
Rk82 (\5\:VSS \17\:VSS) resistor r=0.2529 c=0
Rk83 (\6\:VSS \19\:VSS) resistor r=0.1337 c=0
Rk84 (\8\:VSS \21\:VSS) resistor r=0.2168 c=0
Rk85 (\9\:VSS \23\:VSS) resistor r=0.3156 c=0
Rk50 (\2\:VDD \4\:VDD) resistor r=0.4904 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.1928 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.6414 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.2681 c=0
Rk54 (\5\:VDD \9\:VDD) resistor r=0.199 c=0
Rk55 (\6\:VDD \11\:VDD) resistor r=0.4309 c=0
Rk56 (\7\:VDD \13\:VDD) resistor r=0.07145 c=0
Rk57 (\7\:VDD \14\:VDD) resistor r=0.7354 c=0
Rk58 (\14\:VDD \16\:VDD) resistor r=0.2057 c=0
Rk59 (\14\:VDD \17\:VDD) resistor r=0.1977 c=0
Rk60 (\17\:VDD \19\:VDD) resistor r=0.2103 c=0
Rk66 (\20\:VDD VDD) resistor r=0.1826 c=0
Rk61 (\17\:VDD \20\:VDD) resistor r=0.1952 c=0
Rk37 (D \4\:D) resistor r=0.02026 c=0
Rk1 (\2\:QN QN) resistor r=0.3177 c=0
Rk2 (QN \4\:QN) resistor r=0.05414 c=0
Rk3 (\9\:net492 \10\:net492) resistor r=0.09366 c=0
Rk4 (\10\:net492 \11\:net492) resistor r=0.07727 c=0
Rk5 (\10\:net492 \13\:net492) resistor r=0.1296 c=0
Rk8 (\15\:qbint \16\:qbint) resistor r=0.2277 c=0
Rk9 (\16\:qbint \17\:qbint) resistor r=0.1497 c=0
Rk10 (\16\:qbint \18\:qbint) resistor r=0.06153 c=0
Rk11 (\18\:qbint \20\:qbint) resistor r=0.05742 c=0
Rk12 (\18\:qbint \21\:qbint) resistor r=0.4257 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=0.1625 c=0
Rk15 (\7\:n35 \8\:n35) resistor r=0.725 c=0
Rk16 (\7\:n35 \10\:n35) resistor r=0.3712 c=0
Rk32 (\12\:CKb \13\:CKb) resistor r=0.519 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.1432 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=1.286 c=0
Rk35 (\13\:CKb \16\:CKb) resistor r=0.5197 c=0
Rk36 (\16\:CKb \18\:CKb) resistor r=0.6929 c=0
Rk20 (\5\:mout \7\:mout) resistor r=0.2961 c=0
Rk21 (\7\:mout \9\:mout) resistor r=0.3404 c=0
Rk22 (\9\:mout \11\:mout) resistor r=0.8238 c=0
Rk23 (\11\:mout \13\:mout) resistor r=0.556 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.1124 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.3452 c=0
Rk26 (\11\:CKbb \13\:CKbb) resistor r=0.1731 c=0
Rk27 (\11\:CKbb \14\:CKbb) resistor r=1.1494 c=0
Rk28 (\5\:n20 \6\:n20) resistor r=0.3457 c=0
Rk29 (\6\:n20 \7\:n20) resistor r=0.3789 c=0
Rk30 (\6\:n20 \9\:n20) resistor r=0.1752 c=0
Rk38 (\2\:Db \3\:Db) resistor r=0.7655 c=0
Rk39 (\3\:Db \4\:Db) resistor r=0.6997 c=0
Rk40 (\4\:Db \6\:Db) resistor r=0.0511 c=0
Rk41 (\3\:Db \8\:Db) resistor r=0.2303 c=0
Rk42 (\4\:Db \10\:Db) resistor r=0.5108 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.7219 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.4893 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rk13 (\2\:net405 \4\:net405) resistor r=0.3382 c=0
Rl42 (\1\:CK \2\:CK) resistor r=226.203 c=0
Rl44 (\2\:CK \4\:CK) resistor r=68.9449 c=0
Rl43 (\2\:CK \3\:CK) resistor r=13.091 c=0
Rl53 (\5\:SE \6\:SE) resistor r=204.538 c=0
Rl54 (\6\:SE \7\:SE) resistor r=56.461 c=0
Rl50 (\3\:SE \4\:SE) resistor r=52.6149 c=0
Rl47 (\1\:SE \2\:SE) resistor r=47.2519 c=0
Rl31 (\4\:SN \5\:SN) resistor r=149.566 c=0
Rl32 (\5\:SN \6\:SN) resistor r=48.5844 c=0
Rl20 (\2\:SN \3\:SN) resistor r=119.895 c=0
Rl19 (\1\:SN \2\:SN) resistor r=92.3077 c=0
Rl51 (\1\:SI \2\:SI) resistor r=82.3533 c=0
Rl52 (\2\:SI \3\:SI) resistor r=193.136 c=0
Rl45 (\1\:D \2\:D) resistor r=220.387 c=0
Rl46 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl5 (net492 \6\:net492) resistor r=9.5287 c=0
Rl21 (\12\:qbint \11\:qbint) resistor r=181.461 c=0
Rl22 (\12\:qbint \13\:qbint) resistor r=29.5379 c=0
Rl12 (qbint \7\:qbint) resistor r=4.8851 c=0
Rl9 (\4\:qbint qbint) resistor r=82.084 c=0
Rl15 (\4\:qbint \10\:qbint) resistor r=53.0797 c=0
Rl10 (\4\:qbint \5\:qbint) resistor r=35.772 c=0
Rl16 (n35 \2\:n35) resistor r=28.0797 c=0
Rl17 (\2\:n35 \3\:n35) resistor r=60.772 c=0
Rl18 (\2\:n35 \4\:n35) resistor r=79.6836 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=557.258 c=0
Rl41 (\9\:CKb \10\:CKb) resistor r=62.2302 c=0
Rl38 (\7\:CKb \8\:CKb) resistor r=29.5379 c=0
Rl26 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=155.747 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=192.286 c=0
Rl30 (\3\:CKb \6\:CKb) resistor r=82.3738 c=0
Rl35 (mout \2\:mout) resistor r=131.572 c=0
Rl37 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl36 (\2\:mout \3\:mout) resistor r=3.1183 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=153.282 c=0
Rl40 (\6\:CKbb \7\:CKbb) resistor r=26.3736 c=0
Rl23 (CKbb \2\:CKbb) resistor r=128.08 c=0
Rl24 (\2\:CKbb \3\:CKbb) resistor r=35.772 c=0
Rl25 (\2\:CKbb \4\:CKbb) resistor r=89.2411 c=0
Rl33 (n20 \2\:n20) resistor r=57.4874 c=0
Rl34 (\2\:n20 \3\:n20) resistor r=126.9 c=0
Rl48 (SEb \2\:SEb) resistor r=93.4636 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=200.539 c=0
Rz3 (\4\:Q \3\:Q) resistor r=75 c=0
Rz17 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz21 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz22 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz14 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz15 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz16 (\20\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\4\:QN \3\:QN) resistor r=75 c=0
Rz2 (\13\:net492 \12\:net492) resistor r=75 c=0
Rz4 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz5 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz9 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\9\:Db \10\:Db) resistor r=75 c=0
Rz13 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry3 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry26 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry27 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry28 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry17 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry18 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry19 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry21 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry1 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry2 (\9\:net492 \8\:net492) resistor r=62 c=0
Ry4 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry7 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\10\:mout \11\:mout) resistor r=62 c=0
Ry10 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry13 (\5\:Db \6\:Db) resistor r=62 c=0
Ry14 (\7\:Db \8\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\3\:CK \5\:CK) resistor r=45 c=0
Rx16 (\4\:SE \8\:SE) resistor r=45 c=0
Rx17 (\2\:SE \9\:SE) resistor r=45 c=0
Rx18 (\6\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SN \7\:SN) resistor r=45 c=0
Rx6 (\6\:SN \9\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\11\:net492 \6\:net492) resistor r=45 c=0
Rx2 (\17\:qbint \7\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\4\:n35 \8\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (\4\:CKbb \10\:CKbb) resistor r=45 c=0
Rx9 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57_1__rcx (\3\:QN net492 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.05e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn55 (\3\:Q qbint \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.098e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=4.98173e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:net492 \5\:qbint \10\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=7.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net521 \1\:SN \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.5e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (net518 \13\:qbint net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.263e-14 ps=4.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn52 (\9\:n35 \5\:CKb net518 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.755e-14 ps=7.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=3.75e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\9\:n35 \3\:CKbb \12\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\8\:CKbb \6\:CKb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.445e-14 ad=3.698e-14 ps=1.51e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (net442 \5\:SN \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.445e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=2.45e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn31 (\6\:mout \3\:n20 net442 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net478 \4\:mout \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.325e-14 ad=9.42e-15 ps=9.4e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.25e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn36 (\4\:n20 \7\:CKbb net478 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.567e-14 ps=4.2e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=6.15e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn25 (\9\:Db \9\:CKb \4\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=3.698e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.55e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn20 (\17\:CKb \4\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn11 (net494 \3\:D \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=5.292e-14 ps=8.2e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.125e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.292e-14 ad=2.32e-14 ps=1.02e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=7.15e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=5.1e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn13 (net506 \3\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=4.05e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=2e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn45 (\19\:qbint \3\:n35 \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1622e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp56 (\8\:net492 \10\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=7.25e-14 ad=2.63e-14 ps=1.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.22326e-07 sb=7.67326e-07 sd=160n \
        sca=46.2604 scb=0.0284877 scc=0.00588421 m=(1)
mp50 (\3\:net405 \3\:SN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.63e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=3.6e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \11\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.27326e-07 sb=1.55e-07 sd=160n \
        sca=10.1345 scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\5\:n35 CKbb net405 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\5\:n35 \4\:CKb \10\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\12\:CKbb \2\:CKb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\8\:mout \4\:SN \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=4.73e-14 ps=1.83e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.15e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (\8\:mout n20 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=4.73e-14 ps=9.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.85e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (net417 mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=5.95e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\8\:n20 \7\:CKb net417 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=4.9e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp25 (\8\:n20 \5\:CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=2.85e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp20 (\11\:CKb \1\:CK \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.285e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp11 (net433 \1\:D \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=5.59e-14 ps=7.8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.065e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp12 (\7\:Db \1\:SE net433 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=5.375e-14 ps=9.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=7.6e-07 sd=160n sca=10.1579 \
        scb=0.00732238 scc=7.20014e-05 m=(1)
mp14 (\7\:Db SEb net441 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=5.375e-14 ps=5.8e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=4.65e-07 sd=160n sca=11.144 \
        scb=0.00785651 scc=7.24744e-05 m=(1)
mp13 (net441 \1\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.612e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=3.45e-07 sd=160n sca=12.0249 \
        scb=0.00887156 scc=7.63487e-05 m=(1)
mp10 (\8\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.4e-07 sd=160n sca=15.8545 \
        scb=0.0153548 scc=0.000243119 m=(1)
mp45 (\14\:qbint n35 \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.3e-14 ad=3.58e-14 ps=1.92e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.88468e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends SDFFSX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:01 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSX4
// View name: extracted

simulator lang=spectre

subckt SDFFSX4 CK D Q QN SE SI SN VDD VSS
mp56 (\14\:net492 \16\:qbint \22\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=4.38e-14 ps=1.1e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.12308e-07 sb=1.52744e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(1)
mp57_1__rcx (QN net492 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.27308e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(4)
mp55_1__rcx (Q qbint \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.12e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17308e-07 sb=1.32244e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
C1 (CK VSS) capacitor c=1.07694e-16
C2 (SE VSS) capacitor c=4.26541e-17
C3 (SN VSS) capacitor c=1.91044e-16
C4 (SI VSS) capacitor c=4.0814e-17
C5 (QN VSS) capacitor c=2.12925e-16
C6 (D VSS) capacitor c=4.0662e-17
C7 (Q VSS) capacitor c=2.84818e-16
C8 (VDD VSS) capacitor c=6.55149e-16
C9 (net492 VSS) capacitor c=1.91922e-16
C10 (qbint VSS) capacitor c=2.35708e-16
C11 (n35 VSS) capacitor c=2.06966e-16
C12 (net518 VSS) capacitor c=3.18242e-18
C13 (CKb VSS) capacitor c=3.24901e-17
C14 (mout VSS) capacitor c=2.59816e-17
C15 (CKbb VSS) capacitor c=3.26463e-17
C16 (n20 VSS) capacitor c=2.51871e-17
C17 (Db VSS) capacitor c=4.91516e-17
C18 (net494 VSS) capacitor c=8.83234e-18
C19 (SEb VSS) capacitor c=3.19583e-17
C20 (net405 VSS) capacitor c=8.79322e-17
C21 (net417 VSS) capacitor c=1.10836e-18
C22 (net433 VSS) capacitor c=3.3673e-18
C23 (\7\:SE VSS) capacitor c=5.28682e-17
C24 (\3\:SI VSS) capacitor c=5.56322e-17
C25 (\2\:SE VSS) capacitor c=3.89017e-17
C26 (\3\:D VSS) capacitor c=4.88171e-17
C27 (\1\:CK VSS) capacitor c=3.3654e-17
C28 (\11\:CKb VSS) capacitor c=2.37305e-17
C29 (\5\:CKbb VSS) capacitor c=3.02927e-17
C30 (\5\:CKb VSS) capacitor c=6.9698e-17
C31 (\3\:mout VSS) capacitor c=9.13372e-17
C32 (\4\:n20 VSS) capacitor c=4.55189e-17
C33 (\4\:SN VSS) capacitor c=4.68729e-17
C34 (\3\:CKb VSS) capacitor c=5.26463e-17
C35 (\17\:qbint VSS) capacitor c=5.31648e-17
C36 (\1\:SN VSS) capacitor c=5.25778e-17
C37 (\16\:qbint VSS) capacitor c=3.55076e-17
C38 (\5\:SE VSS) capacitor c=2.99651e-17
C39 (\1\:SI VSS) capacitor c=6.47736e-17
C40 (\3\:SE VSS) capacitor c=6.87488e-17
C41 (\3\:SEb VSS) capacitor c=7.20712e-17
C42 (\1\:D VSS) capacitor c=3.98931e-17
C43 (\3\:CK VSS) capacitor c=4.8259e-17
C44 (\7\:CKb VSS) capacitor c=2.2918e-17
C45 (\9\:CKb VSS) capacitor c=5.05913e-17
C46 (\7\:CKbb VSS) capacitor c=3.98771e-17
C47 (\3\:n20 VSS) capacitor c=6.57676e-17
C48 (\6\:SN VSS) capacitor c=4.17603e-17
C49 (\3\:CKbb VSS) capacitor c=2.74024e-17
C50 (\19\:qbint VSS) capacitor c=2.32118e-17
C51 (\3\:SN VSS) capacitor c=4.46369e-17
C52 (\7\:qbint VSS) capacitor c=2.57208e-17
C53 (\6\:SE VSS) capacitor c=4.43641e-17
C54 (\2\:SI VSS) capacitor c=6.16559e-17
C55 (\4\:SE VSS) capacitor c=4.7594e-17
C56 (\2\:SEb VSS) capacitor c=6.51999e-17
C57 (\1\:SE VSS) capacitor c=4.25606e-17
C58 (\2\:D VSS) capacitor c=5.39514e-17
C59 (\2\:CK VSS) capacitor c=4.39692e-17
C60 (\6\:CKbb VSS) capacitor c=3.69933e-17
C61 (\6\:CKb VSS) capacitor c=2.67541e-17
C62 (\2\:mout VSS) capacitor c=4.88771e-17
C63 (\5\:SN VSS) capacitor c=4.34452e-17
C64 (\4\:CKbb VSS) capacitor c=2.76775e-17
C65 (\4\:CKb VSS) capacitor c=2.69999e-17
C66 (\2\:CKb VSS) capacitor c=3.44292e-17
C67 (\18\:qbint VSS) capacitor c=4.46228e-17
C68 (\2\:SN VSS) capacitor c=6.26177e-17
C69 (\6\:n35 VSS) capacitor c=1.77258e-17
C70 (\9\:qbint VSS) capacitor c=2.28606e-17
C71 (\8\:net492 VSS) capacitor c=9.75019e-18
C72 (\8\:SEb VSS) capacitor c=1.4032e-17
C73 (\6\:VDD VSS) capacitor c=2.8859e-17
C74 (\8\:Db VSS) capacitor c=8.6752e-17
C75 (\8\:VDD VSS) capacitor c=1.81001e-17
C76 (\12\:CKb VSS) capacitor c=5.11017e-17
C77 (\10\:VDD VSS) capacitor c=1.41705e-17
C78 (\10\:CKbb VSS) capacitor c=1.02298e-16
C79 (\6\:Db VSS) capacitor c=8.89775e-17
C80 (\9\:n20 VSS) capacitor c=4.05658e-17
C81 (\13\:VDD VSS) capacitor c=1.49695e-17
C82 (\12\:mout VSS) capacitor c=3.04485e-17
C83 (\16\:VDD VSS) capacitor c=2.84134e-17
C84 (\14\:mout VSS) capacitor c=3.47096e-17
C85 (\10\:n35 VSS) capacitor c=8.60932e-17
C86 (\20\:VDD VSS) capacitor c=2.86854e-17
C87 (\3\:net405 VSS) capacitor c=9.75647e-17
C88 (\26\:qbint VSS) capacitor c=8.70509e-17
C89 (\14\:net492 VSS) capacitor c=3.25352e-17
C90 (\1\:VDD VSS) capacitor c=8.24093e-17
C91 (\4\:SEb VSS) capacitor c=7.53462e-17
C92 (\19\:CKb VSS) capacitor c=5.53213e-17
C93 (\8\:CKbb VSS) capacitor c=8.12608e-17
C94 (\4\:Db VSS) capacitor c=1.67388e-16
C95 (\5\:n20 VSS) capacitor c=5.14752e-17
C96 (\10\:mout VSS) capacitor c=2.97135e-17
C97 (\8\:mout VSS) capacitor c=9.5013e-17
C98 (\12\:n35 VSS) capacitor c=3.50244e-17
C99 (\24\:qbint VSS) capacitor c=2.32681e-17
C100 (\18\:net492 VSS) capacitor c=1.51591e-17
C101 (\6\:qbint VSS) capacitor c=1.36419e-17
C102 (\2\:CKbb VSS) capacitor c=2.29337e-17
C103 (\2\:n20 VSS) capacitor c=3.62463e-17
C104 (\16\:net492 VSS) capacitor c=2.07114e-17
C105 (\17\:net492 VSS) capacitor c=1.8227e-17
C106 (\8\:CKb VSS) capacitor c=3.35554e-17
C107 (\20\:qbint VSS) capacitor c=6.72624e-17
C108 (\21\:qbint VSS) capacitor c=6.43771e-17
C109 (\23\:qbint VSS) capacitor c=4.08533e-17
C110 (\8\:n35 VSS) capacitor c=1.60197e-16
C111 (\9\:n35 VSS) capacitor c=1.61515e-16
C112 (\7\:SN VSS) capacitor c=1.84852e-16
C113 (\8\:SN VSS) capacitor c=8.37469e-17
C114 (\4\:mout VSS) capacitor c=5.23717e-17
C115 (\5\:mout VSS) capacitor c=4.08722e-17
C116 (\6\:mout VSS) capacitor c=3.63553e-17
C117 (\7\:mout VSS) capacitor c=6.57502e-17
C118 (\7\:n20 VSS) capacitor c=6.3996e-17
C119 (\8\:n20 VSS) capacitor c=4.54689e-17
C120 (\12\:CKbb VSS) capacitor c=2.00873e-16
C121 (\13\:CKbb VSS) capacitor c=2.03768e-16
C122 (\14\:CKbb VSS) capacitor c=6.00383e-17
C123 (\14\:CKb VSS) capacitor c=1.29069e-16
C124 (\15\:CKb VSS) capacitor c=9.76116e-17
C125 (\16\:CKb VSS) capacitor c=1.44538e-16
C126 (\17\:CKb VSS) capacitor c=1.59136e-16
C127 (\18\:CKb VSS) capacitor c=8.98833e-17
C128 (\4\:D VSS) capacitor c=7.27952e-17
C129 (\3\:Db VSS) capacitor c=2.16681e-16
C130 (\4\:SI VSS) capacitor c=4.70998e-17
C131 (\8\:SE VSS) capacitor c=5.30396e-17
C132 (\9\:SE VSS) capacitor c=7.68465e-17
C133 (\10\:SE VSS) capacitor c=6.45579e-17
C134 (\6\:SEb VSS) capacitor c=9.57093e-17
C135 (\7\:SEb VSS) capacitor c=5.68098e-17
C136 (\3\:VDD VSS) capacitor c=2.33876e-17
C137 (\4\:VDD VSS) capacitor c=3.17883e-17
C138 (\12\:VDD VSS) capacitor c=4.22e-17
C139 (\15\:VDD VSS) capacitor c=1.83509e-17
C140 (\19\:VDD VSS) capacitor c=1.38208e-17
C141 (\22\:VDD VSS) capacitor c=3.1058e-16
Rk60 (\2\:VSS \3\:VSS) resistor r=0.09006 c=0
Rk61 (\3\:VSS \4\:VSS) resistor r=0.4408 c=0
Rk62 (\4\:VSS \5\:VSS) resistor r=0.2718 c=0
Rk63 (\3\:VSS \7\:VSS) resistor r=0.3106 c=0
Rk64 (\4\:VSS \9\:VSS) resistor r=0.2632 c=0
Rk65 (\5\:VSS \10\:VSS) resistor r=0.5714 c=0
Rk66 (\10\:VSS \11\:VSS) resistor r=0.2794 c=0
Rk67 (\11\:VSS \12\:VSS) resistor r=0.3498 c=0
Rk68 (\12\:VSS \13\:VSS) resistor r=0.5062 c=0
Rk73 (\17\:VSS VSS) resistor r=0.1252 c=0
Rk72 (\13\:VSS \17\:VSS) resistor r=0.06499 c=0
Rk76 (\5\:VSS \21\:VSS) resistor r=0.07145 c=0
Rk77 (\10\:VSS \23\:VSS) resistor r=0.278 c=0
Rk78 (\11\:VSS \25\:VSS) resistor r=0.04329 c=0
Rk47 (\4\:CK CK) resistor r=0.00264 c=0
Rk54 (SE \8\:SE) resistor r=0.1929 c=0
Rk55 (\8\:SE \9\:SE) resistor r=0.2622 c=0
Rk56 (\9\:SE \10\:SE) resistor r=0.4257 c=0
Rk25 (\7\:SN SN) resistor r=1.33 c=0
Rk26 (SN \8\:SN) resistor r=0.4257 c=0
Rk53 (SI \4\:SI) resistor r=0.01176 c=0
Rk48 (D \4\:D) resistor r=0.05101 c=0
Rk86 (\2\:VDD \3\:VDD) resistor r=0.09758 c=0
Rk87 (\3\:VDD \4\:VDD) resistor r=0.4534 c=0
Rk88 (\4\:VDD \5\:VDD) resistor r=0.2505 c=0
Rk89 (\3\:VDD \7\:VDD) resistor r=0.2036 c=0
Rk90 (\4\:VDD \9\:VDD) resistor r=0.2036 c=0
Rk91 (\5\:VDD \11\:VDD) resistor r=0.1199 c=0
Rk92 (\5\:VDD \12\:VDD) resistor r=0.6212 c=0
Rk93 (\12\:VDD \14\:VDD) resistor r=0.04329 c=0
Rk94 (\12\:VDD \15\:VDD) resistor r=0.3672 c=0
Rk95 (\15\:VDD \17\:VDD) resistor r=0.1557 c=0
Rk96 (\15\:VDD \18\:VDD) resistor r=0.2129 c=0
Rk97 (\18\:VDD \19\:VDD) resistor r=0.2881 c=0
Rk98 (\19\:VDD \21\:VDD) resistor r=0.219 c=0
Rk99 (\19\:VDD \22\:VDD) resistor r=0.2328 c=0
Rk108 (\34\:VDD VDD) resistor r=0.1402 c=0
Rk107 (\22\:VDD \34\:VDD) resistor r=0.06499 c=0
Rk7 (\15\:net492 \16\:net492) resistor r=0.2251 c=0
Rk8 (\16\:net492 \17\:net492) resistor r=0.1311 c=0
Rk9 (\16\:net492 \19\:net492) resistor r=0.1174 c=0
Rk16 (\20\:qbint \21\:qbint) resistor r=0.3788 c=0
Rk17 (\21\:qbint \22\:qbint) resistor r=0.06153 c=0
Rk18 (\22\:qbint \23\:qbint) resistor r=0.1475 c=0
Rk19 (\21\:qbint \25\:qbint) resistor r=0.1041 c=0
Rk20 (\22\:qbint \27\:qbint) resistor r=0.3776 c=0
Rk22 (\8\:n35 \9\:n35) resistor r=1.0176 c=0
Rk23 (\9\:n35 \11\:n35) resistor r=0.4233 c=0
Rk24 (\9\:n35 \13\:n35) resistor r=0.08643 c=0
Rk41 (\13\:CKb \14\:CKb) resistor r=0.3463 c=0
Rk42 (\14\:CKb \15\:CKb) resistor r=0.4032 c=0
Rk43 (\14\:CKb \16\:CKb) resistor r=0.6196 c=0
Rk44 (\16\:CKb \17\:CKb) resistor r=0.9034 c=0
Rk45 (\17\:CKb \18\:CKb) resistor r=0.5308 c=0
Rk46 (\15\:CKb \20\:CKb) resistor r=0.3914 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2233 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.1867 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.2377 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.4579 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.1216 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1128 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1202 c=0
Rk37 (\9\:CKbb \11\:CKbb) resistor r=0.3652 c=0
Rk38 (\11\:CKbb \12\:CKbb) resistor r=0.4421 c=0
Rk39 (\12\:CKbb \13\:CKbb) resistor r=1.246 c=0
Rk40 (\12\:CKbb \14\:CKbb) resistor r=0.246 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3333 c=0
Rk35 (\7\:n20 \8\:n20) resistor r=0.2209 c=0
Rk36 (\7\:n20 \10\:n20) resistor r=0.0932 c=0
Rk49 (\2\:Db \3\:Db) resistor r=0.3001 c=0
Rk50 (\3\:Db \5\:Db) resistor r=1.1436 c=0
Rk51 (\5\:Db \7\:Db) resistor r=0.3956 c=0
Rk52 (\3\:Db \9\:Db) resistor r=0.6019 c=0
Rk57 (\5\:SEb \6\:SEb) resistor r=0.7996 c=0
Rk58 (\6\:SEb \7\:SEb) resistor r=0.4064 c=0
Rk59 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rk21 (\2\:net405 \4\:net405) resistor r=0.4518 c=0
Rl57 (\1\:CK \2\:CK) resistor r=62.2302 c=0
Rl58 (\2\:CK \3\:CK) resistor r=158.384 c=0
Rl68 (\6\:SE \7\:SE) resistor r=178.021 c=0
Rl67 (\5\:SE \6\:SE) resistor r=35.7134 c=0
Rl64 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl61 (\1\:SE \2\:SE) resistor r=62.7538 c=0
Rl43 (\4\:SN \5\:SN) resistor r=99.3524 c=0
Rl44 (\5\:SN \6\:SN) resistor r=29.5379 c=0
Rl34 (\1\:SN \2\:SN) resistor r=119.922 c=0
Rl35 (\2\:SN \3\:SN) resistor r=102.615 c=0
Rl66 (\2\:SI \3\:SI) resistor r=130.12 c=0
Rl65 (\1\:SI \2\:SI) resistor r=84.4104 c=0
Rl60 (\2\:D \3\:D) resistor r=118.464 c=0
Rl59 (\1\:D \2\:D) resistor r=113.016 c=0
Rl7 (net492 \8\:net492) resistor r=9.5287 c=0
Rl36 (\18\:qbint \17\:qbint) resistor r=193 c=0
Rl37 (\18\:qbint \19\:qbint) resistor r=29.5379 c=0
Rl20 (qbint \9\:qbint) resistor r=4.8851 c=0
Rl17 (\6\:qbint qbint) resistor r=68.5478 c=0
Rl27 (\6\:qbint \16\:qbint) resistor r=105.003 c=0
Rl18 (\6\:qbint \7\:qbint) resistor r=28.0797 c=0
Rl32 (n35 \6\:n35) resistor r=4.8851 c=0
Rl56 (\10\:CKb \11\:CKb) resistor r=65.0908 c=0
Rl50 (\5\:CKb \6\:CKb) resistor r=62.2302 c=0
Rl42 (\3\:CKb \4\:CKb) resistor r=105.746 c=0
Rl38 (CKb \2\:CKb) resistor r=97.3098 c=0
Rl53 (\7\:CKb \8\:CKb) resistor r=24.1336 c=0
Rl54 (\8\:CKb \9\:CKb) resistor r=179.653 c=0
Rl55 (\8\:CKb \10\:CKb) resistor r=3.3568 c=0
Rl49 (\2\:mout \3\:mout) resistor r=91.2285 c=0
Rl48 (mout \2\:mout) resistor r=28.8462 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl52 (\6\:CKbb \7\:CKbb) resistor r=100.257 c=0
Rl39 (CKbb \2\:CKbb) resistor r=74.2335 c=0
Rl40 (\2\:CKbb \3\:CKbb) resistor r=58.8489 c=0
Rl41 (\2\:CKbb \4\:CKbb) resistor r=62.3759 c=0
Rl47 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl46 (\2\:n20 \3\:n20) resistor r=150.368 c=0
Rl45 (n20 \2\:n20) resistor r=1.2334 c=0
Rl62 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl63 (\2\:SEb \3\:SEb) resistor r=210.285 c=0
Rz16 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz17 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz18 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz19 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz20 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz28 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz29 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz30 (\18\:VDD \1\:VDD) resistor r=6.25 c=0
Rz31 (\34\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\19\:net492 \18\:net492) resistor r=75 c=0
Rz6 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz7 (\13\:n35 \12\:n35) resistor r=75 c=0
Rz12 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\10\:mout \11\:mout) resistor r=75 c=0
Rz11 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz10 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\4\:Db \5\:Db) resistor r=75 c=0
Rz15 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry19 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\17\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry23 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry24 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry25 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry3 (\15\:net492 \14\:net492) resistor r=62 c=0
Ry6 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry9 (\11\:n35 \10\:n35) resistor r=62 c=0
Ry14 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry10 (\12\:mout \13\:mout) resistor r=62 c=0
Ry11 (\14\:mout \15\:mout) resistor r=62 c=0
Ry13 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry12 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry15 (\6\:Db \7\:Db) resistor r=62 c=0
Ry16 (\8\:Db \9\:Db) resistor r=62 c=0
Ry17 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry7 (net405 \2\:net405) resistor r=62 c=0
Ry8 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\6\:SE \8\:SE) resistor r=45 c=0
Rx19 (\4\:SE \9\:SE) resistor r=45 c=0
Rx20 (\1\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SN \7\:SN) resistor r=45 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx16 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\17\:net492 \8\:net492) resistor r=45 c=0
Rx2 (\20\:qbint \18\:qbint) resistor r=45 c=0
Rx3 (\23\:qbint \9\:qbint) resistor r=45 c=0
Rx4 (\8\:n35 \6\:n35) resistor r=45 c=0
Rx11 (\10\:CKb \15\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx7 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (n20 \8\:n20) resistor r=45 c=0
Rx21 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn56 (\18\:net492 \7\:qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.08e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18462e-07 sb=1.61692e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn57_1__rcx (QN net492 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn55_1__rcx (Q qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.077e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.23462e-07 sb=1.52625e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\24\:qbint n35 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.882e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13768e-06 sb=1.24927e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn50 (net521 \3\:SN \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.935e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60638e-06 sb=1.16e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn51 (net518 \19\:qbint net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=7.25e-14 ps=6.1e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.81138e-06 sb=9.55e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn52 (\12\:n35 CKb net518 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.25e-14 ad=3.262e-14 ps=1.29e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.1e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn40 (\12\:n35 \3\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=3.262e-14 ps=5.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn30 (net442 \6\:SN \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=8.7e-15 ps=1.18e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn31 (\10\:mout \3\:n20 net442 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn35 (net478 mout \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn36 (\5\:n20 \7\:CKbb net478 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn25 (\4\:Db \9\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\8\:CKbb \7\:CKb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.175e-14 ad=2.972e-14 ps=1.48e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.8e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn20 (\19\:CKb \3\:CK \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=3.552e-14 ps=9.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.265e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn11 (net494 \1\:D \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=4.205e-14 ps=9.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=9.9e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.55e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.5e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn13 (net506 \1\:SI \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\4\:SEb \5\:SE \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp45 (\26\:qbint n35 \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.828e-14 ad=4.96e-14 ps=1.09e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13016e-06 sb=6.59194e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(2)
mp50 (\3\:net405 \1\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.895e-14 ad=3.44e-14 ps=1.08e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=3.35698e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\3\:net405 \17\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=2.81e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.81e-06 sb=1.30698e-07 sd=160n \
        sca=10.2104 scb=0.00747301 scc=8.05149e-05 m=(1)
mp52 (\10\:n35 CKbb net405 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.91e-14 ad=6.558e-14 ps=1.09e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.28372e-07 sb=4.72326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\10\:n35 \3\:CKb \14\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.63e-14 ad=6.558e-14 ps=7.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78372e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\12\:mout \4\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.842e-14 ad=3.977e-14 ps=2.24e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02791e-07 sb=1.02e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (\12\:mout \4\:n20 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.64e-14 ad=3.977e-14 ps=1.9e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32791e-07 sb=7.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp35 (net417 \3\:mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=1.29e-14 ps=1.9e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.27791e-07 sb=5.95e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\9\:n20 \5\:CKb net417 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.407e-14 ps=5.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.32791e-07 sb=4.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\9\:n20 \5\:CKbb \6\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.407e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.82791e-07 sb=2.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\10\:CKbb \11\:CKb \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.99e-14 ad=3.01e-14 ps=1.97e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19767e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\12\:CKb \1\:CK \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=2.63e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.25e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp11 (net433 \3\:D \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.87e-14 ps=7.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42326e-07 sb=1.03e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp12 (\8\:Db \2\:SE net433 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.87e-14 ps=7.9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.67326e-07 sb=8.05e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp14 (\8\:Db SEb net441 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.87e-14 ps=8.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.92326e-07 sb=5.8e-07 sd=160n sca=10.1879 \
        scb=0.00732855 scc=7.2002e-05 m=(1)
mp13 (net441 \3\:SI \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.085e-14 ps=7.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02733e-06 sb=3.45e-07 sd=160n sca=10.9165 \
        scb=0.00767076 scc=7.22049e-05 m=(1)
mp10 (\8\:SEb \7\:SE \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23233e-06 sb=1.4e-07 sd=160n sca=12.4536 \
        scb=0.00949372 scc=8.10217e-05 m=(1)
ends SDFFSX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:02 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSXL
// View name: extracted

simulator lang=spectre

subckt SDFFSXL CK D Q QN SE SI SN VDD VSS
mp57 (\1\:QN net492 \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.65e-14 ps=9.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.69767e-07 sd=160n sca=23.1398 \
        scb=0.0253243 scc=0.00148794 m=(1)
mp56 (\7\:net492 \5\:qbint \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.63e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=3.33256e-07 sd=160n sca=46.2604 \
        scb=0.0284877 scc=0.00588421 m=(1)
mp55 (\3\:Q qbint \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.758e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=1.28256e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\15\:qbint \3\:n35 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=3.01e-14 ps=8.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.95e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp50 (\3\:net405 \3\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=3.763e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.6e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \8\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.763e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.4e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\5\:n35 \4\:CKbb net405 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\5\:n35 \4\:CKb \11\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\13\:CKbb \2\:CKb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.49e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp30 (\7\:mout \4\:SN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=4.945e-14 ps=1.78e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.225e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (\7\:mout n20 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0943e-13 ad=4.945e-14 ps=1.85e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=9.5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp35 (net417 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0943e-13 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=6.5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp36 (\4\:n20 \7\:CKb net417 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.268e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=5.45e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp25 (\4\:n20 \5\:CKbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=5.268e-14 ps=9.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=2.55e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp20 (\11\:CKb \1\:CK \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (net433 \1\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.58e-14 ps=7.5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp12 (\6\:Db \1\:SE net433 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.75e-07 sd=160n sca=10.4041 \
        scb=0.00751939 scc=8.05211e-05 m=(1)
mp14 (\6\:Db \4\:SEb net441 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.7e-07 sd=160n sca=11.1447 \
        scb=0.00794267 scc=8.08728e-05 m=(1)
mp13 (net441 \3\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=13.2217 \
        scb=0.0107547 scc=0.000102805 m=(1)
mp10 (\9\:SEb \8\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=20.617 \
        scb=0.0226642 scc=0.000873207 m=(1)
C1 (Q VSS) capacitor c=2.19031e-17
C2 (CK VSS) capacitor c=5.18167e-17
C3 (SE VSS) capacitor c=5.04096e-17
C4 (SN VSS) capacitor c=1.85388e-16
C5 (SI VSS) capacitor c=5.05737e-17
C6 (VDD VSS) capacitor c=4.35397e-16
C7 (QN VSS) capacitor c=4.92474e-17
C8 (D VSS) capacitor c=7.78348e-17
C9 (net492 VSS) capacitor c=2.94883e-17
C10 (qbint VSS) capacitor c=1.5556e-17
C11 (n35 VSS) capacitor c=3.31787e-17
C12 (net518 VSS) capacitor c=1.75078e-18
C13 (CKb VSS) capacitor c=1.59703e-17
C14 (mout VSS) capacitor c=7.35231e-17
C15 (CKbb VSS) capacitor c=2.77098e-17
C16 (net442 VSS) capacitor c=2.18407e-18
C17 (n20 VSS) capacitor c=3.38079e-17
C18 (net478 VSS) capacitor c=1.42439e-18
C19 (Db VSS) capacitor c=9.05445e-17
C20 (net494 VSS) capacitor c=5.02687e-18
C21 (net405 VSS) capacitor c=7.35297e-17
C22 (\8\:SE VSS) capacitor c=5.31407e-17
C23 (\3\:SI VSS) capacitor c=5.43391e-17
C24 (\4\:SEb VSS) capacitor c=3.36863e-17
C25 (\1\:SE VSS) capacitor c=4.72804e-17
C26 (\1\:D VSS) capacitor c=7.25133e-17
C27 (\1\:CK VSS) capacitor c=4.25523e-17
C28 (\5\:CKbb VSS) capacitor c=4.66689e-17
C29 (\7\:CKb VSS) capacitor c=7.28715e-17
C30 (\4\:SN VSS) capacitor c=6.79327e-17
C31 (\2\:CKb VSS) capacitor c=4.14238e-17
C32 (\4\:CKb VSS) capacitor c=1.05133e-16
C33 (\4\:CKbb VSS) capacitor c=6.75554e-17
C34 (\8\:qbint VSS) capacitor c=6.92321e-17
C35 (\3\:SN VSS) capacitor c=4.836e-17
C36 (\3\:n35 VSS) capacitor c=5.28435e-17
C37 (\5\:qbint VSS) capacitor c=1.97159e-17
C38 (\5\:SE VSS) capacitor c=3.08675e-17
C39 (\1\:SI VSS) capacitor c=7.65589e-17
C40 (\3\:SE VSS) capacitor c=6.51009e-17
C41 (\3\:SEb VSS) capacitor c=7.48671e-17
C42 (\3\:D VSS) capacitor c=2.3709e-17
C43 (\3\:CK VSS) capacitor c=3.52286e-17
C44 (\9\:CKb VSS) capacitor c=3.65893e-17
C45 (\7\:CKbb VSS) capacitor c=4.15858e-17
C46 (\4\:mout VSS) capacitor c=4.35208e-17
C47 (\3\:n20 VSS) capacitor c=5.41937e-17
C48 (\5\:SN VSS) capacitor c=5.09777e-17
C49 (\6\:CKb VSS) capacitor c=4.31184e-17
C50 (\3\:CKbb VSS) capacitor c=3.07058e-17
C51 (\5\:CKb VSS) capacitor c=1.10805e-16
C52 (\10\:qbint VSS) capacitor c=4.06764e-17
C53 (\1\:SN VSS) capacitor c=5.63438e-17
C54 (\6\:qbint VSS) capacitor c=1.28263e-17
C55 (\7\:qbint VSS) capacitor c=1.26671e-17
C56 (\3\:net492 VSS) capacitor c=1.70384e-17
C57 (\7\:SE VSS) capacitor c=6.05986e-17
C58 (\2\:SI VSS) capacitor c=7.34033e-17
C59 (\4\:SE VSS) capacitor c=5.40625e-17
C60 (\2\:SE VSS) capacitor c=4.47928e-17
C61 (\2\:D VSS) capacitor c=4.19605e-17
C62 (\2\:CK VSS) capacitor c=4.15132e-17
C63 (\10\:CKb VSS) capacitor c=2.6974e-17
C64 (\8\:CKb VSS) capacitor c=2.59152e-17
C65 (\6\:CKbb VSS) capacitor c=6.46316e-17
C66 (\3\:mout VSS) capacitor c=1.64653e-17
C67 (\2\:n20 VSS) capacitor c=4.26956e-17
C68 (\6\:SN VSS) capacitor c=2.7308e-17
C69 (\9\:qbint VSS) capacitor c=6.86292e-17
C70 (\2\:SN VSS) capacitor c=9.18415e-17
C71 (\3\:qbint VSS) capacitor c=4.32805e-18
C72 (\2\:net492 VSS) capacitor c=2.17792e-17
C73 (\9\:SEb VSS) capacitor c=1.36929e-17
C74 (\1\:VDD VSS) capacitor c=3.11601e-17
C75 (\6\:Db VSS) capacitor c=4.80266e-17
C76 (\14\:VDD VSS) capacitor c=3.61195e-17
C77 (\11\:CKb VSS) capacitor c=6.86538e-17
C78 (\4\:Db VSS) capacitor c=1.30678e-16
C79 (\4\:n20 VSS) capacitor c=2.78368e-17
C80 (\16\:VDD VSS) capacitor c=1.4258e-17
C81 (\7\:mout VSS) capacitor c=8.48768e-17
C82 (\18\:VDD VSS) capacitor c=1.8909e-17
C83 (\13\:CKbb VSS) capacitor c=5.34828e-17
C84 (\11\:mout VSS) capacitor c=1.40724e-16
C85 (\5\:n35 VSS) capacitor c=4.41138e-17
C86 (\20\:VDD VSS) capacitor c=3.35012e-17
C87 (\3\:net405 VSS) capacitor c=8.8825e-17
C88 (\22\:VDD VSS) capacitor c=1.29139e-17
C89 (\15\:qbint VSS) capacitor c=5.32195e-17
C90 (\3\:Q VSS) capacitor c=3.71721e-17
C91 (\24\:VDD VSS) capacitor c=5.11291e-17
C92 (\7\:net492 VSS) capacitor c=5.39503e-17
C93 (\1\:QN VSS) capacitor c=4.51677e-17
C94 (\26\:VDD VSS) capacitor c=1.55542e-17
C95 (\3\:VDD VSS) capacitor c=6.23495e-17
C96 (\5\:SEb VSS) capacitor c=5.16162e-17
C97 (\17\:CKb VSS) capacitor c=7.88695e-17
C98 (\8\:Db VSS) capacitor c=8.0784e-17
C99 (\8\:n20 VSS) capacitor c=6.39489e-17
C100 (\9\:mout VSS) capacitor c=3.09311e-17
C101 (\10\:CKbb VSS) capacitor c=3.63982e-17
C102 (\13\:mout VSS) capacitor c=1.19842e-16
C103 (\9\:n35 VSS) capacitor c=8.93119e-17
C104 (\13\:qbint VSS) capacitor c=6.25919e-17
C105 (\1\:Q VSS) capacitor c=6.1085e-17
C106 (\5\:net492 VSS) capacitor c=8.83026e-17
C107 (\3\:QN VSS) capacitor c=3.81091e-17
C108 (\2\:qbint VSS) capacitor c=6.34944e-18
C109 (\4\:qbint VSS) capacitor c=5.49281e-18
C110 (\2\:n35 VSS) capacitor c=5.29898e-17
C111 (\2\:CKbb VSS) capacitor c=2.87912e-17
C112 (\3\:CKb VSS) capacitor c=2.98268e-17
C113 (\2\:mout VSS) capacitor c=3.90246e-17
C114 (\2\:SEb VSS) capacitor c=7.64609e-17
C115 (\4\:net492 VSS) capacitor c=7.11892e-17
C116 (\11\:qbint VSS) capacitor c=6.2794e-17
C117 (\12\:qbint VSS) capacitor c=8.42862e-17
C118 (\17\:qbint VSS) capacitor c=7.41705e-17
C119 (\7\:n35 VSS) capacitor c=1.38601e-16
C120 (\8\:n35 VSS) capacitor c=1.09904e-16
C121 (\7\:SN VSS) capacitor c=1.62844e-16
C122 (\8\:SN VSS) capacitor c=3.16522e-17
C123 (\5\:mout VSS) capacitor c=6.66907e-17
C124 (\6\:mout VSS) capacitor c=4.66114e-17
C125 (\8\:CKbb VSS) capacitor c=1.59306e-16
C126 (\9\:CKbb VSS) capacitor c=1.2174e-16
C127 (\12\:CKbb VSS) capacitor c=4.18618e-17
C128 (\6\:n20 VSS) capacitor c=7.10206e-17
C129 (\7\:n20 VSS) capacitor c=6.3751e-17
C130 (\4\:CK VSS) capacitor c=4.92807e-17
C131 (\13\:CKb VSS) capacitor c=8.79949e-17
C132 (\14\:CKb VSS) capacitor c=7.94286e-17
C133 (\15\:CKb VSS) capacitor c=1.09191e-16
C134 (\16\:CKb VSS) capacitor c=1.42423e-16
C135 (\4\:D VSS) capacitor c=2.13949e-17
C136 (\3\:Db VSS) capacitor c=1.56327e-16
C137 (\4\:SI VSS) capacitor c=7.32612e-17
C138 (\9\:SE VSS) capacitor c=7.10791e-17
C139 (\10\:SE VSS) capacitor c=7.05234e-17
C140 (\7\:SEb VSS) capacitor c=7.26053e-17
C141 (\8\:SEb VSS) capacitor c=5.70097e-17
C142 (\5\:VDD VSS) capacitor c=3.68296e-17
C143 (\6\:VDD VSS) capacitor c=3.35549e-17
C144 (\8\:VDD VSS) capacitor c=3.08135e-17
C145 (\9\:VDD VSS) capacitor c=3.26209e-17
C146 (\10\:VDD VSS) capacitor c=1.26555e-17
C147 (\12\:VDD VSS) capacitor c=1.02031e-17
C148 (\13\:VDD VSS) capacitor c=7.07542e-18
Rk6 (\4\:Q Q) resistor r=0.04195 c=0
Rk5 (\2\:Q \4\:Q) resistor r=0.219 c=0
Rk29 (\4\:CK CK) resistor r=0.1912 c=0
Rk42 (\9\:SE SE) resistor r=0.1768 c=0
Rk41 (\9\:SE \10\:SE) resistor r=0.4141 c=0
Rk43 (SE \11\:SE) resistor r=0.005694 c=0
Rk15 (\7\:SN SN) resistor r=1.3139 c=0
Rk16 (SN \8\:SN) resistor r=0.09304 c=0
Rk40 (SI \4\:SI) resistor r=0.06453 c=0
Rk62 (\2\:VDD \4\:VDD) resistor r=0.4046 c=0
Rk63 (\4\:VDD \5\:VDD) resistor r=0.2204 c=0
Rk64 (\5\:VDD \6\:VDD) resistor r=0.6689 c=0
Rk65 (\6\:VDD \7\:VDD) resistor r=0.06247 c=0
Rk66 (\7\:VDD \8\:VDD) resistor r=0.2069 c=0
Rk67 (\8\:VDD \9\:VDD) resistor r=0.6027 c=0
Rk68 (\9\:VDD \10\:VDD) resistor r=0.1976 c=0
Rk69 (\10\:VDD \11\:VDD) resistor r=0.1928 c=0
Rk70 (\11\:VDD \12\:VDD) resistor r=0.1602 c=0
Rk72 (\13\:VDD VDD) resistor r=0.0171 c=0
Rk71 (\12\:VDD \13\:VDD) resistor r=0.3731 c=0
Rk73 (\5\:VDD \15\:VDD) resistor r=0.2233 c=0
Rk74 (\6\:VDD \17\:VDD) resistor r=0.07358 c=0
Rk75 (\8\:VDD \19\:VDD) resistor r=0.04328 c=0
Rk76 (\9\:VDD \21\:VDD) resistor r=0.2054 c=0
Rk77 (\10\:VDD \23\:VDD) resistor r=0.21 c=0
Rk78 (\12\:VDD \25\:VDD) resistor r=0.4203 c=0
Rk79 (\13\:VDD \27\:VDD) resistor r=0.3464 c=0
Rk1 (\2\:QN QN) resistor r=0.3587 c=0
Rk2 (QN \4\:QN) resistor r=0.03632 c=0
Rk35 (\4\:D D) resistor r=0.0173 c=0
Rk47 (\2\:VSS \4\:VSS) resistor r=0.4576 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.2755 c=0
Rk49 (\5\:VSS \6\:VSS) resistor r=0.5962 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.08001 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.3347 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=0.6353 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.2304 c=0
Rk55 (\11\:VSS VSS) resistor r=0.376 c=0
Rk54 (\10\:VSS \11\:VSS) resistor r=0.1753 c=0
Rk56 (VSS \13\:VSS) resistor r=0.3828 c=0
Rk57 (\5\:VSS \15\:VSS) resistor r=0.2721 c=0
Rk58 (\6\:VSS \17\:VSS) resistor r=0.2133 c=0
Rk59 (\8\:VSS \19\:VSS) resistor r=0.04328 c=0
Rk60 (\9\:VSS \21\:VSS) resistor r=0.3058 c=0
Rk61 (\11\:VSS \23\:VSS) resistor r=0.07358 c=0
Rk3 (\4\:net492 \6\:net492) resistor r=0.5929 c=0
Rk4 (\6\:net492 \8\:net492) resistor r=0.2882 c=0
Rk7 (\11\:qbint \12\:qbint) resistor r=0.3563 c=0
Rk8 (\12\:qbint \14\:qbint) resistor r=0.1393 c=0
Rk9 (\12\:qbint \16\:qbint) resistor r=0.4743 c=0
Rk10 (\14\:qbint \17\:qbint) resistor r=0.5678 c=0
Rk12 (\6\:n35 \7\:n35) resistor r=0.2222 c=0
Rk13 (\7\:n35 \8\:n35) resistor r=0.6787 c=0
Rk14 (\7\:n35 \10\:n35) resistor r=0.3893 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.3782 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.2191 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=0.7001 c=0
Rk33 (\13\:CKb \16\:CKb) resistor r=0.4406 c=0
Rk34 (\16\:CKb \18\:CKb) resistor r=0.587 c=0
Rk17 (\5\:mout \6\:mout) resistor r=0.2914 c=0
Rk18 (\6\:mout \8\:mout) resistor r=0.2281 c=0
Rk19 (\6\:mout \10\:mout) resistor r=0.08248 c=0
Rk20 (\8\:mout \12\:mout) resistor r=0.6494 c=0
Rk21 (\12\:mout \14\:mout) resistor r=0.6934 c=0
Rk22 (\8\:CKbb \9\:CKbb) resistor r=1.0828 c=0
Rk23 (\9\:CKbb \11\:CKbb) resistor r=0.1419 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.1094 c=0
Rk25 (\9\:CKbb \14\:CKbb) resistor r=0.2309 c=0
Rk26 (\5\:n20 \6\:n20) resistor r=0.1268 c=0
Rk27 (\6\:n20 \7\:n20) resistor r=0.3778 c=0
Rk28 (\6\:n20 \9\:n20) resistor r=0.295 c=0
Rk36 (\2\:Db \3\:Db) resistor r=0.7297 c=0
Rk37 (\3\:Db \5\:Db) resistor r=0.6165 c=0
Rk38 (\3\:Db \7\:Db) resistor r=0.2388 c=0
Rk39 (\5\:Db \9\:Db) resistor r=0.4123 c=0
Rk44 (\6\:SEb \7\:SEb) resistor r=0.5552 c=0
Rk45 (\7\:SEb \8\:SEb) resistor r=0.3713 c=0
Rk46 (\7\:SEb \10\:SEb) resistor r=0.04767 c=0
Rk11 (\2\:net405 \4\:net405) resistor r=0.3559 c=0
Rl35 (\1\:CK \2\:CK) resistor r=123.054 c=0
Rl36 (\2\:CK \3\:CK) resistor r=136.333 c=0
Rl43 (\3\:SE \4\:SE) resistor r=39.1533 c=0
Rl39 (\1\:SE \2\:SE) resistor r=74.4182 c=0
Rl48 (\6\:SE \8\:SE) resistor r=199.429 c=0
Rl46 (\5\:SE \6\:SE) resistor r=64.8131 c=0
Rl47 (\6\:SE \7\:SE) resistor r=5.0185 c=0
Rl24 (\4\:SN \5\:SN) resistor r=159.181 c=0
Rl25 (\5\:SN \6\:SN) resistor r=26.1559 c=0
Rl13 (\2\:SN \3\:SN) resistor r=111.916 c=0
Rl12 (\1\:SN \2\:SN) resistor r=92.9995 c=0
Rl45 (\2\:SI \3\:SI) resistor r=104.944 c=0
Rl44 (\1\:SI \2\:SI) resistor r=124.175 c=0
Rl37 (\1\:D \2\:D) resistor r=196.846 c=0
Rl38 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl1 (net492 \2\:net492) resistor r=80.0021 c=0
Rl2 (\2\:net492 \3\:net492) resistor r=24.2328 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=191.541 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=26.1559 c=0
Rl3 (qbint \2\:qbint) resistor r=40.0987 c=0
Rl7 (\2\:qbint \6\:qbint) resistor r=43.9449 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=2.0166 c=0
Rl6 (\4\:qbint \5\:qbint) resistor r=53.6427 c=0
Rl8 (\4\:qbint \7\:qbint) resistor r=37.353 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=34.566 c=0
Rl10 (\2\:n35 \3\:n35) resistor r=165.363 c=0
Rl9 (n35 \2\:n35) resistor r=94.1936 c=0
Rl11 (\2\:n35 \4\:n35) resistor r=16.9983 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=566.873 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=35.3072 c=0
Rl31 (\7\:CKb \8\:CKb) resistor r=52.6149 c=0
Rl19 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl20 (\2\:CKb \3\:CKb) resistor r=90.3625 c=0
Rl21 (\3\:CKb \4\:CKb) resistor r=151.901 c=0
Rl23 (\3\:CKb \6\:CKb) resistor r=70.8353 c=0
Rl28 (mout \2\:mout) resistor r=95.0334 c=0
Rl30 (\2\:mout \4\:mout) resistor r=48.8796 c=0
Rl29 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl32 (\5\:CKbb \6\:CKbb) resistor r=157.235 c=0
Rl33 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl18 (\2\:CKbb \4\:CKbb) resistor r=132.406 c=0
Rl17 (\2\:CKbb \3\:CKbb) resistor r=36.2526 c=0
Rl16 (CKbb \2\:CKbb) resistor r=21.8724 c=0
Rl26 (n20 \2\:n20) resistor r=24.2328 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=143.029 c=0
Rl42 (\2\:SEb \4\:SEb) resistor r=42.7807 c=0
Rl41 (\2\:SEb \3\:SEb) resistor r=221.283 c=0
Rl40 (SEb \2\:SEb) resistor r=8.3086 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz21 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz22 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz23 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz14 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz19 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz20 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz2 (\5\:net492 \6\:net492) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\13\:mout \14\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz9 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\8\:Db \9\:Db) resistor r=75 c=0
Rz13 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry21 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry22 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry23 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry24 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry25 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry17 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry2 (\7\:net492 \8\:net492) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\4\:SE \9\:SE) resistor r=45 c=0
Rx18 (\2\:SE \10\:SE) resistor r=45 c=0
Rx19 (\7\:SE \11\:SE) resistor r=45 c=0
Rx5 (\6\:SN \7\:SN) resistor r=45 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:net492 \4\:net492) resistor r=45 c=0
Rx2 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx3 (\3\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\4\:n35 \8\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (CKbb \12\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (SEb \8\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net492 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.843e-14 ad=2.755e-14 ps=8.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\5\:net492 \7\:qbint \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \6\:qbint \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.828e-14 ps=1.6e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint n35 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.03e-14 ps=7.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn50 (net521 \1\:SN \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=8.7e-15 ps=7.5e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=7.65e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn51 (net518 \10\:qbint net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.48e-14 ps=4.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=6.6e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn52 (\9\:n35 \5\:CKb net518 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.755e-14 ps=7.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=3.75e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn40 (\9\:n35 \3\:CKbb \13\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn21 (\10\:CKbb \6\:CKb \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.517e-14 ad=2.03e-14 ps=1.79e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (net442 \5\:SN \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.517e-14 ad=1.958e-14 ps=1.79e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=3.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn31 (\9\:mout \3\:n20 net442 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net478 \4\:mout \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=8.7e-15 ps=8.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=6.8e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn36 (\8\:n20 \7\:CKbb net478 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.988e-14 ps=4.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=5.75e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\8\:Db \9\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.698e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.03e-14 ps=8.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net494 \3\:D \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=3.77e-14 ps=8.3e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=9.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=2.32e-14 ps=8.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=4.65e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net506 \1\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=3.6e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\5\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
ends SDFFSXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:03 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFTRX1
// View name: extracted

simulator lang=spectre

subckt SDFFTRX1 CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net436 \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
C1 (D VSS) capacitor c=7.91989e-17
C2 (SI VSS) capacitor c=8.64782e-17
C3 (QN VSS) capacitor c=2.29669e-17
C4 (RN VSS) capacitor c=6.30025e-17
C5 (Q VSS) capacitor c=1.70766e-17
C6 (VDD VSS) capacitor c=3.23784e-16
C7 (CK VSS) capacitor c=6.96629e-17
C8 (SE VSS) capacitor c=6.56135e-17
C9 (net436 VSS) capacitor c=2.18789e-17
C10 (qbint VSS) capacitor c=4.50195e-17
C11 (CKb VSS) capacitor c=5.45013e-17
C12 (n30 VSS) capacitor c=5.10791e-17
C13 (mout VSS) capacitor c=7.99829e-17
C14 (CKbb VSS) capacitor c=1.93632e-17
C15 (n20 VSS) capacitor c=1.97545e-17
C16 (Dbp VSS) capacitor c=4.61965e-17
C17 (Db VSS) capacitor c=1.13439e-16
C18 (SEb VSS) capacitor c=4.07741e-17
C19 (net395 VSS) capacitor c=2.89993e-18
C20 (net375 VSS) capacitor c=5.01329e-20
C21 (\1\:D VSS) capacitor c=3.35382e-17
C22 (\1\:RN VSS) capacitor c=5.03813e-17
C23 (\1\:SE VSS) capacitor c=2.71816e-17
C24 (\6\:SE VSS) capacitor c=3.60913e-17
C25 (\1\:SI VSS) capacitor c=4.34466e-17
C26 (\5\:CKb VSS) capacitor c=6.13073e-17
C27 (\6\:CKbb VSS) capacitor c=3.92964e-17
C28 (\8\:CKb VSS) capacitor c=5.87403e-17
C29 (\4\:n20 VSS) capacitor c=3.99945e-17
C30 (\3\:CKb VSS) capacitor c=5.68212e-17
C31 (\3\:CKbb VSS) capacitor c=4.42854e-17
C32 (\8\:qbint VSS) capacitor c=4.37755e-17
C33 (\1\:CK VSS) capacitor c=3.54508e-17
C34 (\7\:qbint VSS) capacitor c=3.11638e-17
C35 (\4\:net436 VSS) capacitor c=4.54578e-17
C36 (\3\:D VSS) capacitor c=3.64e-17
C37 (\3\:RN VSS) capacitor c=2.60523e-17
C38 (\5\:SE VSS) capacitor c=3.71308e-17
C39 (\3\:SEb VSS) capacitor c=3.57849e-17
C40 (\4\:SE VSS) capacitor c=5.30386e-17
C41 (\3\:SI VSS) capacitor c=5.36207e-17
C42 (\9\:CKb VSS) capacitor c=2.35854e-17
C43 (\10\:CKb VSS) capacitor c=2.80188e-17
C44 (\4\:CKbb VSS) capacitor c=7.99498e-17
C45 (\3\:mout VSS) capacitor c=5.25619e-17
C46 (\3\:n20 VSS) capacitor c=3.89952e-17
C47 (\11\:qbint VSS) capacitor c=5.0156e-17
C48 (\2\:n30 VSS) capacitor c=4.32167e-17
C49 (\3\:CK VSS) capacitor c=4.27151e-17
C50 (\5\:qbint VSS) capacitor c=2.92187e-17
C51 (\4\:qbint VSS) capacitor c=2.74337e-17
C52 (\3\:net436 VSS) capacitor c=3.80289e-17
C53 (\2\:D VSS) capacitor c=3.7242e-17
C54 (\2\:RN VSS) capacitor c=4.0913e-17
C55 (\2\:SE VSS) capacitor c=4.94766e-17
C56 (\4\:SEb VSS) capacitor c=4.16052e-17
C57 (\2\:SEb VSS) capacitor c=4.6275e-17
C58 (\2\:SI VSS) capacitor c=5.69348e-17
C59 (\7\:CKbb VSS) capacitor c=4.21271e-17
C60 (\11\:CKb VSS) capacitor c=2.93743e-17
C61 (\5\:CKbb VSS) capacitor c=2.90912e-17
C62 (\2\:mout VSS) capacitor c=5.15503e-17
C63 (\4\:CKb VSS) capacitor c=2.0751e-17
C64 (\2\:CKbb VSS) capacitor c=5.19036e-17
C65 (\2\:CKb VSS) capacitor c=3.28433e-17
C66 (\10\:qbint VSS) capacitor c=5.27633e-17
C67 (\3\:n30 VSS) capacitor c=2.32825e-17
C68 (\2\:CK VSS) capacitor c=2.78309e-17
C69 (\6\:qbint VSS) capacitor c=2.03773e-17
C70 (\1\:VDD VSS) capacitor c=4.17125e-17
C71 (\3\:Db VSS) capacitor c=2.02812e-16
C72 (\11\:VDD VSS) capacitor c=2.06927e-17
C73 (\5\:SEb VSS) capacitor c=1.18666e-16
C74 (\5\:Db VSS) capacitor c=1.29429e-16
C75 (\13\:VDD VSS) capacitor c=4.08934e-17
C76 (\8\:CKbb VSS) capacitor c=8.51042e-17
C77 (\4\:Dbp VSS) capacitor c=1.20971e-16
C78 (\5\:n20 VSS) capacitor c=3.15373e-17
C79 (\15\:VDD VSS) capacitor c=9.0318e-18
C80 (\8\:mout VSS) capacitor c=4.16388e-17
C81 (\4\:n30 VSS) capacitor c=7.53095e-17
C82 (\17\:VDD VSS) capacitor c=3.17715e-17
C83 (\16\:qbint VSS) capacitor c=4.45142e-17
C84 (\15\:CKb VSS) capacitor c=9.37418e-17
C85 (\19\:VDD VSS) capacitor c=3.64584e-17
C86 (\1\:Q VSS) capacitor c=9.61811e-17
C87 (\5\:net436 VSS) capacitor c=2.74392e-17
C88 (\22\:VDD VSS) capacitor c=5.73182e-17
C89 (\1\:QN VSS) capacitor c=4.81242e-17
C90 (\3\:VDD VSS) capacitor c=6.48634e-17
C91 (\7\:SEb VSS) capacitor c=1.31516e-16
C92 (\7\:Db VSS) capacitor c=1.05927e-16
C93 (\8\:Dbp VSS) capacitor c=8.38255e-17
C94 (\14\:CKbb VSS) capacitor c=6.55459e-17
C95 (\6\:Dbp VSS) capacitor c=8.59529e-17
C96 (\9\:n20 VSS) capacitor c=5.5575e-17
C97 (\6\:mout VSS) capacitor c=3.76637e-17
C98 (\6\:n30 VSS) capacitor c=9.99633e-17
C99 (\14\:qbint VSS) capacitor c=8.05533e-17
C100 (\17\:CKb VSS) capacitor c=6.04987e-17
C101 (\3\:Q VSS) capacitor c=5.57635e-17
C102 (\9\:net436 VSS) capacitor c=1.95157e-17
C103 (\3\:QN VSS) capacitor c=2.74556e-17
C104 (\2\:net436 VSS) capacitor c=7.14124e-18
C105 (\2\:qbint VSS) capacitor c=2.30601e-17
C106 (\3\:qbint VSS) capacitor c=3.33487e-17
C107 (\2\:n20 VSS) capacitor c=2.57346e-17
C108 (\6\:CKb VSS) capacitor c=6.13913e-17
C109 (\7\:CKb VSS) capacitor c=7.42802e-17
C110 (\3\:SE VSS) capacitor c=8.91263e-17
C111 (\7\:net436 VSS) capacitor c=2.41457e-17
C112 (\8\:net436 VSS) capacitor c=2.22323e-17
C113 (\4\:CK VSS) capacitor c=4.30876e-17
C114 (\12\:qbint VSS) capacitor c=3.1174e-17
C115 (\13\:qbint VSS) capacitor c=3.18561e-17
C116 (\18\:qbint VSS) capacitor c=1.06323e-16
C117 (\8\:n30 VSS) capacitor c=6.04885e-17
C118 (\4\:mout VSS) capacitor c=5.186e-17
C119 (\5\:mout VSS) capacitor c=5.09291e-17
C120 (\12\:CKb VSS) capacitor c=5.12393e-17
C121 (\13\:CKb VSS) capacitor c=6.79807e-17
C122 (\14\:CKb VSS) capacitor c=9.45778e-17
C123 (\19\:CKb VSS) capacitor c=1.21045e-17
C124 (\20\:CKb VSS) capacitor c=5.41954e-17
C125 (\7\:n20 VSS) capacitor c=5.53094e-17
C126 (\8\:n20 VSS) capacitor c=5.26149e-17
C127 (\10\:CKbb VSS) capacitor c=1.20577e-16
C128 (\11\:CKbb VSS) capacitor c=7.41924e-17
C129 (\12\:CKbb VSS) capacitor c=8.8955e-17
C130 (\13\:CKbb VSS) capacitor c=1.12034e-16
C131 (\16\:CKbb VSS) capacitor c=2.91168e-17
C132 (\4\:SI VSS) capacitor c=4.28298e-17
C133 (\3\:Dbp VSS) capacitor c=1.0455e-16
C134 (\9\:SEb VSS) capacitor c=1.11054e-16
C135 (\10\:SEb VSS) capacitor c=5.45455e-17
C136 (\7\:SE VSS) capacitor c=5.26064e-17
C137 (\4\:RN VSS) capacitor c=3.96668e-17
C138 (\4\:D VSS) capacitor c=4.20097e-17
C139 (\5\:VDD VSS) capacitor c=2.58882e-17
C140 (\6\:VDD VSS) capacitor c=3.298e-17
C141 (\8\:VDD VSS) capacitor c=3.69598e-17
C142 (\9\:VDD VSS) capacitor c=3.01961e-17
C143 (\21\:VDD VSS) capacitor c=1.57649e-17
Rk43 (\4\:D D) resistor r=0.07299 c=0
Rk33 (\4\:SI SI) resistor r=0.09342 c=0
Rk2 (\4\:QN QN) resistor r=0.0928 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk42 (\4\:RN RN) resistor r=0.1928 c=0
Rk7 (\4\:Q Q) resistor r=0.03363 c=0
Rk6 (\2\:Q \4\:Q) resistor r=0.491 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.6439 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.06746 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.6812 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.2529 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.2955 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.5133 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.3932 c=0
Rk54 (\5\:VDD \12\:VDD) resistor r=0.1762 c=0
Rk55 (\6\:VDD \14\:VDD) resistor r=0.2923 c=0
Rk56 (\8\:VDD \16\:VDD) resistor r=0.07334 c=0
Rk57 (\9\:VDD \18\:VDD) resistor r=0.2446 c=0
Rk58 (\10\:VDD \20\:VDD) resistor r=0.3229 c=0
Rk61 (\21\:VDD VDD) resistor r=0.2 c=0
Rk59 (\10\:VDD \21\:VDD) resistor r=0.3512 c=0
Rk60 (\21\:VDD \23\:VDD) resistor r=0.4324 c=0
Rk8 (\4\:CK CK) resistor r=0.1143 c=0
Rk62 (\2\:VSS \3\:VSS) resistor r=0.08249 c=0
Rk63 (\3\:VSS \4\:VSS) resistor r=0.6661 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.2529 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.2945 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.4964 c=0
Rk67 (\7\:VSS \8\:VSS) resistor r=0.4073 c=0
Rk68 (\3\:VSS \10\:VSS) resistor r=0.1821 c=0
Rk69 (\4\:VSS \12\:VSS) resistor r=0.303 c=0
Rk70 (\6\:VSS \14\:VSS) resistor r=0.04326 c=0
Rk71 (\7\:VSS \16\:VSS) resistor r=0.04326 c=0
Rk73 (\17\:VSS VSS) resistor r=0.215 c=0
Rk72 (\8\:VSS \17\:VSS) resistor r=0.3361 c=0
Rk74 (\8\:VSS \19\:VSS) resistor r=0.3347 c=0
Rk75 (\17\:VSS \21\:VSS) resistor r=0.07334 c=0
Rk41 (\7\:SE SE) resistor r=0.03494 c=0
Rk3 (\6\:net436 \7\:net436) resistor r=0.1174 c=0
Rk4 (\7\:net436 \8\:net436) resistor r=0.119 c=0
Rk5 (\7\:net436 \10\:net436) resistor r=0.1055 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.1669 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1202 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.2251 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.7137 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.4686 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.3611 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.5753 c=0
Rk21 (\16\:CKb \18\:CKb) resistor r=0.272 c=0
Rk22 (\13\:CKb \19\:CKb) resistor r=0.02031 c=0
Rk23 (\14\:CKb \20\:CKb) resistor r=0.3158 c=0
Rk13 (\5\:n30 \7\:n30) resistor r=0.5237 c=0
Rk14 (\7\:n30 \8\:n30) resistor r=0.4249 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2403 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.1339 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.229 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.5668 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.3502 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.2125 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.7325 c=0
Rk31 (\11\:CKbb \15\:CKbb) resistor r=0.3718 c=0
Rk32 (\12\:CKbb \16\:CKbb) resistor r=0.04286 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.1265 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.2701 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.2503 c=0
Rk34 (\2\:Dbp \3\:Dbp) resistor r=0.2771 c=0
Rk35 (\3\:Dbp \5\:Dbp) resistor r=0.4525 c=0
Rk36 (\5\:Dbp \7\:Dbp) resistor r=0.4277 c=0
Rk37 (\3\:Dbp \9\:Dbp) resistor r=0.5421 c=0
Rk44 (\2\:Db \4\:Db) resistor r=1.03 c=0
Rk45 (\4\:Db \6\:Db) resistor r=0.851 c=0
Rk46 (\6\:Db \8\:Db) resistor r=0.5915 c=0
Rk38 (\6\:SEb \8\:SEb) resistor r=0.7061 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.6569 c=0
Rk40 (\9\:SEb \10\:SEb) resistor r=0.2593 c=0
Rl45 (\1\:D \2\:D) resistor r=78.079 c=0
Rl46 (\2\:D \3\:D) resistor r=91.5405 c=0
Rl34 (\1\:SI \2\:SI) resistor r=86.7959 c=0
Rl35 (\2\:SI \3\:SI) resistor r=107.95 c=0
Rl43 (\1\:RN \2\:RN) resistor r=131.925 c=0
Rl44 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl38 (\1\:SE \2\:SE) resistor r=31.5021 c=0
Rl41 (\2\:SE \5\:SE) resistor r=132.487 c=0
Rl42 (\3\:SE \6\:SE) resistor r=97.7584 c=0
Rl40 (\3\:SE \4\:SE) resistor r=168.774 c=0
Rl39 (\2\:SE \3\:SE) resistor r=229.236 c=0
Rl3 (\2\:net436 \4\:net436) resistor r=49.7141 c=0
Rl2 (\2\:net436 \3\:net436) resistor r=34.3295 c=0
Rl1 (net436 \2\:net436) resistor r=5.915 c=0
Rl4 (qbint \2\:qbint) resistor r=68.0527 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=4.8851 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=161.779 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=108.895 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=34.3295 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=0.5166 c=0
Rl33 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=51.1559 c=0
Rl17 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=162.128 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=40.6968 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=151.467 c=0
Rl32 (\7\:CKb \10\:CKb) resistor r=34.2969 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=202.903 c=0
Rl12 (n30 \2\:n30) resistor r=142.308 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl24 (mout \2\:mout) resistor r=87.2302 c=0
Rl25 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=35.7713 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=71.8456 c=0
Rl19 (\2\:CKbb \3\:CKbb) resistor r=110.337 c=0
Rl18 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=99.7141 c=0
Rl21 (n20 \2\:n20) resistor r=2.7713 c=0
Rl37 (\3\:SEb \4\:SEb) resistor r=35.7713 c=0
Rl36 (SEb \2\:SEb) resistor r=79.5379 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz16 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz18 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz19 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz20 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz21 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\9\:net436 \10\:net436) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz5 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (\6\:Dbp \7\:Dbp) resistor r=75 c=0
Rz11 (\8\:Dbp \9\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=7.75 c=0
Ry23 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net436 \6\:net436) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (Dbp \2\:Dbp) resistor r=62 c=0
Ry11 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx18 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\2\:SE \7\:SE) resistor r=45 c=0
Rx1 (net436 \8\:net436) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (n20 \8\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx16 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net436 \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q \5\:qbint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\9\:net436 \4\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\17\:CKb \3\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn45 (\14\:qbint \2\:n30 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.665e-14 ad=2.465e-14 ps=1.39e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.855e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn50 (net460 \11\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.665e-14 ad=1.233e-14 ps=1.39e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.66e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn51 (\6\:n30 CKb net460 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=4.278e-14 ps=4.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.53e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=4.277e-14 ps=8.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.19e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn30 (\6\:mout \3\:n20 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.15e-14 ad=4.132e-14 ps=1.39e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=8.6e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn35 (net452 \3\:mout \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.95e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn36 (\9\:n20 \4\:CKbb net452 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.9e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn25 (\6\:Dbp \10\:CKb \9\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.132e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=2.85e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn21 (\14\:CKbb \9\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (net484 \3\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (\8\:Dbp \4\:SE net484 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.045e-14 ps=6.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\7\:Db \3\:SEb \8\:Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.972e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\7\:SEb \5\:SE \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.03e-14 ps=9.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mn0 (net476 \3\:RN \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.32e-14 ps=9.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=3.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.4e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mp56 (\5\:net436 \7\:qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp20 (\15\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp50 (net395 \8\:qbint \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.43e-14 ad=5.483e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.59e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp51 (\4\:n30 \3\:CKbb net395 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.29e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.085e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp30 (\8\:mout \4\:n20 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.061e-13 ad=3.87e-14 ps=1.85e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.6e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp35 (net375 mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.95e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp36 (\5\:n20 \8\:CKb net375 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.9e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp25 (\5\:n20 \6\:CKbb \4\:Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=4.515e-14 ps=9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=2.35e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp21 (\8\:CKbb \5\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.05e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp12 (net411 \1\:SI \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6e-07 sd=160n sca=12.3081 scb=0.0110829 \
        scc=0.000360616 m=(1)
mp13 (Dbp SEb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.44e-14 ps=8.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=3.45e-07 sd=160n sca=12.3081 scb=0.0110829 \
        scc=0.000360616 m=(1)
mp11 (Dbp \6\:SE \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.4e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp10 (\5\:SEb \1\:SE \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0985e-13 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp0 (\3\:Db \1\:RN \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0985e-13 ad=3.44e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=4.05e-07 sd=160n sca=46.5108 \
        scb=0.0286367 scc=0.00588432 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=2e-07 sd=160n sca=47.9436 scb=0.0302509 \
        scc=0.00589103 m=(1)
ends SDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:04 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFTRX2
// View name: extracted

simulator lang=spectre

subckt SDFFTRX2 CK D Q QN RN SE SI VDD VSS
mp56 (\12\:net436 qbint \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.555e-06 sd=160n sca=50.7282 \
        scb=0.0349898 scc=0.00599471 m=(1)
mp20 (\15\:CKb \1\:CK \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=4.085e-14 ps=1.42e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (net395 \11\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.75e-14 ad=6.45e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.28488e-07 sb=1.63e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\8\:n30 \3\:CKbb net395 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.44e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.73488e-07 sb=1.285e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\8\:n30 \3\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.78488e-07 sb=1.08e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\6\:mout \3\:n20 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.93e-14 ad=3.762e-14 ps=1.57e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09849e-06 sb=8.6e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (net375 \3\:mout \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=1.29e-14 ps=1.57e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36349e-06 sb=5.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\5\:n20 \8\:CKb net375 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46849e-06 sb=4.9e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp25 (\5\:n20 \6\:CKbb \5\:Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69349e-06 sb=2.65e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp21 (\14\:CKbb \9\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp12 (net411 \4\:SI \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp13 (\7\:Dbp SEb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp11 (\7\:Dbp \6\:SE \6\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp10 (\5\:SEb \1\:SE \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.4e-07 sd=160n sca=34.0417 \
        scb=0.0261306 scc=0.00427152 m=(1)
mp0 (\3\:Db \1\:RN \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=4.085e-14 ps=1.85e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.75e-07 sd=160n sca=36.3688 \
        scb=0.0292104 scc=0.00429572 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.4e-07 sd=160n sca=46.9401 \
        scb=0.0448095 scc=0.00567769 m=(1)
C1 (D VSS) capacitor c=4.77567e-17
C2 (SI VSS) capacitor c=6.13027e-17
C3 (RN VSS) capacitor c=5.59598e-17
C4 (QN VSS) capacitor c=2.42191e-17
C5 (VDD VSS) capacitor c=3.75118e-16
C6 (CK VSS) capacitor c=3.16273e-17
C7 (Q VSS) capacitor c=1.1787e-17
C8 (SE VSS) capacitor c=8.26888e-17
C9 (qbint VSS) capacitor c=3.98433e-17
C10 (net436 VSS) capacitor c=1.36364e-16
C11 (CKb VSS) capacitor c=4.94822e-17
C12 (n30 VSS) capacitor c=3.51357e-17
C13 (net460 VSS) capacitor c=3.04253e-18
C14 (mout VSS) capacitor c=5.37329e-17
C15 (CKbb VSS) capacitor c=2.31418e-17
C16 (n20 VSS) capacitor c=4.04099e-17
C17 (Dbp VSS) capacitor c=8.70875e-17
C18 (Db VSS) capacitor c=5.82064e-17
C19 (SEb VSS) capacitor c=4.16272e-17
C20 (net395 VSS) capacitor c=6.78854e-18
C21 (\1\:D VSS) capacitor c=3.71228e-17
C22 (\1\:RN VSS) capacitor c=4.36748e-17
C23 (\1\:SE VSS) capacitor c=2.71511e-17
C24 (\6\:SE VSS) capacitor c=3.77156e-17
C25 (\4\:SI VSS) capacitor c=4.64793e-17
C26 (\9\:CKb VSS) capacitor c=4.77175e-17
C27 (\6\:CKbb VSS) capacitor c=4.46978e-17
C28 (\8\:CKb VSS) capacitor c=9.6673e-17
C29 (\3\:mout VSS) capacitor c=8.40755e-17
C30 (\3\:n20 VSS) capacitor c=4.56551e-17
C31 (\3\:CKb VSS) capacitor c=6.35579e-17
C32 (\3\:CKbb VSS) capacitor c=6.07e-17
C33 (\11\:qbint VSS) capacitor c=3.16818e-17
C34 (\3\:n30 VSS) capacitor c=4.79262e-17
C35 (\1\:CK VSS) capacitor c=3.2557e-17
C36 (\4\:qbint VSS) capacitor c=3.6354e-16
C37 (\3\:D VSS) capacitor c=3.57995e-17
C38 (\3\:RN VSS) capacitor c=4.1748e-17
C39 (\5\:SE VSS) capacitor c=2.70328e-17
C40 (\3\:SEb VSS) capacitor c=3.81849e-17
C41 (\4\:SE VSS) capacitor c=5.00053e-17
C42 (\1\:SI VSS) capacitor c=3.57579e-17
C43 (\5\:CKb VSS) capacitor c=2.30947e-17
C44 (\10\:CKb VSS) capacitor c=2.13934e-17
C45 (\5\:CKbb VSS) capacitor c=8.51757e-17
C46 (\13\:qbint VSS) capacitor c=5.86239e-17
C47 (\3\:CK VSS) capacitor c=2.52472e-17
C48 (\2\:qbint VSS) capacitor c=3.16256e-17
C49 (\2\:D VSS) capacitor c=4.22828e-17
C50 (\2\:RN VSS) capacitor c=3.85288e-17
C51 (\2\:SE VSS) capacitor c=4.97856e-17
C52 (\4\:SEb VSS) capacitor c=3.825e-17
C53 (\2\:SEb VSS) capacitor c=4.77177e-17
C54 (\3\:SI VSS) capacitor c=2.76801e-17
C55 (\7\:CKbb VSS) capacitor c=3.95333e-17
C56 (\4\:CKbb VSS) capacitor c=3.06897e-17
C57 (\11\:CKb VSS) capacitor c=3.20323e-17
C58 (\2\:mout VSS) capacitor c=5.53588e-17
C59 (\4\:CKb VSS) capacitor c=2.66919e-17
C60 (\2\:CKbb VSS) capacitor c=4.49859e-17
C61 (\2\:CKb VSS) capacitor c=3.69892e-17
C62 (\12\:qbint VSS) capacitor c=4.28125e-17
C63 (\2\:n30 VSS) capacitor c=2.56249e-17
C64 (\2\:CK VSS) capacitor c=2.42487e-17
C65 (\4\:net436 VSS) capacitor c=2.99319e-17
C66 (\3\:qbint VSS) capacitor c=1.9595e-17
C67 (\1\:VDD VSS) capacitor c=3.80674e-17
C68 (\3\:Db VSS) capacitor c=1.54817e-16
C69 (\14\:VDD VSS) capacitor c=1.39981e-17
C70 (\5\:SEb VSS) capacitor c=1.42052e-16
C71 (\6\:Db VSS) capacitor c=3.337e-17
C72 (\7\:Dbp VSS) capacitor c=5.015e-17
C73 (\16\:VDD VSS) capacitor c=4.32682e-17
C74 (\14\:CKbb VSS) capacitor c=7.03184e-17
C75 (\5\:Dbp VSS) capacitor c=1.15219e-16
C76 (\5\:n20 VSS) capacitor c=3.80032e-17
C77 (\18\:VDD VSS) capacitor c=1.67278e-17
C78 (\6\:mout VSS) capacitor c=4.30955e-17
C79 (\8\:n30 VSS) capacitor c=7.85443e-17
C80 (\20\:VDD VSS) capacitor c=4.13158e-17
C81 (\15\:qbint VSS) capacitor c=7.43276e-17
C82 (\15\:CKb VSS) capacitor c=1.06879e-16
C83 (\2\:Q VSS) capacitor c=5.39632e-17
C84 (\1\:QN VSS) capacitor c=8.95382e-17
C85 (\12\:net436 VSS) capacitor c=1.80137e-17
C86 (\4\:VDD VSS) capacitor c=7.18147e-17
C87 (\7\:SEb VSS) capacitor c=1.44163e-16
C88 (\8\:Db VSS) capacitor c=1.08878e-16
C89 (\8\:CKbb VSS) capacitor c=5.82056e-17
C90 (\9\:Dbp VSS) capacitor c=7.18801e-17
C91 (\9\:n20 VSS) capacitor c=5.62609e-17
C92 (\8\:mout VSS) capacitor c=3.59359e-17
C93 (\4\:n30 VSS) capacitor c=2.35506e-17
C94 (\17\:qbint VSS) capacitor c=9.28796e-17
C95 (\18\:CKb VSS) capacitor c=6.16944e-17
C96 (\4\:Q VSS) capacitor c=5.44087e-17
C97 (\3\:QN VSS) capacitor c=3.49094e-17
C98 (\10\:net436 VSS) capacitor c=2.71127e-17
C99 (\2\:n20 VSS) capacitor c=4.55036e-17
C100 (\6\:CKb VSS) capacitor c=5.51337e-17
C101 (\7\:CKb VSS) capacitor c=5.75331e-17
C102 (\2\:SI VSS) capacitor c=3.47506e-17
C103 (\8\:net436 VSS) capacitor c=3.06069e-17
C104 (\9\:net436 VSS) capacitor c=1.87671e-17
C105 (\3\:SE VSS) capacitor c=8.78133e-17
C106 (\1\:Q VSS) capacitor c=2.38982e-17
C107 (\4\:CK VSS) capacitor c=8.53082e-17
C108 (\14\:qbint VSS) capacitor c=5.33422e-17
C109 (\21\:qbint VSS) capacitor c=7.81191e-17
C110 (\6\:n30 VSS) capacitor c=8.08107e-17
C111 (\7\:n30 VSS) capacitor c=7.85639e-17
C112 (\4\:mout VSS) capacitor c=4.87335e-17
C113 (\5\:mout VSS) capacitor c=5.25302e-17
C114 (\12\:CKb VSS) capacitor c=5.01629e-17
C115 (\13\:CKb VSS) capacitor c=8.48204e-17
C116 (\14\:CKb VSS) capacitor c=1.33529e-16
C117 (\17\:CKb VSS) capacitor c=5.66276e-17
C118 (\7\:n20 VSS) capacitor c=6.05696e-17
C119 (\8\:n20 VSS) capacitor c=5.16038e-17
C120 (\10\:CKbb VSS) capacitor c=6.57724e-17
C121 (\11\:CKbb VSS) capacitor c=8.37632e-17
C122 (\12\:CKbb VSS) capacitor c=1.14698e-16
C123 (\13\:CKbb VSS) capacitor c=1.34111e-16
C124 (\5\:SI VSS) capacitor c=5.74408e-17
C125 (\3\:Dbp VSS) capacitor c=9.12547e-17
C126 (\9\:SEb VSS) capacitor c=1.3922e-16
C127 (\10\:SEb VSS) capacitor c=5.98212e-17
C128 (\7\:SE VSS) capacitor c=3.5428e-17
C129 (\4\:RN VSS) capacitor c=4.78912e-17
C130 (\4\:D VSS) capacitor c=6.85886e-17
C131 (\5\:Db VSS) capacitor c=1.23783e-16
C132 (\3\:VDD VSS) capacitor c=2.01097e-17
C133 (\6\:VDD VSS) capacitor c=3.91464e-17
C134 (\8\:VDD VSS) capacitor c=3.24145e-17
C135 (\9\:VDD VSS) capacitor c=3.50564e-17
C136 (\10\:VDD VSS) capacitor c=2.16865e-16
Rk47 (D \4\:D) resistor r=0.2296 c=0
Rk36 (\5\:SI SI) resistor r=0.1005 c=0
Rk46 (\4\:RN RN) resistor r=0.2054 c=0
Rk4 (\2\:QN QN) resistor r=0.2983 c=0
Rk5 (QN \4\:QN) resistor r=0.03631 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.6496 c=0
Rk53 (\3\:VDD \5\:VDD) resistor r=0.1652 c=0
Rk54 (\5\:VDD \6\:VDD) resistor r=0.6013 c=0
Rk55 (\6\:VDD \7\:VDD) resistor r=0.4509 c=0
Rk56 (\7\:VDD \8\:VDD) resistor r=0.09754 c=0
Rk57 (\8\:VDD \9\:VDD) resistor r=0.5334 c=0
Rk62 (\10\:VDD VDD) resistor r=0.1925 c=0
Rk58 (\9\:VDD \10\:VDD) resistor r=0.4432 c=0
Rk63 (\3\:VDD \15\:VDD) resistor r=0.07346 c=0
Rk64 (\6\:VDD \17\:VDD) resistor r=0.265 c=0
Rk65 (\8\:VDD \19\:VDD) resistor r=0.07346 c=0
Rk66 (\9\:VDD \21\:VDD) resistor r=0.2616 c=0
Rk9 (CK \4\:CK) resistor r=0.07487 c=0
Rk6 (Q \1\:Q) resistor r=0.01016 c=0
Rk7 (\1\:Q \3\:Q) resistor r=0.187 c=0
Rk8 (\1\:Q \5\:Q) resistor r=0.2035 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.4684 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.5862 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.4659 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.08908 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.5099 c=0
Rk79 (\9\:VSS VSS) resistor r=0.1725 c=0
Rk75 (\8\:VSS \9\:VSS) resistor r=0.4422 c=0
Rk80 (\5\:VSS \14\:VSS) resistor r=0.3429 c=0
Rk81 (\7\:VSS \16\:VSS) resistor r=0.04327 c=0
Rk82 (\8\:VSS \18\:VSS) resistor r=0.2915 c=0
Rk45 (\7\:SE SE) resistor r=0.09463 c=0
Rk10 (\14\:qbint \16\:qbint) resistor r=0.257 c=0
Rk12 (\18\:qbint \4\:qbint) resistor r=0.4724 c=0
Rk11 (\16\:qbint \18\:qbint) resistor r=0.3366 c=0
Rk14 (\4\:qbint \21\:qbint) resistor r=0.5476 c=0
Rk1 (\8\:net436 \9\:net436) resistor r=0.1539 c=0
Rk2 (\9\:net436 \11\:net436) resistor r=0.1116 c=0
Rk3 (\9\:net436 \13\:net436) resistor r=0.1457 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.4009 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.4646 c=0
Rk25 (\14\:CKb \16\:CKb) resistor r=0.6799 c=0
Rk26 (\14\:CKb \17\:CKb) resistor r=0.2472 c=0
Rk27 (\16\:CKb \19\:CKb) resistor r=0.2603 c=0
Rk17 (\5\:n30 \6\:n30) resistor r=0.0639 c=0
Rk18 (\6\:n30 \7\:n30) resistor r=0.427 c=0
Rk19 (\6\:n30 \9\:n30) resistor r=0.4183 c=0
Rk20 (\4\:mout \5\:mout) resistor r=0.2414 c=0
Rk21 (\5\:mout \7\:mout) resistor r=0.2614 c=0
Rk22 (\5\:mout \9\:mout) resistor r=0.1457 c=0
Rk31 (\9\:CKbb \10\:CKbb) resistor r=0.3681 c=0
Rk32 (\10\:CKbb \11\:CKbb) resistor r=0.1783 c=0
Rk33 (\11\:CKbb \12\:CKbb) resistor r=0.7534 c=0
Rk34 (\10\:CKbb \13\:CKbb) resistor r=0.4202 c=0
Rk35 (\13\:CKbb \15\:CKbb) resistor r=0.5448 c=0
Rk28 (\6\:n20 \7\:n20) resistor r=0.1636 c=0
Rk29 (\7\:n20 \8\:n20) resistor r=0.2669 c=0
Rk30 (\7\:n20 \10\:n20) resistor r=0.2638 c=0
Rk37 (\2\:Dbp \3\:Dbp) resistor r=0.5463 c=0
Rk38 (\3\:Dbp \4\:Dbp) resistor r=0.4314 c=0
Rk39 (\4\:Dbp \6\:Dbp) resistor r=0.04634 c=0
Rk40 (\3\:Dbp \8\:Dbp) resistor r=0.2374 c=0
Rk41 (\4\:Dbp \10\:Dbp) resistor r=0.4075 c=0
Rk48 (\2\:Db \4\:Db) resistor r=0.4562 c=0
Rk49 (\4\:Db \5\:Db) resistor r=0.8972 c=0
Rk50 (\5\:Db \7\:Db) resistor r=0.09538 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.5127 c=0
Rk42 (\6\:SEb \8\:SEb) resistor r=0.8779 c=0
Rk43 (\8\:SEb \9\:SEb) resistor r=0.8687 c=0
Rk44 (\9\:SEb \10\:SEb) resistor r=0.2797 c=0
Rl49 (\1\:D \2\:D) resistor r=97.3399 c=0
Rl50 (\2\:D \3\:D) resistor r=26.3736 c=0
Rl39 (\2\:SI \4\:SI) resistor r=102.726 c=0
Rl37 (\1\:SI \2\:SI) resistor r=89.1112 c=0
Rl38 (\2\:SI \3\:SI) resistor r=3.1183 c=0
Rl47 (\1\:RN \2\:RN) resistor r=71.8456 c=0
Rl48 (\2\:RN \3\:RN) resistor r=39.1533 c=0
Rl14 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl15 (\2\:CK \3\:CK) resistor r=37.2302 c=0
Rl42 (\1\:SE \2\:SE) resistor r=26.1559 c=0
Rl45 (\2\:SE \5\:SE) resistor r=81.9251 c=0
Rl46 (\3\:SE \6\:SE) resistor r=101.605 c=0
Rl44 (\3\:SE \4\:SE) resistor r=138.005 c=0
Rl43 (\2\:SE \3\:SE) resistor r=300.952 c=0
Rl1 (\2\:qbint qbint) resistor r=92.1596 c=0
Rl18 (\12\:qbint \11\:qbint) resistor r=29.5379 c=0
Rl19 (\12\:qbint \13\:qbint) resistor r=116.076 c=0
Rl2 (\3\:qbint \2\:qbint) resistor r=31.0185 c=0
Rl5 (net436 \4\:net436) resistor r=8.7569 c=0
Rl36 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl23 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl20 (CKb \2\:CKb) resistor r=53.079 c=0
Rl34 (\6\:CKb \9\:CKb) resistor r=160.475 c=0
Rl31 (\5\:CKb \6\:CKb) resistor r=35.2112 c=0
Rl33 (\7\:CKb \8\:CKb) resistor r=251.467 c=0
Rl35 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl32 (\6\:CKb \7\:CKb) resistor r=138.82 c=0
Rl17 (\2\:n30 \3\:n30) resistor r=58.9466 c=0
Rl16 (n30 \2\:n30) resistor r=24.7951 c=0
Rl28 (\2\:mout \3\:mout) resistor r=101.718 c=0
Rl27 (mout \2\:mout) resistor r=37.8119 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=45.3867 c=0
Rl29 (\4\:CKbb \5\:CKbb) resistor r=34.5212 c=0
Rl22 (\2\:CKbb \3\:CKbb) resistor r=133.541 c=0
Rl21 (CKbb \2\:CKbb) resistor r=27.9704 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=56.2212 c=0
Rl24 (n20 \2\:n20) resistor r=111.99 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=5.3317 c=0
Rl41 (\3\:SEb \4\:SEb) resistor r=26.1559 c=0
Rl40 (SEb \2\:SEb) resistor r=73.7687 c=0
Rz2 (\4\:QN \3\:QN) resistor r=75 c=0
Rz15 (\5\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz16 (\7\:VDD \4\:VDD) resistor r=6.25 c=0
Rz17 (\10\:VDD \4\:VDD) resistor r=6.25 c=0
Rz3 (\5\:Q \4\:Q) resistor r=75 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz4 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz1 (\11\:net436 \10\:net436) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (Dbp \2\:Dbp) resistor r=75 c=0
Rz11 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\8\:Db \9\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry2 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \2\:Q) resistor r=20.6667 c=0
Ry23 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry24 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry25 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry4 (\16\:qbint \15\:qbint) resistor r=62 c=0
Ry1 (\13\:net436 \12\:net436) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry11 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx21 (\2\:D \4\:D) resistor r=45 c=0
Rx16 (\3\:SI \5\:SI) resistor r=45 c=0
Rx20 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:SE \7\:SE) resistor r=45 c=0
Rx3 (\14\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\21\:qbint \3\:qbint) resistor r=45 c=0
Rx1 (\8\:net436 \4\:net436) resistor r=45 c=0
Rx9 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx7 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx18 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn56 (\10\:net436 \2\:qbint \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.625e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\18\:CKb \3\:CK \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1e-13 ad=3.19e-14 ps=1.74e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=2.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net460 \13\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=1.958e-14 ps=7.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.66e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn51 (\4\:n30 CKb net460 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.48e-14 ps=5.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.48e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn40 (\4\:n30 CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.48e-14 ps=8.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.195e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn30 (\8\:mout n20 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=3.988e-14 ps=1.52e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=8.75e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn35 (net452 mout \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=8.7e-15 ps=1.52e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=6.1e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn36 (\9\:n20 \5\:CKbb net452 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.64e-14 ps=4.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=5.05e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn25 (\9\:Dbp \10\:CKb \9\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.64e-14 ad=2.03e-14 ps=9.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=1.4e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn21 (\8\:CKbb \5\:CKb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn12 (net484 \1\:SI \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn13 (Dbp \4\:SE net484 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.972e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2.05e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn10 (\7\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn0 (net476 \3\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.015e-14 ps=7.3e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.5e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=3.407e-14 ps=4.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.35e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn57_1__rcx (\3\:QN net436 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.272e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=1.18971e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn55_1__rcx (\4\:Q \4\:qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.78e-14 ad=7.54e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.71058e-07 sb=7.19712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\17\:qbint n30 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.485e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.38134e-06 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mp57 (\1\:QN net436 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.362e-14 ad=6.24e-14 ps=1.18e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.13378e-06 sd=160n sca=31.932 \
        scb=0.0211673 scc=0.00336255 m=(2)
mp55_1__rcx (\2\:Q \4\:qbint \10\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=8.76e-14 ad=1.014e-13 ps=1.31e-06 pd=1.3e-06 \
        nrd=1.16667 nrs=1.16667 sa=7.29551e-07 sb=6.73782e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(2)
mp45 (\15\:qbint \3\:n30 \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.75e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.39597e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends SDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:05 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFTRX4
// View name: extracted

simulator lang=spectre

subckt SDFFTRX4 CK D Q QN RN SE SI VDD VSS
mp1 (\5\:Db \4\:D \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.4e-07 sd=160n sca=36.2105 \
        scb=0.0289447 scc=0.0042917 m=(1)
mp0 (\5\:Db \1\:RN \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=4.085e-14 ps=1.49e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=4.05e-07 sd=160n sca=34.1358 \
        scb=0.0262014 scc=0.0042716 m=(1)
mp10 (\9\:SEb \6\:SE \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.4e-07 sd=160n sca=33.3059 \
        scb=0.0257988 scc=0.00427133 m=(1)
mp11 (\9\:Dbp \5\:SE \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.268e-14 ps=7.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp13 (\9\:Dbp \3\:SEb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.268e-14 ps=5.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=6.15e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp12 (net411 \1\:SI \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=1.72e-14 ps=8.5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.9e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\14\:CKb \1\:CK \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=5.053e-14 ps=8.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.35e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\17\:CKbb \8\:CKb \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp25 (\8\:n20 CKbb Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb net375 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp35 (net375 mout \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.848e-14 ps=8.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.848e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb net395 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp50 (net395 \4\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
C1 (Q VSS) capacitor c=2.39715e-17
C2 (CK VSS) capacitor c=7.11322e-17
C3 (D VSS) capacitor c=2.84813e-17
C4 (SI VSS) capacitor c=6.60778e-17
C5 (QN VSS) capacitor c=1.56514e-17
C6 (VDD VSS) capacitor c=3.61065e-16
C7 (SE VSS) capacitor c=6.19716e-17
C8 (Db VSS) capacitor c=1.05934e-16
C9 (SEb VSS) capacitor c=4.99404e-17
C10 (Dbp VSS) capacitor c=2.13729e-17
C11 (net484 VSS) capacitor c=1.46245e-18
C12 (CKb VSS) capacitor c=7.82702e-17
C13 (CKbb VSS) capacitor c=3.49543e-17
C14 (n20 VSS) capacitor c=5.1853e-17
C15 (mout VSS) capacitor c=6.22266e-17
C16 (n30 VSS) capacitor c=2.16145e-16
C17 (qbint VSS) capacitor c=2.97843e-17
C18 (net436 VSS) capacitor c=2.78527e-16
C19 (net395 VSS) capacitor c=5.26647e-18
C20 (\22\:qbint VSS) capacitor c=4.66957e-17
C21 (\5\:qbint VSS) capacitor c=2.67001e-16
C22 (\4\:qbint VSS) capacitor c=3.89633e-17
C23 (\7\:CKbb VSS) capacitor c=5.08373e-17
C24 (\2\:CKb VSS) capacitor c=1.0612e-16
C25 (\3\:CKb VSS) capacitor c=1.20261e-16
C26 (\8\:CKb VSS) capacitor c=2.6888e-17
C27 (\1\:CK VSS) capacitor c=5.81466e-17
C28 (\1\:SI VSS) capacitor c=8.528e-17
C29 (\3\:SEb VSS) capacitor c=5.53599e-17
C30 (\5\:SE VSS) capacitor c=3.62243e-17
C31 (\6\:SE VSS) capacitor c=2.76079e-17
C32 (\1\:RN VSS) capacitor c=4.01302e-17
C33 (\4\:D VSS) capacitor c=2.85192e-17
C34 (\20\:qbint VSS) capacitor c=3.58492e-17
C35 (\3\:qbint VSS) capacitor c=6.35779e-17
C36 (\5\:CKbb VSS) capacitor c=3.60884e-17
C37 (\3\:n20 VSS) capacitor c=3.32006e-17
C38 (\3\:mout VSS) capacitor c=6.90811e-17
C39 (\3\:CKbb VSS) capacitor c=8.18547e-17
C40 (\7\:CKb VSS) capacitor c=3.33095e-17
C41 (\9\:CKb VSS) capacitor c=1.44712e-17
C42 (\3\:CK VSS) capacitor c=2.4821e-17
C43 (\3\:SI VSS) capacitor c=3.11533e-17
C44 (\1\:SE VSS) capacitor c=6.68987e-17
C45 (\4\:SE VSS) capacitor c=2.69914e-17
C46 (\3\:RN VSS) capacitor c=4.57301e-17
C47 (\1\:D VSS) capacitor c=5.14324e-17
C48 (\21\:qbint VSS) capacitor c=4.06637e-17
C49 (\8\:CKbb VSS) capacitor c=4.00883e-17
C50 (\6\:CKbb VSS) capacitor c=3.39314e-17
C51 (\2\:n20 VSS) capacitor c=3.63214e-17
C52 (\2\:mout VSS) capacitor c=5.71191e-17
C53 (\4\:CKbb VSS) capacitor c=2.53154e-17
C54 (\2\:CKbb VSS) capacitor c=4.15301e-17
C55 (\6\:CKb VSS) capacitor c=1.01851e-17
C56 (\2\:CK VSS) capacitor c=4.22267e-17
C57 (\2\:SI VSS) capacitor c=5.29796e-17
C58 (\4\:SEb VSS) capacitor c=4.269e-17
C59 (\2\:SEb VSS) capacitor c=2.34315e-17
C60 (\3\:SE VSS) capacitor c=4.54854e-17
C61 (\2\:RN VSS) capacitor c=4.31006e-17
C62 (\3\:D VSS) capacitor c=1.27384e-17
C63 (\19\:net436 VSS) capacitor c=3.4963e-17
C64 (\1\:Q VSS) capacitor c=1.52323e-16
C65 (\30\:qbint VSS) capacitor c=5.96205e-17
C66 (\10\:n30 VSS) capacitor c=5.85094e-17
C67 (\4\:mout VSS) capacitor c=2.33674e-17
C68 (\29\:VDD VSS) capacitor c=3.44902e-17
C69 (\8\:n20 VSS) capacitor c=3.53941e-17
C70 (\17\:CKbb VSS) capacitor c=5.18792e-17
C71 (\31\:VDD VSS) capacitor c=3.26324e-17
C72 (\14\:CKb VSS) capacitor c=7.15198e-17
C73 (\33\:VDD VSS) capacitor c=4.21129e-17
C74 (\9\:Dbp VSS) capacitor c=1.88317e-17
C75 (\3\:Db VSS) capacitor c=1.65037e-16
C76 (\9\:SEb VSS) capacitor c=1.2863e-16
C77 (\35\:VDD VSS) capacitor c=2.27971e-17
C78 (\5\:Db VSS) capacitor c=1.51626e-16
C79 (\37\:VDD VSS) capacitor c=3.61567e-17
C80 (\1\:VDD VSS) capacitor c=6.37105e-17
C81 (\15\:net436 VSS) capacitor c=4.45306e-17
C82 (\1\:QN VSS) capacitor c=1.19111e-16
C83 (\24\:qbint VSS) capacitor c=2.14646e-16
C84 (\8\:n30 VSS) capacitor c=6.5001e-17
C85 (\8\:mout VSS) capacitor c=5.26876e-17
C86 (\6\:n20 VSS) capacitor c=3.73304e-17
C87 (\7\:Dbp VSS) capacitor c=1.00578e-16
C88 (\12\:CKbb VSS) capacitor c=8.58798e-17
C89 (\12\:CKb VSS) capacitor c=6.47604e-17
C90 (\5\:Dbp VSS) capacitor c=9.45701e-17
C91 (\7\:SEb VSS) capacitor c=1.35942e-16
C92 (\7\:Db VSS) capacitor c=5.283e-17
C93 (\2\:D VSS) capacitor c=3.00815e-17
C94 (\2\:SE VSS) capacitor c=8.14967e-17
C95 (\4\:CKb VSS) capacitor c=7.30706e-17
C96 (\5\:CKb VSS) capacitor c=2.17849e-17
C97 (\2\:qbint VSS) capacitor c=3.38498e-17
C98 (\5\:D VSS) capacitor c=5.55107e-17
C99 (\4\:RN VSS) capacitor c=1.20683e-16
C100 (\7\:SE VSS) capacitor c=6.17995e-17
C101 (\5\:SEb VSS) capacitor c=1.22683e-16
C102 (\6\:SEb VSS) capacitor c=1.56075e-16
C103 (\4\:SI VSS) capacitor c=5.01263e-17
C104 (\4\:CK VSS) capacitor c=4.6089e-17
C105 (\10\:CKb VSS) capacitor c=3.03577e-17
C106 (\11\:CKb VSS) capacitor c=7.77925e-17
C107 (\3\:Dbp VSS) capacitor c=1.85125e-16
C108 (\4\:Dbp VSS) capacitor c=2.10498e-16
C109 (\4\:n20 VSS) capacitor c=5.85191e-17
C110 (\5\:n20 VSS) capacitor c=5.11866e-17
C111 (\6\:mout VSS) capacitor c=5.44423e-17
C112 (\7\:mout VSS) capacitor c=4.49937e-17
C113 (\9\:CKbb VSS) capacitor c=2.17305e-17
C114 (\10\:CKbb VSS) capacitor c=9.53747e-17
C115 (\11\:CKbb VSS) capacitor c=8.01948e-17
C116 (\14\:CKbb VSS) capacitor c=1.27234e-16
C117 (\15\:CKbb VSS) capacitor c=6.37725e-17
C118 (\16\:CKbb VSS) capacitor c=7.63083e-17
C119 (\6\:n30 VSS) capacitor c=5.19167e-17
C120 (\7\:n30 VSS) capacitor c=8.56421e-17
C121 (\4\:Q VSS) capacitor c=1.22159e-16
C122 (\5\:QN VSS) capacitor c=1.65428e-16
C123 (\23\:qbint VSS) capacitor c=2.438e-16
C124 (\26\:qbint VSS) capacitor c=3.24092e-17
C125 (\27\:qbint VSS) capacitor c=2.28718e-17
C126 (\28\:qbint VSS) capacitor c=4.72822e-17
C127 (\29\:qbint VSS) capacitor c=2.98427e-17
C128 (\17\:net436 VSS) capacitor c=3.5483e-17
C129 (\18\:net436 VSS) capacitor c=3.78918e-17
C130 (\3\:VDD VSS) capacitor c=4.7804e-16
C131 (\10\:VDD VSS) capacitor c=2.00054e-17
C132 (\12\:VDD VSS) capacitor c=2.60623e-17
C133 (\13\:VDD VSS) capacitor c=3.55335e-17
C134 (\15\:VDD VSS) capacitor c=1.22526e-17
C135 (\16\:VDD VSS) capacitor c=7.72461e-18
Rk2 (\4\:RN RN) resistor r=0.01002 c=0
Rk37 (\1\:Q Q) resistor r=0.04991 c=0
Rk38 (Q \4\:Q) resistor r=0.2128 c=0
Rk11 (CK \4\:CK) resistor r=0.1608 c=0
Rk1 (\5\:D D) resistor r=0.1911 c=0
Rk10 (SI \4\:SI) resistor r=0.1745 c=0
Rk43 (\1\:QN QN) resistor r=0.217 c=0
Rk44 (QN \5\:QN) resistor r=0.04798 c=0
Rk80 (\2\:VDD \3\:VDD) resistor r=0.2254 c=0
Rk87 (\3\:VDD \10\:VDD) resistor r=0.5361 c=0
Rk88 (\10\:VDD \11\:VDD) resistor r=0.08755 c=0
Rk89 (\11\:VDD \12\:VDD) resistor r=0.4059 c=0
Rk90 (\12\:VDD \13\:VDD) resistor r=0.3506 c=0
Rk91 (\13\:VDD \14\:VDD) resistor r=0.446 c=0
Rk92 (\14\:VDD \15\:VDD) resistor r=0.1928 c=0
Rk94 (\16\:VDD VDD) resistor r=0.1224 c=0
Rk93 (\15\:VDD \16\:VDD) resistor r=0.2353 c=0
Rk101 (\10\:VDD \30\:VDD) resistor r=0.3636 c=0
Rk102 (\12\:VDD \32\:VDD) resistor r=0.2292 c=0
Rk103 (\13\:VDD \34\:VDD) resistor r=0.244 c=0
Rk104 (\15\:VDD \36\:VDD) resistor r=0.1936 c=0
Rk105 (\16\:VDD \38\:VDD) resistor r=0.4113 c=0
Rk56 (\2\:VSS \3\:VSS) resistor r=0.1252 c=0
Rk63 (\3\:VSS \10\:VSS) resistor r=0.4775 c=0
Rk64 (\10\:VSS \11\:VSS) resistor r=0.07908 c=0
Rk65 (\11\:VSS \12\:VSS) resistor r=0.4786 c=0
Rk66 (\12\:VSS \13\:VSS) resistor r=0.2779 c=0
Rk67 (\13\:VSS \14\:VSS) resistor r=0.446 c=0
Rk69 (\15\:VSS VSS) resistor r=0.343 c=0
Rk68 (\14\:VSS \15\:VSS) resistor r=0.2079 c=0
Rk76 (\10\:VSS \29\:VSS) resistor r=0.04329 c=0
Rk77 (\12\:VSS \31\:VSS) resistor r=0.3791 c=0
Rk78 (\13\:VSS \33\:VSS) resistor r=0.236 c=0
Rk79 (\15\:VSS \35\:VSS) resistor r=0.2903 c=0
Rk3 (\7\:SE SE) resistor r=0.02806 c=0
Rk4 (\2\:Db \4\:Db) resistor r=0.6735 c=0
Rk5 (\4\:Db \6\:Db) resistor r=0.8044 c=0
Rk6 (\6\:Db \8\:Db) resistor r=0.3895 c=0
Rk7 (\5\:SEb \6\:SEb) resistor r=0.8129 c=0
Rk8 (\6\:SEb \8\:SEb) resistor r=0.5887 c=0
Rk9 (\8\:SEb \10\:SEb) resistor r=0.7909 c=0
Rk15 (\2\:Dbp \3\:Dbp) resistor r=0.07204 c=0
Rk16 (\3\:Dbp \4\:Dbp) resistor r=1.3455 c=0
Rk17 (\4\:Dbp \6\:Dbp) resistor r=0.667 c=0
Rk18 (\3\:Dbp \8\:Dbp) resistor r=0.4975 c=0
Rk19 (\4\:Dbp \10\:Dbp) resistor r=0.05258 c=0
Rk12 (\10\:CKb \11\:CKb) resistor r=0.1655 c=0
Rk13 (\11\:CKb \13\:CKb) resistor r=0.3674 c=0
Rk14 (\11\:CKb \15\:CKb) resistor r=0.3375 c=0
Rk26 (\9\:CKbb \10\:CKbb) resistor r=0.02533 c=0
Rk27 (\10\:CKbb \11\:CKbb) resistor r=0.2134 c=0
Rk28 (\11\:CKbb \13\:CKbb) resistor r=0.3986 c=0
Rk29 (\10\:CKbb \14\:CKbb) resistor r=0.771 c=0
Rk30 (\14\:CKbb \15\:CKbb) resistor r=0.3035 c=0
Rk31 (\11\:CKbb \16\:CKbb) resistor r=0.404 c=0
Rk32 (\13\:CKbb \18\:CKbb) resistor r=0.2928 c=0
Rk20 (\4\:n20 \5\:n20) resistor r=0.2802 c=0
Rk21 (\5\:n20 \7\:n20) resistor r=0.1273 c=0
Rk22 (\5\:n20 \9\:n20) resistor r=0.2615 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.1407 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2414 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2584 c=0
Rk33 (\6\:n30 \7\:n30) resistor r=0.2587 c=0
Rk34 (\7\:n30 \9\:n30) resistor r=0.3143 c=0
Rk35 (\7\:n30 \11\:n30) resistor r=0.4203 c=0
Rk47 (\23\:qbint \25\:qbint) resistor r=1.8791 c=0
Rk48 (\25\:qbint \26\:qbint) resistor r=0.4293 c=0
Rk49 (\26\:qbint \27\:qbint) resistor r=0.1058 c=0
Rk50 (\27\:qbint \28\:qbint) resistor r=0.1785 c=0
Rk51 (\26\:qbint \29\:qbint) resistor r=0.06834 c=0
Rk52 (\27\:qbint \31\:qbint) resistor r=0.1976 c=0
Rk53 (\16\:net436 \17\:net436) resistor r=0.3545 c=0
Rk54 (\17\:net436 \18\:net436) resistor r=0.2072 c=0
Rk55 (\17\:net436 \20\:net436) resistor r=0.1266 c=0
Rl4 (\1\:RN \2\:RN) resistor r=78.079 c=0
Rl5 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl15 (\1\:CK \2\:CK) resistor r=212.23 c=0
Rl16 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl3 (\2\:D \4\:D) resistor r=66.0479 c=0
Rl1 (\1\:D \2\:D) resistor r=94.5391 c=0
Rl2 (\2\:D \3\:D) resistor r=12.1383 c=0
Rl13 (\1\:SI \2\:SI) resistor r=210.771 c=0
Rl14 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl11 (\3\:SE \6\:SE) resistor r=33.4251 c=0
Rl9 (\3\:SE \4\:SE) resistor r=76.7181 c=0
Rl10 (\2\:SE \5\:SE) resistor r=122.758 c=0
Rl7 (\1\:SE \2\:SE) resistor r=215.363 c=0
Rl8 (\2\:SE \3\:SE) resistor r=213.851 c=0
Rl12 (\3\:SEb \4\:SEb) resistor r=62.2302 c=0
Rl6 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl25 (\2\:CKb \3\:CKb) resistor r=408.747 c=0
Rl24 (CKb \2\:CKb) resistor r=187.593 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=143.774 c=0
Rl29 (\4\:CKb \7\:CKb) resistor r=55.4507 c=0
Rl30 (\5\:CKb \8\:CKb) resistor r=37.2017 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=9.8883 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=206.49 c=0
Rl32 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl18 (\3\:CKbb \4\:CKbb) resistor r=58.3841 c=0
Rl17 (CKbb \2\:CKbb) resistor r=28.079 c=0
Rl21 (n20 \2\:n20) resistor r=100.692 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl19 (mout \2\:mout) resistor r=37.6944 c=0
Rl20 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl68 (\21\:qbint \22\:qbint) resistor r=62.6944 c=0
Rl67 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl35 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rl33 (\2\:qbint qbint) resistor r=6.99 c=0
Rz27 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz28 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz29 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz30 (\14\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz24 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz25 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz26 (\35\:VSS \34\:VSS) resistor r=75 c=0
Rz1 (Db \2\:Db) resistor r=75 c=0
Rz2 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz5 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz6 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz4 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz9 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz7 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz10 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz15 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz16 (\16\:net436 \15\:net436) resistor r=75 c=0
Ry27 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry28 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry29 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry30 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry31 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry18 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry19 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\14\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:Db \4\:Db) resistor r=62 c=0
Ry2 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (Dbp \2\:Dbp) resistor r=62 c=0
Ry6 (\9\:Dbp \10\:Dbp) resistor r=62 c=0
Ry4 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry9 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry8 (\4\:mout \5\:mout) resistor r=62 c=0
Ry10 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry15 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry16 (\20\:net436 \19\:net436) resistor r=20.6667 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\3\:SE \7\:SE) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx8 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx11 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx15 (\6\:n30 n30) resistor r=45 c=0
Rx16 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx17 (\28\:qbint qbint) resistor r=45 c=0
Rx18 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx19 (\18\:net436 net436) resistor r=45 c=0
mn1 (\7\:Db \1\:D net476 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (net476 \3\:RN \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\7\:SEb \4\:SE \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (Db SEb \5\:Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn13 (\5\:Dbp \1\:SE net484 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.05e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn12 (net484 \3\:SI \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.392e-14 ps=7.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.95e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn20 (\12\:CKb \3\:CK \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn21 (\12\:CKbb \9\:CKb \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\7\:Dbp \7\:CKb \6\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb net452 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (net452 \3\:mout \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.345e-14 ad=3.625e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.553e-14 ps=7.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb net460 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=3.553e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (net460 \3\:qbint \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.088e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.593e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(2)
mn56 (\15\:net436 \20\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn55_1__rcx (\4\:Q \5\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn57_1__rcx (\1\:QN net436 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.095e-14 ad=4.745e-14 ps=1.3325e-06 pd=8.85e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=10.79 scb=0.0100512 scc=0.000418069 m=(4)
mp45 (\30\:qbint n30 \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27395e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp56 (\19\:net436 \22\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
mp57 (\5\:QN net436 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp55_1__rcx (\1\:Q \5\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
ends SDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:06 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFTRXL
// View name: extracted

simulator lang=spectre

subckt SDFFTRXL CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net436 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.5197 \
        scb=0.0328493 scc=0.0059298 m=(1)
mp56 (\5\:net436 \6\:qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=4.837e-14 ps=8.4e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=4.35e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp20 (\15\:CKb \1\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=3.977e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=1.85e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp45 (\15\:qbint n30 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.825e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp50 (net395 \7\:qbint \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.61e-14 ad=5.483e-14 ps=1.35e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.56e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp51 (\7\:n30 \3\:CKbb net395 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.26e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp40 (\7\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.055e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp30 (\8\:mout \3\:n20 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.037e-13 ad=3.87e-14 ps=1.81e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.3e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp35 (net375 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.037e-13 ad=1.29e-14 ps=1.81e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.65e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp36 (\4\:n20 \8\:CKb net375 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.6e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.87e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.35e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp21 (\8\:CKbb \9\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp12 (net411 \4\:SI \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp13 (\6\:Dbp SEb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp11 (\6\:Dbp \7\:SE \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp10 (\5\:SEb \6\:SE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.44e-14 ad=3.01e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp0 (\3\:Db \1\:RN \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.44e-14 ad=4.3e-14 ps=1.56e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=3.85e-07 sd=160n sca=22.1877 \
        scb=0.0209143 scc=0.00225089 m=(1)
mp1 (\3\:Db \4\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.3e-14 ps=7.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.4e-07 sd=160n sca=23.1737 \
        scb=0.0215726 scc=0.00225171 m=(1)
C1 (D VSS) capacitor c=8.98133e-17
C2 (SI VSS) capacitor c=2.65242e-17
C3 (RN VSS) capacitor c=2.88003e-17
C4 (VDD VSS) capacitor c=3.32087e-16
C5 (CK VSS) capacitor c=7.29533e-17
C6 (Q VSS) capacitor c=4.71238e-17
C7 (QN VSS) capacitor c=2.20786e-17
C8 (SE VSS) capacitor c=2.6291e-17
C9 (net436 VSS) capacitor c=2.08137e-17
C10 (qbint VSS) capacitor c=4.27413e-17
C11 (CKb VSS) capacitor c=4.60968e-17
C12 (n30 VSS) capacitor c=5.02332e-17
C13 (net460 VSS) capacitor c=4.17447e-18
C14 (mout VSS) capacitor c=7.63246e-17
C15 (CKbb VSS) capacitor c=2.25269e-17
C16 (n20 VSS) capacitor c=3.98549e-17
C17 (Dbp VSS) capacitor c=1.04148e-16
C18 (Db VSS) capacitor c=1.26017e-16
C19 (SEb VSS) capacitor c=4.14851e-17
C20 (net395 VSS) capacitor c=4.07614e-18
C21 (net375 VSS) capacitor c=4.79291e-20
C22 (\4\:D VSS) capacitor c=3.37545e-17
C23 (\1\:RN VSS) capacitor c=4.39077e-17
C24 (\6\:SE VSS) capacitor c=2.7824e-17
C25 (\7\:SE VSS) capacitor c=3.81274e-17
C26 (\4\:SI VSS) capacitor c=4.59873e-17
C27 (\9\:CKb VSS) capacitor c=5.0594e-17
C28 (\6\:CKbb VSS) capacitor c=4.65109e-17
C29 (\8\:CKb VSS) capacitor c=5.85682e-17
C30 (\3\:n20 VSS) capacitor c=3.71361e-17
C31 (\3\:CKb VSS) capacitor c=5.34695e-17
C32 (\3\:CKbb VSS) capacitor c=4.53365e-17
C33 (\7\:qbint VSS) capacitor c=4.26357e-17
C34 (\1\:CK VSS) capacitor c=3.0729e-17
C35 (\6\:qbint VSS) capacitor c=2.79789e-17
C36 (\4\:net436 VSS) capacitor c=3.15371e-17
C37 (\3\:D VSS) capacitor c=3.05906e-17
C38 (\3\:RN VSS) capacitor c=3.26255e-17
C39 (\1\:SE VSS) capacitor c=3.04012e-17
C40 (\3\:SEb VSS) capacitor c=3.66068e-17
C41 (\5\:SE VSS) capacitor c=6.27555e-17
C42 (\1\:SI VSS) capacitor c=5.2279e-17
C43 (\5\:CKb VSS) capacitor c=3.34714e-17
C44 (\10\:CKb VSS) capacitor c=3.01798e-17
C45 (\4\:CKbb VSS) capacitor c=8.09507e-17
C46 (\3\:mout VSS) capacitor c=5.29132e-17
C47 (\10\:qbint VSS) capacitor c=3.86338e-17
C48 (\2\:n30 VSS) capacitor c=4.03489e-17
C49 (\3\:CK VSS) capacitor c=3.77994e-17
C50 (\5\:qbint VSS) capacitor c=2.11506e-17
C51 (\4\:qbint VSS) capacitor c=2.70819e-17
C52 (\3\:net436 VSS) capacitor c=3.05473e-17
C53 (\1\:D VSS) capacitor c=1.75664e-17
C54 (\2\:RN VSS) capacitor c=4.32635e-17
C55 (\2\:SE VSS) capacitor c=3.198e-17
C56 (\4\:SEb VSS) capacitor c=4.77305e-17
C57 (\2\:SEb VSS) capacitor c=4.20809e-17
C58 (\3\:SI VSS) capacitor c=2.63864e-17
C59 (\7\:CKbb VSS) capacitor c=4.25044e-17
C60 (\11\:CKb VSS) capacitor c=3.20239e-17
C61 (\5\:CKbb VSS) capacitor c=2.98417e-17
C62 (\2\:mout VSS) capacitor c=5.30355e-17
C63 (\2\:n20 VSS) capacitor c=4.30475e-17
C64 (\4\:CKb VSS) capacitor c=2.11792e-17
C65 (\2\:CKbb VSS) capacitor c=4.5628e-17
C66 (\2\:CKb VSS) capacitor c=3.03549e-17
C67 (\9\:qbint VSS) capacitor c=5.1764e-17
C68 (\3\:n30 VSS) capacitor c=2.29256e-17
C69 (\2\:CK VSS) capacitor c=3.63549e-17
C70 (\2\:qbint VSS) capacitor c=4.79849e-17
C71 (\1\:VDD VSS) capacitor c=3.6969e-17
C72 (\3\:Db VSS) capacitor c=2.03636e-16
C73 (\12\:VDD VSS) capacitor c=2.21364e-17
C74 (\5\:SEb VSS) capacitor c=1.00942e-16
C75 (\5\:Db VSS) capacitor c=1.32219e-16
C76 (\6\:Dbp VSS) capacitor c=4.54631e-17
C77 (\14\:VDD VSS) capacitor c=3.8682e-17
C78 (\8\:CKbb VSS) capacitor c=8.48824e-17
C79 (\4\:Dbp VSS) capacitor c=1.04835e-16
C80 (\4\:n20 VSS) capacitor c=3.19627e-17
C81 (\16\:VDD VSS) capacitor c=8.41131e-18
C82 (\8\:mout VSS) capacitor c=4.0655e-17
C83 (\7\:n30 VSS) capacitor c=7.06971e-17
C84 (\18\:VDD VSS) capacitor c=3.11569e-17
C85 (\15\:qbint VSS) capacitor c=4.41722e-17
C86 (\15\:CKb VSS) capacitor c=1.04715e-16
C87 (\20\:VDD VSS) capacitor c=2.61497e-17
C88 (\3\:Q VSS) capacitor c=4.91226e-17
C89 (\5\:net436 VSS) capacitor c=3.45705e-17
C90 (\22\:VDD VSS) capacitor c=3.66927e-17
C91 (\1\:QN VSS) capacitor c=1.97875e-17
C92 (\3\:VDD VSS) capacitor c=7.17098e-17
C93 (\7\:SEb VSS) capacitor c=1.623e-16
C94 (\7\:Db VSS) capacitor c=1.32873e-16
C95 (\14\:CKbb VSS) capacitor c=4.14233e-17
C96 (\8\:Dbp VSS) capacitor c=6.90223e-17
C97 (\8\:n20 VSS) capacitor c=5.97262e-17
C98 (\6\:mout VSS) capacitor c=3.73598e-17
C99 (\5\:n30 VSS) capacitor c=9.13568e-17
C100 (\13\:qbint VSS) capacitor c=9.98903e-17
C101 (\19\:CKb VSS) capacitor c=6.40154e-17
C102 (\1\:Q VSS) capacitor c=7.2366e-17
C103 (\9\:net436 VSS) capacitor c=2.82431e-17
C104 (\3\:QN VSS) capacitor c=3.41876e-17
C105 (\2\:net436 VSS) capacitor c=1.2445e-17
C106 (\3\:qbint VSS) capacitor c=3.82894e-17
C107 (\6\:CKb VSS) capacitor c=6.51832e-17
C108 (\7\:CKb VSS) capacitor c=7.1774e-17
C109 (\2\:SI VSS) capacitor c=3.53319e-17
C110 (\3\:SE VSS) capacitor c=2.50255e-17
C111 (\4\:SE VSS) capacitor c=8.65174e-17
C112 (\7\:net436 VSS) capacitor c=2.95113e-17
C113 (\8\:net436 VSS) capacitor c=2.97844e-17
C114 (\2\:D VSS) capacitor c=2.50996e-17
C115 (\4\:CK VSS) capacitor c=3.04272e-17
C116 (\11\:qbint VSS) capacitor c=3.36171e-17
C117 (\12\:qbint VSS) capacitor c=2.93581e-17
C118 (\17\:qbint VSS) capacitor c=9.02144e-17
C119 (\4\:n30 VSS) capacitor c=7.91282e-17
C120 (\4\:mout VSS) capacitor c=5.38389e-17
C121 (\5\:mout VSS) capacitor c=5.14224e-17
C122 (\12\:CKb VSS) capacitor c=1.64056e-17
C123 (\13\:CKb VSS) capacitor c=6.19298e-17
C124 (\14\:CKb VSS) capacitor c=8.9717e-17
C125 (\17\:CKb VSS) capacitor c=6.14e-17
C126 (\18\:CKb VSS) capacitor c=4.92648e-17
C127 (\6\:n20 VSS) capacitor c=6.13693e-17
C128 (\7\:n20 VSS) capacitor c=5.07428e-17
C129 (\10\:CKbb VSS) capacitor c=1.3287e-16
C130 (\11\:CKbb VSS) capacitor c=6.2803e-17
C131 (\12\:CKbb VSS) capacitor c=9.07828e-17
C132 (\13\:CKbb VSS) capacitor c=1.13122e-16
C133 (\16\:CKbb VSS) capacitor c=2.56444e-17
C134 (\5\:SI VSS) capacitor c=7.53984e-17
C135 (\3\:Dbp VSS) capacitor c=1.19506e-16
C136 (\9\:SEb VSS) capacitor c=1.61695e-16
C137 (\10\:SEb VSS) capacitor c=5.96621e-17
C138 (\8\:SE VSS) capacitor c=1.05467e-16
C139 (\4\:RN VSS) capacitor c=5.74762e-17
C140 (\5\:D VSS) capacitor c=3.8344e-17
C141 (\5\:VDD VSS) capacitor c=2.30049e-17
C142 (\6\:VDD VSS) capacitor c=3.35625e-17
C143 (\8\:VDD VSS) capacitor c=3.18872e-17
C144 (\9\:VDD VSS) capacitor c=3.1542e-17
C145 (\11\:VDD VSS) capacitor c=1.07716e-17
Rk43 (D \5\:D) resistor r=0.1291 c=0
Rk33 (\5\:SI SI) resistor r=0.03534 c=0
Rk42 (RN \4\:RN) resistor r=0.1263 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.52 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.1301 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.606 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.2654 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.2679 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.5133 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.4211 c=0
Rk55 (\11\:VDD VDD) resistor r=0.2025 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.3484 c=0
Rk56 (\5\:VDD \13\:VDD) resistor r=0.1795 c=0
Rk57 (\6\:VDD \15\:VDD) resistor r=0.2624 c=0
Rk58 (\8\:VDD \17\:VDD) resistor r=0.07334 c=0
Rk59 (\9\:VDD \19\:VDD) resistor r=0.2214 c=0
Rk60 (\10\:VDD \21\:VDD) resistor r=0.3351 c=0
Rk61 (\11\:VDD \23\:VDD) resistor r=0.4151 c=0
Rk8 (CK \4\:CK) resistor r=0.08095 c=0
Rk6 (\2\:Q Q) resistor r=0.2325 c=0
Rk7 (Q \4\:Q) resistor r=0.1766 c=0
Rk2 (\4\:QN QN) resistor r=0.08313 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2241 c=0
Rk62 (\2\:VSS \3\:VSS) resistor r=0.0875 c=0
Rk63 (\3\:VSS \4\:VSS) resistor r=0.6336 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.2804 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.2519 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.5114 c=0
Rk67 (\7\:VSS \8\:VSS) resistor r=0.4349 c=0
Rk68 (\3\:VSS \10\:VSS) resistor r=0.293 c=0
Rk69 (\4\:VSS \12\:VSS) resistor r=0.2204 c=0
Rk70 (\6\:VSS \14\:VSS) resistor r=0.04326 c=0
Rk71 (\7\:VSS \16\:VSS) resistor r=0.04326 c=0
Rk73 (\17\:VSS VSS) resistor r=0.2176 c=0
Rk72 (\8\:VSS \17\:VSS) resistor r=0.3337 c=0
Rk74 (\8\:VSS \19\:VSS) resistor r=0.1194 c=0
Rk75 (\17\:VSS \21\:VSS) resistor r=0.07334 c=0
Rk41 (SE \8\:SE) resistor r=0.04113 c=0
Rk3 (\6\:net436 \7\:net436) resistor r=0.1174 c=0
Rk4 (\7\:net436 \8\:net436) resistor r=0.119 c=0
Rk5 (\7\:net436 \10\:net436) resistor r=0.1055 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.1776 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.1202 c=0
Rk11 (\12\:qbint \16\:qbint) resistor r=0.2251 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.7298 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.05038 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2996 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.5266 c=0
Rk21 (\13\:CKb \17\:CKb) resistor r=0.515 c=0
Rk22 (\14\:CKb \18\:CKb) resistor r=0.3162 c=0
Rk23 (\16\:CKb \20\:CKb) resistor r=0.4107 c=0
Rk13 (\4\:n30 \6\:n30) resistor r=0.4506 c=0
Rk14 (\6\:n30 \8\:n30) resistor r=0.4269 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2403 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.1339 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.2297 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.5477 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.4234 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.2125 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.7399 c=0
Rk31 (\11\:CKbb \15\:CKbb) resistor r=0.2495 c=0
Rk32 (\12\:CKbb \16\:CKbb) resistor r=0.04286 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.1244 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.257 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.1998 c=0
Rk34 (\2\:Dbp \3\:Dbp) resistor r=0.6709 c=0
Rk35 (\3\:Dbp \5\:Dbp) resistor r=0.4263 c=0
Rk36 (\3\:Dbp \7\:Dbp) resistor r=0.2392 c=0
Rk37 (\5\:Dbp \9\:Dbp) resistor r=0.395 c=0
Rk44 (\2\:Db \4\:Db) resistor r=1.1956 c=0
Rk45 (\4\:Db \6\:Db) resistor r=0.7797 c=0
Rk46 (\6\:Db \8\:Db) resistor r=0.7843 c=0
Rk38 (\6\:SEb \8\:SEb) resistor r=0.5275 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.8721 c=0
Rk40 (\9\:SEb \10\:SEb) resistor r=0.3236 c=0
Rl47 (\2\:D \4\:D) resistor r=78.5603 c=0
Rl46 (\2\:D \3\:D) resistor r=84.3295 c=0
Rl45 (\1\:D \2\:D) resistor r=15.4894 c=0
Rl34 (\2\:SI \4\:SI) resistor r=102.726 c=0
Rl32 (\1\:SI \2\:SI) resistor r=154.496 c=0
Rl33 (\2\:SI \3\:SI) resistor r=3.1183 c=0
Rl43 (\1\:RN \2\:RN) resistor r=95.3867 c=0
Rl44 (\2\:RN \3\:RN) resistor r=47.3097 c=0
Rl9 (\1\:CK \2\:CK) resistor r=68.4636 c=0
Rl10 (\2\:CK \3\:CK) resistor r=93.4636 c=0
Rl37 (\1\:SE \2\:SE) resistor r=69.0258 c=0
Rl41 (\3\:SE \6\:SE) resistor r=63.143 c=0
Rl38 (\2\:SE \3\:SE) resistor r=17.6971 c=0
Rl42 (\4\:SE \7\:SE) resistor r=124.681 c=0
Rl40 (\4\:SE \5\:SE) resistor r=180.313 c=0
Rl39 (\3\:SE \4\:SE) resistor r=208.082 c=0
Rl3 (\2\:net436 \4\:net436) resistor r=49.7141 c=0
Rl2 (\2\:net436 \3\:net436) resistor r=34.3295 c=0
Rl1 (net436 \2\:net436) resistor r=2.0213 c=0
Rl4 (qbint \2\:qbint) resistor r=131.502 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=58.8489 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=30.0028 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=177.761 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=108.895 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=34.3295 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=0.5166 c=0
Rl31 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=58.8482 c=0
Rl16 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl29 (\6\:CKb \9\:CKb) resistor r=160.998 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=99.845 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl30 (\7\:CKb \10\:CKb) resistor r=45.8353 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=193.595 c=0
Rl11 (n30 \2\:n30) resistor r=142.308 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl22 (mout \2\:mout) resistor r=87.2302 c=0
Rl23 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl24 (\4\:CKbb \5\:CKbb) resistor r=71.8456 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=104.695 c=0
Rl17 (CKbb \2\:CKbb) resistor r=27.9704 c=0
Rl21 (\2\:n20 \3\:n20) resistor r=38.085 c=0
Rl20 (n20 \2\:n20) resistor r=89.6174 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=68.4636 c=0
Rl35 (SEb \2\:SEb) resistor r=73.7687 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz16 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz19 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz20 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz21 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\9\:net436 \10\:net436) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Dbp \2\:Dbp) resistor r=75 c=0
Rz11 (\8\:Dbp \9\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=7.75 c=0
Ry23 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net436 \6\:net436) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry11 (\6\:Dbp \7\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx19 (\1\:D \5\:D) resistor r=45 c=0
Rx14 (\3\:SI \5\:SI) resistor r=45 c=0
Rx18 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\2\:SE \8\:SE) resistor r=45 c=0
Rx1 (net436 \8\:net436) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx7 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\11\:CKb \17\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \4\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx16 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net436 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net436 \4\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.663e-14 ad=2.103e-14 ps=1.58e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=4.7e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn20 (\19\:CKb \3\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.663e-14 ad=3.19e-14 ps=1.58e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.2e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn45 (\13\:qbint \2\:n30 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.765e-14 ad=2.465e-14 ps=1.43e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.855e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn50 (net460 \10\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.765e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.66e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\5\:n30 CKb net460 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.48e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.455e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn40 (\5\:n30 CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=3.48e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.17e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (\6\:mout n20 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=4.278e-14 ps=1.51e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=8.3e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn35 (net452 \3\:mout \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.95e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn36 (\8\:n20 \4\:CKbb net452 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.9e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (\8\:Dbp \10\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=2.85e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\14\:CKbb \5\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn12 (net484 \1\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn13 (Dbp \5\:SE net484 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (\7\:Db \3\:SEb Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.973e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2.05e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\7\:SEb \1\:SE \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.95e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (net476 \3\:RN \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.9e-14 ps=6.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.85e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.9e-14 \
        ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.95e-07 sb=1.4e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
ends SDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:07 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFX1
// View name: extracted

simulator lang=spectre

subckt SDFFX1 CK D Q QN SE SI VDD VSS
mp57 (\1\:QN \4\:net367 \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=35.4384 \
        scb=0.0268597 scc=0.00347151 m=(1)
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.395e-14 ad=5.46e-14 ps=1.24e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.08141e-07 sd=160n sca=23.2995 \
        scb=0.0182724 scc=0.00243236 m=(1)
C1 (QN VSS) capacitor c=2.09463e-17
C2 (CK VSS) capacitor c=6.49766e-17
C3 (SE VSS) capacitor c=4.44978e-17
C4 (Q VSS) capacitor c=6.71908e-17
C5 (VDD VSS) capacitor c=3.24104e-16
C6 (D VSS) capacitor c=3.22268e-17
C7 (net367 VSS) capacitor c=2.3711e-17
C8 (qbint VSS) capacitor c=4.10089e-17
C9 (CKb VSS) capacitor c=4.54256e-17
C10 (n30 VSS) capacitor c=5.26995e-17
C11 (net436 VSS) capacitor c=4.61273e-18
C12 (mout VSS) capacitor c=8.56549e-17
C13 (CKbb VSS) capacitor c=2.24604e-17
C14 (n20 VSS) capacitor c=4.86462e-17
C15 (Db VSS) capacitor c=8.42467e-17
C16 (net449 VSS) capacitor c=6.01168e-18
C17 (SEb VSS) capacitor c=3.78027e-17
C18 (net376 VSS) capacitor c=3.19507e-18
C19 (net384 VSS) capacitor c=3.1537e-18
C20 (\5\:SE VSS) capacitor c=5.15482e-17
C21 (\1\:SI VSS) capacitor c=4.09772e-17
C22 (\2\:SE VSS) capacitor c=3.93094e-17
C23 (\4\:D VSS) capacitor c=5.43541e-17
C24 (\9\:CKb VSS) capacitor c=4.2844e-17
C25 (\6\:CKbb VSS) capacitor c=4.73908e-17
C26 (\8\:CKb VSS) capacitor c=6.76672e-17
C27 (\3\:n20 VSS) capacitor c=3.93911e-17
C28 (\3\:CKb VSS) capacitor c=5.52649e-17
C29 (\3\:CKbb VSS) capacitor c=6.66907e-17
C30 (\8\:qbint VSS) capacitor c=5.87084e-17
C31 (\1\:CK VSS) capacitor c=2.85433e-17
C32 (\7\:qbint VSS) capacitor c=2.65157e-17
C33 (\4\:net367 VSS) capacitor c=4.29525e-17
C34 (\7\:SE VSS) capacitor c=2.76147e-17
C35 (\3\:SI VSS) capacitor c=7.69493e-17
C36 (\3\:SE VSS) capacitor c=6.85252e-17
C37 (\3\:SEb VSS) capacitor c=4.75174e-17
C38 (\1\:D VSS) capacitor c=3.4324e-17
C39 (\5\:CKb VSS) capacitor c=4.06597e-17
C40 (\10\:CKb VSS) capacitor c=2.93057e-17
C41 (\4\:CKbb VSS) capacitor c=8.57095e-17
C42 (\3\:mout VSS) capacitor c=5.55413e-17
C43 (\11\:qbint VSS) capacitor c=3.81448e-17
C44 (\2\:n30 VSS) capacitor c=4.29516e-17
C45 (\3\:CK VSS) capacitor c=3.03184e-17
C46 (\5\:qbint VSS) capacitor c=3.31297e-17
C47 (\4\:qbint VSS) capacitor c=2.78493e-17
C48 (\3\:net367 VSS) capacitor c=3.68741e-17
C49 (\6\:SE VSS) capacitor c=4.48188e-17
C50 (\2\:SI VSS) capacitor c=6.55633e-17
C51 (\4\:SE VSS) capacitor c=5.24707e-17
C52 (\2\:SEb VSS) capacitor c=6.91835e-17
C53 (\1\:SE VSS) capacitor c=3.95192e-17
C54 (\3\:D VSS) capacitor c=2.88583e-17
C55 (\7\:CKbb VSS) capacitor c=3.86218e-17
C56 (\11\:CKb VSS) capacitor c=3.02458e-17
C57 (\5\:CKbb VSS) capacitor c=2.80428e-17
C58 (\2\:mout VSS) capacitor c=5.67614e-17
C59 (\4\:n20 VSS) capacitor c=5.02895e-17
C60 (\2\:CKbb VSS) capacitor c=5.47856e-17
C61 (\4\:CKb VSS) capacitor c=2.45638e-17
C62 (\2\:CKb VSS) capacitor c=3.53569e-17
C63 (\10\:qbint VSS) capacitor c=4.77666e-17
C64 (\3\:n30 VSS) capacitor c=2.17532e-17
C65 (\2\:CK VSS) capacitor c=3.30555e-17
C66 (\6\:qbint VSS) capacitor c=2.61726e-17
C67 (\8\:SEb VSS) capacitor c=1.26588e-17
C68 (\11\:VDD VSS) capacitor c=3.08174e-17
C69 (\6\:Db VSS) capacitor c=3.71967e-17
C70 (\13\:VDD VSS) capacitor c=4.87606e-17
C71 (\15\:CKbb VSS) capacitor c=9.51692e-17
C72 (\4\:Db VSS) capacitor c=1.01229e-16
C73 (\5\:n20 VSS) capacitor c=3.32782e-17
C74 (\15\:VDD VSS) capacitor c=1.34058e-17
C75 (\6\:mout VSS) capacitor c=3.7617e-17
C76 (\4\:n30 VSS) capacitor c=6.77521e-17
C77 (\17\:VDD VSS) capacitor c=1.37569e-17
C78 (\16\:qbint VSS) capacitor c=4.76639e-17
C79 (\15\:CKb VSS) capacitor c=1.15203e-16
C80 (\19\:VDD VSS) capacitor c=4.14704e-17
C81 (\1\:Q VSS) capacitor c=7.73174e-17
C82 (\5\:net367 VSS) capacitor c=3.51978e-17
C83 (\21\:VDD VSS) capacitor c=7.93309e-17
C84 (\1\:QN VSS) capacitor c=5.13721e-17
C85 (\1\:VDD VSS) capacitor c=5.70927e-17
C86 (\4\:SEb VSS) capacitor c=7.80541e-17
C87 (\11\:CKbb VSS) capacitor c=4.83611e-17
C88 (\8\:Db VSS) capacitor c=6.66468e-17
C89 (\9\:n20 VSS) capacitor c=6.43796e-17
C90 (\8\:mout VSS) capacitor c=3.90952e-17
C91 (\6\:n30 VSS) capacitor c=9.16389e-17
C92 (\14\:qbint VSS) capacitor c=8.85657e-17
C93 (\18\:CKb VSS) capacitor c=6.63244e-17
C94 (\9\:net367 VSS) capacitor c=2.08883e-17
C95 (\3\:QN VSS) capacitor c=2.60654e-17
C96 (\2\:net367 VSS) capacitor c=7.40966e-18
C97 (\2\:qbint VSS) capacitor c=1.42998e-17
C98 (\3\:qbint VSS) capacitor c=3.42752e-17
C99 (\6\:CKb VSS) capacitor c=5.17362e-17
C100 (\7\:CKb VSS) capacitor c=6.40982e-17
C101 (\2\:D VSS) capacitor c=2.9945e-17
C102 (\7\:net367 VSS) capacitor c=2.68152e-17
C103 (\8\:net367 VSS) capacitor c=2.56328e-17
C104 (\4\:CK VSS) capacitor c=4.63459e-17
C105 (\12\:qbint VSS) capacitor c=2.83268e-17
C106 (\13\:qbint VSS) capacitor c=3.2702e-17
C107 (\18\:qbint VSS) capacitor c=1.34806e-16
C108 (\8\:n30 VSS) capacitor c=7.98238e-17
C109 (\4\:mout VSS) capacitor c=4.45256e-17
C110 (\5\:mout VSS) capacitor c=4.25237e-17
C111 (\12\:CKb VSS) capacitor c=5.85002e-17
C112 (\13\:CKb VSS) capacitor c=7.06301e-17
C113 (\14\:CKb VSS) capacitor c=9.8746e-17
C114 (\17\:CKb VSS) capacitor c=4.98404e-17
C115 (\7\:n20 VSS) capacitor c=5.42815e-17
C116 (\8\:n20 VSS) capacitor c=4.13903e-17
C117 (\8\:CKbb VSS) capacitor c=1.56846e-17
C118 (\9\:CKbb VSS) capacitor c=8.7578e-17
C119 (\10\:CKbb VSS) capacitor c=6.05114e-17
C120 (\13\:CKbb VSS) capacitor c=1.08114e-16
C121 (\14\:CKbb VSS) capacitor c=1.27892e-16
C122 (\5\:D VSS) capacitor c=7.05617e-17
C123 (\3\:Db VSS) capacitor c=1.46028e-16
C124 (\8\:SE VSS) capacitor c=4.21275e-17
C125 (\9\:SE VSS) capacitor c=7.33569e-17
C126 (\10\:SE VSS) capacitor c=7.04072e-17
C127 (\4\:SI VSS) capacitor c=1.39136e-16
C128 (\6\:SEb VSS) capacitor c=1.19381e-16
C129 (\7\:SEb VSS) capacitor c=8.00403e-17
C130 (\3\:VDD VSS) capacitor c=1.55154e-17
C131 (\4\:VDD VSS) capacitor c=2.14297e-17
C132 (\6\:VDD VSS) capacitor c=4.23864e-17
C133 (\7\:VDD VSS) capacitor c=3.52271e-17
C134 (\9\:VDD VSS) capacitor c=9.84069e-18
C135 (\10\:VDD VSS) capacitor c=1.14073e-17
Rk2 (\4\:QN QN) resistor r=0.07103 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk8 (CK \4\:CK) resistor r=0.203 c=0
Rk39 (\8\:SE SE) resistor r=0.08148 c=0
Rk37 (\8\:SE \9\:SE) resistor r=0.2273 c=0
Rk38 (\9\:SE \10\:SE) resistor r=0.3584 c=0
Rk6 (\2\:Q Q) resistor r=0.3562 c=0
Rk7 (Q \4\:Q) resistor r=0.06161 c=0
Rk40 (SI \4\:SI) resistor r=0.004727 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.1076 c=0
Rk45 (\3\:VDD \4\:VDD) resistor r=0.4506 c=0
Rk46 (\4\:VDD \5\:VDD) resistor r=0.1927 c=0
Rk47 (\5\:VDD \6\:VDD) resistor r=0.3331 c=0
Rk48 (\6\:VDD \7\:VDD) resistor r=0.4857 c=0
Rk49 (\7\:VDD \8\:VDD) resistor r=0.3832 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.05242 c=0
Rk52 (\10\:VDD VDD) resistor r=0.1775 c=0
Rk51 (\9\:VDD \10\:VDD) resistor r=0.3203 c=0
Rk53 (\3\:VDD \12\:VDD) resistor r=0.2824 c=0
Rk54 (\4\:VDD \14\:VDD) resistor r=0.2778 c=0
Rk55 (\6\:VDD \16\:VDD) resistor r=0.07334 c=0
Rk56 (\7\:VDD \18\:VDD) resistor r=0.102 c=0
Rk57 (\9\:VDD \20\:VDD) resistor r=0.2868 c=0
Rk58 (\10\:VDD \22\:VDD) resistor r=0.4029 c=0
Rk32 (\5\:D D) resistor r=0.08015 c=0
Rk59 (\2\:VSS \3\:VSS) resistor r=0.1076 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.4281 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.2153 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.3321 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.4688 c=0
Rk64 (\7\:VSS \8\:VSS) resistor r=0.3973 c=0
Rk65 (\8\:VSS \9\:VSS) resistor r=0.06746 c=0
Rk67 (\10\:VSS VSS) resistor r=0.1925 c=0
Rk66 (\9\:VSS \10\:VSS) resistor r=0.2903 c=0
Rk68 (\3\:VSS \12\:VSS) resistor r=0.2637 c=0
Rk69 (\4\:VSS \14\:VSS) resistor r=0.265 c=0
Rk70 (\6\:VSS \16\:VSS) resistor r=0.04326 c=0
Rk71 (\7\:VSS \18\:VSS) resistor r=0.04326 c=0
Rk72 (\9\:VSS \20\:VSS) resistor r=0.2848 c=0
Rk73 (\10\:VSS \22\:VSS) resistor r=0.07334 c=0
Rk3 (\6\:net367 \7\:net367) resistor r=0.1294 c=0
Rk4 (\7\:net367 \8\:net367) resistor r=0.122 c=0
Rk5 (\7\:net367 \10\:net367) resistor r=0.09348 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.1776 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1202 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.2384 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.7902 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.4318 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2686 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.676 c=0
Rk21 (\14\:CKb \17\:CKb) resistor r=0.3283 c=0
Rk22 (\16\:CKb \19\:CKb) resistor r=0.3818 c=0
Rk13 (\5\:n30 \7\:n30) resistor r=0.3972 c=0
Rk14 (\7\:n30 \8\:n30) resistor r=0.4496 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.19 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2225 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1418 c=0
Rk26 (\8\:CKbb \9\:CKbb) resistor r=0.02782 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.2051 c=0
Rk28 (\10\:CKbb \12\:CKbb) resistor r=0.2493 c=0
Rk29 (\9\:CKbb \13\:CKbb) resistor r=0.696 c=0
Rk30 (\10\:CKbb \14\:CKbb) resistor r=0.4278 c=0
Rk31 (\14\:CKbb \16\:CKbb) resistor r=0.5497 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.1244 c=0
Rk24 (\7\:n20 \8\:n20) resistor r=0.2135 c=0
Rk25 (\7\:n20 \10\:n20) resistor r=0.2139 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.6875 c=0
Rk34 (\3\:Db \5\:Db) resistor r=0.4405 c=0
Rk35 (\3\:Db \7\:Db) resistor r=0.1961 c=0
Rk36 (\5\:Db \9\:Db) resistor r=0.4154 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.7164 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.4988 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.04749 c=0
Rl10 (\1\:CK \2\:CK) resistor r=28.0211 c=0
Rl11 (\2\:CK \3\:CK) resistor r=41.4826 c=0
Rl43 (\5\:SE \6\:SE) resistor r=162.23 c=0
Rl44 (\6\:SE \7\:SE) resistor r=39.1533 c=0
Rl40 (\3\:SE \4\:SE) resistor r=47.3097 c=0
Rl37 (\1\:SE \2\:SE) resistor r=65.2137 c=0
Rl41 (\1\:SI \2\:SI) resistor r=68.4636 c=0
Rl42 (\2\:SI \3\:SI) resistor r=130.002 c=0
Rl36 (\2\:D \4\:D) resistor r=129.649 c=0
Rl34 (\1\:D \2\:D) resistor r=84.3071 c=0
Rl35 (\2\:D \3\:D) resistor r=5.013 c=0
Rl3 (\2\:net367 \4\:net367) resistor r=49.7141 c=0
Rl2 (\2\:net367 \3\:net367) resistor r=34.3295 c=0
Rl1 (net367 \2\:net367) resistor r=5.915 c=0
Rl4 (qbint \2\:qbint) resistor r=58.4373 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=7.9329 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=53.9066 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=36.0826 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=148.082 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=116.588 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=34.3295 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=0.5166 c=0
Rl33 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl18 (\3\:CKb \4\:CKb) resistor r=43.4636 c=0
Rl17 (CKb \2\:CKb) resistor r=47.3097 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=128.08 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=97.1574 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=153.39 c=0
Rl32 (\7\:CKb \10\:CKb) resistor r=40.0661 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=191.223 c=0
Rl12 (n30 \2\:n30) resistor r=150 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl24 (mout \2\:mout) resistor r=97.3098 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=35.3072 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=58.8482 c=0
Rl20 (\2\:CKbb \3\:CKbb) resistor r=158.735 c=0
Rl19 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=39.4748 c=0
Rl21 (n20 \2\:n20) resistor r=97.2848 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=3.9946 c=0
Rl38 (SEb \2\:SEb) resistor r=89.6174 c=0
Rl39 (\2\:SEb \3\:SEb) resistor r=136.093 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz14 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz16 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz19 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz21 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz2 (\9\:net367 \10\:net367) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\8\:Db \9\:Db) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \22\:VDD) resistor r=20.6667 c=0
Ry19 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry20 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry21 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net367 \6\:net367) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\1\:SE \10\:SE) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx14 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (net367 \8\:net367) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\7\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net367 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q \5\:qbint \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.35192e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn56 (\9\:net367 \4\:qbint \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\18\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.698e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\14\:qbint \2\:n30 \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.09e-14 ad=2.465e-14 ps=1.56e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.8e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn50 (net436 \11\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.09e-14 ad=2.32e-14 ps=1.56e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.605e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn51 (\6\:n30 CKb net436 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\6\:n30 CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=3.335e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.125e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\8\:mout n20 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.205e-14 ps=1.56e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (net429 \3\:mout \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=8.7e-15 ps=1.56e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=5.95e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (\9\:n20 \4\:CKbb net429 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=4.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn25 (\9\:n20 \10\:CKb \8\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=2.85e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\11\:CKbb \5\:CKb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net449 \1\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.278e-14 ps=6.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.025e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net449 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=2.32e-14 ps=8.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=6.85e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net461 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=4.8e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net461 \3\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\4\:SEb \7\:SE \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp56 (\5\:net367 \7\:qbint \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp20 (\15\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.395e-14 ad=3.655e-14 ps=1.24e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.7e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.77e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net376 \8\:qbint \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.505e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 \3\:CKbb net376 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.32e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \3\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=9.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.115e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\6\:mout \3\:n20 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=5.16e-14 ps=1.64e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=8.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net356 mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=5.65e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\5\:n20 \8\:CKb net356 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=4.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\5\:n20 \6\:CKbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.085e-14 ps=8.8e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=2.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\15\:CKbb \9\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.763e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp11 (net384 \4\:D \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=2.903e-14 ps=7.8e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.01e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp12 (\6\:Db \2\:SE net384 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.73e-14 ps=7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=8.3e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp14 (\6\:Db SEb net392 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=4.73e-14 ps=7.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.65e-07 sd=160n sca=12.0741 \
        scb=0.0103373 scc=0.000281783 m=(1)
mp13 (net392 \1\:SI \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.763e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.45e-07 sd=160n sca=13.0129 \
        scb=0.0110013 scc=0.000282677 m=(1)
mp10 (\8\:SEb \5\:SE \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.4e-07 sd=160n sca=15.3212 \
        scb=0.0144348 scc=0.000319945 m=(1)
ends SDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:08 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFX2
// View name: extracted

simulator lang=spectre

subckt SDFFX2 CK D Q QN SE SI VDD VSS
mp10 (\10\:SEb \1\:SE \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.39e-06 sd=160n sca=16.6694 \
        scb=0.0168672 scc=0.000344817 m=(1)
mp11 (net384 \1\:D \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.185e-06 sd=160n sca=12.9619 \
        scb=0.0106134 scc=0.000191935 m=(1)
mp12 (\5\:Db \6\:SE net384 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.558e-14 ps=7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.005e-06 sd=160n sca=11.8125 \
        scb=0.00941499 scc=0.000188107 m=(1)
mp14 (\5\:Db \3\:SEb net392 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=6.55e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp13 (net392 \1\:SI \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1327e-13 ad=1.29e-14 ps=1.74e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=5.5e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp21 (\18\:CKbb \7\:CKb \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.1327e-13 ad=3.01e-14 ps=1.74e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.4e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp25 (\9\:n20 CKbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\9\:n20 \2\:CKb net356 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.465e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (net356 mout \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.29e-14 ps=1.62e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.36e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\8\:mout n20 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=5.805e-14 ps=1.62e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.095e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\7\:n30 \9\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.44e-14 ps=9.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=7.8e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\7\:n30 \7\:CKbb net376 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=3.44e-14 ps=6.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=5.75e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (net376 \4\:qbint \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.705e-14 ad=2.687e-14 ps=1.62e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=4.05e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp20 (\13\:CKb \1\:CK \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.857e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.265e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp56 (\8\:net367 \14\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.727e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=28.2418 \
        scb=0.0288633 scc=0.00256816 m=(1)
C1 (D VSS) capacitor c=5.06327e-17
C2 (CK VSS) capacitor c=6.51772e-17
C3 (SI VSS) capacitor c=3.82876e-17
C4 (QN VSS) capacitor c=2.50867e-17
C5 (VDD VSS) capacitor c=3.68706e-16
C6 (Q VSS) capacitor c=4.36319e-17
C7 (SE VSS) capacitor c=7.1095e-17
C8 (SEb VSS) capacitor c=6.4864e-17
C9 (net449 VSS) capacitor c=8.64555e-20
C10 (Db VSS) capacitor c=8.73008e-17
C11 (net461 VSS) capacitor c=1.52853e-18
C12 (CKbb VSS) capacitor c=3.81295e-17
C13 (CKb VSS) capacitor c=3.22442e-17
C14 (n20 VSS) capacitor c=5.03582e-17
C15 (mout VSS) capacitor c=6.08294e-17
C16 (n30 VSS) capacitor c=5.92325e-17
C17 (net436 VSS) capacitor c=1.34497e-18
C18 (qbint VSS) capacitor c=3.3061e-17
C19 (net367 VSS) capacitor c=1.72546e-16
C20 (net384 VSS) capacitor c=1.63206e-18
C21 (net392 VSS) capacitor c=1.24686e-18
C22 (net376 VSS) capacitor c=1.91844e-18
C23 (\14\:qbint VSS) capacitor c=5.93027e-17
C24 (\5\:qbint VSS) capacitor c=4.69636e-16
C25 (\1\:CK VSS) capacitor c=3.147e-17
C26 (\4\:qbint VSS) capacitor c=4.87606e-17
C27 (\7\:CKbb VSS) capacitor c=6.09076e-17
C28 (\9\:CKb VSS) capacitor c=6.58164e-17
C29 (\2\:CKb VSS) capacitor c=6.09503e-17
C30 (\7\:CKb VSS) capacitor c=4.54392e-17
C31 (\1\:SI VSS) capacitor c=6.55088e-17
C32 (\3\:SEb VSS) capacitor c=6.14788e-17
C33 (\6\:SE VSS) capacitor c=4.25288e-17
C34 (\1\:D VSS) capacitor c=3.51228e-17
C35 (\1\:SE VSS) capacitor c=3.95462e-17
C36 (\13\:qbint VSS) capacitor c=3.36692e-17
C37 (\3\:CK VSS) capacitor c=2.84447e-17
C38 (\4\:n30 VSS) capacitor c=3.31759e-17
C39 (\3\:qbint VSS) capacitor c=7.15843e-17
C40 (\8\:CKb VSS) capacitor c=7.87326e-17
C41 (\5\:CKbb VSS) capacitor c=3.55762e-17
C42 (\4\:n20 VSS) capacitor c=3.38161e-17
C43 (\3\:mout VSS) capacitor c=7.44818e-17
C44 (\3\:CKbb VSS) capacitor c=6.92319e-17
C45 (\6\:CKb VSS) capacitor c=3.26943e-17
C46 (\5\:CKb VSS) capacitor c=3.30225e-17
C47 (\3\:SI VSS) capacitor c=3.75096e-17
C48 (\4\:SE VSS) capacitor c=4.70367e-17
C49 (\3\:D VSS) capacitor c=7.60944e-17
C50 (\3\:SE VSS) capacitor c=3.57069e-17
C51 (\12\:qbint VSS) capacitor c=2.85867e-17
C52 (\6\:net367 VSS) capacitor c=2.38419e-17
C53 (\2\:CK VSS) capacitor c=3.38552e-17
C54 (\3\:n30 VSS) capacitor c=2.66129e-17
C55 (\8\:CKbb VSS) capacitor c=4.29369e-17
C56 (\10\:CKb VSS) capacitor c=2.45876e-17
C57 (\6\:CKbb VSS) capacitor c=3.37066e-17
C58 (\3\:n20 VSS) capacitor c=2.97148e-17
C59 (\2\:mout VSS) capacitor c=5.47316e-17
C60 (\4\:CKbb VSS) capacitor c=2.45232e-17
C61 (\2\:CKbb VSS) capacitor c=5.54039e-17
C62 (\2\:SI VSS) capacitor c=4.52624e-17
C63 (\4\:SEb VSS) capacitor c=3.61409e-17
C64 (\5\:SE VSS) capacitor c=6.2372e-17
C65 (\2\:SEb VSS) capacitor c=2.81077e-17
C66 (\2\:D VSS) capacitor c=6.19497e-17
C67 (\2\:SE VSS) capacitor c=3.72947e-17
C68 (\8\:net367 VSS) capacitor c=1.44769e-17
C69 (\1\:QN VSS) capacitor c=9.51028e-17
C70 (\1\:Q VSS) capacitor c=9.1e-17
C71 (\13\:CKb VSS) capacitor c=1.30826e-16
C72 (\24\:qbint VSS) capacitor c=3.24979e-17
C73 (\18\:VDD VSS) capacitor c=2.38453e-17
C74 (\7\:n30 VSS) capacitor c=6.83591e-17
C75 (\8\:mout VSS) capacitor c=2.408e-17
C76 (\20\:VDD VSS) capacitor c=1.70737e-17
C77 (\9\:n20 VSS) capacitor c=4.11499e-17
C78 (\3\:Db VSS) capacitor c=1.68566e-16
C79 (\18\:CKbb VSS) capacitor c=1.03253e-16
C80 (\22\:VDD VSS) capacitor c=3.18708e-17
C81 (\5\:Db VSS) capacitor c=1.69658e-16
C82 (\24\:VDD VSS) capacitor c=3.66784e-17
C83 (\10\:SEb VSS) capacitor c=5.39404e-17
C84 (\1\:VDD VSS) capacitor c=5.8028e-17
C85 (\12\:net367 VSS) capacitor c=2.60359e-17
C86 (\3\:QN VSS) capacitor c=2.72486e-17
C87 (\3\:Q VSS) capacitor c=3.24067e-17
C88 (\11\:CKb VSS) capacitor c=6.52974e-17
C89 (\18\:qbint VSS) capacitor c=8.51141e-17
C90 (\9\:n30 VSS) capacitor c=4.76289e-17
C91 (\6\:mout VSS) capacitor c=6.43574e-17
C92 (\7\:n20 VSS) capacitor c=3.84254e-17
C93 (\13\:CKbb VSS) capacitor c=1.01122e-16
C94 (\7\:Db VSS) capacitor c=8.8083e-17
C95 (\8\:SEb VSS) capacitor c=1.64562e-17
C96 (\3\:CKb VSS) capacitor c=8.69317e-17
C97 (\4\:CKb VSS) capacitor c=3.76935e-17
C98 (\2\:n20 VSS) capacitor c=2.58555e-17
C99 (\2\:qbint VSS) capacitor c=3.33521e-17
C100 (\2\:n30 VSS) capacitor c=2.67165e-17
C101 (\4\:D VSS) capacitor c=7.11369e-17
C102 (\7\:SE VSS) capacitor c=6.50433e-17
C103 (\5\:SEb VSS) capacitor c=1.25767e-16
C104 (\6\:SEb VSS) capacitor c=1.40764e-16
C105 (\7\:SEb VSS) capacitor c=1.20507e-16
C106 (\4\:SI VSS) capacitor c=6.93199e-17
C107 (\5\:n20 VSS) capacitor c=3.82786e-17
C108 (\6\:n20 VSS) capacitor c=5.09407e-17
C109 (\4\:mout VSS) capacitor c=3.44152e-17
C110 (\5\:mout VSS) capacitor c=5.28895e-17
C111 (\9\:CKbb VSS) capacitor c=2.32513e-17
C112 (\10\:CKbb VSS) capacitor c=1.1161e-16
C113 (\11\:CKbb VSS) capacitor c=8.13382e-17
C114 (\12\:CKbb VSS) capacitor c=6.76192e-17
C115 (\15\:CKbb VSS) capacitor c=4.99068e-17
C116 (\16\:CKbb VSS) capacitor c=2.55335e-17
C117 (\17\:CKbb VSS) capacitor c=7.27484e-17
C118 (\5\:n30 VSS) capacitor c=3.49756e-17
C119 (\6\:n30 VSS) capacitor c=6.07299e-17
C120 (\15\:CKb VSS) capacitor c=1.42361e-16
C121 (\16\:CKb VSS) capacitor c=6.43091e-17
C122 (\4\:CK VSS) capacitor c=5.72587e-17
C123 (\15\:qbint VSS) capacitor c=6.3117e-17
C124 (\22\:qbint VSS) capacitor c=3.23885e-17
C125 (\23\:qbint VSS) capacitor c=4.00392e-17
C126 (\10\:net367 VSS) capacitor c=2.01144e-17
C127 (\11\:net367 VSS) capacitor c=2.33879e-17
C128 (\3\:VDD VSS) capacitor c=2.49819e-16
C129 (\7\:VDD VSS) capacitor c=2.41786e-17
C130 (\8\:VDD VSS) capacitor c=5.18546e-17
C131 (\9\:VDD VSS) capacitor c=2.48254e-17
C132 (\11\:VDD VSS) capacitor c=1.73709e-17
Rk1 (D \4\:D) resistor r=0.2261 c=0
Rk32 (CK \4\:CK) resistor r=0.07801 c=0
Rk8 (SI \4\:SI) resistor r=0.05294 c=0
Rk35 (\2\:QN QN) resistor r=0.3617 c=0
Rk36 (QN \4\:QN) resistor r=0.03697 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.0324 c=0
Rk67 (\3\:VDD \6\:VDD) resistor r=0.3433 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.1227 c=0
Rk69 (\7\:VDD \8\:VDD) resistor r=0.4625 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.5779 c=0
Rk71 (\9\:VDD \10\:VDD) resistor r=0.03742 c=0
Rk73 (\11\:VDD VDD) resistor r=0.1675 c=0
Rk72 (\10\:VDD \11\:VDD) resistor r=0.3834 c=0
Rk77 (\7\:VDD \19\:VDD) resistor r=0.1025 c=0
Rk78 (\8\:VDD \21\:VDD) resistor r=0.0433 c=0
Rk79 (\9\:VDD \23\:VDD) resistor r=0.1025 c=0
Rk80 (\11\:VDD \25\:VDD) resistor r=0.2673 c=0
Rk33 (\2\:Q Q) resistor r=0.3452 c=0
Rk34 (Q \4\:Q) resistor r=0.04101 c=0
Rk51 (\1\:VSS \7\:VSS) resistor r=0.3123 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.1377 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.45 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.5754 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.03742 c=0
Rk57 (\12\:VSS VSS) resistor r=0.1525 c=0
Rk56 (\11\:VSS \12\:VSS) resistor r=0.3985 c=0
Rk60 (\8\:VSS \18\:VSS) resistor r=0.3505 c=0
Rk61 (\9\:VSS \20\:VSS) resistor r=0.0433 c=0
Rk62 (\10\:VSS \22\:VSS) resistor r=0.3416 c=0
Rk63 (\12\:VSS \24\:VSS) resistor r=0.3499 c=0
Rk3 (\8\:SE SE) resistor r=0.002303 c=0
Rk2 (\7\:SE \8\:SE) resistor r=0.2281 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=0.8118 c=0
Rk5 (\6\:SEb \7\:SEb) resistor r=0.6592 c=0
Rk6 (\7\:SEb \9\:SEb) resistor r=0.07492 c=0
Rk7 (\7\:SEb \11\:SEb) resistor r=0.519 c=0
Rk9 (\2\:Db \4\:Db) resistor r=0.5195 c=0
Rk10 (\4\:Db \6\:Db) resistor r=0.9882 c=0
Rk11 (\6\:Db \8\:Db) resistor r=0.4497 c=0
Rk18 (\9\:CKbb \10\:CKbb) resistor r=0.01531 c=0
Rk19 (\10\:CKbb \11\:CKbb) resistor r=0.7662 c=0
Rk20 (\11\:CKbb \12\:CKbb) resistor r=0.2063 c=0
Rk21 (\12\:CKbb \14\:CKbb) resistor r=0.3626 c=0
Rk22 (\10\:CKbb \15\:CKbb) resistor r=0.2605 c=0
Rk23 (\11\:CKbb \16\:CKbb) resistor r=0.0805 c=0
Rk24 (\12\:CKbb \17\:CKbb) resistor r=0.3382 c=0
Rk25 (\14\:CKbb \19\:CKbb) resistor r=0.6092 c=0
Rk29 (\12\:CKb \14\:CKb) resistor r=0.4211 c=0
Rk30 (\14\:CKb \15\:CKb) resistor r=0.9213 c=0
Rk31 (\15\:CKb \16\:CKb) resistor r=0.5198 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2193 c=0
Rk13 (\6\:n20 \8\:n20) resistor r=0.09574 c=0
Rk14 (\6\:n20 \10\:n20) resistor r=0.2608 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2074 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2755 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1424 c=0
Rk26 (\5\:n30 \6\:n30) resistor r=0.1422 c=0
Rk27 (\6\:n30 \8\:n30) resistor r=0.4313 c=0
Rk28 (\6\:n30 \10\:n30) resistor r=0.2305 c=0
Rk37 (\15\:qbint \5\:qbint) resistor r=0.4764 c=0
Rk39 (\5\:qbint \19\:qbint) resistor r=0.6089 c=0
Rk42 (\19\:qbint \22\:qbint) resistor r=0.2861 c=0
Rk43 (\22\:qbint \23\:qbint) resistor r=0.1273 c=0
Rk44 (\22\:qbint \25\:qbint) resistor r=0.1429 c=0
Rk45 (\9\:net367 \10\:net367) resistor r=0.09349 c=0
Rk46 (\10\:net367 \11\:net367) resistor r=0.1152 c=0
Rk47 (\10\:net367 \13\:net367) resistor r=0.156 c=0
Rl3 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl4 (\2\:D \3\:D) resistor r=145.387 c=0
Rl34 (\1\:CK \2\:CK) resistor r=53.8462 c=0
Rl35 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl9 (\1\:SI \2\:SI) resistor r=72.3097 c=0
Rl10 (\2\:SI \3\:SI) resistor r=97.3098 c=0
Rl7 (\5\:SE \6\:SE) resistor r=85.7713 c=0
Rl6 (\4\:SE \5\:SE) resistor r=153.4 c=0
Rl1 (\1\:SE \2\:SE) resistor r=83.3841 c=0
Rl2 (\2\:SE \3\:SE) resistor r=89.1533 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=45.3867 c=0
Rl5 (SEb \2\:SEb) resistor r=83.8482 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=31.461 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=31.461 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=93.4636 c=0
Rl11 (CKbb \2\:CKbb) resistor r=54.5677 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=222.208 c=0
Rl27 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=170.697 c=0
Rl17 (\3\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl18 (\4\:CKb \7\:CKb) resistor r=143.912 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=105.747 c=0
Rl15 (\3\:CKb \4\:CKb) resistor r=150.39 c=0
Rl21 (n20 \2\:n20) resistor r=113.25 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=34.4036 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=14.7297 c=0
Rl19 (mout \2\:mout) resistor r=24.2328 c=0
Rl20 (\2\:mout \3\:mout) resistor r=101.526 c=0
Rl31 (n30 \2\:n30) resistor r=113.493 c=0
Rl33 (\2\:n30 \4\:n30) resistor r=24.7024 c=0
Rl32 (\2\:n30 \3\:n30) resistor r=4.4012 c=0
Rl48 (\13\:qbint \14\:qbint) resistor r=117.308 c=0
Rl47 (\12\:qbint \13\:qbint) resistor r=69.208 c=0
Rl30 (\2\:qbint \4\:qbint) resistor r=40.0987 c=0
Rl29 (\2\:qbint \3\:qbint) resistor r=107.406 c=0
Rl28 (\2\:qbint qbint) resistor r=11.5001 c=0
Rl45 (net367 \6\:net367) resistor r=9.5287 c=0
Rz10 (\4\:QN \3\:QN) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz21 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz9 (\4\:Q \3\:Q) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz18 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (\8\:SEb \9\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz6 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz8 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz4 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz11 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz12 (\13\:net367 \12\:net367) resistor r=75 c=0
Ry10 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry19 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry9 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry13 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry14 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\5\:Db \6\:Db) resistor r=62 c=0
Ry6 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry8 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry4 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry11 (\25\:qbint \24\:qbint) resistor r=62 c=0
Ry12 (\9\:net367 \8\:net367) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\5\:SE \7\:SE) resistor r=45 c=0
Rx3 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx9 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx14 (\10\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx17 (\15\:qbint \12\:qbint) resistor r=45 c=0
Rx20 (\23\:qbint qbint) resistor r=45 c=0
Rx21 (\11\:net367 \6\:net367) resistor r=45 c=0
mn10 (\8\:SEb \3\:SE \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.21e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (net449 \3\:D \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.005e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn12 (\7\:Db SEb net449 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn14 (\7\:Db \4\:SE net461 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.335e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=6.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn13 (net461 \3\:SI \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.045e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn21 (\13\:CKbb \5\:CKb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn25 (\7\:n20 \6\:CKb Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.615e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn36 (\7\:n20 \3\:CKbb net429 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.41e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn35 (net429 \3\:mout \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=8.7e-15 ps=1.55e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.305e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (\6\:mout \4\:n20 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.11e-14 ad=2.32e-14 ps=1.55e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.04e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\9\:n30 \5\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.857e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=8.35e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn51 (\9\:n30 \8\:CKb net436 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.857e-14 ps=4.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=4.55e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn50 (net436 \3\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=9.42e-15 ps=7.3e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.45e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn20 (\11\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.13e-14 ad=3.19e-14 ps=1.62e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=1.32e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\12\:net367 \13\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=6.272e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\18\:qbint \4\:n30 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29537e-06 sb=1.4e-07 sd=160n sca=16.6038 \
        scb=0.0171168 scc=0.00137311 m=(1)
mn57 (\3\:QN net367 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.916e-14 ad=4.16e-14 ps=1.635e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2125e-07 sb=4.55577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn55 (\3\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.345e-14 ad=4.16e-14 ps=1.61e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5125e-07 sb=9.25577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\24\:qbint n30 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.705e-14 ad=4.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21032e-06 sb=1.4e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp55_1__rcx (\1\:Q \5\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.549e-14 ad=7.41e-14 ps=1.145e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.77821e-07 sb=8.93846e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(2)
mp57_1__rcx (\1\:QN net367 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.984e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.17821e-07 sb=4.53846e-07 sd=160n sca=17.7255 \
        scb=0.0154354 scc=0.00137898 m=(2)
ends SDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:09 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFX4
// View name: extracted

simulator lang=spectre

subckt SDFFX4 CK D Q QN SE SI VDD VSS
mp10 (\10\:SEb \1\:SE \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.51e-06 sd=160n sca=13.1833 \
        scb=0.0107181 scc=0.000111559 m=(1)
mp11 (net384 \1\:D \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.305e-06 sd=160n sca=11.3131 \
        scb=0.00820755 scc=9.33745e-05 m=(1)
mp12 (\8\:Db \6\:SE net384 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=5.16e-14 ps=7e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.125e-06 sd=160n sca=10.6109 \
        scb=0.00776928 scc=9.29566e-05 m=(1)
mp14 (\8\:Db \3\:SEb net392 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.16e-14 ps=7.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=8.4e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp13 (net392 \1\:SI \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=6.35e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp20 (\14\:CKb \1\:CK \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=8.385e-14 ps=8.3e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28e-06 sb=3.9e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp21 (\17\:CKbb \9\:CKb \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=21.9815 scb=0.0208641 \
        scc=0.00225088 m=(1)
mp25 (\8\:n20 CKbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb net356 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp35 (net356 mout \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=9.03e-14 ps=8.7e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.03e-14 ad=3.44e-14 ps=1.27e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb net376 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp50 (net376 \4\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
C1 (D VSS) capacitor c=4.88817e-17
C2 (Q VSS) capacitor c=2.1377e-17
C3 (CK VSS) capacitor c=3.92338e-17
C4 (SI VSS) capacitor c=1.18946e-16
C5 (QN VSS) capacitor c=1.41261e-17
C6 (VDD VSS) capacitor c=3.50826e-16
C7 (SE VSS) capacitor c=4.75392e-17
C8 (SEb VSS) capacitor c=7.96364e-17
C9 (net449 VSS) capacitor c=1.56005e-19
C10 (Db VSS) capacitor c=9.02937e-17
C11 (net461 VSS) capacitor c=2.5028e-18
C12 (CKb VSS) capacitor c=7.86848e-17
C13 (CKbb VSS) capacitor c=3.48339e-17
C14 (n20 VSS) capacitor c=4.96534e-17
C15 (mout VSS) capacitor c=6.02346e-17
C16 (n30 VSS) capacitor c=2.16396e-16
C17 (qbint VSS) capacitor c=3.12049e-17
C18 (net367 VSS) capacitor c=2.77195e-16
C19 (net384 VSS) capacitor c=6.14441e-21
C20 (net392 VSS) capacitor c=3.45998e-18
C21 (net376 VSS) capacitor c=5.44488e-18
C22 (\22\:qbint VSS) capacitor c=4.63026e-17
C23 (\5\:qbint VSS) capacitor c=2.69934e-16
C24 (\4\:qbint VSS) capacitor c=3.89987e-17
C25 (\7\:CKbb VSS) capacitor c=5.0705e-17
C26 (\2\:CKb VSS) capacitor c=1.08704e-16
C27 (\3\:CKb VSS) capacitor c=1.48137e-16
C28 (\9\:CKb VSS) capacitor c=4.25248e-17
C29 (\1\:CK VSS) capacitor c=4.82764e-17
C30 (\1\:SI VSS) capacitor c=6.71498e-17
C31 (\3\:SEb VSS) capacitor c=4.37598e-17
C32 (\6\:SE VSS) capacitor c=4.54112e-17
C33 (\1\:D VSS) capacitor c=4.00885e-17
C34 (\1\:SE VSS) capacitor c=5.7244e-17
C35 (\20\:qbint VSS) capacitor c=3.58732e-17
C36 (\3\:qbint VSS) capacitor c=6.23678e-17
C37 (\5\:CKbb VSS) capacitor c=3.19605e-17
C38 (\3\:n20 VSS) capacitor c=2.86186e-17
C39 (\3\:mout VSS) capacitor c=5.37557e-17
C40 (\3\:CKbb VSS) capacitor c=4.88287e-17
C41 (\8\:CKb VSS) capacitor c=2.53211e-17
C42 (\7\:CKb VSS) capacitor c=2.46296e-17
C43 (\3\:CK VSS) capacitor c=2.57847e-17
C44 (\3\:SI VSS) capacitor c=2.93237e-17
C45 (\4\:SE VSS) capacitor c=5.08702e-17
C46 (\3\:D VSS) capacitor c=8.95322e-17
C47 (\3\:SE VSS) capacitor c=2.64e-17
C48 (\21\:qbint VSS) capacitor c=4.00807e-17
C49 (\8\:CKbb VSS) capacitor c=3.8851e-17
C50 (\6\:CKbb VSS) capacitor c=3.33208e-17
C51 (\2\:n20 VSS) capacitor c=3.23934e-17
C52 (\2\:mout VSS) capacitor c=5.24408e-17
C53 (\4\:CKbb VSS) capacitor c=2.54435e-17
C54 (\2\:CKbb VSS) capacitor c=5.51835e-17
C55 (\6\:CKb VSS) capacitor c=2.25935e-17
C56 (\2\:CK VSS) capacitor c=4.46936e-17
C57 (\2\:SI VSS) capacitor c=4.82997e-17
C58 (\4\:SEb VSS) capacitor c=3.26674e-17
C59 (\5\:SE VSS) capacitor c=5.90378e-17
C60 (\2\:SEb VSS) capacitor c=3.0228e-17
C61 (\2\:D VSS) capacitor c=6.40869e-17
C62 (\2\:SE VSS) capacitor c=4.06142e-17
C63 (\20\:net367 VSS) capacitor c=3.46361e-17
C64 (\1\:VDD VSS) capacitor c=4.55185e-16
C65 (\1\:Q VSS) capacitor c=1.52305e-16
C66 (\30\:qbint VSS) capacitor c=5.96205e-17
C67 (\10\:n30 VSS) capacitor c=5.85272e-17
C68 (\4\:mout VSS) capacitor c=2.1305e-17
C69 (\21\:VDD VSS) capacitor c=3.89064e-17
C70 (\8\:n20 VSS) capacitor c=3.82477e-17
C71 (\3\:Db VSS) capacitor c=2.30264e-16
C72 (\17\:CKbb VSS) capacitor c=1.03364e-16
C73 (\24\:VDD VSS) capacitor c=1.64383e-17
C74 (\14\:CKb VSS) capacitor c=6.9838e-17
C75 (\27\:VDD VSS) capacitor c=3.88764e-17
C76 (\8\:Db VSS) capacitor c=1.182e-17
C77 (\31\:VDD VSS) capacitor c=2.97923e-17
C78 (\10\:SEb VSS) capacitor c=8.57346e-17
C79 (\3\:VDD VSS) capacitor c=6.97059e-17
C80 (\16\:net367 VSS) capacitor c=4.4982e-17
C81 (\1\:QN VSS) capacitor c=1.19766e-16
C82 (\24\:qbint VSS) capacitor c=2.1274e-16
C83 (\8\:n30 VSS) capacitor c=6.45065e-17
C84 (\8\:mout VSS) capacitor c=5.06393e-17
C85 (\6\:n20 VSS) capacitor c=3.93036e-17
C86 (\12\:CKbb VSS) capacitor c=1.04118e-16
C87 (\12\:CKb VSS) capacitor c=5.16019e-17
C88 (\6\:Db VSS) capacitor c=1.09974e-16
C89 (\7\:SEb VSS) capacitor c=1.04749e-16
C90 (\4\:CKb VSS) capacitor c=6.28327e-17
C91 (\5\:CKb VSS) capacitor c=2.14389e-17
C92 (\2\:qbint VSS) capacitor c=3.73103e-17
C93 (\4\:D VSS) capacitor c=6.6694e-17
C94 (\7\:SE VSS) capacitor c=9.17478e-17
C95 (\8\:SE VSS) capacitor c=5.38042e-17
C96 (\5\:SEb VSS) capacitor c=2.32141e-17
C97 (\6\:SEb VSS) capacitor c=1.34479e-16
C98 (\9\:SEb VSS) capacitor c=1.29872e-16
C99 (\4\:CK VSS) capacitor c=6.99577e-17
C100 (\10\:CKb VSS) capacitor c=1.86009e-17
C101 (\11\:CKb VSS) capacitor c=7.31475e-17
C102 (\5\:Db VSS) capacitor c=2.14868e-16
C103 (\4\:n20 VSS) capacitor c=5.91774e-17
C104 (\5\:n20 VSS) capacitor c=5.91043e-17
C105 (\6\:mout VSS) capacitor c=5.46583e-17
C106 (\7\:mout VSS) capacitor c=5.25365e-17
C107 (\9\:CKbb VSS) capacitor c=2.60426e-17
C108 (\10\:CKbb VSS) capacitor c=1.12028e-16
C109 (\11\:CKbb VSS) capacitor c=6.11117e-17
C110 (\14\:CKbb VSS) capacitor c=1.34824e-16
C111 (\15\:CKbb VSS) capacitor c=6.33901e-17
C112 (\16\:CKbb VSS) capacitor c=7.41138e-17
C113 (\6\:n30 VSS) capacitor c=5.53689e-17
C114 (\7\:n30 VSS) capacitor c=8.70457e-17
C115 (\4\:Q VSS) capacitor c=1.21622e-16
C116 (\5\:QN VSS) capacitor c=1.65631e-16
C117 (\23\:qbint VSS) capacitor c=2.42629e-16
C118 (\26\:qbint VSS) capacitor c=3.23315e-17
C119 (\27\:qbint VSS) capacitor c=2.28383e-17
C120 (\28\:qbint VSS) capacitor c=4.73048e-17
C121 (\29\:qbint VSS) capacitor c=2.63562e-17
C122 (\18\:net367 VSS) capacitor c=3.53045e-17
C123 (\19\:net367 VSS) capacitor c=3.84853e-17
C124 (\20\:VDD VSS) capacitor c=2.12752e-17
C125 (\23\:VDD VSS) capacitor c=3.66137e-17
C126 (\26\:VDD VSS) capacitor c=2.1085e-17
C127 (\30\:VDD VSS) capacitor c=2.06204e-17
Rk1 (\4\:D D) resistor r=0.04824 c=0
Rk34 (\1\:Q Q) resistor r=0.04991 c=0
Rk35 (Q \4\:Q) resistor r=0.2087 c=0
Rk9 (CK \4\:CK) resistor r=0.1571 c=0
Rk8 (\4\:SI SI) resistor r=0.002999 c=0
Rk40 (\1\:QN QN) resistor r=0.2139 c=0
Rk41 (QN \5\:QN) resistor r=0.04798 c=0
Rk84 (\1\:VDD \19\:VDD) resistor r=0.3232 c=0
Rk85 (\19\:VDD \20\:VDD) resistor r=0.2555 c=0
Rk86 (\20\:VDD \22\:VDD) resistor r=0.3636 c=0
Rk87 (\20\:VDD \23\:VDD) resistor r=0.3923 c=0
Rk88 (\23\:VDD \25\:VDD) resistor r=0.04329 c=0
Rk89 (\23\:VDD \26\:VDD) resistor r=0.4524 c=0
Rk90 (\26\:VDD \28\:VDD) resistor r=0.229 c=0
Rk91 (\26\:VDD \29\:VDD) resistor r=0.1001 c=0
Rk94 (\30\:VDD VDD) resistor r=0.2277 c=0
Rk92 (\29\:VDD \30\:VDD) resistor r=0.3232 c=0
Rk93 (\30\:VDD \32\:VDD) resistor r=0.2336 c=0
Rk58 (\1\:VSS \9\:VSS) resistor r=0.258 c=0
Rk59 (\9\:VSS \10\:VSS) resistor r=0.2555 c=0
Rk60 (\10\:VSS \11\:VSS) resistor r=0.5913 c=0
Rk61 (\11\:VSS \12\:VSS) resistor r=0.2628 c=0
Rk62 (\12\:VSS \13\:VSS) resistor r=0.09256 c=0
Rk64 (\14\:VSS VSS) resistor r=0.2152 c=0
Rk63 (\13\:VSS \14\:VSS) resistor r=0.3357 c=0
Rk70 (\10\:VSS \26\:VSS) resistor r=0.1224 c=0
Rk71 (\11\:VSS \28\:VSS) resistor r=0.1936 c=0
Rk72 (\12\:VSS \30\:VSS) resistor r=0.127 c=0
Rk73 (\14\:VSS \32\:VSS) resistor r=0.07369 c=0
Rk3 (\8\:SE SE) resistor r=0.06515 c=0
Rk2 (\7\:SE \8\:SE) resistor r=0.3453 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=0.02032 c=0
Rk5 (\6\:SEb \8\:SEb) resistor r=0.4544 c=0
Rk6 (\6\:SEb \9\:SEb) resistor r=0.8152 c=0
Rk7 (\8\:SEb \11\:SEb) resistor r=0.7816 c=0
Rk13 (\2\:Db \4\:Db) resistor r=0.5362 c=0
Rk14 (\4\:Db \5\:Db) resistor r=1.4895 c=0
Rk15 (\5\:Db \7\:Db) resistor r=0.5994 c=0
Rk16 (\5\:Db \9\:Db) resistor r=0.05409 c=0
Rk10 (\10\:CKb \11\:CKb) resistor r=0.08108 c=0
Rk11 (\11\:CKb \13\:CKb) resistor r=0.3312 c=0
Rk12 (\11\:CKb \15\:CKb) resistor r=0.356 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.04789 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1763 c=0
Rk25 (\11\:CKbb \13\:CKbb) resistor r=0.2652 c=0
Rk26 (\10\:CKbb \14\:CKbb) resistor r=0.9706 c=0
Rk27 (\14\:CKbb \15\:CKbb) resistor r=0.3035 c=0
Rk28 (\11\:CKbb \16\:CKbb) resistor r=0.3569 c=0
Rk29 (\13\:CKbb \18\:CKbb) resistor r=0.7036 c=0
Rk17 (\4\:n20 \5\:n20) resistor r=0.3076 c=0
Rk18 (\5\:n20 \7\:n20) resistor r=0.1276 c=0
Rk19 (\5\:n20 \9\:n20) resistor r=0.2579 c=0
Rk20 (\5\:mout \6\:mout) resistor r=0.1341 c=0
Rk21 (\6\:mout \7\:mout) resistor r=0.3002 c=0
Rk22 (\6\:mout \9\:mout) resistor r=0.2658 c=0
Rk30 (\6\:n30 \7\:n30) resistor r=0.2587 c=0
Rk31 (\7\:n30 \9\:n30) resistor r=0.3143 c=0
Rk32 (\7\:n30 \11\:n30) resistor r=0.4203 c=0
Rk44 (\23\:qbint \25\:qbint) resistor r=1.8863 c=0
Rk45 (\25\:qbint \26\:qbint) resistor r=0.431 c=0
Rk46 (\26\:qbint \27\:qbint) resistor r=0.1042 c=0
Rk47 (\27\:qbint \28\:qbint) resistor r=0.1785 c=0
Rk48 (\26\:qbint \29\:qbint) resistor r=0.06889 c=0
Rk49 (\27\:qbint \31\:qbint) resistor r=0.1976 c=0
Rk50 (\17\:net367 \18\:net367) resistor r=0.3545 c=0
Rk51 (\18\:net367 \19\:net367) resistor r=0.2097 c=0
Rk52 (\18\:net367 \21\:net367) resistor r=0.1229 c=0
Rl3 (\1\:D \2\:D) resistor r=39.1533 c=0
Rl4 (\2\:D \3\:D) resistor r=187.23 c=0
Rl11 (\1\:CK \2\:CK) resistor r=182.692 c=0
Rl12 (\2\:CK \3\:CK) resistor r=45.3297 c=0
Rl9 (\1\:SI \2\:SI) resistor r=186.538 c=0
Rl10 (\2\:SI \3\:SI) resistor r=41.7582 c=0
Rl7 (\5\:SE \6\:SE) resistor r=88.2566 c=0
Rl6 (\4\:SE \5\:SE) resistor r=169.208 c=0
Rl1 (\1\:SE \2\:SE) resistor r=198.077 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.9451 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=49.2328 c=0
Rl5 (SEb \2\:SEb) resistor r=44.9225 c=0
Rl21 (\2\:CKb \3\:CKb) resistor r=441.439 c=0
Rl20 (CKb \2\:CKb) resistor r=187.593 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=100.733 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=239.928 c=0
Rl26 (\4\:CKb \8\:CKb) resistor r=30.4507 c=0
Rl27 (\5\:CKb \9\:CKb) resistor r=107.374 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=73.4664 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=81.1594 c=0
Rl28 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=87.1289 c=0
Rl13 (CKbb \2\:CKbb) resistor r=58.4139 c=0
Rl17 (n20 \2\:n20) resistor r=100.692 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl15 (mout \2\:mout) resistor r=33.8482 c=0
Rl16 (\2\:mout \3\:mout) resistor r=93.4636 c=0
Rl65 (\21\:qbint \22\:qbint) resistor r=60.7713 c=0
Rl64 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl31 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl30 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rl29 (\2\:qbint qbint) resistor r=6.99 c=0
Rz25 (\1\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz26 (\19\:VDD \3\:VDD) resistor r=6.25 c=0
Rz27 (\29\:VDD \3\:VDD) resistor r=6.25 c=0
Rz21 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz22 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz23 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz24 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz7 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz5 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz8 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz13 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz14 (\17\:net367 \16\:net367) resistor r=75 c=0
Ry24 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry26 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry27 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=5.6364 c=0
Ry16 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry3 (\3\:Db \4\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry7 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry5 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry6 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry13 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry14 (\21\:net367 \20\:net367) resistor r=20.6667 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\5\:SE \7\:SE) resistor r=45 c=0
Rx3 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx8 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx11 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx15 (\6\:n30 n30) resistor r=45 c=0
Rx16 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx17 (\28\:qbint qbint) resistor r=45 c=0
Rx18 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx19 (\19\:net367 net367) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=2.103e-14 ps=1.45e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.26e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (net449 \3\:D \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=8.7e-15 ps=1.45e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (\6\:Db SEb net449 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.95e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn14 (\6\:Db \4\:SE net461 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn13 (net461 \3\:SI \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.48e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=4.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn20 (\12\:CKb \3\:CK \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.03e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn21 (\12\:CKbb \7\:CKb \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn25 (\6\:n20 \8\:CKb Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.422e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb net429 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.45e-14 ad=4.422e-14 ps=4.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (net429 \3\:mout \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.43e-14 ad=1.45e-14 ps=1.27e-06 pd=4.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.43e-14 ad=4.422e-14 ps=1.27e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=3.553e-14 ps=9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb net436 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.552e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (net436 \3\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.087e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.622e-14 ad=3.28e-14 ps=1.085e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34841e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(2)
mn56 (\16\:net367 \20\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn55_1__rcx (\4\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.531e-14 ad=4.16e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn57_1__rcx (\1\:QN net367 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.14e-14 ad=4.745e-14 ps=1.34e-06 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mp45 (\30\:qbint n30 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29823e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp56 (\20\:net367 \22\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
mp55 (\1\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57 (\5\:QN net367 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
ends SDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:10 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFXL
// View name: extracted

simulator lang=spectre

subckt SDFFXL CK D Q QN SE SI VDD VSS
mp57 (\1\:QN \4\:net367 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.5197 \
        scb=0.0328493 scc=0.0059298 m=(1)
mp56 (\5\:net367 \6\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.773e-14 ps=7.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp20 (\15\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp45 (\15\:qbint n30 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=3.01e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp50 (net376 \7\:qbint \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.99e-14 ad=7.203e-14 ps=1.58e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.74e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\4\:n30 \3\:CKbb net376 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.36e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=9.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.155e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout n20 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=5.16e-14 ps=1.58e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=8.7e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (net356 mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=1.505e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=6.05e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\4\:n20 \8\:CKb net356 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.73e-14 ps=5.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=4.9e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.73e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=2.25e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp21 (\9\:CKbb \9\:CKb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp11 (net384 \3\:D \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.763e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp12 (\7\:Db \1\:SE net384 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.7e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp14 (\7\:Db SEb net392 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=5.65e-07 sd=160n sca=11.4714 \
        scb=0.00922898 scc=0.00018799 m=(1)
mp13 (net392 \3\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=2.903e-14 ps=8.3e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=3.85e-07 sd=160n sca=12.2443 \
        scb=0.00977105 scc=0.000188654 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=15.1631 \
        scb=0.0142072 scc=0.000247556 m=(1)
C1 (CK VSS) capacitor c=8.20357e-17
C2 (SE VSS) capacitor c=5.49843e-17
C3 (SI VSS) capacitor c=7.27395e-17
C4 (VDD VSS) capacitor c=3.61725e-16
C5 (D VSS) capacitor c=5.56342e-17
C6 (Q VSS) capacitor c=6.15843e-17
C7 (QN VSS) capacitor c=2.45893e-17
C8 (net367 VSS) capacitor c=2.09166e-17
C9 (qbint VSS) capacitor c=4.84266e-17
C10 (CKb VSS) capacitor c=4.69622e-17
C11 (n30 VSS) capacitor c=5.1907e-17
C12 (mout VSS) capacitor c=7.74425e-17
C13 (CKbb VSS) capacitor c=2.27183e-17
C14 (n20 VSS) capacitor c=4.28996e-17
C15 (Db VSS) capacitor c=9.88259e-17
C16 (net449 VSS) capacitor c=6.91177e-18
C17 (SEb VSS) capacitor c=3.74835e-17
C18 (net376 VSS) capacitor c=5.92504e-18
C19 (net384 VSS) capacitor c=4.61231e-18
C20 (\5\:SE VSS) capacitor c=4.83673e-17
C21 (\3\:SI VSS) capacitor c=5.34157e-17
C22 (\1\:SE VSS) capacitor c=4.77396e-17
C23 (\3\:D VSS) capacitor c=4.65357e-17
C24 (\9\:CKb VSS) capacitor c=5.16464e-17
C25 (\7\:CKbb VSS) capacitor c=3.99332e-17
C26 (\8\:CKb VSS) capacitor c=6.85881e-17
C27 (\3\:CKb VSS) capacitor c=5.15212e-17
C28 (\3\:CKbb VSS) capacitor c=4.83167e-17
C29 (\7\:qbint VSS) capacitor c=3.87918e-17
C30 (\1\:CK VSS) capacitor c=3.28009e-17
C31 (\6\:qbint VSS) capacitor c=3.33047e-17
C32 (\4\:net367 VSS) capacitor c=2.94671e-17
C33 (\8\:SE VSS) capacitor c=3.05372e-17
C34 (\1\:SI VSS) capacitor c=7.52108e-17
C35 (\3\:SE VSS) capacitor c=6.5996e-17
C36 (\3\:SEb VSS) capacitor c=7.31249e-17
C37 (\1\:D VSS) capacitor c=4.24988e-17
C38 (\5\:CKb VSS) capacitor c=2.8974e-17
C39 (\10\:CKb VSS) capacitor c=2.39528e-17
C40 (\5\:CKbb VSS) capacitor c=8.50625e-17
C41 (\3\:mout VSS) capacitor c=4.89747e-17
C42 (\3\:n20 VSS) capacitor c=3.19636e-17
C43 (\10\:qbint VSS) capacitor c=3.85116e-17
C44 (\2\:n30 VSS) capacitor c=3.70448e-17
C45 (\3\:CK VSS) capacitor c=4.08944e-17
C46 (\5\:qbint VSS) capacitor c=2.37079e-17
C47 (\4\:qbint VSS) capacitor c=2.78473e-17
C48 (\3\:net367 VSS) capacitor c=3.22097e-17
C49 (\7\:SE VSS) capacitor c=2.19115e-17
C50 (\2\:SI VSS) capacitor c=7.02821e-17
C51 (\4\:SE VSS) capacitor c=5.35879e-17
C52 (\2\:SEb VSS) capacitor c=7.29678e-17
C53 (\2\:SE VSS) capacitor c=3.9233e-17
C54 (\2\:D VSS) capacitor c=6.54312e-17
C55 (\8\:CKbb VSS) capacitor c=4.31878e-17
C56 (\11\:CKb VSS) capacitor c=2.82601e-17
C57 (\6\:CKbb VSS) capacitor c=3.08509e-17
C58 (\2\:mout VSS) capacitor c=5.84527e-17
C59 (\2\:n20 VSS) capacitor c=3.86715e-17
C60 (\4\:CKb VSS) capacitor c=2.13263e-17
C61 (\4\:CKbb VSS) capacitor c=1.95882e-17
C62 (\2\:CKb VSS) capacitor c=4.50304e-17
C63 (\9\:qbint VSS) capacitor c=1.98193e-17
C64 (\3\:n30 VSS) capacitor c=2.19388e-17
C65 (\2\:CK VSS) capacitor c=3.73234e-17
C66 (\2\:qbint VSS) capacitor c=5.1788e-17
C67 (\4\:SEb VSS) capacitor c=1.23546e-17
C68 (\1\:VDD VSS) capacitor c=3.13082e-17
C69 (\7\:Db VSS) capacitor c=3.44112e-17
C70 (\6\:VDD VSS) capacitor c=4.2913e-17
C71 (\9\:CKbb VSS) capacitor c=7.84997e-17
C72 (\5\:Db VSS) capacitor c=1.09443e-16
C73 (\4\:n20 VSS) capacitor c=4.32272e-17
C74 (\10\:VDD VSS) capacitor c=1.65609e-17
C75 (\8\:mout VSS) capacitor c=3.69024e-17
C76 (\4\:n30 VSS) capacitor c=7.09059e-17
C77 (\13\:VDD VSS) capacitor c=1.53252e-17
C78 (\15\:qbint VSS) capacitor c=3.97522e-17
C79 (\15\:CKb VSS) capacitor c=1.26004e-16
C80 (\16\:VDD VSS) capacitor c=3.81138e-17
C81 (\3\:Q VSS) capacitor c=6.33873e-17
C82 (\5\:net367 VSS) capacitor c=3.13247e-17
C83 (\20\:VDD VSS) capacitor c=3.78639e-17
C84 (\1\:QN VSS) capacitor c=3.12571e-17
C85 (\3\:VDD VSS) capacitor c=7.37917e-17
C86 (\8\:SEb VSS) capacitor c=4.63284e-17
C87 (\15\:CKbb VSS) capacitor c=5.45853e-17
C88 (\9\:Db VSS) capacitor c=7.11032e-17
C89 (\8\:n20 VSS) capacitor c=5.71754e-17
C90 (\6\:mout VSS) capacitor c=4.87018e-17
C91 (\8\:n30 VSS) capacitor c=2.80423e-17
C92 (\13\:qbint VSS) capacitor c=1.05762e-16
C93 (\18\:CKb VSS) capacitor c=5.31584e-17
C94 (\1\:Q VSS) capacitor c=3.92221e-17
C95 (\9\:net367 VSS) capacitor c=2.85009e-17
C96 (\3\:QN VSS) capacitor c=4.02739e-17
C97 (\2\:net367 VSS) capacitor c=1.26125e-17
C98 (\3\:qbint VSS) capacitor c=3.79322e-17
C99 (\8\:qbint VSS) capacitor c=3.74092e-17
C100 (\2\:CKbb VSS) capacitor c=3.24845e-17
C101 (\6\:CKb VSS) capacitor c=6.77557e-17
C102 (\7\:CKb VSS) capacitor c=6.77563e-17
C103 (\6\:SE VSS) capacitor c=3.30539e-17
C104 (\7\:net367 VSS) capacitor c=3.01119e-17
C105 (\8\:net367 VSS) capacitor c=3.11728e-17
C106 (\4\:CK VSS) capacitor c=2.84121e-17
C107 (\11\:qbint VSS) capacitor c=3.9226e-17
C108 (\12\:qbint VSS) capacitor c=4.82973e-17
C109 (\17\:qbint VSS) capacitor c=8.64135e-17
C110 (\6\:n30 VSS) capacitor c=1.1186e-16
C111 (\7\:n30 VSS) capacitor c=1.18787e-16
C112 (\4\:mout VSS) capacitor c=5.67295e-17
C113 (\5\:mout VSS) capacitor c=6.24295e-17
C114 (\12\:CKb VSS) capacitor c=5.9022e-17
C115 (\13\:CKb VSS) capacitor c=7.1079e-17
C116 (\14\:CKb VSS) capacitor c=1.18768e-16
C117 (\17\:CKb VSS) capacitor c=6.09471e-17
C118 (\6\:n20 VSS) capacitor c=6.35748e-17
C119 (\7\:n20 VSS) capacitor c=5.81402e-17
C120 (\11\:CKbb VSS) capacitor c=1.41459e-16
C121 (\12\:CKbb VSS) capacitor c=6.56643e-17
C122 (\13\:CKbb VSS) capacitor c=1.19724e-16
C123 (\14\:CKbb VSS) capacitor c=1.21233e-16
C124 (\4\:D VSS) capacitor c=4.65838e-17
C125 (\3\:Db VSS) capacitor c=1.44157e-16
C126 (\9\:SE VSS) capacitor c=4.7511e-17
C127 (\10\:SE VSS) capacitor c=4.92747e-17
C128 (\11\:SE VSS) capacitor c=5.41879e-17
C129 (\4\:SI VSS) capacitor c=7.24755e-17
C130 (\6\:SEb VSS) capacitor c=6.766e-17
C131 (\7\:SEb VSS) capacitor c=7.09338e-17
C132 (\5\:VDD VSS) capacitor c=3.22493e-17
C133 (\9\:VDD VSS) capacitor c=3.46315e-17
C134 (\12\:VDD VSS) capacitor c=4.54224e-17
C135 (\15\:VDD VSS) capacitor c=1.53312e-17
C136 (\19\:VDD VSS) capacitor c=1.10953e-17
Rk8 (\4\:CK CK) resistor r=0.05411 c=0
Rk39 (\10\:SE SE) resistor r=0.08741 c=0
Rk38 (\9\:SE \10\:SE) resistor r=0.162 c=0
Rk40 (SE \11\:SE) resistor r=0.234 c=0
Rk41 (\4\:SI SI) resistor r=0.07108 c=0
Rk58 (\2\:VDD \4\:VDD) resistor r=0.3114 c=0
Rk59 (\4\:VDD \5\:VDD) resistor r=0.4212 c=0
Rk60 (\5\:VDD \7\:VDD) resistor r=0.2676 c=0
Rk61 (\5\:VDD \8\:VDD) resistor r=0.4306 c=0
Rk62 (\8\:VDD \9\:VDD) resistor r=0.1275 c=0
Rk63 (\9\:VDD \11\:VDD) resistor r=0.07323 c=0
Rk64 (\9\:VDD \12\:VDD) resistor r=0.5832 c=0
Rk65 (\12\:VDD \14\:VDD) resistor r=0.1018 c=0
Rk66 (\12\:VDD \15\:VDD) resistor r=0.4454 c=0
Rk67 (\15\:VDD \17\:VDD) resistor r=0.2934 c=0
Rk68 (\15\:VDD \18\:VDD) resistor r=0.04488 c=0
Rk71 (\19\:VDD VDD) resistor r=0.2024 c=0
Rk69 (\18\:VDD \19\:VDD) resistor r=0.3479 c=0
Rk70 (\19\:VDD \21\:VDD) resistor r=0.4145 c=0
Rk32 (\4\:D D) resistor r=0.07554 c=0
Rk6 (\2\:Q Q) resistor r=0.1433 c=0
Rk7 (Q \4\:Q) resistor r=0.2901 c=0
Rk2 (\4\:QN QN) resistor r=0.04898 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2343 c=0
Rk45 (\2\:VSS \4\:VSS) resistor r=0.325 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.3955 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.4556 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.1125 c=0
Rk49 (\7\:VSS \8\:VSS) resistor r=0.5832 c=0
Rk50 (\8\:VSS \9\:VSS) resistor r=0.5063 c=0
Rk52 (\10\:VSS VSS) resistor r=0.2174 c=0
Rk51 (\9\:VSS \10\:VSS) resistor r=0.3329 c=0
Rk53 (\5\:VSS \12\:VSS) resistor r=0.268 c=0
Rk54 (\7\:VSS \14\:VSS) resistor r=0.1217 c=0
Rk55 (\8\:VSS \16\:VSS) resistor r=0.3264 c=0
Rk56 (\9\:VSS \18\:VSS) resistor r=0.1193 c=0
Rk57 (\10\:VSS \20\:VSS) resistor r=0.07323 c=0
Rk3 (\6\:net367 \7\:net367) resistor r=0.09342 c=0
Rk4 (\7\:net367 \8\:net367) resistor r=0.1189 c=0
Rk5 (\7\:net367 \10\:net367) resistor r=0.1293 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.2207 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.2138 c=0
Rk11 (\12\:qbint \16\:qbint) resistor r=0.2044 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.7123 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.4487 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.3722 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.7611 c=0
Rk22 (\14\:CKb \17\:CKb) resistor r=0.3257 c=0
Rk23 (\16\:CKb \19\:CKb) resistor r=0.3872 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.4337 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.6752 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.1079 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.2657 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1475 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.2912 c=0
Rk27 (\10\:CKbb \11\:CKbb) resistor r=0.5807 c=0
Rk28 (\11\:CKbb \12\:CKbb) resistor r=0.3773 c=0
Rk29 (\12\:CKbb \13\:CKbb) resistor r=0.2249 c=0
Rk30 (\13\:CKbb \14\:CKbb) resistor r=0.8335 c=0
Rk31 (\12\:CKbb \16\:CKbb) resistor r=0.2712 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.1962 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.3021 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.2447 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.6712 c=0
Rk34 (\3\:Db \4\:Db) resistor r=0.4324 c=0
Rk35 (\4\:Db \6\:Db) resistor r=0.04625 c=0
Rk36 (\3\:Db \8\:Db) resistor r=0.2375 c=0
Rk37 (\4\:Db \10\:Db) resistor r=0.3945 c=0
Rk42 (\5\:SEb \6\:SEb) resistor r=0.07366 c=0
Rk43 (\6\:SEb \7\:SEb) resistor r=0.3518 c=0
Rk44 (\6\:SEb \9\:SEb) resistor r=0.4576 c=0
Rl9 (\1\:CK \2\:CK) resistor r=51.1559 c=0
Rl10 (\2\:CK \3\:CK) resistor r=93.4636 c=0
Rl38 (\3\:SE \4\:SE) resistor r=39.1533 c=0
Rl35 (\1\:SE \2\:SE) resistor r=54.5379 c=0
Rl41 (\5\:SE \6\:SE) resistor r=179.649 c=0
Rl43 (\6\:SE \8\:SE) resistor r=46.9565 c=0
Rl42 (\6\:SE \7\:SE) resistor r=1.2301 c=0
Rl40 (\2\:SI \3\:SI) resistor r=97.3098 c=0
Rl39 (\1\:SI \2\:SI) resistor r=110.771 c=0
Rl34 (\2\:D \3\:D) resistor r=96.8221 c=0
Rl33 (\1\:D \2\:D) resistor r=141.129 c=0
Rl3 (\2\:net367 \4\:net367) resistor r=34.3295 c=0
Rl2 (\2\:net367 \3\:net367) resistor r=49.7141 c=0
Rl1 (net367 \2\:net367) resistor r=2.0213 c=0
Rl4 (qbint \2\:qbint) resistor r=114.502 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=53.0797 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=35.772 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=212.376 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=86.2526 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=4.3144 c=0
Rl32 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl16 (CKb \2\:CKb) resistor r=76.1559 c=0
Rl30 (\6\:CKb \9\:CKb) resistor r=159.297 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=78.8241 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=203.39 c=0
Rl31 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=200.39 c=0
Rl11 (n30 \2\:n30) resistor r=180.616 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl23 (mout \2\:mout) resistor r=123.769 c=0
Rl24 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl26 (\7\:CKbb \8\:CKbb) resistor r=66.0764 c=0
Rl25 (\5\:CKbb \6\:CKbb) resistor r=35.3072 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=133.001 c=0
Rl17 (CKbb \2\:CKbb) resistor r=33.3555 c=0
Rl19 (\2\:CKbb \4\:CKbb) resistor r=9.7447 c=0
Rl21 (n20 \2\:n20) resistor r=58.7903 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl36 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=193.351 c=0
Rz19 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz20 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz21 (\3\:VDD \18\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz2 (\9\:net367 \10\:net367) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\9\:Db \10\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry16 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry17 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry18 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry19 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry13 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry14 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry15 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net367 \6\:net367) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\5\:Db \6\:Db) resistor r=62 c=0
Ry11 (\7\:Db \8\:Db) resistor r=62 c=0
Ry12 (\4\:SEb \5\:SEb) resistor r=62 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\7\:SE \9\:SE) resistor r=45 c=0
Rx16 (\4\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SE \11\:SE) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (net367 \8\:net367) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net367 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net367 \4\:qbint \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=2.03e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\18\:CKb \3\:CK \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=3.19e-14 ps=1.58e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.2e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn45 (\13\:qbint \2\:n30 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.625e-14 ad=2.828e-14 ps=7.9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=2e-06 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn50 (net436 \10\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.625e-14 ad=1.958e-14 ps=7.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.8e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (\8\:n30 CKb net436 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.62e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\8\:n30 CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=3.045e-14 ps=1.07e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.365e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn30 (\6\:mout \3\:n20 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.67e-14 ad=5.655e-14 ps=1.31e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=9.3e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn35 (net429 \3\:mout \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.67e-14 ad=8.7e-15 ps=1.31e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=6.65e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn36 (\8\:n20 \5\:CKbb net429 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=5.6e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn25 (\8\:n20 \10\:CKb \9\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.9e-14 ps=9.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=3.15e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\15\:CKbb \5\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net449 \1\:D \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.48e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net449 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net461 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=4.5e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net461 \1\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\8\:SEb \8\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
ends SDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:11 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX1 CK D E Q SE SI VDD VSS
mp0 (\7\:Eb \1\:E \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0405e-13 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.545e-06 sd=160n sca=26.4132 \
        scb=0.0275127 scc=0.00222015 m=(1)
mp10 (\7\:SEb \4\:SE \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.545e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=1.4e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp21 (\11\:Ckbb \6\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.698e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.65e-07 sd=160n sca=12.1061 \
        scb=0.0090276 scc=8.48627e-05 m=(1)
mp20 (\11\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.698e-14 ad=3.333e-14 ps=9.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.55e-07 sd=160n sca=21.8638 \
        scb=0.0242315 scc=0.00109598 m=(1)
C1 (SI VSS) capacitor c=8.31606e-17
C2 (Q VSS) capacitor c=4.10106e-17
C3 (VDD VSS) capacitor c=4.13136e-16
C4 (SE VSS) capacitor c=6.99051e-17
C5 (E VSS) capacitor c=9.29534e-17
C6 (CK VSS) capacitor c=5.63999e-17
C7 (Eb VSS) capacitor c=4.06654e-17
C8 (net526 VSS) capacitor c=3.75784e-18
C9 (Db VSS) capacitor c=1.03378e-16
C10 (net494 VSS) capacitor c=4.20351e-18
C11 (qint VSS) capacitor c=5.99268e-17
C12 (SEb VSS) capacitor c=3.03574e-17
C13 (Dbp VSS) capacitor c=9.78087e-17
C14 (net518 VSS) capacitor c=1.38086e-18
C15 (qbint VSS) capacitor c=2.75014e-17
C16 (n30 VSS) capacitor c=3.85024e-17
C17 (net509 VSS) capacitor c=1.7501e-18
C18 (CKb VSS) capacitor c=7.73984e-17
C19 (mout VSS) capacitor c=5.77335e-17
C20 (Ckbb VSS) capacitor c=4.92171e-17
C21 (n20 VSS) capacitor c=3.9148e-17
C22 (net501 VSS) capacitor c=3.07124e-18
C23 (net449 VSS) capacitor c=6.3857e-18
C24 (net405 VSS) capacitor c=4.25424e-18
C25 (net441 VSS) capacitor c=2.81703e-19
C26 (net426 VSS) capacitor c=3.30932e-18
C27 (net417 VSS) capacitor c=1.17958e-18
C28 (\1\:CK VSS) capacitor c=4.29474e-17
C29 (\6\:CKb VSS) capacitor c=3.66614e-17
C30 (\5\:Ckbb VSS) capacitor c=3.61216e-17
C31 (\4\:CKb VSS) capacitor c=7.88551e-17
C32 (\3\:mout VSS) capacitor c=8.66261e-17
C33 (\3\:n20 VSS) capacitor c=4.18743e-17
C34 (\2\:CKb VSS) capacitor c=4.7475e-17
C35 (\2\:Ckbb VSS) capacitor c=4.37113e-17
C36 (\12\:qbint VSS) capacitor c=5.11156e-17
C37 (\7\:qbint VSS) capacitor c=2.72994e-17
C38 (\8\:qbint VSS) capacitor c=2.0841e-17
C39 (\1\:SI VSS) capacitor c=8.87972e-17
C40 (\3\:SEb VSS) capacitor c=6.32213e-17
C41 (\5\:SE VSS) capacitor c=2.42847e-17
C42 (\4\:SE VSS) capacitor c=2.57212e-17
C43 (\3\:qint VSS) capacitor c=4.44992e-17
C44 (\4\:E VSS) capacitor c=6.98074e-17
C45 (\1\:D VSS) capacitor c=5.24685e-17
C46 (\1\:E VSS) capacitor c=3.78165e-17
C47 (\3\:CK VSS) capacitor c=3.90645e-17
C48 (\10\:CKb VSS) capacitor c=2.7444e-17
C49 (\8\:CKb VSS) capacitor c=4.51836e-17
C50 (\7\:Ckbb VSS) capacitor c=5.17117e-17
C51 (\3\:Ckbb VSS) capacitor c=4.26036e-17
C52 (\9\:qbint VSS) capacitor c=5.34913e-17
C53 (\3\:n30 VSS) capacitor c=4.65101e-17
C54 (\6\:qbint VSS) capacitor c=2.58224e-17
C55 (\5\:qbint VSS) capacitor c=2.34841e-17
C56 (\3\:SI VSS) capacitor c=6.04152e-17
C57 (\1\:SE VSS) capacitor c=1.02496e-16
C58 (\6\:SE VSS) capacitor c=3.19254e-17
C59 (\3\:Eb VSS) capacitor c=4.68411e-17
C60 (\6\:E VSS) capacitor c=3.47872e-17
C61 (\3\:D VSS) capacitor c=5.25249e-17
C62 (\3\:E VSS) capacitor c=2.17879e-17
C63 (\2\:CK VSS) capacitor c=5.87269e-17
C64 (\9\:CKb VSS) capacitor c=2.42959e-17
C65 (\5\:CKb VSS) capacitor c=2.75332e-17
C66 (\2\:mout VSS) capacitor c=4.33655e-17
C67 (\2\:n20 VSS) capacitor c=4.5898e-17
C68 (\4\:Ckbb VSS) capacitor c=3.87197e-17
C69 (\3\:CKb VSS) capacitor c=2.27618e-17
C70 (\11\:qbint VSS) capacitor c=2.63814e-17
C71 (\2\:n30 VSS) capacitor c=4.02887e-17
C72 (\4\:SI VSS) capacitor c=1.47717e-17
C73 (\4\:SEb VSS) capacitor c=4.68113e-17
C74 (\2\:SEb VSS) capacitor c=3.74795e-17
C75 (\3\:SE VSS) capacitor c=3.71862e-17
C76 (\2\:qint VSS) capacitor c=4.04173e-17
C77 (\4\:Eb VSS) capacitor c=3.39561e-17
C78 (\5\:E VSS) capacitor c=5.56969e-17
C79 (\2\:Eb VSS) capacitor c=4.05416e-17
C80 (\2\:D VSS) capacitor c=4.66566e-17
C81 (\2\:E VSS) capacitor c=2.65278e-17
C82 (\11\:CKb VSS) capacitor c=4.2364e-17
C83 (\1\:VDD VSS) capacitor c=6.8142e-17
C84 (\11\:Ckbb VSS) capacitor c=1.36493e-16
C85 (\8\:n20 VSS) capacitor c=3.66083e-17
C86 (\13\:VDD VSS) capacitor c=3.01007e-17
C87 (\8\:mout VSS) capacitor c=6.83803e-17
C88 (\8\:n30 VSS) capacitor c=4.76203e-17
C89 (\15\:VDD VSS) capacitor c=4.60356e-17
C90 (\17\:qbint VSS) capacitor c=5.36373e-17
C91 (\4\:Q VSS) capacitor c=7.61776e-17
C92 (\17\:VDD VSS) capacitor c=7.56819e-17
C93 (\4\:qint VSS) capacitor c=2.59066e-16
C94 (\19\:VDD VSS) capacitor c=4.29255e-17
C95 (\7\:Dbp VSS) capacitor c=1.00916e-16
C96 (\7\:SEb VSS) capacitor c=1.14629e-16
C97 (\21\:VDD VSS) capacitor c=5.91801e-17
C98 (\7\:Db VSS) capacitor c=9.03337e-17
C99 (\23\:VDD VSS) capacitor c=3.28155e-17
C100 (\7\:Eb VSS) capacitor c=7.09017e-17
C101 (\3\:VDD VSS) capacitor c=1.01572e-16
C102 (\15\:CKb VSS) capacitor c=4.86481e-17
C103 (\15\:Ckbb VSS) capacitor c=1.30706e-16
C104 (\3\:Dbp VSS) capacitor c=3.30189e-16
C105 (\4\:n20 VSS) capacitor c=7.58524e-17
C106 (\6\:mout VSS) capacitor c=3.3191e-17
C107 (\4\:n30 VSS) capacitor c=8.43067e-17
C108 (\15\:qbint VSS) capacitor c=3.64626e-17
C109 (\1\:Q VSS) capacitor c=2.89229e-17
C110 (\7\:qint VSS) capacitor c=5.25155e-17
C111 (\5\:Dbp VSS) capacitor c=3.25122e-16
C112 (\3\:Db VSS) capacitor c=1.7729e-16
C113 (\10\:SEb VSS) capacitor c=9.59198e-17
C114 (\5\:Db VSS) capacitor c=1.49633e-16
C115 (\5\:Eb VSS) capacitor c=6.72616e-17
C116 (\2\:SE VSS) capacitor c=5.6123e-17
C117 (\2\:SI VSS) capacitor c=3.68558e-17
C118 (\2\:qbint VSS) capacitor c=8.49189e-18
C119 (\3\:qbint VSS) capacitor c=1.07223e-17
C120 (\4\:qbint VSS) capacitor c=1.13492e-17
C121 (\10\:qbint VSS) capacitor c=2.18448e-17
C122 (\6\:Ckbb VSS) capacitor c=2.98081e-17
C123 (\4\:D VSS) capacitor c=1.15127e-16
C124 (\7\:E VSS) capacitor c=8.09014e-17
C125 (\7\:CKb VSS) capacitor c=3.797e-17
C126 (\9\:Eb VSS) capacitor c=1.16334e-16
C127 (\10\:Eb VSS) capacitor c=4.95571e-17
C128 (\11\:Eb VSS) capacitor c=1.2457e-16
C129 (\7\:SE VSS) capacitor c=4.05054e-17
C130 (\5\:SEb VSS) capacitor c=7.83703e-17
C131 (\6\:SEb VSS) capacitor c=1.42801e-16
C132 (\9\:SEb VSS) capacitor c=8.06967e-17
C133 (\5\:SI VSS) capacitor c=3.27029e-17
C134 (\6\:qint VSS) capacitor c=2.38958e-16
C135 (\3\:Q VSS) capacitor c=3.8772e-17
C136 (\13\:qbint VSS) capacitor c=5.36332e-17
C137 (\14\:qbint VSS) capacitor c=6.32193e-17
C138 (\6\:n30 VSS) capacitor c=8.50694e-17
C139 (\7\:n30 VSS) capacitor c=5.54079e-17
C140 (\4\:mout VSS) capacitor c=5.34166e-17
C141 (\5\:mout VSS) capacitor c=5.06891e-17
C142 (\6\:n20 VSS) capacitor c=5.96068e-17
C143 (\7\:n20 VSS) capacitor c=5.42465e-17
C144 (\9\:Ckbb VSS) capacitor c=5.66462e-17
C145 (\10\:Ckbb VSS) capacitor c=1.51822e-16
C146 (\13\:Ckbb VSS) capacitor c=1.49784e-16
C147 (\14\:Ckbb VSS) capacitor c=4.42798e-17
C148 (\4\:CK VSS) capacitor c=3.51429e-17
C149 (\13\:CKb VSS) capacitor c=1.66865e-16
C150 (\14\:CKb VSS) capacitor c=8.94369e-17
C151 (\17\:CKb VSS) capacitor c=1.77005e-16
C152 (\18\:CKb VSS) capacitor c=7.5622e-17
C153 (\5\:VDD VSS) capacitor c=5.42353e-17
C154 (\6\:VDD VSS) capacitor c=3.10208e-17
C155 (\8\:VDD VSS) capacitor c=9.31258e-18
C156 (\9\:VDD VSS) capacitor c=4.38374e-17
C157 (\10\:VDD VSS) capacitor c=4.06963e-17
C158 (\12\:VDD VSS) capacitor c=1.30614e-17
Rk1 (D \4\:D) resistor r=0.003212 c=0
Rk16 (\5\:SI SI) resistor r=0.1334 c=0
Rk65 (\2\:VSS \4\:VSS) resistor r=0.4192 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.2758 c=0
Rk67 (\5\:VSS \6\:VSS) resistor r=0.5114 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.2657 c=0
Rk69 (\7\:VSS \8\:VSS) resistor r=0.1293 c=0
Rk70 (\8\:VSS \9\:VSS) resistor r=0.3072 c=0
Rk71 (\9\:VSS \10\:VSS) resistor r=0.6167 c=0
Rk72 (\10\:VSS \11\:VSS) resistor r=0.1478 c=0
Rk74 (\12\:VSS VSS) resistor r=0.278 c=0
Rk73 (\11\:VSS \12\:VSS) resistor r=0.2732 c=0
Rk75 (\5\:VSS \14\:VSS) resistor r=0.1632 c=0
Rk76 (\6\:VSS \16\:VSS) resistor r=0.1632 c=0
Rk77 (\8\:VSS \18\:VSS) resistor r=0.04333 c=0
Rk78 (\9\:VSS \20\:VSS) resistor r=0.2216 c=0
Rk79 (\10\:VSS \22\:VSS) resistor r=0.2016 c=0
Rk80 (\12\:VSS \24\:VSS) resistor r=0.2048 c=0
Rk20 (\3\:Q Q) resistor r=0.1692 c=0
Rk19 (\2\:Q \3\:Q) resistor r=0.1225 c=0
Rk21 (\3\:Q \5\:Q) resistor r=0.2854 c=0
Rk49 (\2\:VDD \4\:VDD) resistor r=0.4198 c=0
Rk50 (\4\:VDD \5\:VDD) resistor r=0.3325 c=0
Rk51 (\5\:VDD \6\:VDD) resistor r=0.5004 c=0
Rk52 (\6\:VDD \7\:VDD) resistor r=0.2181 c=0
Rk53 (\7\:VDD \8\:VDD) resistor r=0.1453 c=0
Rk54 (\8\:VDD \9\:VDD) resistor r=0.2078 c=0
Rk55 (\9\:VDD \10\:VDD) resistor r=0.7121 c=0
Rk56 (\10\:VDD \11\:VDD) resistor r=0.1378 c=0
Rk58 (\12\:VDD VDD) resistor r=0.278 c=0
Rk57 (\11\:VDD \12\:VDD) resistor r=0.2732 c=0
Rk59 (\5\:VDD \14\:VDD) resistor r=0.04333 c=0
Rk60 (\6\:VDD \16\:VDD) resistor r=0.3154 c=0
Rk61 (\8\:VDD \18\:VDD) resistor r=0.4456 c=0
Rk62 (\9\:VDD \20\:VDD) resistor r=0.2566 c=0
Rk63 (\10\:VDD \22\:VDD) resistor r=0.2827 c=0
Rk64 (\12\:VDD \24\:VDD) resistor r=0.2518 c=0
Rk8 (\7\:SE SE) resistor r=0.13 c=0
Rk3 (\8\:E E) resistor r=0.004287 c=0
Rk2 (\7\:E \8\:E) resistor r=0.5742 c=0
Rk43 (CK \4\:CK) resistor r=0.1112 c=0
Rk4 (\6\:Eb \8\:Eb) resistor r=0.548 c=0
Rk5 (\8\:Eb \9\:Eb) resistor r=0.4272 c=0
Rk6 (\9\:Eb \10\:Eb) resistor r=0.1752 c=0
Rk7 (\9\:Eb \11\:Eb) resistor r=0.7856 c=0
Rk9 (\2\:Db \4\:Db) resistor r=0.585 c=0
Rk10 (\4\:Db \6\:Db) resistor r=0.8979 c=0
Rk11 (\6\:Db \8\:Db) resistor r=0.4397 c=0
Rk17 (\5\:qint \6\:qint) resistor r=1.9244 c=0
Rk18 (\5\:qint \8\:qint) resistor r=0.2673 c=0
Rk12 (\5\:SEb \6\:SEb) resistor r=0.5176 c=0
Rk13 (\6\:SEb \8\:SEb) resistor r=0.4142 c=0
Rk14 (\6\:SEb \9\:SEb) resistor r=0.3774 c=0
Rk15 (\8\:SEb \11\:SEb) resistor r=0.5281 c=0
Rk34 (\2\:Dbp \4\:Dbp) resistor r=0.4211 c=0
Rk35 (\4\:Dbp \6\:Dbp) resistor r=2.5236 c=0
Rk36 (\6\:Dbp \8\:Dbp) resistor r=0.3891 c=0
Rk22 (\13\:qbint \14\:qbint) resistor r=0.2652 c=0
Rk23 (\14\:qbint \16\:qbint) resistor r=0.1484 c=0
Rk24 (\14\:qbint \18\:qbint) resistor r=0.3029 c=0
Rk25 (\5\:n30 \6\:n30) resistor r=0.5183 c=0
Rk26 (\6\:n30 \7\:n30) resistor r=0.2668 c=0
Rk27 (\6\:n30 \9\:n30) resistor r=0.2781 c=0
Rk44 (\12\:CKb \13\:CKb) resistor r=0.2948 c=0
Rk45 (\13\:CKb \14\:CKb) resistor r=0.6009 c=0
Rk46 (\14\:CKb \16\:CKb) resistor r=0.2778 c=0
Rk47 (\13\:CKb \17\:CKb) resistor r=0.8113 c=0
Rk48 (\17\:CKb \18\:CKb) resistor r=0.6058 c=0
Rk28 (\4\:mout \5\:mout) resistor r=0.2704 c=0
Rk29 (\5\:mout \7\:mout) resistor r=0.06976 c=0
Rk30 (\5\:mout \9\:mout) resistor r=0.2704 c=0
Rk37 (\9\:Ckbb \10\:Ckbb) resistor r=0.2388 c=0
Rk38 (\10\:Ckbb \12\:Ckbb) resistor r=0.3582 c=0
Rk39 (\10\:Ckbb \13\:Ckbb) resistor r=0.9467 c=0
Rk40 (\13\:Ckbb \14\:Ckbb) resistor r=0.1615 c=0
Rk41 (\12\:Ckbb \16\:Ckbb) resistor r=0.7527 c=0
Rk42 (\13\:Ckbb \17\:Ckbb) resistor r=0.0463 c=0
Rk31 (\5\:n20 \6\:n20) resistor r=0.439 c=0
Rk32 (\6\:n20 \7\:n20) resistor r=0.2704 c=0
Rk33 (\6\:n20 \9\:n20) resistor r=0.07077 c=0
Rl3 (\1\:D \2\:D) resistor r=33.8482 c=0
Rl4 (\2\:D \3\:D) resistor r=106.925 c=0
Rl18 (\1\:SI \2\:SI) resistor r=86.2409 c=0
Rl19 (\2\:SI \3\:SI) resistor r=63.9053 c=0
Rl20 (\2\:SI \4\:SI) resistor r=4.5264 c=0
Rl14 (\3\:SE \4\:SE) resistor r=35.3482 c=0
Rl16 (\3\:SE \6\:SE) resistor r=99.7951 c=0
Rl15 (\2\:SE \5\:SE) resistor r=32.3738 c=0
Rl12 (\1\:SE \2\:SE) resistor r=216.851 c=0
Rl13 (\2\:SE \3\:SE) resistor r=146.543 c=0
Rl6 (\4\:E \5\:E) resistor r=177.966 c=0
Rl7 (\5\:E \6\:E) resistor r=24.2328 c=0
Rl1 (\1\:E \2\:E) resistor r=111.538 c=0
Rl2 (\2\:E \3\:E) resistor r=33.7912 c=0
Rl49 (\1\:CK \2\:CK) resistor r=214.129 c=0
Rl50 (\2\:CK \3\:CK) resistor r=101.374 c=0
Rl8 (\3\:Eb \4\:Eb) resistor r=33.8482 c=0
Rl5 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl10 (\2\:qint \3\:qint) resistor r=35.989 c=0
Rl9 (qint \2\:qint) resistor r=108.883 c=0
Rl17 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl11 (SEb \2\:SEb) resistor r=54.5379 c=0
Rl25 (\2\:qbint \6\:qbint) resistor r=30.4507 c=0
Rl21 (qbint \2\:qbint) resistor r=83.8288 c=0
Rl26 (\3\:qbint \7\:qbint) resistor r=47.7584 c=0
Rl22 (\2\:qbint \3\:qbint) resistor r=19.6209 c=0
Rl27 (\4\:qbint \8\:qbint) resistor r=53.0797 c=0
Rl24 (\4\:qbint \5\:qbint) resistor r=35.772 c=0
Rl23 (\3\:qbint \4\:qbint) resistor r=70.0689 c=0
Rl32 (\10\:qbint \12\:qbint) resistor r=71.8171 c=0
Rl30 (\9\:qbint \10\:qbint) resistor r=88.7699 c=0
Rl31 (\10\:qbint \11\:qbint) resistor r=5.8511 c=0
Rl28 (n30 \2\:n30) resistor r=29.5379 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=79.5379 c=0
Rl34 (CKb \2\:CKb) resistor r=136.104 c=0
Rl48 (\9\:CKb \10\:CKb) resistor r=39.1533 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=53.079 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl45 (\6\:CKb \7\:CKb) resistor r=185.772 c=0
Rl46 (\7\:CKb \8\:CKb) resistor r=177.349 c=0
Rl47 (\7\:CKb \9\:CKb) resistor r=80.6945 c=0
Rl40 (\2\:mout \3\:mout) resistor r=70.6854 c=0
Rl39 (mout \2\:mout) resistor r=57.929 c=0
Rl36 (\3\:Ckbb \4\:Ckbb) resistor r=55.0021 c=0
Rl33 (Ckbb \2\:Ckbb) resistor r=34.6607 c=0
Rl42 (\5\:Ckbb \6\:Ckbb) resistor r=38.8561 c=0
Rl43 (\6\:Ckbb \7\:Ckbb) resistor r=96.0468 c=0
Rl44 (\6\:Ckbb \8\:Ckbb) resistor r=2.9709 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=45.708 c=0
Rl37 (n20 \2\:n20) resistor r=72.3097 c=0
Rz18 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz19 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz6 (\1\:Q \2\:Q) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz16 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz1 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz2 (\3\:Db \4\:Db) resistor r=75 c=0
Rz3 (\5\:Db \6\:Db) resistor r=75 c=0
Rz5 (\7\:qint \8\:qint) resistor r=75 c=0
Rz4 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz11 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz12 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz7 (\15\:qbint \16\:qbint) resistor r=75 c=0
Rz8 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz14 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz9 (\6\:mout \7\:mout) resistor r=75 c=0
Rz13 (\15\:Ckbb \16\:Ckbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry22 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry23 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry6 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=31 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry1 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry2 (Db \2\:Db) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry5 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry11 (Dbp \2\:Dbp) resistor r=62 c=0
Ry12 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry7 (\17\:qbint \18\:qbint) resistor r=31 c=0
Ry8 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry14 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry13 (\11\:Ckbb \12\:Ckbb) resistor r=62 c=0
Ry10 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\4\:SI \5\:SI) resistor r=45 c=0
Rx6 (\3\:SE \7\:SE) resistor r=45 c=0
Rx2 (\5\:E \7\:E) resistor r=45 c=0
Rx3 (\2\:E \8\:E) resistor r=45 c=0
Rx19 (\2\:CK \4\:CK) resistor r=45 c=0
Rx4 (\2\:Eb \10\:Eb) resistor r=45 c=0
Rx5 (\4\:Eb \11\:Eb) resistor r=45 c=0
Rx10 (\2\:qint \6\:qint) resistor r=45 c=0
Rx7 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx8 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx11 (\11\:qbint \13\:qbint) resistor r=45 c=0
Rx12 (qbint \14\:qbint) resistor r=45 c=0
Rx13 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\9\:CKb \14\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \17\:CKb) resistor r=45 c=0
Rx22 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\2\:mout \4\:mout) resistor r=45 c=0
Rx16 (\8\:Ckbb \9\:Ckbb) resistor r=45 c=0
Rx17 (Ckbb \14\:Ckbb) resistor r=45 c=0
Rx18 (\4\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx15 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\5\:Eb \3\:E \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.773e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.655e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn10 (\10\:SEb \6\:SE \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.468e-14 ad=2.03e-14 ps=1.19e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn21 (\15\:Ckbb \10\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn20 (\15\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (net526 \3\:D \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.773e-14 ad=4.29e-14 ps=1.37e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.02115e-07 sb=1.01692e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\5\:Db \6\:E net526 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=5.98e-14 ps=8.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.12115e-07 sb=8.06923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\5\:Db \3\:Eb net494 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.98e-14 ps=7.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.87115e-07 sb=5.31923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (net494 qint \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.468e-14 ad=3.51e-14 ps=1.19e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06712e-06 sb=3.51923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn11 (\3\:Db SEb \5\:Dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.8e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(1)
mn13 (\5\:Dbp \1\:SE net518 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn12 (net518 \3\:SI \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.285e-14 ad=3.64e-14 ps=1.6e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55288e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\7\:qint \5\:qbint \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.285e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn45 (\15\:qbint \3\:n30 \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.278e-14 ad=3.895e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.87e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net509 \9\:qbint \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.278e-14 ad=2.87e-14 ps=1.51e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.51e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (\4\:n30 CKb net509 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.325e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\4\:n30 \3\:Ckbb \6\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.12e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (\6\:mout n20 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.278e-14 ad=4.613e-14 ps=1.51e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=8.5e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net501 mout \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.278e-14 ad=2.05e-14 ps=1.51e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=4.9e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn36 (\4\:n20 \7\:Ckbb net501 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=3.28e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=3.45e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn25 (\4\:n20 \8\:CKb \3\:Dbp VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp3 (net449 \1\:D \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0405e-13 ad=5.265e-14 ps=1.52e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.68782e-07 sb=9.61731e-07 sd=160n sca=16.8075 \
        scb=0.014774 scc=0.00118868 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.48782e-07 sb=7.81731e-07 sd=160n sca=16.3155 \
        scb=0.0145891 scc=0.00118861 m=(1)
mp2 (\7\:Db \4\:E net405 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.03782e-07 sb=5.26731e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp1 (net405 \3\:qint \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.545e-14 ad=5.265e-14 ps=1.44e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.83782e-07 sb=3.46731e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp11 (Db \5\:SE \7\:Dbp VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=5.46e-14 ps=1.5e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.48462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (\7\:Dbp \3\:SEb net441 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.404e-13 ps=9e-07 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=2.43462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (net441 \1\:SI \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.4e-14 ad=2.34e-14 ps=1.23e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.38462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp55 (\4\:Q \7\:qbint \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75256e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp56 (\4\:qint \8\:qbint \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=3.58e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp45 (\17\:qbint n30 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.975e-14 ps=9.4e-07 pd=1.07e-06 nrd=1.16667 \
