        nrs=1.16667 sa=2.25e-07 sb=1.83e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp50 (net426 \12\:qbint \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.625e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp51 (\8\:n30 \2\:Ckbb net426 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.44e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp40 (\8\:n30 \2\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.023e-13 ad=4.96e-14 ps=1.28e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.235e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp30 (\8\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=1.023e-13 ps=1.68e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=8.6e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp35 (net417 \3\:mout \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=1.86e-14 ps=1.68e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=5.95e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp36 (\8\:n20 \4\:CKb net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=4.9e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp25 (\8\:n20 \5\:Ckbb Dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.835e-14 ad=4.96e-14 ps=1.19e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=2.85e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
ends SEDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:13 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX2 CK D E Q SE SI VDD VSS
mp0 (\7\:Eb \1\:E \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.36e-06 sd=160n sca=14.119 scb=0.012489 \
        scc=0.00033733 m=(1)
mp10 (\7\:SEb \6\:SE \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.363e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp21 (\10\:Ckbb \6\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.267e-14 ad=3.655e-14 ps=9.2e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.3e-07 sd=160n sca=12.2145 \
        scb=0.00974237 scc=0.000188593 m=(1)
mp20 (\18\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=3.01e-14 ps=9.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=16.1974 \
        scb=0.0160404 scc=0.000308643 m=(1)
C1 (SI VSS) capacitor c=7.31585e-17
C2 (Q VSS) capacitor c=2.74608e-17
C3 (VDD VSS) capacitor c=4.17589e-16
C4 (SE VSS) capacitor c=4.24807e-17
C5 (E VSS) capacitor c=4.34332e-17
C6 (CK VSS) capacitor c=2.45228e-17
C7 (Eb VSS) capacitor c=6.3732e-17
C8 (net526 VSS) capacitor c=4.94823e-18
C9 (Db VSS) capacitor c=8.48048e-17
C10 (net494 VSS) capacitor c=3.18617e-18
C11 (qint VSS) capacitor c=3.6561e-17
C12 (SEb VSS) capacitor c=3.32565e-17
C13 (Dbp VSS) capacitor c=8.83023e-17
C14 (net518 VSS) capacitor c=1.39771e-18
C15 (qbint VSS) capacitor c=4.6892e-17
C16 (n30 VSS) capacitor c=4.58482e-17
C17 (net509 VSS) capacitor c=3.41934e-18
C18 (CKb VSS) capacitor c=7.52887e-17
C19 (mout VSS) capacitor c=4.37764e-17
C20 (Ckbb VSS) capacitor c=4.47334e-17
C21 (n20 VSS) capacitor c=4.4085e-17
C22 (net501 VSS) capacitor c=1.52067e-18
C23 (net449 VSS) capacitor c=1.88455e-18
C24 (net405 VSS) capacitor c=6.71218e-18
C25 (net441 VSS) capacitor c=1.64085e-18
C26 (net426 VSS) capacitor c=4.71835e-18
C27 (net417 VSS) capacitor c=1.2468e-18
C28 (\1\:CK VSS) capacitor c=3.27696e-17
C29 (\6\:CKb VSS) capacitor c=3.71459e-17
C30 (\5\:Ckbb VSS) capacitor c=3.66363e-17
C31 (\4\:CKb VSS) capacitor c=6.95285e-17
C32 (\3\:mout VSS) capacitor c=9.65807e-17
C33 (\3\:n20 VSS) capacitor c=5.63341e-17
C34 (\2\:CKb VSS) capacitor c=5.54083e-17
C35 (\16\:qbint VSS) capacitor c=5.31057e-17
C36 (\1\:SI VSS) capacitor c=5.39821e-17
C37 (\3\:SEb VSS) capacitor c=3.72403e-17
C38 (\5\:SE VSS) capacitor c=2.59369e-17
C39 (\6\:SE VSS) capacitor c=3.15321e-17
C40 (\4\:E VSS) capacitor c=6.53358e-17
C41 (\1\:D VSS) capacitor c=9.26442e-17
C42 (\1\:E VSS) capacitor c=5.28153e-17
C43 (\3\:CK VSS) capacitor c=5.00717e-17
C44 (\10\:CKb VSS) capacitor c=2.55572e-17
C45 (\8\:CKb VSS) capacitor c=4.77076e-17
C46 (\7\:Ckbb VSS) capacitor c=6.57069e-17
C47 (\3\:Ckbb VSS) capacitor c=3.7306e-17
C48 (\13\:qbint VSS) capacitor c=3.08739e-17
C49 (\3\:n30 VSS) capacitor c=4.90707e-17
C50 (\9\:qbint VSS) capacitor c=2.65114e-17
C51 (\3\:SI VSS) capacitor c=8.10922e-17
C52 (\1\:SE VSS) capacitor c=1.03329e-16
C53 (\4\:SE VSS) capacitor c=4.18448e-17
C54 (\3\:qint VSS) capacitor c=1.00295e-16
C55 (\3\:Eb VSS) capacitor c=5.75275e-17
C56 (\6\:E VSS) capacitor c=3.09247e-17
C57 (\3\:D VSS) capacitor c=6.32244e-17
C58 (\3\:E VSS) capacitor c=2.74337e-17
C59 (\4\:CK VSS) capacitor c=1.29561e-17
C60 (\9\:CKb VSS) capacitor c=1.85948e-17
C61 (\6\:Ckbb VSS) capacitor c=2.43767e-17
C62 (\5\:CKb VSS) capacitor c=3.00606e-17
C63 (\2\:mout VSS) capacitor c=5.17862e-17
C64 (\2\:n20 VSS) capacitor c=3.90024e-17
C65 (\4\:Ckbb VSS) capacitor c=3.99469e-17
C66 (\3\:CKb VSS) capacitor c=2.10798e-17
C67 (\2\:Ckbb VSS) capacitor c=4.12063e-17
C68 (\15\:qbint VSS) capacitor c=3.25864e-17
C69 (\2\:n30 VSS) capacitor c=3.80739e-17
C70 (\8\:qbint VSS) capacitor c=1.97356e-17
C71 (\4\:SI VSS) capacitor c=4.84068e-17
C72 (\4\:SEb VSS) capacitor c=4.71172e-17
C73 (\2\:SEb VSS) capacitor c=3.43092e-17
C74 (\3\:SE VSS) capacitor c=5.29068e-17
C75 (\2\:qint VSS) capacitor c=4.06128e-17
C76 (\4\:Eb VSS) capacitor c=4.52189e-17
C77 (\5\:E VSS) capacitor c=6.58165e-17
C78 (\2\:Eb VSS) capacitor c=3.50545e-17
C79 (\2\:D VSS) capacitor c=5.15234e-17
C80 (\2\:E VSS) capacitor c=4.16908e-17
C81 (\18\:CKb VSS) capacitor c=3.29215e-17
C82 (\1\:VDD VSS) capacitor c=5.93457e-17
C83 (\10\:Ckbb VSS) capacitor c=9.98175e-17
C84 (\8\:n20 VSS) capacitor c=4.29635e-17
C85 (\13\:VDD VSS) capacitor c=2.17812e-17
C86 (\4\:mout VSS) capacitor c=5.89414e-17
C87 (\8\:n30 VSS) capacitor c=5.97687e-17
C88 (\15\:VDD VSS) capacitor c=6.31179e-17
C89 (\21\:qbint VSS) capacitor c=4.93079e-17
C90 (\8\:qint VSS) capacitor c=1.70476e-17
C91 (\1\:Q VSS) capacitor c=6.54261e-17
C92 (\7\:Dbp VSS) capacitor c=9.27837e-17
C93 (\7\:SEb VSS) capacitor c=1.13337e-16
C94 (\21\:VDD VSS) capacitor c=6.87248e-17
C95 (\7\:Db VSS) capacitor c=1.14157e-16
C96 (\23\:VDD VSS) capacitor c=2.75365e-17
C97 (\7\:Eb VSS) capacitor c=7.94691e-17
C98 (\3\:VDD VSS) capacitor c=8.45461e-17
C99 (\11\:CKb VSS) capacitor c=2.32923e-17
C100 (\14\:Ckbb VSS) capacitor c=1.06097e-16
C101 (\3\:Dbp VSS) capacitor c=3.82227e-16
C102 (\4\:n20 VSS) capacitor c=6.9449e-17
C103 (\7\:mout VSS) capacitor c=4.87322e-17
C104 (\4\:n30 VSS) capacitor c=8.78565e-17
C105 (\19\:qbint VSS) capacitor c=5.02897e-17
C106 (\6\:qint VSS) capacitor c=8.23892e-17
C107 (\3\:Q VSS) capacitor c=4.88125e-17
C108 (\5\:Dbp VSS) capacitor c=3.61654e-16
C109 (\3\:Db VSS) capacitor c=1.52256e-16
C110 (\10\:SEb VSS) capacitor c=8.6339e-17
C111 (\5\:Db VSS) capacitor c=1.70268e-16
C112 (\5\:Eb VSS) capacitor c=9.66379e-17
C113 (\2\:SE VSS) capacitor c=5.71535e-17
C114 (\2\:qbint VSS) capacitor c=1.27861e-17
C115 (\3\:qbint VSS) capacitor c=3.73253e-18
C116 (\4\:qbint VSS) capacitor c=1.44319e-16
C117 (\14\:qbint VSS) capacitor c=2.68772e-17
C118 (\4\:D VSS) capacitor c=9.7041e-17
C119 (\7\:E VSS) capacitor c=7.61954e-17
C120 (\8\:E VSS) capacitor c=7.20808e-17
C121 (\7\:CKb VSS) capacitor c=3.55688e-17
C122 (\9\:Eb VSS) capacitor c=1.21866e-16
C123 (\10\:Eb VSS) capacitor c=4.60098e-17
C124 (\11\:Eb VSS) capacitor c=1.202e-16
C125 (\2\:CK VSS) capacitor c=3.79514e-17
C126 (\8\:SE VSS) capacitor c=5.25927e-17
C127 (\5\:SEb VSS) capacitor c=6.76918e-17
C128 (\6\:SEb VSS) capacitor c=1.37513e-16
C129 (\9\:SEb VSS) capacitor c=8.05773e-17
C130 (\5\:SI VSS) capacitor c=3.74785e-17
C131 (\4\:qint VSS) capacitor c=2.44122e-16
C132 (\5\:qint VSS) capacitor c=2.33881e-16
C133 (\17\:qbint VSS) capacitor c=5.43319e-17
C134 (\18\:qbint VSS) capacitor c=6.26099e-17
C135 (\6\:n30 VSS) capacitor c=8.78019e-17
C136 (\7\:n30 VSS) capacitor c=6.07084e-17
C137 (\6\:mout VSS) capacitor c=4.35284e-17
C138 (\9\:mout VSS) capacitor c=4.39292e-17
C139 (\6\:n20 VSS) capacitor c=5.93845e-17
C140 (\7\:n20 VSS) capacitor c=4.43323e-17
C141 (\8\:Ckbb VSS) capacitor c=6.34999e-17
C142 (\9\:Ckbb VSS) capacitor c=1.59172e-16
C143 (\12\:Ckbb VSS) capacitor c=1.30366e-16
C144 (\13\:Ckbb VSS) capacitor c=1.76076e-17
C145 (\16\:Ckbb VSS) capacitor c=4.66368e-17
C146 (\13\:CKb VSS) capacitor c=5.39534e-17
C147 (\14\:CKb VSS) capacitor c=1.32216e-16
C148 (\15\:CKb VSS) capacitor c=1.67086e-16
C149 (\16\:CKb VSS) capacitor c=7.49682e-17
C150 (\17\:CKb VSS) capacitor c=2.91227e-17
C151 (\5\:CK VSS) capacitor c=7.31758e-17
C152 (\5\:VDD VSS) capacitor c=4.54153e-17
C153 (\6\:VDD VSS) capacitor c=2.23379e-17
C154 (\8\:VDD VSS) capacitor c=1.11279e-16
C155 (\10\:VDD VSS) capacitor c=4.30426e-17
C156 (\12\:VDD VSS) capacitor c=2.42182e-17
Rk1 (\4\:D D) resistor r=0.003004 c=0
Rk17 (\5\:SI SI) resistor r=0.05217 c=0
Rk18 (\2\:Q Q) resistor r=0.2414 c=0
Rk19 (Q \4\:Q) resistor r=0.08409 c=0
Rk67 (\2\:VSS \4\:VSS) resistor r=0.4568 c=0
Rk68 (\4\:VSS \5\:VSS) resistor r=0.2823 c=0
Rk69 (\5\:VSS \6\:VSS) resistor r=0.5354 c=0
Rk70 (\6\:VSS \7\:VSS) resistor r=0.2832 c=0
Rk71 (\7\:VSS \8\:VSS) resistor r=0.1193 c=0
Rk73 (\8\:VSS \10\:VSS) resistor r=0.6392 c=0
Rk74 (\10\:VSS \11\:VSS) resistor r=0.1478 c=0
Rk76 (\12\:VSS VSS) resistor r=0.277 c=0
Rk75 (\11\:VSS \12\:VSS) resistor r=0.2723 c=0
Rk77 (\5\:VSS \14\:VSS) resistor r=0.04332 c=0
Rk78 (\6\:VSS \16\:VSS) resistor r=0.2366 c=0
Rk81 (\10\:VSS \22\:VSS) resistor r=0.1745 c=0
Rk82 (\12\:VSS \24\:VSS) resistor r=0.1211 c=0
Rk51 (\2\:VDD \4\:VDD) resistor r=0.5549 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.335 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.5229 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.2431 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.09512 c=0
Rk57 (\8\:VDD \10\:VDD) resistor r=0.7395 c=0
Rk58 (\10\:VDD \11\:VDD) resistor r=0.1628 c=0
Rk60 (\12\:VDD VDD) resistor r=0.278 c=0
Rk59 (\11\:VDD \12\:VDD) resistor r=0.2732 c=0
Rk61 (\5\:VDD \14\:VDD) resistor r=0.04332 c=0
Rk62 (\6\:VDD \16\:VDD) resistor r=0.3384 c=0
Rk65 (\10\:VDD \22\:VDD) resistor r=0.2473 c=0
Rk66 (\12\:VDD \24\:VDD) resistor r=0.1744 c=0
Rk9 (SE \8\:SE) resistor r=0.05225 c=0
Rk8 (\7\:SE \8\:SE) resistor r=0.001772 c=0
Rk3 (\8\:E E) resistor r=0.1322 c=0
Rk2 (\7\:E \8\:E) resistor r=0.53 c=0
Rk50 (CK \5\:CK) resistor r=0.06251 c=0
Rk4 (\6\:Eb \8\:Eb) resistor r=0.8928 c=0
Rk5 (\8\:Eb \9\:Eb) resistor r=0.2918 c=0
Rk6 (\9\:Eb \10\:Eb) resistor r=0.175 c=0
Rk7 (\9\:Eb \11\:Eb) resistor r=0.8958 c=0
Rk10 (\2\:Db \4\:Db) resistor r=0.4645 c=0
Rk11 (\4\:Db \6\:Db) resistor r=0.9933 c=0
Rk12 (\6\:Db \8\:Db) resistor r=0.5856 c=0
Rk20 (\4\:qint \5\:qint) resistor r=1.8102 c=0
Rk21 (\5\:qint \7\:qint) resistor r=0.5173 c=0
Rk22 (\5\:qint \9\:qint) resistor r=0.05784 c=0
Rk13 (\5\:SEb \6\:SEb) resistor r=0.4997 c=0
Rk14 (\6\:SEb \8\:SEb) resistor r=0.3644 c=0
Rk15 (\6\:SEb \9\:SEb) resistor r=0.3726 c=0
Rk16 (\8\:SEb \11\:SEb) resistor r=0.5618 c=0
Rk35 (\2\:Dbp \4\:Dbp) resistor r=0.4582 c=0
Rk36 (\4\:Dbp \6\:Dbp) resistor r=2.8143 c=0
Rk37 (\6\:Dbp \8\:Dbp) resistor r=0.3409 c=0
Rk23 (\17\:qbint \18\:qbint) resistor r=0.226 c=0
Rk24 (\18\:qbint \20\:qbint) resistor r=0.08584 c=0
Rk25 (\18\:qbint \22\:qbint) resistor r=0.2829 c=0
Rk26 (\5\:n30 \6\:n30) resistor r=0.4747 c=0
Rk27 (\6\:n30 \7\:n30) resistor r=0.2481 c=0
Rk28 (\6\:n30 \9\:n30) resistor r=0.345 c=0
Rk44 (\12\:CKb \13\:CKb) resistor r=0.2034 c=0
Rk45 (\13\:CKb \14\:CKb) resistor r=0.363 c=0
Rk46 (\14\:CKb \15\:CKb) resistor r=0.9003 c=0
Rk47 (\15\:CKb \16\:CKb) resistor r=0.554 c=0
Rk48 (\13\:CKb \17\:CKb) resistor r=0.1176 c=0
Rk49 (\14\:CKb \19\:CKb) resistor r=0.1756 c=0
Rk29 (\5\:mout \6\:mout) resistor r=0.3134 c=0
Rk30 (\6\:mout \8\:mout) resistor r=0.1882 c=0
Rk31 (\6\:mout \9\:mout) resistor r=0.2058 c=0
Rk38 (\8\:Ckbb \9\:Ckbb) resistor r=0.245 c=0
Rk39 (\9\:Ckbb \11\:Ckbb) resistor r=0.2901 c=0
Rk40 (\9\:Ckbb \12\:Ckbb) resistor r=1.0096 c=0
Rk41 (\12\:Ckbb \13\:Ckbb) resistor r=0.0984 c=0
Rk42 (\11\:Ckbb \15\:Ckbb) resistor r=0.6457 c=0
Rk43 (\12\:Ckbb \16\:Ckbb) resistor r=0.1375 c=0
Rk32 (\5\:n20 \6\:n20) resistor r=0.3803 c=0
Rk33 (\6\:n20 \7\:n20) resistor r=0.2058 c=0
Rk34 (\6\:n20 \9\:n20) resistor r=0.1206 c=0
Rl3 (\1\:D \2\:D) resistor r=78.079 c=0
Rl4 (\2\:D \3\:D) resistor r=122.31 c=0
Rl18 (\1\:SI \2\:SI) resistor r=47.9178 c=0
Rl19 (\2\:SI \3\:SI) resistor r=104.871 c=0
Rl20 (\2\:SI \4\:SI) resistor r=4.0612 c=0
Rl16 (\3\:SE \6\:SE) resistor r=94.9636 c=0
Rl14 (\3\:SE \4\:SE) resistor r=99.7951 c=0
Rl15 (\2\:SE \5\:SE) resistor r=30.4507 c=0
Rl12 (\1\:SE \2\:SE) resistor r=191.851 c=0
Rl13 (\2\:SE \3\:SE) resistor r=186.928 c=0
Rl6 (\4\:E \5\:E) resistor r=232.246 c=0
Rl7 (\5\:E \6\:E) resistor r=24.2328 c=0
Rl1 (\1\:E \2\:E) resistor r=155.769 c=0
Rl2 (\2\:E \3\:E) resistor r=48.2661 c=0
Rl52 (\1\:CK \2\:CK) resistor r=91.0479 c=0
Rl53 (\2\:CK \3\:CK) resistor r=173.385 c=0
Rl54 (\2\:CK \4\:CK) resistor r=5.1011 c=0
Rl8 (\3\:Eb \4\:Eb) resistor r=49.2328 c=0
Rl5 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl9 (qint \2\:qint) resistor r=24.2328 c=0
Rl10 (\2\:qint \3\:qint) resistor r=176.156 c=0
Rl17 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl11 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl21 (\2\:qbint qbint) resistor r=122.758 c=0
Rl27 (\2\:qbint \8\:qbint) resistor r=42.6971 c=0
Rl28 (\3\:qbint \9\:qbint) resistor r=36.22 c=0
Rl22 (\3\:qbint \2\:qbint) resistor r=27.3132 c=0
Rl23 (\4\:qbint \3\:qbint) resistor r=67.6978 c=0
Rl36 (\14\:qbint \16\:qbint) resistor r=82.3738 c=0
Rl34 (\14\:qbint \13\:qbint) resistor r=76.901 c=0
Rl35 (\14\:qbint \15\:qbint) resistor r=35.0048 c=0
Rl32 (n30 \2\:n30) resistor r=24.2328 c=0
Rl33 (\2\:n30 \3\:n30) resistor r=93.4636 c=0
Rl38 (CKb \2\:CKb) resistor r=168.796 c=0
Rl51 (\9\:CKb \10\:CKb) resistor r=39.1533 c=0
Rl45 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl39 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl48 (\6\:CKb \7\:CKb) resistor r=168.464 c=0
Rl49 (\7\:CKb \8\:CKb) resistor r=188.887 c=0
Rl50 (\7\:CKb \9\:CKb) resistor r=28.7715 c=0
Rl44 (\2\:mout \3\:mout) resistor r=86.3335 c=0
Rl43 (mout \2\:mout) resistor r=32.9629 c=0
Rl46 (\5\:Ckbb \6\:Ckbb) resistor r=24.2328 c=0
Rl47 (\6\:Ckbb \7\:Ckbb) resistor r=106.491 c=0
Rl40 (\3\:Ckbb \4\:Ckbb) resistor r=70.3867 c=0
Rl37 (Ckbb \2\:Ckbb) resistor r=38.5707 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=46.4312 c=0
Rl41 (n20 \2\:n20) resistor r=86.3335 c=0
Rz5 (\4\:Q \3\:Q) resistor r=75 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz16 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz2 (\3\:Db \4\:Db) resistor r=75 c=0
Rz3 (\5\:Db \6\:Db) resistor r=75 c=0
Rz6 (\6\:qint \7\:qint) resistor r=75 c=0
Rz4 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz11 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz12 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz7 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz8 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz14 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz9 (\7\:mout \8\:mout) resistor r=75 c=0
Rz13 (\14\:Ckbb \15\:Ckbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry5 (\2\:Q \1\:Q) resistor r=62 c=0
Ry22 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry23 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry24 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \15\:VDD) resistor r=20.6667 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=31 c=0
Ry21 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry1 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry2 (Db \2\:Db) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry6 (\8\:qint \9\:qint) resistor r=62 c=0
Ry4 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry11 (Dbp \2\:Dbp) resistor r=62 c=0
Ry12 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry7 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry8 (\8\:n30 \9\:n30) resistor r=31 c=0
Ry14 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\4\:mout \5\:mout) resistor r=62 c=0
Ry13 (\10\:Ckbb \11\:Ckbb) resistor r=62 c=0
Ry10 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\4\:SI \5\:SI) resistor r=45 c=0
Rx6 (\3\:SE \7\:SE) resistor r=45 c=0
Rx2 (\5\:E \7\:E) resistor r=45 c=0
Rx3 (\2\:E \8\:E) resistor r=45 c=0
Rx22 (\4\:CK \5\:CK) resistor r=45 c=0
Rx4 (\2\:Eb \10\:Eb) resistor r=45 c=0
Rx5 (\4\:Eb \11\:Eb) resistor r=45 c=0
Rx10 (\2\:qint \4\:qint) resistor r=45 c=0
Rx7 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx8 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx11 (\17\:qbint \15\:qbint) resistor r=45 c=0
Rx12 (\18\:qbint \8\:qbint) resistor r=45 c=0
Rx13 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx19 (\5\:CKb \15\:CKb) resistor r=45 c=0
Rx20 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx21 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:mout \9\:mout) resistor r=45 c=0
Rx16 (\6\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx17 (\4\:Ckbb \13\:Ckbb) resistor r=45 c=0
Rx18 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx15 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\5\:Eb \3\:E \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.03e-14 ps=1e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn10 (\10\:SEb \4\:SE \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=3.698e-14 ps=9.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=2.55e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn21 (\14\:Ckbb \10\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn20 (\11\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (net526 \3\:D \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.29e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98942e-07 sb=1.01692e-06 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn4 (\5\:Db \6\:E net526 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.93e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.08942e-07 sb=8.06923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn2 (\5\:Db \3\:Eb net494 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=7.93e-14 ps=6.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.58942e-07 sb=4.56923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn1 (net494 \3\:qint \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.63942e-07 sb=3.51923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn11 (\3\:Db SEb \5\:Dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.25529e-06 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(1)
mn13 (\5\:Dbp \1\:SE net518 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.02029e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn12 (net518 \3\:SI \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.14e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=9.15288e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn45 (\19\:qbint \3\:n30 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.525e-14 ad=5.33e-14 ps=1.12e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.53913e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn55 (\3\:Q \4\:qbint \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.222e-14 ad=4.16e-14 ps=1.295e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=5.60288e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(2)
mn56 (\6\:qint \9\:qbint \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=2.87e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.4e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn50 (net509 \13\:qbint \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.525e-14 ad=3.28e-14 ps=1.12e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.54e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn51 (\4\:n30 CKb net509 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.382e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.335e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn40 (\4\:n30 \3\:Ckbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=3.383e-14 ps=1.04e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.125e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn30 (\7\:mout n20 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=6.458e-14 ps=1.45e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=7.65e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn35 (net501 mout \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=2.255e-14 ps=1.45e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=5e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn36 (\4\:n20 \7\:Ckbb net501 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.255e-14 ad=3.28e-14 ps=6.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.745e-06 sb=3.45e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn25 (\4\:n20 \8\:CKb \3\:Dbp VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=1.4e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mp3 (net449 \1\:D \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.8141e-07 sd=160n sca=11.9271 \
        scb=0.00973247 scc=0.000231921 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.775e-14 ps=9e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.74551e-07 sb=8.7641e-07 sd=160n sca=11.6054 \
        scb=0.0095923 scc=0.000231863 m=(1)
mp2 (\7\:Db \4\:E net405 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.555e-14 ad=8.775e-14 ps=1.27e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.44551e-07 sb=6.0641e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp1 (net405 qint \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.363e-14 ad=9.555e-14 ps=1.33e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.34551e-07 sb=3.1641e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp11 (Db \5\:SE \7\:Dbp VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.443e-13 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37231e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp13 (\7\:Dbp \3\:SEb net441 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=1.443e-13 ps=1.05e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=9.57308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp12 (net441 \1\:SI \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.11e-13 ad=5.265e-14 ps=1.64e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.77308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp45 (\21\:qbint n30 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=4.5e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15385e-07 sb=1.52705e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.055e-13 ad=6.24e-14 ps=1.64e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=5.12308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(2)
mp56 (\8\:qint qbint \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1e-13 ad=3.58e-14 ps=1.64e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.38613e-06 sb=1.15484e-07 sd=160n sca=13.3668 scb=0.0122284 \
        scc=0.000582667 m=(1)
mp50 (net426 \16\:qbint \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.94e-14 ad=4.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84355e-07 sb=1.62e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 Ckbb net426 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.69355e-07 sb=1.435e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.765e-14 ad=4.96e-14 ps=1.25e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74355e-07 sb=1.23e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\4\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.108e-13 ad=9.765e-14 ps=1.77e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.13435e-06 sb=8.7e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net417 \3\:mout \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.108e-13 ad=1.86e-14 ps=1.77e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39935e-06 sb=6.05e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\8\:n20 \4\:CKb net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.89e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.50435e-06 sb=5e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (\8\:n20 \5\:Ckbb Dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=5.89e-14 ps=1.15e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73935e-06 sb=2.65e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
ends SEDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:14 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX4 CK D E Q SE SI VDD VSS
mp56 (\8\:qint \18\:qbint \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.28e-14 ad=1.521e-13 ps=1.37e-06 pd=1.56e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.57628e-07 sb=3.9e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp12 (net441 \4\:SI \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=5.65e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp13 (\4\:Dbp \2\:SEb net441 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.04551e-07 sb=4.6e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp11 (\5\:Db \6\:SE \4\:Dbp VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=8.775e-14 ps=1.16e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.39551e-07 sb=2.25e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp1 (net405 qint \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.995e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55705e-07 sb=9.69295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp2 (\7\:Db \2\:E net405 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60705e-07 sb=8.64295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=7.02e-14 ps=1.22e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85705e-07 sb=6.39295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp3 (net449 \1\:D \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=8.58e-14 ps=1.54e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.50705e-07 sb=3.74295e-07 sd=160n sca=17.4538 \
        scb=0.0152267 scc=0.00128072 m=(1)
mp55_1__rcx (Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.235e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.73641e-06 sd=160n sca=31.4485 \
        scb=0.0346421 scc=0.00289038 m=(4)
C1 (D VSS) capacitor c=1.42812e-16
C2 (Q VSS) capacitor c=2.57234e-16
C3 (CK VSS) capacitor c=4.37042e-17
C4 (VDD VSS) capacitor c=7.60459e-16
C5 (SE VSS) capacitor c=7.36724e-17
C6 (E VSS) capacitor c=6.56155e-17
C7 (SI VSS) capacitor c=5.70435e-17
C8 (qbint VSS) capacitor c=2.29569e-16
C9 (n30 VSS) capacitor c=1.88649e-16
C10 (net509 VSS) capacitor c=2.29117e-18
C11 (CKb VSS) capacitor c=2.42788e-17
C12 (mout VSS) capacitor c=5.32717e-17
C13 (Ckbb VSS) capacitor c=5.03907e-17
C14 (n20 VSS) capacitor c=3.99401e-17
C15 (net501 VSS) capacitor c=3.92598e-19
C16 (Dbp VSS) capacitor c=9.38008e-17
C17 (qint VSS) capacitor c=1.05836e-16
C18 (net518 VSS) capacitor c=4.02074e-18
C19 (Db VSS) capacitor c=9.42209e-17
C20 (SEb VSS) capacitor c=5.69769e-17
C21 (net494 VSS) capacitor c=7.29788e-18
C22 (Eb VSS) capacitor c=3.69975e-17
C23 (net426 VSS) capacitor c=4.31478e-18
C24 (net417 VSS) capacitor c=3.63511e-18
C25 (net441 VSS) capacitor c=2.40277e-18
C26 (net405 VSS) capacitor c=2.4314e-18
C27 (net449 VSS) capacitor c=6.67059e-18
C28 (\7\:E VSS) capacitor c=3.62009e-17
C29 (\1\:D VSS) capacitor c=4.31914e-17
C30 (\2\:E VSS) capacitor c=7.17544e-17
C31 (\1\:SE VSS) capacitor c=4.08992e-17
C32 (\6\:SE VSS) capacitor c=4.68449e-17
C33 (\2\:SEb VSS) capacitor c=7.03513e-17
C34 (\4\:SI VSS) capacitor c=6.84902e-17
C35 (\1\:CK VSS) capacitor c=2.41071e-17
C36 (\18\:qbint VSS) capacitor c=4.72578e-17
C37 (\7\:CKb VSS) capacitor c=2.18736e-17
C38 (\7\:Ckbb VSS) capacitor c=3.57881e-17
C39 (\4\:CKb VSS) capacitor c=1.07108e-16
C40 (\5\:CKb VSS) capacitor c=8.82931e-17
C41 (\14\:qbint VSS) capacitor c=4.5532e-17
C42 (\5\:E VSS) capacitor c=2.06363e-17
C43 (\3\:D VSS) capacitor c=6.91879e-17
C44 (\3\:E VSS) capacitor c=7.09038e-17
C45 (\3\:Eb VSS) capacitor c=6.40125e-17
C46 (\4\:qint VSS) capacitor c=2.81098e-17
C47 (\5\:SE VSS) capacitor c=3.93394e-17
C48 (\3\:SEb VSS) capacitor c=3.13543e-17
C49 (\4\:SE VSS) capacitor c=6.48711e-17
C50 (\1\:SI VSS) capacitor c=4.99463e-17
C51 (\3\:CK VSS) capacitor c=3.87561e-17
C52 (\20\:qbint VSS) capacitor c=4.41282e-17
C53 (\8\:CKb VSS) capacitor c=2.82543e-17
C54 (\5\:Ckbb VSS) capacitor c=5.95916e-17
C55 (\4\:mout VSS) capacitor c=5.55758e-17
C56 (\3\:n20 VSS) capacitor c=3.88756e-17
C57 (\3\:Ckbb VSS) capacitor c=3.33105e-17
C58 (\6\:CKb VSS) capacitor c=6.4441e-17
C59 (\17\:qbint VSS) capacitor c=3.841e-17
C60 (\6\:E VSS) capacitor c=2.57354e-17
C61 (\2\:D VSS) capacitor c=4.06323e-17
C62 (\4\:E VSS) capacitor c=4.64328e-17
C63 (\1\:E VSS) capacitor c=4.72399e-17
C64 (\3\:qint VSS) capacitor c=2.55575e-17
C65 (\2\:SE VSS) capacitor c=7.85904e-17
C66 (\5\:SEb VSS) capacitor c=3.78165e-17
C67 (\4\:SEb VSS) capacitor c=3.95696e-17
C68 (\3\:SI VSS) capacitor c=2.54846e-17
C69 (\2\:CK VSS) capacitor c=3.54205e-17
C70 (\2\:CKb VSS) capacitor c=3.69686e-17
C71 (\19\:qbint VSS) capacitor c=3.0732e-17
C72 (\8\:Ckbb VSS) capacitor c=3.29668e-17
C73 (\6\:Ckbb VSS) capacitor c=4.27648e-17
C74 (\3\:mout VSS) capacitor c=2.35477e-17
C75 (\2\:n20 VSS) capacitor c=3.33874e-17
C76 (\4\:Ckbb VSS) capacitor c=2.8974e-17
C77 (\2\:Ckbb VSS) capacitor c=3.44994e-17
C78 (\16\:qbint VSS) capacitor c=2.79274e-17
C79 (\8\:qbint VSS) capacitor c=1.99353e-17
C80 (\7\:Eb VSS) capacitor c=1.01398e-16
C81 (\16\:VDD VSS) capacitor c=3.67865e-17
C82 (\7\:Db VSS) capacitor c=5.60763e-17
C83 (\18\:VDD VSS) capacitor c=4.11068e-17
C84 (\9\:SEb VSS) capacitor c=9.28764e-17
C85 (\5\:Db VSS) capacitor c=4.53421e-17
C86 (\4\:Dbp VSS) capacitor c=5.44263e-17
C87 (\20\:VDD VSS) capacitor c=2.05931e-17
C88 (\13\:CKb VSS) capacitor c=5.6802e-17
C89 (\8\:qint VSS) capacitor c=8.28028e-17
C90 (\22\:VDD VSS) capacitor c=6.46831e-17
C91 (\9\:Ckbb VSS) capacitor c=6.6158e-17
C92 (\10\:Dbp VSS) capacitor c=4.32015e-17
C93 (\4\:n20 VSS) capacitor c=6.24892e-17
C94 (\24\:VDD VSS) capacitor c=4.99971e-17
C95 (\9\:mout VSS) capacitor c=5.25073e-17
C96 (\7\:n30 VSS) capacitor c=2.91211e-17
C97 (\26\:qbint VSS) capacitor c=3.99166e-17
C98 (\1\:VDD VSS) capacitor c=1.10141e-16
C99 (\5\:Eb VSS) capacitor c=4.79193e-17
C100 (\6\:SEb VSS) capacitor c=6.29787e-17
C101 (\9\:Db VSS) capacitor c=7.57205e-17
C102 (\9\:CKb VSS) capacitor c=8.91886e-17
C103 (\6\:qint VSS) capacitor c=2.69097e-16
C104 (\11\:Ckbb VSS) capacitor c=7.80353e-17
C105 (\7\:Dbp VSS) capacitor c=7.23899e-17
C106 (\8\:n20 VSS) capacitor c=7.49663e-17
C107 (\7\:mout VSS) capacitor c=5.52002e-17
C108 (\11\:n30 VSS) capacitor c=8.33719e-17
C109 (\28\:qbint VSS) capacitor c=3.38555e-17
C110 (\15\:qbint VSS) capacitor c=3.12907e-17
C111 (\2\:mout VSS) capacitor c=3.497e-17
C112 (\3\:CKb VSS) capacitor c=6.45748e-17
C113 (\2\:SI VSS) capacitor c=3.72236e-17
C114 (\3\:SE VSS) capacitor c=7.29359e-17
C115 (\2\:qint VSS) capacitor c=2.38444e-17
C116 (\9\:n30 VSS) capacitor c=9.65347e-17
C117 (\10\:n30 VSS) capacitor c=9.27899e-17
C118 (\2\:Eb VSS) capacitor c=5.12911e-17
C119 (\5\:mout VSS) capacitor c=6.52896e-17
C120 (\6\:mout VSS) capacitor c=4.56282e-17
C121 (\6\:n20 VSS) capacitor c=8.43628e-17
C122 (\7\:n20 VSS) capacitor c=8.41085e-17
C123 (\13\:Ckbb VSS) capacitor c=1.07936e-16
C124 (\14\:Ckbb VSS) capacitor c=1.29558e-16
C125 (\15\:Ckbb VSS) capacitor c=1.34144e-16
C126 (\16\:Ckbb VSS) capacitor c=9.19873e-17
C127 (\17\:Ckbb VSS) capacitor c=7.28414e-17
C128 (\18\:Ckbb VSS) capacitor c=4.13122e-17
C129 (\19\:Ckbb VSS) capacitor c=5.14172e-17
C130 (\21\:qbint VSS) capacitor c=2.5675e-16
C131 (\22\:qbint VSS) capacitor c=2.4549e-16
C132 (\23\:qbint VSS) capacitor c=2.42832e-17
C133 (\24\:qbint VSS) capacitor c=3.05722e-17
C134 (\25\:qbint VSS) capacitor c=2.35956e-17
C135 (\11\:CKb VSS) capacitor c=1.67879e-16
C136 (\12\:CKb VSS) capacitor c=9.91113e-17
C137 (\4\:CK VSS) capacitor c=7.26217e-17
C138 (\5\:SI VSS) capacitor c=8.75724e-17
C139 (\3\:Dbp VSS) capacitor c=2.47862e-16
C140 (\6\:Dbp VSS) capacitor c=2.56556e-16
C141 (\8\:SEb VSS) capacitor c=5.15438e-17
C142 (\11\:SEb VSS) capacitor c=1.21341e-16
C143 (\12\:SEb VSS) capacitor c=4.02108e-17
C144 (\13\:SEb VSS) capacitor c=4.17474e-17
C145 (\5\:qint VSS) capacitor c=2.99209e-16
C146 (\7\:SE VSS) capacitor c=5.04509e-17
C147 (\3\:Db VSS) capacitor c=1.48872e-16
C148 (\4\:Db VSS) capacitor c=9.48019e-17
C149 (\8\:E VSS) capacitor c=6.82223e-17
C150 (\9\:E VSS) capacitor c=6.24321e-17
C151 (\10\:E VSS) capacitor c=3.24864e-17
C152 (\9\:Eb VSS) capacitor c=1.09596e-16
C153 (\3\:VDD VSS) capacitor c=1.39991e-17
C154 (\4\:VDD VSS) capacitor c=3.15254e-17
C155 (\6\:VDD VSS) capacitor c=4.55517e-17
C156 (\7\:VDD VSS) capacitor c=3.84391e-17
C157 (\9\:VDD VSS) capacitor c=6.40935e-17
Rk53 (D \4\:D) resistor r=0.00509 c=0
Rk33 (CK \4\:CK) resistor r=0.1025 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.05499 c=0
Rk60 (\3\:VDD \4\:VDD) resistor r=0.4009 c=0
Rk61 (\4\:VDD \5\:VDD) resistor r=0.3961 c=0
Rk62 (\5\:VDD \6\:VDD) resistor r=0.356 c=0
Rk63 (\6\:VDD \7\:VDD) resistor r=0.6543 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.1929 c=0
Rk66 (\9\:VDD VDD) resistor r=0.6518 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.4513 c=0
Rk72 (\3\:VDD \17\:VDD) resistor r=0.2547 c=0
Rk73 (\4\:VDD \19\:VDD) resistor r=0.2554 c=0
Rk74 (\6\:VDD \21\:VDD) resistor r=0.07405 c=0
Rk75 (\7\:VDD \23\:VDD) resistor r=0.2723 c=0
Rk76 (\9\:VDD \25\:VDD) resistor r=0.2637 c=0
Rk47 (SE \7\:SE) resistor r=0.02065 c=0
Rk55 (\9\:E E) resistor r=0.2611 c=0
Rk54 (\8\:E \9\:E) resistor r=0.3114 c=0
Rk56 (E \10\:E) resistor r=0.1412 c=0
Rk34 (SI \5\:SI) resistor r=0.0691 c=0
Rk80 (\2\:VSS \3\:VSS) resistor r=0.05499 c=0
Rk81 (\3\:VSS \4\:VSS) resistor r=0.436 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.361 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.3459 c=0
Rk84 (\6\:VSS \7\:VSS) resistor r=0.6518 c=0
Rk85 (\7\:VSS \8\:VSS) resistor r=0.2055 c=0
Rk87 (\9\:VSS VSS) resistor r=0.6718 c=0
Rk86 (\8\:VSS \9\:VSS) resistor r=0.4463 c=0
Rk93 (\3\:VSS \17\:VSS) resistor r=0.2915 c=0
Rk94 (\4\:VSS \19\:VSS) resistor r=0.2384 c=0
Rk95 (\6\:VSS \21\:VSS) resistor r=0.2604 c=0
Rk96 (\7\:VSS \23\:VSS) resistor r=0.2993 c=0
Rk97 (\9\:VSS \25\:VSS) resistor r=0.296 c=0
Rk24 (\21\:qbint \22\:qbint) resistor r=2.266 c=0
Rk25 (\22\:qbint \23\:qbint) resistor r=0.183 c=0
Rk26 (\23\:qbint \24\:qbint) resistor r=0.2231 c=0
Rk27 (\24\:qbint \25\:qbint) resistor r=0.1016 c=0
Rk28 (\23\:qbint \27\:qbint) resistor r=0.1387 c=0
Rk29 (\24\:qbint \29\:qbint) resistor r=0.1868 c=0
Rk7 (\8\:n30 \9\:n30) resistor r=0.06101 c=0
Rk8 (\9\:n30 \10\:n30) resistor r=0.6427 c=0
Rk9 (\9\:n30 \12\:n30) resistor r=0.3688 c=0
Rk30 (\10\:CKb \11\:CKb) resistor r=0.5558 c=0
Rk31 (\11\:CKb \12\:CKb) resistor r=0.8925 c=0
Rk32 (\11\:CKb \14\:CKb) resistor r=0.1782 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.2587 c=0
Rk11 (\6\:mout \8\:mout) resistor r=0.1613 c=0
Rk12 (\6\:mout \10\:mout) resistor r=0.2265 c=0
Rk16 (\10\:Ckbb \12\:Ckbb) resistor r=0.3391 c=0
Rk17 (\12\:Ckbb \13\:Ckbb) resistor r=0.506 c=0
Rk18 (\13\:Ckbb \14\:Ckbb) resistor r=0.4525 c=0
Rk19 (\14\:Ckbb \15\:Ckbb) resistor r=0.7052 c=0
Rk20 (\15\:Ckbb \16\:Ckbb) resistor r=0.5982 c=0
Rk21 (\13\:Ckbb \17\:Ckbb) resistor r=0.4144 c=0
Rk22 (\14\:Ckbb \18\:Ckbb) resistor r=0.08119 c=0
Rk23 (\15\:Ckbb \19\:Ckbb) resistor r=0.2304 c=0
Rk13 (\5\:n20 \6\:n20) resistor r=0.1815 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.4381 c=0
Rk15 (\6\:n20 \9\:n20) resistor r=0.3158 c=0
Rk35 (\2\:Dbp \3\:Dbp) resistor r=0.6187 c=0
Rk36 (\3\:Dbp \5\:Dbp) resistor r=0.1001 c=0
Rk37 (\3\:Dbp \6\:Dbp) resistor r=1.7858 c=0
Rk38 (\6\:Dbp \8\:Dbp) resistor r=0.4313 c=0
Rk39 (\5\:Dbp \9\:Dbp) resistor r=0.1794 c=0
Rk40 (\6\:Dbp \11\:Dbp) resistor r=0.1628 c=0
Rk45 (\5\:qint \7\:qint) resistor r=2.3912 c=0
Rk46 (\7\:qint \9\:qint) resistor r=0.5296 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.6497 c=0
Rk49 (\3\:Db \4\:Db) resistor r=0.6435 c=0
Rk50 (\4\:Db \6\:Db) resistor r=0.07972 c=0
Rk51 (\3\:Db \8\:Db) resistor r=0.2506 c=0
Rk52 (\4\:Db \10\:Db) resistor r=0.4293 c=0
Rk41 (\7\:SEb \8\:SEb) resistor r=0.1937 c=0
Rk42 (\10\:SEb \11\:SEb) resistor r=0.7898 c=0
Rk43 (\11\:SEb \12\:SEb) resistor r=0.08634 c=0
Rk44 (\11\:SEb \13\:SEb) resistor r=0.2134 c=0
Rk57 (\6\:Eb \8\:Eb) resistor r=0.4652 c=0
Rk58 (\8\:Eb \9\:Eb) resistor r=0.6821 c=0
Rl60 (\1\:D \2\:D) resistor r=39.1533 c=0
Rl61 (\2\:D \3\:D) resistor r=87.2302 c=0
Rl39 (\1\:CK \2\:CK) resistor r=67.3077 c=0
Rl40 (\2\:CK \3\:CK) resistor r=70.3297 c=0
Rl47 (\1\:SE \2\:SE) resistor r=132.669 c=0
Rl50 (\2\:SE \5\:SE) resistor r=97.872 c=0
Rl51 (\3\:SE \6\:SE) resistor r=47.3105 c=0
Rl49 (\3\:SE \4\:SE) resistor r=143.03 c=0
Rl48 (\2\:SE \3\:SE) resistor r=241.222 c=0
Rl63 (\6\:E \7\:E) resistor r=97.2527 c=0
Rl62 (\5\:E \6\:E) resistor r=40.3846 c=0
Rl59 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl55 (\1\:E \2\:E) resistor r=33.8727 c=0
Rl43 (\2\:SI \4\:SI) resistor r=37.3411 c=0
Rl41 (\1\:SI \2\:SI) resistor r=110.786 c=0
Rl42 (\2\:SI \3\:SI) resistor r=8.3025 c=0
Rl38 (\20\:qbint \18\:qbint) resistor r=92.3077 c=0
Rl37 (\19\:qbint \18\:qbint) resistor r=146.131 c=0
Rl7 (qbint \8\:qbint) resistor r=9.5287 c=0
Rl18 (\15\:qbint \14\:qbint) resistor r=34.3295 c=0
Rl20 (\15\:qbint \17\:qbint) resistor r=124.714 c=0
Rl19 (\15\:qbint \16\:qbint) resistor r=11.4953 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=520.72 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=210.777 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=24.7951 c=0
Rl30 (CKb \2\:CKb) resistor r=35.3482 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=149.543 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=49.6815 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=248.466 c=0
Rl25 (mout \2\:mout) resistor r=95.0334 c=0
Rl27 (\2\:mout \4\:mout) resistor r=62.3411 c=0
Rl26 (\2\:mout \3\:mout) resistor r=6.9867 c=0
Rl29 (\7\:Ckbb \8\:Ckbb) resistor r=30.0021 c=0
Rl28 (\5\:Ckbb \6\:Ckbb) resistor r=35.7713 c=0
Rl22 (\3\:Ckbb \4\:Ckbb) resistor r=24.2328 c=0
Rl21 (Ckbb \2\:Ckbb) resistor r=64.6174 c=0
Rl23 (n20 \2\:n20) resistor r=24.2328 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=114.617 c=0
Rl52 (qint \2\:qint) resistor r=120.387 c=0
Rl54 (\2\:qint \4\:qint) resistor r=28.0797 c=0
Rl53 (\2\:qint \3\:qint) resistor r=54.6257 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=27.6559 c=0
Rl46 (\4\:SEb \5\:SEb) resistor r=107.617 c=0
Rl44 (SEb \2\:SEb) resistor r=39.4 c=0
Rl56 (Eb \2\:Eb) resistor r=67.4757 c=0
Rl57 (\2\:Eb \3\:Eb) resistor r=139.972 c=0
Rl58 (\2\:Eb \4\:Eb) resistor r=1.2666 c=0
Rz19 (VDD \1\:VDD) resistor r=6.25 c=0
Rz16 (\2\:VDD \1\:VDD) resistor r=15 c=0
Rz17 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz18 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz25 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz7 (\29\:qbint \28\:qbint) resistor r=75 c=0
Rz3 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz8 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz6 (\11\:Ckbb \12\:Ckbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Dbp \2\:Dbp) resistor r=75 c=0
Rz10 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz12 (\6\:qint \7\:qint) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\9\:Db \10\:Db) resistor r=75 c=0
Rz11 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz15 (\5\:Eb \6\:Eb) resistor r=75 c=0
Ry18 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry29 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry27 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry28 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry3 (\8\:n30 \7\:n30) resistor r=62 c=0
Ry8 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry6 (\9\:Ckbb \10\:Ckbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry10 (\4\:Dbp \9\:Dbp) resistor r=62 c=0
Ry11 (\10\:Dbp \11\:Dbp) resistor r=62 c=0
Ry13 (\8\:qint \9\:qint) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry15 (\7\:Db \8\:Db) resistor r=31 c=0
Ry12 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry16 (\7\:Eb \8\:Eb) resistor r=62 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:SE \7\:SE) resistor r=45 c=0
Rx20 (\1\:E \8\:E) resistor r=45 c=0
Rx21 (\4\:E \9\:E) resistor r=45 c=0
Rx22 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx8 (\21\:qbint \19\:qbint) resistor r=45 c=0
Rx9 (\22\:qbint \16\:qbint) resistor r=45 c=0
Rx10 (\25\:qbint \8\:qbint) resistor r=45 c=0
Rx1 (\10\:n30 n30) resistor r=45 c=0
Rx11 (\2\:CKb \12\:CKb) resistor r=45 c=0
Rx2 (\3\:mout \5\:mout) resistor r=45 c=0
Rx4 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx5 (\8\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx6 (\6\:Ckbb \18\:Ckbb) resistor r=45 c=0
Rx7 (\4\:Ckbb \19\:Ckbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\3\:qint \5\:qint) resistor r=45 c=0
Rx14 (\5\:SEb \8\:SEb) resistor r=45 c=0
Rx15 (SEb \12\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \13\:SEb) resistor r=45 c=0
Rx23 (\4\:Eb \9\:Eb) resistor r=45 c=0
mn56 (\6\:qint \20\:qbint \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.345e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.70288e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn12 (net518 \1\:SI \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.888e-14 ad=3.77e-14 ps=1.11e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35192e-07 sb=5.65e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn13 (Dbp \4\:SE net518 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=4.94e-14 ps=8.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25192e-07 sb=3.75e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn11 (\9\:Db \3\:SEb Dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.60192e-07 sb=1.4e-07 sd=160n sca=13.5771 scb=0.0135427 \
        scc=0.000870653 m=(1)
mn1 (net494 \4\:qint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.852e-14 ad=6.24e-14 ps=1.27e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05192e-07 sb=1.00173e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (Db \3\:Eb net494 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.90192e-07 sb=7.16731e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (Db \3\:E net526 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.95192e-07 sb=5.11731e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3 (net526 \3\:D \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=1.56e-14 ps=1.39e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00019e-06 sb=4.06731e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn55_1__rcx (Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.152e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72817e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn50 (net509 \17\:qbint VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.92e-14 ps=8.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.945e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\11\:n30 \6\:CKb net509 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=5.842e-14 ps=8.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=1.66e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\11\:n30 \3\:Ckbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.74e-14 ad=5.842e-14 ps=9.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.33e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.432e-14 ad=5.74e-14 ps=9.4e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net501 \4\:mout \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=1.23e-14 ps=9.4e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.95e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:Ckbb net501 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.715e-14 ps=5.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.9e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:n20 \8\:CKb \7\:Dbp VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.715e-14 ps=1.04e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn45 (\28\:qbint n30 VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.58e-14 ad=3.28e-14 ps=8.85e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(2)
mn21 (\11\:Ckbb CKb \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn20 (\9\:CKb \3\:CK \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.888e-14 ad=2.175e-14 ps=1.11e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=9.05e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn10 (\6\:SEb \5\:SE \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.852e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.57017e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn0 (\5\:Eb \5\:E \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=2.465e-14 ps=1.39e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57466e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp50 (net426 \14\:qbint VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.84e-14 ad=3.565e-14 ps=1.23e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.82e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp51 (\7\:n30 Ckbb net426 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.905e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.66e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp40 (\7\:n30 \5\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=7.905e-14 ps=1.49e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.93e-06 sb=1.36e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp30 (\9\:mout n20 \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.3485e-13 ps=1.15e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.8e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp35 (net417 mout \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=4.96e-14 ps=1.15e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.7e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp36 (\4\:n20 \4\:CKb net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.58e-14 ps=9.4e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp25 (\4\:n20 \7\:Ckbb \10\:Dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=5.58e-14 ps=9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp45 (\26\:qbint n30 VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.42e-14 ad=4.96e-14 ps=1.205e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(2)
mp21 (\9\:Ckbb \7\:CKb \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.28e-14 ad=4.3e-14 ps=1.37e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=6.8e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp20 (\13\:CKb \1\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp10 (\9\:SEb \1\:SE \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.995e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12814e-06 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp0 (\7\:Eb \7\:E \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22233e-06 sb=1.4e-07 sd=160n sca=29.3406 \
        scb=0.0316245 scc=0.00259206 m=(1)
ends SEDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:15 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX8 CK D E Q SE SI VDD VSS
mp55_1__rcx (Q qbint \12\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87978e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (D VSS) capacitor c=7.80229e-17
C2 (CK VSS) capacitor c=8.15234e-17
C3 (VDD VSS) capacitor c=4.77867e-16
C4 (SE VSS) capacitor c=6.92726e-17
C5 (Q VSS) capacitor c=4.88581e-16
C6 (SI VSS) capacitor c=5.9637e-17
C7 (qbint VSS) capacitor c=3.78962e-16
C8 (n30 VSS) capacitor c=2.08611e-16
C9 (CKb VSS) capacitor c=3.56599e-17
C10 (net509 VSS) capacitor c=1.63557e-18
C11 (mout VSS) capacitor c=5.41216e-17
C12 (Ckbb VSS) capacitor c=3.5076e-17
C13 (n20 VSS) capacitor c=6.14683e-17
C14 (net501 VSS) capacitor c=1.73278e-18
C15 (Dbp VSS) capacitor c=4.50004e-17
C16 (qint VSS) capacitor c=5.30659e-17
C17 (net518 VSS) capacitor c=3.88713e-18
C18 (Db VSS) capacitor c=5.04517e-17
C19 (SEb VSS) capacitor c=4.66919e-17
C20 (net494 VSS) capacitor c=8.40528e-18
C21 (Eb VSS) capacitor c=4.76216e-17
C22 (net526 VSS) capacitor c=1.16406e-19
C23 (net426 VSS) capacitor c=8.95935e-19
C24 (net417 VSS) capacitor c=7.44544e-18
C25 (net441 VSS) capacitor c=5.18739e-19
C26 (net405 VSS) capacitor c=3.55892e-18
C27 (net449 VSS) capacitor c=4.24268e-18
C28 (\7\:E VSS) capacitor c=6.40814e-17
C29 (\3\:D VSS) capacitor c=7.29087e-17
C30 (\1\:E VSS) capacitor c=5.86786e-17
C31 (\1\:SE VSS) capacitor c=4.86177e-17
C32 (\6\:SE VSS) capacitor c=3.25241e-17
C33 (\2\:SEb VSS) capacitor c=9.02415e-17
C34 (\3\:SI VSS) capacitor c=7.89076e-17
C35 (\25\:qbint VSS) capacitor c=1.49427e-16
C36 (\7\:Ckbb VSS) capacitor c=3.78555e-17
C37 (\4\:CKb VSS) capacitor c=9.40074e-17
C38 (\5\:CKb VSS) capacitor c=1.09697e-16
C39 (\24\:qbint VSS) capacitor c=4.65029e-17
C40 (\3\:CK VSS) capacitor c=3.22731e-17
C41 (\5\:E VSS) capacitor c=3.12429e-17
C42 (\1\:D VSS) capacitor c=7.74016e-17
C43 (\3\:E VSS) capacitor c=6.49697e-17
C44 (\3\:Eb VSS) capacitor c=6.31245e-17
C45 (\4\:qint VSS) capacitor c=5.86841e-17
C46 (\5\:SE VSS) capacitor c=4.36828e-17
C47 (\3\:SEb VSS) capacitor c=3.09005e-17
C48 (\4\:SE VSS) capacitor c=6.86296e-17
C49 (\1\:SI VSS) capacitor c=3.22287e-17
C50 (\7\:CKb VSS) capacitor c=2.85349e-17
C51 (\8\:CKb VSS) capacitor c=2.99661e-17
C52 (\5\:Ckbb VSS) capacitor c=5.69313e-17
C53 (\3\:mout VSS) capacitor c=6.63669e-17
C54 (\3\:n20 VSS) capacitor c=2.70239e-17
C55 (\3\:Ckbb VSS) capacitor c=3.157e-17
C56 (\9\:CKb VSS) capacitor c=4.96095e-17
C57 (\22\:qbint VSS) capacitor c=9.33036e-17
C58 (\1\:CK VSS) capacitor c=3.81579e-17
C59 (\6\:E VSS) capacitor c=5.34491e-17
C60 (\2\:D VSS) capacitor c=8.04193e-17
C61 (\4\:E VSS) capacitor c=5.08317e-17
C62 (\2\:Eb VSS) capacitor c=7.04865e-17
C63 (\2\:E VSS) capacitor c=4.29476e-17
C64 (\3\:qint VSS) capacitor c=2.92356e-17
C65 (\2\:SE VSS) capacitor c=6.23581e-17
C66 (\4\:SEb VSS) capacitor c=4.76589e-17
C67 (\2\:SI VSS) capacitor c=4.36161e-17
C68 (\8\:Ckbb VSS) capacitor c=2.87851e-17
C69 (\6\:Ckbb VSS) capacitor c=4.72197e-17
C70 (\2\:mout VSS) capacitor c=5.17003e-17
C71 (\2\:n20 VSS) capacitor c=3.76324e-17
C72 (\4\:Ckbb VSS) capacitor c=4.02179e-17
C73 (\6\:CKb VSS) capacitor c=5.98193e-17
C74 (\2\:Ckbb VSS) capacitor c=4.77648e-17
C75 (\23\:qbint VSS) capacitor c=6.91765e-17
C76 (\2\:CK VSS) capacitor c=4.27805e-17
C77 (\6\:Eb VSS) capacitor c=1.02715e-16
C78 (\1\:VDD VSS) capacitor c=3.28502e-17
C79 (\7\:Db VSS) capacitor c=1.25691e-16
C80 (\18\:VDD VSS) capacitor c=2.64264e-17
C81 (\5\:SEb VSS) capacitor c=1.13688e-16
C82 (\5\:Db VSS) capacitor c=7.32563e-17
C83 (\4\:Dbp VSS) capacitor c=6.14088e-17
C84 (\6\:qint VSS) capacitor c=2.80928e-16
C85 (\11\:Ckbb VSS) capacitor c=6.76629e-17
C86 (\8\:Dbp VSS) capacitor c=9.5172e-17
C87 (\4\:n20 VSS) capacitor c=1.01433e-16
C88 (\24\:VDD VSS) capacitor c=6.44045e-17
C89 (\8\:mout VSS) capacitor c=5.45262e-17
C90 (\11\:n30 VSS) capacitor c=8.59052e-17
C91 (\26\:VDD VSS) capacitor c=1.30415e-17
C92 (\13\:CKb VSS) capacitor c=6.6341e-17
C93 (\34\:qbint VSS) capacitor c=3.22747e-16
C94 (\3\:VDD VSS) capacitor c=1.00615e-16
C95 (\4\:Eb VSS) capacitor c=8.0021e-17
C96 (\9\:SEb VSS) capacitor c=8.34774e-17
C97 (\9\:Db VSS) capacitor c=3.54305e-17
C98 (\8\:qint VSS) capacitor c=7.30119e-17
C99 (\9\:Ckbb VSS) capacitor c=5.92846e-17
C100 (\6\:Dbp VSS) capacitor c=1.8639e-16
C101 (\8\:n20 VSS) capacitor c=1.74636e-17
C102 (\6\:mout VSS) capacitor c=3.12081e-17
C103 (\13\:n30 VSS) capacitor c=2.26812e-16
C104 (\10\:CKb VSS) capacitor c=4.49181e-17
C105 (\2\:CKb VSS) capacitor c=4.35932e-17
C106 (\3\:CKb VSS) capacitor c=6.36842e-17
C107 (\3\:SE VSS) capacitor c=7.6366e-17
C108 (\2\:qint VSS) capacitor c=4.12309e-17
C109 (\4\:CK VSS) capacitor c=4.79486e-17
C110 (\12\:CKb VSS) capacitor c=9.09034e-17
C111 (\15\:CKb VSS) capacitor c=9.5597e-17
C112 (\15\:n30 VSS) capacitor c=1.81206e-16
C113 (\4\:mout VSS) capacitor c=7.13213e-17
C114 (\5\:mout VSS) capacitor c=6.60219e-17
C115 (\6\:n20 VSS) capacitor c=7.32269e-17
C116 (\7\:n20 VSS) capacitor c=5.86108e-17
C117 (\13\:Ckbb VSS) capacitor c=9.68022e-17
C118 (\14\:Ckbb VSS) capacitor c=1.66357e-16
C119 (\15\:Ckbb VSS) capacitor c=2.13015e-16
C120 (\16\:Ckbb VSS) capacitor c=8.70042e-17
C121 (\17\:Ckbb VSS) capacitor c=6.52404e-17
C122 (\18\:Ckbb VSS) capacitor c=5.00661e-17
C123 (\19\:Ckbb VSS) capacitor c=7.79415e-17
C124 (\32\:qbint VSS) capacitor c=2.86525e-16
C125 (\33\:qbint VSS) capacitor c=4.13513e-16
C126 (\39\:qbint VSS) capacitor c=2.85477e-17
C127 (\40\:qbint VSS) capacitor c=6.81373e-17
C128 (\4\:SI VSS) capacitor c=5.49702e-17
C129 (\3\:Dbp VSS) capacitor c=2.08925e-16
C130 (\7\:SEb VSS) capacitor c=9.73722e-17
C131 (\8\:SEb VSS) capacitor c=8.05213e-17
C132 (\11\:SEb VSS) capacitor c=2.63982e-17
C133 (\7\:SE VSS) capacitor c=3.69201e-17
C134 (\5\:qint VSS) capacitor c=2.27209e-16
C135 (\3\:Db VSS) capacitor c=1.18672e-16
C136 (\4\:Db VSS) capacitor c=8.89726e-17
C137 (\4\:D VSS) capacitor c=3.2504e-17
C138 (\8\:E VSS) capacitor c=6.496e-17
C139 (\9\:E VSS) capacitor c=1.04809e-16
C140 (\10\:E VSS) capacitor c=5.27294e-17
C141 (\8\:Eb VSS) capacitor c=6.63255e-17
C142 (\5\:VDD VSS) capacitor c=4.60599e-17
C143 (\6\:VDD VSS) capacitor c=1.58857e-16
C144 (\9\:VDD VSS) capacitor c=4.57488e-17
C145 (\11\:VDD VSS) capacitor c=3.29379e-17
C146 (\12\:VDD VSS) capacitor c=5.00317e-16
Rk62 (D \4\:D) resistor r=0.05675 c=0
Rk13 (\4\:CK CK) resistor r=0.03487 c=0
Rk68 (\2\:VSS \4\:VSS) resistor r=0.4272 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.2958 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.5941 c=0
Rk73 (\6\:VSS \9\:VSS) resistor r=0.7145 c=0
Rk74 (\9\:VSS \10\:VSS) resistor r=0.2807 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.3083 c=0
Rk82 (\12\:VSS VSS) resistor r=0.1074 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.5163 c=0
Rk83 (\5\:VSS \19\:VSS) resistor r=0.1786 c=0
Rk86 (\9\:VSS \25\:VSS) resistor r=0.2099 c=0
Rk87 (\11\:VSS \27\:VSS) resistor r=0.1429 c=0
Rk93 (\2\:VDD \4\:VDD) resistor r=0.2953 c=0
Rk94 (\4\:VDD \5\:VDD) resistor r=0.2647 c=0
Rk95 (\5\:VDD \6\:VDD) resistor r=0.696 c=0
Rk98 (\6\:VDD \9\:VDD) resistor r=0.7421 c=0
Rk99 (\9\:VDD \10\:VDD) resistor r=0.2958 c=0
Rk100 (\10\:VDD \11\:VDD) resistor r=0.4362 c=0
Rk107 (\12\:VDD VDD) resistor r=0.1074 c=0
Rk101 (\11\:VDD \12\:VDD) resistor r=0.3884 c=0
Rk108 (\5\:VDD \19\:VDD) resistor r=0.04332 c=0
Rk111 (\9\:VDD \25\:VDD) resistor r=0.2684 c=0
Rk112 (\11\:VDD \27\:VDD) resistor r=0.07405 c=0
Rk54 (\7\:SE SE) resistor r=0.04807 c=0
Rk64 (\9\:E E) resistor r=0.006309 c=0
Rk63 (\8\:E \9\:E) resistor r=0.4238 c=0
Rk65 (E \10\:E) resistor r=0.3403 c=0
Rk43 (\4\:SI SI) resistor r=0.1679 c=0
Rk34 (\33\:qbint \34\:qbint) resistor r=0.4736 c=0
Rk33 (\32\:qbint \33\:qbint) resistor r=2.7896 c=0
Rk38 (\34\:qbint \39\:qbint) resistor r=0.1663 c=0
Rk39 (\33\:qbint \40\:qbint) resistor r=0.4168 c=0
Rk17 (\12\:n30 \14\:n30) resistor r=0.4341 c=0
Rk18 (\14\:n30 \15\:n30) resistor r=1.4427 c=0
Rk14 (\11\:CKb \12\:CKb) resistor r=0.2115 c=0
Rk15 (\12\:CKb \14\:CKb) resistor r=0.2896 c=0
Rk16 (\12\:CKb \15\:CKb) resistor r=0.5678 c=0
Rk19 (\4\:mout \5\:mout) resistor r=0.3931 c=0
Rk20 (\5\:mout \7\:mout) resistor r=0.2558 c=0
Rk21 (\5\:mout \9\:mout) resistor r=0.1415 c=0
Rk25 (\10\:Ckbb \12\:Ckbb) resistor r=0.3723 c=0
Rk26 (\12\:Ckbb \13\:Ckbb) resistor r=0.4142 c=0
Rk27 (\13\:Ckbb \14\:Ckbb) resistor r=0.4289 c=0
Rk28 (\14\:Ckbb \15\:Ckbb) resistor r=0.8874 c=0
Rk29 (\15\:Ckbb \16\:Ckbb) resistor r=0.64 c=0
Rk30 (\13\:Ckbb \17\:Ckbb) resistor r=0.2555 c=0
Rk31 (\14\:Ckbb \18\:Ckbb) resistor r=0.1965 c=0
Rk32 (\15\:Ckbb \19\:Ckbb) resistor r=0.3642 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.4855 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.3472 c=0
Rk24 (\6\:n20 \9\:n20) resistor r=0.03466 c=0
Rk44 (\2\:Dbp \3\:Dbp) resistor r=0.1445 c=0
Rk45 (\3\:Dbp \5\:Dbp) resistor r=0.2894 c=0
Rk46 (\3\:Dbp \7\:Dbp) resistor r=1.5049 c=0
Rk47 (\7\:Dbp \9\:Dbp) resistor r=0.6037 c=0
Rk55 (\5\:qint \7\:qint) resistor r=1.6831 c=0
Rk56 (\7\:qint \9\:qint) resistor r=0.5034 c=0
Rk57 (\2\:Db \3\:Db) resistor r=0.2918 c=0
Rk58 (\3\:Db \4\:Db) resistor r=0.4428 c=0
Rk59 (\4\:Db \6\:Db) resistor r=0.4566 c=0
Rk60 (\3\:Db \8\:Db) resistor r=0.7311 c=0
Rk61 (\4\:Db \10\:Db) resistor r=0.07228 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.735 c=0
Rk49 (\7\:SEb \8\:SEb) resistor r=0.1539 c=0
Rk50 (\8\:SEb \10\:SEb) resistor r=0.5759 c=0
Rk51 (\8\:SEb \11\:SEb) resistor r=0.05355 c=0
Rk66 (\5\:Eb \7\:Eb) resistor r=0.7352 c=0
Rk67 (\7\:Eb \8\:Eb) resistor r=0.4553 c=0
Rl73 (\2\:D \3\:D) resistor r=96.9426 c=0
Rl72 (\1\:D \2\:D) resistor r=114.617 c=0
Rl31 (\2\:CK \3\:CK) resistor r=41.7582 c=0
Rl30 (\1\:CK \2\:CK) resistor r=90.3846 c=0
Rl60 (\1\:SE \2\:SE) resistor r=106.502 c=0
Rl63 (\2\:SE \5\:SE) resistor r=132.487 c=0
Rl64 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl62 (\3\:SE \4\:SE) resistor r=175.722 c=0
Rl61 (\2\:SE \3\:SE) resistor r=191.222 c=0
Rl75 (\6\:E \7\:E) resistor r=192.285 c=0
Rl74 (\5\:E \6\:E) resistor r=61.3335 c=0
Rl71 (\3\:E \4\:E) resistor r=49.2328 c=0
Rl68 (\1\:E \2\:E) resistor r=33.7903 c=0
Rl57 (\2\:SI \3\:SI) resistor r=78.6942 c=0
Rl56 (\1\:SI \2\:SI) resistor r=48.4455 c=0
Rl34 (\23\:qbint \24\:qbint) resistor r=24.2328 c=0
Rl33 (\23\:qbint \22\:qbint) resistor r=154.568 c=0
Rl45 (\4\:CKb \5\:CKb) resistor r=530.335 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=216.873 c=0
Rl49 (\6\:CKb \9\:CKb) resistor r=28.2967 c=0
Rl42 (CKb \2\:CKb) resistor r=121.413 c=0
Rl47 (\2\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl44 (\3\:CKb \4\:CKb) resistor r=106.926 c=0
Rl48 (\3\:CKb \8\:CKb) resistor r=45.3874 c=0
Rl43 (\2\:CKb \3\:CKb) resistor r=264.3 c=0
Rl38 (mout \2\:mout) resistor r=37.5309 c=0
Rl39 (\2\:mout \3\:mout) resistor r=94.0258 c=0
Rl41 (\7\:Ckbb \8\:Ckbb) resistor r=24.2328 c=0
Rl40 (\5\:Ckbb \6\:Ckbb) resistor r=63.0341 c=0
Rl35 (\3\:Ckbb \4\:Ckbb) resistor r=53.079 c=0
Rl32 (Ckbb \2\:Ckbb) resistor r=24.2328 c=0
Rl36 (n20 \2\:n20) resistor r=103.079 c=0
Rl37 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl65 (\2\:qint qint) resistor r=37.3411 c=0
Rl67 (\2\:qint \4\:qint) resistor r=175.803 c=0
Rl66 (\2\:qint \3\:qint) resistor r=10.9341 c=0
Rl59 (\3\:SEb \4\:SEb) resistor r=47.3097 c=0
Rl58 (SEb \2\:SEb) resistor r=111.516 c=0
Rl69 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl70 (\2\:Eb \3\:Eb) resistor r=199.326 c=0
Rz19 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz24 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz30 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz31 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz32 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz33 (\12\:VDD \3\:VDD) resistor r=6.25 c=0
Rz6 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz5 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz7 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Dbp \2\:Dbp) resistor r=75 c=0
Rz13 (\6\:Dbp \7\:Dbp) resistor r=75 c=0
Rz15 (\9\:qint \8\:qint) resistor r=75 c=0
Rz16 (Db \2\:Db) resistor r=75 c=0
Rz17 (\9\:Db \10\:Db) resistor r=75 c=0
Rz14 (\9\:SEb \10\:SEb) resistor r=75 c=0
Rz18 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry19 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry20 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry21 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\12\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry23 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry24 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry28 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry6 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:Ckbb \12\:Ckbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry13 (\8\:Dbp \9\:Dbp) resistor r=62 c=0
Ry15 (\7\:qint \6\:qint) resistor r=20.6667 c=0
Ry16 (\5\:Db \6\:Db) resistor r=62 c=0
Ry17 (\7\:Db \8\:Db) resistor r=20.6667 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry18 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx18 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx16 (\2\:SE \7\:SE) resistor r=45 c=0
Rx19 (\2\:E \8\:E) resistor r=45 c=0
Rx20 (\4\:E \9\:E) resistor r=45 c=0
Rx21 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\2\:SI \4\:SI) resistor r=45 c=0
Rx10 (\32\:qbint \25\:qbint) resistor r=45 c=0
Rx11 (\39\:qbint qbint) resistor r=45 c=0
Rx12 (\40\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\15\:n30 n30) resistor r=45 c=0
Rx2 (\6\:CKb \15\:CKb) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx6 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx7 (\8\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx8 (\6\:Ckbb \18\:Ckbb) resistor r=45 c=0
Rx9 (\4\:Ckbb \19\:Ckbb) resistor r=45 c=0
Rx5 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\5\:qint \3\:qint) resistor r=45 c=0
Rx14 (SEb \7\:SEb) resistor r=45 c=0
Rx15 (\4\:SEb \11\:SEb) resistor r=45 c=0
Rx22 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn55 (Q qbint \12\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn12 (net518 \1\:SI \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.42e-14 ps=1.07e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75192e-07 sb=6.75e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn13 (Dbp \4\:SE net518 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=7.15e-14 ps=8.6e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19019e-06 sb=4.6e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn11 (\9\:Db \3\:SEb Dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=3.64e-14 ps=1.07e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51019e-06 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn1 (net494 \4\:qint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=7.15e-14 ps=9.6e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.70096e-07 sb=9.30769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (Db \3\:Eb net494 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.16e-14 ps=1.07e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.90096e-07 sb=6.10769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn4 (Db \3\:E net526 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.95096e-07 sb=4.05769e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn3 (net526 \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.00096e-07 sb=3.00769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn45_1__rcx (\34\:qbint n30 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(3)
mn56_1__rcx (\8\:qint \25\:qbint \6\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=8.296e-14 ad=4.94e-14 ps=1.285e-06 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=4.20192e-07 sb=1.23e-06 sd=160n \
        sca=8.65991 scb=0.00681295 scc=0.000165238 m=(2)
mn20 (\10\:CKb \1\:CK \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.787e-14 ad=2.755e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn21 (\9\:Ckbb \7\:CKb \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.443e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.665e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\9\:SEb \5\:SE \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06948e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn0 (\4\:Eb \5\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=2.03e-14 ps=1.07e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1131e-06 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn50 (net509 \22\:qbint \26\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.787e-14 ad=1.23e-14 ps=1.24e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.78e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\13\:n30 \9\:CKb net509 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.637e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4378e-07 sb=1.675e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\13\:n30 \3\:Ckbb \6\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.0865e-13 ad=5.638e-14 ps=1.47e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6378e-07 sb=1.355e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\6\:mout \3\:n20 \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=1.0865e-13 ps=7.3e-07 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43878e-06 sb=7.8e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net501 \3\:mout \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.742e-14 ps=7.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64378e-06 sb=5.75e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\8\:n20 \5\:Ckbb net501 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.743e-14 ad=3.28e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77378e-06 sb=4.45e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (\8\:n20 \8\:CKb \6\:Dbp VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=3.28e-14 ps=8.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91512e-06 sb=2.4e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mp12 (net441 \3\:SI \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=2.34e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.41859e-07 sb=6.25e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp13 (\4\:Dbp \2\:SEb net441 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.2675e-13 ps=9e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.46859e-07 sb=5.2e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp11 (\5\:Db \6\:SE \4\:Dbp VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2675e-13 ad=5.85e-14 ps=1.43e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.31686e-06 sb=1.5e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp1 (net405 qint \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.12e-14 ad=3.9e-14 ps=1.68e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=7.89551e-07 sd=160n sca=11.5347 \
        scb=0.00974379 scc=0.00025826 m=(1)
mp2 (\7\:Db \1\:E net405 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.13141e-07 sb=6.44551e-07 sd=160n sca=11.5347 \
        scb=0.00974379 scc=0.00025826 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.18141e-07 sb=4.39551e-07 sd=160n sca=11.7928 \
        scb=0.00981106 scc=0.000258271 m=(1)
mp3 (net449 \3\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.875e-14 ps=1.16e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.88141e-07 sb=2.69551e-07 sd=160n sca=12.4181 \
        scb=0.0101715 scc=0.000258557 m=(1)
mp45_1__rcx (\34\:qbint n30 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.62e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.22308e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp56 (\6\:qint \25\:qbint \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.0797e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.61859e-07 sb=1.105e-06 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(2)
mp20 (\13\:CKb \3\:CK \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.833e-14 ad=3.77e-14 ps=2.02e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75349e-07 sb=2e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\11\:Ckbb CKb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.2625e-13 ad=3.01e-14 ps=2.36e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54e-06 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp10 (\5\:SEb \1\:SE \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.12e-14 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.1436e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp0 (\6\:Eb \7\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13872e-06 sb=1.4e-07 sd=160n sca=15.5146 \
        scb=0.0146627 scc=0.000413871 m=(1)
mp50 (net426 \24\:qbint \26\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.833e-14 ad=4.185e-14 ps=2.02e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42903e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\11\:n30 Ckbb net426 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=1.4725e-13 ps=8.9e-07 pd=1.57e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22903e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\11\:n30 \5\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=1.4725e-13 ps=1.49e-06 pd=1.57e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.0429e-06 sb=1.48e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\8\:mout n20 \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=1.3485e-13 ps=1.32e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5229e-06 sb=1e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net417 mout \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7879e-06 sb=7.35e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \4\:CKb net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=5.58e-14 ps=1.08e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95863e-06 sb=4.6e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:Ckbb \8\:Dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
ends SEDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:16 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFTRX1
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX1 CK D E Q QN RN SE SI VDD VSS
mp57 (\3\:QN \4\:net582 \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
mp55 (\3\:Q \7\:qbint \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=5.46e-14 ps=1.42e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.67372e-07 sb=1.4e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
C1 (D VSS) capacitor c=6.13315e-17
C2 (QN VSS) capacitor c=1.67867e-17
C3 (SE VSS) capacitor c=2.40022e-17
C4 (E VSS) capacitor c=2.35987e-17
C5 (SI VSS) capacitor c=4.5579e-17
C6 (VDD VSS) capacitor c=5.62414e-16
C7 (RN VSS) capacitor c=5.14804e-17
C8 (net582 VSS) capacitor c=2.18917e-17
C9 (qbint VSS) capacitor c=1.79575e-17
C10 (n30 VSS) capacitor c=3.42812e-17
C11 (net618 VSS) capacitor c=1.73213e-18
C12 (CKb VSS) capacitor c=3.49325e-17
C13 (mout VSS) capacitor c=6.51857e-17
C14 (CKbb VSS) capacitor c=5.70292e-17
C15 (n20 VSS) capacitor c=4.88898e-17
C16 (Dpb VSS) capacitor c=6.70669e-17
C17 (SEb VSS) capacitor c=4.33516e-17
C18 (net658 VSS) capacitor c=6.34019e-18
C19 (Dp VSS) capacitor c=3.79383e-17
C20 (RNb VSS) capacitor c=3.75629e-17
C21 (net634 VSS) capacitor c=2.06852e-18
C22 (Eb VSS) capacitor c=5.36958e-17
C23 (Db VSS) capacitor c=9.44253e-17
C24 (net529 VSS) capacitor c=3.92877e-19
C25 (net521 VSS) capacitor c=1.06974e-18
C26 (net557 VSS) capacitor c=3.88657e-18
C27 (net549 VSS) capacitor c=1.41178e-18
C28 (net493 VSS) capacitor c=8.63733e-17
C29 (net505 VSS) capacitor c=8.24737e-17
C30 (\1\:D VSS) capacitor c=3.50599e-17
C31 (\4\:E VSS) capacitor c=4.07627e-17
C32 (\2\:Db VSS) capacitor c=5.91707e-17
C33 (\3\:E VSS) capacitor c=4.0275e-17
C34 (\11\:qbint VSS) capacitor c=5.17552e-17
C35 (\3\:RNb VSS) capacitor c=5.83352e-17
C36 (\1\:RN VSS) capacitor c=3.10181e-17
C37 (\7\:qbint VSS) capacitor c=3.54775e-17
C38 (\4\:SE VSS) capacitor c=3.91612e-17
C39 (\1\:SI VSS) capacitor c=4.95342e-17
C40 (\1\:SE VSS) capacitor c=4.35271e-17
C41 (\1\:CK VSS) capacitor c=3.90431e-17
C42 (\7\:CKbb VSS) capacitor c=3.78608e-17
C43 (\4\:CKb VSS) capacitor c=1.37134e-16
C44 (\5\:CKb VSS) capacitor c=1.23557e-16
C45 (\4\:qbint VSS) capacitor c=5.50826e-17
C46 (\3\:n30 VSS) capacitor c=3.53738e-17
C47 (\2\:qbint VSS) capacitor c=3.18164e-17
C48 (\4\:net582 VSS) capacitor c=4.41686e-17
C49 (\3\:D VSS) capacitor c=3.05051e-17
C50 (\7\:E VSS) capacitor c=2.90524e-17
C51 (\1\:E VSS) capacitor c=6.90388e-17
C52 (\3\:Eb VSS) capacitor c=4.58908e-17
C53 (\10\:qbint VSS) capacitor c=9.97929e-17
C54 (\3\:RN VSS) capacitor c=3.26532e-17
C55 (\9\:qbint VSS) capacitor c=5.07459e-17
C56 (\3\:Dp VSS) capacitor c=4.80505e-17
C57 (\3\:SEb VSS) capacitor c=6.55197e-17
C58 (\6\:SE VSS) capacitor c=2.56765e-17
C59 (\3\:SI VSS) capacitor c=2.67583e-17
C60 (\3\:SE VSS) capacitor c=2.21581e-17
C61 (\3\:CK VSS) capacitor c=3.89824e-17
C62 (\8\:CKb VSS) capacitor c=2.73007e-17
C63 (\9\:CKb VSS) capacitor c=2.26122e-17
C64 (\5\:CKbb VSS) capacitor c=8.17137e-17
C65 (\3\:mout VSS) capacitor c=6.69927e-17
C66 (\3\:n20 VSS) capacitor c=3.2134e-17
C67 (\3\:CKbb VSS) capacitor c=6.03518e-17
C68 (\6\:CKb VSS) capacitor c=8.78379e-17
C69 (\5\:qbint VSS) capacitor c=5.62097e-17
C70 (\3\:qbint VSS) capacitor c=4.52794e-17
C71 (\3\:net582 VSS) capacitor c=3.91111e-17
C72 (\2\:D VSS) capacitor c=2.96106e-17
C73 (\6\:E VSS) capacitor c=2.88516e-17
C74 (\3\:Db VSS) capacitor c=1.94205e-17
C75 (\2\:E VSS) capacitor c=6.98852e-17
C76 (\2\:Eb VSS) capacitor c=4.34611e-17
C77 (\12\:qbint VSS) capacitor c=3.43841e-17
C78 (\2\:RNb VSS) capacitor c=6.33346e-17
C79 (\2\:RN VSS) capacitor c=3.63e-17
C80 (\8\:qbint VSS) capacitor c=2.09861e-17
C81 (\2\:Dp VSS) capacitor c=3.41757e-17
C82 (\4\:SEb VSS) capacitor c=3.07421e-17
C83 (\5\:SE VSS) capacitor c=3.48488e-17
C84 (\2\:SEb VSS) capacitor c=2.95979e-17
C85 (\2\:SI VSS) capacitor c=2.61504e-17
C86 (\2\:SE VSS) capacitor c=2.05842e-17
C87 (\2\:CK VSS) capacitor c=3.8465e-17
C88 (\7\:CKb VSS) capacitor c=2.57972e-17
C89 (\8\:CKbb VSS) capacitor c=5.08285e-17
C90 (\6\:CKbb VSS) capacitor c=2.47145e-17
C91 (\2\:mout VSS) capacitor c=5.37766e-17
C92 (\2\:n20 VSS) capacitor c=3.40546e-17
C93 (\4\:CKbb VSS) capacitor c=2.12867e-17
C94 (\2\:CKbb VSS) capacitor c=5.79721e-17
C95 (\6\:qbint VSS) capacitor c=3.20773e-17
C96 (\2\:n30 VSS) capacitor c=3.58901e-17
C97 (\4\:Db VSS) capacitor c=1.13604e-16
C98 (\1\:VDD VSS) capacitor c=1.88996e-17
C99 (\4\:Eb VSS) capacitor c=5.19987e-17
C100 (\4\:Dp VSS) capacitor c=7.32093e-17
C101 (\10\:Dp VSS) capacitor c=2.17434e-17
C102 (\3\:net505 VSS) capacitor c=7.55755e-17
C103 (\3\:net493 VSS) capacitor c=6.63825e-17
C104 (\14\:VDD VSS) capacitor c=1.67949e-17
C105 (\6\:RNb VSS) capacitor c=5.50645e-17
C106 (\3\:Q VSS) capacitor c=7.10559e-17
C107 (\16\:VDD VSS) capacitor c=4.81258e-17
C108 (\3\:Dpb VSS) capacitor c=2.8105e-16
C109 (\18\:VDD VSS) capacitor c=3.06367e-17
C110 (\8\:SEb VSS) capacitor c=1.36099e-16
C111 (\10\:CKb VSS) capacitor c=6.10549e-17
C112 (\20\:VDD VSS) capacitor c=2.72365e-17
C113 (\9\:CKbb VSS) capacitor c=5.98914e-17
C114 (\5\:Dpb VSS) capacitor c=2.4251e-16
C115 (\4\:n20 VSS) capacitor c=4.94959e-17
C116 (\22\:VDD VSS) capacitor c=6.78402e-17
C117 (\8\:mout VSS) capacitor c=5.59739e-17
C118 (\8\:n30 VSS) capacitor c=3.5377e-17
C119 (\24\:VDD VSS) capacitor c=4.31751e-17
C120 (\16\:qbint VSS) capacitor c=8.96871e-17
C121 (\5\:net582 VSS) capacitor c=3.46039e-17
C122 (\26\:VDD VSS) capacitor c=8.50874e-17
C123 (\3\:QN VSS) capacitor c=5.42789e-17
C124 (\3\:VDD VSS) capacitor c=1.75268e-16
C125 (\7\:Db VSS) capacitor c=4.5087e-17
C126 (\8\:Eb VSS) capacitor c=2.17386e-17
C127 (\13\:Dp VSS) capacitor c=1.11844e-16
C128 (\8\:Dp VSS) capacitor c=9.32583e-17
C129 (\8\:RNb VSS) capacitor c=4.79785e-17
C130 (\1\:Q VSS) capacitor c=8.05362e-17
C131 (\6\:SEb VSS) capacitor c=1.77032e-16
C132 (\14\:CKb VSS) capacitor c=2.96287e-17
C133 (\11\:CKbb VSS) capacitor c=7.30602e-17
C134 (\7\:Dpb VSS) capacitor c=8.80678e-17
C135 (\8\:n20 VSS) capacitor c=3.08565e-17
C136 (\6\:mout VSS) capacitor c=4.90382e-17
C137 (\4\:n30 VSS) capacitor c=6.81232e-17
C138 (\20\:qbint VSS) capacitor c=4.61268e-17
C139 (\9\:net582 VSS) capacitor c=1.58172e-17
C140 (\1\:QN VSS) capacitor c=9.56012e-18
C141 (\2\:net582 VSS) capacitor c=7.93253e-18
C142 (\2\:CKb VSS) capacitor c=3.06815e-17
C143 (\3\:CKb VSS) capacitor c=7.74218e-17
C144 (\7\:net582 VSS) capacitor c=2.23472e-17
C145 (\8\:net582 VSS) capacitor c=3.14573e-17
C146 (\6\:n30 VSS) capacitor c=8.51489e-17
C147 (\7\:n30 VSS) capacitor c=7.53563e-17
C148 (\4\:mout VSS) capacitor c=7.55431e-17
C149 (\5\:mout VSS) capacitor c=6.85378e-17
C150 (\6\:n20 VSS) capacitor c=6.7088e-17
C151 (\7\:n20 VSS) capacitor c=5.78229e-17
C152 (\5\:E VSS) capacitor c=2.6702e-17
C153 (\13\:CKbb VSS) capacitor c=5.76598e-17
C154 (\14\:CKbb VSS) capacitor c=7.0233e-17
C155 (\15\:CKbb VSS) capacitor c=1.00396e-16
C156 (\16\:CKbb VSS) capacitor c=8.66884e-17
C157 (\17\:CKbb VSS) capacitor c=8.84645e-17
C158 (\4\:CK VSS) capacitor c=3.84281e-17
C159 (\6\:CK VSS) capacitor c=6.30491e-17
C160 (\12\:CKb VSS) capacitor c=5.24709e-17
C161 (\13\:CKb VSS) capacitor c=4.96274e-17
C162 (\4\:SI VSS) capacitor c=8.22682e-17
C163 (\7\:SE VSS) capacitor c=1.03021e-16
C164 (\8\:SE VSS) capacitor c=1.11967e-16
C165 (\9\:SE VSS) capacitor c=2.52559e-17
C166 (\5\:SEb VSS) capacitor c=1.35876e-16
C167 (\10\:SEb VSS) capacitor c=1.06392e-16
C168 (\4\:RN VSS) capacitor c=7.3774e-17
C169 (\4\:RNb VSS) capacitor c=6.40148e-17
C170 (\5\:RNb VSS) capacitor c=5.65247e-17
C171 (\13\:qbint VSS) capacitor c=9.38957e-17
C172 (\14\:qbint VSS) capacitor c=5.04972e-16
C173 (\15\:qbint VSS) capacitor c=4.45567e-16
C174 (\18\:qbint VSS) capacitor c=5.52728e-17
C175 (\19\:qbint VSS) capacitor c=2.15831e-17
C176 (\22\:qbint VSS) capacitor c=3.74133e-17
C177 (\6\:Dp VSS) capacitor c=1.12129e-16
C178 (\7\:Dp VSS) capacitor c=2.41358e-16
C179 (\12\:Dp VSS) capacitor c=1.86115e-16
C180 (\8\:E VSS) capacitor c=5.70782e-17
C181 (\9\:E VSS) capacitor c=8.12991e-17
C182 (\6\:Eb VSS) capacitor c=1.08288e-16
C183 (\7\:Eb VSS) capacitor c=1.53376e-16
C184 (\4\:D VSS) capacitor c=4.95738e-17
C185 (\6\:Db VSS) capacitor c=8.38919e-17
C186 (\6\:VDD VSS) capacitor c=4.21635e-17
C187 (\7\:VDD VSS) capacitor c=3.952e-17
C188 (\9\:VDD VSS) capacitor c=3.628e-17
C189 (\10\:VDD VSS) capacitor c=5.79145e-17
C190 (\12\:VDD VSS) capacitor c=1.26935e-17
C191 (\13\:VDD VSS) capacitor c=1.55213e-17
Rk63 (\4\:D D) resistor r=0.1696 c=0
Rk1 (QN \2\:QN) resistor r=0.03908 c=0
Rk2 (QN \4\:QN) resistor r=0.2585 c=0
Rk29 (\8\:SE SE) resistor r=0.0121 c=0
Rk28 (\7\:SE \8\:SE) resistor r=0.8009 c=0
Rk30 (\8\:SE \9\:SE) resistor r=0.08252 c=0
Rk58 (E \8\:E) resistor r=0.03641 c=0
Rk59 (\8\:E \9\:E) resistor r=0.2615 c=0
Rk37 (\2\:Q Q) resistor r=0.04342 c=0
Rk38 (Q \4\:Q) resistor r=0.267 c=0
Rk27 (SI \4\:SI) resistor r=0.0195 c=0
Rk66 (\2\:VDD \4\:VDD) resistor r=0.2312 c=0
Rk67 (\4\:VDD \5\:VDD) resistor r=0.8538 c=0
Rk68 (\5\:VDD \6\:VDD) resistor r=0.4467 c=0
Rk69 (\6\:VDD \7\:VDD) resistor r=0.5004 c=0
Rk70 (\7\:VDD \8\:VDD) resistor r=0.2547 c=0
Rk71 (\8\:VDD \9\:VDD) resistor r=0.187 c=0
Rk72 (\9\:VDD \10\:VDD) resistor r=0.5481 c=0
Rk73 (\10\:VDD \11\:VDD) resistor r=0.4664 c=0
Rk74 (\11\:VDD \12\:VDD) resistor r=0.07757 c=0
Rk76 (\13\:VDD VDD) resistor r=0.1074 c=0
Rk75 (\12\:VDD \13\:VDD) resistor r=0.3659 c=0
Rk77 (\5\:VDD \15\:VDD) resistor r=0.0715 c=0
Rk78 (\6\:VDD \17\:VDD) resistor r=0.2064 c=0
Rk79 (\7\:VDD \19\:VDD) resistor r=0.04333 c=0
Rk80 (\9\:VDD \21\:VDD) resistor r=0.04333 c=0
Rk81 (\10\:VDD \23\:VDD) resistor r=0.3046 c=0
Rk82 (\12\:VDD \25\:VDD) resistor r=0.2064 c=0
Rk83 (\13\:VDD \27\:VDD) resistor r=0.4131 c=0
Rk39 (RN \4\:RN) resistor r=0.08752 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.4374 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.4087 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.115 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.2429 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.0851 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.4363 c=0
Rk90 (\9\:VSS \10\:VSS) resistor r=0.554 c=0
Rk91 (\10\:VSS \11\:VSS) resistor r=0.213 c=0
Rk92 (\11\:VSS \12\:VSS) resistor r=0.203 c=0
Rk93 (\12\:VSS \13\:VSS) resistor r=0.534 c=0
Rk94 (\13\:VSS \14\:VSS) resistor r=0.4664 c=0
Rk95 (\14\:VSS \15\:VSS) resistor r=0.05249 c=0
Rk97 (\16\:VSS VSS) resistor r=0.1074 c=0
Rk96 (\15\:VSS \16\:VSS) resistor r=0.391 c=0
Rk98 (\5\:VSS \18\:VSS) resistor r=0.19 c=0
Rk99 (\6\:VSS \20\:VSS) resistor r=0.2008 c=0
Rk100 (\7\:VSS \22\:VSS) resistor r=0.2709 c=0
Rk101 (\9\:VSS \24\:VSS) resistor r=0.3041 c=0
Rk102 (\10\:VSS \26\:VSS) resistor r=0.1029 c=0
Rk103 (\12\:VSS \28\:VSS) resistor r=0.2171 c=0
Rk104 (\13\:VSS \30\:VSS) resistor r=0.123 c=0
Rk105 (\15\:VSS \32\:VSS) resistor r=0.3679 c=0
Rk106 (\16\:VSS \34\:VSS) resistor r=0.2886 c=0
Rk21 (\4\:CK \5\:CK) resistor r=0.001437 c=0
Rk22 (CK \6\:CK) resistor r=0.001365 c=0
Rk23 (\4\:CK \6\:CK) resistor r=0.07063 c=0
Rk3 (\6\:net582 \7\:net582) resistor r=0.13 c=0
Rk4 (\7\:net582 \8\:net582) resistor r=0.1226 c=0
Rk5 (\7\:net582 \10\:net582) resistor r=0.0939 c=0
Rk43 (\13\:qbint \14\:qbint) resistor r=0.8565 c=0
Rk44 (\14\:qbint \15\:qbint) resistor r=3.3628 c=0
Rk45 (\15\:qbint \17\:qbint) resistor r=0.412 c=0
Rk46 (\14\:qbint \18\:qbint) resistor r=0.253 c=0
Rk47 (\15\:qbint \19\:qbint) resistor r=0.03527 c=0
Rk48 (\17\:qbint \21\:qbint) resistor r=0.437 c=0
Rk49 (\17\:qbint \22\:qbint) resistor r=0.2281 c=0
Rk6 (\5\:n30 \6\:n30) resistor r=0.3394 c=0
Rk7 (\6\:n30 \7\:n30) resistor r=0.4232 c=0
Rk8 (\6\:n30 \9\:n30) resistor r=0.05919 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.3426 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.2254 c=0
Rk26 (\12\:CKb \15\:CKb) resistor r=0.1298 c=0
Rk9 (\4\:mout \5\:mout) resistor r=0.3387 c=0
Rk10 (\5\:mout \7\:mout) resistor r=0.2599 c=0
Rk11 (\5\:mout \9\:mout) resistor r=0.185 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.4361 c=0
Rk16 (\12\:CKbb \13\:CKbb) resistor r=0.2609 c=0
Rk17 (\13\:CKbb \14\:CKbb) resistor r=0.1721 c=0
Rk18 (\14\:CKbb \15\:CKbb) resistor r=0.5416 c=0
Rk19 (\15\:CKbb \16\:CKbb) resistor r=0.5831 c=0
Rk20 (\13\:CKbb \17\:CKbb) resistor r=0.4083 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2925 c=0
Rk13 (\6\:n20 \7\:n20) resistor r=0.3095 c=0
Rk14 (\6\:n20 \9\:n20) resistor r=0.1352 c=0
Rk31 (\2\:Dpb \4\:Dpb) resistor r=0.4142 c=0
Rk32 (\4\:Dpb \6\:Dpb) resistor r=1.6426 c=0
Rk33 (\6\:Dpb \8\:Dpb) resistor r=0.4468 c=0
Rk34 (\5\:SEb \7\:SEb) resistor r=1.0724 c=0
Rk35 (\7\:SEb \9\:SEb) resistor r=0.4831 c=0
Rk36 (\9\:SEb \10\:SEb) resistor r=0.6472 c=0
Rk52 (\5\:Dp \6\:Dp) resistor r=0.3391 c=0
Rk53 (\6\:Dp \7\:Dp) resistor r=0.6329 c=0
Rk54 (\7\:Dp \9\:Dp) resistor r=0.071 c=0
Rk55 (\6\:Dp \11\:Dp) resistor r=0.04671 c=0
Rk56 (\7\:Dp \12\:Dp) resistor r=1.4712 c=0
Rk57 (\9\:Dp \14\:Dp) resistor r=0.7253 c=0
Rk40 (\4\:RNb \5\:RNb) resistor r=0.2829 c=0
Rk41 (\5\:RNb \7\:RNb) resistor r=0.2469 c=0
Rk42 (\5\:RNb \9\:RNb) resistor r=0.2138 c=0
Rk60 (\5\:Eb \6\:Eb) resistor r=0.2365 c=0
Rk61 (\6\:Eb \7\:Eb) resistor r=0.8246 c=0
Rk62 (\6\:Eb \9\:Eb) resistor r=0.06371 c=0
Rk64 (\5\:Db \6\:Db) resistor r=0.777 c=0
Rk65 (\5\:Db \8\:Db) resistor r=0.357 c=0
Rk50 (\2\:net493 \4\:net493) resistor r=0.3328 c=0
Rk51 (\2\:net505 \4\:net505) resistor r=0.5124 c=0
Rl55 (\1\:D \2\:D) resistor r=39.6174 c=0
Rl56 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl33 (\4\:SE \5\:SE) resistor r=74.9772 c=0
Rl34 (\5\:SE \6\:SE) resistor r=24.7951 c=0
Rl28 (\1\:SE \2\:SE) resistor r=61.5385 c=0
Rl29 (\2\:SE \3\:SE) resistor r=29.9451 c=0
Rl49 (\2\:E \3\:E) resistor r=61.5157 c=0
Rl48 (\1\:E \2\:E) resistor r=134.41 c=0
Rl52 (\4\:E \5\:E) resistor r=47.3105 c=0
Rl54 (\5\:E \7\:E) resistor r=55.0028 c=0
Rl53 (\5\:E \6\:E) resistor r=92.681 c=0
Rl30 (\1\:SI \2\:SI) resistor r=60.3072 c=0
Rl31 (\2\:SI \3\:SI) resistor r=29.5379 c=0
Rl40 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl41 (\2\:RN \3\:RN) resistor r=139.153 c=0
Rl26 (\1\:CK \2\:CK) resistor r=53.8462 c=0
Rl27 (\2\:CK \3\:CK) resistor r=100.676 c=0
Rl3 (\2\:net582 \4\:net582) resistor r=49.7141 c=0
Rl2 (\2\:net582 \3\:net582) resistor r=34.3295 c=0
Rl1 (net582 \2\:net582) resistor r=5.915 c=0
Rl44 (\10\:qbint \11\:qbint) resistor r=209.181 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=167.308 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=92.3077 c=0
Rl45 (\11\:qbint \12\:qbint) resistor r=32.908 c=0
Rl38 (\7\:qbint \8\:qbint) resistor r=29.5379 c=0
Rl39 (\8\:qbint \9\:qbint) resistor r=56.461 c=0
Rl9 (\4\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl4 (qbint \2\:qbint) resistor r=31.0981 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=45.708 c=0
Rl6 (n30 \2\:n30) resistor r=105.002 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=403.412 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=35.7134 c=0
Rl18 (CKb \2\:CKb) resistor r=53.0797 c=0
Rl23 (\2\:CKb \7\:CKb) resistor r=54.1777 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=184.159 c=0
Rl25 (\3\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=198.915 c=0
Rl14 (mout \2\:mout) resistor r=50.6918 c=0
Rl15 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=64.6174 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=51.1559 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl10 (CKbb \2\:CKbb) resistor r=64.6174 c=0
Rl12 (n20 \2\:n20) resistor r=112.23 c=0
Rl13 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl35 (\3\:SEb \4\:SEb) resistor r=93.4636 c=0
Rl32 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl36 (Dp \2\:Dp) resistor r=60.3072 c=0
Rl37 (\2\:Dp \3\:Dp) resistor r=29.5379 c=0
Rl43 (\2\:RNb \3\:RNb) resistor r=89.6174 c=0
Rl42 (RNb \2\:RNb) resistor r=101.477 c=0
Rl46 (Eb \2\:Eb) resistor r=126.718 c=0
Rl47 (\2\:Eb \3\:Eb) resistor r=35.8888 c=0
Rl50 (Db \2\:Db) resistor r=226.489 c=0
Rl51 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz11 (\1\:Q \2\:Q) resistor r=75 c=0
Rz18 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz19 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz20 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz21 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz22 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz28 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz29 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz30 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz31 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz2 (\9\:net582 \10\:net582) resistor r=75 c=0
Rz13 (\20\:qbint \21\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dpb \2\:Dpb) resistor r=75 c=0
Rz9 (\7\:Dpb \8\:Dpb) resistor r=75 c=0
Rz10 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz14 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz12 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz16 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz17 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry11 (\3\:Q \4\:Q) resistor r=62 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry24 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry25 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry26 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry27 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry28 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry29 (\26\:VDD \27\:VDD) resistor r=20.6667 c=0
Ry30 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry31 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry32 (\3\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry33 (\3\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net582 \6\:net582) resistor r=62 c=0
Ry13 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Dpb \4\:Dpb) resistor r=62 c=0
Ry9 (\5\:Dpb \6\:Dpb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\10\:Dp \11\:Dp) resistor r=62 c=0
Ry12 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry20 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry21 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx26 (\2\:D \4\:D) resistor r=45 c=0
Rx12 (\5\:SE \7\:SE) resistor r=45 c=0
Rx13 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:E \8\:E) resistor r=45 c=0
Rx24 (\2\:E \9\:E) resistor r=45 c=0
Rx11 (\2\:SI \4\:SI) resistor r=45 c=0
Rx16 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\2\:CK \5\:CK) resistor r=45 c=0
Rx1 (net582 \8\:net582) resistor r=45 c=0
Rx18 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx19 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx20 (\6\:qbint \19\:qbint) resistor r=45 c=0
Rx21 (qbint \22\:qbint) resistor r=45 c=0
Rx2 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:mout \4\:mout) resistor r=45 c=0
Rx5 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx15 (\2\:SEb \10\:SEb) resistor r=45 c=0
Rx22 (\2\:Dp \12\:Dp) resistor r=45 c=0
Rx17 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx25 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx27 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\1\:QN \3\:net582 \33\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\1\:Q \9\:qbint \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=5.59e-14 ps=9.8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.71635e-07 sb=2.15e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:net582 \3\:qbint \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\20\:qbint n30 \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.815e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \5\:qbint \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.55e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\4\:n30 \6\:CKb net618 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.365e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\4\:n30 \3\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.16e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.45e-14 ad=3.988e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=8.7e-15 ps=1.44e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net606 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:n20 \9\:CKb \7\:Dpb VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.465e-14 ps=8e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\11\:CKbb \8\:CKb \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.25e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn20 (\14\:CKb \3\:CK \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.2e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn10 (\6\:SEb \3\:SE \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.087e-14 ad=3.698e-14 ps=1.69e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.565e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn13 (net658 \3\:SI \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.087e-14 ad=5.365e-14 ps=1.69e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.245e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn14 (Dpb \6\:SE net658 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=2.755e-14 ps=1.03e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=8.3e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn12 (Dpb \3\:SEb net650 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.755e-14 ps=4.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=5.95e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn11 (net650 \3\:Dp \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=8.7e-15 ps=9.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33e-06 sb=4.9e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn2 (\8\:RNb \3\:RN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.465e-14 ps=9e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=8.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn3 (\8\:Dp RNb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.8e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn5 (\8\:Dp \10\:qbint net634 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn4 (net634 \3\:Eb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.725e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn6 (net638 \1\:E \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn7 (\13\:Dp Db net638 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\8\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn1 (\7\:Db \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mp56 (\5\:net582 \2\:qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
mp45 (\16\:qbint \3\:n30 \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.865e-06 sd=160n sca=11.99 scb=0.01053 \
        scc=0.000305882 m=(1)
mp50 (net529 \4\:qbint \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=2.903e-14 ps=1.21e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.55e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\8\:n30 CKbb net529 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.548e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.37e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\8\:n30 \5\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.548e-14 ps=9.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.16e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=8.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net521 mout \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.75e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \4\:CKb net521 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.7e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Dpb VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=4.085e-14 ps=9e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=2.35e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb CKb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.25e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\10\:CKb \1\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp10 (\8\:SEb \1\:SE \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.031e-13 ad=3.01e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp13 (net557 \1\:SI \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.031e-13 ad=3.333e-14 ps=1.8e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.17e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp14 (\3\:Dpb SEb net557 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=5.268e-14 ps=7.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=9.7e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp12 (\3\:Dpb \4\:SE net549 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.268e-14 ps=8.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=6.8e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp11 (net549 Dp \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=4.73e-14 ps=1.42e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=4.15e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp2 (\6\:RNb \1\:RN \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.53e-14 ad=4.3e-14 ps=1.67e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=8.15e-07 sd=160n sca=16.4667 scb=0.0163489 \
        scc=0.00112485 m=(1)
mp3 (\3\:net493 \3\:RNb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.53e-14 ad=3.44e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=5.5e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp5 (\3\:net505 \11\:qbint \3\:net493 VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.7e-07 sb=3.45e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp4 (\3\:net505 Eb net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp6 (\10\:Dp \3\:E net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp7 (\4\:Dp \2\:Db net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp0 (\4\:Eb \4\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.455e-14 ad=3.01e-14 ps=1.76e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=49.0504 \
        scb=0.032034 scc=0.00591335 m=(1)
mp1 (\4\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.455e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=57.444 \
        scb=0.0450892 scc=0.00689963 m=(1)
ends SEDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:17 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFTRX2
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX2 CK D E Q QN RN SE SI VDD VSS
mp10 (\5\:SEb \1\:SE \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=26.5786 \
        scb=0.0259232 scc=0.00247005 m=(1)
mp13 (net557 \1\:SI \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=1.29e-14 ps=1e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.3e-07 sd=160n sca=23.7838 \
        scb=0.0218743 scc=0.00242478 m=(1)
mp14 (\4\:Dpb \3\:SEb net557 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.25e-07 sd=160n sca=23.3365 \
        scb=0.0215703 scc=0.00242447 m=(1)
mp12 (\4\:Dpb \6\:SE net549 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=6.128e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.95e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp11 (net549 \2\:Dp \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=2.473e-14 ps=1.77e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.35e-07 sd=160n sca=22.8495 scb=0.0214046 \
        scc=0.00242442 m=(1)
mp21 (\15\:CKbb \8\:CKb \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.315e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp25 (\6\:n20 CKbb \6\:Dpb VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.91093e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\6\:n20 \6\:CKb net521 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.87e-14 ps=7.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.68593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (net521 mout \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.547e-14 ad=3.332e-14 ps=1.96e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.48593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\4\:mout n20 \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.547e-14 ad=8.6e-14 ps=1.96e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.24593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\7\:n30 \9\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=3.87e-14 ps=1.23e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=8.0093e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\7\:n30 \5\:CKbb net529 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=3.87e-14 ps=8.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=5.7593e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (net529 \3\:qbint \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.663e-14 ad=4.193e-14 ps=2.05e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=3.3593e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp20 (\15\:CKb \3\:CK \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1785e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29233e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\11\:net582 \12\:qbint \7\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=8.268e-14 ad=2.63e-14 ps=1.97e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.31e-06 sb=1.22326e-07 sd=160n \
        sca=45.7906 scb=0.0283307 scc=0.00588417 m=(1)
mp2 (\7\:RNb \1\:RN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.805e-14 ps=8.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=8.15e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp3 (net493 RNb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=5.5e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp5 (net505 \13\:qbint net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=3.45e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp4 (net505 Eb \3\:net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=1.4e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp6 (\11\:Dp \3\:E \3\:net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp7 (\4\:Dp \2\:Db \3\:net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.3037 \
        scb=0.0150346 scc=0.000885439 m=(1)
mp0 (\7\:Eb \4\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.01e-14 ps=1.66e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=18.613 \
        scb=0.0184651 scc=0.00105196 m=(1)
mp1 (\6\:Db \3\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=4.515e-14 ps=1.66e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2.1e-07 sd=160n sca=23.8984 \
        scb=0.0274473 scc=0.0014436 m=(1)
C1 (D VSS) capacitor c=8.84096e-17
C2 (CK VSS) capacitor c=5.4137e-17
C3 (E VSS) capacitor c=7.86304e-17
C4 (Q VSS) capacitor c=2.01994e-17
C5 (VDD VSS) capacitor c=5.94373e-16
C6 (SE VSS) capacitor c=4.06855e-17
C7 (SI VSS) capacitor c=1.04552e-16
C8 (QN VSS) capacitor c=2.91019e-17
C9 (SEb VSS) capacitor c=5.06365e-17
C10 (net658 VSS) capacitor c=8.64555e-20
C11 (Dpb VSS) capacitor c=7.32006e-17
C12 (net650 VSS) capacitor c=2.61787e-18
C13 (Dp VSS) capacitor c=3.29499e-17
C14 (CKbb VSS) capacitor c=4.25729e-17
C15 (CKb VSS) capacitor c=3.25989e-17
C16 (n20 VSS) capacitor c=5.20413e-17
C17 (mout VSS) capacitor c=3.86844e-17
C18 (n30 VSS) capacitor c=2.94245e-17
C19 (net618 VSS) capacitor c=1.54832e-18
C20 (qbint VSS) capacitor c=6.84295e-17
C21 (net582 VSS) capacitor c=1.9055e-16
C22 (RNb VSS) capacitor c=5.67567e-17
C23 (Eb VSS) capacitor c=5.24549e-17
C24 (net638 VSS) capacitor c=4.34495e-19
C25 (Db VSS) capacitor c=6.7728e-17
C26 (net557 VSS) capacitor c=2.17167e-18
C27 (net549 VSS) capacitor c=2.63014e-18
C28 (net521 VSS) capacitor c=2.79667e-18
C29 (net529 VSS) capacitor c=4.69748e-18
C30 (net493 VSS) capacitor c=7.0261e-17
C31 (net505 VSS) capacitor c=9.57766e-17
C32 (\3\:D VSS) capacitor c=4.92562e-17
C33 (\4\:E VSS) capacitor c=4.80831e-17
C34 (\2\:Db VSS) capacitor c=4.10213e-17
C35 (\3\:E VSS) capacitor c=3.95181e-17
C36 (\13\:qbint VSS) capacitor c=7.23798e-17
C37 (\1\:RN VSS) capacitor c=3.30585e-17
C38 (\12\:qbint VSS) capacitor c=6.36256e-17
C39 (\3\:CK VSS) capacitor c=2.96654e-17
C40 (\3\:n30 VSS) capacitor c=5.86289e-17
C41 (\3\:qbint VSS) capacitor c=4.11017e-17
C42 (\5\:CKbb VSS) capacitor c=5.80853e-17
C43 (\9\:CKb VSS) capacitor c=3.49942e-17
C44 (\6\:CKb VSS) capacitor c=3.3131e-17
C45 (\8\:CKb VSS) capacitor c=5.38699e-17
C46 (\2\:Dp VSS) capacitor c=6.26113e-17
C47 (\6\:SE VSS) capacitor c=5.51444e-17
C48 (\3\:SEb VSS) capacitor c=4.71858e-17
C49 (\1\:SI VSS) capacitor c=5.9129e-17
C50 (\1\:SE VSS) capacitor c=4.5879e-17
C51 (\1\:D VSS) capacitor c=2.86539e-17
C52 (\7\:E VSS) capacitor c=3.72718e-17
C53 (\1\:E VSS) capacitor c=4.57531e-17
C54 (\3\:Eb VSS) capacitor c=3.12211e-17
C55 (\14\:qbint VSS) capacitor c=6.14257e-17
C56 (\3\:RNb VSS) capacitor c=4.14769e-17
C57 (\3\:RN VSS) capacitor c=5.39684e-17
C58 (\11\:qbint VSS) capacitor c=3.31754e-17
C59 (\4\:qbint VSS) capacitor c=1.72222e-16
C60 (\1\:CK VSS) capacitor c=3.57022e-17
C61 (\11\:CKb VSS) capacitor c=5.78608e-17
C62 (\7\:CKbb VSS) capacitor c=1.83176e-17
C63 (\3\:n20 VSS) capacitor c=2.48722e-17
C64 (\3\:mout VSS) capacitor c=7.79197e-17
C65 (\3\:CKbb VSS) capacitor c=7.50113e-17
C66 (\7\:CKb VSS) capacitor c=2.46198e-17
C67 (\5\:CKb VSS) capacitor c=3.04196e-17
C68 (\3\:Dp VSS) capacitor c=6.49357e-17
C69 (\4\:SE VSS) capacitor c=6.6042e-17
C70 (\4\:SI VSS) capacitor c=6.03179e-17
C71 (\3\:SE VSS) capacitor c=2.5395e-17
C72 (\2\:D VSS) capacitor c=3.93773e-17
C73 (\6\:E VSS) capacitor c=2.61067e-17
C74 (\3\:Db VSS) capacitor c=2.27074e-17
C75 (\2\:E VSS) capacitor c=4.00463e-17
C76 (\2\:Eb VSS) capacitor c=4.95152e-17
C77 (\15\:qbint VSS) capacitor c=2.61892e-17
C78 (\2\:RNb VSS) capacitor c=4.89502e-17
C79 (\2\:RN VSS) capacitor c=3.59121e-17
C80 (\10\:qbint VSS) capacitor c=2.17766e-17
C81 (\2\:CK VSS) capacitor c=3.86184e-17
C82 (\2\:n30 VSS) capacitor c=2.32223e-17
C83 (\2\:qbint VSS) capacitor c=4.2574e-17
C84 (\12\:CKb VSS) capacitor c=3.63909e-17
C85 (\6\:CKbb VSS) capacitor c=5.42603e-17
C86 (\10\:CKb VSS) capacitor c=3.5463e-17
C87 (\2\:n20 VSS) capacitor c=3.49069e-17
C88 (\2\:mout VSS) capacitor c=5.37578e-17
C89 (\4\:CKbb VSS) capacitor c=2.59958e-17
C90 (\2\:CKbb VSS) capacitor c=4.00894e-17
C91 (\7\:SE VSS) capacitor c=4.39112e-17
C92 (\2\:SEb VSS) capacitor c=6.22714e-17
C93 (\5\:SE VSS) capacitor c=4.66353e-17
C94 (\3\:SI VSS) capacitor c=5.83743e-17
C95 (\2\:SE VSS) capacitor c=3.09787e-17
C96 (\6\:Db VSS) capacitor c=1.04604e-16
C97 (\1\:VDD VSS) capacitor c=2.37403e-17
C98 (\7\:Eb VSS) capacitor c=8.23379e-17
C99 (\4\:Dp VSS) capacitor c=7.40365e-17
C100 (\3\:net505 VSS) capacitor c=1.09882e-16
C101 (\3\:net493 VSS) capacitor c=8.90818e-17
C102 (\16\:VDD VSS) capacitor c=4.17482e-17
C103 (\7\:RNb VSS) capacitor c=1.10327e-16
C104 (\11\:net582 VSS) capacitor c=3.03376e-17
C105 (\4\:QN VSS) capacitor c=2.71195e-17
C106 (\2\:Q VSS) capacitor c=2.37262e-17
C107 (\15\:CKb VSS) capacitor c=1.16597e-16
C108 (\21\:qbint VSS) capacitor c=8.36508e-17
C109 (\24\:VDD VSS) capacitor c=2.50528e-17
C110 (\7\:n30 VSS) capacitor c=8.50427e-17
C111 (\4\:mout VSS) capacitor c=4.47461e-17
C112 (\26\:VDD VSS) capacitor c=1.81678e-17
C113 (\6\:n20 VSS) capacitor c=5.77146e-17
C114 (\6\:Dpb VSS) capacitor c=3.00986e-17
C115 (\15\:CKbb VSS) capacitor c=6.33283e-17
C116 (\28\:VDD VSS) capacitor c=1.97714e-17
C117 (\4\:Dpb VSS) capacitor c=1.24621e-16
C118 (\30\:VDD VSS) capacitor c=4.21626e-17
C119 (\5\:SEb VSS) capacitor c=1.26247e-16
C120 (\3\:VDD VSS) capacitor c=1.66684e-16
C121 (\4\:Db VSS) capacitor c=6.97263e-17
C122 (\5\:Eb VSS) capacitor c=1.60197e-16
C123 (\9\:Dp VSS) capacitor c=1.10602e-16
C124 (\13\:Dp VSS) capacitor c=6.09764e-17
C125 (\4\:RNb VSS) capacitor c=2.01236e-17
C126 (\7\:net582 VSS) capacitor c=6.23601e-17
C127 (\1\:QN VSS) capacitor c=3.2644e-17
C128 (\4\:Q VSS) capacitor c=5.25879e-17
C129 (\13\:CKb VSS) capacitor c=6.87082e-17
C130 (\19\:qbint VSS) capacitor c=9.08339e-17
C131 (\5\:n30 VSS) capacitor c=9.52847e-17
C132 (\8\:mout VSS) capacitor c=5.53761e-17
C133 (\8\:n20 VSS) capacitor c=3.53392e-17
C134 (\11\:CKbb VSS) capacitor c=6.72839e-17
C135 (\8\:Dpb VSS) capacitor c=1.01774e-16
C136 (\7\:SEb VSS) capacitor c=8.00507e-17
C137 (\2\:CKb VSS) capacitor c=4.95874e-17
C138 (\3\:CKb VSS) capacitor c=4.47481e-17
C139 (\4\:CKb VSS) capacitor c=3.77119e-17
C140 (\5\:SI VSS) capacitor c=4.14328e-17
C141 (\4\:SEb VSS) capacitor c=8.53594e-17
C142 (\8\:SE VSS) capacitor c=1.22755e-16
C143 (\9\:SE VSS) capacitor c=1.0927e-16
C144 (\10\:SE VSS) capacitor c=3.29268e-17
C145 (\11\:SE VSS) capacitor c=3.13151e-17
C146 (\3\:Dpb VSS) capacitor c=1.24082e-16
C147 (\4\:n20 VSS) capacitor c=5.07986e-17
C148 (\5\:n20 VSS) capacitor c=6.38492e-17
C149 (\5\:E VSS) capacitor c=3.22156e-17
C150 (\6\:mout VSS) capacitor c=4.74091e-17
C151 (\7\:mout VSS) capacitor c=5.19744e-17
C152 (\8\:CKbb VSS) capacitor c=1.18286e-16
C153 (\9\:CKbb VSS) capacitor c=9.23106e-17
C154 (\10\:CKbb VSS) capacitor c=6.39491e-17
C155 (\13\:CKbb VSS) capacitor c=1.98737e-17
C156 (\14\:CKbb VSS) capacitor c=8.12701e-17
C157 (\4\:n30 VSS) capacitor c=8.18117e-17
C158 (\17\:CKb VSS) capacitor c=1.29377e-16
C159 (\18\:CKb VSS) capacitor c=1.57817e-16
C160 (\19\:CKb VSS) capacitor c=1.18599e-16
C161 (\20\:CKb VSS) capacitor c=5.17634e-17
C162 (\21\:CKb VSS) capacitor c=6.16684e-17
C163 (\4\:CK VSS) capacitor c=5.64819e-17
C164 (\1\:Q VSS) capacitor c=3.34692e-17
C165 (\3\:QN VSS) capacitor c=4.02156e-17
C166 (\9\:net582 VSS) capacitor c=4.05088e-17
C167 (\10\:net582 VSS) capacitor c=2.65393e-17
C168 (\4\:RN VSS) capacitor c=6.44601e-17
C169 (\5\:RN VSS) capacitor c=6.30241e-17
C170 (\6\:RNb VSS) capacitor c=1.15255e-16
C171 (\9\:RNb VSS) capacitor c=4.5712e-17
C172 (\16\:qbint VSS) capacitor c=7.65188e-17
C173 (\17\:qbint VSS) capacitor c=1.55595e-16
C174 (\18\:qbint VSS) capacitor c=1.32277e-16
C175 (\23\:qbint VSS) capacitor c=5.98385e-17
C176 (\24\:qbint VSS) capacitor c=5.07822e-17
C177 (\6\:Dp VSS) capacitor c=1.34751e-16
C178 (\7\:Dp VSS) capacitor c=5.17271e-16
C179 (\8\:Dp VSS) capacitor c=5.43669e-16
C180 (\8\:E VSS) capacitor c=5.73422e-17
C181 (\4\:Eb VSS) capacitor c=1.16507e-16
C182 (\4\:D VSS) capacitor c=4.67927e-17
C183 (\8\:Db VSS) capacitor c=6.81924e-17
C184 (\5\:VDD VSS) capacitor c=5.94219e-17
C185 (\7\:VDD VSS) capacitor c=1.45129e-16
C186 (\10\:VDD VSS) capacitor c=1.26652e-17
C187 (\12\:VDD VSS) capacitor c=6.21188e-17
C188 (\13\:VDD VSS) capacitor c=1.75752e-17
C189 (\15\:VDD VSS) capacitor c=1.37087e-17
Rk66 (\4\:D D) resistor r=0.1052 c=0
Rk69 (\2\:VSS \4\:VSS) resistor r=0.3652 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.3988 c=0
Rk71 (\5\:VSS \6\:VSS) resistor r=0.08493 c=0
Rk72 (\6\:VSS \7\:VSS) resistor r=0.3123 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.05406 c=0
Rk74 (\8\:VSS \9\:VSS) resistor r=0.3176 c=0
Rk77 (\9\:VSS \12\:VSS) resistor r=0.4135 c=0
Rk78 (\5\:VSS \14\:VSS) resistor r=0.2414 c=0
Rk79 (\6\:VSS \16\:VSS) resistor r=0.226 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.04335 c=0
Rk84 (\12\:VSS \25\:VSS) resistor r=0.5469 c=0
Rk85 (\25\:VSS \26\:VSS) resistor r=0.5944 c=0
Rk86 (\26\:VSS \27\:VSS) resistor r=0.06254 c=0
Rk88 (\28\:VSS VSS) resistor r=0.2028 c=0
Rk87 (\27\:VSS \28\:VSS) resistor r=0.3486 c=0
Rk89 (\12\:VSS \30\:VSS) resistor r=0.3447 c=0
Rk90 (\25\:VSS \32\:VSS) resistor r=0.1637 c=0
Rk91 (\26\:VSS \34\:VSS) resistor r=0.3131 c=0
Rk92 (\28\:VSS \36\:VSS) resistor r=0.3108 c=0
Rk32 (CK \4\:CK) resistor r=0.1836 c=0
Rk62 (\8\:E E) resistor r=0.2631 c=0
Rk63 (E \9\:E) resistor r=0.003311 c=0
Rk33 (Q \1\:Q) resistor r=0.04369 c=0
Rk34 (\1\:Q \3\:Q) resistor r=0.051 c=0
Rk35 (\1\:Q \5\:Q) resistor r=0.1531 c=0
Rk93 (\2\:VDD \4\:VDD) resistor r=0.1204 c=0
Rk94 (\4\:VDD \5\:VDD) resistor r=0.7752 c=0
Rk95 (\5\:VDD \6\:VDD) resistor r=0.0776 c=0
Rk96 (\6\:VDD \7\:VDD) resistor r=0.3662 c=0
Rk99 (\7\:VDD \10\:VDD) resistor r=0.3048 c=0
Rk100 (\10\:VDD \11\:VDD) resistor r=0.05908 c=0
Rk101 (\11\:VDD \12\:VDD) resistor r=0.6573 c=0
Rk102 (\12\:VDD \13\:VDD) resistor r=0.4479 c=0
Rk103 (\13\:VDD \14\:VDD) resistor r=0.09672 c=0
Rk105 (\15\:VDD VDD) resistor r=0.2028 c=0
Rk104 (\14\:VDD \15\:VDD) resistor r=0.3486 c=0
Rk106 (\5\:VDD \17\:VDD) resistor r=0.1753 c=0
Rk110 (\10\:VDD \25\:VDD) resistor r=0.04335 c=0
Rk111 (\12\:VDD \27\:VDD) resistor r=0.0744 c=0
Rk112 (\13\:VDD \29\:VDD) resistor r=0.04335 c=0
Rk113 (\15\:VDD \31\:VDD) resistor r=0.3284 c=0
Rk4 (\8\:SE \9\:SE) resistor r=0.9059 c=0
Rk6 (\10\:SE SE) resistor r=0.04983 c=0
Rk5 (\9\:SE \10\:SE) resistor r=0.23 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.08816 c=0
Rk42 (RN \4\:RN) resistor r=0.004987 c=0
Rk44 (\4\:RN \5\:RN) resistor r=0.05906 c=0
Rk43 (\5\:RN \6\:RN) resistor r=0.005088 c=0
Rk1 (\5\:SI SI) resistor r=0.06196 c=0
Rk37 (\3\:QN QN) resistor r=0.04113 c=0
Rk36 (\2\:QN \3\:QN) resistor r=0.1178 c=0
Rk38 (\3\:QN \5\:QN) resistor r=0.183 c=0
Rk2 (\4\:SEb \6\:SEb) resistor r=0.4946 c=0
Rk3 (\6\:SEb \8\:SEb) resistor r=0.6889 c=0
Rk8 (\2\:Dpb \3\:Dpb) resistor r=0.3754 c=0
Rk9 (\3\:Dpb \5\:Dpb) resistor r=0.5903 c=0
Rk10 (\3\:Dpb \7\:Dpb) resistor r=0.05034 c=0
Rk11 (\5\:Dpb \9\:Dpb) resistor r=0.5309 c=0
Rk56 (\5\:Dp \6\:Dp) resistor r=0.4071 c=0
Rk57 (\6\:Dp \7\:Dp) resistor r=0.4312 c=0
Rk58 (\7\:Dp \8\:Dp) resistor r=4.291 c=0
Rk59 (\6\:Dp \10\:Dp) resistor r=0.6038 c=0
Rk60 (\6\:Dp \12\:Dp) resistor r=0.02745 c=0
Rk61 (\7\:Dp \14\:Dp) resistor r=0.2868 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.8779 c=0
Rk19 (\9\:CKbb \10\:CKbb) resistor r=0.2701 c=0
Rk20 (\10\:CKbb \12\:CKbb) resistor r=0.2758 c=0
Rk21 (\9\:CKbb \13\:CKbb) resistor r=0.0379 c=0
Rk22 (\10\:CKbb \14\:CKbb) resistor r=0.3631 c=0
Rk23 (\12\:CKbb \16\:CKbb) resistor r=0.4055 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=0.398 c=0
Rk27 (\16\:CKb \17\:CKb) resistor r=0.625 c=0
Rk28 (\17\:CKb \18\:CKb) resistor r=0.4201 c=0
Rk29 (\18\:CKb \19\:CKb) resistor r=0.8159 c=0
Rk30 (\17\:CKb \20\:CKb) resistor r=0.2462 c=0
Rk31 (\18\:CKb \21\:CKb) resistor r=0.2216 c=0
Rk12 (\4\:n20 \5\:n20) resistor r=0.3489 c=0
Rk13 (\5\:n20 \7\:n20) resistor r=0.2821 c=0
Rk14 (\5\:n20 \9\:n20) resistor r=0.1211 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.1211 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.2976 c=0
Rk17 (\6\:mout \9\:mout) resistor r=0.2622 c=0
Rk24 (\4\:n30 \6\:n30) resistor r=0.4793 c=0
Rk25 (\6\:n30 \8\:n30) resistor r=0.398 c=0
Rk48 (\16\:qbint \17\:qbint) resistor r=0.5864 c=0
Rk49 (\17\:qbint \18\:qbint) resistor r=0.8132 c=0
Rk50 (\18\:qbint \20\:qbint) resistor r=0.4957 c=0
Rk51 (\20\:qbint \22\:qbint) resistor r=0.3383 c=0
Rk52 (\18\:qbint \23\:qbint) resistor r=0.2333 c=0
Rk53 (\22\:qbint \24\:qbint) resistor r=0.2558 c=0
Rk39 (\8\:net582 \9\:net582) resistor r=0.2983 c=0
Rk40 (\9\:net582 \10\:net582) resistor r=0.1491 c=0
Rk41 (\9\:net582 \12\:net582) resistor r=0.1281 c=0
Rk45 (\5\:RNb \6\:RNb) resistor r=0.0416 c=0
Rk46 (\6\:RNb \8\:RNb) resistor r=0.7176 c=0
Rk47 (\6\:RNb \9\:RNb) resistor r=0.2684 c=0
Rk64 (\4\:Eb \6\:Eb) resistor r=0.9292 c=0
Rk65 (\6\:Eb \8\:Eb) resistor r=0.5193 c=0
Rk67 (\5\:Db \7\:Db) resistor r=0.5301 c=0
Rk68 (\7\:Db \8\:Db) resistor r=0.6441 c=0
Rk54 (\2\:net493 \4\:net493) resistor r=0.3068 c=0
Rk55 (\2\:net505 \4\:net505) resistor r=0.6555 c=0
Rl63 (\2\:D \3\:D) resistor r=130.002 c=0
Rl62 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl34 (\2\:CK \3\:CK) resistor r=59.5926 c=0
Rl33 (\1\:CK \2\:CK) resistor r=32.2239 c=0
Rl56 (\2\:E \3\:E) resistor r=48.0649 c=0
Rl55 (\1\:E \2\:E) resistor r=74.7951 c=0
Rl59 (\4\:E \5\:E) resistor r=66.1873 c=0
Rl61 (\5\:E \7\:E) resistor r=108.495 c=0
Rl60 (\5\:E \6\:E) resistor r=17.513 c=0
Rl9 (\6\:SE \7\:SE) resistor r=54.5379 c=0
Rl6 (\4\:SE \5\:SE) resistor r=35.3072 c=0
Rl1 (\1\:SE \2\:SE) resistor r=104.538 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl47 (\1\:RN \2\:RN) resistor r=50.6918 c=0
Rl48 (\2\:RN \3\:RN) resistor r=156.461 c=0
Rl3 (\1\:SI \2\:SI) resistor r=51.6416 c=0
Rl5 (\2\:SI \4\:SI) resistor r=111.257 c=0
Rl4 (\2\:SI \3\:SI) resistor r=3.3229 c=0
Rl8 (\2\:SEb \3\:SEb) resistor r=26.3736 c=0
Rl7 (SEb \2\:SEb) resistor r=126.895 c=0
Rl11 (\2\:Dp \3\:Dp) resistor r=159.467 c=0
Rl10 (Dp \2\:Dp) resistor r=41.0764 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=151.043 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=66.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=51.1559 c=0
Rl28 (\11\:CKb \12\:CKb) resistor r=39.6174 c=0
Rl25 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl18 (\2\:CKb \6\:CKb) resistor r=26.0667 c=0
Rl14 (CKb \2\:CKb) resistor r=3.7088 c=0
Rl19 (\3\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=170.863 c=0
Rl20 (\4\:CKb \8\:CKb) resistor r=76.0821 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=84.2779 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=146.229 c=0
Rl23 (n20 \2\:n20) resistor r=101.156 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl21 (mout \2\:mout) resistor r=24.2328 c=0
Rl22 (\2\:mout \3\:mout) resistor r=106.558 c=0
Rl32 (\2\:n30 \3\:n30) resistor r=32.4874 c=0
Rl31 (n30 \2\:n30) resistor r=28.1965 c=0
Rl51 (\14\:qbint \13\:qbint) resistor r=232.692 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=143.796 c=0
Rl52 (\15\:qbint \14\:qbint) resistor r=44.9225 c=0
Rl45 (\10\:qbint \11\:qbint) resistor r=35.8844 c=0
Rl30 (\2\:qbint \3\:qbint) resistor r=24.2328 c=0
Rl29 (\2\:qbint qbint) resistor r=101.156 c=0
Rl49 (RNb \2\:RNb) resistor r=170.387 c=0
Rl50 (\2\:RNb \3\:RNb) resistor r=33.8482 c=0
Rl53 (Eb \2\:Eb) resistor r=172.872 c=0
Rl54 (\2\:Eb \3\:Eb) resistor r=33.5406 c=0
Rl57 (Db \2\:Db) resistor r=157.258 c=0
Rl58 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz25 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz26 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz27 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz28 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz9 (\5\:Q \4\:Q) resistor r=75 c=0
Rz29 (\4\:VDD \3\:VDD) resistor r=15 c=0
Rz30 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz31 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz32 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz10 (\2\:QN \1\:QN) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz2 (Dpb \2\:Dpb) resistor r=75 c=0
Rz3 (\8\:Dpb \9\:Dpb) resistor r=75 c=0
Rz14 (\9\:Dp \10\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz13 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz11 (\8\:net582 \7\:net582) resistor r=75 c=0
Rz12 (\4\:RNb \5\:RNb) resistor r=75 c=0
Rz16 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz17 (\4\:Db \5\:Db) resistor r=75 c=0
Ry22 (\4\:VSS \3\:VSS) resistor r=12.4 c=0
Ry23 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry24 (\12\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry25 (\27\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry9 (\3\:Q \2\:Q) resistor r=62 c=0
Ry26 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry31 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry32 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry33 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry34 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry10 (\5\:QN \4\:QN) resistor r=62 c=0
Ry1 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry2 (\4\:Dpb \5\:Dpb) resistor r=62 c=0
Ry3 (\6\:Dpb \7\:Dpb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry6 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry13 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry11 (\12\:net582 \11\:net582) resistor r=62 c=0
Ry12 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry20 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry21 (\6\:Db \7\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx27 (\2\:D \4\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx24 (\6\:E \8\:E) resistor r=45 c=0
Rx25 (\2\:E \9\:E) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx17 (\2\:RN \6\:RN) resistor r=45 c=0
Rx1 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx23 (Dp \8\:Dp) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (CKb \19\:CKb) resistor r=45 c=0
Rx13 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx7 (\2\:mout \7\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx19 (\16\:qbint \15\:qbint) resistor r=45 c=0
Rx20 (\17\:qbint \10\:qbint) resistor r=45 c=0
Rx21 (\23\:qbint \4\:qbint) resistor r=45 c=0
Rx22 (\24\:qbint \2\:qbint) resistor r=45 c=0
Rx16 (\10\:net582 net582) resistor r=45 c=0
Rx18 (\2\:RNb \9\:RNb) resistor r=45 c=0
Rx26 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx28 (\3\:Db \8\:Db) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \35\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (net658 \4\:SI \35\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.2e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (\8\:Dpb \4\:SE net658 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=8.15e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (\8\:Dpb SEb net650 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=6.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net650 \3\:Dp \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn21 (\11\:CKbb \5\:CKb \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\8\:n20 \7\:CKb Dpb VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=5.003e-14 ps=5.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\8\:n20 \3\:CKbb net606 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.003e-14 ps=4.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.72e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=8.7e-15 ps=1.32e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.615e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=6.235e-14 ps=1.32e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.35e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:n30 \7\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.235e-14 ad=4.422e-14 ps=1.15e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=8.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 \11\:CKb net618 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.422e-14 ps=4.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=5.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 qbint \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=8.7e-15 ps=9.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=4.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\13\:CKb \1\:CK \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.345e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn56 (\7\:net582 \11\:qbint \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\4\:RNb \3\:RN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\13\:Dp \3\:RNb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn5 (\13\:Dp \14\:qbint net634 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (net634 \3\:Eb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=1.595e-14 ps=1.11e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (net638 \1\:E \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=1.45e-14 ps=9.8e-07 pd=4.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.85e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn7 (\9\:Dp Db net638 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.45e-14 ad=2.03e-14 ps=4.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn0 (\5\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn1 (\4\:Db \1\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn45 (\19\:qbint n30 \29\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=3.178e-14 ps=9.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46439e-06 sb=1.55e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.672e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=9.76058e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn57 (\1\:QN net582 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.672e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.71058e-07 sb=5.06058e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mp45 (\21\:qbint \3\:n30 \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.663e-14 ad=4.34e-14 ps=2.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0121e-06 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp55_1__rcx (\2\:Q \4\:qbint \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.1743e-13 ad=6.24e-14 ps=1.82e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=9.14103e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57_1__rcx (\4\:QN net582 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.984e-14 ad=6.24e-14 ps=1.855e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.69551e-07 sb=4.44103e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
ends SEDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:18 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFTRX4
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX4 CK D E Q QN RN SE SI VDD VSS
mp10 (\5\:SEb \1\:SE \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=3.01e-14 ps=1.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=25.3738 \
        scb=0.0277485 scc=0.00188421 m=(1)
mp13 (net557 \1\:SI \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=1.29e-14 ps=1.13e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.3e-07 sd=160n sca=20.6042 \
        scb=0.0198237 scc=0.00166414 m=(1)
mp14 (\4\:Dpb \3\:SEb net557 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.127e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.25e-07 sd=160n sca=19.9561 \
        scb=0.0191767 scc=0.00166251 m=(1)
mp12 (\4\:Dpb \6\:SE net549 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=6.127e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.95e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp11 (net549 \2\:Dp \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.19e-14 ad=2.472e-14 ps=1.72e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.35e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp21 (\14\:CKbb \8\:CKb \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.19e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp25 (\7\:n20 CKbb \6\:Dpb VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88279e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\7\:n20 \6\:CKb net521 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (net521 mout \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.442e-14 ad=3.332e-14 ps=2e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.55198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\8\:mout n20 \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.442e-14 ad=6.773e-14 ps=2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.35198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\12\:n30 \9\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=5.16e-14 ps=1.06e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=9.91977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\12\:n30 \5\:CKbb net529 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=5.16e-14 ps=7.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=7.06977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp50 (net529 qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.015e-14 ad=3.547e-14 ps=2.09e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=4.96977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp20 (\17\:CKb \3\:CK \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1772e-13 ad=4.085e-14 ps=1.89e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp2 (\6\:RNb \3\:RN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=3.01e-14 ps=1.71e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.7e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp3 (\3\:net493 \3\:RNb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.77e-14 ad=6.773e-14 ps=1.71e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.05e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp5 (net505 \22\:qbint \3\:net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.45e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp4 (net505 Eb net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp6 (\10\:Dp \3\:E \3\:net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.332e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=3.45e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp7 (\4\:Dp \2\:Db \3\:net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=13.7129 \
        scb=0.0130599 scc=0.000590384 m=(1)
mp0 (\4\:Eb \4\:E \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=3.01e-14 ps=1.5e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
mp1 (\4\:Db \1\:D \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=3.44e-14 ps=1.5e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.6e-07 sd=160n sca=55.1271 \
        scb=0.0420653 scc=0.00650135 m=(1)
C1 (D VSS) capacitor c=4.33631e-17
C2 (Q VSS) capacitor c=9.92334e-17
C3 (E VSS) capacitor c=6.10535e-17
C4 (QN VSS) capacitor c=9.45668e-17
C5 (VDD VSS) capacitor c=6.54945e-16
C6 (SE VSS) capacitor c=5.49122e-17
C7 (RN VSS) capacitor c=7.68823e-17
C8 (SEb VSS) capacitor c=5.4968e-17
C9 (net658 VSS) capacitor c=8.64555e-20
C10 (Dpb VSS) capacitor c=7.57089e-17
C11 (net650 VSS) capacitor c=2.61787e-18
C12 (Dp VSS) capacitor c=3.26403e-17
C13 (CKbb VSS) capacitor c=3.96318e-17
C14 (CKb VSS) capacitor c=2.89192e-17
C15 (n20 VSS) capacitor c=5.90503e-17
C16 (mout VSS) capacitor c=4.6819e-17
C17 (n30 VSS) capacitor c=1.21203e-16
C18 (net618 VSS) capacitor c=1.63901e-18
C19 (qbint VSS) capacitor c=4.51048e-17
C20 (net582 VSS) capacitor c=2.89586e-16
C21 (RNb VSS) capacitor c=4.48736e-17
C22 (Eb VSS) capacitor c=4.76364e-17
C23 (net638 VSS) capacitor c=1.98014e-18
C24 (Db VSS) capacitor c=2.24153e-17
C25 (net557 VSS) capacitor c=2.07571e-18
C26 (net549 VSS) capacitor c=2.62936e-18
C27 (net521 VSS) capacitor c=4.23174e-18
C28 (net529 VSS) capacitor c=5.55958e-18
C29 (net493 VSS) capacitor c=8.36506e-17
C30 (net505 VSS) capacitor c=8.02248e-17
C31 (\1\:D VSS) capacitor c=4.09225e-17
C32 (\4\:E VSS) capacitor c=4.48228e-17
C33 (\2\:Db VSS) capacitor c=5.42743e-17
C34 (\3\:E VSS) capacitor c=4.37739e-17
C35 (\22\:qbint VSS) capacitor c=4.76333e-17
C36 (\3\:RNb VSS) capacitor c=4.43197e-17
C37 (\3\:RN VSS) capacitor c=3.91543e-17
C38 (\21\:qbint VSS) capacitor c=5.64117e-17
C39 (\3\:CK VSS) capacitor c=3.98505e-17
C40 (\5\:CKbb VSS) capacitor c=7.38522e-17
C41 (\9\:CKb VSS) capacitor c=3.41954e-17
C42 (\6\:CKb VSS) capacitor c=3.59587e-17
C43 (\8\:CKb VSS) capacitor c=5.46946e-17
C44 (\2\:Dp VSS) capacitor c=6.40192e-17
C45 (\6\:SE VSS) capacitor c=5.23868e-17
C46 (\3\:SEb VSS) capacitor c=4.78551e-17
C47 (\1\:SI VSS) capacitor c=6.1375e-17
C48 (\1\:SE VSS) capacitor c=4.95933e-17
C49 (\3\:D VSS) capacitor c=2.73516e-17
C50 (\7\:E VSS) capacitor c=2.99114e-17
C51 (\3\:Db VSS) capacitor c=7.13476e-17
C52 (\1\:E VSS) capacitor c=5.35186e-17
C53 (\3\:Eb VSS) capacitor c=2.82801e-17
C54 (\23\:qbint VSS) capacitor c=5.2244e-17
C55 (\1\:RN VSS) capacitor c=4.59238e-17
C56 (\19\:qbint VSS) capacitor c=3.25857e-17
C57 (\4\:qbint VSS) capacitor c=3.4155e-16
C58 (\1\:CK VSS) capacitor c=3.06661e-17
C59 (\3\:qbint VSS) capacitor c=6.12528e-17
C60 (\11\:CKb VSS) capacitor c=5.75383e-17
C61 (\7\:CKbb VSS) capacitor c=1.87124e-17
C62 (\4\:n20 VSS) capacitor c=2.86365e-17
C63 (\3\:mout VSS) capacitor c=7.40659e-17
C64 (\3\:CKbb VSS) capacitor c=8.54535e-17
C65 (\7\:CKb VSS) capacitor c=2.7829e-17
C66 (\5\:CKb VSS) capacitor c=3.32534e-17
C67 (\3\:Dp VSS) capacitor c=6.61023e-17
C68 (\4\:SE VSS) capacitor c=6.6042e-17
C69 (\4\:SI VSS) capacitor c=6.02437e-17
C70 (\3\:SE VSS) capacitor c=2.54311e-17
C71 (\2\:D VSS) capacitor c=3.00027e-17
C72 (\6\:E VSS) capacitor c=2.43392e-17
C73 (\2\:E VSS) capacitor c=5.21729e-17
C74 (\2\:Eb VSS) capacitor c=3.66717e-17
C75 (\24\:qbint VSS) capacitor c=2.74544e-17
C76 (\2\:RNb VSS) capacitor c=5.92761e-17
C77 (\2\:RN VSS) capacitor c=4.94869e-17
C78 (\20\:qbint VSS) capacitor c=3.49438e-17
C79 (\2\:CK VSS) capacitor c=2.16789e-17
C80 (\4\:n30 VSS) capacitor c=2.59195e-17
C81 (\2\:qbint VSS) capacitor c=4.63403e-17
C82 (\12\:CKb VSS) capacitor c=5.10337e-17
C83 (\10\:CKb VSS) capacitor c=3.05245e-17
C84 (\6\:CKbb VSS) capacitor c=5.27462e-17
C85 (\3\:n20 VSS) capacitor c=2.50573e-17
C86 (\2\:mout VSS) capacitor c=7.12043e-17
C87 (\4\:CKbb VSS) capacitor c=2.11175e-17
C88 (\2\:CKbb VSS) capacitor c=4.50051e-17
C89 (\7\:SE VSS) capacitor c=4.57055e-17
C90 (\2\:SEb VSS) capacitor c=6.16773e-17
C91 (\5\:SE VSS) capacitor c=4.68411e-17
C92 (\3\:SI VSS) capacitor c=5.62601e-17
C93 (\2\:SE VSS) capacitor c=3.29922e-17
C94 (\4\:Db VSS) capacitor c=8.70201e-17
C95 (\8\:VDD VSS) capacitor c=5.20344e-17
C96 (\4\:Eb VSS) capacitor c=6.013e-17
C97 (\4\:Dp VSS) capacitor c=6.94834e-17
C98 (\3\:net505 VSS) capacitor c=8.63295e-17
C99 (\10\:Dp VSS) capacitor c=3.40127e-17
C100 (\3\:net493 VSS) capacitor c=7.53234e-17
C101 (\1\:VDD VSS) capacitor c=1.98282e-17
C102 (\6\:RNb VSS) capacitor c=5.80367e-17
C103 (\14\:net582 VSS) capacitor c=1.50911e-17
C104 (\17\:CKb VSS) capacitor c=1.12889e-16
C105 (\29\:qbint VSS) capacitor c=5.52558e-17
C106 (\12\:n30 VSS) capacitor c=7.99207e-17
C107 (\8\:mout VSS) capacitor c=4.38559e-17
C108 (\30\:VDD VSS) capacitor c=1.96266e-17
C109 (\7\:n20 VSS) capacitor c=5.52733e-17
C110 (\6\:Dpb VSS) capacitor c=3.18852e-17
C111 (\14\:CKbb VSS) capacitor c=6.43933e-17
C112 (\33\:VDD VSS) capacitor c=2.36853e-17
C113 (\4\:Dpb VSS) capacitor c=1.31508e-16
C114 (\37\:VDD VSS) capacitor c=3.92242e-17
C115 (\5\:SEb VSS) capacitor c=1.24112e-16
C116 (\5\:VDD VSS) capacitor c=1.49486e-16
C117 (\7\:Db VSS) capacitor c=4.10283e-17
C118 (\6\:Eb VSS) capacitor c=1.63062e-16
C119 (\12\:Dp VSS) capacitor c=1.00852e-16
C120 (\14\:Dp VSS) capacitor c=4.36995e-17
C121 (\8\:RNb VSS) capacitor c=2.88993e-17
C122 (\18\:net582 VSS) capacitor c=6.61175e-17
C123 (\1\:QN VSS) capacitor c=1.10772e-16
C124 (\1\:Q VSS) capacitor c=1.36813e-16
C125 (\19\:CKb VSS) capacitor c=7.54983e-17
C126 (\35\:qbint VSS) capacitor c=1.71076e-17
C127 (\10\:n30 VSS) capacitor c=2.27015e-17
C128 (\6\:mout VSS) capacitor c=5.23318e-17
C129 (\9\:n20 VSS) capacitor c=3.65027e-17
C130 (\11\:CKbb VSS) capacitor c=6.89121e-17
C131 (\8\:Dpb VSS) capacitor c=1.0508e-16
C132 (\7\:SEb VSS) capacitor c=7.00336e-17
C133 (\2\:CKb VSS) capacitor c=5.7765e-17
C134 (\3\:CKb VSS) capacitor c=4.48248e-17
C135 (\4\:CKb VSS) capacitor c=3.79459e-17
C136 (\2\:n20 VSS) capacitor c=2.70592e-17
C137 (\5\:SI VSS) capacitor c=1.43146e-16
C138 (\4\:SEb VSS) capacitor c=8.95631e-17
C139 (\8\:SE VSS) capacitor c=1.22571e-16
C140 (\9\:SE VSS) capacitor c=1.09079e-16
C141 (\11\:SE VSS) capacitor c=2.70371e-17
C142 (\3\:Dpb VSS) capacitor c=1.20812e-16
C143 (\5\:n20 VSS) capacitor c=5.42129e-17
C144 (\6\:n20 VSS) capacitor c=6.2147e-17
C145 (\4\:mout VSS) capacitor c=4.4154e-17
C146 (\5\:mout VSS) capacitor c=4.81648e-17
C147 (\8\:CKbb VSS) capacitor c=1.17402e-16
C148 (\9\:CKbb VSS) capacitor c=7.73588e-17
C149 (\10\:CKbb VSS) capacitor c=5.71706e-17
C150 (\13\:CKbb VSS) capacitor c=8.09586e-17
C151 (\8\:n30 VSS) capacitor c=8.35368e-17
C152 (\9\:n30 VSS) capacitor c=6.58251e-17
C153 (\5\:E VSS) capacitor c=2.46118e-17
C154 (\13\:CKb VSS) capacitor c=5.46164e-17
C155 (\14\:CKb VSS) capacitor c=1.66063e-16
C156 (\15\:CKb VSS) capacitor c=1.48642e-16
C157 (\16\:CKb VSS) capacitor c=1.07247e-16
C158 (\21\:CKb VSS) capacitor c=6.06522e-17
C159 (\4\:CK VSS) capacitor c=1.0588e-16
C160 (\16\:net582 VSS) capacitor c=5.4005e-17
C161 (\17\:net582 VSS) capacitor c=4.63955e-17
C162 (\4\:RN VSS) capacitor c=5.55486e-17
C163 (\4\:RNb VSS) capacitor c=3.81725e-17
C164 (\5\:RNb VSS) capacitor c=5.78956e-17
C165 (\25\:qbint VSS) capacitor c=1.1037e-16
C166 (\26\:qbint VSS) capacitor c=2.51173e-16
C167 (\27\:qbint VSS) capacitor c=2.5548e-16
C168 (\28\:qbint VSS) capacitor c=1.21747e-16
C169 (\31\:qbint VSS) capacitor c=5.70581e-17
C170 (\32\:qbint VSS) capacitor c=4.77478e-17
C171 (\6\:Dp VSS) capacitor c=5.63738e-17
C172 (\7\:Dp VSS) capacitor c=1.33596e-16
C173 (\8\:Dp VSS) capacitor c=5.83289e-16
C174 (\9\:Dp VSS) capacitor c=6.78989e-16
C175 (\8\:E VSS) capacitor c=2.59868e-17
C176 (\9\:E VSS) capacitor c=7.39845e-17
C177 (\8\:Eb VSS) capacitor c=1.80795e-16
C178 (\4\:D VSS) capacitor c=7.26533e-17
C179 (\6\:Db VSS) capacitor c=1.02793e-16
C180 (\3\:VDD VSS) capacitor c=4.09445e-17
C181 (\4\:VDD VSS) capacitor c=2.13967e-16
C182 (\23\:VDD VSS) capacitor c=5.64463e-17
C183 (\29\:VDD VSS) capacitor c=6.74532e-17
C184 (\32\:VDD VSS) capacitor c=1.87821e-17
C185 (\36\:VDD VSS) capacitor c=1.56009e-17
Rk73 (D \4\:D) resistor r=0.1712 c=0
Rk34 (\1\:Q Q) resistor r=0.3826 c=0
Rk32 (\4\:CK CK) resistor r=0.03189 c=0
Rk69 (\8\:E E) resistor r=0.0319 c=0
Rk70 (E \9\:E) resistor r=0.2494 c=0
Rk39 (\1\:QN QN) resistor r=0.3282 c=0
Rk105 (\2\:VDD \3\:VDD) resistor r=0.07405 c=0
Rk106 (\3\:VDD \4\:VDD) resistor r=0.4486 c=0
Rk108 (\3\:VDD \7\:VDD) resistor r=0.5341 c=0
Rk109 (\7\:VDD \9\:VDD) resistor r=0.6132 c=0
Rk118 (\4\:VDD \23\:VDD) resistor r=0.2896 c=0
Rk122 (\23\:VDD \29\:VDD) resistor r=0.7357 c=0
Rk123 (\29\:VDD \31\:VDD) resistor r=0.07405 c=0
Rk124 (\29\:VDD \32\:VDD) resistor r=0.415 c=0
Rk125 (\32\:VDD \34\:VDD) resistor r=0.04332 c=0
Rk126 (\32\:VDD \35\:VDD) resistor r=0.05153 c=0
Rk129 (\36\:VDD VDD) resistor r=0.1576 c=0
Rk127 (\35\:VDD \36\:VDD) resistor r=0.3936 c=0
Rk128 (\36\:VDD \38\:VDD) resistor r=0.2667 c=0
Rk5 (\9\:SE SE) resistor r=0.2173 c=0
Rk4 (\8\:SE \9\:SE) resistor r=0.9019 c=0
Rk6 (SE \10\:SE) resistor r=0.01035 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.08778 c=0
Rk46 (RN \4\:RN) resistor r=0.1137 c=0
Rk1 (\5\:SI SI) resistor r=0.003299 c=0
Rk76 (\2\:VSS \4\:VSS) resistor r=0.5187 c=0
Rk77 (\4\:VSS \5\:VSS) resistor r=0.1534 c=0
Rk78 (\5\:VSS \6\:VSS) resistor r=0.3022 c=0
Rk79 (\6\:VSS \7\:VSS) resistor r=0.4442 c=0
Rk85 (\7\:VSS \13\:VSS) resistor r=0.415 c=0
Rk88 (\13\:VSS \16\:VSS) resistor r=0.563 c=0
Rk89 (\16\:VSS \17\:VSS) resistor r=0.5764 c=0
Rk91 (\18\:VSS VSS) resistor r=0.1576 c=0
Rk90 (\17\:VSS \18\:VSS) resistor r=0.3936 c=0
Rk92 (\4\:VSS \20\:VSS) resistor r=0.2931 c=0
Rk93 (\5\:VSS \22\:VSS) resistor r=0.07405 c=0
Rk94 (\6\:VSS \24\:VSS) resistor r=0.04332 c=0
Rk102 (\16\:VSS \40\:VSS) resistor r=0.04332 c=0
Rk103 (\17\:VSS \42\:VSS) resistor r=0.3581 c=0
Rk104 (\18\:VSS \44\:VSS) resistor r=0.3094 c=0
Rk2 (\4\:SEb \6\:SEb) resistor r=0.5459 c=0
Rk3 (\6\:SEb \8\:SEb) resistor r=0.6251 c=0
Rk8 (\2\:Dpb \3\:Dpb) resistor r=0.3904 c=0
Rk9 (\3\:Dpb \5\:Dpb) resistor r=0.588 c=0
Rk10 (\3\:Dpb \7\:Dpb) resistor r=0.06035 c=0
Rk11 (\5\:Dpb \9\:Dpb) resistor r=0.5454 c=0
Rk62 (\5\:Dp \6\:Dp) resistor r=0.3459 c=0
Rk63 (\6\:Dp \7\:Dp) resistor r=0.1805 c=0
Rk64 (\7\:Dp \8\:Dp) resistor r=0.3849 c=0
Rk65 (\8\:Dp \9\:Dp) resistor r=5.3912 c=0
Rk66 (\6\:Dp \11\:Dp) resistor r=0.03441 c=0
Rk67 (\7\:Dp \13\:Dp) resistor r=0.6102 c=0
Rk68 (\8\:Dp \15\:Dp) resistor r=0.1945 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.8482 c=0
Rk19 (\9\:CKbb \10\:CKbb) resistor r=0.1164 c=0
Rk20 (\10\:CKbb \12\:CKbb) resistor r=0.2746 c=0
Rk21 (\10\:CKbb \13\:CKbb) resistor r=0.3615 c=0
Rk22 (\12\:CKbb \15\:CKbb) resistor r=0.4225 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2242 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.4209 c=0
Rk28 (\15\:CKb \16\:CKb) resistor r=0.7375 c=0
Rk29 (\14\:CKb \18\:CKb) resistor r=0.9008 c=0
Rk30 (\18\:CKb \20\:CKb) resistor r=0.3374 c=0
Rk31 (\15\:CKb \21\:CKb) resistor r=0.2207 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.3027 c=0
Rk13 (\6\:n20 \8\:n20) resistor r=0.2842 c=0
Rk14 (\6\:n20 \10\:n20) resistor r=0.1206 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.1867 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2321 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1541 c=0
Rk23 (\8\:n30 \9\:n30) resistor r=0.4387 c=0
Rk24 (\9\:n30 \11\:n30) resistor r=0.06436 c=0
Rk25 (\9\:n30 \13\:n30) resistor r=0.3288 c=0
Rk50 (\25\:qbint \26\:qbint) resistor r=0.8224 c=0
Rk56 (\27\:qbint \4\:qbint) resistor r=0.3073 c=0
Rk51 (\26\:qbint \27\:qbint) resistor r=1.421 c=0
Rk52 (\27\:qbint \28\:qbint) resistor r=0.9882 c=0
Rk53 (\28\:qbint \30\:qbint) resistor r=0.2082 c=0
Rk54 (\30\:qbint \31\:qbint) resistor r=0.2512 c=0
Rk55 (\26\:qbint \32\:qbint) resistor r=0.2536 c=0
Rk58 (\28\:qbint \36\:qbint) resistor r=0.06101 c=0
Rk43 (\15\:net582 \16\:net582) resistor r=0.03466 c=0
Rk44 (\16\:net582 \17\:net582) resistor r=0.3591 c=0
Rk45 (\16\:net582 \19\:net582) resistor r=0.3626 c=0
Rk47 (\4\:RNb \5\:RNb) resistor r=0.187 c=0
Rk48 (\5\:RNb \7\:RNb) resistor r=0.3794 c=0
Rk49 (\5\:RNb \9\:RNb) resistor r=0.09154 c=0
Rk71 (\5\:Eb \7\:Eb) resistor r=0.3476 c=0
Rk72 (\7\:Eb \8\:Eb) resistor r=1.2182 c=0
Rk74 (\5\:Db \6\:Db) resistor r=0.8 c=0
Rk75 (\5\:Db \8\:Db) resistor r=0.264 c=0
Rk60 (\2\:net493 \4\:net493) resistor r=0.2998 c=0
Rk61 (\2\:net505 \4\:net505) resistor r=0.5169 c=0
Rl82 (\1\:D \2\:D) resistor r=39.6174 c=0
Rl83 (\2\:D \3\:D) resistor r=24.2328 c=0
Rl39 (\2\:CK \3\:CK) resistor r=76.3736 c=0
Rl38 (\1\:CK \2\:CK) resistor r=26.9231 c=0
Rl76 (\2\:E \3\:E) resistor r=55.7572 c=0
Rl75 (\1\:E \2\:E) resistor r=134.41 c=0
Rl79 (\4\:E \5\:E) resistor r=47.3105 c=0
Rl81 (\5\:E \7\:E) resistor r=41.5412 c=0
Rl80 (\5\:E \6\:E) resistor r=69.604 c=0
Rl9 (\6\:SE \7\:SE) resistor r=64.1533 c=0
Rl6 (\4\:SE \5\:SE) resistor r=35.3072 c=0
Rl1 (\1\:SE \2\:SE) resistor r=114.153 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl68 (\2\:RN \3\:RN) resistor r=79.3856 c=0
Rl67 (\1\:RN \2\:RN) resistor r=85.7713 c=0
Rl3 (\1\:SI \2\:SI) resistor r=61.257 c=0
Rl5 (\2\:SI \4\:SI) resistor r=111.257 c=0
Rl4 (\2\:SI \3\:SI) resistor r=3.3229 c=0
Rl8 (\2\:SEb \3\:SEb) resistor r=26.3736 c=0
Rl7 (SEb \2\:SEb) resistor r=136.511 c=0
Rl11 (\2\:Dp \3\:Dp) resistor r=169.083 c=0
Rl10 (Dp \2\:Dp) resistor r=41.0764 c=0
Rl27 (\5\:CKbb \6\:CKbb) resistor r=187.581 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=44.7803 c=0
Rl12 (CKbb \2\:CKbb) resistor r=63.0341 c=0
Rl29 (\11\:CKb \12\:CKb) resistor r=53.079 c=0
Rl26 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl18 (\2\:CKb \6\:CKb) resistor r=24.7024 c=0
Rl14 (CKb \2\:CKb) resistor r=4.4012 c=0
Rl19 (\3\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=162.881 c=0
Rl20 (\4\:CKb \8\:CKb) resistor r=85.6975 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=84.2779 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=146.229 c=0
Rl23 (n20 \2\:n20) resistor r=113.176 c=0
Rl25 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=1.2666 c=0
Rl21 (mout \2\:mout) resistor r=41.5405 c=0
Rl22 (\2\:mout \3\:mout) resistor r=93.0293 c=0
Rl34 (n30 \4\:n30) resistor r=4.6955 c=0
Rl71 (\23\:qbint \22\:qbint) resistor r=174.673 c=0
Rl72 (\24\:qbint \23\:qbint) resistor r=24.2328 c=0
Rl66 (\20\:qbint \21\:qbint) resistor r=64.8409 c=0
Rl65 (\20\:qbint \19\:qbint) resistor r=41.1312 c=0
Rl30 (\2\:qbint qbint) resistor r=41.5405 c=0
Rl31 (\2\:qbint \3\:qbint) resistor r=85.7713 c=0
Rl70 (\2\:RNb \3\:RNb) resistor r=118.464 c=0
Rl69 (RNb \2\:RNb) resistor r=65.6605 c=0
Rl73 (Eb \2\:Eb) resistor r=118.464 c=0
Rl74 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl78 (\2\:Db \3\:Db) resistor r=223.077 c=0
Rl77 (Db \2\:Db) resistor r=31.0981 c=0
Rz34 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz35 (\7\:VDD \5\:VDD) resistor r=6.25 c=0
Rz36 (\23\:VDD \5\:VDD) resistor r=6.25 c=0
Rz37 (\35\:VDD \5\:VDD) resistor r=6.25 c=0
Rz20 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz31 (\40\:VSS \39\:VSS) resistor r=75 c=0
Rz32 (\42\:VSS \41\:VSS) resistor r=75 c=0
Rz33 (\44\:VSS \43\:VSS) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz2 (Dpb \2\:Dpb) resistor r=75 c=0
Rz3 (\8\:Dpb \9\:Dpb) resistor r=75 c=0
Rz16 (\12\:Dp \13\:Dp) resistor r=75 c=0
Rz17 (\14\:Dp \15\:Dp) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz4 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz15 (\36\:qbint \35\:qbint) resistor r=75 c=0
Rz13 (\19\:net582 \18\:net582) resistor r=75 c=0
Rz14 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz18 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz19 (\7\:Db \8\:Db) resistor r=75 c=0
Ry28 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry29 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry37 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry38 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry39 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry27 (\17\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry2 (\4\:Dpb \5\:Dpb) resistor r=62 c=0
Ry3 (\6\:Dpb \7\:Dpb) resistor r=62 c=0
Ry20 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry21 (\10\:Dp \11\:Dp) resistor r=62 c=0
Ry6 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry8 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry4 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry15 (\30\:qbint \29\:qbint) resistor r=62 c=0
Ry13 (\15\:net582 \14\:net582) resistor r=62 c=0
Ry14 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry22 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry23 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (net493 \2\:net493) resistor r=62 c=0
Ry17 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry18 (net505 \2\:net505) resistor r=62 c=0
Ry19 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx28 (\2\:D \4\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx25 (\6\:E \8\:E) resistor r=45 c=0
Rx26 (\2\:E \9\:E) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx17 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx24 (Dp \9\:Dp) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\12\:CKb \13\:CKb) resistor r=45 c=0
Rx13 (CKb \16\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx7 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\8\:n30 \4\:n30) resistor r=45 c=0
Rx19 (\25\:qbint \24\:qbint) resistor r=45 c=0
Rx20 (\31\:qbint \2\:qbint) resistor r=45 c=0
Rx21 (\32\:qbint \20\:qbint) resistor r=45 c=0
Rx16 (\17\:net582 net582) resistor r=45 c=0
Rx18 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx27 (\2\:Eb \8\:Eb) resistor r=45 c=0
Rx29 (Db \6\:Db) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \43\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (net658 \4\:SI \43\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.2e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (\8\:Dpb \4\:SE net658 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=8.15e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (\8\:Dpb SEb net650 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=6.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net650 \3\:Dp \41\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn21 (\11\:CKbb \5\:CKb \41\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\9\:n20 \7\:CKb Dpb VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.422e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\9\:n20 \3\:CKbb net606 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.422e-14 ps=4.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.845e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \39\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.74e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \4\:n20 \39\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=4.567e-14 ps=1.6e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\10\:n30 \7\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.567e-14 ad=4.857e-14 ps=9.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.115e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\10\:n30 \11\:CKb net618 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=4.857e-14 ps=4.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=7.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \3\:qbint \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.102e-14 ad=1.015e-14 ps=8.6e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=6.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\19\:CKb \1\:CK \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=3.407e-14 ps=1.62e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn2 (\8\:RNb \1\:RN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.452e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (\14\:Dp RNb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.452e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=4.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (\14\:Dp \23\:qbint net634 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2.8e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (net634 \3\:Eb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=1.957e-14 ps=1.28e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn6 (net638 \1\:E \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=1.377e-14 ps=6.4e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=2.8e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn7 (\12\:Dp \3\:Db net638 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.03e-14 ps=4.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn0 (\6\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\35\:qbint n30 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.486e-14 ad=3.382e-14 ps=7.75e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=3.5e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn56 (\18\:net582 \19\:qbint \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn55_1__rcx (\1\:Q \4\:qbint \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.783e-14 ad=4.16e-14 ps=1.485e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04231e-07 sb=2e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn57_1__rcx (\1\:QN net582 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=4.16e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34423e-06 sb=1.08e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mp45 (\29\:qbint n30 \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.662e-14 ad=4.96e-14 ps=1.945e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.30242e-07 sb=3.75e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(2)
mp56 (\14\:net582 \21\:qbint \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.254e-13 ad=5.46e-14 ps=1.88e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=27.1129 scb=0.0194379 \
        scc=0.00296416 m=(1)
mp57_1__rcx (QN net582 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29987e-06 sb=1.08e-06 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(4)
mp55_1__rcx (Q \4\:qbint \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.2348e-13 ad=6.825e-14 ps=1.8825e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.29872e-07 sb=2e-06 sd=160n \
        sca=27.1129 scb=0.0194379 scc=0.00296416 m=(4)
ends SEDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:20 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFTRXL
// View name: extracted

simulator lang=spectre

subckt SEDFFTRXL CK D E Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net582 \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.205e-14 ad=3.547e-14 ps=1.92e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
mp56 (\5\:net582 qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.205e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=48.8019 \
        scb=0.0316124 scc=0.00590646 m=(1)
mp45 (\16\:qbint n30 \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.96e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72e-06 sd=160n sca=12.1962 \
        scb=0.0105853 scc=0.000305891 m=(1)
mp50 (net529 \4\:qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.96e-14 ad=2.903e-14 ps=1.21e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.435e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\8\:n30 CKbb net529 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.548e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.255e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\8\:n30 \5\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.548e-14 ps=9.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.045e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=7.25e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net521 mout \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=4.6e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \4\:CKb net521 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.655e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=3.55e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \8\:CKbb \8\:Dpb VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.655e-14 ps=7.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.5e-14 ad=4.3e-14 ps=1.98e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=4.35e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp20 (\10\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.5e-14 ad=4.3e-14 ps=1.98e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=2e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp10 (\8\:SEb \1\:SE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=3.01e-14 ps=1.86e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp13 (net557 \1\:SI \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=1.505e-14 ps=1.86e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.06e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp14 (\3\:Dpb SEb net557 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.838e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=9.45e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp12 (\3\:Dpb \5\:SE net549 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.838e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6.75e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp11 (net549 Dp \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=4.838e-14 ps=1.86e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.05e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp55 (\1\:Q \7\:qbint \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=3.01e-14 ps=1.86e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp2 (\6\:RNb \3\:RN \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.918e-14 ad=4.085e-14 ps=1.56e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.2e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp3 (\3\:net493 \3\:RNb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.918e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.5e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (\3\:net505 \11\:qbint \3\:net493 VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.65e-07 sb=3.45e-07 sd=160n \
        sca=12.7104 scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\3\:net505 \4\:Eb net493 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\11\:Dp \3\:E net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp7 (\4\:Dp Db net505 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=15.4613 \
        scb=0.0150753 scc=0.000885445 m=(1)
mp0 (\5\:Eb \4\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.755e-14 ad=3.01e-14 ps=1.88e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.6797 \
        scb=0.0303382 scc=0.0046002 m=(1)
mp1 (\4\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.755e-14 ad=3.01e-14 ps=1.88e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=47.8434 \
        scb=0.0441905 scc=0.00576115 m=(1)
C1 (D VSS) capacitor c=7.32131e-17
C2 (Q VSS) capacitor c=6.66787e-17
C3 (SE VSS) capacitor c=3.88064e-17
C4 (E VSS) capacitor c=2.80071e-17
C5 (VDD VSS) capacitor c=6.02573e-16
C6 (RN VSS) capacitor c=5.02271e-17
C7 (QN VSS) capacitor c=2.78099e-17
C8 (CK VSS) capacitor c=1.06824e-16
C9 (net582 VSS) capacitor c=2.01676e-17
C10 (qbint VSS) capacitor c=4.04758e-17
C11 (n30 VSS) capacitor c=3.97156e-17
C12 (net618 VSS) capacitor c=1.73811e-18
C13 (CKb VSS) capacitor c=3.73145e-17
C14 (mout VSS) capacitor c=6.51571e-17
C15 (CKbb VSS) capacitor c=5.70181e-17
C16 (n20 VSS) capacitor c=4.88936e-17
C17 (Dpb VSS) capacitor c=8.36781e-17
C18 (SEb VSS) capacitor c=6.13065e-17
C19 (net658 VSS) capacitor c=5.45368e-18
C20 (Dp VSS) capacitor c=5.09979e-17
C21 (RNb VSS) capacitor c=4.51231e-17
C22 (net634 VSS) capacitor c=2.6712e-18
C23 (Eb VSS) capacitor c=1.81182e-17
C24 (net638 VSS) capacitor c=4.7126e-20
C25 (Db VSS) capacitor c=6.72105e-17
C26 (net529 VSS) capacitor c=3.89755e-19
C27 (net521 VSS) capacitor c=1.06974e-18
C28 (net557 VSS) capacitor c=1.30105e-18
C29 (net549 VSS) capacitor c=3.18606e-18
C30 (net493 VSS) capacitor c=8.38751e-17
C31 (net505 VSS) capacitor c=8.35865e-17
C32 (\1\:D VSS) capacitor c=3.50687e-17
C33 (\4\:E VSS) capacitor c=4.50291e-17
C34 (\3\:E VSS) capacitor c=4.1497e-17
C35 (\4\:Eb VSS) capacitor c=5.62053e-17
C36 (\11\:qbint VSS) capacitor c=5.11968e-17
C37 (\3\:RNb VSS) capacitor c=5.58061e-17
C38 (\3\:RN VSS) capacitor c=3.42879e-17
C39 (\7\:qbint VSS) capacitor c=4.40616e-17
C40 (\5\:SE VSS) capacitor c=4.35701e-17
C41 (\1\:SI VSS) capacitor c=6.0149e-17
C42 (\1\:SE VSS) capacitor c=4.79751e-17
C43 (\1\:CK VSS) capacitor c=3.62202e-17
C44 (\8\:CKbb VSS) capacitor c=3.6891e-17
C45 (\4\:CKb VSS) capacitor c=1.43708e-16
C46 (\5\:CKb VSS) capacitor c=1.23655e-16
C47 (\4\:qbint VSS) capacitor c=5.48059e-17
C48 (\4\:net582 VSS) capacitor c=4.03274e-17
C49 (\4\:D VSS) capacitor c=3.06035e-17
C50 (\7\:E VSS) capacitor c=2.9615e-17
C51 (\2\:Db VSS) capacitor c=8.76941e-17
C52 (\1\:E VSS) capacitor c=6.94163e-17
C53 (\3\:Eb VSS) capacitor c=4.22204e-17
C54 (\10\:qbint VSS) capacitor c=9.16698e-17
C55 (\1\:RN VSS) capacitor c=4.69068e-17
C56 (\8\:qbint VSS) capacitor c=5.15035e-17
C57 (\3\:Dp VSS) capacitor c=3.70133e-17
C58 (\3\:SEb VSS) capacitor c=7.28271e-17
C59 (\7\:SE VSS) capacitor c=3.30523e-17
C60 (\3\:SI VSS) capacitor c=3.9754e-17
C61 (\4\:SE VSS) capacitor c=3.25038e-17
C62 (\3\:CK VSS) capacitor c=3.62732e-17
C63 (\8\:CKb VSS) capacitor c=2.46215e-17
C64 (\9\:CKb VSS) capacitor c=2.71305e-17
C65 (\5\:CKbb VSS) capacitor c=8.99785e-17
C66 (\3\:mout VSS) capacitor c=6.80648e-17
C67 (\3\:n20 VSS) capacitor c=3.21574e-17
C68 (\3\:CKbb VSS) capacitor c=6.03183e-17
C69 (\6\:CKb VSS) capacitor c=8.76305e-17
C70 (\5\:qbint VSS) capacitor c=5.50223e-17
C71 (\3\:n30 VSS) capacitor c=3.52379e-17
C72 (\2\:qbint VSS) capacitor c=4.65218e-17
C73 (\3\:net582 VSS) capacitor c=2.68516e-17
C74 (\3\:D VSS) capacitor c=2.31139e-17
C75 (\6\:E VSS) capacitor c=3.44925e-17
C76 (\3\:Db VSS) capacitor c=1.93283e-17
C77 (\2\:E VSS) capacitor c=7.18564e-17
C78 (\12\:qbint VSS) capacitor c=3.37711e-17
C79 (\2\:RNb VSS) capacitor c=6.1737e-17
C80 (\2\:RN VSS) capacitor c=4.32262e-17
C81 (\9\:qbint VSS) capacitor c=2.44319e-17
C82 (\2\:Dp VSS) capacitor c=4.26018e-17
C83 (\4\:SEb VSS) capacitor c=2.881e-17
C84 (\6\:SE VSS) capacitor c=4.41952e-17
C85 (\2\:SEb VSS) capacitor c=3.8516e-17
C86 (\2\:SI VSS) capacitor c=4.75867e-17
C87 (\3\:SE VSS) capacitor c=8.32292e-18
C88 (\2\:CK VSS) capacitor c=3.70519e-17
C89 (\7\:CKb VSS) capacitor c=1.81934e-17
C90 (\7\:CKbb VSS) capacitor c=4.59558e-17
C91 (\6\:CKbb VSS) capacitor c=2.9279e-17
C92 (\2\:mout VSS) capacitor c=5.5447e-17
C93 (\2\:n20 VSS) capacitor c=3.40951e-17
C94 (\4\:CKbb VSS) capacitor c=2.20394e-17
C95 (\2\:CKbb VSS) capacitor c=5.79835e-17
C96 (\6\:qbint VSS) capacitor c=3.01822e-17
C97 (\2\:n30 VSS) capacitor c=3.24285e-17
C98 (\3\:qbint VSS) capacitor c=2.05395e-17
C99 (\4\:Db VSS) capacitor c=1.03404e-16
C100 (\1\:VDD VSS) capacitor c=1.6342e-17
C101 (\5\:Eb VSS) capacitor c=6.69926e-17
C102 (\4\:Dp VSS) capacitor c=8.05347e-17
C103 (\11\:Dp VSS) capacitor c=1.93868e-17
C104 (\3\:net505 VSS) capacitor c=7.85439e-17
C105 (\3\:net493 VSS) capacitor c=6.20861e-17
C106 (\6\:VDD VSS) capacitor c=1.97754e-17
C107 (\6\:RNb VSS) capacitor c=4.51034e-17
C108 (\1\:Q VSS) capacitor c=3.24431e-17
C109 (\9\:VDD VSS) capacitor c=1.95567e-17
C110 (\3\:Dpb VSS) capacitor c=2.79923e-16
C111 (\12\:VDD VSS) capacitor c=3.01661e-17
C112 (\8\:SEb VSS) capacitor c=1.65027e-16
C113 (\10\:CKb VSS) capacitor c=7.01261e-17
C114 (\16\:VDD VSS) capacitor c=2.41455e-17
C115 (\9\:CKbb VSS) capacitor c=6.24833e-17
C116 (\8\:Dpb VSS) capacitor c=4.25912e-17
C117 (\4\:n20 VSS) capacitor c=5.1587e-17
C118 (\19\:VDD VSS) capacitor c=6.78051e-17
C119 (\8\:mout VSS) capacitor c=5.59473e-17
C120 (\8\:n30 VSS) capacitor c=3.53075e-17
C121 (\23\:VDD VSS) capacitor c=3.6315e-17
C122 (\16\:qbint VSS) capacitor c=8.29455e-17
C123 (\5\:net582 VSS) capacitor c=3.3424e-17
C124 (\26\:VDD VSS) capacitor c=8.57797e-18
C125 (\1\:QN VSS) capacitor c=2.74599e-17
C126 (\3\:VDD VSS) capacitor c=1.89865e-16
C127 (\7\:Db VSS) capacitor c=3.78694e-17
C128 (\7\:Eb VSS) capacitor c=1.32418e-16
C129 (\13\:Dp VSS) capacitor c=1.11311e-16
C130 (\8\:Dp VSS) capacitor c=1.76617e-16
C131 (\8\:RNb VSS) capacitor c=4.74504e-17
C132 (\3\:Q VSS) capacitor c=5.64952e-17
C133 (\6\:SEb VSS) capacitor c=2.09306e-16
C134 (\14\:CKb VSS) capacitor c=3.73793e-17
C135 (\11\:CKbb VSS) capacitor c=7.25052e-17
C136 (\6\:Dpb VSS) capacitor c=8.2835e-17
C137 (\8\:n20 VSS) capacitor c=3.71286e-17
C138 (\6\:mout VSS) capacitor c=5.34538e-17
C139 (\4\:n30 VSS) capacitor c=7.02948e-17
C140 (\19\:qbint VSS) capacitor c=6.48925e-17
C141 (\9\:net582 VSS) capacitor c=3.61863e-17
C142 (\3\:QN VSS) capacitor c=3.10658e-17
C143 (\2\:net582 VSS) capacitor c=1.25154e-17
C144 (\2\:CKb VSS) capacitor c=3.30968e-17
C145 (\3\:CKb VSS) capacitor c=6.93646e-17
C146 (\2\:SE VSS) capacitor c=1.84501e-17
C147 (\7\:net582 VSS) capacitor c=2.8393e-17
C148 (\8\:net582 VSS) capacitor c=3.5235e-17
C149 (\6\:n30 VSS) capacitor c=8.67204e-17
C150 (\7\:n30 VSS) capacitor c=7.2888e-17
C151 (\2\:Eb VSS) capacitor c=3.39978e-17
C152 (\4\:mout VSS) capacitor c=7.60995e-17
C153 (\5\:mout VSS) capacitor c=6.8662e-17
C154 (\6\:n20 VSS) capacitor c=5.69815e-17
C155 (\7\:n20 VSS) capacitor c=5.86263e-17
C156 (\5\:E VSS) capacitor c=3.05792e-17
C157 (\2\:D VSS) capacitor c=1.43486e-17
C158 (\13\:CKbb VSS) capacitor c=7.44355e-17
C159 (\14\:CKbb VSS) capacitor c=7.73877e-17
C160 (\15\:CKbb VSS) capacitor c=1.07005e-16
C161 (\16\:CKbb VSS) capacitor c=8.3966e-17
C162 (\17\:CKbb VSS) capacitor c=7.4181e-17
C163 (\12\:CKb VSS) capacitor c=7.20972e-17
C164 (\13\:CKb VSS) capacitor c=5.95718e-17
C165 (\4\:SI VSS) capacitor c=3.97247e-17
C166 (\6\:SI VSS) capacitor c=4.66197e-17
C167 (\8\:SE VSS) capacitor c=8.15745e-17
C168 (\9\:SE VSS) capacitor c=8.50443e-17
C169 (\5\:Dpb VSS) capacitor c=2.57207e-16
C170 (\5\:SEb VSS) capacitor c=1.17536e-16
C171 (\10\:SEb VSS) capacitor c=9.1974e-17
C172 (\4\:RN VSS) capacitor c=7.19295e-17
C173 (\4\:RNb VSS) capacitor c=6.27693e-17
C174 (\5\:RNb VSS) capacitor c=6.48936e-17
C175 (\13\:qbint VSS) capacitor c=9.0298e-17
C176 (\14\:qbint VSS) capacitor c=4.6283e-16
C177 (\15\:qbint VSS) capacitor c=4.68536e-16
C178 (\18\:qbint VSS) capacitor c=2.05984e-17
C179 (\21\:qbint VSS) capacitor c=2.69402e-17
C180 (\6\:Dp VSS) capacitor c=9.39588e-17
C181 (\7\:Dp VSS) capacitor c=1.33682e-16
C182 (\10\:Dp VSS) capacitor c=1.81878e-16
C183 (\8\:E VSS) capacitor c=4.05039e-17
C184 (\9\:E VSS) capacitor c=2.93775e-17
C185 (\10\:E VSS) capacitor c=2.69337e-17
C186 (\9\:Eb VSS) capacitor c=1.20107e-16
C187 (\5\:D VSS) capacitor c=5.66202e-17
C188 (\6\:Db VSS) capacitor c=9.25733e-17
C189 (\8\:VDD VSS) capacitor c=4.39889e-17
C190 (\11\:VDD VSS) capacitor c=4.02749e-17
C191 (\15\:VDD VSS) capacitor c=3.95667e-17
C192 (\18\:VDD VSS) capacitor c=5.65659e-17
C193 (\22\:VDD VSS) capacitor c=1.11894e-17
C194 (\25\:VDD VSS) capacitor c=1.09064e-17
Rk62 (D \5\:D) resistor r=0.1492 c=0
Rk37 (Q \2\:Q) resistor r=0.2127 c=0
Rk38 (Q \4\:Q) resistor r=0.1294 c=0
Rk29 (\9\:SE SE) resistor r=0.08774 c=0
Rk28 (\8\:SE \9\:SE) resistor r=0.5266 c=0
Rk59 (\9\:E E) resistor r=0.002661 c=0
Rk57 (\8\:E \9\:E) resistor r=0.1468 c=0
Rk58 (\9\:E \10\:E) resistor r=0.06555 c=0
Rk25 (\4\:SI \5\:SI) resistor r=0.007126 c=0
Rk26 (SI \6\:SI) resistor r=0.006968 c=0
Rk27 (\4\:SI \6\:SI) resistor r=0.01584 c=0
Rk65 (\2\:VDD \4\:VDD) resistor r=0.1325 c=0
Rk66 (\4\:VDD \5\:VDD) resistor r=0.8029 c=0
Rk67 (\5\:VDD \7\:VDD) resistor r=0.1208 c=0
Rk68 (\5\:VDD \8\:VDD) resistor r=0.416 c=0
Rk69 (\8\:VDD \10\:VDD) resistor r=0.04334 c=0
Rk70 (\8\:VDD \11\:VDD) resistor r=0.4594 c=0
Rk71 (\11\:VDD \13\:VDD) resistor r=0.04334 c=0
Rk72 (\11\:VDD \14\:VDD) resistor r=0.325 c=0
Rk73 (\14\:VDD \15\:VDD) resistor r=0.2021 c=0
Rk74 (\15\:VDD \17\:VDD) resistor r=0.04334 c=0
Rk75 (\15\:VDD \18\:VDD) resistor r=0.5933 c=0
Rk76 (\18\:VDD \20\:VDD) resistor r=0.3051 c=0
Rk77 (\18\:VDD \21\:VDD) resistor r=0.4063 c=0
Rk78 (\21\:VDD \22\:VDD) resistor r=0.1077 c=0
Rk79 (\22\:VDD \24\:VDD) resistor r=0.1914 c=0
Rk82 (\25\:VDD VDD) resistor r=0.12 c=0
Rk80 (\22\:VDD \25\:VDD) resistor r=0.3233 c=0
Rk81 (\25\:VDD \27\:VDD) resistor r=0.1031 c=0
Rk39 (RN \4\:RN) resistor r=0.03526 c=0
Rk83 (\2\:VSS \4\:VSS) resistor r=0.4131 c=0
Rk84 (\4\:VSS \5\:VSS) resistor r=0.3536 c=0
Rk85 (\5\:VSS \6\:VSS) resistor r=0.1426 c=0
Rk86 (\6\:VSS \7\:VSS) resistor r=0.248 c=0
Rk87 (\7\:VSS \8\:VSS) resistor r=0.05751 c=0
Rk88 (\8\:VSS \9\:VSS) resistor r=0.4163 c=0
Rk89 (\9\:VSS \10\:VSS) resistor r=0.4763 c=0
Rk90 (\10\:VSS \11\:VSS) resistor r=0.3109 c=0
Rk91 (\11\:VSS \12\:VSS) resistor r=0.2181 c=0
Rk92 (\12\:VSS \13\:VSS) resistor r=0.5792 c=0
Rk93 (\13\:VSS \14\:VSS) resistor r=0.4063 c=0
Rk94 (\14\:VSS \15\:VSS) resistor r=0.1227 c=0
Rk96 (\16\:VSS VSS) resistor r=0.12 c=0
Rk95 (\15\:VSS \16\:VSS) resistor r=0.3082 c=0
Rk97 (\5\:VSS \18\:VSS) resistor r=0.1903 c=0
Rk98 (\6\:VSS \20\:VSS) resistor r=0.1903 c=0
Rk99 (\7\:VSS \22\:VSS) resistor r=0.3206 c=0
Rk100 (\9\:VSS \24\:VSS) resistor r=0.2801 c=0
Rk101 (\10\:VSS \26\:VSS) resistor r=0.1735 c=0
Rk102 (\12\:VSS \28\:VSS) resistor r=0.2623 c=0
Rk103 (\13\:VSS \30\:VSS) resistor r=0.1433 c=0
Rk104 (\15\:VSS \32\:VSS) resistor r=0.3666 c=0
Rk105 (\16\:VSS \34\:VSS) resistor r=0.3818 c=0
Rk2 (\4\:QN QN) resistor r=0.05602 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2328 c=0
Rk21 (\4\:CK CK) resistor r=0.006094 c=0
Rk3 (\6\:net582 \7\:net582) resistor r=0.115 c=0
Rk4 (\7\:net582 \8\:net582) resistor r=0.1197 c=0
Rk5 (\7\:net582 \10\:net582) resistor r=0.109 c=0
Rk43 (\13\:qbint \14\:qbint) resistor r=0.6255 c=0
Rk44 (\14\:qbint \15\:qbint) resistor r=3.4274 c=0
Rk45 (\15\:qbint \17\:qbint) resistor r=0.3782 c=0
Rk46 (\15\:qbint \18\:qbint) resistor r=0.03527 c=0
Rk47 (\17\:qbint \20\:qbint) resistor r=0.4621 c=0
Rk48 (\17\:qbint \21\:qbint) resistor r=0.1956 c=0
Rk6 (\5\:n30 \6\:n30) resistor r=0.3399 c=0
Rk7 (\6\:n30 \7\:n30) resistor r=0.4388 c=0
Rk8 (\6\:n30 \9\:n30) resistor r=0.05922 c=0
Rk22 (\11\:CKb \12\:CKb) resistor r=0.3939 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.3157 c=0
Rk24 (\12\:CKb \15\:CKb) resistor r=0.2238 c=0
Rk9 (\4\:mout \5\:mout) resistor r=0.3392 c=0
Rk10 (\5\:mout \7\:mout) resistor r=0.2603 c=0
Rk11 (\5\:mout \9\:mout) resistor r=0.1853 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.4342 c=0
Rk16 (\12\:CKbb \13\:CKbb) resistor r=0.2754 c=0
Rk17 (\13\:CKbb \14\:CKbb) resistor r=0.2112 c=0
Rk18 (\14\:CKbb \15\:CKbb) resistor r=0.4637 c=0
Rk19 (\15\:CKbb \16\:CKbb) resistor r=0.5537 c=0
Rk20 (\13\:CKbb \17\:CKbb) resistor r=0.4255 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2987 c=0
Rk13 (\6\:n20 \7\:n20) resistor r=0.31 c=0
Rk14 (\6\:n20 \9\:n20) resistor r=0.1284 c=0
Rk30 (\2\:Dpb \4\:Dpb) resistor r=0.5786 c=0
Rk31 (\4\:Dpb \5\:Dpb) resistor r=1.7445 c=0
Rk32 (\5\:Dpb \7\:Dpb) resistor r=0.4659 c=0
Rk33 (\5\:Dpb \9\:Dpb) resistor r=0.09047 c=0
Rk34 (\5\:SEb \7\:SEb) resistor r=0.8068 c=0
Rk35 (\7\:SEb \9\:SEb) resistor r=0.9062 c=0
Rk36 (\9\:SEb \10\:SEb) resistor r=0.5606 c=0
Rk51 (\5\:Dp \6\:Dp) resistor r=0.3165 c=0
Rk52 (\6\:Dp \7\:Dp) resistor r=0.6342 c=0
Rk53 (\7\:Dp \9\:Dp) resistor r=0.08336 c=0
Rk54 (\9\:Dp \10\:Dp) resistor r=1.5293 c=0
Rk55 (\6\:Dp \12\:Dp) resistor r=0.05709 c=0
Rk56 (\7\:Dp \14\:Dp) resistor r=0.678 c=0
Rk40 (\4\:RNb \5\:RNb) resistor r=0.28 c=0
Rk41 (\5\:RNb \7\:RNb) resistor r=0.2472 c=0
Rk42 (\5\:RNb \9\:RNb) resistor r=0.2342 c=0
Rk60 (\6\:Eb \8\:Eb) resistor r=0.3209 c=0
Rk61 (\8\:Eb \9\:Eb) resistor r=0.7042 c=0
Rk63 (\5\:Db \6\:Db) resistor r=0.7564 c=0
Rk64 (\5\:Db \8\:Db) resistor r=0.2759 c=0
Rk49 (\2\:net493 \4\:net493) resistor r=0.333 c=0
Rk50 (\2\:net505 \4\:net505) resistor r=0.5298 c=0
Rl57 (\1\:D \2\:D) resistor r=43.9449 c=0
Rl59 (\2\:D \4\:D) resistor r=47.791 c=0
Rl58 (\2\:D \3\:D) resistor r=1.2666 c=0
Rl34 (\5\:SE \6\:SE) resistor r=94.2308 c=0
Rl35 (\6\:SE \7\:SE) resistor r=39.5604 c=0
Rl28 (\1\:SE \2\:SE) resistor r=100.803 c=0
Rl30 (\2\:SE \4\:SE) resistor r=46.9565 c=0
Rl29 (\2\:SE \3\:SE) resistor r=3.1183 c=0
Rl51 (\2\:E \3\:E) resistor r=84.5926 c=0
Rl50 (\1\:E \2\:E) resistor r=134.41 c=0
Rl54 (\4\:E \5\:E) resistor r=55.0028 c=0
Rl56 (\5\:E \7\:E) resistor r=41.5412 c=0
Rl55 (\5\:E \6\:E) resistor r=75.3733 c=0
Rl31 (\1\:SI \2\:SI) resistor r=30.0021 c=0
Rl32 (\2\:SI \3\:SI) resistor r=99.2328 c=0
Rl42 (\2\:RN \3\:RN) resistor r=30.2198 c=0
Rl41 (\1\:RN \2\:RN) resistor r=140.385 c=0
Rl26 (\1\:CK \2\:CK) resistor r=24.2328 c=0
Rl27 (\2\:CK \3\:CK) resistor r=101.156 c=0
Rl3 (\2\:net582 \4\:net582) resistor r=47.791 c=0
Rl2 (\2\:net582 \3\:net582) resistor r=36.2526 c=0
Rl1 (net582 \2\:net582) resistor r=2.0213 c=0
Rl45 (\10\:qbint \11\:qbint) resistor r=211.104 c=0
Rl39 (\7\:qbint \8\:qbint) resistor r=157.692 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=167.308 c=0
Rl4 (qbint \2\:qbint) resistor r=92.3077 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=32.908 c=0
Rl40 (\7\:qbint \9\:qbint) resistor r=80.0021 c=0
Rl9 (\4\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl5 (qbint \3\:qbint) resistor r=24.2328 c=0
Rl6 (n30 \2\:n30) resistor r=33.8482 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=105.002 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=403.412 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=39.1533 c=0
Rl18 (CKb \2\:CKb) resistor r=53.0797 c=0
Rl23 (\2\:CKb \7\:CKb) resistor r=32.6176 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=195.697 c=0
Rl25 (\3\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=221.992 c=0
Rl14 (mout \2\:mout) resistor r=50.6918 c=0
Rl15 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=62.9746 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl10 (CKbb \2\:CKbb) resistor r=64.6174 c=0
Rl12 (n20 \2\:n20) resistor r=112.23 c=0
Rl13 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=51.1559 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (Dp \2\:Dp) resistor r=103.079 c=0
Rl38 (\2\:Dp \3\:Dp) resistor r=26.1559 c=0
Rl44 (\2\:RNb \3\:RNb) resistor r=89.6174 c=0
Rl43 (RNb \2\:RNb) resistor r=93.0292 c=0
Rl49 (\2\:Eb \4\:Eb) resistor r=151.637 c=0
Rl48 (\2\:Eb \3\:Eb) resistor r=34.3295 c=0
Rl47 (Eb \2\:Eb) resistor r=5.915 c=0
Rl52 (Db \2\:Db) resistor r=240.385 c=0
Rl53 (Db \3\:Db) resistor r=24.2328 c=0
Rz11 (\3\:Q \4\:Q) resistor r=75 c=0
Rz18 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz19 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz20 (\3\:VDD \14\:VDD) resistor r=6.25 c=0
Rz21 (\3\:VDD \21\:VDD) resistor r=6.25 c=0
Rz22 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz28 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz29 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz30 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz31 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\9\:net582 \10\:net582) resistor r=75 c=0
Rz13 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dpb \2\:Dpb) resistor r=75 c=0
Rz9 (\6\:Dpb \7\:Dpb) resistor r=75 c=0
Rz10 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz14 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz12 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz16 (\7\:Eb \8\:Eb) resistor r=75 c=0
Rz17 (\7\:Db \8\:Db) resistor r=75 c=0
Ry11 (\1\:Q \2\:Q) resistor r=62 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry24 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry25 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry26 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry27 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry29 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry30 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry31 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry32 (\3\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry33 (\3\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry2 (\5\:net582 \6\:net582) resistor r=62 c=0
Ry13 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Dpb \4\:Dpb) resistor r=62 c=0
Ry9 (\8\:Dpb \9\:Dpb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry12 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry20 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry21 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx26 (\3\:D \5\:D) resistor r=45 c=0
Rx12 (\6\:SE \8\:SE) resistor r=45 c=0
Rx13 (\3\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:E \8\:E) resistor r=45 c=0
Rx24 (\2\:E \10\:E) resistor r=45 c=0
Rx11 (\2\:SI \5\:SI) resistor r=45 c=0
Rx16 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (net582 \8\:net582) resistor r=45 c=0
Rx18 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx19 (\9\:qbint \14\:qbint) resistor r=45 c=0
Rx20 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx21 (\3\:qbint \21\:qbint) resistor r=45 c=0
Rx2 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:mout \4\:mout) resistor r=45 c=0
Rx5 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\7\:CKbb \17\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx15 (\2\:SEb \10\:SEb) resistor r=45 c=0
Rx22 (\2\:Dp \10\:Dp) resistor r=45 c=0
Rx17 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx25 (Eb \9\:Eb) resistor r=45 c=0
Rx27 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:net582 \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net582 \2\:qbint \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint \3\:n30 \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.895e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \5\:qbint \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.61e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\4\:n30 \6\:CKb net618 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.425e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\4\:n30 \3\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=3.988e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net606 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:n20 \9\:CKb \6\:Dpb VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.9e-14 ps=8.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\11\:CKbb \8\:CKb \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn20 (\14\:CKb \3\:CK \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn10 (\6\:SEb \4\:SE \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net658 \3\:SI \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=3.915e-14 ps=9.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.145e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Dpb \7\:SE net658 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=8.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Dpb \3\:SEb net650 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=6.25e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net650 \3\:Dp \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.305e-14 ps=7.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.9e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn55 (\3\:Q \8\:qbint \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=2.25e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn2 (\8\:RNb \1\:RN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=3.408e-14 ps=7.7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=7.75e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn3 (\8\:Dp RNb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.9e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn5 (\8\:Dp \10\:qbint net634 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.85e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn4 (net634 \3\:Eb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=1.015e-14 ps=9.6e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn6 (net638 \1\:E \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn7 (\13\:Dp \2\:Db net638 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\7\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \4\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends SEDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:21 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFX1
// View name: extracted

simulator lang=spectre

subckt SEDFFX1 CK D E Q QN SE SI VDD VSS
mp0 (\8\:Eb \1\:E \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52e-06 sd=160n sca=16.022 \
        scb=0.0154303 scc=0.000486038 m=(1)
mp3 (net473 \1\:D \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.118e-13 ps=7.5e-07 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.315e-06 sd=160n sca=14.0018 \
        scb=0.0126046 scc=0.00046222 m=(1)
mp4 (\5\:Db Eb net473 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=5.697e-14 ps=1.47e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=7.5e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp2 (\5\:Db \6\:E net425 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.697e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=4.4e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp1 (net425 \6\:net502 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.515e-14 ad=1.29e-14 ps=1.9e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=3.35e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp56 (\7\:net502 \2\:net536 \15\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp10 (\9\:SEb \7\:SE \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp11 (\5\:Dbp \6\:SE \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.15e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp13 (\5\:Dbp \3\:SEb net465 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.257e-14 ad=4.515e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=6.6e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp12 (net465 \1\:SI \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1447e-13 ad=2.257e-14 ps=1.9e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=5.1e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp45 (\13\:net536 n30 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net457 \10\:net536 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=2.902e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.655e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 CKbb net457 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.475e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.277e-14 ad=3.44e-14 ps=1.2e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.27e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\4\:mout \4\:n20 \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.312e-14 ad=8.277e-14 ps=1.67e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net437 \3\:mout \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.312e-14 ad=1.29e-14 ps=1.67e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=6.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\9\:n20 \4\:CKb net437 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.483e-14 ps=5.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=5.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\9\:n20 \5\:CKbb Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=5.483e-14 ps=8.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\8\:CKbb \6\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.268e-14 ad=3.655e-14 ps=9.2e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.3e-07 sd=160n sca=12.2638 \
        scb=0.00952133 scc=0.000140215 m=(1)
mp20 (\16\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.268e-14 ad=3.01e-14 ps=9.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=18.3227 \
        scb=0.0195692 scc=0.000509714 m=(1)
C1 (E VSS) capacitor c=5.13837e-17
C2 (D VSS) capacitor c=6.66241e-17
C3 (Q VSS) capacitor c=4.0687e-17
C4 (SI VSS) capacitor c=8.1122e-17
C5 (QN VSS) capacitor c=2.50379e-17
C6 (VDD VSS) capacitor c=5.17887e-16
C7 (SE VSS) capacitor c=6.8718e-17
C8 (Eb VSS) capacitor c=2.12312e-17
C9 (net554 VSS) capacitor c=1.71389e-18
C10 (Db VSS) capacitor c=8.4107e-17
C11 (net514 VSS) capacitor c=2.23071e-18
C12 (net502 VSS) capacitor c=3.86146e-17
C13 (net536 VSS) capacitor c=2.65992e-17
C14 (SEb VSS) capacitor c=4.07552e-17
C15 (Dbp VSS) capacitor c=8.30433e-17
C16 (net546 VSS) capacitor c=1.34803e-18
C17 (n30 VSS) capacitor c=3.32908e-17
C18 (CKb VSS) capacitor c=7.98198e-17
C19 (mout VSS) capacitor c=3.06323e-17
C20 (CKbb VSS) capacitor c=4.77837e-17
C21 (n20 VSS) capacitor c=2.49961e-17
C22 (net526 VSS) capacitor c=5.54575e-19
C23 (net473 VSS) capacitor c=1.23721e-17
C24 (net425 VSS) capacitor c=2.76038e-18
C25 (net465 VSS) capacitor c=3.19593e-18
C26 (net457 VSS) capacitor c=4.15529e-18
C27 (net437 VSS) capacitor c=7.65789e-19
C28 (\1\:CK VSS) capacitor c=3.22442e-17
C29 (\6\:CKb VSS) capacitor c=3.42479e-17
C30 (\5\:CKbb VSS) capacitor c=2.81313e-17
C31 (\4\:CKb VSS) capacitor c=6.39019e-17
C32 (\3\:mout VSS) capacitor c=9.0918e-17
C33 (\4\:n20 VSS) capacitor c=3.74224e-17
C34 (\2\:CKb VSS) capacitor c=5.85947e-17
C35 (\10\:net536 VSS) capacitor c=5.45928e-17
C36 (\4\:net536 VSS) capacitor c=3.82451e-17
C37 (\1\:SI VSS) capacitor c=5.5184e-17
C38 (\3\:SEb VSS) capacitor c=5.06259e-17
C39 (\6\:SE VSS) capacitor c=3.88605e-17
C40 (\7\:SE VSS) capacitor c=3.01388e-17
C41 (\2\:net536 VSS) capacitor c=4.35175e-17
C42 (\6\:net502 VSS) capacitor c=5.85386e-17
C43 (\6\:E VSS) capacitor c=5.8201e-17
C44 (\1\:D VSS) capacitor c=3.55525e-17
C45 (\1\:E VSS) capacitor c=4.29513e-17
C46 (\3\:CK VSS) capacitor c=3.77169e-17
C47 (\9\:CKb VSS) capacitor c=2.45828e-17
C48 (\8\:CKb VSS) capacitor c=4.887e-17
C49 (\7\:CKbb VSS) capacitor c=4.40101e-17
C50 (\3\:n20 VSS) capacitor c=4.16962e-17
C51 (\3\:CKbb VSS) capacitor c=4.40601e-17
C52 (\7\:net536 VSS) capacitor c=4.0966e-17
C53 (\3\:n30 VSS) capacitor c=4.10521e-17
C54 (\6\:net536 VSS) capacitor c=3.23398e-17
C55 (\3\:SI VSS) capacitor c=3.07582e-17
C56 (\1\:SE VSS) capacitor c=5.66604e-17
C57 (\5\:SE VSS) capacitor c=2.9422e-17
C58 (\3\:net536 VSS) capacitor c=4.46209e-17
C59 (\5\:net502 VSS) capacitor c=2.38414e-17
C60 (\4\:net502 VSS) capacitor c=4.20951e-17
C61 (\3\:Eb VSS) capacitor c=5.71646e-17
C62 (\4\:E VSS) capacitor c=4.22642e-17
C63 (\3\:D VSS) capacitor c=2.98342e-17
C64 (\3\:E VSS) capacitor c=2.25018e-17
C65 (\2\:CK VSS) capacitor c=4.06934e-17
C66 (\7\:CKb VSS) capacitor c=4.56802e-17
C67 (\6\:CKbb VSS) capacitor c=3.55678e-17
C68 (\5\:CKb VSS) capacitor c=2.91627e-17
C69 (\2\:mout VSS) capacitor c=4.74187e-17
C70 (\4\:CKbb VSS) capacitor c=3.5053e-17
C71 (\3\:CKb VSS) capacitor c=2.4236e-17
C72 (\2\:CKbb VSS) capacitor c=4.72184e-17
C73 (\9\:net536 VSS) capacitor c=3.20445e-17
C74 (\2\:n30 VSS) capacitor c=3.29343e-17
C75 (\5\:net536 VSS) capacitor c=2.4645e-17
C76 (\2\:SI VSS) capacitor c=4.50535e-17
C77 (\4\:SEb VSS) capacitor c=3.63536e-17
C78 (\2\:SEb VSS) capacitor c=2.29214e-17
C79 (\4\:SE VSS) capacitor c=2.51699e-17
C80 (\7\:E VSS) capacitor c=5.28516e-17
C81 (\2\:Eb VSS) capacitor c=3.35359e-17
C82 (\5\:E VSS) capacitor c=3.06021e-17
C83 (\2\:D VSS) capacitor c=4.22305e-17
C84 (\2\:E VSS) capacitor c=4.01242e-17
C85 (\16\:CKb VSS) capacitor c=4.77727e-17
C86 (\1\:VDD VSS) capacitor c=6.48177e-17
C87 (\8\:CKbb VSS) capacitor c=1.10687e-16
C88 (\9\:n20 VSS) capacitor c=3.85251e-17
C89 (\8\:VDD VSS) capacitor c=2.49515e-17
C90 (\4\:mout VSS) capacitor c=6.17217e-17
C91 (\4\:n30 VSS) capacitor c=3.68892e-17
C92 (\10\:VDD VSS) capacitor c=4.76013e-18
C93 (\13\:net536 VSS) capacitor c=5.78472e-17
C94 (\1\:Q VSS) capacitor c=5.75213e-17
C95 (\12\:VDD VSS) capacitor c=3.14811e-17
C96 (\5\:Dbp VSS) capacitor c=4.70991e-16
C97 (\3\:Db VSS) capacitor c=2.0629e-16
C98 (\9\:SEb VSS) capacitor c=6.3206e-17
C99 (\15\:VDD VSS) capacitor c=3.05262e-17
C100 (\7\:net502 VSS) capacitor c=5.72796e-17
C101 (\3\:QN VSS) capacitor c=3.52393e-17
C102 (\18\:VDD VSS) capacitor c=9.71576e-18
C103 (\5\:Db VSS) capacitor c=1.43505e-16
C104 (\22\:VDD VSS) capacitor c=3.63784e-17
C105 (\8\:Eb VSS) capacitor c=6.86844e-18
C106 (\3\:VDD VSS) capacitor c=1.39446e-16
C107 (\10\:CKb VSS) capacitor c=5.14484e-17
C108 (\13\:CKbb VSS) capacitor c=8.85058e-17
C109 (\3\:Dbp VSS) capacitor c=3.4925e-16
C110 (\5\:n20 VSS) capacitor c=6.31976e-17
C111 (\7\:mout VSS) capacitor c=4.98293e-17
C112 (\8\:n30 VSS) capacitor c=7.32602e-17
C113 (\15\:net536 VSS) capacitor c=3.39432e-17
C114 (\3\:Q VSS) capacitor c=4.70394e-17
C115 (\7\:Dbp VSS) capacitor c=1.00203e-16
C116 (\7\:SEb VSS) capacitor c=1.05832e-16
C117 (\9\:net502 VSS) capacitor c=1.26327e-16
C118 (\1\:QN VSS) capacitor c=7.74856e-17
C119 (\7\:Db VSS) capacitor c=1.12045e-16
C120 (\6\:Eb VSS) capacitor c=6.08043e-17
C121 (\3\:net502 VSS) capacitor c=4.88613e-17
C122 (\2\:SE VSS) capacitor c=5.53706e-17
C123 (\3\:SE VSS) capacitor c=1.85455e-17
C124 (\8\:net536 VSS) capacitor c=2.91532e-17
C125 (\2\:n20 VSS) capacitor c=2.33668e-17
C126 (\4\:D VSS) capacitor c=4.86976e-17
C127 (\4\:Eb VSS) capacitor c=9.14934e-17
C128 (\5\:Eb VSS) capacitor c=1.21281e-16
C129 (\8\:E VSS) capacitor c=1.43597e-16
C130 (\9\:E VSS) capacitor c=1.27903e-16
C131 (\10\:E VSS) capacitor c=5.54977e-17
C132 (\11\:E VSS) capacitor c=1.74903e-17
C133 (\11\:net502 VSS) capacitor c=9.67247e-17
C134 (\8\:SE VSS) capacitor c=4.82405e-17
C135 (\5\:SEb VSS) capacitor c=1.31673e-16
C136 (\6\:SEb VSS) capacitor c=1.10311e-16
C137 (\4\:SI VSS) capacitor c=6.37328e-17
C138 (\11\:net536 VSS) capacitor c=4.95001e-17
C139 (\12\:net536 VSS) capacitor c=3.22052e-17
C140 (\17\:net536 VSS) capacitor c=2.01241e-16
C141 (\18\:net536 VSS) capacitor c=8.87177e-17
C142 (\19\:net536 VSS) capacitor c=1.67899e-16
C143 (\6\:n30 VSS) capacitor c=7.63688e-17
C144 (\7\:n30 VSS) capacitor c=3.81889e-17
C145 (\6\:mout VSS) capacitor c=4.75601e-17
C146 (\9\:mout VSS) capacitor c=4.18043e-17
C147 (\7\:n20 VSS) capacitor c=5.62522e-17
C148 (\8\:n20 VSS) capacitor c=4.74788e-17
C149 (\10\:CKbb VSS) capacitor c=1.6655e-16
C150 (\11\:CKbb VSS) capacitor c=1.32954e-16
C151 (\12\:CKbb VSS) capacitor c=4.73654e-17
C152 (\15\:CKbb VSS) capacitor c=6.39384e-17
C153 (\16\:CKbb VSS) capacitor c=2.5137e-17
C154 (\12\:CKb VSS) capacitor c=5.8066e-17
C155 (\13\:CKb VSS) capacitor c=1.33786e-16
C156 (\14\:CKb VSS) capacitor c=1.90346e-16
C157 (\15\:CKb VSS) capacitor c=7.75008e-17
C158 (\4\:CK VSS) capacitor c=7.21437e-17
C159 (\5\:VDD VSS) capacitor c=4.36573e-17
C160 (\6\:VDD VSS) capacitor c=3.32647e-17
C161 (\14\:VDD VSS) capacitor c=5.8282e-17
C162 (\17\:VDD VSS) capacitor c=1.94969e-17
C163 (\21\:VDD VSS) capacitor c=1.19724e-17
Rk5 (\8\:E \9\:E) resistor r=0.9926 c=0
Rk8 (\10\:E E) resistor r=0.1492 c=0
Rk6 (\9\:E \10\:E) resistor r=0.3882 c=0
Rk7 (\9\:E \11\:E) resistor r=0.06914 c=0
Rk54 (\4\:CK CK) resistor r=0.003489 c=0
Rk1 (\4\:D D) resistor r=0.04288 c=0
Rk23 (\2\:Q Q) resistor r=0.3201 c=0
Rk24 (Q \4\:Q) resistor r=0.01422 c=0
Rk22 (\4\:SI SI) resistor r=0.03603 c=0
Rk9 (\2\:QN QN) resistor r=0.1748 c=0
Rk10 (QN \4\:QN) resistor r=0.05862 c=0
Rk55 (\2\:VDD \4\:VDD) resistor r=0.627 c=0
Rk56 (\4\:VDD \5\:VDD) resistor r=0.2722 c=0
Rk57 (\5\:VDD \6\:VDD) resistor r=0.5052 c=0
Rk58 (\6\:VDD \7\:VDD) resistor r=0.3735 c=0
Rk59 (\5\:VDD \9\:VDD) resistor r=0.04331 c=0
Rk60 (\6\:VDD \11\:VDD) resistor r=0.07393 c=0
Rk61 (\7\:VDD \13\:VDD) resistor r=0.07147 c=0
Rk62 (\7\:VDD \14\:VDD) resistor r=0.6245 c=0
Rk63 (\14\:VDD \16\:VDD) resistor r=0.04331 c=0
Rk64 (\14\:VDD \17\:VDD) resistor r=0.3347 c=0
Rk65 (\17\:VDD \19\:VDD) resistor r=0.07393 c=0
Rk66 (\17\:VDD \20\:VDD) resistor r=0.2431 c=0
Rk69 (\21\:VDD VDD) resistor r=0.2052 c=0
Rk67 (\20\:VDD \21\:VDD) resistor r=0.3459 c=0
Rk68 (\21\:VDD \23\:VDD) resistor r=0.2998 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.6147 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.2531 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.4937 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.4061 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.1277 c=0
Rk75 (\8\:VSS \9\:VSS) resistor r=0.5313 c=0
Rk76 (\9\:VSS \10\:VSS) resistor r=0.3858 c=0
Rk77 (\10\:VSS \11\:VSS) resistor r=0.1578 c=0
Rk79 (\12\:VSS VSS) resistor r=0.2077 c=0
Rk78 (\11\:VSS \12\:VSS) resistor r=0.3434 c=0
Rk80 (\5\:VSS \14\:VSS) resistor r=0.1026 c=0
Rk81 (\6\:VSS \16\:VSS) resistor r=0.1394 c=0
Rk82 (\8\:VSS \18\:VSS) resistor r=0.3153 c=0
Rk83 (\9\:VSS \20\:VSS) resistor r=0.4072 c=0
Rk84 (\10\:VSS \22\:VSS) resistor r=0.07393 c=0
Rk85 (\12\:VSS \24\:VSS) resistor r=0.3265 c=0
Rk13 (\8\:SE SE) resistor r=0.1657 c=0
Rk2 (\4\:Eb \5\:Eb) resistor r=0.6772 c=0
Rk3 (\5\:Eb \7\:Eb) resistor r=0.5904 c=0
Rk4 (\5\:Eb \9\:Eb) resistor r=0.0279 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.4458 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.0612 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.6549 c=0
Rk11 (\8\:net502 \10\:net502) resistor r=0.3754 c=0
Rk12 (\10\:net502 \11\:net502) resistor r=0.7331 c=0
Rk25 (\11\:net536 \12\:net536) resistor r=0.2184 c=0
Rk26 (\12\:net536 \14\:net536) resistor r=0.2868 c=0
Rk27 (\12\:net536 \16\:net536) resistor r=0.113 c=0
Rk28 (\14\:net536 \17\:net536) resistor r=0.5458 c=0
Rk29 (\17\:net536 \18\:net536) resistor r=0.4008 c=0
Rk30 (\17\:net536 \19\:net536) resistor r=1.1952 c=0
Rk17 (\5\:SEb \6\:SEb) resistor r=0.7733 c=0
Rk18 (\6\:SEb \8\:SEb) resistor r=0.5479 c=0
Rk19 (\8\:SEb \10\:SEb) resistor r=0.3959 c=0
Rk40 (\2\:Dbp \4\:Dbp) resistor r=0.4348 c=0
Rk41 (\4\:Dbp \6\:Dbp) resistor r=2.9427 c=0
Rk42 (\6\:Dbp \8\:Dbp) resistor r=0.5103 c=0
Rk31 (\5\:n30 \6\:n30) resistor r=0.2997 c=0
Rk32 (\6\:n30 \7\:n30) resistor r=0.1939 c=0
Rk33 (\6\:n30 \9\:n30) resistor r=0.3909 c=0
Rk49 (\11\:CKb \12\:CKb) resistor r=0.3029 c=0
Rk50 (\12\:CKb \13\:CKb) resistor r=0.3287 c=0
Rk51 (\13\:CKb \14\:CKb) resistor r=0.8845 c=0
Rk52 (\14\:CKb \15\:CKb) resistor r=0.6047 c=0
Rk53 (\13\:CKb \17\:CKb) resistor r=0.2656 c=0
Rk34 (\5\:mout \6\:mout) resistor r=0.2678 c=0
Rk35 (\6\:mout \8\:mout) resistor r=0.1953 c=0
Rk36 (\6\:mout \9\:mout) resistor r=0.2352 c=0
Rk43 (\9\:CKbb \10\:CKbb) resistor r=0.3552 c=0
Rk44 (\10\:CKbb \11\:CKbb) resistor r=1.0417 c=0
Rk45 (\11\:CKbb \12\:CKbb) resistor r=0.1564 c=0
Rk46 (\9\:CKbb \14\:CKbb) resistor r=0.577 c=0
Rk47 (\10\:CKbb \15\:CKbb) resistor r=0.2519 c=0
Rk48 (\11\:CKbb \16\:CKbb) resistor r=0.04992 c=0
Rk37 (\6\:n20 \7\:n20) resistor r=0.3364 c=0
Rk38 (\7\:n20 \8\:n20) resistor r=0.2811 c=0
Rk39 (\7\:n20 \10\:n20) resistor r=0.1242 c=0
Rl8 (\6\:E \7\:E) resistor r=71.8456 c=0
Rl5 (\4\:E \5\:E) resistor r=26.098 c=0
Rl1 (\1\:E \2\:E) resistor r=123.077 c=0
Rl2 (\2\:E \3\:E) resistor r=29.9451 c=0
Rl48 (\1\:CK \2\:CK) resistor r=101.923 c=0
Rl49 (\2\:CK \3\:CK) resistor r=101.099 c=0
Rl3 (\1\:D \2\:D) resistor r=73.7687 c=0
Rl4 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl24 (\1\:SI \2\:SI) resistor r=109.41 c=0
Rl25 (\2\:SI \3\:SI) resistor r=44.208 c=0
Rl20 (\4\:SE \5\:SE) resistor r=49.7951 c=0
Rl21 (\2\:SE \6\:SE) resistor r=93.9123 c=0
Rl17 (\1\:SE \2\:SE) resistor r=128.824 c=0
Rl22 (\3\:SE \7\:SE) resistor r=30.4507 c=0
Rl19 (\3\:SE \4\:SE) resistor r=11.9279 c=0
Rl18 (\2\:SE \3\:SE) resistor r=160.006 c=0
Rl6 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl7 (\2\:Eb \3\:Eb) resistor r=124.233 c=0
Rl9 (net502 \2\:net502) resistor r=81.3086 c=0
Rl12 (\2\:net502 \5\:net502) resistor r=37.8013 c=0
Rl13 (\3\:net502 \6\:net502) resistor r=118.925 c=0
Rl11 (\3\:net502 \4\:net502) resistor r=119.768 c=0
Rl10 (\2\:net502 \3\:net502) resistor r=5.848 c=0
Rl15 (\2\:net536 \3\:net536) resistor r=119.083 c=0
Rl26 (\4\:net536 \5\:net536) resistor r=24.7951 c=0
Rl27 (\5\:net536 \6\:net536) resistor r=69.6516 c=0
Rl14 (net536 \2\:net536) resistor r=77.6149 c=0
Rl32 (\8\:net536 \10\:net536) resistor r=99.6815 c=0
Rl30 (\7\:net536 \8\:net536) resistor r=74.9779 c=0
Rl31 (\8\:net536 \9\:net536) resistor r=32.6176 c=0
Rl23 (\3\:SEb \4\:SEb) resistor r=35.7713 c=0
Rl16 (SEb \2\:SEb) resistor r=98.7687 c=0
Rl28 (n30 \2\:n30) resistor r=41.5405 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=85.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=187.66 c=0
Rl45 (\6\:CKb \7\:CKb) resistor r=157.176 c=0
Rl47 (\7\:CKb \9\:CKb) resistor r=34.4104 c=0
Rl46 (\7\:CKb \8\:CKb) resistor r=192.285 c=0
Rl42 (\4\:CKb \5\:CKb) resistor r=62.2302 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=50.6918 c=0
Rl41 (\2\:mout \3\:mout) resistor r=101.099 c=0
Rl40 (mout \2\:mout) resistor r=30.7692 c=0
Rl43 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl44 (\6\:CKbb \7\:CKbb) resistor r=129.104 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=53.079 c=0
Rl33 (CKbb \2\:CKbb) resistor r=35.7134 c=0
Rl39 (\2\:n20 \4\:n20) resistor r=36.2526 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=111.253 c=0
Rl37 (n20 \2\:n20) resistor r=2.7713 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\1\:QN \2\:QN) resistor r=75 c=0
Rz16 (\3\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz17 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz18 (\3\:VDD \20\:VDD) resistor r=6.25 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz21 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz24 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz25 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz1 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz4 (Db \2\:Db) resistor r=75 c=0
Rz5 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:net502 \10\:net502) resistor r=75 c=0
Rz8 (\15\:net536 \16\:net536) resistor r=75 c=0
Rz6 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz12 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz13 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz9 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz15 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz10 (\7\:mout \8\:mout) resistor r=75 c=0
Rz14 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz11 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry7 (\1\:Q \2\:Q) resistor r=62 c=0
Ry2 (\3\:QN \4\:QN) resistor r=62 c=0
Ry16 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry17 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry18 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry19 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry20 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry21 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry24 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry25 (\3\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry4 (\3\:Db \4\:Db) resistor r=62 c=0
Ry5 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\7\:net502 \8\:net502) resistor r=62 c=0
Ry8 (\13\:net536 \14\:net536) resistor r=62 c=0
Ry6 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry12 (Dbp \2\:Dbp) resistor r=62 c=0
Ry13 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry15 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry10 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx3 (\7\:E \8\:E) resistor r=45 c=0
Rx4 (\2\:E \10\:E) resistor r=45 c=0
Rx5 (\5\:E \11\:E) resistor r=45 c=0
Rx23 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\4\:SE \8\:SE) resistor r=45 c=0
Rx2 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx6 (\2\:net502 \11\:net502) resistor r=45 c=0
Rx11 (\9\:net536 \11\:net536) resistor r=45 c=0
Rx12 (\5\:net536 \18\:net536) resistor r=45 c=0
Rx13 (net536 \19\:net536) resistor r=45 c=0
Rx8 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx9 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx14 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx22 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:mout \9\:mout) resistor r=45 c=0
Rx17 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx18 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx19 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx16 (n20 \8\:n20) resistor r=45 c=0
mn0 (\6\:Eb \3\:E \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.465e-14 ps=7.2e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.49e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (net554 \3\:D \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.567e-14 ps=7.2e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.23e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\7\:Db \4\:E net554 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=8.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\7\:Db \3\:Eb net514 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.32e-14 ps=5.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=6.65e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (net514 \4\:net502 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=1.885e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=4.9e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn56 (\9\:net502 \3\:net536 \19\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn10 (\7\:SEb \5\:SE \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn11 (Db SEb \7\:Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn13 (\7\:Dbp \1\:SE net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.32e-14 ps=4.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (net546 \3\:SI \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.355e-14 ad=1.378e-14 ps=1.13e-06 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.85e-07 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\15\:net536 \3\:n30 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.107e-14 ad=2.755e-14 ps=1.51e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.92e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn50 (net534 \7\:net536 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.107e-14 ad=1.522e-14 ps=1.51e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.56e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn51 (\8\:n30 CKb net534 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.537e-14 ps=5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.41e-06 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=4.422e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.19e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (\7\:mout \3\:n20 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.99e-14 ad=4.422e-14 ps=1.53e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=8.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn35 (net526 mout \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.99e-14 ad=2.682e-14 ps=1.53e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=5.75e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn36 (\5\:n20 \7\:CKbb net526 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=3.45e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn25 (\3\:Dbp \8\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn21 (\13\:CKbb \9\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\10\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn57 (\1\:QN \5\:net502 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=5.85e-14 ps=1.5e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75481e-07 sb=2.25e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn55 (\3\:Q \6\:net536 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.355e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.78462e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp57 (\3\:QN net502 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.515e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.82821e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp55 (\1\:Q \4\:net536 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1447e-13 ad=6.63e-14 ps=1.9e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.37244e-07 sb=1.7e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
ends SEDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:22 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFX2
// View name: extracted

simulator lang=spectre

subckt SEDFFX2 CK D E Q QN SE SI VDD VSS
mp55_1__rcx (\1\:Q net536 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.267e-14 ad=6.24e-14 ps=1.515e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.03205e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
mp57 (\3\:QN \3\:net502 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.896e-14 ad=6.24e-14 ps=1.625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40897e-07 sb=9.92244e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
C1 (E VSS) capacitor c=2.72527e-17
C2 (SI VSS) capacitor c=1.20881e-16
C3 (D VSS) capacitor c=4.66502e-17
C4 (VDD VSS) capacitor c=6.15623e-16
C5 (CK VSS) capacitor c=5.07892e-17
C6 (QN VSS) capacitor c=6.61745e-17
C7 (SE VSS) capacitor c=2.71625e-17
C8 (net536 VSS) capacitor c=1.32469e-16
C9 (n30 VSS) capacitor c=4.38861e-17
C10 (net534 VSS) capacitor c=7.06727e-19
C11 (CKb VSS) capacitor c=2.12795e-17
C12 (mout VSS) capacitor c=6.53592e-17
C13 (CKbb VSS) capacitor c=6.05994e-17
C14 (n20 VSS) capacitor c=4.9817e-17
C15 (Dbp VSS) capacitor c=1.02232e-16
C16 (net502 VSS) capacitor c=4.0915e-17
C17 (net546 VSS) capacitor c=2.28169e-18
C18 (Db VSS) capacitor c=9.04222e-17
C19 (SEb VSS) capacitor c=4.80241e-17
C20 (net514 VSS) capacitor c=1.93422e-18
C21 (Eb VSS) capacitor c=3.95431e-17
C22 (net457 VSS) capacitor c=8.85234e-19
C23 (net437 VSS) capacitor c=1.06974e-18
C24 (net465 VSS) capacitor c=5.22461e-19
C25 (net425 VSS) capacitor c=5.02212e-18
C26 (\5\:E VSS) capacitor c=3.91443e-17
C27 (\1\:D VSS) capacitor c=5.38226e-17
C28 (\1\:E VSS) capacitor c=5.20435e-17
C29 (\5\:SE VSS) capacitor c=3.31838e-17
C30 (\6\:SE VSS) capacitor c=4.03911e-17
C31 (\2\:SEb VSS) capacitor c=6.39862e-17
C32 (\1\:SI VSS) capacitor c=6.12623e-17
C33 (\1\:CK VSS) capacitor c=3.18242e-17
C34 (\11\:net536 VSS) capacitor c=6.29425e-17
C35 (\6\:CKb VSS) capacitor c=4.11422e-17
C36 (\7\:CKbb VSS) capacitor c=3.90404e-17
C37 (\7\:CKb VSS) capacitor c=1.52378e-16
C38 (\8\:CKb VSS) capacitor c=1.21243e-16
C39 (\9\:net536 VSS) capacitor c=4.54976e-17
C40 (\3\:n30 VSS) capacitor c=5.19643e-17
C41 (\7\:E VSS) capacitor c=2.15805e-17
C42 (\3\:D VSS) capacitor c=4.06524e-17
C43 (\3\:E VSS) capacitor c=5.02822e-17
C44 (\3\:Eb VSS) capacitor c=1.04678e-16
C45 (\6\:net502 VSS) capacitor c=5.34955e-17
C46 (\1\:SE VSS) capacitor c=3.83053e-17
C47 (\3\:SEb VSS) capacitor c=2.15493e-17
C48 (\4\:SE VSS) capacitor c=4.9197e-17
C49 (\4\:SI VSS) capacitor c=3.93335e-17
C50 (\3\:CK VSS) capacitor c=3.4692e-17
C51 (\13\:net536 VSS) capacitor c=3.35962e-17
C52 (\5\:CKb VSS) capacitor c=1.97839e-17
C53 (\5\:CKbb VSS) capacitor c=8.07977e-17
C54 (\3\:mout VSS) capacitor c=6.80828e-17
C55 (\3\:n20 VSS) capacitor c=3.10018e-17
C56 (\3\:CKbb VSS) capacitor c=5.82816e-17
C57 (\9\:CKb VSS) capacitor c=1.0604e-16
C58 (\8\:net536 VSS) capacitor c=8.09696e-17
C59 (\6\:E VSS) capacitor c=3.36801e-17
C60 (\2\:D VSS) capacitor c=4.89175e-17
C61 (\2\:Eb VSS) capacitor c=9.74812e-17
C62 (\4\:E VSS) capacitor c=4.33918e-17
C63 (\2\:E VSS) capacitor c=4.1894e-17
C64 (\5\:net502 VSS) capacitor c=2.69609e-17
C65 (\2\:SE VSS) capacitor c=6.42189e-17
C66 (\5\:SEb VSS) capacitor c=3.95014e-17
C67 (\4\:SEb VSS) capacitor c=4.25699e-17
C68 (\3\:SI VSS) capacitor c=2.61903e-17
C69 (\2\:CK VSS) capacitor c=3.05381e-17
C70 (\2\:CKb VSS) capacitor c=1.52831e-17
C71 (\12\:net536 VSS) capacitor c=3.77085e-17
C72 (\8\:CKbb VSS) capacitor c=4.95114e-17
C73 (\6\:CKbb VSS) capacitor c=2.46095e-17
C74 (\2\:mout VSS) capacitor c=5.71521e-17
C75 (\2\:n20 VSS) capacitor c=3.44789e-17
C76 (\4\:CKbb VSS) capacitor c=2.28099e-17
C77 (\2\:CKbb VSS) capacitor c=6.24344e-17
C78 (\10\:net536 VSS) capacitor c=2.65484e-17
C79 (\4\:n30 VSS) capacitor c=2.25681e-17
C80 (\6\:net536 VSS) capacitor c=2.22908e-17
C81 (\8\:Eb VSS) capacitor c=1.65054e-17
C82 (\16\:VDD VSS) capacitor c=3.03409e-17
C83 (\6\:Db VSS) capacitor c=2.78948e-17
C84 (\3\:QN VSS) capacitor c=4.56745e-18
C85 (\8\:SEb VSS) capacitor c=9.1777e-17
C86 (\4\:Db VSS) capacitor c=2.09814e-16
C87 (\7\:Dbp VSS) capacitor c=3.1228e-17
C88 (\22\:VDD VSS) capacitor c=2.6407e-17
C89 (\14\:CKb VSS) capacitor c=5.03024e-17
C90 (\14\:net502 VSS) capacitor c=7.74133e-17
C91 (\24\:VDD VSS) capacitor c=5.95741e-17
C92 (\9\:CKbb VSS) capacitor c=5.86161e-17
C93 (\5\:Dbp VSS) capacitor c=3.14719e-17
C94 (\4\:n20 VSS) capacitor c=5.52853e-17
C95 (\26\:VDD VSS) capacitor c=6.72167e-17
C96 (\8\:mout VSS) capacitor c=5.72435e-17
C97 (\9\:n30 VSS) capacitor c=3.04869e-17
C98 (\28\:VDD VSS) capacitor c=3.11857e-17
C99 (\16\:net536 VSS) capacitor c=5.93946e-17
C100 (\1\:Q VSS) capacitor c=6.67255e-17
C101 (\1\:VDD VSS) capacitor c=1.00085e-16
C102 (\4\:Eb VSS) capacitor c=6.45169e-17
C103 (\1\:QN VSS) capacitor c=6.5862e-17
C104 (\11\:SEb VSS) capacitor c=4.58593e-17
C105 (\8\:Db VSS) capacitor c=1.2746e-16
C106 (\10\:CKb VSS) capacitor c=1.12793e-16
C107 (\12\:net502 VSS) capacitor c=3.61766e-16
C108 (\11\:CKbb VSS) capacitor c=7.68975e-17
C109 (\9\:Dbp VSS) capacitor c=7.18625e-17
C110 (\8\:n20 VSS) capacitor c=3.95066e-17
C111 (\6\:mout VSS) capacitor c=4.86725e-17
C112 (\5\:n30 VSS) capacitor c=6.95044e-17
C113 (\20\:net536 VSS) capacitor c=2.62325e-17
C114 (\3\:Q VSS) capacitor c=3.1524e-17
C115 (\2\:n30 VSS) capacitor c=2.53756e-17
C116 (\3\:CKb VSS) capacitor c=1.65651e-17
C117 (\4\:CKb VSS) capacitor c=6.16144e-17
C118 (\2\:SI VSS) capacitor c=4.05176e-17
C119 (\3\:SE VSS) capacitor c=9.23408e-17
C120 (\2\:net502 VSS) capacitor c=4.24947e-17
C121 (\3\:net502 VSS) capacitor c=1.26637e-16
C122 (\7\:n30 VSS) capacitor c=1.11125e-16
C123 (\8\:n30 VSS) capacitor c=6.41847e-17
C124 (\4\:mout VSS) capacitor c=7.07795e-17
C125 (\5\:mout VSS) capacitor c=6.74186e-17
C126 (\6\:n20 VSS) capacitor c=6.05771e-17
C127 (\7\:n20 VSS) capacitor c=5.87255e-17
C128 (\14\:net536 VSS) capacitor c=1.85887e-16
C129 (\15\:net536 VSS) capacitor c=2.32154e-16
C130 (\18\:net536 VSS) capacitor c=2.12504e-17
C131 (\19\:net536 VSS) capacitor c=2.23802e-17
C132 (\22\:net536 VSS) capacitor c=1.92473e-17
C133 (\13\:CKbb VSS) capacitor c=7.11877e-17
C134 (\14\:CKbb VSS) capacitor c=7.90682e-17
C135 (\15\:CKbb VSS) capacitor c=9.44218e-17
C136 (\16\:CKbb VSS) capacitor c=9.61365e-17
C137 (\17\:CKbb VSS) capacitor c=8.13413e-17
C138 (\12\:CKb VSS) capacitor c=1.65074e-16
C139 (\13\:CKb VSS) capacitor c=1.0565e-16
C140 (\4\:CK VSS) capacitor c=5.5839e-17
C141 (\3\:Dbp VSS) capacitor c=2.55434e-16
C142 (\4\:Dbp VSS) capacitor c=2.38759e-16
C143 (\6\:SEb VSS) capacitor c=6.57898e-17
C144 (\7\:SEb VSS) capacitor c=8.24585e-17
C145 (\10\:SEb VSS) capacitor c=1.11869e-16
C146 (\7\:SE VSS) capacitor c=4.84069e-17
C147 (\11\:net502 VSS) capacitor c=3.77417e-16
C148 (\3\:Db VSS) capacitor c=1.88901e-16
C149 (\4\:D VSS) capacitor c=8.52457e-17
C150 (\8\:E VSS) capacitor c=6.23039e-17
C151 (\9\:E VSS) capacitor c=1.08622e-16
C152 (\10\:E VSS) capacitor c=6.70769e-17
C153 (\6\:Eb VSS) capacitor c=7.89991e-17
C154 (\7\:Eb VSS) capacitor c=8.87308e-17
C155 (\3\:VDD VSS) capacitor c=1.87359e-17
C156 (\4\:VDD VSS) capacitor c=1.2345e-16
C157 (\7\:VDD VSS) capacitor c=5.39648e-17
C158 (\9\:VDD VSS) capacitor c=4.12271e-17
C159 (\10\:VDD VSS) capacitor c=5.224e-17
C160 (\12\:VDD VSS) capacitor c=8.31071e-18
Rk47 (\8\:E \9\:E) resistor r=0.3108 c=0
Rk49 (\10\:E E) resistor r=0.02815 c=0
Rk48 (\9\:E \10\:E) resistor r=0.5273 c=0
Rk28 (SI \5\:SI) resistor r=0.009678 c=0
Rk74 (\2\:VSS \3\:VSS) resistor r=0.233 c=0
Rk75 (\3\:VSS \4\:VSS) resistor r=0.3357 c=0
Rk77 (\3\:VSS \7\:VSS) resistor r=0.2664 c=0
Rk79 (\4\:VSS \10\:VSS) resistor r=0.8205 c=0
Rk80 (\10\:VSS \11\:VSS) resistor r=0.3835 c=0
Rk81 (\11\:VSS \12\:VSS) resistor r=0.223 c=0
Rk82 (\12\:VSS \13\:VSS) resistor r=0.6115 c=0
Rk83 (\13\:VSS \14\:VSS) resistor r=0.3685 c=0
Rk85 (\15\:VSS VSS) resistor r=0.2429 c=0
Rk84 (\14\:VSS \15\:VSS) resistor r=0.1001 c=0
Rk88 (\10\:VSS \20\:VSS) resistor r=0.2986 c=0
Rk89 (\12\:VSS \22\:VSS) resistor r=0.4021 c=0
Rk90 (\13\:VSS \24\:VSS) resistor r=0.1427 c=0
Rk91 (\15\:VSS \26\:VSS) resistor r=0.07393 c=0
Rk46 (D \4\:D) resistor r=0.01623 c=0
Rk1 (\2\:Q Q) resistor r=0.3171 c=0
Rk2 (Q \4\:Q) resistor r=0.0543 c=0
Rk53 (\2\:VDD \3\:VDD) resistor r=0.1804 c=0
Rk54 (\3\:VDD \4\:VDD) resistor r=0.4084 c=0
Rk57 (\4\:VDD \7\:VDD) resistor r=0.7961 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.3324 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.2556 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.5789 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.3685 c=0
Rk63 (\12\:VDD VDD) resistor r=0.1777 c=0
Rk62 (\11\:VDD \12\:VDD) resistor r=0.1503 c=0
Rk66 (\3\:VDD \17\:VDD) resistor r=0.2677 c=0
Rk69 (\7\:VDD \23\:VDD) resistor r=0.04331 c=0
Rk70 (\9\:VDD \25\:VDD) resistor r=0.2783 c=0
Rk71 (\10\:VDD \27\:VDD) resistor r=0.3012 c=0
Rk72 (\12\:VDD \29\:VDD) resistor r=0.1831 c=0
Rk27 (\4\:CK CK) resistor r=0.1151 c=0
Rk41 (\4\:QN QN) resistor r=0.01535 c=0
Rk40 (\2\:QN \4\:QN) resistor r=0.3371 c=0
Rk37 (SE \7\:SE) resistor r=0.04597 c=0
Rk12 (\14\:net536 \15\:net536) resistor r=1.578 c=0
Rk13 (\15\:net536 \17\:net536) resistor r=0.5162 c=0
Rk14 (\15\:net536 \18\:net536) resistor r=0.04992 c=0
Rk15 (\17\:net536 \19\:net536) resistor r=0.1996 c=0
Rk16 (\19\:net536 \21\:net536) resistor r=0.1682 c=0
Rk17 (\19\:net536 \22\:net536) resistor r=0.1014 c=0
Rk3 (\6\:n30 \7\:n30) resistor r=0.3431 c=0
Rk4 (\7\:n30 \8\:n30) resistor r=0.4995 c=0
Rk5 (\7\:n30 \10\:n30) resistor r=0.04586 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.6931 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.7748 c=0
Rk26 (\12\:CKb \15\:CKb) resistor r=0.2244 c=0
Rk6 (\4\:mout \5\:mout) resistor r=0.3294 c=0
Rk7 (\5\:mout \7\:mout) resistor r=0.2592 c=0
Rk8 (\5\:mout \9\:mout) resistor r=0.1845 c=0
Rk18 (\10\:CKbb \12\:CKbb) resistor r=0.3349 c=0
Rk19 (\12\:CKbb \13\:CKbb) resistor r=0.4311 c=0
Rk20 (\13\:CKbb \14\:CKbb) resistor r=0.2104 c=0
Rk21 (\14\:CKbb \15\:CKbb) resistor r=0.5657 c=0
Rk22 (\15\:CKbb \16\:CKbb) resistor r=0.5367 c=0
Rk23 (\13\:CKbb \17\:CKbb) resistor r=0.3812 c=0
Rk9 (\5\:n20 \6\:n20) resistor r=0.2952 c=0
Rk10 (\6\:n20 \7\:n20) resistor r=0.3078 c=0
Rk11 (\6\:n20 \9\:n20) resistor r=0.1279 c=0
Rk29 (\2\:Dbp \3\:Dbp) resistor r=0.6485 c=0
Rk30 (\3\:Dbp \4\:Dbp) resistor r=1.7477 c=0
Rk31 (\4\:Dbp \6\:Dbp) resistor r=0.1026 c=0
Rk32 (\3\:Dbp \8\:Dbp) resistor r=0.1015 c=0
Rk33 (\4\:Dbp \10\:Dbp) resistor r=0.3953 c=0
Rk38 (\11\:net502 \13\:net502) resistor r=2.8719 c=0
Rk39 (\13\:net502 \15\:net502) resistor r=0.4359 c=0
Rk42 (\2\:Db \3\:Db) resistor r=0.6775 c=0
Rk43 (\3\:Db \5\:Db) resistor r=1.246 c=0
Rk44 (\3\:Db \7\:Db) resistor r=0.1514 c=0
Rk45 (\5\:Db \9\:Db) resistor r=0.7318 c=0
Rk34 (\6\:SEb \7\:SEb) resistor r=0.3253 c=0
Rk35 (\9\:SEb \10\:SEb) resistor r=0.4384 c=0
Rk36 (\10\:SEb \12\:SEb) resistor r=0.2412 c=0
Rk50 (\5\:Eb \6\:Eb) resistor r=0.5107 c=0
Rk51 (\6\:Eb \7\:Eb) resistor r=0.5634 c=0
Rk52 (\6\:Eb \9\:Eb) resistor r=0.2315 c=0
Rl58 (\5\:E \6\:E) resistor r=171.846 c=0
Rl59 (\6\:E \7\:E) resistor r=35.3072 c=0
Rl53 (\3\:E \4\:E) resistor r=35.5399 c=0
Rl52 (\1\:E \2\:E) resistor r=24.2328 c=0
Rl32 (\1\:SI \2\:SI) resistor r=68.1104 c=0
Rl34 (\2\:SI \4\:SI) resistor r=131.572 c=0
Rl33 (\2\:SI \3\:SI) resistor r=10.9341 c=0
Rl56 (\1\:D \2\:D) resistor r=123.077 c=0
Rl57 (\2\:D \3\:D) resistor r=85.989 c=0
Rl30 (\1\:CK \2\:CK) resistor r=50.6918 c=0
Rl31 (\2\:CK \3\:CK) resistor r=133.384 c=0
Rl41 (\2\:SE \5\:SE) resistor r=58.4251 c=0
Rl38 (\1\:SE \2\:SE) resistor r=74.7951 c=0
Rl42 (\3\:SE \6\:SE) resistor r=101.157 c=0
Rl40 (\3\:SE \4\:SE) resistor r=156.492 c=0
Rl39 (\2\:SE \3\:SE) resistor r=316.222 c=0
Rl29 (\13\:net536 \11\:net536) resistor r=92.3077 c=0
Rl10 (\8\:net536 \9\:net536) resistor r=172.643 c=0
Rl28 (\12\:net536 \11\:net536) resistor r=251.9 c=0
Rl11 (\10\:net536 \9\:net536) resistor r=24.2328 c=0
Rl5 (net536 \6\:net536) resistor r=9.5287 c=0
Rl8 (\2\:n30 \3\:n30) resistor r=47.0949 c=0
Rl7 (n30 \2\:n30) resistor r=41.6119 c=0
Rl9 (\2\:n30 \4\:n30) resistor r=65.7849 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=403.412 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=210.67 c=0
Rl20 (CKb \2\:CKb) resistor r=40.3846 c=0
Rl24 (\3\:CKb \6\:CKb) resistor r=25.6632 c=0
Rl21 (\2\:CKb \3\:CKb) resistor r=9.4946 c=0
Rl25 (\4\:CKb \7\:CKb) resistor r=247.62 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=34.2969 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=150.721 c=0
Rl16 (mout \2\:mout) resistor r=49.2328 c=0
Rl17 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl19 (\7\:CKbb \8\:CKbb) resistor r=58.3841 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=62.2302 c=0
Rl14 (n20 \2\:n20) resistor r=112.23 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl43 (\2\:net502 net502) resistor r=105.003 c=0
Rl47 (\2\:net502 \6\:net502) resistor r=124.234 c=0
Rl46 (\3\:net502 \5\:net502) resistor r=3.6042 c=0
Rl44 (\3\:net502 \2\:net502) resistor r=91.3077 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=35.3482 c=0
Rl37 (\4\:SEb \5\:SEb) resistor r=107.617 c=0
Rl35 (SEb \2\:SEb) resistor r=55.01 c=0
Rl54 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl55 (\2\:Eb \3\:Eb) resistor r=264.183 c=0
Rz20 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz24 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz25 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz26 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz16 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz17 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz18 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\2\:QN \1\:QN) resistor r=75 c=0
Rz5 (\21\:net536 \20\:net536) resistor r=75 c=0
Rz2 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz7 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz4 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dbp \2\:Dbp) resistor r=75 c=0
Rz9 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz11 (\13\:net502 \12\:net502) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\11\:SEb \12\:SEb) resistor r=75 c=0
Rz15 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry25 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry26 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry27 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry28 (\14\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry22 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry23 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry12 (\4\:QN \3\:QN) resistor r=62 c=0
Ry5 (\17\:net536 \16\:net536) resistor r=62 c=0
Ry2 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry7 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry4 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry11 (\15\:net502 \14\:net502) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry15 (\8\:Eb \9\:Eb) resistor r=62 c=0
Rx20 (\2\:E \8\:E) resistor r=45 c=0
Rx21 (\4\:E \9\:E) resistor r=45 c=0
Rx22 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\2\:SE \7\:SE) resistor r=45 c=0
Rx4 (\14\:net536 \12\:net536) resistor r=45 c=0
Rx5 (\18\:net536 \10\:net536) resistor r=45 c=0
Rx6 (\22\:net536 \6\:net536) resistor r=45 c=0
Rx1 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx11 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx2 (\2\:mout \4\:mout) resistor r=45 c=0
Rx7 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\11\:net502 \5\:net502) resistor r=45 c=0
Rx14 (\4\:SEb \6\:SEb) resistor r=45 c=0
Rx15 (SEb \7\:SEb) resistor r=45 c=0
Rx16 (\5\:SEb \10\:SEb) resistor r=45 c=0
Rx23 (\2\:Eb \7\:Eb) resistor r=45 c=0
mn55_1__rcx (\3\:Q net536 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.153e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.17212e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN \3\:net502 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.998e-14 ad=4.16e-14 ps=1.185e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=1.01365e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn45 (\20\:net536 n30 VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=2.53e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.23415e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net534 \8\:net536 \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=1.015e-14 ps=1.5e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.54e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\5\:n30 \9\:CKb net534 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=1.425e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\6\:mout \3\:CKbb \5\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=3.988e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net526 \3\:mout \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net526 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.003e-14 ps=4.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\9\:Dbp \5\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\11\:CKbb CKb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\12\:net502 \13\:net536 \21\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\10\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.248e-14 ps=8.7e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=9.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (net546 \4\:SI \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=1.957e-14 ps=8.7e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=6.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn13 (Dbp \4\:SE net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.48e-14 ps=5.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=4.25e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\11\:SEb \1\:SE \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=3.263e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.835e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (net514 \6\:net502 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=8.7e-15 ps=1.35e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.08e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn2 (Db \3\:Eb net514 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=9.75e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn4 (Db \3\:E net554 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.465e-14 ps=5.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=7.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn3 (net554 \3\:D \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=1.595e-14 ps=1.13e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=6.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn0 (\4\:Eb \7\:E \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=2.03e-14 ps=1.13e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp45 (\16\:net536 \3\:n30 VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.075e-14 ad=3.7e-14 ps=1.97e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.19355e-07 sd=160n sca=36.7709 \
        scb=0.0239974 scc=0.00420525 m=(1)
mp50 (net457 \9\:net536 \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.99e-14 ad=2.472e-14 ps=1.17e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09302e-07 sb=1.455e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\9\:n30 CKbb net457 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.762e-14 ps=6.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69302e-07 sb=1.295e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\9\:n30 \8\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.762e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.89302e-07 sb=1.075e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.09302e-07 sb=7.55e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net437 mout \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0743e-06 sb=4.9e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \7\:CKb net437 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1793e-06 sb=3.85e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.3e-14 ps=7.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4243e-06 sb=1.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb \6\:CKb \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.827e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\14\:net502 \11\:net536 \24\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=8.827e-14 ad=7.525e-14 ps=1.45e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=4.7e-07 sb=3.5e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\14\:CKb \1\:CK \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0435e-13 ad=3.01e-14 ps=1.71e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp12 (net465 \1\:SI \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0435e-13 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=5e-07 sd=160n sca=13.1637 scb=0.0123476 \
        scc=0.000501177 m=(1)
mp13 (\7\:Dbp \2\:SEb net465 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp11 (\7\:Dbp \6\:SE \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp10 (\8\:SEb \5\:SE \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1297e-13 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05581e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp1 (net425 net502 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.495e-14 ad=2.902e-14 ps=1.55e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.04884e-07 sb=1.08e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp2 (\6\:Db \1\:E net425 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.84884e-07 sb=9e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp4 (\6\:Db Eb net473 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08988e-06 sb=6.95e-07 sd=160n sca=11.1829 \
        scb=0.00913745 scc=0.000187969 m=(1)
mp3 (net473 \1\:D \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.417e-14 ad=2.58e-14 ps=1.12e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25488e-06 sb=5.3e-07 sd=160n sca=11.6362 \
        scb=0.00930804 scc=0.000188027 m=(1)
mp0 (\8\:Eb \5\:E \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.417e-14 ad=3.01e-14 ps=1.12e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64488e-06 sb=1.4e-07 sd=160n sca=15.5174 \
        scb=0.0148358 scc=0.000265687 m=(1)
ends SEDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:23 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFX4
// View name: extracted

simulator lang=spectre

subckt SEDFFX4 CK D E Q QN SE SI VDD VSS
mp56 (\23\:net502 \16\:net536 \19\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=1.006e-13 ad=1.443e-13 ps=1.41e-06 pd=1.52e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.44551e-07 sb=3.7e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(1)
mp55_1__rcx (Q net536 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54032e-06 sd=160n sca=32.0426 \
        scb=0.0350053 scc=0.00300251 m=(4)
mp57_1__rcx (QN \3\:net502 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.904e-14 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=1.37936e-06 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(4)
C1 (E VSS) capacitor c=1.88799e-17
C2 (SI VSS) capacitor c=5.06128e-17
C3 (QN VSS) capacitor c=1.05233e-16
C4 (D VSS) capacitor c=6.33868e-17
C5 (VDD VSS) capacitor c=8.15272e-16
C6 (CK VSS) capacitor c=1.07151e-16
C7 (Q VSS) capacitor c=2.6336e-16
C8 (SE VSS) capacitor c=5.05735e-17
C9 (net536 VSS) capacitor c=2.46134e-16
C10 (n30 VSS) capacitor c=1.87282e-16
C11 (net534 VSS) capacitor c=1.87509e-18
C12 (CKb VSS) capacitor c=2.53999e-17
C13 (mout VSS) capacitor c=6.09564e-17
C14 (CKbb VSS) capacitor c=5.31236e-17
C15 (n20 VSS) capacitor c=4.92614e-17
C16 (Dbp VSS) capacitor c=9.9916e-17
C17 (net502 VSS) capacitor c=3.51717e-17
C18 (net546 VSS) capacitor c=1.89263e-18
C19 (Db VSS) capacitor c=8.80413e-17
C20 (SEb VSS) capacitor c=3.78538e-17
C21 (Eb VSS) capacitor c=3.27293e-17
C22 (net457 VSS) capacitor c=1.78516e-18
C23 (net437 VSS) capacitor c=2.32221e-18
C24 (net465 VSS) capacitor c=2.42689e-18
C25 (net425 VSS) capacitor c=1.00901e-18
C26 (net473 VSS) capacitor c=3.72746e-18
C27 (\5\:E VSS) capacitor c=4.67271e-17
C28 (\3\:D VSS) capacitor c=4.69779e-17
C29 (\1\:E VSS) capacitor c=6.23015e-17
C30 (\12\:net502 VSS) capacitor c=6.95601e-17
C31 (\6\:SE VSS) capacitor c=2.69852e-17
C32 (\7\:SE VSS) capacitor c=3.65264e-17
C33 (\2\:SEb VSS) capacitor c=3.8327e-17
C34 (\4\:SI VSS) capacitor c=5.43419e-17
C35 (\1\:CK VSS) capacitor c=4.8962e-17
C36 (\16\:net536 VSS) capacitor c=4.69758e-17
C37 (\7\:CKb VSS) capacitor c=3.02583e-17
C38 (\8\:CKbb VSS) capacitor c=3.94068e-17
C39 (\4\:CKb VSS) capacitor c=1.29506e-16
C40 (\5\:CKb VSS) capacitor c=1.12056e-16
C41 (\13\:net536 VSS) capacitor c=5.49318e-17
C42 (\7\:E VSS) capacitor c=3.45237e-17
C43 (\1\:D VSS) capacitor c=5.59418e-17
C44 (\3\:E VSS) capacitor c=5.26078e-17
C45 (\3\:Eb VSS) capacitor c=8.88077e-17
C46 (\1\:SE VSS) capacitor c=4.86074e-17
C47 (\3\:SEb VSS) capacitor c=2.59927e-17
C48 (\5\:SE VSS) capacitor c=4.39963e-17
C49 (\1\:SI VSS) capacitor c=2.87576e-17
C50 (\3\:CK VSS) capacitor c=2.77988e-17
C51 (\18\:net536 VSS) capacitor c=4.79316e-17
C52 (\8\:CKb VSS) capacitor c=3.10469e-17
C53 (\5\:CKbb VSS) capacitor c=8.56051e-17
C54 (\3\:mout VSS) capacitor c=6.43629e-17
C55 (\3\:n20 VSS) capacitor c=2.82294e-17
C56 (\3\:CKbb VSS) capacitor c=5.4736e-17
C57 (\6\:CKb VSS) capacitor c=8.03382e-17
C58 (\14\:net536 VSS) capacitor c=5.65198e-17
C59 (\6\:E VSS) capacitor c=4.4147e-17
C60 (\2\:D VSS) capacitor c=7.31512e-17
C61 (\4\:E VSS) capacitor c=5.30014e-17
C62 (\2\:Eb VSS) capacitor c=7.90593e-17
C63 (\2\:E VSS) capacitor c=5.98105e-17
C64 (\2\:SE VSS) capacitor c=4.64033e-17
C65 (\5\:SEb VSS) capacitor c=3.95274e-17
C66 (\4\:SEb VSS) capacitor c=4.96606e-17
C67 (\3\:SI VSS) capacitor c=3.57751e-17
C68 (\2\:CK VSS) capacitor c=3.54128e-17
C69 (\2\:CKb VSS) capacitor c=3.26545e-17
C70 (\17\:net536 VSS) capacitor c=3.18182e-17
C71 (\7\:CKbb VSS) capacitor c=4.7287e-17
C72 (\6\:CKbb VSS) capacitor c=2.82186e-17
C73 (\2\:mout VSS) capacitor c=5.2524e-17
C74 (\2\:n20 VSS) capacitor c=3.39902e-17
C75 (\4\:CKbb VSS) capacitor c=2.1247e-17
C76 (\2\:CKbb VSS) capacitor c=5.62634e-17
C77 (\15\:net536 VSS) capacitor c=3.04549e-17
C78 (\6\:Eb VSS) capacitor c=1.16123e-16
C79 (\1\:VDD VSS) capacitor c=1.07071e-17
C80 (\6\:Db VSS) capacitor c=4.08228e-17
C81 (\8\:SEb VSS) capacitor c=7.28717e-17
C82 (\4\:Db VSS) capacitor c=1.96957e-16
C83 (\7\:Dbp VSS) capacitor c=2.75207e-17
C84 (\16\:VDD VSS) capacitor c=4.73464e-17
C85 (\11\:CKb VSS) capacitor c=1.82788e-16
C86 (\23\:net502 VSS) capacitor c=8.5658e-17
C87 (\19\:VDD VSS) capacitor c=5.66884e-17
C88 (\16\:CKbb VSS) capacitor c=6.77763e-17
C89 (\5\:Dbp VSS) capacitor c=3.50031e-17
C90 (\4\:n20 VSS) capacitor c=4.75824e-17
C91 (\22\:VDD VSS) capacitor c=7.12513e-17
C92 (\8\:mout VSS) capacitor c=5.43467e-17
C93 (\12\:n30 VSS) capacitor c=2.96164e-17
C94 (\21\:net536 VSS) capacitor c=8.26826e-17
C95 (\3\:VDD VSS) capacitor c=1.14653e-16
C96 (\4\:Eb VSS) capacitor c=6.63707e-17
C97 (\1\:QN VSS) capacitor c=9.71519e-17
C98 (\11\:SEb VSS) capacitor c=5.15475e-17
C99 (\8\:Db VSS) capacitor c=1.05348e-16
C100 (\9\:CKb VSS) capacitor c=7.81343e-17
C101 (\21\:net502 VSS) capacitor c=2.42663e-16
C102 (\11\:CKbb VSS) capacitor c=9.37854e-17
C103 (\9\:Dbp VSS) capacitor c=9.68557e-17
C104 (\8\:n20 VSS) capacitor c=3.72168e-17
C105 (\6\:mout VSS) capacitor c=4.89544e-17
C106 (\10\:n30 VSS) capacitor c=7.09767e-17
C107 (\26\:net536 VSS) capacitor c=2.22278e-17
C108 (\3\:CKb VSS) capacitor c=7.18312e-17
C109 (\3\:SE VSS) capacitor c=3.56921e-17
C110 (\4\:SE VSS) capacitor c=7.95588e-17
C111 (\2\:net502 VSS) capacitor c=4.32424e-17
C112 (\3\:net502 VSS) capacitor c=2.61264e-16
C113 (\8\:n30 VSS) capacitor c=6.52052e-17
C114 (\9\:n30 VSS) capacitor c=7.49724e-17
C115 (\4\:mout VSS) capacitor c=7.60323e-17
C116 (\5\:mout VSS) capacitor c=5.71649e-17
C117 (\6\:n20 VSS) capacitor c=5.92313e-17
C118 (\7\:n20 VSS) capacitor c=5.97061e-17
C119 (\19\:net536 VSS) capacitor c=1.9536e-16
C120 (\20\:net536 VSS) capacitor c=2.3181e-16
C121 (\23\:net536 VSS) capacitor c=3.91378e-17
C122 (\24\:net536 VSS) capacitor c=2.64361e-17
C123 (\25\:net536 VSS) capacitor c=2.32628e-17
C124 (\9\:CKbb VSS) capacitor c=7.31203e-17
C125 (\10\:CKbb VSS) capacitor c=8.00526e-17
C126 (\13\:CKbb VSS) capacitor c=7.20247e-17
C127 (\14\:CKbb VSS) capacitor c=1.2001e-16
C128 (\15\:CKbb VSS) capacitor c=8.48787e-17
C129 (\13\:CKb VSS) capacitor c=1.05195e-16
C130 (\5\:SI VSS) capacitor c=8.046e-17
C131 (\3\:Dbp VSS) capacitor c=2.73468e-16
C132 (\4\:Dbp VSS) capacitor c=2.39141e-16
C133 (\6\:SEb VSS) capacitor c=5.38218e-17
C134 (\7\:SEb VSS) capacitor c=7.62562e-17
C135 (\10\:SEb VSS) capacitor c=6.08184e-17
C136 (\8\:SE VSS) capacitor c=7.69765e-17
C137 (\20\:net502 VSS) capacitor c=2.51477e-16
C138 (\3\:Db VSS) capacitor c=2.01402e-16
C139 (\8\:E VSS) capacitor c=2.92878e-17
C140 (\9\:E VSS) capacitor c=2.48808e-17
C141 (\10\:E VSS) capacitor c=3.74204e-17
C142 (\11\:E VSS) capacitor c=4.87495e-17
C143 (\4\:D VSS) capacitor c=7.52938e-17
C144 (\8\:Eb VSS) capacitor c=7.59422e-17
C145 (\5\:VDD VSS) capacitor c=1.72101e-16
C146 (\15\:VDD VSS) capacitor c=4.92583e-17
C147 (\21\:VDD VSS) capacitor c=5.78431e-17
Rk54 (\9\:E E) resistor r=0.03645 c=0
Rk52 (\8\:E \9\:E) resistor r=0.1451 c=0
Rk53 (\9\:E \10\:E) resistor r=0.1053 c=0
Rk55 (\10\:E \11\:E) resistor r=0.2733 c=0
Rk31 (\5\:SI SI) resistor r=0.1095 c=0
Rk44 (\1\:QN QN) resistor r=0.2874 c=0
Rk56 (D \4\:D) resistor r=0.01829 c=0
Rk59 (\2\:VSS \4\:VSS) resistor r=0.3308 c=0
Rk60 (\4\:VSS \5\:VSS) resistor r=0.3761 c=0
Rk63 (\5\:VSS \8\:VSS) resistor r=0.6596 c=0
Rk64 (\8\:VSS \9\:VSS) resistor r=0.5448 c=0
Rk66 (\10\:VSS VSS) resistor r=0.5289 c=0
Rk65 (\9\:VSS \10\:VSS) resistor r=0.5944 c=0
Rk74 (\8\:VSS \22\:VSS) resistor r=0.123 c=0
Rk75 (\9\:VSS \24\:VSS) resistor r=0.3473 c=0
Rk76 (\10\:VSS \26\:VSS) resistor r=0.123 c=0
Rk81 (\2\:VDD \4\:VDD) resistor r=0.1206 c=0
Rk82 (\4\:VDD \5\:VDD) resistor r=0.4117 c=0
Rk89 (\5\:VDD \15\:VDD) resistor r=0.5866 c=0
Rk90 (\15\:VDD \17\:VDD) resistor r=0.2644 c=0
Rk91 (\15\:VDD \18\:VDD) resistor r=0.5367 c=0
Rk92 (\18\:VDD \20\:VDD) resistor r=0.3244 c=0
Rk95 (\21\:VDD VDD) resistor r=0.5289 c=0
Rk93 (\18\:VDD \21\:VDD) resistor r=0.5948 c=0
Rk94 (\21\:VDD \23\:VDD) resistor r=0.3467 c=0
Rk30 (\4\:CK CK) resistor r=0.002143 c=0
Rk40 (\8\:SE SE) resistor r=0.005181 c=0
Rk16 (\19\:net536 \20\:net536) resistor r=1.6607 c=0
Rk17 (\20\:net536 \22\:net536) resistor r=0.3384 c=0
Rk18 (\22\:net536 \23\:net536) resistor r=0.2896 c=0
Rk19 (\23\:net536 \24\:net536) resistor r=0.16 c=0
Rk20 (\20\:net536 \25\:net536) resistor r=0.03527 c=0
Rk21 (\23\:net536 \27\:net536) resistor r=0.1637 c=0
Rk7 (\8\:n30 \9\:n30) resistor r=0.4198 c=0
Rk8 (\9\:n30 \11\:n30) resistor r=0.377 c=0
Rk9 (\9\:n30 \13\:n30) resistor r=0.04983 c=0
Rk28 (\10\:CKb \12\:CKb) resistor r=0.4703 c=0
Rk29 (\12\:CKb \13\:CKb) resistor r=0.9305 c=0
Rk10 (\4\:mout \5\:mout) resistor r=0.3387 c=0
Rk11 (\5\:mout \7\:mout) resistor r=0.2465 c=0
Rk12 (\5\:mout \9\:mout) resistor r=0.1751 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.4025 c=0
Rk23 (\10\:CKbb \12\:CKbb) resistor r=0.4677 c=0
Rk24 (\10\:CKbb \13\:CKbb) resistor r=0.2186 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.4586 c=0
Rk26 (\14\:CKbb \15\:CKbb) resistor r=0.5768 c=0
Rk27 (\12\:CKbb \17\:CKbb) resistor r=0.3365 c=0
Rk13 (\5\:n20 \6\:n20) resistor r=0.2954 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.3095 c=0
Rk15 (\6\:n20 \9\:n20) resistor r=0.1282 c=0
Rk32 (\2\:Dbp \3\:Dbp) resistor r=0.6186 c=0
Rk33 (\3\:Dbp \4\:Dbp) resistor r=1.6534 c=0
Rk34 (\4\:Dbp \6\:Dbp) resistor r=0.1241 c=0
Rk35 (\3\:Dbp \8\:Dbp) resistor r=0.1918 c=0
Rk36 (\4\:Dbp \10\:Dbp) resistor r=0.4369 c=0
Rk41 (\20\:net502 \22\:net502) resistor r=2.0049 c=0
Rk42 (\22\:net502 \24\:net502) resistor r=0.5115 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.7458 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.2073 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.09878 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.6487 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.2807 c=0
Rk38 (\9\:SEb \10\:SEb) resistor r=0.2176 c=0
Rk39 (\10\:SEb \12\:SEb) resistor r=0.1196 c=0
Rk57 (\5\:Eb \7\:Eb) resistor r=0.6439 c=0
Rk58 (\7\:Eb \8\:Eb) resistor r=0.5199 c=0
Rl75 (\5\:E \6\:E) resistor r=124.233 c=0
Rl76 (\6\:E \7\:E) resistor r=74.2328 c=0
Rl72 (\3\:E \4\:E) resistor r=74.2328 c=0
Rl69 (\1\:E \2\:E) resistor r=71.8456 c=0
Rl41 (\2\:SI \4\:SI) resistor r=154.785 c=0
Rl39 (\1\:SI \2\:SI) resistor r=47.0924 c=0
Rl40 (\2\:SI \3\:SI) resistor r=2.9709 c=0
Rl74 (\2\:D \3\:D) resistor r=53.022 c=0
Rl73 (\1\:D \2\:D) resistor r=150 c=0
Rl37 (\1\:CK \2\:CK) resistor r=148.769 c=0
Rl38 (\2\:CK \3\:CK) resistor r=29.5379 c=0
Rl45 (\1\:SE \2\:SE) resistor r=85.7713 c=0
Rl49 (\3\:SE \6\:SE) resistor r=30.4507 c=0
Rl46 (\2\:SE \3\:SE) resistor r=27.8747 c=0
Rl50 (\4\:SE \7\:SE) resistor r=95.3874 c=0
Rl48 (\4\:SE \5\:SE) resistor r=144.953 c=0
Rl47 (\3\:SE \4\:SE) resistor r=187.377 c=0
Rl36 (\18\:net536 \16\:net536) resistor r=92.3077 c=0
Rl18 (\14\:net536 \13\:net536) resistor r=167.308 c=0
Rl35 (\17\:net536 \16\:net536) resistor r=176.9 c=0
Rl19 (\15\:net536 \13\:net536) resistor r=24.2328 c=0
Rl31 (\4\:CKb \5\:CKb) resistor r=407.258 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl33 (\2\:CKb \7\:CKb) resistor r=28.1713 c=0
Rl28 (CKb \2\:CKb) resistor r=34.4634 c=0
Rl30 (\3\:CKb \4\:CKb) resistor r=168.774 c=0
Rl34 (\3\:CKb \8\:CKb) resistor r=53.5277 c=0
Rl29 (\2\:CKb \3\:CKb) resistor r=211.87 c=0
Rl24 (mout \2\:mout) resistor r=50.6918 c=0
Rl25 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=57.2054 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl21 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl20 (CKbb \2\:CKbb) resistor r=74.4182 c=0
Rl22 (n20 \2\:n20) resistor r=112.23 c=0
Rl23 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl61 (\2\:net502 \12\:net502) resistor r=140.066 c=0
Rl51 (\2\:net502 net502) resistor r=86.8026 c=0
Rl52 (\3\:net502 \2\:net502) resistor r=71.544 c=0
Rl43 (\3\:SEb \4\:SEb) resistor r=35.3482 c=0
Rl44 (\4\:SEb \5\:SEb) resistor r=96.0784 c=0
Rl42 (SEb \2\:SEb) resistor r=62.9746 c=0
Rl70 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl71 (\2\:Eb \3\:Eb) resistor r=206.812 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz24 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz32 (VDD \3\:VDD) resistor r=6.25 c=0
Rz29 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz30 (\5\:VDD \3\:VDD) resistor r=6.25 c=0
Rz31 (\18\:VDD \3\:VDD) resistor r=6.25 c=0
Rz6 (\27\:net536 \26\:net536) resistor r=75 c=0
Rz3 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz8 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Dbp \2\:Dbp) resistor r=75 c=0
Rz10 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz12 (\22\:net502 \21\:net502) resistor r=75 c=0
Rz15 (Db \2\:Db) resistor r=75 c=0
Rz16 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\11\:SEb \12\:SEb) resistor r=75 c=0
Rz17 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry21 (VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry19 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry28 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry6 (\22\:net536 \21\:net536) resistor r=31 c=0
Ry3 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry8 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry9 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry10 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry12 (\24\:net502 \23\:net502) resistor r=62 c=0
Ry15 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (\6\:Db \7\:Db) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry17 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx19 (\6\:E \8\:E) resistor r=45 c=0
Rx20 (\4\:E \10\:E) resistor r=45 c=0
Rx21 (\2\:E \11\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx22 (\2\:D \4\:D) resistor r=45 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\19\:net536 \17\:net536) resistor r=45 c=0
Rx5 (\24\:net536 net536) resistor r=45 c=0
Rx6 (\25\:net536 \15\:net536) resistor r=45 c=0
Rx1 (\8\:n30 n30) resistor r=45 c=0
Rx11 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx2 (\2\:mout \4\:mout) resistor r=45 c=0
Rx7 (\7\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\20\:net502 \3\:net502) resistor r=45 c=0
Rx14 (\4\:SEb \6\:SEb) resistor r=45 c=0
Rx15 (SEb \7\:SEb) resistor r=45 c=0
Rx16 (\5\:SEb \10\:SEb) resistor r=45 c=0
Rx23 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn56 (\21\:net502 \18\:net536 \23\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.71058e-07 sb=1.4e-07 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(1)
mn55_1__rcx (Q net536 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.156e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54163e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN \3\:net502 \5\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.182e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.18462e-07 sb=1.28087e-06 sd=160n \
        sca=12.4994 scb=0.0122912 scc=0.000683921 m=(4)
mn45_1__rcx (\26\:net536 n30 VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.119e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.5039e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn50 (net534 \14\:net536 VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.572e-14 ad=2.537e-14 ps=8.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.645e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn51 (\10\:n30 \6\:CKb net534 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.665e-06 sb=1.425e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn40 (\6\:mout \3\:CKbb \10\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.987e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.22e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\6\:mout \3\:n20 \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=3.988e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn35 (net526 \3\:mout \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=8.7e-15 ps=1.32e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn36 (\8\:n20 \5\:CKbb net526 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.3e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn25 (\9\:Dbp \8\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=4.132e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn21 (\11\:CKbb CKb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\9\:CKb \3\:CK \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.698e-14 ps=1.35e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=9.5e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn12 (net546 \1\:SI \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.553e-14 ps=1.35e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=6.85e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn13 (Dbp \5\:SE net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.552e-14 ad=3.045e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=3.95e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn10 (\11\:SEb \1\:SE \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.262e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.40052e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (net514 net502 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.045e-14 ad=1.377e-14 ps=9e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13345e-06 sb=8.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (Db \3\:Eb net514 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.32e-14 ps=4.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27345e-06 sb=7.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (Db \3\:E net554 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47845e-06 sb=5.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (net554 \1\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.957e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65845e-06 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\4\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84552e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45 (\21\:net536 n30 VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.784e-14 ad=4.96e-14 ps=1.19e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.47081e-06 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(2)
mp50 (net457 \13\:net536 VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.807e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.47e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp51 (\12\:n30 CKbb net457 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.192e-14 ps=7.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.285e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp40 (\12\:n30 \5\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.192e-14 ps=9.8e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.045e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp30 (\8\:mout n20 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.25e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp35 (net437 mout \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.505e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.6e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp36 (\4\:n20 \4\:CKb net437 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp25 (\4\:n20 \8\:CKbb \5\:Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp21 (\16\:CKbb \7\:CKb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.006e-13 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\11\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=8.45e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp12 (net465 \4\:SI \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=3.117e-14 ps=8.4e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.95e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp13 (\7\:Dbp \2\:SEb net465 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.73e-14 ps=7.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=4.05e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp11 (\7\:Dbp \7\:SE \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.73e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.4e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (\8\:SEb \6\:SE \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.685e-14 ad=3.01e-14 ps=1.55e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.44186e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp1 (net425 \12\:net502 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.81e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20837e-06 sb=9.15e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp2 (\6\:Db \1\:E net425 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31337e-06 sb=8.1e-07 sd=160n sca=11.3768 \
        scb=0.00954713 scc=0.000220652 m=(1)
mp4 (\6\:Db Eb net473 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.87e-14 ps=7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53837e-06 sb=5.85e-07 sd=160n sca=12.0147 \
        scb=0.00980752 scc=0.000220768 m=(1)
mp3 (net473 \3\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=2.902e-14 ps=1.47e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71837e-06 sb=4.05e-07 sd=160n sca=13.1142 \
        scb=0.0109112 scc=0.000223955 m=(1)
mp0 (\6\:Eb \5\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.93314e-06 sb=1.4e-07 sd=160n sca=18.9625 \
        scb=0.0206935 scc=0.000592237 m=(1)
ends SEDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:24 2013 )
// Library name: gsclib045_hvt
// Cell name: SEDFFXL
// View name: extracted

simulator lang=spectre

subckt SEDFFXL CK D E Q QN SE SI VDD VSS
mp0 (\8\:Eb \1\:E \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.315e-06 sd=160n sca=14.7678 \
        scb=0.0134734 scc=0.000346306 m=(1)
mp3 (net473 \1\:D \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.665e-14 ps=7.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11e-06 sd=160n sca=13.0329 \
        scb=0.0112451 scc=0.000332435 m=(1)
mp4 (\5\:Db Eb net473 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=5.805e-14 ps=1.05e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=7.55e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp2 (\5\:Db \6\:E net425 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.805e-14 ps=5.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=4.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (net425 \6\:net502 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.69e-14 ad=1.29e-14 ps=1.52e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=3.35e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp57 (\1\:QN net502 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.69e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp56 (\7\:net502 net536 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.073e-13 ad=5.375e-14 ps=1.87e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=4.05e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp10 (\10\:SEb \6\:SE \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.073e-13 ad=3.01e-14 ps=1.87e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.4e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp11 (\5\:Dbp \5\:SE \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.945e-14 ps=7.1e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp13 (\5\:Dbp \3\:SEb net465 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.945e-14 ps=5.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=6.3e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp12 (net465 \1\:SI \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0352e-13 ad=1.72e-14 ps=1.72e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=5.05e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp55 (\3\:Q \4\:net536 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0352e-13 ad=3.977e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.85e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp45 (\13\:net536 n30 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.955e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp50 (net457 \10\:net536 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.687e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp51 (\8\:n30 \2\:CKbb net457 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=5.267e-14 ps=6.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.58e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\8\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=5.267e-14 ps=1.18e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.29e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp30 (\4\:mout \3\:n20 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=8.062e-14 ps=1.78e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=8.7e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp35 (net437 \3\:mout \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=1.29e-14 ps=1.78e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=6.05e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp36 (\8\:n20 \4\:CKb net437 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.595e-06 sb=5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp25 (\8\:n20 \5\:CKbb Dbp VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=4.085e-14 ps=9.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=2.65e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp21 (\8\:CKbb \9\:CKb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=3.01e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=16.6557 \
        scb=0.0159745 scc=0.000820274 m=(1)
mp20 (\10\:CKb \1\:CK \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=3.01e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=22.504 \
        scb=0.0257568 scc=0.00118856 m=(1)
C1 (E VSS) capacitor c=3.35266e-17
C2 (Q VSS) capacitor c=5.14706e-17
C3 (SI VSS) capacitor c=8.72545e-17
C4 (QN VSS) capacitor c=5.00403e-17
C5 (VDD VSS) capacitor c=4.94861e-16
C6 (SE VSS) capacitor c=6.83967e-17
C7 (Eb VSS) capacitor c=2.31486e-17
C8 (net554 VSS) capacitor c=1.26437e-18
C9 (Db VSS) capacitor c=8.85508e-17
C10 (net514 VSS) capacitor c=2.25811e-18
C11 (net502 VSS) capacitor c=2.82345e-17
C12 (net536 VSS) capacitor c=4.60946e-17
C13 (SEb VSS) capacitor c=4.97645e-17
C14 (Dbp VSS) capacitor c=7.08803e-17
C15 (net546 VSS) capacitor c=1.49514e-18
C16 (n30 VSS) capacitor c=2.82456e-17
C17 (net534 VSS) capacitor c=3.38808e-18
C18 (CKb VSS) capacitor c=2.13362e-17
C19 (mout VSS) capacitor c=3.21952e-17
C20 (CKbb VSS) capacitor c=3.16751e-17
C21 (n20 VSS) capacitor c=3.59834e-17
C22 (net526 VSS) capacitor c=9.1449e-19
C23 (net473 VSS) capacitor c=7.19064e-18
C24 (net425 VSS) capacitor c=7.47869e-19
C25 (net465 VSS) capacitor c=2.16936e-18
C26 (net457 VSS) capacitor c=2.27913e-18
C27 (net437 VSS) capacitor c=7.04986e-19
C28 (\1\:CK VSS) capacitor c=3.29513e-17
C29 (\9\:CKb VSS) capacitor c=3.41472e-17
C30 (\5\:CKbb VSS) capacitor c=2.60617e-17
C31 (\4\:CKb VSS) capacitor c=6.87616e-17
C32 (\3\:mout VSS) capacitor c=7.88291e-17
C33 (\3\:n20 VSS) capacitor c=3.63018e-17
C34 (\2\:CKb VSS) capacitor c=5.34045e-17
C35 (\2\:CKbb VSS) capacitor c=4.8506e-17
C36 (\10\:net536 VSS) capacitor c=4.82074e-17
C37 (\4\:net536 VSS) capacitor c=3.4424e-17
C38 (\1\:SI VSS) capacitor c=7.19026e-17
C39 (\3\:SEb VSS) capacitor c=5.29765e-17
C40 (\5\:SE VSS) capacitor c=3.40737e-17
C41 (\6\:SE VSS) capacitor c=3.41399e-17
C42 (\6\:net502 VSS) capacitor c=6.14933e-17
C43 (\6\:E VSS) capacitor c=5.6257e-17
C44 (\1\:D VSS) capacitor c=3.98917e-17
C45 (\1\:E VSS) capacitor c=5.02296e-17
C46 (\3\:CK VSS) capacitor c=3.8471e-17
C47 (\6\:CKb VSS) capacitor c=2.27278e-17
C48 (\8\:CKb VSS) capacitor c=5.01189e-17
C49 (\7\:CKbb VSS) capacitor c=4.35485e-17
C50 (\3\:CKbb VSS) capacitor c=4.38288e-17
C51 (\3\:CKb VSS) capacitor c=6.78455e-17
C52 (\7\:net536 VSS) capacitor c=3.50308e-17
C53 (\3\:n30 VSS) capacitor c=4.56676e-17
C54 (\5\:net536 VSS) capacitor c=4.71732e-17
C55 (\3\:SI VSS) capacitor c=2.74777e-17
C56 (\1\:SE VSS) capacitor c=6.0631e-17
C57 (\7\:SE VSS) capacitor c=2.83198e-17
C58 (\3\:net536 VSS) capacitor c=3.43041e-17
C59 (\5\:net502 VSS) capacitor c=1.56255e-17
C60 (\4\:net502 VSS) capacitor c=4.10733e-17
C61 (\3\:Eb VSS) capacitor c=5.63937e-17
C62 (\4\:E VSS) capacitor c=5.51659e-17
C63 (\3\:D VSS) capacitor c=4.52202e-17
C64 (\3\:E VSS) capacitor c=2.37069e-17
C65 (\2\:CK VSS) capacitor c=3.51516e-17
C66 (\7\:CKb VSS) capacitor c=4.4266e-17
C67 (\6\:CKbb VSS) capacitor c=3.47379e-17
C68 (\5\:CKb VSS) capacitor c=2.71996e-17
C69 (\2\:mout VSS) capacitor c=4.59075e-17
C70 (\2\:n20 VSS) capacitor c=4.71923e-17
C71 (\4\:CKbb VSS) capacitor c=4.33043e-17
C72 (\9\:net536 VSS) capacitor c=5.16644e-17
C73 (\2\:n30 VSS) capacitor c=3.28121e-17
C74 (\6\:net536 VSS) capacitor c=1.81444e-17
C75 (\2\:SI VSS) capacitor c=4.52988e-17
C76 (\4\:SEb VSS) capacitor c=4.90689e-17
C77 (\2\:SEb VSS) capacitor c=2.49734e-17
C78 (\4\:SE VSS) capacitor c=2.32666e-17
C79 (\2\:net536 VSS) capacitor c=2.19927e-17
C80 (\7\:E VSS) capacitor c=4.89663e-17
C81 (\2\:Eb VSS) capacitor c=3.50545e-17
C82 (\5\:E VSS) capacitor c=3.54361e-17
C83 (\2\:D VSS) capacitor c=4.95204e-17
C84 (\2\:E VSS) capacitor c=4.64054e-17
C85 (\10\:CKb VSS) capacitor c=2.50624e-17
C86 (\8\:VDD VSS) capacitor c=5.4448e-17
C87 (\8\:n20 VSS) capacitor c=3.77724e-17
C88 (\1\:VDD VSS) capacitor c=2.11747e-17
C89 (\4\:mout VSS) capacitor c=6.06896e-17
C90 (\8\:n30 VSS) capacitor c=3.52908e-17
C91 (\10\:VDD VSS) capacitor c=5.5321e-17
C92 (\13\:net536 VSS) capacitor c=9.11804e-17
C93 (\3\:Q VSS) capacitor c=6.9999e-17
C94 (\12\:VDD VSS) capacitor c=3.17673e-17
C95 (\5\:Dbp VSS) capacitor c=4.69603e-16
C96 (\3\:Db VSS) capacitor c=2.51014e-16
C97 (\10\:SEb VSS) capacitor c=5.82061e-17
C98 (\15\:VDD VSS) capacitor c=1.68714e-17
C99 (\7\:net502 VSS) capacitor c=6.724e-17
C100 (\1\:QN VSS) capacitor c=5.40856e-17
C101 (\18\:VDD VSS) capacitor c=1.18167e-17
C102 (\5\:Db VSS) capacitor c=2.08687e-16
C103 (\22\:VDD VSS) capacitor c=3.78937e-17
C104 (\8\:Eb VSS) capacitor c=6.32421e-18
C105 (\5\:VDD VSS) capacitor c=1.13424e-16
C106 (\16\:CKb VSS) capacitor c=5.48265e-17
C107 (\10\:CKbb VSS) capacitor c=6.81623e-17
C108 (\3\:Dbp VSS) capacitor c=3.847e-16
C109 (\4\:n20 VSS) capacitor c=6.8727e-17
C110 (\7\:mout VSS) capacitor c=4.55806e-17
C111 (\4\:n30 VSS) capacitor c=7.34524e-17
C112 (\15\:net536 VSS) capacitor c=2.4605e-17
C113 (\1\:Q VSS) capacitor c=5.97114e-17
C114 (\7\:Dbp VSS) capacitor c=1.09671e-16
C115 (\7\:SEb VSS) capacitor c=8.67143e-17
C116 (\9\:net502 VSS) capacitor c=1.07046e-16
C117 (\3\:QN VSS) capacitor c=4.87117e-17
C118 (\7\:Db VSS) capacitor c=1.14812e-16
C119 (\6\:Eb VSS) capacitor c=6.00629e-17
C120 (\3\:net502 VSS) capacitor c=5.48927e-17
C121 (\2\:SE VSS) capacitor c=7.16652e-17
C122 (\3\:SE VSS) capacitor c=2.12452e-17
C123 (\4\:D VSS) capacitor c=5.60871e-17
C124 (\6\:D VSS) capacitor c=4.50625e-17
C125 (\4\:Eb VSS) capacitor c=7.23188e-17
C126 (\5\:Eb VSS) capacitor c=1.06519e-16
C127 (\8\:E VSS) capacitor c=1.44345e-16
C128 (\9\:E VSS) capacitor c=1.00589e-16
C129 (\10\:E VSS) capacitor c=5.85091e-17
C130 (\11\:E VSS) capacitor c=1.66877e-17
C131 (\11\:net502 VSS) capacitor c=1.15435e-16
C132 (\8\:SE VSS) capacitor c=4.36117e-17
C133 (\5\:SEb VSS) capacitor c=9.68162e-17
C134 (\6\:SEb VSS) capacitor c=1.15983e-16
C135 (\9\:SEb VSS) capacitor c=2.95868e-17
C136 (\4\:SI VSS) capacitor c=2.76249e-17
C137 (\11\:net536 VSS) capacitor c=5.48868e-17
C138 (\12\:net536 VSS) capacitor c=4.47618e-17
C139 (\17\:net536 VSS) capacitor c=1.85e-16
C140 (\18\:net536 VSS) capacitor c=1.62314e-16
C141 (\6\:n30 VSS) capacitor c=6.93655e-17
C142 (\7\:n30 VSS) capacitor c=5.7093e-17
C143 (\6\:mout VSS) capacitor c=4.31803e-17
C144 (\9\:mout VSS) capacitor c=5.33356e-17
C145 (\6\:n20 VSS) capacitor c=5.9181e-17
C146 (\7\:n20 VSS) capacitor c=5.76477e-17
C147 (\9\:CKbb VSS) capacitor c=1.06862e-16
C148 (\12\:CKbb VSS) capacitor c=1.59509e-16
C149 (\13\:CKbb VSS) capacitor c=5.94686e-17
C150 (\14\:CKbb VSS) capacitor c=1.34603e-16
C151 (\15\:CKbb VSS) capacitor c=3.67243e-17
C152 (\12\:CKb VSS) capacitor c=1.44935e-16
C153 (\13\:CKb VSS) capacitor c=7.48612e-17
C154 (\14\:CKb VSS) capacitor c=1.44479e-16
C155 (\15\:CKb VSS) capacitor c=8.25516e-17
C156 (\4\:CK VSS) capacitor c=9.56998e-17
C157 (\3\:VDD VSS) capacitor c=3.53589e-17
C158 (\4\:VDD VSS) capacitor c=4.18097e-17
C159 (\14\:VDD VSS) capacitor c=4.302e-17
C160 (\17\:VDD VSS) capacitor c=2.49906e-17
C161 (\21\:VDD VSS) capacitor c=1.30671e-17
Rk8 (\9\:E E) resistor r=0.02565 c=0
Rk7 (\8\:E \9\:E) resistor r=1.0099 c=0
Rk9 (E \10\:E) resistor r=0.2775 c=0
Rk10 (\9\:E \11\:E) resistor r=0.06846 c=0
Rk55 (CK \4\:CK) resistor r=0.002335 c=0
Rk1 (\4\:D D) resistor r=0.00236 c=0
Rk3 (\4\:D \6\:D) resistor r=0.0559 c=0
Rk2 (\5\:D \6\:D) resistor r=0.00236 c=0
Rk26 (Q \2\:Q) resistor r=0.1421 c=0
Rk27 (Q \4\:Q) resistor r=0.2646 c=0
Rk25 (\4\:SI SI) resistor r=0.02102 c=0
Rk11 (\2\:QN QN) resistor r=0.2871 c=0
Rk12 (QN \4\:QN) resistor r=0.07112 c=0
Rk71 (\2\:VDD \3\:VDD) resistor r=0.04331 c=0
Rk72 (\3\:VDD \4\:VDD) resistor r=0.5579 c=0
Rk73 (\4\:VDD \6\:VDD) resistor r=0.4312 c=0
Rk74 (\3\:VDD \7\:VDD) resistor r=0.212 c=0
Rk75 (\7\:VDD \9\:VDD) resistor r=0.5494 c=0
Rk76 (\4\:VDD \11\:VDD) resistor r=0.3984 c=0
Rk77 (\6\:VDD \13\:VDD) resistor r=0.149 c=0
Rk78 (\6\:VDD \14\:VDD) resistor r=0.5788 c=0
Rk79 (\14\:VDD \16\:VDD) resistor r=0.04331 c=0
Rk80 (\14\:VDD \17\:VDD) resistor r=0.4325 c=0
Rk81 (\17\:VDD \19\:VDD) resistor r=0.07393 c=0
Rk82 (\17\:VDD \20\:VDD) resistor r=0.1904 c=0
Rk85 (\21\:VDD VDD) resistor r=0.2202 c=0
Rk83 (\20\:VDD \21\:VDD) resistor r=0.3308 c=0
Rk84 (\21\:VDD \23\:VDD) resistor r=0.2864 c=0
Rk56 (\2\:VSS \4\:VSS) resistor r=0.6923 c=0
Rk57 (\4\:VSS \5\:VSS) resistor r=0.1703 c=0
Rk58 (\5\:VSS \6\:VSS) resistor r=0.5463 c=0
Rk59 (\6\:VSS \7\:VSS) resistor r=0.4863 c=0
Rk60 (\5\:VSS \9\:VSS) resistor r=0.1227 c=0
Rk61 (\6\:VSS \11\:VSS) resistor r=0.1227 c=0
Rk62 (\7\:VSS \12\:VSS) resistor r=0.5948 c=0
Rk63 (\12\:VSS \13\:VSS) resistor r=0.5388 c=0
Rk64 (\13\:VSS \14\:VSS) resistor r=0.07002 c=0
Rk66 (\15\:VSS VSS) resistor r=0.155 c=0
Rk65 (\14\:VSS \15\:VSS) resistor r=0.396 c=0
Rk67 (\7\:VSS \17\:VSS) resistor r=0.328 c=0
Rk68 (\12\:VSS \19\:VSS) resistor r=0.3891 c=0
Rk69 (\13\:VSS \21\:VSS) resistor r=0.07393 c=0
Rk70 (\15\:VSS \23\:VSS) resistor r=0.3048 c=0
Rk15 (\8\:SE SE) resistor r=0.09696 c=0
Rk4 (\4\:Eb \5\:Eb) resistor r=0.5379 c=0
Rk5 (\5\:Eb \7\:Eb) resistor r=0.5558 c=0
Rk6 (\5\:Eb \9\:Eb) resistor r=0.0279 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.4924 c=0
Rk17 (\4\:Db \6\:Db) resistor r=1.4859 c=0
Rk18 (\6\:Db \8\:Db) resistor r=0.6842 c=0
Rk13 (\8\:net502 \10\:net502) resistor r=0.2782 c=0
Rk14 (\10\:net502 \11\:net502) resistor r=0.8766 c=0
Rk28 (\11\:net536 \12\:net536) resistor r=0.254 c=0
Rk29 (\12\:net536 \14\:net536) resistor r=0.3363 c=0
Rk30 (\12\:net536 \16\:net536) resistor r=0.1205 c=0
Rk31 (\14\:net536 \17\:net536) resistor r=0.5297 c=0
Rk32 (\17\:net536 \18\:net536) resistor r=1.1628 c=0
Rk19 (\5\:SEb \6\:SEb) resistor r=0.6386 c=0
Rk20 (\6\:SEb \8\:SEb) resistor r=0.5401 c=0
Rk21 (\6\:SEb \9\:SEb) resistor r=0.02283 c=0
Rk22 (\8\:SEb \11\:SEb) resistor r=0.2589 c=0
Rk42 (\2\:Dbp \4\:Dbp) resistor r=0.3557 c=0
Rk43 (\4\:Dbp \6\:Dbp) resistor r=3.1556 c=0
Rk44 (\6\:Dbp \8\:Dbp) resistor r=0.5405 c=0
Rk33 (\5\:n30 \6\:n30) resistor r=0.4704 c=0
Rk34 (\6\:n30 \7\:n30) resistor r=0.2542 c=0
Rk35 (\6\:n30 \9\:n30) resistor r=0.2161 c=0
Rk50 (\11\:CKb \12\:CKb) resistor r=0.1976 c=0
Rk51 (\12\:CKb \13\:CKb) resistor r=0.365 c=0
Rk52 (\12\:CKb \14\:CKb) resistor r=0.761 c=0
Rk53 (\14\:CKb \15\:CKb) resistor r=0.6275 c=0
Rk54 (\13\:CKb \17\:CKb) resistor r=0.3047 c=0
Rk36 (\5\:mout \6\:mout) resistor r=0.2459 c=0
Rk37 (\6\:mout \8\:mout) resistor r=0.1771 c=0
Rk38 (\6\:mout \9\:mout) resistor r=0.2484 c=0
Rk45 (\9\:CKbb \11\:CKbb) resistor r=0.4367 c=0
Rk46 (\9\:CKbb \12\:CKbb) resistor r=0.4129 c=0
Rk47 (\12\:CKbb \13\:CKbb) resistor r=0.2339 c=0
Rk48 (\12\:CKbb \14\:CKbb) resistor r=0.9742 c=0
Rk49 (\14\:CKbb \15\:CKbb) resistor r=0.1916 c=0
Rk39 (\5\:n20 \6\:n20) resistor r=0.3813 c=0
Rk40 (\6\:n20 \7\:n20) resistor r=0.2473 c=0
Rk41 (\6\:n20 \9\:n20) resistor r=0.09076 c=0
Rl8 (\6\:E \7\:E) resistor r=71.8456 c=0
Rl5 (\4\:E \5\:E) resistor r=29.5379 c=0
Rl1 (\1\:E \2\:E) resistor r=171.131 c=0
Rl2 (\2\:E \3\:E) resistor r=24.7951 c=0
Rl47 (\1\:CK \2\:CK) resistor r=58.3841 c=0
Rl48 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl3 (\1\:D \2\:D) resistor r=85.3072 c=0
Rl4 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl24 (\1\:SI \2\:SI) resistor r=145.387 c=0
Rl25 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl22 (\4\:SE \7\:SE) resistor r=43.4636 c=0
Rl20 (\2\:SE \5\:SE) resistor r=72.7584 c=0
Rl17 (\1\:SE \2\:SE) resistor r=176.467 c=0
Rl21 (\3\:SE \6\:SE) resistor r=22.7584 c=0
Rl19 (\3\:SE \4\:SE) resistor r=14.4132 c=0
Rl18 (\2\:SE \3\:SE) resistor r=179.236 c=0
Rl6 (Eb \2\:Eb) resistor r=26.098 c=0
Rl7 (\2\:Eb \3\:Eb) resistor r=129.944 c=0
Rl9 (net502 \2\:net502) resistor r=158.232 c=0
Rl12 (\2\:net502 \5\:net502) resistor r=37.8013 c=0
Rl13 (\3\:net502 \6\:net502) resistor r=130.464 c=0
Rl11 (\3\:net502 \4\:net502) resistor r=119.768 c=0
Rl10 (\2\:net502 \3\:net502) resistor r=5.848 c=0
Rl26 (\4\:net536 \5\:net536) resistor r=211.538 c=0
Rl15 (net536 \3\:net536) resistor r=98.0769 c=0
Rl27 (\4\:net536 \6\:net536) resistor r=24.2328 c=0
Rl14 (net536 \2\:net536) resistor r=50.6918 c=0
Rl32 (\8\:net536 \10\:net536) resistor r=87.8234 c=0
Rl30 (\7\:net536 \8\:net536) resistor r=77.7541 c=0
Rl31 (\8\:net536 \9\:net536) resistor r=14.3357 c=0
Rl23 (\3\:SEb \4\:SEb) resistor r=71.8456 c=0
Rl16 (SEb \2\:SEb) resistor r=44.9225 c=0
Rl28 (n30 \2\:n30) resistor r=24.2328 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=85.7713 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=159.181 c=0
Rl46 (\7\:CKb \9\:CKb) resistor r=115.929 c=0
Rl44 (\6\:CKb \7\:CKb) resistor r=36.0048 c=0
Rl45 (\7\:CKb \8\:CKb) resistor r=221.257 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=62.2302 c=0
Rl34 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl40 (\2\:mout \3\:mout) resistor r=83.7912 c=0
Rl39 (mout \2\:mout) resistor r=30.7692 c=0
Rl42 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl43 (\6\:CKbb \7\:CKbb) resistor r=98.7985 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=85.7713 c=0
Rl33 (CKbb \2\:CKbb) resistor r=50.334 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=49.131 c=0
Rl37 (n20 \2\:n20) resistor r=76.1559 c=0
Rz7 (\1\:Q \2\:Q) resistor r=75 c=0
Rz2 (\3\:QN \4\:QN) resistor r=75 c=0
Rz23 (\5\:VDD \6\:VDD) resistor r=6.25 c=0
Rz24 (\5\:VDD \7\:VDD) resistor r=6.25 c=0
Rz25 (\5\:VDD \20\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz17 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz18 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz4 (Db \2\:Db) resistor r=75 c=0
Rz5 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:net502 \10\:net502) resistor r=75 c=0
Rz8 (\15\:net536 \16\:net536) resistor r=75 c=0
Rz6 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz12 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz13 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz9 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz15 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz10 (\7\:mout \8\:mout) resistor r=75 c=0
Rz14 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry7 (\3\:Q \4\:Q) resistor r=62 c=0
Ry2 (\1\:QN \2\:QN) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry21 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry22 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry23 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry4 (\3\:Db \4\:Db) resistor r=62 c=0
Ry5 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\7\:net502 \8\:net502) resistor r=62 c=0
Ry8 (\13\:net536 \14\:net536) resistor r=62 c=0
Ry6 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry12 (Dbp \2\:Dbp) resistor r=62 c=0
Ry13 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry15 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry10 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx3 (\7\:E \8\:E) resistor r=45 c=0
Rx4 (\2\:E \10\:E) resistor r=45 c=0
Rx5 (\5\:E \11\:E) resistor r=45 c=0
Rx23 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \5\:D) resistor r=45 c=0
Rx10 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\4\:SE \8\:SE) resistor r=45 c=0
Rx2 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx6 (\2\:net502 \11\:net502) resistor r=45 c=0
Rx11 (\9\:net536 \11\:net536) resistor r=45 c=0
Rx12 (\6\:net536 \17\:net536) resistor r=45 c=0
Rx13 (\2\:net536 \18\:net536) resistor r=45 c=0
Rx8 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx9 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx14 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx22 (CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:mout \9\:mout) resistor r=45 c=0
Rx17 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx18 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx19 (CKbb \15\:CKbb) resistor r=45 c=0
Rx16 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\6\:Eb \3\:E \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.435e-14 ad=2.175e-14 ps=1.05e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.42e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn3 (net554 \3\:D \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.435e-14 ad=1.305e-14 ps=1.05e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.025e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn4 (\7\:Db \4\:E net554 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.537e-14 ps=4.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=8.9e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (\7\:Db \3\:Eb net514 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.537e-14 ps=5.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=6.7e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn1 (net514 \4\:net502 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.69e-14 ad=1.957e-14 ps=1.48e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=4.9e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn57 (\3\:QN \5\:net502 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.69e-14 ad=3.262e-14 ps=1.48e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=2.25e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn56 (\9\:net502 \3\:net536 \18\:VSS VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.2e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\7\:SEb \7\:SE \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (Db SEb \7\:Dbp VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn13 (\7\:Dbp \1\:SE net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.537e-14 ps=6.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6.7e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn12 (net546 \3\:SI \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=2.392e-14 ps=8.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.6e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn55 (\1\:Q \5\:net536 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\15\:net536 \3\:n30 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.455e-14 ad=3.407e-14 ps=1.42e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.955e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn50 (net534 \7\:net536 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.455e-14 ad=2.972e-14 ps=1.42e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.64e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn51 (\4\:n30 \3\:CKb net534 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.39e-06 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.712e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.185e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\7\:mout n20 \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=4.713e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=8.15e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (net526 mout \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=2.32e-14 ps=1.32e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=5.5e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn36 (\4\:n20 \7\:CKbb net526 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn25 (\3\:Dbp \8\:CKb \4\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn21 (\10\:CKbb \6\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\16\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
ends SEDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:26 2013 )
// Library name: gsclib045_hvt
// Cell name: SMDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX1 CK D0 D1 Q S0 SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=31.1408 \
        scb=0.033664 scc=0.00281778 m=(1)
mp12 (net417 \4\:SI \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.695e-14 ad=2.34e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.73654e-07 sb=5.13333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp13 (\8\:dbp \2\:SEb net417 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.78654e-07 sb=4.08333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp11 (\8\:dbp \6\:SE \5\:db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.83654e-07 sb=2.03333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp1 (net425 \4\:D0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=11.6718 \
        scb=0.0096151 scc=0.000231869 m=(1)
mp3 (net429 \1\:D1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=13.0988 \
        scb=0.0108483 scc=0.000234868 m=(1)
C1 (CK VSS) capacitor c=5.87284e-17
C2 (S0 VSS) capacitor c=8.14845e-17
C3 (VDD VSS) capacitor c=3.56233e-16
C4 (SE VSS) capacitor c=7.40388e-17
C5 (D1 VSS) capacitor c=1.13439e-16
C6 (SI VSS) capacitor c=5.09666e-17
C7 (qbint VSS) capacitor c=2.28288e-17
C8 (CKb VSS) capacitor c=4.78071e-17
C9 (n30 VSS) capacitor c=5.97201e-17
C10 (net482 VSS) capacitor c=2.77605e-18
C11 (mout VSS) capacitor c=6.35276e-17
C12 (CKbb VSS) capacitor c=2.42917e-17
C13 (n20 VSS) capacitor c=4.05304e-17
C14 (net474 VSS) capacitor c=6.70793e-19
C15 (dbp VSS) capacitor c=8.84193e-17
C16 (db VSS) capacitor c=1.23593e-16
C17 (SEb VSS) capacitor c=5.5492e-17
C18 (net498 VSS) capacitor c=6.50309e-18
C19 (S0b VSS) capacitor c=3.40782e-17
C20 (net409 VSS) capacitor c=8.55417e-18
C21 (net393 VSS) capacitor c=5.52914e-18
C22 (net417 VSS) capacitor c=1.63895e-18
C23 (net425 VSS) capacitor c=1.71352e-18
C24 (net429 VSS) capacitor c=7.45545e-18
C25 (\8\:S0 VSS) capacitor c=5.12558e-17
C26 (\1\:D1 VSS) capacitor c=5.47347e-17
C27 (\2\:S0 VSS) capacitor c=7.25887e-17
C28 (\4\:D0 VSS) capacitor c=9.9905e-17
C29 (\5\:SE VSS) capacitor c=4.71704e-17
C30 (\6\:SE VSS) capacitor c=3.16381e-17
C31 (\2\:SEb VSS) capacitor c=7.25862e-17
C32 (\4\:SI VSS) capacitor c=8.91151e-17
C33 (\10\:CKb VSS) capacitor c=6.06263e-17
C34 (\7\:CKbb VSS) capacitor c=3.86459e-17
C35 (\8\:CKb VSS) capacitor c=4.16514e-17
C36 (\3\:CKb VSS) capacitor c=2.37686e-17
C37 (\3\:CKbb VSS) capacitor c=6.34436e-17
C38 (\5\:qbint VSS) capacitor c=6.62738e-17
C39 (\1\:CK VSS) capacitor c=3.21291e-17
C40 (\4\:qbint VSS) capacitor c=4.72324e-17
C41 (\7\:S0 VSS) capacitor c=3.35002e-17
C42 (\3\:D1 VSS) capacitor c=8.62299e-17
C43 (\3\:S0 VSS) capacitor c=7.09764e-17
C44 (\3\:S0b VSS) capacitor c=6.09148e-17
C45 (\1\:D0 VSS) capacitor c=5.32682e-17
C46 (\1\:SE VSS) capacitor c=4.21403e-17
C47 (\3\:SEb VSS) capacitor c=3.65247e-17
C48 (\4\:SE VSS) capacitor c=8.67695e-17
C49 (\1\:SI VSS) capacitor c=7.03975e-17
C50 (\5\:CKb VSS) capacitor c=4.42613e-17
C51 (\11\:CKb VSS) capacitor c=2.46432e-17
C52 (\5\:CKbb VSS) capacitor c=5.47157e-17
C53 (\4\:mout VSS) capacitor c=5.38672e-17
C54 (\3\:n20 VSS) capacitor c=4.77619e-17
C55 (\7\:qbint VSS) capacitor c=5.99718e-17
C56 (\3\:n30 VSS) capacitor c=2.82061e-17
C57 (\3\:CK VSS) capacitor c=4.33258e-17
C58 (\3\:qbint VSS) capacitor c=2.94788e-17
C59 (\5\:S0 VSS) capacitor c=1.13952e-17
C60 (\2\:D1 VSS) capacitor c=5.14536e-17
C61 (\4\:S0 VSS) capacitor c=4.61606e-17
C62 (\2\:S0b VSS) capacitor c=6.79446e-17
C63 (\1\:S0 VSS) capacitor c=5.15059e-17
C64 (\3\:D0 VSS) capacitor c=2.49441e-17
C65 (\2\:SE VSS) capacitor c=7.57605e-17
C66 (\4\:SEb VSS) capacitor c=4.10792e-17
C67 (\3\:SI VSS) capacitor c=3.28471e-17
C68 (\8\:CKbb VSS) capacitor c=3.2118e-17
C69 (\9\:CKb VSS) capacitor c=2.63145e-17
C70 (\6\:CKbb VSS) capacitor c=3.75114e-17
C71 (\3\:mout VSS) capacitor c=1.80499e-17
C72 (\2\:n20 VSS) capacitor c=3.68046e-17
C73 (\4\:CKbb VSS) capacitor c=2.00818e-17
C74 (\4\:CKb VSS) capacitor c=2.81594e-17
C75 (\2\:CKb VSS) capacitor c=5.47215e-17
C76 (\6\:qbint VSS) capacitor c=5.17129e-17
C77 (\2\:n30 VSS) capacitor c=4.13342e-17
C78 (\2\:CK VSS) capacitor c=2.7344e-17
C79 (\6\:S0b VSS) capacitor c=1.06764e-16
C80 (\1\:VDD VSS) capacitor c=2.76418e-17
C81 (\7\:db VSS) capacitor c=4.91776e-17
C82 (\7\:VDD VSS) capacitor c=3.71036e-17
C83 (\10\:SEb VSS) capacitor c=1.08063e-16
C84 (\5\:db VSS) capacitor c=3.69654e-17
C85 (\8\:dbp VSS) capacitor c=6.28124e-17
C86 (\9\:VDD VSS) capacitor c=4.69705e-17
C87 (\15\:CKbb VSS) capacitor c=7.42003e-17
C88 (\4\:dbp VSS) capacitor c=1.00302e-16
C89 (\4\:n20 VSS) capacitor c=6.83114e-17
C90 (\12\:VDD VSS) capacitor c=3.8501e-17
C91 (\9\:mout VSS) capacitor c=6.03535e-17
C92 (\8\:n30 VSS) capacitor c=9.74052e-17
C93 (\15\:VDD VSS) capacitor c=3.38631e-17
C94 (\12\:qbint VSS) capacitor c=4.37521e-17
C95 (\15\:CKb VSS) capacitor c=9.02884e-17
C96 (\18\:VDD VSS) capacitor c=3.66787e-17
C97 (\1\:Q VSS) capacitor c=5.70459e-17
C98 (\3\:VDD VSS) capacitor c=1.31582e-16
C99 (\4\:S0b VSS) capacitor c=8.08513e-17
C100 (\5\:SEb VSS) capacitor c=8.68371e-17
C101 (\9\:db VSS) capacitor c=9.89133e-17
C102 (\9\:CKbb VSS) capacitor c=6.2498e-17
C103 (\6\:dbp VSS) capacitor c=8.08449e-17
C104 (\8\:n20 VSS) capacitor c=6.7573e-17
C105 (\7\:mout VSS) capacitor c=5.01007e-17
C106 (\4\:n30 VSS) capacitor c=1.82155e-17
C107 (\10\:qbint VSS) capacitor c=8.39421e-17
C108 (\17\:CKb VSS) capacitor c=5.77219e-17
C109 (\3\:Q VSS) capacitor c=5.37768e-17
C110 (\2\:qbint VSS) capacitor c=1.57265e-17
C111 (\2\:CKbb VSS) capacitor c=5.03385e-17
C112 (\2\:mout VSS) capacitor c=3.89394e-17
C113 (\6\:CKb VSS) capacitor c=5.55332e-17
C114 (\7\:CKb VSS) capacitor c=5.04032e-17
C115 (\2\:SI VSS) capacitor c=3.49556e-17
C116 (\3\:SE VSS) capacitor c=6.90853e-17
C117 (\2\:D0 VSS) capacitor c=4.23486e-17
C118 (\4\:CK VSS) capacitor c=5.67574e-17
C119 (\6\:S0 VSS) capacitor c=3.20513e-17
C120 (\8\:qbint VSS) capacitor c=3.76831e-17
C121 (\9\:qbint VSS) capacitor c=3.91866e-17
C122 (\14\:qbint VSS) capacitor c=1.4058e-16
C123 (\6\:n30 VSS) capacitor c=6.70566e-17
C124 (\7\:n30 VSS) capacitor c=7.40175e-17
C125 (\5\:mout VSS) capacitor c=4.56729e-17
C126 (\6\:mout VSS) capacitor c=5.68146e-17
C127 (\12\:CKb VSS) capacitor c=4.97662e-17
C128 (\13\:CKb VSS) capacitor c=1.00179e-16
C129 (\14\:CKb VSS) capacitor c=1.22766e-16
C130 (\19\:CKb VSS) capacitor c=1.02698e-16
C131 (\20\:CKb VSS) capacitor c=6.87842e-17
C132 (\6\:n20 VSS) capacitor c=8.12176e-17
C133 (\7\:n20 VSS) capacitor c=6.30554e-17
C134 (\11\:CKbb VSS) capacitor c=9.13844e-17
C135 (\12\:CKbb VSS) capacitor c=1.2065e-16
C136 (\13\:CKbb VSS) capacitor c=1.16259e-16
C137 (\14\:CKbb VSS) capacitor c=1.1296e-16
C138 (\17\:CKbb VSS) capacitor c=5.84584e-17
C139 (\5\:SI VSS) capacitor c=7.48702e-17
C140 (\3\:dbp VSS) capacitor c=9.9465e-17
C141 (\8\:SE VSS) capacitor c=6.40541e-17
C142 (\7\:SEb VSS) capacitor c=7.81403e-17
C143 (\8\:SEb VSS) capacitor c=9.63183e-17
C144 (\9\:SEb VSS) capacitor c=3.78575e-17
C145 (\5\:D0 VSS) capacitor c=1.31259e-16
C146 (\3\:db VSS) capacitor c=1.29619e-16
C147 (\4\:db VSS) capacitor c=1.15662e-16
C148 (\9\:S0 VSS) capacitor c=7.51474e-17
C149 (\11\:S0 VSS) capacitor c=5.3796e-17
C150 (\8\:S0b VSS) capacitor c=7.29295e-17
C151 (\5\:VDD VSS) capacitor c=5.16641e-17
C152 (\11\:VDD VSS) capacitor c=4.51169e-17
C153 (\17\:VDD VSS) capacitor c=1.44556e-17
Rk41 (\5\:D0 D0) resistor r=0.003002 c=0
Rk1 (\2\:Q Q) resistor r=0.3602 c=0
Rk2 (Q \4\:Q) resistor r=0.05967 c=0
Rk3 (\4\:CK CK) resistor r=0.1973 c=0
Rk48 (\9\:S0 S0) resistor r=0.3968 c=0
Rk49 (S0 \10\:S0) resistor r=0.002702 c=0
Rk50 (\10\:S0 \11\:S0) resistor r=0.3244 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.2504 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.3359 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5666 c=0
Rk56 (\5\:VDD \8\:VDD) resistor r=0.1786 c=0
Rk57 (\6\:VDD \10\:VDD) resistor r=0.2807 c=0
Rk58 (\6\:VDD \11\:VDD) resistor r=0.5822 c=0
Rk59 (\11\:VDD \13\:VDD) resistor r=0.2196 c=0
Rk60 (\11\:VDD \14\:VDD) resistor r=0.6224 c=0
Rk61 (\14\:VDD \16\:VDD) resistor r=0.266 c=0
Rk64 (\17\:VDD VDD) resistor r=0.1099 c=0
Rk62 (\14\:VDD \17\:VDD) resistor r=0.4412 c=0
Rk63 (\17\:VDD \19\:VDD) resistor r=0.2722 c=0
Rk36 (SE \8\:SE) resistor r=0.01201 c=0
Rk47 (\4\:D1 D1) resistor r=0.01279 c=0
Rk29 (\5\:SI SI) resistor r=0.01802 c=0
Rk65 (\2\:VSS \4\:VSS) resistor r=0.3522 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.3183 c=0
Rk67 (\5\:VSS \6\:VSS) resistor r=0.5338 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.04996 c=0
Rk69 (\7\:VSS \8\:VSS) resistor r=0.5656 c=0
Rk70 (\8\:VSS \9\:VSS) resistor r=0.6358 c=0
Rk71 (\5\:VSS \11\:VSS) resistor r=0.1976 c=0
Rk72 (\6\:VSS \13\:VSS) resistor r=0.2759 c=0
Rk73 (\8\:VSS \15\:VSS) resistor r=0.04331 c=0
Rk75 (\16\:VSS VSS) resistor r=0.1099 c=0
Rk74 (\9\:VSS \16\:VSS) resistor r=0.4418 c=0
Rk76 (\9\:VSS \18\:VSS) resistor r=0.2726 c=0
Rk77 (\16\:VSS \20\:VSS) resistor r=0.2937 c=0
Rk4 (\8\:qbint \9\:qbint) resistor r=0.2116 c=0
Rk5 (\9\:qbint \11\:qbint) resistor r=0.3019 c=0
Rk6 (\9\:qbint \13\:qbint) resistor r=0.1908 c=0
Rk7 (\11\:qbint \14\:qbint) resistor r=0.7181 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.23 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.3637 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.6823 c=0
Rk17 (\16\:CKb \18\:CKb) resistor r=0.274 c=0
Rk18 (\13\:CKb \19\:CKb) resistor r=0.7408 c=0
Rk19 (\14\:CKb \20\:CKb) resistor r=0.3578 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.06093 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.4162 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.3957 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.2421 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.179 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2857 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3701 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2845 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.8729 c=0
Rk26 (\11\:CKbb \14\:CKbb) resistor r=0.3758 c=0
Rk27 (\14\:CKbb \16\:CKbb) resistor r=0.4989 c=0
Rk28 (\12\:CKbb \17\:CKbb) resistor r=0.2347 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2239 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.398 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.2833 c=0
Rk30 (\2\:dbp \3\:dbp) resistor r=0.5918 c=0
Rk31 (\3\:dbp \5\:dbp) resistor r=0.3814 c=0
Rk32 (\5\:dbp \7\:dbp) resistor r=0.4327 c=0
Rk33 (\3\:dbp \9\:dbp) resistor r=0.2187 c=0
Rk42 (\2\:db \3\:db) resistor r=0.8279 c=0
Rk43 (\3\:db \4\:db) resistor r=0.4113 c=0
Rk44 (\4\:db \6\:db) resistor r=0.04027 c=0
Rk45 (\3\:db \8\:db) resistor r=0.1979 c=0
Rk46 (\4\:db \10\:db) resistor r=0.4808 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.5643 c=0
Rk38 (\7\:SEb \8\:SEb) resistor r=0.1767 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.1437 c=0
Rk40 (\8\:SEb \11\:SEb) resistor r=0.6361 c=0
Rk51 (\5\:S0b \7\:S0b) resistor r=0.6607 c=0
Rk52 (\7\:S0b \8\:S0b) resistor r=0.5458 c=0
Rl40 (\2\:D0 \4\:D0) resistor r=76.8641 c=0
Rl38 (\1\:D0 \2\:D0) resistor r=121.734 c=0
Rl39 (\2\:D0 \3\:D0) resistor r=11.665 c=0
Rl4 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl5 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl44 (\3\:S0 \4\:S0) resistor r=43.4636 c=0
Rl41 (\1\:S0 \2\:S0) resistor r=36.4253 c=0
Rl49 (\6\:S0 \8\:S0) resistor r=143.11 c=0
Rl48 (\6\:S0 \7\:S0) resistor r=64.2642 c=0
Rl47 (\5\:S0 \6\:S0) resistor r=3.7334 c=0
Rl36 (\2\:SE \5\:SE) resistor r=148.798 c=0
Rl33 (\1\:SE \2\:SE) resistor r=135.337 c=0
Rl37 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl35 (\3\:SE \4\:SE) resistor r=137.261 c=0
Rl34 (\2\:SE \3\:SE) resistor r=157.169 c=0
Rl45 (\1\:D1 \2\:D1) resistor r=73.7687 c=0
Rl46 (\2\:D1 \3\:D1) resistor r=117.999 c=0
Rl30 (\2\:SI \4\:SI) resistor r=74.4619 c=0
Rl28 (\1\:SI \2\:SI) resistor r=59.125 c=0
Rl29 (\2\:SI \3\:SI) resistor r=15.5599 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=45.8535 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=111.334 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=68.9449 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl25 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl10 (CKb \2\:CKb) resistor r=53.079 c=0
Rl26 (\6\:CKb \10\:CKb) resistor r=207.374 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=86.5164 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=172.62 c=0
Rl27 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=163.852 c=0
Rl6 (n30 \2\:n30) resistor r=117.308 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.9451 c=0
Rl17 (mout \2\:mout) resistor r=128.56 c=0
Rl19 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl18 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl21 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=37.6944 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=178.636 c=0
Rl12 (CKbb \2\:CKbb) resistor r=28.858 c=0
Rl14 (\2\:CKbb \4\:CKbb) resistor r=81.0483 c=0
Rl15 (n20 \2\:n20) resistor r=44.9225 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=100.692 c=0
Rl32 (\3\:SEb \4\:SEb) resistor r=39.1533 c=0
Rl31 (SEb \2\:SEb) resistor r=34.6607 c=0
Rl42 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl43 (\2\:S0b \3\:S0b) resistor r=170.02 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz16 (\3\:VDD \14\:VDD) resistor r=6.25 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz18 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz5 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (dbp \2\:dbp) resistor r=75 c=0
Rz9 (\6\:dbp \7\:dbp) resistor r=75 c=0
Rz11 (db \2\:db) resistor r=75 c=0
Rz12 (\9\:db \10\:db) resistor r=75 c=0
Rz10 (\5\:SEb \6\:SEb) resistor r=75 c=0
Rz13 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry16 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry21 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry22 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry9 (\8\:dbp \9\:dbp) resistor r=31 c=0
Ry11 (\5\:db \6\:db) resistor r=62 c=0
Ry12 (\7\:db \8\:db) resistor r=31 c=0
Ry10 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry13 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\1\:S0 \9\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \10\:S0) resistor r=45 c=0
Rx21 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx14 (\2\:SE \8\:SE) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx3 (qbint \14\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \7\:SEb) resistor r=45 c=0
Rx16 (SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn12 (net490 \1\:SI \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=5.65e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41635e-07 sb=4.6e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=2.25e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn1 (net498 \1\:D0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=8.33365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41058e-07 sb=5.63365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46058e-07 sb=3.58365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn3 (net510 \3\:D1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51058e-07 sb=2.53365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn20 (\17\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\9\:CKbb \5\:CKb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\5\:SEb \1\:SE \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\4\:S0b \7\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn45 (\10\:qbint \3\:n30 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.485e-14 ad=3.485e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mn50 (net482 \7\:qbint \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.485e-14 ad=2.768e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=2e-06 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mn51 (\4\:n30 CKb net482 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.305e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.85e-06 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn40 (\7\:mout CKbb \4\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=1.1377e-13 ps=8.3e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.595e-06 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn30 (\7\:mout \3\:n20 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=1.1377e-13 ps=1.32e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=9.95e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn35 (net474 \4\:mout \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=1.435e-14 ps=1.32e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=7.3e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn36 (\8\:n20 \5\:CKbb net474 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=6.15e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn25 (\6\:dbp \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mp20 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.304 scb=0.0253194 \
        scc=0.00302671 m=(1)
mp21 (\15\:CKbb \10\:CKb \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.695e-14 ad=3.01e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.46279e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp10 (\10\:SEb \5\:SE \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp0 (\6\:S0b \8\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=18.2097 \
        scb=0.0194526 scc=0.000535674 m=(1)
mp45 (\12\:qbint n30 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.1541 scb=0.0174883 \
        scc=0.00172295 m=(1)
mp50 (net409 \5\:qbint \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.83e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 \3\:CKbb net409 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=6.975e-14 ps=9e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.645e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:n30 \3\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.375e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\9\:mout n20 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=1.333e-13 ps=1.32e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=9e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net393 mout \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=6.045e-14 ps=1.32e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=6.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.89e-14 ps=1.01e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=3.95e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=19.1541 scb=0.0174883 \
        scc=0.00172295 m=(1)
ends SMDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:27 2013 )
// Library name: gsclib045_hvt
// Cell name: SMDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX2 CK D0 D1 Q S0 SE SI VDD VSS
mp45 (\12\:qbint \3\:n30 \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.905e-14 ad=5.85e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.39103e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp12 (net417 \4\:SI \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=5.65e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp13 (\6\:dbp \2\:SEb net417 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=9.36e-14 ps=9e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=4.6e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp11 (\6\:dbp \6\:SE \5\:db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=9.36e-14 ps=1.13e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.15321e-07 sb=1.75e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp1 (net425 \1\:D0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=7.99551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=6.94551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=7.02e-14 ps=1.09e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.69551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (net429 \3\:D1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.045e-14 ps=1.16e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65064e-07 sb=2.69551e-07 sd=160n sca=14.0034 \
        scb=0.0123236 scc=0.000647549 m=(1)
mp55 (\1\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.997e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.32436e-07 sd=160n sca=36.0887 \
        scb=0.0354203 scc=0.00361645 m=(2)
C1 (D0 VSS) capacitor c=6.3041e-17
C2 (CK VSS) capacitor c=1.02175e-16
C3 (S0 VSS) capacitor c=2.30981e-17
C4 (Q VSS) capacitor c=3.81186e-17
C5 (VDD VSS) capacitor c=5.29401e-16
C6 (SE VSS) capacitor c=7.82192e-17
C7 (D1 VSS) capacitor c=5.93904e-17
C8 (SI VSS) capacitor c=4.19388e-17
C9 (qbint VSS) capacitor c=1.45711e-16
C10 (CKb VSS) capacitor c=3.90513e-17
C11 (n30 VSS) capacitor c=3.68988e-17
C12 (mout VSS) capacitor c=5.88636e-17
C13 (CKbb VSS) capacitor c=1.89949e-17
C14 (n20 VSS) capacitor c=4.08103e-17
C15 (net474 VSS) capacitor c=2.84767e-19
C16 (dbp VSS) capacitor c=7.84113e-17
C17 (net490 VSS) capacitor c=3.26724e-18
C18 (db VSS) capacitor c=1.02311e-16
C19 (SEb VSS) capacitor c=3.94287e-17
C20 (net498 VSS) capacitor c=7.2523e-18
C21 (S0b VSS) capacitor c=4.20535e-17
C22 (net409 VSS) capacitor c=1.05054e-17
C23 (net393 VSS) capacitor c=5.3009e-18
C24 (net417 VSS) capacitor c=2.26823e-18
C25 (net425 VSS) capacitor c=2.11964e-18
C26 (net429 VSS) capacitor c=4.59827e-18
C27 (\7\:S0 VSS) capacitor c=6.14732e-17
C28 (\3\:D1 VSS) capacitor c=5.27016e-17
C29 (\2\:S0 VSS) capacitor c=7.15509e-17
C30 (\1\:D0 VSS) capacitor c=9.26314e-17
C31 (\1\:SE VSS) capacitor c=6.67475e-17
C32 (\6\:SE VSS) capacitor c=3.44287e-17
C33 (\2\:SEb VSS) capacitor c=8.7032e-17
C34 (\4\:SI VSS) capacitor c=8.77735e-17
C35 (\10\:CKb VSS) capacitor c=5.40423e-17
C36 (\6\:CKbb VSS) capacitor c=3.85224e-17
C37 (\8\:CKb VSS) capacitor c=4.37794e-17
C38 (\3\:mout VSS) capacitor c=5.78157e-17
C39 (\3\:CKb VSS) capacitor c=2.66863e-17
C40 (\3\:CKbb VSS) capacitor c=7.66515e-17
C41 (\8\:qbint VSS) capacitor c=4.435e-17
C42 (\3\:n30 VSS) capacitor c=4.9133e-17
C43 (\1\:CK VSS) capacitor c=3.33541e-17
C44 (\5\:S0 VSS) capacitor c=2.44047e-17
C45 (\1\:D1 VSS) capacitor c=8.1146e-17
C46 (\3\:S0 VSS) capacitor c=7.06136e-17
C47 (\3\:S0b VSS) capacitor c=6.53212e-17
C48 (\4\:D0 VSS) capacitor c=4.6876e-17
C49 (\5\:SE VSS) capacitor c=3.80657e-17
C50 (\3\:SEb VSS) capacitor c=3.81826e-17
C51 (\4\:SE VSS) capacitor c=6.98767e-17
C52 (\1\:SI VSS) capacitor c=5.32555e-17
C53 (\5\:CKb VSS) capacitor c=2.93959e-17
C54 (\11\:CKb VSS) capacitor c=2.55805e-17
C55 (\4\:CKbb VSS) capacitor c=6.22452e-17
C56 (\3\:n20 VSS) capacitor c=4.47517e-17
C57 (\10\:qbint VSS) capacitor c=5.66809e-17
C58 (\3\:CK VSS) capacitor c=3.67856e-17
C59 (\6\:S0 VSS) capacitor c=4.03557e-17
C60 (\2\:D1 VSS) capacitor c=5.09457e-17
C61 (\4\:S0 VSS) capacitor c=4.32975e-17
C62 (\2\:S0b VSS) capacitor c=5.40502e-17
C63 (\1\:S0 VSS) capacitor c=4.63637e-17
C64 (\3\:D0 VSS) capacitor c=2.99988e-17
C65 (\2\:SE VSS) capacitor c=6.81912e-17
C66 (\4\:SEb VSS) capacitor c=4.11894e-17
C67 (\3\:SI VSS) capacitor c=2.57848e-17
C68 (\7\:CKbb VSS) capacitor c=3.44441e-17
C69 (\9\:CKb VSS) capacitor c=2.37516e-17
C70 (\5\:CKbb VSS) capacitor c=4.1965e-17
C71 (\2\:mout VSS) capacitor c=5.85364e-17
C72 (\2\:n20 VSS) capacitor c=3.40146e-17
C73 (\2\:CKbb VSS) capacitor c=4.39717e-17
C74 (\4\:CKb VSS) capacitor c=3.86557e-17
C75 (\2\:CKb VSS) capacitor c=3.81086e-17
C76 (\9\:qbint VSS) capacitor c=4.62597e-17
C77 (\2\:n30 VSS) capacitor c=2.74563e-17
C78 (\2\:CK VSS) capacitor c=2.57544e-17
C79 (\6\:S0b VSS) capacitor c=1.16391e-16
C80 (\1\:VDD VSS) capacitor c=3.01583e-17
C81 (\7\:db VSS) capacitor c=6.71371e-17
C82 (\14\:VDD VSS) capacitor c=4.55356e-17
C83 (\5\:SEb VSS) capacitor c=9.93462e-17
C84 (\5\:db VSS) capacitor c=4.45255e-17
C85 (\6\:dbp VSS) capacitor c=5.34499e-17
C86 (\16\:VDD VSS) capacitor c=4.39877e-17
C87 (\14\:CKbb VSS) capacitor c=7.66686e-17
C88 (\4\:dbp VSS) capacitor c=1.03742e-16
C89 (\4\:n20 VSS) capacitor c=6.31022e-17
C90 (\18\:VDD VSS) capacitor c=3.32038e-17
C91 (\8\:mout VSS) capacitor c=5.63343e-17
C92 (\4\:n30 VSS) capacitor c=8.72969e-17
C93 (\20\:VDD VSS) capacitor c=3.88214e-17
C94 (\12\:qbint VSS) capacitor c=7.48548e-17
C95 (\15\:CKb VSS) capacitor c=1.09156e-16
C96 (\1\:Q VSS) capacitor c=6.71939e-17
C97 (\3\:VDD VSS) capacitor c=8.20175e-17
C98 (\4\:S0b VSS) capacitor c=6.21019e-17
C99 (\10\:SEb VSS) capacitor c=7.9436e-17
C100 (\9\:db VSS) capacitor c=9.01523e-17
C101 (\8\:CKbb VSS) capacitor c=5.39879e-17
C102 (\8\:dbp VSS) capacitor c=7.51702e-17
C103 (\8\:n20 VSS) capacitor c=7.1093e-17
C104 (\6\:mout VSS) capacitor c=5.09349e-17
C105 (\8\:n30 VSS) capacitor c=1.85673e-17
C106 (\14\:qbint VSS) capacitor c=8.47802e-17
C107 (\19\:CKb VSS) capacitor c=6.68126e-17
C108 (\3\:Q VSS) capacitor c=3.18395e-17
C109 (\6\:CKb VSS) capacitor c=6.63321e-17
C110 (\7\:CKb VSS) capacitor c=5.90474e-17
C111 (\2\:SI VSS) capacitor c=4.25106e-17
C112 (\3\:SE VSS) capacitor c=6.84175e-17
C113 (\2\:D0 VSS) capacitor c=3.01915e-17
C114 (\4\:CK VSS) capacitor c=3.45016e-17
C115 (\11\:qbint VSS) capacitor c=5.00763e-17
C116 (\16\:qbint VSS) capacitor c=1.28536e-16
C117 (\6\:n30 VSS) capacitor c=6.83564e-17
C118 (\7\:n30 VSS) capacitor c=8.0918e-17
C119 (\4\:mout VSS) capacitor c=6.29249e-17
C120 (\5\:mout VSS) capacitor c=5.18513e-17
C121 (\12\:CKb VSS) capacitor c=4.82475e-17
C122 (\13\:CKb VSS) capacitor c=9.96097e-17
C123 (\14\:CKb VSS) capacitor c=1.15488e-16
C124 (\17\:CKb VSS) capacitor c=1.02955e-16
C125 (\18\:CKb VSS) capacitor c=5.71161e-17
C126 (\6\:n20 VSS) capacitor c=8.05592e-17
C127 (\7\:n20 VSS) capacitor c=6.82214e-17
C128 (\10\:CKbb VSS) capacitor c=9.64836e-17
C129 (\11\:CKbb VSS) capacitor c=1.57993e-16
C130 (\12\:CKbb VSS) capacitor c=9.96584e-17
C131 (\13\:CKbb VSS) capacitor c=1.24452e-16
C132 (\16\:CKbb VSS) capacitor c=4.6135e-17
C133 (\5\:SI VSS) capacitor c=7.19818e-17
C134 (\3\:dbp VSS) capacitor c=1.02303e-16
C135 (\7\:SE VSS) capacitor c=5.32323e-17
C136 (\7\:SEb VSS) capacitor c=1.12803e-16
C137 (\8\:SEb VSS) capacitor c=2.54615e-17
C138 (\9\:SEb VSS) capacitor c=7.82841e-17
C139 (\5\:D0 VSS) capacitor c=6.59278e-17
C140 (\3\:db VSS) capacitor c=1.38095e-16
C141 (\4\:db VSS) capacitor c=9.82728e-17
C142 (\4\:D1 VSS) capacitor c=8.27226e-17
C143 (\8\:S0 VSS) capacitor c=6.81236e-17
C144 (\9\:S0 VSS) capacitor c=1.0001e-16
C145 (\10\:S0 VSS) capacitor c=2.99296e-17
C146 (\8\:S0b VSS) capacitor c=8.68965e-17
C147 (\5\:VDD VSS) capacitor c=3.92847e-17
C148 (\6\:VDD VSS) capacitor c=3.15765e-17
C149 (\8\:VDD VSS) capacitor c=5.07164e-17
C150 (\9\:VDD VSS) capacitor c=2.41087e-17
Rk40 (D0 \5\:D0) resistor r=0.1299 c=0
Rk52 (\2\:VSS \4\:VSS) resistor r=0.4371 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.2605 c=0
Rk54 (\5\:VSS \6\:VSS) resistor r=0.6314 c=0
Rk55 (\6\:VSS \7\:VSS) resistor r=0.1603 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.4185 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=0.664 c=0
Rk59 (\10\:VSS VSS) resistor r=0.3583 c=0
Rk58 (\9\:VSS \10\:VSS) resistor r=0.1201 c=0
Rk62 (\5\:VSS \15\:VSS) resistor r=0.2303 c=0
Rk63 (\6\:VSS \17\:VSS) resistor r=0.3132 c=0
Rk64 (\8\:VSS \19\:VSS) resistor r=0.2823 c=0
Rk65 (\9\:VSS \21\:VSS) resistor r=0.2823 c=0
Rk5 (\4\:CK CK) resistor r=0.02699 c=0
Rk48 (\9\:S0 S0) resistor r=0.2581 c=0
Rk47 (\8\:S0 \9\:S0) resistor r=0.3297 c=0
Rk49 (S0 \10\:S0) resistor r=0.108 c=0
Rk1 (\2\:Q Q) resistor r=0.2042 c=0
Rk2 (Q \4\:Q) resistor r=0.1835 c=0
Rk67 (\2\:VDD \4\:VDD) resistor r=0.333 c=0
Rk68 (\4\:VDD \5\:VDD) resistor r=0.2605 c=0
Rk69 (\5\:VDD \6\:VDD) resistor r=0.6665 c=0
Rk70 (\6\:VDD \7\:VDD) resistor r=0.1252 c=0
Rk71 (\7\:VDD \8\:VDD) resistor r=0.4811 c=0
Rk72 (\8\:VDD \9\:VDD) resistor r=0.6414 c=0
Rk74 (\10\:VDD VDD) resistor r=0.3357 c=0
Rk73 (\9\:VDD \10\:VDD) resistor r=0.08003 c=0
Rk77 (\5\:VDD \15\:VDD) resistor r=0.2814 c=0
Rk78 (\6\:VDD \17\:VDD) resistor r=0.2658 c=0
Rk79 (\8\:VDD \19\:VDD) resistor r=0.159 c=0
Rk80 (\9\:VDD \21\:VDD) resistor r=0.2623 c=0
Rk35 (\7\:SE SE) resistor r=0.1256 c=0
Rk46 (D1 \4\:D1) resistor r=0.01164 c=0
Rk30 (\5\:SI SI) resistor r=0.1124 c=0
Rk6 (\11\:qbint \13\:qbint) resistor r=0.269 c=0
Rk7 (\13\:qbint \15\:qbint) resistor r=0.341 c=0
Rk8 (\15\:qbint \16\:qbint) resistor r=0.6406 c=0
Rk15 (\12\:CKb \13\:CKb) resistor r=0.2414 c=0
Rk16 (\13\:CKb \14\:CKb) resistor r=0.3417 c=0
Rk17 (\14\:CKb \16\:CKb) resistor r=0.5962 c=0
Rk18 (\13\:CKb \17\:CKb) resistor r=0.7694 c=0
Rk19 (\14\:CKb \18\:CKb) resistor r=0.2548 c=0
Rk20 (\16\:CKb \20\:CKb) resistor r=0.3125 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.3556 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.4579 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.07075 c=0
Rk12 (\4\:mout \5\:mout) resistor r=0.271 c=0
Rk13 (\5\:mout \7\:mout) resistor r=0.1609 c=0
Rk14 (\5\:mout \9\:mout) resistor r=0.2238 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.3506 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.4384 c=0
Rk26 (\11\:CKbb \12\:CKbb) resistor r=0.92 c=0
Rk27 (\10\:CKbb \13\:CKbb) resistor r=0.3918 c=0
Rk28 (\13\:CKbb \15\:CKbb) resistor r=0.526 c=0
Rk29 (\11\:CKbb \16\:CKbb) resistor r=0.1137 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.1863 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.4043 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.3034 c=0
Rk31 (\2\:dbp \3\:dbp) resistor r=0.5569 c=0
Rk32 (\3\:dbp \5\:dbp) resistor r=0.414 c=0
Rk33 (\3\:dbp \7\:dbp) resistor r=0.1803 c=0
Rk34 (\5\:dbp \9\:dbp) resistor r=0.4005 c=0
Rk41 (\2\:db \3\:db) resistor r=0.6511 c=0
Rk42 (\3\:db \4\:db) resistor r=0.4973 c=0
Rk43 (\4\:db \6\:db) resistor r=0.1165 c=0
Rk44 (\3\:db \8\:db) resistor r=0.2658 c=0
Rk45 (\4\:db \10\:db) resistor r=0.421 c=0
Rk36 (\6\:SEb \7\:SEb) resistor r=0.7613 c=0
Rk37 (\7\:SEb \8\:SEb) resistor r=0.07943 c=0
Rk38 (\7\:SEb \9\:SEb) resistor r=0.2307 c=0
Rk39 (\9\:SEb \11\:SEb) resistor r=0.5336 c=0
Rk50 (\5\:S0b \7\:S0b) resistor r=0.6332 c=0
Rk51 (\7\:S0b \8\:S0b) resistor r=0.5193 c=0
Rl39 (\1\:D0 \2\:D0) resistor r=60.772 c=0
Rl41 (\2\:D0 \4\:D0) resistor r=105.003 c=0
Rl40 (\2\:D0 \3\:D0) resistor r=58.0656 c=0
Rl7 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl8 (\2\:CK \3\:CK) resistor r=44.9225 c=0
Rl49 (\6\:S0 \7\:S0) resistor r=180.746 c=0
Rl48 (\5\:S0 \6\:S0) resistor r=34.4104 c=0
Rl45 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl42 (\1\:S0 \2\:S0) resistor r=33.3481 c=0
Rl34 (\1\:SE \2\:SE) resistor r=162.26 c=0
Rl37 (\2\:SE \5\:SE) resistor r=152.645 c=0
Rl38 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl36 (\3\:SE \4\:SE) resistor r=139.184 c=0
Rl35 (\2\:SE \3\:SE) resistor r=157.169 c=0
Rl47 (\2\:D1 \3\:D1) resistor r=26.3736 c=0
Rl46 (\1\:D1 \2\:D1) resistor r=119.231 c=0
Rl31 (\2\:SI \4\:SI) resistor r=42.0218 c=0
Rl29 (\1\:SI \2\:SI) resistor r=93.5105 c=0
Rl30 (\2\:SI \3\:SI) resistor r=2.0166 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=29.5379 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=106.461 c=0
Rl5 (qbint \6\:qbint) resistor r=8.1398 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl13 (CKb \2\:CKb) resistor r=58.8482 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=157.374 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=67.2856 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=163.005 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=192.698 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=41.8301 c=0
Rl9 (n30 \2\:n30) resistor r=24.7951 c=0
Rl20 (\2\:mout \3\:mout) resistor r=83.7903 c=0
Rl19 (mout \2\:mout) resistor r=64.6308 c=0
Rl22 (\6\:CKbb \7\:CKbb) resistor r=35.3072 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=37.2302 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=226.466 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.7951 c=0
Rl17 (n20 \2\:n20) resistor r=24.2328 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=108.848 c=0
Rl33 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl32 (SEb \2\:SEb) resistor r=51.1187 c=0
Rl43 (S0b \2\:S0b) resistor r=25.6167 c=0
Rl44 (\2\:S0b \3\:S0b) resistor r=121.55 c=0
Rz14 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz21 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz22 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz2 (\15\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (dbp \2\:dbp) resistor r=75 c=0
Rz9 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz11 (db \2\:db) resistor r=75 c=0
Rz12 (\9\:db \10\:db) resistor r=75 c=0
Rz10 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz13 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry14 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry15 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry19 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry20 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry21 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry22 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry9 (\6\:dbp \7\:dbp) resistor r=31 c=0
Ry11 (\5\:db \6\:db) resistor r=62 c=0
Ry12 (\7\:db \8\:db) resistor r=20.6667 c=0
Ry10 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry13 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx14 (\2\:SE \7\:SE) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (SEb \8\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn45 (\14\:qbint n30 \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.035e-14 ad=4.42e-14 ps=8.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.59808e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn12 (net490 \1\:SI \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.8e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=5.72e-14 ps=7.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.96635e-07 sb=5.2e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.63e-14 ps=9.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.61635e-07 sb=2.55e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn1 (net498 \4\:D0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=6.5e-14 ps=1.06e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9875e-07 sb=9.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=4.16e-14 ps=1.02e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9375e-07 sb=6.86058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9875e-07 sb=4.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (net510 \1\:D1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=1.56e-14 ps=1.28e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0375e-07 sb=3.76058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn55_1__rcx (\3\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.111e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.59712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\19\:CKb \3\:CK VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.583e-14 ad=3.988e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\8\:CKbb \5\:CKb \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.85e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn10 (\10\:SEb \5\:SE \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=2.03e-14 ps=1.06e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22483e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=2.465e-14 ps=1.28e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2769e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (net482 \10\:qbint \20\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.035e-14 ad=3.178e-14 ps=8.6e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=2e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn51 (\8\:n30 CKb net482 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=8.2e-14 ps=7.2e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.83e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\6\:mout CKbb \8\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.2e-14 ad=6.662e-14 ps=1.21e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.385e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn30 (\6\:mout \3\:n20 \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.14e-14 ad=6.663e-14 ps=1.02e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=1.015e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net474 mout \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=1.23e-14 ps=1.02e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.735e-06 sb=6.8e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn36 (\8\:n20 \4\:CKbb net474 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.408e-14 ps=5.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=5.75e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=6.458e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mp20 (\15\:CKb \1\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.268e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.45e-07 sd=160n sca=36.2017 \
        scb=0.0268185 scc=0.00456568 m=(1)
mp21 (\14\:CKbb \10\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp10 (\5\:SEb \1\:SE \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.00616e-06 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp0 (\6\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00174e-06 sb=1.4e-07 sd=160n sca=18.1789 \
        scb=0.0176591 scc=0.00112786 m=(1)
mp50 (net409 \8\:qbint \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=6.355e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.79435e-07 sb=1.92339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp51 (\4\:n30 \3\:CKbb net409 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.355e-14 ad=7.595e-14 ps=1.03e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.29435e-07 sb=1.67339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=7.595e-14 ps=1.48e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.19435e-07 sb=1.38339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp30 (\8\:mout n20 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39444e-06 sb=9.08387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp35 (net393 \3\:mout \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.665e-14 ps=1.38e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65944e-06 sb=6.43387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=5.89e-14 ps=1.05e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91944e-06 sb=3.83387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.6e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.99202e-06 sb=1.48387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
ends SMDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:28 2013 )
// Library name: gsclib045_hvt
// Cell name: SMDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX4 CK D0 D1 Q S0 SE SI VDD VSS
mp20 (\15\:CKb \3\:CK \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=34.5903 scb=0.0376512 \
        scc=0.00347075 m=(1)
mp21 (\8\:CKbb \10\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.05e-14 ad=2.95e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37209e-07 sb=8.1e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (\5\:SEb \1\:SE \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp0 (\6\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.868e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=14.7678 \
        scb=0.0134734 scc=0.000346306 m=(1)
C1 (D0 VSS) capacitor c=8.4305e-17
C2 (S0 VSS) capacitor c=3.98419e-17
C3 (VDD VSS) capacitor c=3.93868e-16
C4 (SE VSS) capacitor c=2.83917e-17
C5 (D1 VSS) capacitor c=5.07083e-17
C6 (Q VSS) capacitor c=4.12922e-17
C7 (SI VSS) capacitor c=3.90095e-17
C8 (CKb VSS) capacitor c=4.71953e-17
C9 (qbint VSS) capacitor c=2.69316e-16
C10 (n30 VSS) capacitor c=9.66857e-17
C11 (net482 VSS) capacitor c=3.02224e-18
C12 (mout VSS) capacitor c=6.02531e-17
C13 (CKbb VSS) capacitor c=1.84214e-17
C14 (n20 VSS) capacitor c=3.83656e-17
C15 (net474 VSS) capacitor c=5.97186e-19
C16 (dbp VSS) capacitor c=8.57815e-17
C17 (db VSS) capacitor c=1.01157e-16
C18 (SEb VSS) capacitor c=5.70484e-17
C19 (net498 VSS) capacitor c=1.87259e-18
C20 (S0b VSS) capacitor c=4.61717e-17
C21 (net409 VSS) capacitor c=6.03734e-18
C22 (net393 VSS) capacitor c=4.05178e-18
C23 (net417 VSS) capacitor c=1.8729e-18
C24 (net425 VSS) capacitor c=2.9009e-18
C25 (net429 VSS) capacitor c=3.79054e-18
C26 (\7\:S0 VSS) capacitor c=4.11388e-17
C27 (\3\:D1 VSS) capacitor c=6.68921e-17
C28 (\2\:S0 VSS) capacitor c=5.83927e-17
C29 (\4\:D0 VSS) capacitor c=9.03014e-17
C30 (\1\:SE VSS) capacitor c=3.60126e-17
C31 (\6\:SE VSS) capacitor c=4.08294e-17
C32 (\2\:SEb VSS) capacitor c=7.09121e-17
C33 (\4\:SI VSS) capacitor c=8.20385e-17
C34 (\10\:CKb VSS) capacitor c=5.15616e-17
C35 (\6\:CKbb VSS) capacitor c=3.86058e-17
C36 (\8\:CKb VSS) capacitor c=3.5583e-17
C37 (\3\:CKb VSS) capacitor c=2.77591e-17
C38 (\3\:CKbb VSS) capacitor c=8.75919e-17
C39 (\15\:qbint VSS) capacitor c=7.68134e-17
C40 (\3\:CK VSS) capacitor c=3.28008e-17
C41 (\5\:S0 VSS) capacitor c=2.76145e-17
C42 (\1\:D1 VSS) capacitor c=7.70469e-17
C43 (\3\:S0 VSS) capacitor c=6.59156e-17
C44 (\3\:S0b VSS) capacitor c=1.05779e-16
C45 (\1\:D0 VSS) capacitor c=7.68348e-17
C46 (\5\:SE VSS) capacitor c=3.57394e-17
C47 (\3\:SEb VSS) capacitor c=3.98139e-17
C48 (\4\:SE VSS) capacitor c=6.60349e-17
C49 (\1\:SI VSS) capacitor c=5.20067e-17
C50 (\5\:CKb VSS) capacitor c=3.43903e-17
C51 (\11\:CKb VSS) capacitor c=2.39276e-17
C52 (\4\:CKbb VSS) capacitor c=5.99885e-17
C53 (\3\:mout VSS) capacitor c=5.74149e-17
C54 (\3\:n20 VSS) capacitor c=4.14012e-17
C55 (\17\:qbint VSS) capacitor c=4.53897e-17
C56 (\1\:CK VSS) capacitor c=3.25114e-17
C57 (\6\:S0 VSS) capacitor c=3.96509e-17
C58 (\2\:D1 VSS) capacitor c=6.90765e-17
C59 (\4\:S0 VSS) capacitor c=5.58939e-17
C60 (\2\:S0b VSS) capacitor c=6.755e-17
C61 (\1\:S0 VSS) capacitor c=5.137e-17
C62 (\3\:D0 VSS) capacitor c=2.23536e-17
C63 (\2\:SE VSS) capacitor c=6.25496e-17
C64 (\4\:SEb VSS) capacitor c=4.04017e-17
C65 (\3\:SI VSS) capacitor c=2.94381e-17
C66 (\7\:CKbb VSS) capacitor c=4.29432e-17
C67 (\9\:CKb VSS) capacitor c=2.54076e-17
C68 (\5\:CKbb VSS) capacitor c=3.83846e-17
C69 (\2\:mout VSS) capacitor c=4.63691e-17
C70 (\2\:n20 VSS) capacitor c=3.16935e-17
C71 (\2\:CKbb VSS) capacitor c=3.90012e-17
C72 (\4\:CKb VSS) capacitor c=4.14337e-17
C73 (\2\:CKb VSS) capacitor c=4.55208e-17
C74 (\16\:qbint VSS) capacitor c=6.12636e-17
C75 (\8\:n30 VSS) capacitor c=1.73809e-17
C76 (\2\:CK VSS) capacitor c=3.01836e-17
C77 (\6\:S0b VSS) capacitor c=1.00549e-16
C78 (\1\:VDD VSS) capacitor c=3.4972e-17
C79 (\7\:db VSS) capacitor c=7.05163e-17
C80 (\14\:VDD VSS) capacitor c=5.12389e-17
C81 (\5\:SEb VSS) capacitor c=1.14309e-16
C82 (\5\:db VSS) capacitor c=4.10848e-17
C83 (\4\:dbp VSS) capacitor c=7.3246e-17
C84 (\16\:VDD VSS) capacitor c=3.53654e-17
C85 (\8\:CKbb VSS) capacitor c=7.82384e-17
C86 (\6\:dbp VSS) capacitor c=1.04023e-16
C87 (\4\:n20 VSS) capacitor c=5.50849e-17
C88 (\18\:VDD VSS) capacitor c=3.4417e-17
C89 (\4\:mout VSS) capacitor c=6.45284e-17
C90 (\12\:n30 VSS) capacitor c=9.9605e-17
C91 (\23\:qbint VSS) capacitor c=5.04574e-17
C92 (\1\:Q VSS) capacitor c=1.66415e-16
C93 (\15\:CKb VSS) capacitor c=1.63142e-16
C94 (\3\:VDD VSS) capacitor c=8.31076e-17
C95 (\4\:S0b VSS) capacitor c=5.63507e-17
C96 (\10\:SEb VSS) capacitor c=7.75788e-17
C97 (\9\:db VSS) capacitor c=7.33422e-17
C98 (\14\:CKbb VSS) capacitor c=5.18258e-17
C99 (\8\:dbp VSS) capacitor c=6.78784e-17
C100 (\8\:n20 VSS) capacitor c=6.88192e-17
C101 (\7\:mout VSS) capacitor c=4.71059e-17
C102 (\9\:n30 VSS) capacitor c=8.21486e-17
C103 (\21\:qbint VSS) capacitor c=4.63875e-17
C104 (\17\:CKb VSS) capacitor c=5.37404e-17
C105 (\3\:n30 VSS) capacitor c=8.27576e-17
C106 (\6\:CKb VSS) capacitor c=6.27173e-17
C107 (\7\:CKb VSS) capacitor c=6.50411e-17
C108 (\2\:SI VSS) capacitor c=3.52505e-17
C109 (\3\:SE VSS) capacitor c=6.88315e-17
C110 (\4\:CK VSS) capacitor c=1.15782e-16
C111 (\2\:D0 VSS) capacitor c=3.33971e-17
C112 (\18\:qbint VSS) capacitor c=6.70777e-17
C113 (\19\:qbint VSS) capacitor c=4.70226e-17
C114 (\20\:qbint VSS) capacitor c=3.24242e-17
C115 (\11\:n30 VSS) capacitor c=9.25318e-17
C116 (\6\:mout VSS) capacitor c=5.04064e-17
C117 (\9\:mout VSS) capacitor c=5.40428e-17
C118 (\12\:CKb VSS) capacitor c=5.53756e-17
C119 (\13\:CKb VSS) capacitor c=1.00864e-16
C120 (\14\:CKb VSS) capacitor c=2.12188e-16
C121 (\19\:CKb VSS) capacitor c=9.23072e-17
C122 (\20\:CKb VSS) capacitor c=8.14951e-17
C123 (\6\:n20 VSS) capacitor c=7.03398e-17
C124 (\7\:n20 VSS) capacitor c=7.94573e-17
C125 (\10\:CKbb VSS) capacitor c=1.18052e-16
C126 (\11\:CKbb VSS) capacitor c=7.28359e-17
C127 (\12\:CKbb VSS) capacitor c=1.00444e-16
C128 (\13\:CKbb VSS) capacitor c=1.04237e-16
C129 (\16\:CKbb VSS) capacitor c=6.03866e-17
C130 (\5\:SI VSS) capacitor c=7.68359e-17
C131 (\3\:dbp VSS) capacitor c=8.96947e-17
C132 (\7\:SEb VSS) capacitor c=7.98565e-17
C133 (\8\:SEb VSS) capacitor c=3.84398e-17
C134 (\9\:SEb VSS) capacitor c=8.52978e-17
C135 (\7\:SE VSS) capacitor c=8.30422e-17
C136 (\5\:D0 VSS) capacitor c=6.3367e-17
C137 (\3\:db VSS) capacitor c=1.49195e-16
C138 (\4\:db VSS) capacitor c=8.27359e-17
C139 (\4\:D1 VSS) capacitor c=7.51233e-17
C140 (\8\:S0 VSS) capacitor c=7.86524e-17
C141 (\9\:S0 VSS) capacitor c=6.05573e-17
C142 (\10\:S0 VSS) capacitor c=2.79591e-17
C143 (\8\:S0b VSS) capacitor c=9.40556e-17
C144 (\5\:VDD VSS) capacitor c=3.64467e-17
C145 (\6\:VDD VSS) capacitor c=3.20666e-17
C146 (\8\:VDD VSS) capacitor c=3.10702e-17
C147 (\9\:VDD VSS) capacitor c=1.75042e-16
Rk46 (\5\:D0 D0) resistor r=0.02098 c=0
Rk1 (\4\:CK CK) resistor r=0.002997 c=0
Rk54 (\9\:S0 S0) resistor r=0.2875 c=0
Rk53 (\8\:S0 \9\:S0) resistor r=0.3841 c=0
Rk55 (S0 \10\:S0) resistor r=0.03339 c=0
Rk58 (\2\:VSS \4\:VSS) resistor r=0.4302 c=0
Rk59 (\4\:VSS \5\:VSS) resistor r=0.2655 c=0
Rk60 (\5\:VSS \6\:VSS) resistor r=0.5786 c=0
Rk61 (\6\:VSS \7\:VSS) resistor r=0.258 c=0
Rk62 (\7\:VSS \8\:VSS) resistor r=0.3523 c=0
Rk71 (\9\:VSS VSS) resistor r=0.1123 c=0
Rk63 (\8\:VSS \9\:VSS) resistor r=0.6554 c=0
Rk65 (\5\:VSS \12\:VSS) resistor r=0.1804 c=0
Rk66 (\6\:VSS \14\:VSS) resistor r=0.2695 c=0
Rk67 (\8\:VSS \16\:VSS) resistor r=0.04328 c=0
Rk75 (\2\:VDD \4\:VDD) resistor r=0.2979 c=0
Rk76 (\4\:VDD \5\:VDD) resistor r=0.2605 c=0
Rk77 (\5\:VDD \6\:VDD) resistor r=0.6187 c=0
Rk78 (\6\:VDD \7\:VDD) resistor r=0.2229 c=0
Rk79 (\7\:VDD \8\:VDD) resistor r=0.3683 c=0
Rk85 (\9\:VDD VDD) resistor r=0.1324 c=0
Rk80 (\8\:VDD \9\:VDD) resistor r=0.5611 c=0
Rk86 (\5\:VDD \15\:VDD) resistor r=0.2216 c=0
Rk87 (\6\:VDD \17\:VDD) resistor r=0.2532 c=0
Rk88 (\8\:VDD \19\:VDD) resistor r=0.202 c=0
Rk43 (\7\:SE SE) resistor r=0.005993 c=0
Rk52 (D1 \4\:D1) resistor r=0.05461 c=0
Rk6 (\1\:Q Q) resistor r=0.02432 c=0
Rk31 (SI \5\:SI) resistor r=0.07572 c=0
Rk16 (\12\:CKb \13\:CKb) resistor r=0.3022 c=0
Rk17 (\13\:CKb \14\:CKb) resistor r=0.3617 c=0
Rk18 (\14\:CKb \16\:CKb) resistor r=1.3338 c=0
Rk19 (\16\:CKb \18\:CKb) resistor r=0.37 c=0
Rk20 (\13\:CKb \19\:CKb) resistor r=0.6893 c=0
Rk21 (\14\:CKb \20\:CKb) resistor r=0.3534 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.3865 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.1927 c=0
Rk9 (\19\:qbint \22\:qbint) resistor r=0.2468 c=0
Rk10 (\19\:qbint \24\:qbint) resistor r=0.2692 c=0
Rk11 (\10\:n30 \11\:n30) resistor r=0.4714 c=0
Rk12 (\10\:n30 \13\:n30) resistor r=0.4786 c=0
Rk13 (\5\:mout \6\:mout) resistor r=0.2474 c=0
Rk14 (\6\:mout \8\:mout) resistor r=0.1649 c=0
Rk15 (\6\:mout \9\:mout) resistor r=0.2462 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.5271 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.3528 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=0.2851 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.846 c=0
Rk29 (\11\:CKbb \15\:CKbb) resistor r=0.2718 c=0
Rk30 (\12\:CKbb \16\:CKbb) resistor r=0.2303 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.149 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.3933 c=0
Rk24 (\6\:n20 \9\:n20) resistor r=0.303 c=0
Rk32 (\2\:dbp \3\:dbp) resistor r=0.5263 c=0
Rk33 (\3\:dbp \5\:dbp) resistor r=0.1258 c=0
Rk34 (\3\:dbp \7\:dbp) resistor r=0.4271 c=0
Rk35 (\7\:dbp \9\:dbp) resistor r=0.3601 c=0
Rk36 (\5\:dbp \10\:dbp) resistor r=0.1627 c=0
Rk47 (\2\:db \3\:db) resistor r=0.7325 c=0
Rk48 (\3\:db \4\:db) resistor r=0.4829 c=0
Rk49 (\4\:db \6\:db) resistor r=0.07934 c=0
Rk50 (\3\:db \8\:db) resistor r=0.2634 c=0
Rk51 (\4\:db \10\:db) resistor r=0.356 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.6934 c=0
Rk38 (\7\:SEb \8\:SEb) resistor r=0.12 c=0
Rk39 (\7\:SEb \9\:SEb) resistor r=0.1527 c=0
Rk40 (\9\:SEb \11\:SEb) resistor r=0.5886 c=0
Rk56 (\5\:S0b \7\:S0b) resistor r=0.6043 c=0
Rk57 (\7\:S0b \8\:S0b) resistor r=0.6029 c=0
Rl53 (\2\:D0 \4\:D0) resistor r=159.077 c=0
Rl51 (\1\:D0 \2\:D0) resistor r=126.433 c=0
Rl52 (\2\:D0 \3\:D0) resistor r=6.4284 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.9443 c=0
Rl1 (\1\:CK \2\:CK) resistor r=62.9757 c=0
Rl61 (\6\:S0 \7\:S0) resistor r=135.714 c=0
Rl60 (\5\:S0 \6\:S0) resistor r=69.2308 c=0
Rl57 (\3\:S0 \4\:S0) resistor r=55.0021 c=0
Rl54 (\1\:S0 \2\:S0) resistor r=59.5926 c=0
Rl46 (\1\:SE \2\:SE) resistor r=80.0021 c=0
Rl49 (\2\:SE \5\:SE) resistor r=164.617 c=0
Rl50 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl48 (\3\:SE \4\:SE) resistor r=127.645 c=0
Rl47 (\2\:SE \3\:SE) resistor r=199.477 c=0
Rl59 (\2\:D1 \3\:D1) resistor r=111.516 c=0
Rl58 (\1\:D1 \2\:D1) resistor r=113.257 c=0
Rl43 (\2\:SI \4\:SI) resistor r=41.1873 c=0
Rl41 (\1\:SI \2\:SI) resistor r=85.265 c=0
Rl42 (\2\:SI \3\:SI) resistor r=8.3025 c=0
Rl38 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=31.6893 c=0
Rl25 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl39 (\6\:CKb \10\:CKb) resistor r=165.066 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=88.4394 c=0
Rl37 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl40 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=192.698 c=0
Rl23 (\16\:qbint \15\:qbint) resistor r=123.334 c=0
Rl24 (\16\:qbint \17\:qbint) resistor r=33.3841 c=0
Rl17 (\3\:n30 n30) resistor r=44.9718 c=0
Rl22 (\3\:n30 \8\:n30) resistor r=4.6885 c=0
Rl31 (mout \2\:mout) resistor r=79.9442 c=0
Rl32 (\2\:mout \3\:mout) resistor r=26.098 c=0
Rl34 (\6\:CKbb \7\:CKbb) resistor r=33.3841 c=0
Rl33 (\4\:CKbb \5\:CKbb) resistor r=33.3841 c=0
Rl28 (\2\:CKbb \3\:CKbb) resistor r=191.862 c=0
Rl27 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl29 (n20 \2\:n20) resistor r=29.5379 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=83.3841 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl44 (SEb \2\:SEb) resistor r=39.4 c=0
Rl55 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl56 (\2\:S0b \3\:S0b) resistor r=179.675 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz16 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz17 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz18 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz23 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz24 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz25 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz6 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\22\:qbint \21\:qbint) resistor r=75 c=0
Rz4 (\10\:n30 \9\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (dbp \2\:dbp) resistor r=75 c=0
Rz10 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz12 (db \2\:db) resistor r=75 c=0
Rz13 (\9\:db \10\:db) resistor r=75 c=0
Rz11 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz14 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry16 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry17 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry20 (\15\:VDD \14\:VDD) resistor r=31 c=0
Ry21 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry22 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\24\:qbint \23\:qbint) resistor r=62 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry10 (\6\:dbp \7\:dbp) resistor r=62 c=0
Ry11 (\4\:dbp \10\:dbp) resistor r=62 c=0
Ry13 (\5\:db \6\:db) resistor r=62 c=0
Ry14 (\7\:db \8\:db) resistor r=20.6667 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry15 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx16 (\2\:SE \7\:SE) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\20\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (SEb \8\:SEb) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn20 (\17\:CKb \1\:CK \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.74e-14 ad=2.465e-14 ps=1.59e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.58655e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn21 (\14\:CKbb \5\:CKb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\10\:SEb \5\:SE \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.53e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.08483e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.427e-14 ad=2.465e-14 ps=1.11e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.63621e-07 sb=1.7e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn12 (net490 \1\:SI \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.51e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.4e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.94e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.16635e-07 sb=4.6e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.51635e-07 sb=2.25e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn1 (net498 \1\:D0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.53e-14 ad=1.56e-14 ps=1.4e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.92788e-07 sb=7.43654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.97788e-07 sb=6.38654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.02788e-07 sb=4.33654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn3 (net510 \1\:D1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.427e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.07788e-07 sb=3.28654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn55_1__rcx (\1\:Q qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.473e-14 ad=4.16e-14 ps=1.0275e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.47788e-07 sb=1.72817e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn50 (net482 \17\:qbint \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.53e-14 ad=2.358e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50634e-06 sb=2e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (\9\:n30 CKb net482 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=8.61e-14 ps=6.4e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66634e-06 sb=1.84e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn40 (\7\:mout CKbb \9\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.61e-14 ad=7.073e-14 ps=1.25e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.375e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn30 (\7\:mout \3\:n20 \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.29e-14 ad=7.073e-14 ps=1.48e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.85e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn35 (net474 \3\:mout \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.29e-14 ad=1.23e-14 ps=1.48e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.2e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn36 (\8\:n20 \4\:CKbb net474 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.15e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn45 (\21\:qbint \3\:n30 \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.68e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03634e-06 sb=2e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(2)
mp12 (net417 \4\:SI \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.05e-14 ad=2.34e-14 ps=1.18e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55577e-07 sb=5.65e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp13 (\4\:dbp \2\:SEb net417 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60577e-07 sb=4.6e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp11 (\4\:dbp \6\:SE \5\:db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.775e-14 ad=7.41e-14 ps=1.23e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95577e-07 sb=2.25e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp1 (net425 \4\:D0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.29e-14 ps=1.16e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.15e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.02e-14 ps=1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.24551e-07 sb=7.6e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.49551e-07 sb=5.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp3 (net429 \3\:D1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.868e-14 ad=5.265e-14 ps=1.47e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.29551e-07 sb=3.55e-07 sd=160n sca=11.6183 \
        scb=0.00959647 scc=0.000231864 m=(1)
mp55_1__rcx (\1\:Q qbint \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.235e-14 ad=6.24e-14 ps=1.515e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=1.76308e-06 sd=160n sca=20.0514 \
        scb=0.0177139 scc=0.00149226 m=(4)
mp50 (net409 \15\:qbint \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=3.875e-14 ps=1.38e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72153e-06 sb=1.73339e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp51 (\12\:n30 \3\:CKbb net409 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89153e-06 sb=1.56339e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp40 (\12\:n30 \3\:CKb \4\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.35839e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp30 (\4\:mout n20 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.3485e-13 ps=1.38e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.78387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp35 (net393 mout \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=5.735e-14 ps=1.38e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.13387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.89e-14 ps=9.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.83387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp25 (\4\:n20 \6\:CKbb \6\:dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.6e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.48387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp45 (\23\:qbint n30 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.94e-14 ad=4.96e-14 ps=1.38e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25153e-06 sb=2e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(2)
ends SMDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:29 2013 )
// Library name: gsclib045_hvt
// Cell name: SMDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX8 CK D0 D1 Q S0 SE SI VDD VSS
mp55_1__rcx (Q qbint \10\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90404e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (D0 VSS) capacitor c=6.32161e-17
C2 (CK VSS) capacitor c=7.72213e-17
C3 (S0 VSS) capacitor c=3.18976e-17
C4 (VDD VSS) capacitor c=4.0766e-16
C5 (SE VSS) capacitor c=7.1894e-17
C6 (D1 VSS) capacitor c=1.35393e-16
C7 (Q VSS) capacitor c=5.07427e-16
C8 (SI VSS) capacitor c=4.04237e-17
C9 (qbint VSS) capacitor c=3.74074e-16
C10 (n30 VSS) capacitor c=2.10781e-16
C11 (CKb VSS) capacitor c=4.55519e-17
C12 (net482 VSS) capacitor c=2.62936e-18
C13 (mout VSS) capacitor c=5.93788e-17
C14 (CKbb VSS) capacitor c=2.40475e-17
C15 (n20 VSS) capacitor c=3.75426e-17
C16 (net474 VSS) capacitor c=1.38453e-18
C17 (dbp VSS) capacitor c=6.02402e-17
C18 (net490 VSS) capacitor c=2.07039e-18
C19 (db VSS) capacitor c=1.05645e-16
C20 (SEb VSS) capacitor c=7.24514e-17
C21 (net498 VSS) capacitor c=5.7093e-18
C22 (S0b VSS) capacitor c=3.59515e-17
C23 (net409 VSS) capacitor c=2.7333e-18
C24 (net393 VSS) capacitor c=2.33668e-18
C25 (net417 VSS) capacitor c=2.23037e-18
C26 (net425 VSS) capacitor c=2.05099e-18
C27 (net429 VSS) capacitor c=6.74141e-18
C28 (\7\:S0 VSS) capacitor c=3.80017e-17
C29 (\1\:D1 VSS) capacitor c=4.6473e-17
C30 (\2\:S0 VSS) capacitor c=7.05875e-17
C31 (\4\:D0 VSS) capacitor c=9.07195e-17
C32 (\1\:SE VSS) capacitor c=5.79959e-17
C33 (\6\:SE VSS) capacitor c=3.1443e-17
C34 (\1\:SI VSS) capacitor c=9.19536e-17
C35 (\5\:CKb VSS) capacitor c=7.45847e-17
C36 (\7\:CKbb VSS) capacitor c=3.88523e-17
C37 (\8\:CKb VSS) capacitor c=4.89494e-17
C38 (\3\:CKb VSS) capacitor c=2.46469e-17
C39 (\3\:CKbb VSS) capacitor c=7.62758e-17
C40 (\22\:qbint VSS) capacitor c=4.68773e-17
C41 (\1\:CK VSS) capacitor c=3.26e-17
C42 (\5\:S0 VSS) capacitor c=2.39046e-17
C43 (\3\:D1 VSS) capacitor c=7.21087e-17
C44 (\3\:S0 VSS) capacitor c=7.12869e-17
C45 (\3\:S0b VSS) capacitor c=6.53354e-17
C46 (\1\:D0 VSS) capacitor c=5.53797e-17
C47 (\5\:SE VSS) capacitor c=4.18538e-17
C48 (\3\:SEb VSS) capacitor c=3.42111e-17
C49 (\4\:SE VSS) capacitor c=9.61221e-17
C50 (\4\:SI VSS) capacitor c=8.26922e-17
C51 (\10\:CKb VSS) capacitor c=3.75498e-17
C52 (\11\:CKb VSS) capacitor c=2.41108e-17
C53 (\5\:CKbb VSS) capacitor c=5.92285e-17
C54 (\4\:mout VSS) capacitor c=5.5934e-17
C55 (\3\:n20 VSS) capacitor c=3.86277e-17
C56 (\24\:qbint VSS) capacitor c=5.26567e-17
C57 (\3\:CK VSS) capacitor c=3.11001e-17
C58 (\6\:S0 VSS) capacitor c=2.67833e-17
C59 (\2\:D1 VSS) capacitor c=4.07816e-17
C60 (\4\:S0 VSS) capacitor c=4.33603e-17
C61 (\2\:S0b VSS) capacitor c=5.0605e-17
C62 (\1\:S0 VSS) capacitor c=4.79561e-17
C63 (\3\:D0 VSS) capacitor c=4.1277e-17
C64 (\2\:SE VSS) capacitor c=7.50678e-17
C65 (\4\:SEb VSS) capacitor c=3.96051e-17
C66 (\2\:SEb VSS) capacitor c=5.38415e-17
C67 (\3\:SI VSS) capacitor c=3.95314e-17
C68 (\8\:CKbb VSS) capacitor c=3.73913e-17
C69 (\9\:CKb VSS) capacitor c=2.83488e-17
C70 (\6\:CKbb VSS) capacitor c=4.48179e-17
C71 (\3\:mout VSS) capacitor c=2.01376e-17
C72 (\2\:n20 VSS) capacitor c=2.95901e-17
C73 (\4\:CKbb VSS) capacitor c=2.17637e-17
C74 (\4\:CKb VSS) capacitor c=3.85449e-17
C75 (\2\:CKb VSS) capacitor c=4.19488e-17
C76 (\23\:qbint VSS) capacitor c=4.36797e-17
C77 (\2\:CK VSS) capacitor c=2.94965e-17
C78 (\6\:S0b VSS) capacitor c=9.53129e-17
C79 (\16\:VDD VSS) capacitor c=3.30869e-17
C80 (\6\:db VSS) capacitor c=5.38448e-17
C81 (\18\:VDD VSS) capacitor c=4.00611e-17
C82 (\5\:SEb VSS) capacitor c=9.22151e-17
C83 (\4\:db VSS) capacitor c=1.48807e-16
C84 (\20\:VDD VSS) capacitor c=4.43531e-17
C85 (\14\:CKbb VSS) capacitor c=9.74292e-17
C86 (\4\:dbp VSS) capacitor c=1.01235e-16
C87 (\4\:n20 VSS) capacitor c=6.26358e-17
C88 (\22\:VDD VSS) capacitor c=3.45653e-17
C89 (\5\:mout VSS) capacitor c=4.41662e-17
C90 (\14\:n30 VSS) capacitor c=1.08217e-16
C91 (\24\:VDD VSS) capacitor c=2.61992e-17
C92 (\18\:CKb VSS) capacitor c=1.11618e-16
C93 (\26\:qbint VSS) capacitor c=3.8183e-16
C94 (\1\:VDD VSS) capacitor c=7.52202e-17
C95 (\4\:S0b VSS) capacitor c=5.09675e-17
C96 (\10\:SEb VSS) capacitor c=1.16359e-16
C97 (\8\:db VSS) capacitor c=9.84624e-17
C98 (\6\:dbp VSS) capacitor c=7.18962e-17
C99 (\16\:CKbb VSS) capacitor c=5.12026e-17
C100 (\8\:dbp VSS) capacitor c=8.30085e-17
C101 (\8\:n20 VSS) capacitor c=6.45148e-17
C102 (\8\:mout VSS) capacitor c=4.87884e-17
C103 (\12\:n30 VSS) capacitor c=2.05844e-16
C104 (\15\:CKb VSS) capacitor c=1.51409e-16
C105 (\2\:CKbb VSS) capacitor c=3.86426e-17
C106 (\2\:mout VSS) capacitor c=2.98058e-17
C107 (\6\:CKb VSS) capacitor c=7.05896e-17
C108 (\7\:CKb VSS) capacitor c=5.36359e-17
C109 (\2\:SI VSS) capacitor c=3.83364e-17
C110 (\3\:SE VSS) capacitor c=7.3403e-17
C111 (\2\:D0 VSS) capacitor c=3.38681e-17
C112 (\4\:CK VSS) capacitor c=4.25043e-17
C113 (\25\:qbint VSS) capacitor c=1.27201e-16
C114 (\37\:qbint VSS) capacitor c=2.76634e-17
C115 (\11\:n30 VSS) capacitor c=1.61592e-16
C116 (\7\:mout VSS) capacitor c=6.07742e-17
C117 (\10\:mout VSS) capacitor c=7.36739e-17
C118 (\12\:CKb VSS) capacitor c=1.05321e-16
C119 (\13\:CKb VSS) capacitor c=1.22774e-16
C120 (\14\:CKb VSS) capacitor c=1.6454e-16
C121 (\17\:CKb VSS) capacitor c=6.79525e-17
C122 (\6\:n20 VSS) capacitor c=7.21789e-17
C123 (\7\:n20 VSS) capacitor c=8.36345e-17
C124 (\9\:CKbb VSS) capacitor c=1.29727e-16
C125 (\10\:CKbb VSS) capacitor c=1.45384e-16
C126 (\11\:CKbb VSS) capacitor c=4.56218e-17
C127 (\12\:CKbb VSS) capacitor c=7.67373e-17
C128 (\13\:CKbb VSS) capacitor c=1.49908e-16
C129 (\5\:SI VSS) capacitor c=6.04573e-17
C130 (\3\:dbp VSS) capacitor c=1.03688e-16
C131 (\7\:SE VSS) capacitor c=6.90341e-17
C132 (\7\:SEb VSS) capacitor c=9.49232e-17
C133 (\8\:SEb VSS) capacitor c=3.60134e-17
C134 (\9\:SEb VSS) capacitor c=7.94308e-17
C135 (\5\:D0 VSS) capacitor c=6.97205e-17
C136 (\3\:db VSS) capacitor c=1.28021e-16
C137 (\8\:S0 VSS) capacitor c=6.99848e-17
C138 (\9\:S0 VSS) capacitor c=5.17391e-17
C139 (\10\:S0 VSS) capacitor c=6.39258e-17
C140 (\8\:S0b VSS) capacitor c=1.02357e-16
C141 (\3\:VDD VSS) capacitor c=1.62917e-17
C142 (\4\:VDD VSS) capacitor c=3.14641e-17
C143 (\6\:VDD VSS) capacitor c=4.61088e-17
C144 (\7\:VDD VSS) capacitor c=3.66299e-17
C145 (\9\:VDD VSS) capacitor c=2.75625e-17
C146 (\10\:VDD VSS) capacitor c=5.19606e-16
Rk49 (D0 \5\:D0) resistor r=0.1475 c=0
Rk11 (\4\:CK CK) resistor r=0.1658 c=0
Rk55 (\8\:S0 S0) resistor r=0.2785 c=0
Rk56 (S0 \9\:S0) resistor r=0.02672 c=0
Rk57 (\9\:S0 \10\:S0) resistor r=0.3875 c=0
Rk84 (\2\:VSS \3\:VSS) resistor r=0.1051 c=0
Rk85 (\3\:VSS \4\:VSS) resistor r=0.3984 c=0
Rk86 (\4\:VSS \5\:VSS) resistor r=0.2982 c=0
Rk87 (\5\:VSS \6\:VSS) resistor r=0.2757 c=0
Rk88 (\6\:VSS \7\:VSS) resistor r=0.5965 c=0
Rk89 (\7\:VSS \8\:VSS) resistor r=0.3308 c=0
Rk90 (\8\:VSS \9\:VSS) resistor r=0.3083 c=0
Rk97 (\10\:VSS VSS) resistor r=0.1074 c=0
Rk91 (\9\:VSS \10\:VSS) resistor r=0.5162 c=0
Rk98 (\3\:VSS \17\:VSS) resistor r=0.3045 c=0
Rk99 (\4\:VSS \19\:VSS) resistor r=0.2317 c=0
Rk100 (\6\:VSS \21\:VSS) resistor r=0.2555 c=0
Rk101 (\7\:VSS \23\:VSS) resistor r=0.201 c=0
Rk102 (\9\:VSS \25\:VSS) resistor r=0.1026 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.1051 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.4059 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.2907 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.2757 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.6516 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.2757 c=0
Rk66 (\8\:VDD \9\:VDD) resistor r=0.2957 c=0
Rk73 (\10\:VDD VDD) resistor r=0.1074 c=0
Rk67 (\9\:VDD \10\:VDD) resistor r=0.5288 c=0
Rk74 (\3\:VDD \17\:VDD) resistor r=0.2243 c=0
Rk75 (\4\:VDD \19\:VDD) resistor r=0.2273 c=0
Rk76 (\6\:VDD \21\:VDD) resistor r=0.2365 c=0
Rk77 (\7\:VDD \23\:VDD) resistor r=0.1862 c=0
Rk78 (\9\:VDD \25\:VDD) resistor r=0.2042 c=0
Rk44 (SE \7\:SE) resistor r=0.1249 c=0
Rk54 (\4\:D1 D1) resistor r=0.004469 c=0
Rk39 (SI \5\:SI) resistor r=0.1413 c=0
Rk12 (\25\:qbint \26\:qbint) resistor r=0.9606 c=0
Rk19 (\26\:qbint \37\:qbint) resistor r=0.166 c=0
Rk20 (\11\:n30 \13\:n30) resistor r=1.2746 c=0
Rk21 (\13\:n30 \15\:n30) resistor r=0.4567 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.7396 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.673 c=0
Rk27 (\14\:CKb \16\:CKb) resistor r=0.6287 c=0
Rk28 (\13\:CKb \17\:CKb) resistor r=0.2825 c=0
Rk29 (\16\:CKb \19\:CKb) resistor r=0.6911 c=0
Rk22 (\6\:mout \7\:mout) resistor r=0.2446 c=0
Rk23 (\7\:mout \9\:mout) resistor r=0.1294 c=0
Rk24 (\7\:mout \10\:mout) resistor r=0.3113 c=0
Rk33 (\9\:CKbb \10\:CKbb) resistor r=1.0082 c=0
Rk34 (\10\:CKbb \11\:CKbb) resistor r=0.1502 c=0
Rk35 (\10\:CKbb \12\:CKbb) resistor r=0.365 c=0
Rk36 (\12\:CKbb \13\:CKbb) resistor r=0.3089 c=0
Rk37 (\13\:CKbb \15\:CKbb) resistor r=0.6631 c=0
Rk38 (\12\:CKbb \17\:CKbb) resistor r=0.2756 c=0
Rk30 (\5\:n20 \6\:n20) resistor r=0.1756 c=0
Rk31 (\6\:n20 \7\:n20) resistor r=0.4455 c=0
Rk32 (\6\:n20 \9\:n20) resistor r=0.2541 c=0
Rk40 (\2\:dbp \3\:dbp) resistor r=0.251 c=0
Rk41 (\3\:dbp \5\:dbp) resistor r=0.3815 c=0
Rk42 (\3\:dbp \7\:dbp) resistor r=0.5281 c=0
Rk43 (\5\:dbp \9\:dbp) resistor r=0.4601 c=0
Rk50 (\2\:db \3\:db) resistor r=0.7389 c=0
Rk51 (\3\:db \5\:db) resistor r=0.4683 c=0
Rk52 (\3\:db \7\:db) resistor r=0.2421 c=0
Rk53 (\5\:db \9\:db) resistor r=0.5095 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.6453 c=0
Rk46 (\7\:SEb \8\:SEb) resistor r=0.1632 c=0
Rk47 (\7\:SEb \9\:SEb) resistor r=0.1202 c=0
Rk48 (\9\:SEb \11\:SEb) resistor r=0.7546 c=0
Rk58 (\5\:S0b \7\:S0b) resistor r=0.4812 c=0
Rk59 (\7\:S0b \8\:S0b) resistor r=0.645 c=0
Rl64 (\2\:D0 \4\:D0) resistor r=47.3105 c=0
Rl62 (\1\:D0 \2\:D0) resistor r=115.43 c=0
Rl63 (\2\:D0 \3\:D0) resistor r=58.0656 c=0
Rl30 (\1\:CK \2\:CK) resistor r=73.0769 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl72 (\6\:S0 \7\:S0) resistor r=106.868 c=0
Rl71 (\5\:S0 \6\:S0) resistor r=40.3846 c=0
Rl68 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl65 (\1\:S0 \2\:S0) resistor r=33.3481 c=0
Rl57 (\1\:SE \2\:SE) resistor r=146.875 c=0
Rl60 (\2\:SE \5\:SE) resistor r=171.875 c=0
Rl61 (\3\:SE \6\:SE) resistor r=30.4507 c=0
Rl59 (\3\:SE \4\:SE) resistor r=164.928 c=0
Rl58 (\2\:SE \3\:SE) resistor r=145.182 c=0
Rl69 (\1\:D1 \2\:D1) resistor r=56.461 c=0
Rl70 (\2\:D1 \3\:D1) resistor r=87.2302 c=0
Rl52 (\1\:SI \2\:SI) resistor r=55.0028 c=0
Rl54 (\2\:SI \4\:SI) resistor r=93.4643 c=0
Rl53 (\2\:SI \3\:SI) resistor r=62.3759 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=46.131 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=57.4874 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl34 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=216.555 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=123.055 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=136.082 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=163.852 c=0
Rl41 (mout \2\:mout) resistor r=84.3295 c=0
Rl43 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl42 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=141.851 c=0
Rl36 (CKbb \2\:CKbb) resistor r=22.7584 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=71.5433 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=71.8456 c=0
Rl56 (\3\:SEb \4\:SEb) resistor r=46.8456 c=0
Rl55 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl66 (S0b \2\:S0b) resistor r=25.6167 c=0
Rl67 (\2\:S0b \3\:S0b) resistor r=121.55 c=0
Rz22 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz19 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz20 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz11 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (\6\:dbp \7\:dbp) resistor r=75 c=0
Rz13 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz15 (db \2\:db) resistor r=75 c=0
Rz16 (\8\:db \9\:db) resistor r=75 c=0
Rz14 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz17 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry28 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry29 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry31 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry11 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (dbp \2\:dbp) resistor r=31 c=0
Ry13 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry15 (\4\:db \5\:db) resistor r=62 c=0
Ry16 (\6\:db \7\:db) resistor r=31 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry17 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx14 (\2\:SE \7\:SE) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
