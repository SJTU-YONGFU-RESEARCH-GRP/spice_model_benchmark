Rk33 (\6\:Gbb \7\:Gbb) resistor r=0.3443 c=0
Rk34 (\7\:Gbb \8\:Gbb) resistor r=0.3885 c=0
Rk35 (\7\:Gbb \10\:Gbb) resistor r=0.09609 c=0
Rk36 (\8\:Gbb \11\:Gbb) resistor r=0.3443 c=0
Rl57 (\1\:D \2\:D) resistor r=71.8456 c=0
Rl58 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl1 (\1\:G \2\:G) resistor r=94.5242 c=0
Rl2 (\2\:G \3\:G) resistor r=22.4021 c=0
Rl59 (\4\:Gb \5\:Gb) resistor r=186.538 c=0
Rl54 (Gb \2\:Gb) resistor r=186.104 c=0
Rl60 (\5\:Gb \6\:Gb) resistor r=29.5379 c=0
Rl55 (\2\:Gb \3\:Gb) resistor r=24.2328 c=0
Rl52 (\32\:Qint \33\:Qint) resistor r=83.8482 c=0
Rl51 (\32\:Qint \31\:Qint) resistor r=116.862 c=0
Rl23 (\9\:Qint Qint) resistor r=52.3132 c=0
Rl46 (\3\:n0 n0) resistor r=94.8893 c=0
Rl50 (\3\:n0 \7\:n0) resistor r=3.8088 c=0
Rl56 (\3\:Gbb \4\:Gbb) resistor r=29.5379 c=0
Rl53 (Gbb \2\:Gbb) resistor r=57.6695 c=0
Rz20 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz21 (\5\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz9 (\9\:Gb \10\:Gb) resistor r=75 c=0
Rz7 (\39\:Qint \38\:Qint) resistor r=75 c=0
Rz8 (\9\:n0 \8\:n0) resistor r=75 c=0
Rz10 (\9\:Gbb \10\:Gbb) resistor r=75 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry11 (\11\:Gb \12\:Gb) resistor r=62 c=0
Ry9 (\41\:Qint \40\:Qint) resistor r=31 c=0
Ry10 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry12 (\5\:Gbb \6\:Gbb) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:G \4\:G) resistor r=45 c=0
Rx7 (\6\:Gb \7\:Gb) resistor r=45 c=0
Rx8 (\3\:Gb \8\:Gb) resistor r=45 c=0
Rx2 (\20\:Qbint Qbint) resistor r=45 c=0
Rx3 (\34\:Qint \32\:Qint) resistor r=45 c=0
Rx4 (\37\:Qint Qint) resistor r=45 c=0
Rx5 (\11\:n0 \7\:n0) resistor r=45 c=0
Rx9 (\4\:Gbb \8\:Gbb) resistor r=45 c=0
Rx10 (Gbb \11\:Gbb) resistor r=45 c=0
mn0 (\9\:Gb \3\:G \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=2.61e-14 ps=1.62e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn15 (net245 \31\:Qint \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.135e-14 ad=2.827e-14 ps=1.62e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.05e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn16 (\8\:n0 \2\:Gb net245 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.32e-14 ps=6.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.1e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn6 (\8\:n0 \3\:Gbb net257 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn5 (net257 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn1 (\9\:Gbb \5\:Gb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=2.972e-14 ps=1.51e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn21_1__rcx (\4\:Q Qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.098e-14 ad=4.16e-14 ps=1.4925e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=2e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn20_1__rcx (\15\:Qbint \9\:Qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=8.66e-14 ad=4.16e-14 ps=1.45e-06 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.19337e-06 sb=1.95452e-06 sd=160n \
        sca=11.3041 scb=0.010759 scc=0.000493236 m=(4)
mn22_1__rcx (\1\:QN Qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.591e-14 ad=4.16e-14 ps=1.45e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99115e-06 sb=1.58144e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn10_1__rcx (\38\:Qint n0 \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.26e-14 ad=3.28e-14 ps=1.535e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.11488e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(2)
mp21 (\1\:Q Qbint \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.314e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=2e-06 sd=160n sca=18.6696 \
        scb=0.0162362 scc=0.00138051 m=(4)
mp22 (\5\:QN Qint \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.432e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.90128e-06 sb=1.53878e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp20_1__rcx (\21\:Qbint \9\:Qint \5\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.08955e-06 sb=1.90673e-06 sd=160n \
        sca=17.2385 scb=0.0152696 scc=0.00137893 m=(4)
mp10_1__rcx (\40\:Qint \3\:n0 \5\:VDD VDD) g45p1hvt w=(3.1e-07) \
        l=4.5e-08 nf=1 as=6.453e-14 ad=4.96e-14 ps=1.12e-06 pd=9.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=1.22395e-06 sd=160n \
        sca=12.9031 scb=0.0116454 scc=0.000496931 m=(2)
ends TLATX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:19 2013 )
// Library name: gsclib045_hvt
// Cell name: TLATXL
// View name: extracted

simulator lang=spectre

subckt TLATXL D G Q QN VDD VSS
mp1 (\8\:Gbb Gb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.655e-14 ps=7.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.275e-06 sd=160n sca=16.8928 \
        scb=0.0171325 scc=0.000344283 m=(1)
mp5 (net220 \1\:D \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.655e-14 ps=7.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.06e-06 sd=160n sca=12.2564 \
        scb=0.00923826 scc=8.62349e-05 m=(1)
mp6 (\6\:n0 \4\:Gb net220 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.483e-14 ps=7.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=8.45e-07 sd=160n sca=10.8469 \
        scb=0.00772406 scc=8.06202e-05 m=(1)
mp16 (\6\:n0 Gbb net212 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=5.483e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=5.45e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp15 (net212 \3\:Qint \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.537e-14 ad=1.935e-14 ps=1.33e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.1e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp10 (\17\:Qint \3\:n0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.537e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp0 (\14\:Gb \3\:G \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.5e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp22 (\3\:QN \10\:Qint \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\7\:Qbint \8\:Qint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.15e-07 sd=160n sca=35.6619 \
        scb=0.0280625 scc=0.00428121 m=(1)
mp21 (\1\:Q \4\:Qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.1e-07 sd=160n sca=40.8819 \
        scb=0.0369433 scc=0.00464292 m=(1)
C1 (G VSS) capacitor c=4.84243e-17
C2 (QN VSS) capacitor c=6.73343e-17
C3 (D VSS) capacitor c=1.17282e-16
C4 (VDD VSS) capacitor c=2.20551e-16
C5 (Q VSS) capacitor c=1.62424e-17
C6 (Gb VSS) capacitor c=2.83924e-17
C7 (Gbb VSS) capacitor c=7.30952e-17
C8 (net257 VSS) capacitor c=1.11361e-17
C9 (n0 VSS) capacitor c=3.41733e-17
C10 (Qint VSS) capacitor c=8.82648e-17
C11 (Qbint VSS) capacitor c=3.37146e-17
C12 (net212 VSS) capacitor c=1.45695e-18
C13 (\4\:Qbint VSS) capacitor c=2.93798e-17
C14 (\8\:Qint VSS) capacitor c=4.0536e-17
C15 (\10\:Qint VSS) capacitor c=6.78011e-17
C16 (\3\:G VSS) capacitor c=3.28762e-17
C17 (\3\:n0 VSS) capacitor c=6.34393e-17
C18 (\3\:Qint VSS) capacitor c=6.34648e-17
C19 (\4\:Gb VSS) capacitor c=3.1397e-17
C20 (\1\:D VSS) capacitor c=5.15507e-17
C21 (\4\:Qint VSS) capacitor c=2.11785e-17
C22 (\9\:Qint VSS) capacitor c=2.70883e-17
C23 (\1\:G VSS) capacitor c=7.07554e-17
C24 (\6\:Gb VSS) capacitor c=7.60398e-17
C25 (\4\:Gbb VSS) capacitor c=3.33432e-17
C26 (\3\:D VSS) capacitor c=4.2283e-17
C27 (\3\:Gb VSS) capacitor c=5.11966e-17
C28 (\3\:Qbint VSS) capacitor c=2.14591e-17
C29 (\7\:Qint VSS) capacitor c=5.698e-17
C30 (\2\:G VSS) capacitor c=7.25257e-17
C31 (\2\:n0 VSS) capacitor c=6.3873e-17
C32 (\2\:Qint VSS) capacitor c=8.08445e-17
C33 (\7\:Gb VSS) capacitor c=3.93074e-17
C34 (\5\:Gb VSS) capacitor c=3.5228e-17
C35 (\3\:Gbb VSS) capacitor c=2.72777e-17
C36 (\2\:D VSS) capacitor c=4.86436e-17
C37 (\2\:Gb VSS) capacitor c=4.73361e-17
C38 (\1\:Q VSS) capacitor c=1.57222e-17
C39 (\1\:VDD VSS) capacitor c=3.84945e-17
C40 (\7\:Qbint VSS) capacitor c=2.96348e-17
C41 (\3\:QN VSS) capacitor c=2.34099e-17
C42 (\6\:VDD VSS) capacitor c=3.12592e-17
C43 (\14\:Gb VSS) capacitor c=1.11644e-16
C44 (\17\:Qint VSS) capacitor c=4.36862e-17
C45 (\9\:VDD VSS) capacitor c=2.53087e-17
C46 (\6\:n0 VSS) capacitor c=8.01923e-17
C47 (\13\:VDD VSS) capacitor c=3.46206e-17
C48 (\8\:Gbb VSS) capacitor c=6.20865e-17
C49 (\3\:VDD VSS) capacitor c=5.37689e-17
C50 (\3\:Q VSS) capacitor c=3.00297e-17
C51 (\9\:Qbint VSS) capacitor c=3.53809e-17
C52 (\1\:QN VSS) capacitor c=8.3669e-17
C53 (\8\:Gb VSS) capacitor c=8.2607e-17
C54 (\11\:Qint VSS) capacitor c=2.74014e-17
C55 (\8\:n0 VSS) capacitor c=4.14265e-17
C56 (\6\:Gbb VSS) capacitor c=6.61346e-17
C57 (\2\:Gbb VSS) capacitor c=3.72639e-17
C58 (\5\:Qint VSS) capacitor c=3.42811e-17
C59 (\6\:Qint VSS) capacitor c=1.69205e-17
C60 (\2\:Qbint VSS) capacitor c=1.38948e-17
C61 (\5\:Gbb VSS) capacitor c=8.93721e-17
C62 (\4\:n0 VSS) capacitor c=3.83749e-17
C63 (\5\:n0 VSS) capacitor c=7.61203e-17
C64 (\10\:Gb VSS) capacitor c=1.60751e-16
C65 (\11\:Gb VSS) capacitor c=1.03221e-16
C66 (\12\:Gb VSS) capacitor c=1.28902e-16
C67 (\13\:Gb VSS) capacitor c=6.76728e-17
C68 (\4\:G VSS) capacitor c=3.48497e-17
C69 (\13\:Qint VSS) capacitor c=4.40983e-17
C70 (\14\:Qint VSS) capacitor c=4.84893e-17
C71 (\15\:Qint VSS) capacitor c=2.76015e-17
C72 (\16\:Qint VSS) capacitor c=6.1142e-17
C73 (\5\:Qbint VSS) capacitor c=2.35723e-17
C74 (\6\:Qbint VSS) capacitor c=2.19928e-17
C75 (\5\:VDD VSS) capacitor c=4.33118e-17
C76 (\8\:VDD VSS) capacitor c=1.82256e-17
C77 (\12\:VDD VSS) capacitor c=2.44435e-17
Rk12 (G \4\:G) resistor r=0.1856 c=0
Rk18 (\2\:QN QN) resistor r=0.5789 c=0
Rk19 (QN \4\:QN) resistor r=0.05589 c=0
Rk1 (\4\:D D) resistor r=0.001683 c=0
Rk34 (\2\:VDD \4\:VDD) resistor r=0.451 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.4133 c=0
Rk36 (\5\:VDD \7\:VDD) resistor r=0.1789 c=0
Rk37 (\5\:VDD \8\:VDD) resistor r=0.3369 c=0
Rk38 (\8\:VDD \10\:VDD) resistor r=0.04326 c=0
Rk39 (\8\:VDD \11\:VDD) resistor r=0.04897 c=0
Rk42 (\12\:VDD VDD) resistor r=0.1524 c=0
Rk40 (\11\:VDD \12\:VDD) resistor r=0.3982 c=0
Rk41 (\12\:VDD \14\:VDD) resistor r=0.2226 c=0
Rk23 (Q \2\:Q) resistor r=0.07781 c=0
Rk24 (Q \4\:Q) resistor r=0.1915 c=0
Rk25 (\2\:VSS \4\:VSS) resistor r=0.3555 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.3606 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.3629 c=0
Rk28 (\6\:VSS \7\:VSS) resistor r=0.07748 c=0
Rk30 (\8\:VSS VSS) resistor r=0.1674 c=0
Rk29 (\7\:VSS \8\:VSS) resistor r=0.3832 c=0
Rk31 (\5\:VSS \10\:VSS) resistor r=0.2882 c=0
Rk32 (\6\:VSS \12\:VSS) resistor r=0.07334 c=0
Rk33 (\8\:VSS \14\:VSS) resistor r=0.07334 c=0
Rk7 (\9\:Gb \10\:Gb) resistor r=0.6321 c=0
Rk8 (\10\:Gb \11\:Gb) resistor r=0.7103 c=0
Rk9 (\11\:Gb \12\:Gb) resistor r=0.1302 c=0
Rk10 (\12\:Gb \13\:Gb) resistor r=0.3464 c=0
Rk11 (\12\:Gb \15\:Gb) resistor r=0.9488 c=0
Rk2 (\5\:Gbb \7\:Gbb) resistor r=0.4931 c=0
Rk3 (\7\:Gbb \9\:Gbb) resistor r=0.5303 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.2377 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.5164 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.1271 c=0
Rk13 (\12\:Qint \13\:Qint) resistor r=0.1044 c=0
Rk14 (\13\:Qint \14\:Qint) resistor r=0.3093 c=0
Rk15 (\14\:Qint \15\:Qint) resistor r=0.1899 c=0
Rk16 (\13\:Qint \16\:Qint) resistor r=0.2829 c=0
Rk17 (\14\:Qint \18\:Qint) resistor r=0.1856 c=0
Rk20 (\5\:Qbint \6\:Qbint) resistor r=0.1209 c=0
Rk21 (\6\:Qbint \8\:Qbint) resistor r=0.1268 c=0
Rk22 (\6\:Qbint \10\:Qbint) resistor r=0.2057 c=0
Rl15 (\2\:G \3\:G) resistor r=26.3736 c=0
Rl14 (\1\:G \2\:G) resistor r=239.129 c=0
Rl3 (\1\:D \2\:D) resistor r=117.999 c=0
Rl4 (\2\:D \3\:D) resistor r=102.615 c=0
Rl9 (\6\:Gb \7\:Gb) resistor r=31.0185 c=0
Rl5 (\4\:Gb \5\:Gb) resistor r=66.5405 c=0
Rl1 (Gb \2\:Gb) resistor r=29.5379 c=0
Rl2 (\2\:Gb \3\:Gb) resistor r=191.076 c=0
Rl6 (Gbb \2\:Gbb) resistor r=196.221 c=0
Rl8 (\2\:Gbb \4\:Gbb) resistor r=50.349 c=0
Rl7 (\2\:Gbb \3\:Gbb) resistor r=80.5242 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=191.483 c=0
Rl12 (n0 \2\:n0) resistor r=30.5087 c=0
Rl21 (\7\:Qint \10\:Qint) resistor r=222.253 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=109.593 c=0
Rl10 (Qint \2\:Qint) resistor r=132.487 c=0
Rl19 (\5\:Qint \8\:Qint) resistor r=82.3738 c=0
Rl16 (\4\:Qint \5\:Qint) resistor r=44.2087 c=0
Rl20 (\6\:Qint \9\:Qint) resistor r=32.1542 c=0
Rl18 (\6\:Qint \7\:Qint) resistor r=6.0041 c=0
Rl17 (\5\:Qint \6\:Qint) resistor r=203.768 c=0
Rl24 (\2\:Qbint \4\:Qbint) resistor r=23.7402 c=0
Rl22 (Qbint \2\:Qbint) resistor r=100.308 c=0
Rl23 (\2\:Qbint \3\:Qbint) resistor r=5.8511 c=0
Rz5 (\1\:QN \2\:QN) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz13 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz3 (\8\:Gb \9\:Gb) resistor r=75 c=0
Rz1 (\6\:Gbb \7\:Gbb) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (\11\:Qint \12\:Qint) resistor r=75 c=0
Rz6 (\9\:Qbint \10\:Qbint) resistor r=75 c=0
Ry5 (\3\:QN \4\:QN) resistor r=62 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry12 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\1\:Q \2\:Q) resistor r=62 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry9 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry3 (\14\:Gb \15\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\7\:Qbint \8\:Qbint) resistor r=62 c=0
Rx7 (\2\:G \4\:G) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx5 (\5\:Gb \11\:Gb) resistor r=45 c=0
Rx6 (\2\:Gb \13\:Gb) resistor r=45 c=0
Rx2 (\3\:Gbb \5\:Gbb) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Qint \15\:Qint) resistor r=45 c=0
Rx9 (\7\:Qint \16\:Qint) resistor r=45 c=0
Rx10 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
mn1 (\6\:Gbb \3\:Gb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=1.42e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (net257 \3\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=6.598e-14 ps=1.42e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.195e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn6 (\8\:n0 \4\:Gbb net257 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.598e-14 ad=2.32e-14 ps=1.2e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.95e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn16 (\8\:n0 \6\:Gb net245 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn15 (net245 Qint \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=8.7e-15 ps=1.45e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\11\:Qint n0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=2.755e-14 ps=1.45e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=1.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\8\:Gb \1\:G \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn22 (\1\:QN \9\:Qint \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn20 (\9\:Qbint \4\:Qint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\3\:Q Qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
ends TLATXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:20 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR2X1
// View name: extracted

simulator lang=spectre

subckt XNOR2X1 A B VDD VSS Y
mp5 (\1\:Y n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=5.46e-14 ps=1.84e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=33.3935 \
        scb=0.0357498 scc=0.00324908 m=(1)
C1 (A VSS) capacitor c=6.03952e-17
C2 (Y VSS) capacitor c=1.84759e-17
C3 (VDD VSS) capacitor c=1.10495e-16
C4 (n0 VSS) capacitor c=4.11935e-17
C5 (n1 VSS) capacitor c=1.08538e-16
C6 (n2 VSS) capacitor c=4.50313e-17
C7 (\4\:B VSS) capacitor c=3.8499e-17
C8 (\1\:B VSS) capacitor c=5.64065e-17
C9 (\1\:A VSS) capacitor c=4.14201e-17
C10 (\6\:B VSS) capacitor c=3.73462e-17
C11 (\2\:n1 VSS) capacitor c=6.78451e-17
C12 (\3\:n2 VSS) capacitor c=4.92351e-17
C13 (\3\:B VSS) capacitor c=5.20044e-17
C14 (\3\:A VSS) capacitor c=4.45859e-17
C15 (\3\:n0 VSS) capacitor c=4.19318e-17
C16 (\5\:B VSS) capacitor c=3.70968e-17
C17 (\3\:n1 VSS) capacitor c=3.11525e-17
C18 (\2\:B VSS) capacitor c=7.778e-17
C19 (\4\:n2 VSS) capacitor c=4.84421e-17
C20 (\2\:n2 VSS) capacitor c=2.66676e-17
C21 (\2\:A VSS) capacitor c=3.94836e-17
C22 (\2\:n0 VSS) capacitor c=2.6378e-17
C23 (\8\:n2 VSS) capacitor c=7.00741e-17
C24 (\1\:VDD VSS) capacitor c=4.47922e-17
C25 (\6\:n0 VSS) capacitor c=1.50498e-16
C26 (\4\:n1 VSS) capacitor c=9.69954e-17
C27 (\6\:VDD VSS) capacitor c=7.89395e-18
C28 (\1\:Y VSS) capacitor c=7.99782e-17
C29 (\5\:n2 VSS) capacitor c=1.99369e-17
C30 (\4\:n0 VSS) capacitor c=1.00221e-16
C31 (\6\:n1 VSS) capacitor c=1.21137e-16
C32 (\3\:Y VSS) capacitor c=4.92514e-17
C33 (\4\:A VSS) capacitor c=4.80908e-17
C34 (\8\:n0 VSS) capacitor c=1.25416e-16
C35 (\8\:n1 VSS) capacitor c=8.56778e-17
C36 (\7\:B VSS) capacitor c=3.48014e-17
C37 (\8\:B VSS) capacitor c=7.08491e-17
C38 (\7\:n2 VSS) capacitor c=4.88703e-17
C39 (\10\:n2 VSS) capacitor c=1.06438e-16
C40 (\11\:n2 VSS) capacitor c=8.19942e-17
C41 (\4\:VDD VSS) capacitor c=2.40281e-17
C42 (\5\:VDD VSS) capacitor c=7.14335e-18
Rk3 (\4\:A A) resistor r=0.1344 c=0
Rk2 (\4\:Y Y) resistor r=0.02554 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.4604 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4663 c=0
Rk16 (\5\:VSS VSS) resistor r=0.1026 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.1983 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.3051 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.2524 c=0
Rk20 (\5\:VDD VDD) resistor r=0.07995 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.2209 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.07488 c=0
Rk8 (\7\:B B) resistor r=0.105 c=0
Rk9 (B \8\:B) resistor r=0.04993 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.5904 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.738 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4858 c=0
Rk7 (\7\:n1 \8\:n1) resistor r=0.4295 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1354 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2777 c=0
Rk12 (\9\:n2 \10\:n2) resistor r=0.6504 c=0
Rk13 (\7\:n2 \11\:n2) resistor r=0.2288 c=0
Rl3 (\1\:A \2\:A) resistor r=29.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=104.538 c=0
Rl11 (\4\:B \5\:B) resistor r=24.2328 c=0
Rl12 (\5\:B \6\:B) resistor r=106.925 c=0
Rl6 (\1\:B \2\:B) resistor r=26.098 c=0
Rl7 (\2\:B \3\:B) resistor r=138.45 c=0
Rl1 (n0 \2\:n0) resistor r=26.098 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=56.8672 c=0
Rl9 (n1 \2\:n1) resistor r=159.615 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=66.5405 c=0
Rl8 (\3\:n2 \4\:n2) resistor r=24.2328 c=0
Rl5 (n2 \2\:n2) resistor r=52.6149 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.40962e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(1)
mn0 (\6\:n1 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.65e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn4 (\4\:n0 \3\:B \6\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn3 (\4\:n0 \3\:n2 net145 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.45e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\5\:n2 \6\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp0 (\4\:n1 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=3.44e-14 ps=1.84e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.47326e-07 sd=160n sca=30.7589 \
        scb=0.0279464 scc=0.00328165 m=(1)
mp4 (\4\:n1 n2 \6\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.42326e-07 sd=160n sca=28.8228 \
        scb=0.0245184 scc=0.00324094 m=(1)
mp3 (\6\:n0 \1\:B net112 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.548e-14 ps=5.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.32326e-07 sd=160n sca=28.9644 \
        scb=0.0247513 scc=0.00324182 m=(1)
mp2 (net112 n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.27326e-07 sd=160n sca=29.7748 \
        scb=0.0261855 scc=0.00325287 m=(1)
mp1 (\8\:n2 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=2.63e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.22326e-07 sd=160n sca=35.5405 \
        scb=0.0359913 scc=0.00371931 m=(1)
ends XNOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:21 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR2X2
// View name: extracted

simulator lang=spectre

subckt XNOR2X2 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.095e-14 \
        ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.53654e-07 sd=160n sca=26.5621 scb=0.0304693 \
        scc=0.00192189 m=(2)
C1 (A VSS) capacitor c=4.39321e-17
C2 (VDD VSS) capacitor c=2.68718e-16
C3 (Y VSS) capacitor c=5.23072e-17
C4 (B VSS) capacitor c=8.4126e-17
C5 (n0 VSS) capacitor c=1.631e-16
C6 (n1 VSS) capacitor c=7.38034e-17
C7 (n2 VSS) capacitor c=4.22106e-17
C8 (net112 VSS) capacitor c=2.2804e-18
C9 (\4\:B VSS) capacitor c=3.34785e-17
C10 (\1\:B VSS) capacitor c=4.52449e-17
C11 (\1\:A VSS) capacitor c=4.70866e-17
C12 (\6\:B VSS) capacitor c=3.6091e-17
C13 (\2\:n1 VSS) capacitor c=4.92691e-17
C14 (\3\:n2 VSS) capacitor c=4.20676e-17
C15 (\3\:B VSS) capacitor c=5.58661e-17
C16 (\3\:A VSS) capacitor c=2.87177e-17
C17 (\5\:B VSS) capacitor c=3.34177e-17
C18 (\3\:n1 VSS) capacitor c=3.14832e-17
C19 (\2\:B VSS) capacitor c=7.28618e-17
C20 (\4\:n2 VSS) capacitor c=4.41211e-17
C21 (\2\:n2 VSS) capacitor c=2.49968e-17
C22 (\2\:A VSS) capacitor c=3.73715e-17
C23 (\6\:n2 VSS) capacitor c=1.2696e-16
C24 (\8\:VDD VSS) capacitor c=6.77323e-17
C25 (\7\:n0 VSS) capacitor c=1.41718e-16
C26 (\7\:n1 VSS) capacitor c=8.84658e-17
C27 (\1\:Y VSS) capacitor c=9.29982e-17
C28 (\10\:n2 VSS) capacitor c=1.91932e-17
C29 (\10\:n0 VSS) capacitor c=7.93932e-17
C30 (\5\:n1 VSS) capacitor c=1.06709e-16
C31 (\3\:Y VSS) capacitor c=6.69666e-17
C32 (\5\:A VSS) capacitor c=5.02239e-17
C33 (\9\:n0 VSS) capacitor c=1.39572e-16
C34 (\4\:n1 VSS) capacitor c=5.94123e-17
C35 (\8\:B VSS) capacitor c=7.44339e-17
C36 (\5\:n2 VSS) capacitor c=1.09838e-16
C37 (\8\:n2 VSS) capacitor c=6.40781e-17
C38 (\9\:n2 VSS) capacitor c=9.23034e-17
C39 (\7\:VDD VSS) capacitor c=4.62997e-17
Rk3 (\4\:A \5\:A) resistor r=0.002857 c=0
Rk4 (\6\:A A) resistor r=0.002971 c=0
Rk5 (\5\:A \6\:A) resistor r=0.06502 c=0
Rk24 (VDD \7\:VDD) resistor r=0.1956 c=0
Rk25 (\7\:VDD \9\:VDD) resistor r=0.6008 c=0
Rk17 (\4\:VSS VSS) resistor r=0.1956 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.6113 c=0
Rk1 (\2\:Y Y) resistor r=0.2399 c=0
Rk2 (Y \4\:Y) resistor r=0.1958 c=0
Rk10 (B \7\:B) resistor r=0.0075 c=0
Rk11 (\7\:B \8\:B) resistor r=0.1907 c=0
Rk6 (\8\:n0 \9\:n0) resistor r=0.7954 c=0
Rk7 (\8\:n0 \11\:n0) resistor r=0.4367 c=0
Rk8 (\4\:n1 \6\:n1) resistor r=0.4285 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.4717 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.7606 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.2667 c=0
Rk14 (\8\:n2 \9\:n2) resistor r=0.3421 c=0
Rk15 (\8\:n2 \11\:n2) resistor r=0.09346 c=0
Rl6 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl7 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl14 (\4\:B \5\:B) resistor r=48.7687 c=0
Rl15 (\5\:B \6\:B) resistor r=87.2302 c=0
Rl10 (\1\:B \2\:B) resistor r=30.6172 c=0
Rl11 (\2\:B \3\:B) resistor r=155.254 c=0
Rl12 (n1 \2\:n1) resistor r=161.538 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl9 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl8 (n2 \2\:n2) resistor r=50.6918 c=0
Rz5 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz1 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\10\:n2 \11\:n2) resistor r=75 c=0
Ry8 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \5\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \9\:n2) resistor r=45 c=0
mn5 (\3\:Y n0 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.039e-14 \
        ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.6125e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mn0 (\5\:n1 \3\:A VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.263e-14 ps=9.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.005e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\10\:n0 \3\:B \5\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.393e-14 ps=7.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (\10\:n0 \3\:n2 net145 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.393e-14 ps=5.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=5.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.885e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.5e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (\10\:n2 \6\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.45e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mp0 (\7\:n1 \1\:A VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=4.837e-14 ps=1.17e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1e-06 sd=160n sca=16.298 scb=0.01559 \
        scc=0.000885958 m=(1)
mp4 (\7\:n1 n2 \7\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.3e-07 sd=160n sca=15.5147 \
        scb=0.015083 scc=0.000885445 m=(1)
mp3 (\7\:n0 \1\:B net112 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=5.25e-07 sd=160n sca=16.1384 \
        scb=0.0154529 scc=0.000885735 m=(1)
mp2 (net112 n1 \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.45e-07 sd=160n sca=17.5209 \
        scb=0.017113 scc=0.000893675 m=(1)
mp1 (\6\:n2 \4\:B \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=22.379 \
        scb=0.0254075 scc=0.00119864 m=(1)
ends XNOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:22 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR2X4
// View name: extracted

simulator lang=spectre

subckt XNOR2X4 A B VDD VSS Y
mp4 (\4\:n1 \3\:n2 \13\:n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.523e-14 ps=1.1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.89103e-07 sb=5.79551e-07 sd=160n sca=12.0589 \
        scb=0.0100044 scc=0.000274129 m=(1)
mp3 (\13\:n0 \3\:B net112 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.94103e-07 sb=3.74551e-07 sd=160n sca=13.0911 \
        scb=0.0108737 scc=0.000275827 m=(1)
mp2 (net112 n1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0991e-06 sb=2.69551e-07 sd=160n sca=14.1331 \
        scb=0.0123288 scc=0.000285937 m=(1)
mp5_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.119e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38346e-06 sd=160n sca=25.2855 \
        scb=0.0288799 scc=0.00168046 m=(4)
C1 (A VSS) capacitor c=3.95322e-17
C2 (Y VSS) capacitor c=3.34453e-17
C3 (VDD VSS) capacitor c=3.50423e-16
C4 (B VSS) capacitor c=2.98203e-17
C5 (n0 VSS) capacitor c=2.88456e-16
C6 (n1 VSS) capacitor c=7.65476e-17
C7 (n2 VSS) capacitor c=4.9748e-17
C8 (\5\:B VSS) capacitor c=4.38519e-17
C9 (\3\:B VSS) capacitor c=9.08084e-17
C10 (\3\:n2 VSS) capacitor c=6.04807e-17
C11 (\1\:A VSS) capacitor c=4.86411e-17
C12 (\7\:B VSS) capacitor c=3.33408e-17
C13 (\3\:n1 VSS) capacitor c=8.70983e-17
C14 (\1\:B VSS) capacitor c=4.80116e-17
C15 (\3\:A VSS) capacitor c=4.66706e-17
C16 (\6\:B VSS) capacitor c=5.66627e-17
C17 (\2\:n1 VSS) capacitor c=7.69044e-17
C18 (\4\:B VSS) capacitor c=6.09868e-17
C19 (\2\:n2 VSS) capacitor c=7.1549e-17
C20 (\2\:B VSS) capacitor c=4.48189e-17
C21 (\2\:A VSS) capacitor c=4.35825e-17
C22 (\4\:n2 VSS) capacitor c=4.50214e-17
C23 (\1\:VDD VSS) capacitor c=7.13646e-17
C24 (\13\:n0 VSS) capacitor c=1.31697e-16
C25 (\4\:n1 VSS) capacitor c=3.62593e-17
C26 (\1\:Y VSS) capacitor c=2.29446e-16
C27 (\8\:n2 VSS) capacitor c=3.08008e-17
C28 (\16\:n0 VSS) capacitor c=1.33191e-16
C29 (\7\:n1 VSS) capacitor c=9.63058e-17
C30 (\4\:Y VSS) capacitor c=1.64186e-16
C31 (\4\:A VSS) capacitor c=5.34978e-17
C32 (\15\:n0 VSS) capacitor c=2.56027e-16
C33 (\6\:n1 VSS) capacitor c=9.80345e-17
C34 (\9\:n1 VSS) capacitor c=6.93421e-17
C35 (\8\:B VSS) capacitor c=7.68814e-17
C36 (\9\:B VSS) capacitor c=5.10664e-17
C37 (\10\:B VSS) capacitor c=7.35235e-17
C38 (\6\:n2 VSS) capacitor c=8.89118e-17
C39 (\7\:n2 VSS) capacitor c=7.19634e-17
C40 (\4\:VDD VSS) capacitor c=3.38119e-17
Rk7 (A \4\:A) resistor r=0.05291 c=0
Rk2 (\1\:Y Y) resistor r=0.2077 c=0
Rk3 (Y \4\:Y) resistor r=0.103 c=0
Rk20 (\4\:VDD VDD) resistor r=0.09048 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.6345 c=0
Rk27 (\4\:VSS VSS) resistor r=0.1011 c=0
Rk26 (\2\:VSS \4\:VSS) resistor r=0.5025 c=0
Rk13 (B \8\:B) resistor r=0.05065 c=0
Rk14 (\8\:B \9\:B) resistor r=0.1995 c=0
Rk15 (\9\:B \10\:B) resistor r=0.3157 c=0
Rk8 (\14\:n0 \15\:n0) resistor r=1.1557 c=0
Rk9 (\15\:n0 \17\:n0) resistor r=0.9928 c=0
Rk10 (\5\:n1 \6\:n1) resistor r=0.06323 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.4893 c=0
Rk12 (\6\:n1 \9\:n1) resistor r=0.341 c=0
Rk16 (\5\:n2 \6\:n2) resistor r=0.369 c=0
Rk17 (\6\:n2 \7\:n2) resistor r=0.4101 c=0
Rk18 (\6\:n2 \9\:n2) resistor r=0.0803 c=0
Rl12 (\1\:A \2\:A) resistor r=123.769 c=0
Rl13 (\2\:A \3\:A) resistor r=57.2589 c=0
Rl20 (\5\:B \6\:B) resistor r=105.746 c=0
Rl21 (\6\:B \7\:B) resistor r=86.3335 c=0
Rl17 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl14 (\1\:B \2\:B) resistor r=51.903 c=0
Rl18 (n1 \2\:n1) resistor r=24.2328 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=177.645 c=0
Rl16 (\2\:n2 \3\:n2) resistor r=157.143 c=0
Rl15 (n2 \2\:n2) resistor r=26.9231 c=0
Rz7 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz3 (\17\:n0 \16\:n0) resistor r=37.5 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry6 (\2\:VDD \1\:VDD) resistor r=20.6667 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=31 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\15\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \7\:n2) resistor r=45 c=0
mn4 (\16\:n0 \1\:B \7\:n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.833e-14 ad=4.16e-14 ps=8.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.24615e-07 sb=6.36058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\16\:n0 n2 net145 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.16e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.29615e-07 sb=4.31058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (net145 \3\:n1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.21e-14 ps=9.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05962e-06 sb=3.01058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_1__rcx (\4\:Y n0 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.081e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34894e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.833e-14 ps=9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=9.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\8\:n2 \7\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp0 (\4\:n1 \1\:A VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=8.523e-14 ps=1.16e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.045e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\4\:n2 \5\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=1.4e-07 sd=160n sca=22.7425 \
        scb=0.0263845 scc=0.00115464 m=(1)
ends XNOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:23 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR2XL
// View name: extracted

simulator lang=spectre

subckt XNOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.17e-14 ps=1.74e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47442e-07 sb=1.15733e-06 sd=160n sca=27.5082 \
        scb=0.031157 scc=0.00214164 m=(1)
mp0 (\7\:n1 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.548e-14 ps=1.74e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52442e-07 sb=9.52326e-07 sd=160n sca=21.6735 \
        scb=0.0213374 scc=0.00167521 m=(1)
mp4 (\7\:n1 n2 \4\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.62442e-07 sb=7.42326e-07 sd=160n sca=20.0463 \
        scb=0.0191953 scc=0.00166251 m=(1)
mp3 (\4\:n0 \1\:B net112 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.67442e-07 sb=5.37326e-07 sd=160n sca=19.9753 \
        scb=0.0191105 scc=0.0016624 m=(1)
mp2 (net112 n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.75e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.72442e-07 sb=3.32326e-07 sd=160n sca=21.2505 \
        scb=0.0206889 scc=0.0016691 m=(1)
mp1 (\8\:n2 \5\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=2.63e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18244e-06 sb=1.22326e-07 sd=160n sca=25.996 \
        scb=0.028784 scc=0.00194969 m=(1)
C1 (A VSS) capacitor c=6.38222e-17
C2 (VDD VSS) capacitor c=1.3561e-16
C3 (Y VSS) capacitor c=3.98427e-17
C4 (B VSS) capacitor c=2.75544e-17
C5 (n0 VSS) capacitor c=3.30706e-17
C6 (n1 VSS) capacitor c=7.99282e-17
C7 (n2 VSS) capacitor c=5.31397e-17
C8 (net112 VSS) capacitor c=4.43785e-18
C9 (\5\:B VSS) capacitor c=3.76994e-17
C10 (\1\:B VSS) capacitor c=4.00226e-17
C11 (\1\:A VSS) capacitor c=5.16865e-17
C12 (\7\:B VSS) capacitor c=3.38154e-17
C13 (\2\:n1 VSS) capacitor c=4.36806e-17
C14 (\3\:n2 VSS) capacitor c=3.91347e-17
C15 (\3\:B VSS) capacitor c=6.10931e-17
C16 (\3\:A VSS) capacitor c=3.14351e-17
C17 (\3\:n0 VSS) capacitor c=3.70164e-17
C18 (\6\:B VSS) capacitor c=3.88823e-17
C19 (\3\:n1 VSS) capacitor c=3.06491e-17
C20 (\4\:B VSS) capacitor c=3.01567e-17
C21 (\4\:n2 VSS) capacitor c=4.27941e-17
C22 (\2\:n2 VSS) capacitor c=2.3665e-17
C23 (\2\:A VSS) capacitor c=3.99165e-17
C24 (\2\:n0 VSS) capacitor c=3.24908e-17
C25 (\8\:n2 VSS) capacitor c=9.31861e-17
C26 (\1\:VDD VSS) capacitor c=3.4911e-17
C27 (\4\:n0 VSS) capacitor c=1.6305e-16
C28 (\7\:n1 VSS) capacitor c=8.92966e-17
C29 (\6\:VDD VSS) capacitor c=2.83553e-17
C30 (\1\:Y VSS) capacitor c=5.86672e-17
C31 (\5\:n2 VSS) capacitor c=1.93713e-17
C32 (\7\:n0 VSS) capacitor c=7.81621e-17
C33 (\5\:n1 VSS) capacitor c=1.2375e-16
C34 (\3\:Y VSS) capacitor c=2.59561e-17
C35 (\2\:B VSS) capacitor c=4.5307e-17
C36 (\4\:A VSS) capacitor c=3.57017e-17
C37 (\6\:n0 VSS) capacitor c=1.21188e-16
C38 (\4\:n1 VSS) capacitor c=6.44533e-17
C39 (\8\:B VSS) capacitor c=5.18835e-17
C40 (\9\:B VSS) capacitor c=4.77602e-17
C41 (\7\:n2 VSS) capacitor c=5.77562e-17
C42 (\10\:n2 VSS) capacitor c=7.7645e-17
C43 (\11\:n2 VSS) capacitor c=1.0555e-16
C44 (\4\:VDD VSS) capacitor c=3.20429e-17
C45 (\5\:VDD VSS) capacitor c=1.00136e-17
Rk3 (A \4\:A) resistor r=0.08017 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.551 c=0
Rk16 (\5\:VSS VSS) resistor r=0.135 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2155 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.3456 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.2921 c=0
Rk20 (\5\:VDD VDD) resistor r=0.15 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.2004 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.1608 c=0
Rk1 (\2\:Y Y) resistor r=0.2937 c=0
Rk2 (Y \4\:Y) resistor r=0.08433 c=0
Rk8 (\8\:B B) resistor r=0.07907 c=0
Rk9 (B \9\:B) resistor r=0.0911 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8388 c=0
Rk5 (\5\:n0 \8\:n0) resistor r=0.3989 c=0
Rk6 (\4\:n1 \6\:n1) resistor r=0.4559 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.5094 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1047 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2748 c=0
Rk12 (\7\:n2 \10\:n2) resistor r=0.3435 c=0
Rk13 (\9\:n2 \11\:n2) resistor r=0.7396 c=0
Rl3 (\1\:A \2\:A) resistor r=83.3841 c=0
Rl4 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl12 (\5\:B \6\:B) resistor r=39.5596 c=0
Rl13 (\6\:B \7\:B) resistor r=76.098 c=0
Rl7 (\1\:B \2\:B) resistor r=25.7494 c=0
Rl8 (\2\:B \3\:B) resistor r=146.518 c=0
Rl9 (\2\:B \4\:B) resistor r=5.783 c=0
Rl1 (n0 \2\:n0) resistor r=33.3841 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.1533 c=0
Rl10 (n1 \2\:n1) resistor r=148.077 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl6 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl5 (n2 \2\:n2) resistor r=69.9225 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\4\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\2\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn0 (\5\:n1 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.7e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn4 (\7\:n0 \3\:B \5\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.392e-14 ps=6.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.6e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn3 (\7\:n0 \3\:n2 net145 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.392e-14 ps=6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.247e-14 ps=6.2e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=3.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (\5\:n2 \7\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
ends XNOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:23 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR3X1
// View name: extracted

simulator lang=spectre

subckt XNOR3X1 A B C VDD VSS Y
mp3 (\14\:n62 \1\:A \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.184e-13 ad=5.46e-14 ps=1.83e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.48205e-07 sd=160n sca=32.1464 \
        scb=0.0331985 scc=0.00298203 m=(1)
mp2 (\7\:n62 \3\:B n9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.58e-14 ad=6.9e-14 ps=1.64e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46923e-07 sb=4.9859e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp11 (\7\:n62 \4\:n61 \8\:n12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=6.9e-14 ps=1.28e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.09231e-07 sb=2.95513e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp8 (\3\:Y n11 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4125e-13 ad=6.63e-14 ps=2.07e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.01538e-07 sb=1.7e-07 sd=160n sca=41.3017 \
        scb=0.035902 scc=0.00422214 m=(1)
C1 (B VSS) capacitor c=6.057e-17
C2 (A VSS) capacitor c=7.25191e-17
C3 (Y VSS) capacitor c=4.34425e-17
C4 (VDD VSS) capacitor c=4.37919e-16
C5 (C VSS) capacitor c=4.29059e-17
C6 (n62 VSS) capacitor c=7.17541e-17
C7 (n61 VSS) capacitor c=6.24514e-17
C8 (n8 VSS) capacitor c=6.88991e-17
C9 (n9 VSS) capacitor c=3.18248e-16
C10 (n12 VSS) capacitor c=8.37684e-17
C11 (n11 VSS) capacitor c=3.12602e-17
C12 (n60 VSS) capacitor c=4.59291e-17
C13 (\3\:C VSS) capacitor c=3.29882e-17
C14 (\7\:C VSS) capacitor c=3.67656e-17
C15 (\3\:n60 VSS) capacitor c=6.65781e-17
C16 (\2\:B VSS) capacitor c=1.06213e-16
C17 (\4\:n61 VSS) capacitor c=7.81244e-17
C18 (\3\:B VSS) capacitor c=1.346e-16
C19 (\3\:n62 VSS) capacitor c=4.76525e-17
C20 (\8\:B VSS) capacitor c=5.1581e-17
C21 (\1\:A VSS) capacitor c=4.98956e-17
C22 (\3\:n11 VSS) capacitor c=2.63333e-17
C23 (\6\:C VSS) capacitor c=4.55948e-17
C24 (\4\:n60 VSS) capacitor c=3.66958e-17
C25 (\1\:C VSS) capacitor c=3.95215e-17
C26 (\10\:n61 VSS) capacitor c=4.51266e-17
C27 (\1\:B VSS) capacitor c=8.543e-17
C28 (\9\:n61 VSS) capacitor c=2.52827e-17
C29 (\6\:B VSS) capacitor c=3.825e-17
C30 (\7\:B VSS) capacitor c=4.03144e-17
C31 (\4\:A VSS) capacitor c=3.43754e-17
C32 (\2\:n11 VSS) capacitor c=1.6765e-17
C33 (\5\:C VSS) capacitor c=5.5058e-17
C34 (\2\:C VSS) capacitor c=2.28626e-17
C35 (\2\:n8 VSS) capacitor c=6.54009e-17
C36 (\11\:n61 VSS) capacitor c=3.36993e-17
C37 (\7\:n61 VSS) capacitor c=2.82076e-17
C38 (\2\:n61 VSS) capacitor c=7.97778e-17
C39 (\4\:n62 VSS) capacitor c=3.0215e-17
C40 (\3\:n61 VSS) capacitor c=6.35563e-17
C41 (\2\:n62 VSS) capacitor c=5.42016e-17
C42 (\5\:B VSS) capacitor c=8.13792e-17
C43 (\3\:A VSS) capacitor c=1.30862e-17
C44 (\3\:Y VSS) capacitor c=4.06574e-17
C45 (\1\:VDD VSS) capacitor c=7.68694e-17
C46 (\5\:n60 VSS) capacitor c=6.35494e-17
C47 (\3\:n12 VSS) capacitor c=1.53812e-16
C48 (\8\:n11 VSS) capacitor c=1.05901e-16
C49 (\5\:n9 VSS) capacitor c=2.5183e-16
C50 (\4\:n8 VSS) capacitor c=1.43666e-16
C51 (\8\:n12 VSS) capacitor c=6.80506e-17
C52 (\7\:n62 VSS) capacitor c=1.54482e-16
C53 (\6\:n8 VSS) capacitor c=1.16154e-16
C54 (\9\:VDD VSS) capacitor c=2.52037e-17
C55 (\16\:n61 VSS) capacitor c=5.84314e-17
C56 (\7\:VDD VSS) capacitor c=5.76607e-17
C57 (\14\:n62 VSS) capacitor c=2.96937e-17
C58 (\3\:VDD VSS) capacitor c=1.08341e-16
C59 (\8\:n60 VSS) capacitor c=4.8149e-17
C60 (\6\:n11 VSS) capacitor c=9.16253e-17
C61 (\7\:n9 VSS) capacitor c=6.17342e-17
C62 (\9\:n8 VSS) capacitor c=1.37502e-16
C63 (\6\:n12 VSS) capacitor c=1.04683e-16
C64 (\5\:n62 VSS) capacitor c=8.39459e-17
C65 (\3\:n9 VSS) capacitor c=1.14172e-16
C66 (\11\:n8 VSS) capacitor c=1.34293e-16
C67 (\14\:n61 VSS) capacitor c=5.78312e-17
C68 (\11\:n62 VSS) capacitor c=1.16627e-16
C69 (\2\:A VSS) capacitor c=1.91808e-17
C70 (\5\:n61 VSS) capacitor c=4.07372e-17
C71 (\6\:n61 VSS) capacitor c=2.12494e-17
C72 (\4\:B VSS) capacitor c=1.33957e-16
C73 (\2\:n60 VSS) capacitor c=5.48964e-17
C74 (\4\:C VSS) capacitor c=3.85722e-17
C75 (\5\:A VSS) capacitor c=3.22469e-17
C76 (\9\:B VSS) capacitor c=5.31524e-17
C77 (\12\:n61 VSS) capacitor c=1.06121e-17
C78 (\13\:n61 VSS) capacitor c=4.64037e-17
C79 (\18\:n61 VSS) capacitor c=5.85224e-17
C80 (\19\:n61 VSS) capacitor c=5.75891e-17
C81 (\9\:n62 VSS) capacitor c=1.21215e-16
C82 (\10\:n62 VSS) capacitor c=1.45551e-16
C83 (\13\:n62 VSS) capacitor c=8.69027e-17
C84 (\20\:n61 VSS) capacitor c=4.05818e-17
C85 (\21\:n61 VSS) capacitor c=5.84591e-17
C86 (\3\:n8 VSS) capacitor c=5.83304e-17
C87 (\8\:n8 VSS) capacitor c=2.173e-17
C88 (\8\:C VSS) capacitor c=4.83587e-17
C89 (\9\:C VSS) capacitor c=2.5298e-17
C90 (\5\:n12 VSS) capacitor c=1.68212e-16
C91 (\7\:n60 VSS) capacitor c=4.28584e-17
C92 (\4\:n11 VSS) capacitor c=3.93609e-17
C93 (\5\:n11 VSS) capacitor c=1.93597e-16
Rk40 (\2\:VSS \4\:VSS) resistor r=0.5433 c=0
Rk41 (\4\:VSS \5\:VSS) resistor r=1.1055 c=0
Rk43 (\7\:VSS VSS) resistor r=0.1533 c=0
Rk42 (\5\:VSS \7\:VSS) resistor r=0.09704 c=0
Rk44 (VSS \9\:VSS) resistor r=0.04124 c=0
Rk2 (B \9\:B) resistor r=0.09811 c=0
Rk1 (\5\:A A) resistor r=0.09363 c=0
Rk33 (Y \4\:Y) resistor r=0.3303 c=0
Rk35 (\4\:VDD VDD) resistor r=0.6839 c=0
Rk34 (\2\:VDD \4\:VDD) resistor r=0.4125 c=0
Rk36 (VDD \5\:VDD) resistor r=0.03274 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.04822 c=0
Rk38 (\6\:VDD \8\:VDD) resistor r=0.4895 c=0
Rk39 (\6\:VDD \10\:VDD) resistor r=0.04903 c=0
Rk21 (C \8\:C) resistor r=0.3082 c=0
Rk22 (C \9\:C) resistor r=0.02421 c=0
Rk8 (\6\:n62 \8\:n62) resistor r=0.537 c=0
Rk9 (\8\:n62 \9\:n62) resistor r=0.6857 c=0
Rk10 (\9\:n62 \10\:n62) resistor r=0.7105 c=0
Rk11 (\10\:n62 \12\:n62) resistor r=0.7098 c=0
Rk12 (\12\:n62 \13\:n62) resistor r=0.6063 c=0
Rk13 (\10\:n62 \15\:n62) resistor r=0.1074 c=0
Rk3 (\12\:n61 \13\:n61) resistor r=0.0477 c=0
Rk4 (\13\:n61 \15\:n61) resistor r=0.2173 c=0
Rk5 (\13\:n61 \17\:n61) resistor r=0.2062 c=0
Rk7 (\18\:n61 \19\:n61) resistor r=0.2415 c=0
Rk14 (\20\:n61 \21\:n61) resistor r=0.2153 c=0
Rk15 (\3\:n8 \5\:n8) resistor r=0.2704 c=0
Rk16 (\5\:n8 \7\:n8) resistor r=0.8102 c=0
Rk17 (\8\:n8 \10\:n8) resistor r=0.12 c=0
Rk18 (\10\:n8 \12\:n8) resistor r=0.9717 c=0
Rk6 (\2\:n9 \4\:n9) resistor r=0.8306 c=0
Rk19 (\6\:n9 \8\:n9) resistor r=0.5375 c=0
Rk20 (\9\:n9 \10\:n9) resistor r=1.105 c=0
Rk23 (\2\:n12 \4\:n12) resistor r=0.3949 c=0
Rk24 (\4\:n12 \5\:n12) resistor r=0.753 c=0
Rk25 (\5\:n12 \7\:n12) resistor r=0.6441 c=0
Rk26 (\5\:n12 \9\:n12) resistor r=0.3429 c=0
Rk29 (\4\:n11 \5\:n11) resistor r=0.1621 c=0
Rk30 (\5\:n11 \7\:n11) resistor r=0.7721 c=0
Rk31 (\5\:n11 \9\:n11) resistor r=0.7957 c=0
Rk27 (\6\:n60 \7\:n60) resistor r=0.1826 c=0
Rk28 (\7\:n60 \9\:n60) resistor r=0.09203 c=0
Rl14 (\2\:B \3\:B) resistor r=278.412 c=0
Rl13 (\1\:B \2\:B) resistor r=215.425 c=0
Rl19 (\5\:B \8\:B) resistor r=80.6172 c=0
Rl18 (\5\:B \7\:B) resistor r=22.5951 c=0
Rl15 (\3\:B \4\:B) resistor r=222.62 c=0
Rl17 (\4\:B \6\:B) resistor r=63.143 c=0
Rl16 (\4\:B \5\:B) resistor r=332.076 c=0
Rl1 (\1\:A \2\:A) resistor r=90.0987 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=9.8995 c=0
Rl29 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl22 (\1\:C \2\:C) resistor r=47.59 c=0
Rl26 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl28 (\4\:C \6\:C) resistor r=103.08 c=0
Rl27 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=124.029 c=0
Rl4 (n62 \2\:n62) resistor r=223.334 c=0
Rl20 (\10\:n61 \11\:n61) resistor r=53.079 c=0
Rl6 (n61 \2\:n61) resistor r=135.771 c=0
Rl7 (\2\:n61 \3\:n61) resistor r=213.948 c=0
Rl8 (\4\:n61 \5\:n61) resistor r=33.3918 c=0
Rl11 (\5\:n61 \8\:n61) resistor r=17.233 c=0
Rl12 (\6\:n61 \9\:n61) resistor r=37.3411 c=0
Rl10 (\6\:n61 \7\:n61) resistor r=10.9341 c=0
Rl9 (\5\:n61 \6\:n61) resistor r=108.473 c=0
Rl21 (n8 \2\:n8) resistor r=420.614 c=0
Rl30 (n11 \2\:n11) resistor r=24.2328 c=0
Rl31 (\2\:n11 \3\:n11) resistor r=39.6174 c=0
Rl24 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl25 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rl23 (n60 \2\:n60) resistor r=106.101 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=18.75 c=0
Rz16 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz17 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\1\:Y Y) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\14\:n61 \15\:n61) resistor r=75 c=0
Rz5 (\9\:n8 \10\:n8) resistor r=75 c=0
Rz6 (\11\:n8 \12\:n8) resistor r=75 c=0
Rz2 (\3\:n9 \4\:n9) resistor r=75 c=0
Rz7 (\7\:n9 \8\:n9) resistor r=75 c=0
Rz8 (n12 \2\:n12) resistor r=75 c=0
Rz9 (\6\:n12 \7\:n12) resistor r=75 c=0
Rz11 (\6\:n11 \7\:n11) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry19 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry14 (\3\:Y \4\:Y) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=12.4 c=0
Ry16 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry17 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\16\:n61 \17\:n61) resistor r=62 c=0
Ry5 (\4\:n8 \5\:n8) resistor r=62 c=0
Ry6 (\6\:n8 \7\:n8) resistor r=62 c=0
Ry2 (n9 \2\:n9) resistor r=62 c=0
Ry7 (\5\:n9 \6\:n9) resistor r=62 c=0
Ry8 (\5\:n9 \9\:n9) resistor r=62 c=0
Ry9 (n9 \10\:n9) resistor r=62 c=0
Ry10 (\3\:n12 \4\:n12) resistor r=62 c=0
Ry11 (\8\:n12 \9\:n12) resistor r=62 c=0
Ry13 (\8\:n11 \9\:n11) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\5\:B \9\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\3\:n61 \12\:n61) resistor r=45 c=0
Rx4 (\2\:n61 \18\:n61) resistor r=45 c=0
Rx5 (\7\:n61 \19\:n61) resistor r=45 c=0
Rx8 (\11\:n61 \20\:n61) resistor r=45 c=0
Rx9 (\8\:n61 \21\:n61) resistor r=45 c=0
Rx10 (n8 \3\:n8) resistor r=45 c=0
Rx11 (\2\:n8 \8\:n8) resistor r=45 c=0
Rx15 (\2\:n11 \4\:n11) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn3 (\11\:n62 \4\:A \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.095e-14 ad=3.485e-14 ps=1.46e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.1561e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn2 (\3\:n9 \9\:n61 \5\:n62 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=8.74e-14 ps=9.3e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.7122e-07 sb=6.8e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn11 (\6\:n12 \1\:B \5\:n62 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17622e-06 sb=3.75e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn10 (\6\:n12 \10\:n61 \9\:n8 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.385e-14 ad=3.28e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38122e-06 sb=1.7e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn8 (\1\:Y \3\:n11 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.845e-14 ps=1.77e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\14\:n61 \7\:B \8\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.095e-14 ad=3.23e-14 ps=1.46e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=13.1062 \
        scb=0.0134056 scc=0.000712852 m=(1)
mn9 (\11\:n8 n62 \6\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.57e-14 ad=5.08e-14 ps=1.11e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn1 (\3\:n9 \6\:B \11\:n8 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.08e-14 ad=8.74e-14 ps=9.7e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn6 (\6\:n11 \1\:C \7\:n9 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=4.18e-14 ps=7.2e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn5 (\6\:n11 \4\:n60 n12 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn7 (\8\:n60 \6\:C \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mp4 (\16\:n61 \8\:B \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.184e-13 ad=7.905e-14 ps=1.83e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.55e-07 sd=160n sca=26.5499 \
        scb=0.0223018 scc=0.00266168 m=(1)
mp9 (\6\:n8 \3\:n62 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=6.96452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (\6\:n8 n61 n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=9.58e-14 \
        ad=6.82e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.7629e-07 sb=4.31452e-07 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp10 (\4\:n8 \2\:B \8\:n12 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=6.83e-14 ps=1.28e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.01452e-07 sb=1.7e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp6 (\5\:n9 \3\:n60 \8\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.83e-14 ps=9.4e-07 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\3\:n12 \7\:C \8\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.27e-14 ps=9.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp7 (\5\:n60 \3\:C \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4125e-13 ad=5.27e-14 ps=2.07e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.94355e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
ends XNOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:24 2013 )
// Library name: gsclib045_hvt
// Cell name: XNOR3XL
// View name: extracted

simulator lang=spectre

subckt XNOR3XL A B C VDD VSS Y
mp3 (\14\:n62 \1\:A \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.085e-13 ad=4.34e-14 ps=1.7e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=24.5071 \
        scb=0.0280884 scc=0.00153635 m=(1)
mp4 (\16\:n61 \8\:B \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.085e-13 ad=7.595e-14 ps=1.7e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2.45e-07 sd=160n sca=16.826 \
        scb=0.0155728 scc=0.000870508 m=(1)
mp9 (\6\:n8 \3\:n62 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.07e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.61774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (\6\:n8 n61 n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=9.18e-14 \
        ad=6.82e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.35e-07 sb=4.96774e-07 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp2 (\7\:n62 \3\:B n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.18e-14 ad=6.355e-14 ps=1.64e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.26452e-07 sb=5.65242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp11 (\7\:n62 \4\:n61 \8\:n12 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=6.355e-14 ps=1.21e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.76452e-07 sb=3.15242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp10 (\4\:n8 \2\:B \8\:n12 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=5.93e-14 ps=1.21e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.23468e-07 sb=1.7e-07 sd=160n sca=10.9702 \
        scb=0.00883933 scc=0.000174052 m=(1)
mp6 (\5\:n9 \3\:n60 \8\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.055e-13 ps=9.4e-07 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\3\:n12 \7\:C \8\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.27e-14 ps=9.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp7 (\5\:n60 \3\:C \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=5.27e-14 ps=1.85e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.30242e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
C1 (B VSS) capacitor c=6.80083e-17
C2 (A VSS) capacitor c=7.43427e-17
C3 (VDD VSS) capacitor c=3.44831e-16
C4 (C VSS) capacitor c=4.1704e-17
C5 (n62 VSS) capacitor c=7.11225e-17
C6 (n61 VSS) capacitor c=6.31146e-17
C7 (n8 VSS) capacitor c=7.51274e-17
C8 (n9 VSS) capacitor c=3.11911e-16
C9 (n12 VSS) capacitor c=7.43811e-17
C10 (n11 VSS) capacitor c=2.57878e-17
C11 (n60 VSS) capacitor c=4.5807e-17
C12 (\3\:C VSS) capacitor c=2.90607e-17
C13 (\7\:C VSS) capacitor c=3.50857e-17
C14 (\3\:n60 VSS) capacitor c=6.82021e-17
C15 (\2\:B VSS) capacitor c=1.00432e-16
C16 (\4\:n61 VSS) capacitor c=7.10522e-17
C17 (\3\:B VSS) capacitor c=9.42401e-17
C18 (\3\:n62 VSS) capacitor c=4.57291e-17
C19 (\8\:B VSS) capacitor c=5.01902e-17
C20 (\1\:A VSS) capacitor c=4.23357e-17
C21 (\3\:n11 VSS) capacitor c=2.77589e-17
C22 (\6\:C VSS) capacitor c=4.51524e-17
C23 (\4\:n60 VSS) capacitor c=3.67992e-17
C24 (\1\:C VSS) capacitor c=4.04835e-17
C25 (\10\:n61 VSS) capacitor c=5.55351e-17
C26 (\1\:B VSS) capacitor c=1.03974e-16
C27 (\9\:n61 VSS) capacitor c=2.37092e-17
C28 (\6\:B VSS) capacitor c=3.82956e-17
C29 (\7\:B VSS) capacitor c=3.58637e-17
C30 (\4\:A VSS) capacitor c=3.03162e-17
C31 (\2\:n11 VSS) capacitor c=2.09504e-17
C32 (\5\:C VSS) capacitor c=5.75866e-17
C33 (\2\:C VSS) capacitor c=2.4221e-17
C34 (\2\:n8 VSS) capacitor c=7.9545e-17
C35 (\11\:n61 VSS) capacitor c=4.0297e-17
C36 (\7\:n61 VSS) capacitor c=2.51989e-17
C37 (\2\:n61 VSS) capacitor c=8.07537e-17
C38 (\4\:n62 VSS) capacitor c=2.891e-17
C39 (\2\:n62 VSS) capacitor c=5.0723e-17
C40 (\3\:n61 VSS) capacitor c=6.89989e-17
C41 (\5\:B VSS) capacitor c=8.44512e-17
C42 (\3\:A VSS) capacitor c=1.31466e-17
C43 (\1\:Y VSS) capacitor c=3.59021e-17
C44 (\1\:VDD VSS) capacitor c=8.71473e-17
C45 (\5\:n60 VSS) capacitor c=6.51648e-17
C46 (\3\:n12 VSS) capacitor c=1.45275e-16
C47 (\8\:n11 VSS) capacitor c=9.58654e-17
C48 (\5\:n9 VSS) capacitor c=2.36861e-16
C49 (\4\:n8 VSS) capacitor c=1.27877e-16
C50 (\8\:n12 VSS) capacitor c=6.83969e-17
C51 (\7\:n62 VSS) capacitor c=1.5597e-16
C52 (\6\:n8 VSS) capacitor c=1.04556e-16
C53 (\9\:VDD VSS) capacitor c=1.0529e-17
C54 (\16\:n61 VSS) capacitor c=6.90032e-17
C55 (\7\:VDD VSS) capacitor c=4.0424e-17
C56 (\14\:n62 VSS) capacitor c=2.69317e-17
C57 (\3\:VDD VSS) capacitor c=1.54697e-16
C58 (\3\:Y VSS) capacitor c=5.09216e-17
C59 (\8\:n60 VSS) capacitor c=4.83363e-17
C60 (\6\:n11 VSS) capacitor c=9.11801e-17
C61 (\8\:n9 VSS) capacitor c=5.50551e-17
C62 (\9\:n8 VSS) capacitor c=1.27726e-16
C63 (\6\:n12 VSS) capacitor c=1.01194e-16
C64 (\5\:n62 VSS) capacitor c=9.30211e-17
C65 (\3\:n9 VSS) capacitor c=1.12753e-16
C66 (\11\:n8 VSS) capacitor c=1.40467e-16
C67 (\14\:n61 VSS) capacitor c=5.74085e-17
C68 (\11\:n62 VSS) capacitor c=1.16932e-16
C69 (\2\:A VSS) capacitor c=1.99891e-17
C70 (\5\:n61 VSS) capacitor c=4.78755e-17
C71 (\6\:n61 VSS) capacitor c=2.53724e-17
C72 (\4\:B VSS) capacitor c=1.55453e-16
C73 (\2\:n60 VSS) capacitor c=4.93801e-17
C74 (\4\:C VSS) capacitor c=3.87849e-17
C75 (\5\:A VSS) capacitor c=3.65661e-17
C76 (\9\:B VSS) capacitor c=4.75994e-17
C77 (\12\:n61 VSS) capacitor c=1.02811e-17
C78 (\13\:n61 VSS) capacitor c=4.20573e-17
C79 (\18\:n61 VSS) capacitor c=6.24628e-17
C80 (\19\:n61 VSS) capacitor c=6.61654e-17
C81 (\9\:n62 VSS) capacitor c=1.33378e-16
C82 (\10\:n62 VSS) capacitor c=1.64099e-16
C83 (\13\:n62 VSS) capacitor c=7.37082e-17
C84 (\20\:n61 VSS) capacitor c=4.17144e-17
C85 (\21\:n61 VSS) capacitor c=5.86403e-17
C86 (\3\:n8 VSS) capacitor c=5.21822e-17
C87 (\8\:n8 VSS) capacitor c=2.14728e-17
C88 (\8\:C VSS) capacitor c=3.04943e-17
C89 (\9\:C VSS) capacitor c=3.66184e-17
C90 (\5\:n12 VSS) capacitor c=1.66591e-16
C91 (\7\:n60 VSS) capacitor c=4.30346e-17
C92 (\4\:n11 VSS) capacitor c=3.85109e-17
C93 (\5\:n11 VSS) capacitor c=1.9163e-16
C94 (\6\:VDD VSS) capacitor c=1.28389e-17
Rk2 (B \9\:B) resistor r=0.07476 c=0
Rk1 (\5\:A A) resistor r=0.08124 c=0
Rk32 (\2\:Y Y) resistor r=0.2806 c=0
Rk33 (Y \4\:Y) resistor r=0.03227 c=0
Rk34 (\2\:VDD \4\:VDD) resistor r=0.5553 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=1.1034 c=0
Rk37 (\6\:VDD VDD) resistor r=0.2895 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.05904 c=0
Rk38 (VDD \8\:VDD) resistor r=0.1989 c=0
Rk39 (\6\:VDD \10\:VDD) resistor r=0.04331 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.5469 c=0
Rk41 (\4\:VSS \5\:VSS) resistor r=1.1034 c=0
Rk43 (\6\:VSS VSS) resistor r=0.2519 c=0
Rk42 (\5\:VSS \6\:VSS) resistor r=0.09666 c=0
Rk44 (VSS \8\:VSS) resistor r=0.122 c=0
Rk45 (\6\:VSS \10\:VSS) resistor r=0.04331 c=0
Rk21 (\8\:C C) resistor r=0.1487 c=0
Rk22 (C \9\:C) resistor r=0.1626 c=0
Rk8 (\6\:n62 \8\:n62) resistor r=0.5309 c=0
Rk9 (\8\:n62 \9\:n62) resistor r=0.7002 c=0
Rk10 (\9\:n62 \10\:n62) resistor r=0.7521 c=0
Rk11 (\10\:n62 \12\:n62) resistor r=0.6936 c=0
Rk12 (\12\:n62 \13\:n62) resistor r=0.5851 c=0
Rk13 (\10\:n62 \15\:n62) resistor r=0.113 c=0
Rk3 (\12\:n61 \13\:n61) resistor r=0.03536 c=0
Rk4 (\13\:n61 \15\:n61) resistor r=0.2047 c=0
Rk5 (\13\:n61 \17\:n61) resistor r=0.2322 c=0
Rk7 (\18\:n61 \19\:n61) resistor r=0.2584 c=0
Rk14 (\20\:n61 \21\:n61) resistor r=0.1661 c=0
Rk15 (\3\:n8 \5\:n8) resistor r=0.2376 c=0
Rk16 (\5\:n8 \7\:n8) resistor r=0.7362 c=0
Rk17 (\8\:n8 \10\:n8) resistor r=0.1186 c=0
Rk18 (\10\:n8 \12\:n8) resistor r=0.9606 c=0
Rk6 (\2\:n9 \4\:n9) resistor r=0.8462 c=0
Rk19 (\6\:n9 \7\:n9) resistor r=1.0098 c=0
Rk20 (\9\:n9 \10\:n9) resistor r=0.4429 c=0
Rk23 (\2\:n12 \4\:n12) resistor r=0.3763 c=0
Rk24 (\4\:n12 \5\:n12) resistor r=0.7219 c=0
Rk25 (\5\:n12 \7\:n12) resistor r=0.6327 c=0
Rk26 (\5\:n12 \9\:n12) resistor r=0.339 c=0
Rk29 (\4\:n11 \5\:n11) resistor r=0.1546 c=0
Rk30 (\5\:n11 \7\:n11) resistor r=0.8123 c=0
Rk31 (\5\:n11 \9\:n11) resistor r=0.7381 c=0
Rk27 (\6\:n60 \7\:n60) resistor r=0.1817 c=0
Rk28 (\7\:n60 \9\:n60) resistor r=0.09164 c=0
Rl14 (\2\:B \3\:B) resistor r=284.181 c=0
Rl13 (\1\:B \2\:B) resistor r=244.165 c=0
Rl19 (\5\:B \8\:B) resistor r=97.3098 c=0
Rl18 (\5\:B \7\:B) resistor r=30.0021 c=0
Rl15 (\3\:B \4\:B) resistor r=241.851 c=0
Rl17 (\4\:B \6\:B) resistor r=57.3738 c=0
Rl16 (\4\:B \5\:B) resistor r=336.808 c=0
Rl1 (\1\:A \2\:A) resistor r=107.406 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=8.3038 c=0
Rl29 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl22 (\1\:C \2\:C) resistor r=47.59 c=0
Rl26 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl28 (\4\:C \6\:C) resistor r=103.08 c=0
Rl27 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=132.902 c=0
Rl4 (n62 \2\:n62) resistor r=221.411 c=0
Rl20 (\10\:n61 \11\:n61) resistor r=47.3097 c=0
Rl6 (n61 \2\:n61) resistor r=135.771 c=0
Rl7 (\2\:n61 \3\:n61) resistor r=213.948 c=0
Rl8 (\4\:n61 \5\:n61) resistor r=98.7765 c=0
Rl11 (\5\:n61 \8\:n61) resistor r=17.233 c=0
Rl12 (\6\:n61 \9\:n61) resistor r=34.3295 c=0
Rl10 (\6\:n61 \7\:n61) resistor r=8.3038 c=0
Rl9 (\5\:n61 \6\:n61) resistor r=101.615 c=0
Rl21 (n8 \2\:n8) resistor r=176.032 c=0
Rl30 (n11 \2\:n11) resistor r=41.5405 c=0
Rl31 (\2\:n11 \3\:n11) resistor r=64.6174 c=0
Rl24 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl25 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rl23 (n60 \2\:n60) resistor r=106.101 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=18.75 c=0
Rz16 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz17 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\14\:n61 \15\:n61) resistor r=75 c=0
Rz5 (\9\:n8 \10\:n8) resistor r=75 c=0
Rz6 (\11\:n8 \12\:n8) resistor r=75 c=0
Rz2 (\3\:n9 \4\:n9) resistor r=75 c=0
Rz7 (\8\:n9 \9\:n9) resistor r=75 c=0
Rz8 (n12 \2\:n12) resistor r=75 c=0
Rz9 (\6\:n12 \7\:n12) resistor r=75 c=0
Rz11 (\6\:n11 \7\:n11) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=12.4 c=0
Ry16 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry17 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry19 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\16\:n61 \17\:n61) resistor r=62 c=0
Ry5 (\4\:n8 \5\:n8) resistor r=62 c=0
Ry6 (\6\:n8 \7\:n8) resistor r=62 c=0
Ry2 (n9 \2\:n9) resistor r=62 c=0
Ry7 (\5\:n9 \6\:n9) resistor r=62 c=0
Ry8 (n9 \7\:n9) resistor r=62 c=0
Ry9 (\5\:n9 \10\:n9) resistor r=62 c=0
Ry10 (\3\:n12 \4\:n12) resistor r=62 c=0
Ry11 (\8\:n12 \9\:n12) resistor r=62 c=0
Ry13 (\8\:n11 \9\:n11) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\5\:B \9\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\5\:C \8\:C) resistor r=45 c=0
Rx13 (\2\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\3\:n61 \12\:n61) resistor r=45 c=0
Rx4 (\2\:n61 \18\:n61) resistor r=45 c=0
Rx5 (\7\:n61 \19\:n61) resistor r=45 c=0
Rx8 (\11\:n61 \20\:n61) resistor r=45 c=0
Rx9 (\8\:n61 \21\:n61) resistor r=45 c=0
Rx10 (n8 \3\:n8) resistor r=45 c=0
Rx11 (\2\:n8 \8\:n8) resistor r=45 c=0
Rx15 (\2\:n11 \4\:n11) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn3 (\11\:n62 \4\:A \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=3.485e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.19756e-07 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mn10 (\6\:n12 \10\:n61 \9\:n8 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=3.82e-14 ps=9.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32634e-06 sb=1.7e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn8 (\3\:Y \3\:n11 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.485e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\14\:n61 \7\:B \7\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=3.23e-14 ps=1.54e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.7e-07 sd=160n sca=14.2386 \
        scb=0.0147775 scc=0.000909887 m=(1)
mn9 (\11\:n8 n62 \9\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.75e-14 ad=5.26e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn1 (\3\:n9 \6\:B \11\:n8 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.26e-14 ad=7.6e-14 ps=1e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn2 (\3\:n9 \9\:n61 \5\:n62 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=7.6e-14 ps=9e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=7.1e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn11 (\6\:n12 \1\:B \5\:n62 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.82e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=4.05e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn6 (\6\:n11 \1\:C \8\:n9 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=4.18e-14 ps=7.2e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn5 (\6\:n11 \4\:n60 n12 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn7 (\8\:n60 \6\:C \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mp8 (\1\:Y n11 \1\:VDD VDD) g45p1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=3.485e-14 ps=1.85e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=28.0221 scb=0.032906 \
        scc=0.00213116 m=(1)
ends XNOR3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:25 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR2X1
// View name: extracted

simulator lang=spectre

subckt XOR2X1 A B VDD VSS Y
mp5 (\3\:Y n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.87115e-07 sd=160n sca=38.6307 \
        scb=0.0321643 scc=0.00380145 m=(1)
C1 (A VSS) capacitor c=9.52594e-17
C2 (Y VSS) capacitor c=1.49768e-17
C3 (VDD VSS) capacitor c=1.23492e-16
C4 (B VSS) capacitor c=1.02825e-16
C5 (n0 VSS) capacitor c=4.14124e-17
C6 (n1 VSS) capacitor c=4.79634e-17
C7 (n2 VSS) capacitor c=3.47083e-17
C8 (net130 VSS) capacitor c=3.2875e-18
C9 (\7\:B VSS) capacitor c=4.15232e-17
C10 (\3\:n1 VSS) capacitor c=7.22075e-17
C11 (\1\:B VSS) capacitor c=4.57696e-17
C12 (\1\:A VSS) capacitor c=4.63281e-17
C13 (\5\:B VSS) capacitor c=3.78567e-17
C14 (\3\:B VSS) capacitor c=6.54239e-17
C15 (\3\:n2 VSS) capacitor c=6.62901e-17
C16 (\3\:A VSS) capacitor c=3.59855e-17
C17 (\3\:n0 VSS) capacitor c=3.63323e-17
C18 (\6\:B VSS) capacitor c=4.9845e-17
C19 (\2\:n1 VSS) capacitor c=7.31573e-17
C20 (\4\:B VSS) capacitor c=6.1258e-17
C21 (\2\:n2 VSS) capacitor c=6.20041e-17
C22 (\2\:B VSS) capacitor c=5.55342e-17
C23 (\2\:A VSS) capacitor c=4.73094e-17
C24 (\2\:n0 VSS) capacitor c=2.75339e-17
C25 (\6\:n2 VSS) capacitor c=1.00463e-16
C26 (\1\:VDD VSS) capacitor c=4.34637e-17
C27 (\7\:n0 VSS) capacitor c=1.1498e-16
C28 (\6\:n1 VSS) capacitor c=6.42063e-17
C29 (\6\:VDD VSS) capacitor c=2.55681e-17
C30 (\3\:Y VSS) capacitor c=8.46551e-17
C31 (\4\:n2 VSS) capacitor c=5.57795e-17
C32 (\4\:n0 VSS) capacitor c=1.26156e-16
C33 (\8\:n1 VSS) capacitor c=3.85185e-17
C34 (\1\:Y VSS) capacitor c=7.57595e-17
C35 (\4\:A VSS) capacitor c=7.36912e-17
C36 (\6\:n0 VSS) capacitor c=2.82842e-16
C37 (\4\:n1 VSS) capacitor c=7.22622e-17
C38 (\5\:n1 VSS) capacitor c=1.47257e-16
C39 (\8\:B VSS) capacitor c=4.72172e-17
C40 (\10\:B VSS) capacitor c=7.17268e-17
C41 (\8\:n2 VSS) capacitor c=7.13514e-17
C42 (\4\:VDD VSS) capacitor c=3.62592e-17
C43 (\5\:VDD VSS) capacitor c=1.25442e-17
Rk3 (A \4\:A) resistor r=0.2026 c=0
Rk2 (\4\:Y Y) resistor r=0.03363 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.488 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.5029 c=0
Rk20 (\5\:VDD VDD) resistor r=0.1517 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.1972 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.06847 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.5228 c=0
Rk16 (\5\:VSS VSS) resistor r=0.1517 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.1972 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.0509 c=0
Rk9 (\8\:B B) resistor r=0.1378 c=0
Rk10 (B \9\:B) resistor r=0.03572 c=0
Rk11 (\9\:B \10\:B) resistor r=0.1734 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.9195 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8649 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4267 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.4706 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.09434 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.5146 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.4061 c=0
Rl3 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl4 (\2\:A \3\:A) resistor r=69.9225 c=0
Rl12 (\6\:B \7\:B) resistor r=91.5895 c=0
Rl11 (\5\:B \6\:B) resistor r=70.9489 c=0
Rl8 (\3\:B \4\:B) resistor r=74.2328 c=0
Rl5 (\1\:B \2\:B) resistor r=87.6365 c=0
Rl1 (n0 \2\:n0) resistor r=35.3072 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=136.894 c=0
Rl9 (n1 \2\:n1) resistor r=32.267 c=0
Rl6 (n2 \2\:n2) resistor r=24.2328 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=148.798 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \8\:n2) resistor r=45 c=0
mn5 (\1\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.64e-14 ps=1.56e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.08942e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\8\:n1 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.915e-14 ps=1.56e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.7e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\4\:n0 \3\:n2 \8\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net131 n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.5e-07 sd=160n sca=15.0952 \
        scb=0.0139603 scc=0.000435069 m=(1)
mp4 (\6\:n1 \1\:B \7\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.45e-07 sd=160n sca=13.633 \
        scb=0.0120861 scc=0.000425416 m=(1)
mp3 (\7\:n0 n2 net130 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=5.25e-07 sd=160n sca=13.6458 \
        scb=0.0121015 scc=0.000425438 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=14.8634 \
        scb=0.0136114 scc=0.000432055 m=(1)
mp1 (\6\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=19.3929 \
        scb=0.0213506 scc=0.000688958 m=(1)
ends XOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:26 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR2X2
// View name: extracted

simulator lang=spectre

subckt XOR2X2 A B VDD VSS Y
mp5 (\3\:Y n0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.826e-14 ad=6.24e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.73526e-07 sd=160n sca=22.1173 \
        scb=0.0235828 scc=0.00128647 m=(2)
C1 (VDD VSS) capacitor c=1.2638e-16
C2 (Y VSS) capacitor c=6.24434e-17
C3 (B VSS) capacitor c=5.6512e-17
C4 (n0 VSS) capacitor c=1.38487e-16
C5 (n1 VSS) capacitor c=4.8225e-17
C6 (n2 VSS) capacitor c=2.98851e-17
C7 (net130 VSS) capacitor c=1.88405e-18
C8 (\7\:B VSS) capacitor c=3.89021e-17
C9 (\3\:n1 VSS) capacitor c=8.96263e-17
C10 (\2\:n2 VSS) capacitor c=7.86672e-17
C11 (\1\:B VSS) capacitor c=4.17204e-17
C12 (\1\:A VSS) capacitor c=3.59161e-17
C13 (\5\:B VSS) capacitor c=4.14188e-17
C14 (\3\:B VSS) capacitor c=7.01522e-17
C15 (\3\:n2 VSS) capacitor c=6.84166e-17
C16 (\3\:A VSS) capacitor c=4.08917e-17
C17 (\6\:B VSS) capacitor c=5.33881e-17
C18 (\2\:n1 VSS) capacitor c=7.83729e-17
C19 (\4\:B VSS) capacitor c=7.0855e-17
C20 (\2\:B VSS) capacitor c=4.42822e-17
C21 (\2\:A VSS) capacitor c=3.59421e-17
C22 (\8\:n2 VSS) capacitor c=1.08958e-17
C23 (\1\:VDD VSS) capacitor c=6.78052e-17
C24 (\10\:n0 VSS) capacitor c=1.13681e-16
C25 (\6\:n1 VSS) capacitor c=5.97862e-17
C26 (\3\:Y VSS) capacitor c=8.59937e-17
C27 (\4\:n2 VSS) capacitor c=5.56415e-17
C28 (\7\:n0 VSS) capacitor c=1.03976e-16
C29 (\8\:n1 VSS) capacitor c=3.78307e-17
C30 (\1\:Y VSS) capacitor c=4.49962e-17
C31 (\4\:A VSS) capacitor c=1.29454e-16
C32 (\9\:n0 VSS) capacitor c=2.55434e-16
C33 (\4\:n1 VSS) capacitor c=8.93173e-17
C34 (\5\:n1 VSS) capacitor c=9.09055e-17
C35 (\8\:B VSS) capacitor c=2.95104e-17
C36 (\9\:B VSS) capacitor c=3.35495e-17
C37 (\10\:B VSS) capacitor c=4.60576e-17
C38 (\6\:n2 VSS) capacitor c=1.11673e-16
C39 (\7\:n2 VSS) capacitor c=8.18396e-17
C40 (\4\:VDD VSS) capacitor c=3.70778e-17
C41 (\5\:VDD VSS) capacitor c=9.01807e-17
Rk3 (A \4\:A) resistor r=0.03171 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.5922 c=0
Rk24 (\5\:VDD VDD) resistor r=0.02463 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.1794 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.6099 c=0
Rk18 (\5\:VSS VSS) resistor r=0.02463 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1954 c=0
Rk1 (\2\:Y Y) resistor r=0.1481 c=0
Rk2 (Y \4\:Y) resistor r=0.4376 c=0
Rk9 (\8\:B B) resistor r=0.1668 c=0
Rk10 (B \9\:B) resistor r=0.06849 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2021 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.9513 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.9572 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4557 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.3155 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.1277 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.524 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.6001 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04786 c=0
Rl6 (\1\:A \2\:A) resistor r=60.7134 c=0
Rl7 (\2\:A \3\:A) resistor r=99.1749 c=0
Rl15 (\6\:B \7\:B) resistor r=78.8233 c=0
Rl14 (\5\:B \6\:B) resistor r=86.3335 c=0
Rl11 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl8 (\1\:B \2\:B) resistor r=71.8456 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=149.361 c=0
Rl12 (n1 \2\:n1) resistor r=31.791 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=208.747 c=0
Rl9 (n2 \2\:n2) resistor r=24.2328 c=0
Rz5 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry6 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry2 (\11\:n0 \10\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (n2 \7\:n2) resistor r=45 c=0
mn5 (\1\:Y n0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.483e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.95577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\8\:n1 \3\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=5.728e-14 ps=9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.095e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\7\:n0 \3\:n2 \8\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.32e-14 ps=1.08e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\7\:n0 \3\:B net131 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net131 n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0243e-13 ad=5.805e-14 ps=1.74e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.015e-06 sd=160n sca=13.1802 \
        scb=0.0118482 scc=0.000425234 m=(1)
mp4 (\6\:n1 \1\:B \10\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=5.805e-14 ps=7.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=7e-07 sd=160n sca=12.8224 scb=0.011715 \
        scc=0.000425192 m=(1)
mp3 (\10\:n0 \2\:n2 net130 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.87e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=4.75e-07 sd=160n sca=13.569 \
        scb=0.0120992 scc=0.00042546 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=3.45e-07 sd=160n sca=14.4226 \
        scb=0.0130013 scc=0.000428203 m=(1)
mp1 (\8\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=17.794 \
        scb=0.0186079 scc=0.000545865 m=(1)
ends XOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:27 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR2X4
// View name: extracted

simulator lang=spectre

subckt XOR2X4 A B VDD VSS Y
mp4 (\4\:n1 \3\:B \13\:n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.25e-13 ps=1.1e-06 pd=1.78e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.9109e-07 sb=5.85064e-07 sd=160n sca=16.6552 \
        scb=0.0146982 scc=0.00118864 m=(1)
mp3 (\13\:n0 \3\:n2 net130 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09609e-06 sb=3.80064e-07 sd=160n sca=17.6259 \
        scb=0.0154648 scc=0.00118993 m=(1)
mp2 (net130 n1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.9e-14 ps=1.1e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24109e-06 sb=2.35064e-07 sd=160n sca=19.1246 \
        scb=0.0176055 scc=0.00120723 m=(1)
mp5_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.119e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.42346e-06 sd=160n sca=25.2855 \
        scb=0.0288799 scc=0.00168046 m=(4)
C1 (A VSS) capacitor c=7.36607e-17
C2 (Y VSS) capacitor c=1.89553e-17
C3 (VDD VSS) capacitor c=3.19513e-16
C4 (B VSS) capacitor c=3.64475e-17
C5 (n0 VSS) capacitor c=2.65918e-16
C6 (n1 VSS) capacitor c=6.3182e-17
C7 (n2 VSS) capacitor c=4.0838e-17
C8 (net131 VSS) capacitor c=3.62849e-18
C9 (net130 VSS) capacitor c=2.74008e-18
C10 (\4\:B VSS) capacitor c=5.16867e-17
C11 (\3\:n2 VSS) capacitor c=5.95991e-17
C12 (\3\:B VSS) capacitor c=5.74094e-17
C13 (\1\:A VSS) capacitor c=4.41869e-17
C14 (\6\:B VSS) capacitor c=4.15541e-17
C15 (\3\:n1 VSS) capacitor c=7.03595e-17
C16 (\1\:B VSS) capacitor c=3.98596e-17
C17 (\3\:A VSS) capacitor c=3.70611e-17
C18 (\5\:B VSS) capacitor c=4.5398e-17
C19 (\2\:n1 VSS) capacitor c=5.27772e-17
C20 (\2\:B VSS) capacitor c=6.69392e-17
C21 (\4\:n2 VSS) capacitor c=4.53948e-17
C22 (\2\:n2 VSS) capacitor c=2.93889e-17
C23 (\2\:A VSS) capacitor c=3.87404e-17
C24 (\5\:n2 VSS) capacitor c=4.69377e-17
C25 (\1\:VDD VSS) capacitor c=5.6747e-17
C26 (\13\:n0 VSS) capacitor c=1.20038e-16
C27 (\4\:n1 VSS) capacitor c=3.83162e-17
C28 (\1\:Y VSS) capacitor c=1.77161e-16
C29 (\10\:n2 VSS) capacitor c=1.87211e-17
C30 (\17\:n0 VSS) capacitor c=1.12902e-16
C31 (\7\:n1 VSS) capacitor c=8.75004e-17
C32 (\4\:Y VSS) capacitor c=1.2289e-16
C33 (\5\:A VSS) capacitor c=7.0233e-17
C34 (\15\:n0 VSS) capacitor c=2.06719e-16
C35 (\16\:n0 VSS) capacitor c=2.33121e-17
C36 (\6\:n1 VSS) capacitor c=8.1768e-17
C37 (\9\:n1 VSS) capacitor c=8.44377e-17
C38 (\7\:B VSS) capacitor c=5.47934e-17
C39 (\8\:B VSS) capacitor c=3.12908e-17
C40 (\7\:n2 VSS) capacitor c=1.10629e-16
C41 (\8\:n2 VSS) capacitor c=7.4494e-17
C42 (\9\:n2 VSS) capacitor c=3.18349e-17
C43 (\12\:n2 VSS) capacitor c=5.53143e-17
C44 (\4\:VDD VSS) capacitor c=4.0169e-17
Rk6 (\4\:A \5\:A) resistor r=0.006435 c=0
Rk7 (\6\:A A) resistor r=0.006521 c=0
Rk8 (\5\:A \6\:A) resistor r=0.0943 c=0
Rk2 (\1\:Y Y) resistor r=0.03962 c=0
Rk3 (Y \4\:Y) resistor r=0.3399 c=0
Rk23 (\4\:VDD VDD) resistor r=0.1554 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.7599 c=0
Rk33 (VSS \8\:VSS) resistor r=0.1403 c=0
Rk34 (\8\:VSS \10\:VSS) resistor r=0.6263 c=0
Rk15 (B \7\:B) resistor r=0.1778 c=0
Rk16 (B \8\:B) resistor r=0.0301 c=0
Rk9 (\14\:n0 \15\:n0) resistor r=1.0357 c=0
Rk10 (\15\:n0 \16\:n0) resistor r=0.109 c=0
Rk11 (\15\:n0 \18\:n0) resistor r=0.8439 c=0
Rk12 (\5\:n1 \6\:n1) resistor r=0.1048 c=0
Rk13 (\6\:n1 \8\:n1) resistor r=0.364 c=0
Rk14 (\6\:n1 \9\:n1) resistor r=0.5203 c=0
Rk17 (\6\:n2 \7\:n2) resistor r=0.5264 c=0
Rk18 (\7\:n2 \8\:n2) resistor r=0.5889 c=0
Rk19 (\8\:n2 \9\:n2) resistor r=0.08708 c=0
Rk20 (\7\:n2 \11\:n2) resistor r=0.07544 c=0
Rk21 (\8\:n2 \12\:n2) resistor r=0.2588 c=0
Rl12 (\1\:A \2\:A) resistor r=116.076 c=0
Rl13 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl20 (\4\:B \5\:B) resistor r=117.288 c=0
Rl21 (\5\:B \6\:B) resistor r=86.5184 c=0
Rl17 (\2\:B \3\:B) resistor r=166.862 c=0
Rl16 (\1\:B \2\:B) resistor r=31.9251 c=0
Rl18 (n1 \2\:n1) resistor r=24.2328 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=116.54 c=0
Rl15 (\3\:n2 \4\:n2) resistor r=39.6174 c=0
Rl14 (n2 \2\:n2) resistor r=37.2302 c=0
Rz9 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=75 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\10\:n2 \11\:n2) resistor r=75 c=0
Ry6 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\5\:n2 \6\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:B \7\:B) resistor r=45 c=0
Rx5 (\5\:B \8\:B) resistor r=45 c=0
Rx2 (\16\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn4 (\17\:n0 n2 \7\:n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.733e-14 ad=6.24e-14 ps=1.29e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.36154e-07 sb=7.01635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\17\:n0 \1\:B net131 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=7.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12115e-06 sb=4.16635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (net131 \3\:n1 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.51e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.30115e-06 sb=2.36635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_1__rcx (\4\:Y n0 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.026e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37231e-06 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.145e-14 ad=6.733e-14 ps=9e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.04569e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\10\:n2 \6\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02448e-06 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp0 (\4\:n1 \1\:A VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.25e-13 ps=1.16e-06 pd=1.78e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.18872e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\5\:n2 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71849e-06 sb=1.4e-07 sd=160n sca=24.9308 \
        scb=0.0292329 scc=0.0015565 m=(1)
ends XOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:28 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR2XL
// View name: extracted

simulator lang=spectre

subckt XOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=3.01e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=25.0648 \
        scb=0.0294525 scc=0.00155947 m=(1)
mp0 (\7\:n1 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=4.515e-14 ps=1.58e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.95e-07 sd=160n sca=16.6712 \
        scb=0.0163973 scc=0.000573191 m=(1)
mp4 (\7\:n1 \2\:B \7\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=7.4e-07 sd=160n sca=14.3602 scb=0.0131207 \
        scc=0.000544277 m=(1)
mp3 (\7\:n0 \2\:n2 net130 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.35e-07 sd=160n sca=14.2892 \
        scb=0.0130359 scc=0.000544163 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.45e-07 sd=160n sca=15.406 \
        scb=0.0143862 scc=0.000549226 m=(1)
mp1 (\8\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=19.4967 \
        scb=0.0213498 scc=0.00074757 m=(1)
C1 (A VSS) capacitor c=1.1759e-16
C2 (Y VSS) capacitor c=6.7797e-17
C3 (VDD VSS) capacitor c=1.44225e-16
C4 (B VSS) capacitor c=2.48947e-17
C5 (n0 VSS) capacitor c=4.51386e-17
C6 (n1 VSS) capacitor c=2.65261e-17
C7 (n2 VSS) capacitor c=6.53513e-17
C8 (net130 VSS) capacitor c=5.21894e-19
C9 (\7\:B VSS) capacitor c=3.81569e-17
C10 (\3\:n1 VSS) capacitor c=8.61236e-17
C11 (\2\:n2 VSS) capacitor c=5.88962e-17
C12 (\2\:B VSS) capacitor c=3.69731e-17
C13 (\1\:A VSS) capacitor c=4.05082e-17
C14 (\5\:B VSS) capacitor c=4.44054e-17
C15 (\4\:n1 VSS) capacitor c=4.32183e-17
C16 (\3\:B VSS) capacitor c=6.16461e-17
C17 (\3\:A VSS) capacitor c=4.3037e-17
C18 (\3\:n0 VSS) capacitor c=3.05004e-17
C19 (\6\:B VSS) capacitor c=5.98828e-17
C20 (\4\:B VSS) capacitor c=6.38834e-17
C21 (\3\:n2 VSS) capacitor c=3.31541e-17
C22 (\1\:B VSS) capacitor c=3.92003e-17
C23 (\2\:A VSS) capacitor c=3.99804e-17
C24 (\2\:n0 VSS) capacitor c=3.96009e-17
C25 (\8\:n2 VSS) capacitor c=1.07701e-17
C26 (\1\:VDD VSS) capacitor c=4.35438e-17
C27 (\7\:n0 VSS) capacitor c=1.24258e-16
C28 (\7\:n1 VSS) capacitor c=7.45906e-17
C29 (\6\:VDD VSS) capacitor c=1.40643e-17
C30 (\1\:Y VSS) capacitor c=5.5149e-17
C31 (\4\:n2 VSS) capacitor c=3.99556e-17
C32 (\4\:n0 VSS) capacitor c=1.17617e-16
C33 (\9\:n1 VSS) capacitor c=4.02834e-17
C34 (\3\:Y VSS) capacitor c=2.85293e-17
C35 (\2\:n1 VSS) capacitor c=5.31705e-17
C36 (\4\:A VSS) capacitor c=7.46194e-17
C37 (\6\:n0 VSS) capacitor c=2.79612e-16
C38 (\5\:n1 VSS) capacitor c=7.01948e-17
C39 (\6\:n1 VSS) capacitor c=1.00424e-16
C40 (\8\:B VSS) capacitor c=6.33122e-17
C41 (\9\:B VSS) capacitor c=4.7572e-17
C42 (\10\:B VSS) capacitor c=6.25448e-17
C43 (\6\:n2 VSS) capacitor c=1.08298e-16
C44 (\7\:n2 VSS) capacitor c=9.39191e-17
C45 (\4\:VDD VSS) capacitor c=4.29636e-17
C46 (\5\:VDD VSS) capacitor c=1.06658e-17
Rk3 (A \4\:A) resistor r=0.2701 c=0
Rk1 (\2\:Y Y) resistor r=0.2725 c=0
Rk2 (Y \4\:Y) resistor r=0.0976 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.5051 c=0
Rk21 (\5\:VDD VDD) resistor r=0.1276 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk22 (\5\:VDD \7\:VDD) resistor r=0.1048 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.5447 c=0
Rk17 (\5\:VSS VSS) resistor r=0.1125 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.2382 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.09135 c=0
Rk10 (\9\:B B) resistor r=0.06653 c=0
Rk9 (\8\:B \9\:B) resistor r=0.1615 c=0
Rk11 (B \10\:B) resistor r=0.1661 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8935 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8779 c=0
Rk6 (\5\:n1 \6\:n1) resistor r=0.4181 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.4325 c=0
Rk8 (\6\:n1 \10\:n1) resistor r=0.09515 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.445 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5898 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04841 c=0
Rl3 (\1\:A \2\:A) resistor r=54.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=112.23 c=0
Rl13 (\6\:B \7\:B) resistor r=70.3297 c=0
Rl12 (\5\:B \6\:B) resistor r=99.7901 c=0
Rl8 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl5 (\1\:B \2\:B) resistor r=30.3481 c=0
Rl1 (n0 \2\:n0) resistor r=126.156 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=37.6944 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=170.434 c=0
Rl11 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl9 (n1 \2\:n1) resistor r=2.0213 c=0
Rl6 (n2 \2\:n2) resistor r=195.27 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\9\:n1 \10\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\1\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (n1 \5\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.3e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn0 (\9\:n1 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=5.51e-14 ps=1.4e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.095e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn4 (\4\:n0 n2 \9\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=6.7e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=2.32e-14 ps=4.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=4.65e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (net131 \4\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.087e-14 ps=6.1e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
ends XOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:29 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR3X1
// View name: extracted

simulator lang=spectre

subckt XOR3X1 A B C VDD VSS Y
mp10 (\14\:n62 \1\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.27e-13 ad=6.435e-14 ps=1.91e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=4.48205e-07 sd=160n sca=36.5002 \
        scb=0.0347521 scc=0.00363944 m=(1)
mp1 (n44 \3\:n61 \7\:n62 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=9.58e-14 ps=1.16e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46923e-07 sb=4.94359e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp5 (\8\:n56 \11\:B \7\:n62 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=7.125e-14 ps=1.16e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95385e-07 sb=3.05128e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp7 (\1\:Y n50 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.365e-13 ad=6.63e-14 ps=1.88e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45513e-07 sb=1.7e-07 sd=160n sca=25.5198 \
        scb=0.0290048 scc=0.00173993 m=(1)
C1 (B VSS) capacitor c=5.49827e-17
C2 (A VSS) capacitor c=7.65449e-17
C3 (VDD VSS) capacitor c=3.32627e-16
C4 (C VSS) capacitor c=4.32068e-17
C5 (n62 VSS) capacitor c=6.88314e-17
C6 (n61 VSS) capacitor c=1.00817e-16
C7 (n11 VSS) capacitor c=6.74615e-17
C8 (n44 VSS) capacitor c=3.10298e-16
C9 (n56 VSS) capacitor c=8.39522e-17
C10 (n50 VSS) capacitor c=3.23358e-17
C11 (n60 VSS) capacitor c=4.58758e-17
C12 (\3\:C VSS) capacitor c=3.06074e-17
C13 (\7\:C VSS) capacitor c=3.47677e-17
C14 (\3\:n60 VSS) capacitor c=6.62554e-17
C15 (\2\:n61 VSS) capacitor c=9.36211e-17
C16 (\11\:B VSS) capacitor c=8.16041e-17
C17 (\3\:n61 VSS) capacitor c=1.33058e-16
C18 (\1\:B VSS) capacitor c=6.28229e-17
C19 (\3\:n62 VSS) capacitor c=4.79943e-17
C20 (\5\:B VSS) capacitor c=4.48206e-17
C21 (\1\:A VSS) capacitor c=4.67925e-17
C22 (\3\:n50 VSS) capacitor c=2.77528e-17
C23 (\6\:C VSS) capacitor c=4.51835e-17
C24 (\4\:n60 VSS) capacitor c=3.67883e-17
C25 (\1\:C VSS) capacitor c=4.2306e-17
C26 (\13\:B VSS) capacitor c=4.936e-17
C27 (\12\:B VSS) capacitor c=2.60663e-17
C28 (\6\:n61 VSS) capacitor c=3.802e-17
C29 (\6\:B VSS) capacitor c=3.71506e-17
C30 (\4\:A VSS) capacitor c=3.27282e-17
C31 (\2\:n50 VSS) capacitor c=2.03874e-17
C32 (\5\:C VSS) capacitor c=5.54428e-17
C33 (\2\:C VSS) capacitor c=2.52333e-17
C34 (\2\:n11 VSS) capacitor c=7.20406e-17
C35 (\14\:B VSS) capacitor c=3.72099e-17
C36 (\7\:B VSS) capacitor c=2.64739e-17
C37 (\10\:B VSS) capacitor c=3.04649e-17
C38 (\2\:B VSS) capacitor c=1.11053e-16
C39 (\4\:n62 VSS) capacitor c=3.37617e-17
C40 (\2\:n62 VSS) capacitor c=5.15526e-17
C41 (\5\:n61 VSS) capacitor c=9.12333e-17
C42 (\4\:B VSS) capacitor c=2.4466e-17
C43 (\3\:A VSS) capacitor c=1.26091e-17
C44 (\1\:Y VSS) capacitor c=3.28678e-17
C45 (\1\:VDD VSS) capacitor c=9.05527e-17
C46 (\5\:n60 VSS) capacitor c=6.49592e-17
C47 (\3\:n56 VSS) capacitor c=1.43421e-16
C48 (\8\:n50 VSS) capacitor c=9.73341e-17
C49 (\5\:n44 VSS) capacitor c=2.54299e-16
C50 (\4\:n11 VSS) capacitor c=1.26926e-16
C51 (\8\:n56 VSS) capacitor c=6.84579e-17
C52 (\7\:n62 VSS) capacitor c=1.54625e-16
C53 (\6\:n11 VSS) capacitor c=9.57844e-17
C54 (\6\:VDD VSS) capacitor c=1.06501e-17
C55 (\10\:n61 VSS) capacitor c=5.94111e-17
C56 (\8\:VDD VSS) capacitor c=3.87579e-17
C57 (\14\:n62 VSS) capacitor c=3.68726e-17
C58 (\3\:VDD VSS) capacitor c=1.63281e-16
C59 (\3\:Y VSS) capacitor c=4.9947e-17
C60 (\8\:n60 VSS) capacitor c=4.82908e-17
C61 (\6\:n50 VSS) capacitor c=9.80419e-17
C62 (\7\:n44 VSS) capacitor c=7.42973e-17
C63 (\9\:n11 VSS) capacitor c=1.39997e-16
C64 (\6\:n56 VSS) capacitor c=1.14989e-16
C65 (\5\:n62 VSS) capacitor c=8.44111e-17
C66 (\3\:n44 VSS) capacitor c=1.12341e-16
C67 (\11\:n11 VSS) capacitor c=1.34799e-16
C68 (\7\:n61 VSS) capacitor c=3.78496e-17
C69 (\11\:n62 VSS) capacitor c=1.30374e-16
C70 (\2\:A VSS) capacitor c=1.71928e-17
C71 (\3\:B VSS) capacitor c=6.31202e-17
C72 (\8\:B VSS) capacitor c=2.4619e-17
C73 (\9\:B VSS) capacitor c=1.33109e-17
C74 (\4\:n61 VSS) capacitor c=1.07801e-16
C75 (\2\:n60 VSS) capacitor c=5.54105e-17
C76 (\4\:C VSS) capacitor c=3.87755e-17
C77 (\5\:A VSS) capacitor c=3.58965e-17
C78 (\15\:B VSS) capacitor c=5.52388e-17
C79 (\9\:n61 VSS) capacitor c=3.55563e-17
C80 (\16\:B VSS) capacitor c=5.86816e-17
C81 (\17\:B VSS) capacitor c=5.7672e-17
C82 (\9\:n62 VSS) capacitor c=1.0217e-16
C83 (\10\:n62 VSS) capacitor c=1.35022e-16
C84 (\13\:n62 VSS) capacitor c=8.80177e-17
C85 (\18\:B VSS) capacitor c=3.66248e-17
C86 (\19\:B VSS) capacitor c=6.33784e-17
C87 (\3\:n11 VSS) capacitor c=5.28411e-17
C88 (\8\:n11 VSS) capacitor c=2.68451e-17
C89 (\8\:C VSS) capacitor c=4.94143e-17
C90 (\9\:C VSS) capacitor c=2.46967e-17
C91 (\5\:n56 VSS) capacitor c=1.79538e-16
C92 (\7\:n60 VSS) capacitor c=4.29869e-17
C93 (\4\:n50 VSS) capacitor c=4.14014e-17
C94 (\5\:n50 VSS) capacitor c=1.90599e-16
Rk38 (\2\:VSS \4\:VSS) resistor r=0.5477 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=1.1038 c=0
Rk41 (\7\:VSS VSS) resistor r=0.1851 c=0
Rk40 (\5\:VSS \7\:VSS) resistor r=0.04668 c=0
Rk42 (VSS \9\:VSS) resistor r=0.04107 c=0
Rk2 (\15\:B B) resistor r=0.1059 c=0
Rk6 (\16\:B \17\:B) resistor r=0.2407 c=0
Rk13 (\18\:B \19\:B) resistor r=0.1663 c=0
Rk1 (\5\:A A) resistor r=0.1078 c=0
Rk31 (\2\:Y Y) resistor r=0.2712 c=0
Rk32 (Y \4\:Y) resistor r=0.03227 c=0
Rk33 (\2\:VDD \4\:VDD) resistor r=0.556 c=0
Rk35 (\5\:VDD VDD) resistor r=0.453 c=0
Rk34 (\4\:VDD \5\:VDD) resistor r=1.1043 c=0
Rk36 (\5\:VDD \7\:VDD) resistor r=0.0715 c=0
Rk37 (VDD \9\:VDD) resistor r=0.09035 c=0
Rk20 (C \8\:C) resistor r=0.3097 c=0
Rk21 (C \9\:C) resistor r=0.02032 c=0
Rk7 (\6\:n62 \8\:n62) resistor r=0.5324 c=0
Rk8 (\8\:n62 \9\:n62) resistor r=0.6798 c=0
Rk9 (\9\:n62 \10\:n62) resistor r=0.5712 c=0
Rk10 (\10\:n62 \12\:n62) resistor r=0.6965 c=0
Rk11 (\12\:n62 \13\:n62) resistor r=0.6679 c=0
Rk12 (\10\:n62 \15\:n62) resistor r=0.142 c=0
Rk3 (\8\:n61 \9\:n61) resistor r=0.1097 c=0
Rk4 (\9\:n61 \11\:n61) resistor r=0.2038 c=0
Rk14 (\3\:n11 \5\:n11) resistor r=0.2383 c=0
Rk15 (\5\:n11 \7\:n11) resistor r=0.716 c=0
Rk16 (\8\:n11 \10\:n11) resistor r=0.119 c=0
Rk17 (\10\:n11 \12\:n11) resistor r=0.9659 c=0
Rk5 (\2\:n44 \4\:n44) resistor r=0.8235 c=0
Rk18 (\6\:n44 \8\:n44) resistor r=0.5607 c=0
Rk19 (\9\:n44 \10\:n44) resistor r=1.0211 c=0
Rk22 (\2\:n56 \4\:n56) resistor r=0.3916 c=0
Rk23 (\4\:n56 \5\:n56) resistor r=0.6721 c=0
Rk24 (\5\:n56 \7\:n56) resistor r=0.6991 c=0
Rk25 (\5\:n56 \9\:n56) resistor r=0.34 c=0
Rk28 (\4\:n50 \5\:n50) resistor r=0.1551 c=0
Rk29 (\5\:n50 \7\:n50) resistor r=0.8146 c=0
Rk30 (\5\:n50 \9\:n50) resistor r=0.7402 c=0
Rk26 (\6\:n60 \7\:n60) resistor r=0.1819 c=0
Rk27 (\7\:n60 \9\:n60) resistor r=0.09174 c=0
Rl21 (\13\:B \14\:B) resistor r=58.8482 c=0
Rl6 (\1\:B \2\:B) resistor r=135.771 c=0
Rl10 (\4\:B \6\:B) resistor r=24.2328 c=0
Rl9 (\3\:B \5\:B) resistor r=39.6181 c=0
Rl7 (\2\:B \3\:B) resistor r=370.63 c=0
Rl8 (\3\:B \4\:B) resistor r=35.0048 c=0
Rl14 (\8\:B \11\:B) resistor r=55.4507 c=0
Rl11 (\7\:B \8\:B) resistor r=19.1561 c=0
Rl15 (\9\:B \12\:B) resistor r=37.3411 c=0
Rl13 (\9\:B \10\:B) resistor r=10.9341 c=0
Rl12 (\8\:B \9\:B) resistor r=79.6267 c=0
Rl1 (\1\:A \2\:A) resistor r=88.1757 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=6.708 c=0
Rl30 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl23 (\1\:C \2\:C) resistor r=47.59 c=0
Rl27 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl29 (\4\:C \6\:C) resistor r=103.08 c=0
Rl28 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=124.029 c=0
Rl4 (n62 \2\:n62) resistor r=214.575 c=0
Rl17 (\2\:n61 \3\:n61) resistor r=278.412 c=0
Rl16 (n61 \2\:n61) resistor r=215.318 c=0
Rl18 (\3\:n61 \4\:n61) resistor r=222.62 c=0
Rl20 (\4\:n61 \6\:n61) resistor r=63.143 c=0
Rl19 (\4\:n61 \5\:n61) resistor r=239.768 c=0
Rl22 (n11 \2\:n11) resistor r=420.614 c=0
Rl31 (n50 \2\:n50) resistor r=35.7713 c=0
Rl32 (\2\:n50 \3\:n50) resistor r=64.6174 c=0
Rl25 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl26 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rl24 (n60 \2\:n60) resistor r=106.101 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=18.75 c=0
Rz16 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz17 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\7\:n61 \8\:n61) resistor r=75 c=0
Rz5 (\9\:n11 \10\:n11) resistor r=75 c=0
Rz6 (\11\:n11 \12\:n11) resistor r=75 c=0
Rz2 (\3\:n44 \4\:n44) resistor r=75 c=0
Rz7 (\7\:n44 \8\:n44) resistor r=75 c=0
Rz8 (n56 \2\:n56) resistor r=75 c=0
Rz9 (\6\:n56 \7\:n56) resistor r=75 c=0
Rz11 (\6\:n50 \7\:n50) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry19 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=12.4 c=0
Ry16 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\10\:n61 \11\:n61) resistor r=62 c=0
Ry5 (\4\:n11 \5\:n11) resistor r=62 c=0
Ry6 (\6\:n11 \7\:n11) resistor r=62 c=0
Ry2 (n44 \2\:n44) resistor r=62 c=0
Ry7 (\5\:n44 \6\:n44) resistor r=62 c=0
Ry8 (\5\:n44 \9\:n44) resistor r=62 c=0
Ry9 (n44 \10\:n44) resistor r=62 c=0
Ry10 (\3\:n56 \4\:n56) resistor r=62 c=0
Ry11 (\8\:n56 \9\:n56) resistor r=62 c=0
Ry13 (\8\:n50 \9\:n50) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\4\:B \15\:B) resistor r=45 c=0
Rx4 (\2\:B \16\:B) resistor r=45 c=0
Rx5 (\10\:B \17\:B) resistor r=45 c=0
Rx8 (\14\:B \18\:B) resistor r=45 c=0
Rx9 (\7\:B \19\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\5\:n61 \9\:n61) resistor r=45 c=0
Rx10 (n11 \3\:n11) resistor r=45 c=0
Rx11 (\2\:n11 \8\:n11) resistor r=45 c=0
Rx15 (\2\:n50 \4\:n50) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn10 (\11\:n62 \4\:A \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.295e-14 ad=3.485e-14 ps=1.47e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.08293e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn1 (\5\:n62 \12\:B \3\:n44 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.715e-14 ps=1.27e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7122e-07 sb=6.6061e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn5 (\5\:n62 n61 \6\:n56 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.82e-14 ad=4.715e-14 ps=7.9e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14622e-06 sb=3.8561e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn7 (\3\:Y \3\:n50 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.485e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn9 (\7\:n61 \6\:B \8\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.295e-14 ad=4.75e-14 ps=1.47e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=2.5e-07 sd=160n sca=12.1373 \
        scb=0.0121311 scc=0.000556832 m=(1)
mn0 (\11\:n11 n62 \6\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.57e-14 ad=5.08e-14 ps=1.11e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn2 (\11\:n11 \6\:n61 \3\:n44 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=5.08e-14 ps=1.27e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn6 (\6\:n56 \13\:B \9\:n11 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=3.82e-14 ps=8.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.7e-07 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn4 (\7\:n44 \1\:C \6\:n50 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=3.23e-14 ps=8.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn3 (n56 \4\:n60 \6\:n50 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.31e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn8 (\8\:n60 \6\:C \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mp9 (\10\:n61 \5\:B \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.27e-13 ad=7.285e-14 ps=1.91e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.35e-07 sd=160n sca=31.7573 \
        scb=0.0238304 scc=0.00348201 m=(1)
mp0 (\6\:n11 \3\:n62 \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=6.96452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp2 (n44 \1\:B \6\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=9.58e-14 ps=1.06e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7629e-07 sb=4.31452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp6 (\4\:n11 \2\:n61 \8\:n56 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=6.83e-14 ps=1.31e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.01452e-07 sb=1.7e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp4 (\8\:n50 \3\:n60 \5\:n44 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp3 (\8\:n50 \7\:C \3\:n56 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=4.96e-14 ps=9.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp8 (\5\:n60 \3\:C \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.365e-13 ad=5.27e-14 ps=1.88e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
ends XOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:20:30 2013 )
// Library name: gsclib045_hvt
// Cell name: XOR3XL
// View name: extracted

simulator lang=spectre

subckt XOR3XL A B C VDD VSS Y
mp10 (\14\:n62 \1\:A \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=4.34e-14 ps=1.67e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=23.5711 \
        scb=0.0270642 scc=0.00135402 m=(1)
mp9 (\10\:n61 \6\:B \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=7.595e-14 ps=1.67e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2.45e-07 sd=160n sca=15.89 \
        scb=0.0145486 scc=0.000688173 m=(1)
mp0 (\6\:n11 \3\:n62 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=7.61774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp2 (n44 \1\:B \6\:n11 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=9.18e-14 ps=1.06e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7629e-07 sb=4.96774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (n44 \3\:n61 \7\:n62 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=9.18e-14 ps=1e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.92581e-07 sb=5.65242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\8\:n56 \12\:B \7\:n62 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.88e-14 ps=1e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.27581e-07 sb=3.30242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp6 (\4\:n11 \2\:n61 \8\:n56 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=5.93e-14 ps=1.24e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.89597e-07 sb=1.7e-07 sd=160n sca=10.9702 \
        scb=0.00883933 scc=0.000174052 m=(1)
mp4 (\8\:n50 \3\:n60 \5\:n44 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp3 (\8\:n50 \7\:C \3\:n56 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=4.96e-14 ps=9.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp8 (\5\:n60 \3\:C \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=5.27e-14 ps=1.85e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.30242e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
C1 (B VSS) capacitor c=6.96109e-17
C2 (A VSS) capacitor c=7.72406e-17
C3 (VDD VSS) capacitor c=3.54687e-16
C4 (C VSS) capacitor c=4.33372e-17
C5 (n62 VSS) capacitor c=6.6348e-17
C6 (n61 VSS) capacitor c=1.01079e-16
C7 (n11 VSS) capacitor c=7.47837e-17
C8 (n44 VSS) capacitor c=3.31044e-16
C9 (n56 VSS) capacitor c=8.40754e-17
C10 (n50 VSS) capacitor c=2.57878e-17
C11 (n60 VSS) capacitor c=4.58758e-17
C12 (\3\:C VSS) capacitor c=2.90607e-17
C13 (\7\:C VSS) capacitor c=3.47766e-17
C14 (\3\:n60 VSS) capacitor c=6.58879e-17
C15 (\2\:n61 VSS) capacitor c=1.01402e-16
C16 (\12\:B VSS) capacitor c=7.12452e-17
C17 (\3\:n61 VSS) capacitor c=9.48787e-17
C18 (\1\:B VSS) capacitor c=6.23712e-17
C19 (\3\:n62 VSS) capacitor c=4.77839e-17
C20 (\6\:B VSS) capacitor c=4.77929e-17
C21 (\1\:A VSS) capacitor c=4.3791e-17
C22 (\3\:n50 VSS) capacitor c=2.67141e-17
C23 (\6\:C VSS) capacitor c=4.46016e-17
C24 (\4\:n60 VSS) capacitor c=3.65917e-17
C25 (\1\:C VSS) capacitor c=4.04697e-17
C26 (\14\:B VSS) capacitor c=4.65989e-17
C27 (\13\:B VSS) capacitor c=2.45532e-17
C28 (\6\:n61 VSS) capacitor c=3.81261e-17
C29 (\7\:B VSS) capacitor c=3.63274e-17
C30 (\4\:A VSS) capacitor c=3.02549e-17
C31 (\2\:n50 VSS) capacitor c=2.09504e-17
C32 (\5\:C VSS) capacitor c=5.55789e-17
C33 (\2\:C VSS) capacitor c=2.49607e-17
C34 (\2\:n11 VSS) capacitor c=7.96795e-17
C35 (\15\:B VSS) capacitor c=4.08714e-17
C36 (\8\:B VSS) capacitor c=2.99644e-17
C37 (\11\:B VSS) capacitor c=2.51989e-17
C38 (\4\:n62 VSS) capacitor c=3.17228e-17
C39 (\2\:n62 VSS) capacitor c=4.76935e-17
C40 (\5\:n61 VSS) capacitor c=8.65499e-17
C41 (\4\:B VSS) capacitor c=2.67531e-17
C42 (\3\:A VSS) capacitor c=1.27416e-17
C43 (\1\:Y VSS) capacitor c=3.59021e-17
C44 (\1\:VDD VSS) capacitor c=8.75364e-17
C45 (\5\:n60 VSS) capacitor c=6.51648e-17
C46 (\3\:n56 VSS) capacitor c=1.5273e-16
C47 (\8\:n50 VSS) capacitor c=9.75605e-17
C48 (\5\:n44 VSS) capacitor c=2.54775e-16
C49 (\4\:n11 VSS) capacitor c=1.27821e-16
C50 (\8\:n56 VSS) capacitor c=6.86067e-17
C51 (\7\:n62 VSS) capacitor c=1.55531e-16
C52 (\6\:n11 VSS) capacitor c=1.04554e-16
C53 (\9\:VDD VSS) capacitor c=1.0529e-17
C54 (\10\:n61 VSS) capacitor c=8.30896e-17
C55 (\7\:VDD VSS) capacitor c=3.73848e-17
C56 (\14\:n62 VSS) capacitor c=2.71076e-17
C57 (\3\:VDD VSS) capacitor c=1.56312e-16
C58 (\3\:Y VSS) capacitor c=5.09216e-17
C59 (\8\:n60 VSS) capacitor c=4.83363e-17
C60 (\6\:n50 VSS) capacitor c=9.77154e-17
C61 (\7\:n44 VSS) capacitor c=6.43026e-17
C62 (\9\:n11 VSS) capacitor c=1.37967e-16
C63 (\6\:n56 VSS) capacitor c=1.11807e-16
C64 (\5\:n62 VSS) capacitor c=9.44027e-17
C65 (\3\:n44 VSS) capacitor c=1.09863e-16
C66 (\11\:n11 VSS) capacitor c=1.39005e-16
C67 (\7\:n61 VSS) capacitor c=3.73773e-17
C68 (\11\:n62 VSS) capacitor c=1.12994e-16
C69 (\2\:A VSS) capacitor c=2.17283e-17
C70 (\2\:B VSS) capacitor c=1.07627e-16
C71 (\3\:B VSS) capacitor c=6.16327e-17
C72 (\9\:B VSS) capacitor c=2.11541e-17
C73 (\10\:B VSS) capacitor c=2.3833e-17
C74 (\4\:n61 VSS) capacitor c=1.25078e-16
C75 (\2\:n60 VSS) capacitor c=5.53491e-17
C76 (\4\:C VSS) capacitor c=3.87749e-17
C77 (\5\:A VSS) capacitor c=3.35698e-17
C78 (\16\:B VSS) capacitor c=5.94849e-17
C79 (\9\:n61 VSS) capacitor c=5.73233e-17
C80 (\17\:B VSS) capacitor c=6.42224e-17
C81 (\18\:B VSS) capacitor c=6.61725e-17
C82 (\9\:n62 VSS) capacitor c=1.28324e-16
C83 (\10\:n62 VSS) capacitor c=1.63489e-16
C84 (\13\:n62 VSS) capacitor c=6.74379e-17
C85 (\19\:B VSS) capacitor c=3.76444e-17
C86 (\20\:B VSS) capacitor c=6.35371e-17
C87 (\3\:n11 VSS) capacitor c=5.21822e-17
C88 (\8\:n11 VSS) capacitor c=2.14728e-17
C89 (\8\:C VSS) capacitor c=4.95747e-17
C90 (\9\:C VSS) capacitor c=2.48107e-17
C91 (\5\:n56 VSS) capacitor c=1.71804e-16
C92 (\7\:n60 VSS) capacitor c=4.30346e-17
C93 (\4\:n50 VSS) capacitor c=3.85134e-17
C94 (\5\:n50 VSS) capacitor c=1.9163e-16
C95 (\6\:VDD VSS) capacitor c=1.23303e-17
Rk2 (\16\:B B) resistor r=0.2075 c=0
Rk6 (\17\:B \18\:B) resistor r=0.2584 c=0
Rk13 (\19\:B \20\:B) resistor r=0.1661 c=0
Rk1 (\5\:A A) resistor r=0.08725 c=0
Rk31 (\2\:Y Y) resistor r=0.2806 c=0
Rk32 (Y \4\:Y) resistor r=0.03227 c=0
Rk33 (\2\:VDD \4\:VDD) resistor r=0.5553 c=0
Rk34 (\4\:VDD \5\:VDD) resistor r=1.1034 c=0
Rk36 (\6\:VDD VDD) resistor r=0.2895 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.05904 c=0
Rk37 (VDD \8\:VDD) resistor r=0.1938 c=0
Rk38 (\6\:VDD \10\:VDD) resistor r=0.04331 c=0
Rk39 (\2\:VSS \4\:VSS) resistor r=0.5469 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=1.1034 c=0
Rk42 (\6\:VSS VSS) resistor r=0.2519 c=0
Rk41 (\5\:VSS \6\:VSS) resistor r=0.09666 c=0
Rk43 (VSS \8\:VSS) resistor r=0.122 c=0
Rk44 (\6\:VSS \10\:VSS) resistor r=0.04331 c=0
Rk20 (C \8\:C) resistor r=0.3089 c=0
Rk21 (C \9\:C) resistor r=0.02032 c=0
Rk7 (\6\:n62 \8\:n62) resistor r=0.5309 c=0
Rk8 (\8\:n62 \9\:n62) resistor r=0.7002 c=0
Rk9 (\9\:n62 \10\:n62) resistor r=0.7198 c=0
Rk10 (\10\:n62 \12\:n62) resistor r=0.6908 c=0
Rk11 (\12\:n62 \13\:n62) resistor r=0.5692 c=0
Rk12 (\10\:n62 \15\:n62) resistor r=0.113 c=0
Rk3 (\8\:n61 \9\:n61) resistor r=0.1048 c=0
Rk4 (\9\:n61 \11\:n61) resistor r=0.2997 c=0
Rk14 (\3\:n11 \5\:n11) resistor r=0.2376 c=0
Rk15 (\5\:n11 \7\:n11) resistor r=0.7362 c=0
Rk16 (\8\:n11 \10\:n11) resistor r=0.1186 c=0
Rk17 (\10\:n11 \12\:n11) resistor r=0.9632 c=0
Rk5 (\2\:n44 \4\:n44) resistor r=0.8462 c=0
Rk18 (\6\:n44 \8\:n44) resistor r=0.5314 c=0
Rk19 (\9\:n44 \10\:n44) resistor r=1.0989 c=0
Rk22 (\2\:n56 \4\:n56) resistor r=0.3905 c=0
Rk23 (\4\:n56 \5\:n56) resistor r=0.7258 c=0
Rk24 (\5\:n56 \7\:n56) resistor r=0.6678 c=0
Rk25 (\5\:n56 \9\:n56) resistor r=0.339 c=0
Rk28 (\4\:n50 \5\:n50) resistor r=0.1546 c=0
Rk29 (\5\:n50 \7\:n50) resistor r=0.8123 c=0
Rk30 (\5\:n50 \9\:n50) resistor r=0.7381 c=0
Rk26 (\6\:n60 \7\:n60) resistor r=0.1817 c=0
Rk27 (\7\:n60 \9\:n60) resistor r=0.09164 c=0
Rl22 (\14\:B \15\:B) resistor r=53.079 c=0
Rl11 (\4\:B \7\:B) resistor r=24.2328 c=0
Rl6 (\1\:B \2\:B) resistor r=131.458 c=0
Rl9 (\2\:B \5\:B) resistor r=3.9152 c=0
Rl10 (\3\:B \6\:B) resistor r=72.3105 c=0
Rl8 (\3\:B \4\:B) resistor r=35.0048 c=0
Rl7 (\2\:B \3\:B) resistor r=327.99 c=0
Rl15 (\9\:B \12\:B) resistor r=97.7584 c=0
Rl12 (\8\:B \9\:B) resistor r=19.1561 c=0
Rl16 (\10\:B \13\:B) resistor r=34.3295 c=0
Rl14 (\10\:B \11\:B) resistor r=8.3038 c=0
Rl13 (\9\:B \10\:B) resistor r=95.8459 c=0
Rl1 (\1\:A \2\:A) resistor r=117.022 c=0
Rl3 (\2\:A \4\:A) resistor r=38.1757 c=0
Rl2 (\2\:A \3\:A) resistor r=8.3038 c=0
Rl31 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl24 (\1\:C \2\:C) resistor r=47.59 c=0
Rl28 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl30 (\4\:C \6\:C) resistor r=103.08 c=0
Rl29 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=132.902 c=0
Rl4 (n62 \2\:n62) resistor r=205.584 c=0
Rl18 (\2\:n61 \3\:n61) resistor r=284.181 c=0
Rl17 (n61 \2\:n61) resistor r=255.703 c=0
Rl19 (\3\:n61 \4\:n61) resistor r=241.851 c=0
Rl21 (\4\:n61 \6\:n61) resistor r=57.3738 c=0
Rl20 (\4\:n61 \5\:n61) resistor r=241.764 c=0
Rl23 (n11 \2\:n11) resistor r=176.032 c=0
Rl32 (n50 \2\:n50) resistor r=41.5405 c=0
Rl33 (\2\:n50 \3\:n50) resistor r=64.6174 c=0
Rl26 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl27 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rl25 (n60 \2\:n60) resistor r=106.101 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=18.75 c=0
Rz16 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz17 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\7\:n61 \8\:n61) resistor r=75 c=0
Rz5 (\9\:n11 \10\:n11) resistor r=75 c=0
Rz6 (\11\:n11 \12\:n11) resistor r=75 c=0
Rz2 (\3\:n44 \4\:n44) resistor r=75 c=0
Rz7 (\7\:n44 \8\:n44) resistor r=75 c=0
Rz8 (n56 \2\:n56) resistor r=75 c=0
Rz9 (\6\:n56 \7\:n56) resistor r=75 c=0
Rz11 (\6\:n50 \7\:n50) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=12.4 c=0
Ry16 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry17 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry19 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\10\:n61 \11\:n61) resistor r=62 c=0
Ry5 (\4\:n11 \5\:n11) resistor r=62 c=0
Ry6 (\6\:n11 \7\:n11) resistor r=62 c=0
Ry2 (n44 \2\:n44) resistor r=62 c=0
Ry7 (\5\:n44 \6\:n44) resistor r=62 c=0
Ry8 (\5\:n44 \9\:n44) resistor r=62 c=0
Ry9 (n44 \10\:n44) resistor r=62 c=0
Ry10 (\3\:n56 \4\:n56) resistor r=62 c=0
Ry11 (\8\:n56 \9\:n56) resistor r=62 c=0
Ry13 (\8\:n50 \9\:n50) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\4\:B \16\:B) resistor r=45 c=0
Rx4 (\5\:B \17\:B) resistor r=45 c=0
Rx5 (\11\:B \18\:B) resistor r=45 c=0
Rx8 (\15\:B \19\:B) resistor r=45 c=0
Rx9 (\8\:B \20\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\5\:n61 \9\:n61) resistor r=45 c=0
Rx10 (n11 \3\:n11) resistor r=45 c=0
Rx11 (\2\:n11 \8\:n11) resistor r=45 c=0
Rx15 (\2\:n50 \4\:n50) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn10 (\11\:n62 \4\:A \7\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.23e-14 ps=1.5e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.45e-07 sd=160n sca=13.8407 \
        scb=0.0143094 scc=0.000839093 m=(1)
mn9 (\7\:n61 \7\:B \7\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.23e-14 ps=1.5e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.7e-07 sd=160n sca=13.8407 \
        scb=0.0143094 scc=0.000839093 m=(1)
mn0 (\11\:n11 n62 \9\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.75e-14 ad=5.26e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn2 (\11\:n11 \6\:n61 \3\:n44 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=5.26e-14 ps=1.18e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn1 (\5\:n62 \13\:B \3\:n44 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=4.37e-14 ps=1.18e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=7.1e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn5 (\5\:n62 n61 \6\:n56 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.37e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=4.35e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn6 (\6\:n56 \14\:B \9\:n11 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.7e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn4 (\7\:n44 \1\:C \6\:n50 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=3.23e-14 ps=8.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn3 (n56 \4\:n60 \6\:n50 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.31e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn8 (\8\:n60 \6\:C \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.0475e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mn7 (\3\:Y \3\:n50 \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.0475e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mp7 (\1\:Y n50 \1\:VDD VDD) g45p1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=3.485e-14 ps=1.85e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=28.0221 scb=0.032906 \
        scc=0.00213116 m=(1)
ends XOR3XL
// End of subcircuit definition.

