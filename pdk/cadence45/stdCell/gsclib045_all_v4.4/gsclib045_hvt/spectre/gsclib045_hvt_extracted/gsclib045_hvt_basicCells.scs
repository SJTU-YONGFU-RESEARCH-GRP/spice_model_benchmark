// Generated for: spectre (May  1 09:11:54 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFHX1
// View name: extracted

simulator lang=spectre

subckt ADDFHX1 A B CI CO S VDD VSS
mp12 (\1\:CO COb \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=38.6307 \
        scb=0.0321643 scc=0.00380145 m=(1)
mp13 (\3\:S Sb \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=7.41e-14 ps=1.58e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.0359e-07 sb=1.9e-07 sd=160n sca=33.8487 \
        scb=0.0240553 scc=0.00339289 m=(1)
C1 (A VSS) capacitor c=3.63893e-17
C2 (CO VSS) capacitor c=6.58826e-17
C3 (VDD VSS) capacitor c=2.39838e-16
C4 (B VSS) capacitor c=6.0703e-17
C5 (CI VSS) capacitor c=3.31085e-17
C6 (S VSS) capacitor c=2.26932e-17
C7 (COb VSS) capacitor c=3.15978e-17
C8 (n2 VSS) capacitor c=8.7605e-17
C9 (n4 VSS) capacitor c=7.20481e-17
C10 (Sb VSS) capacitor c=3.53114e-17
C11 (n7 VSS) capacitor c=2.00123e-18
C12 (n6 VSS) capacitor c=2.33477e-18
C13 (n3 VSS) capacitor c=6.6619e-17
C14 (n1 VSS) capacitor c=2.10879e-18
C15 (n5 VSS) capacitor c=8.22217e-17
C16 (n9 VSS) capacitor c=4.257e-18
C17 (n8 VSS) capacitor c=2.25667e-18
C18 (\10\:A VSS) capacitor c=7.32347e-17
C19 (\11\:B VSS) capacitor c=6.24937e-17
C20 (\11\:CI VSS) capacitor c=7.50071e-17
C21 (\6\:COb VSS) capacitor c=3.43086e-17
C22 (\9\:A VSS) capacitor c=6.34026e-17
C23 (\10\:B VSS) capacitor c=5.31937e-17
C24 (\7\:CI VSS) capacitor c=7.46988e-17
C25 (\6\:A VSS) capacitor c=8.50631e-17
C26 (\7\:B VSS) capacitor c=6.43972e-17
C27 (\1\:CI VSS) capacitor c=4.74443e-17
C28 (\1\:B VSS) capacitor c=4.42571e-17
C29 (\1\:A VSS) capacitor c=5.51681e-17
C30 (\3\:Sb VSS) capacitor c=2.67459e-17
C31 (\12\:A VSS) capacitor c=6.21258e-17
C32 (\13\:B VSS) capacitor c=1.0662e-16
C33 (\8\:CI VSS) capacitor c=5.80396e-17
C34 (\4\:COb VSS) capacitor c=5.74e-17
C35 (\7\:A VSS) capacitor c=5.14216e-17
C36 (\8\:B VSS) capacitor c=6.13665e-17
C37 (\5\:CI VSS) capacitor c=3.48525e-17
C38 (\4\:A VSS) capacitor c=7.4808e-17
C39 (\4\:B VSS) capacitor c=9.64273e-17
C40 (\3\:CI VSS) capacitor c=4.31738e-17
C41 (\3\:B VSS) capacitor c=5.13155e-17
C42 (\3\:A VSS) capacitor c=4.03116e-17
C43 (\3\:COb VSS) capacitor c=2.36981e-17
C44 (\2\:Sb VSS) capacitor c=2.14513e-17
C45 (\11\:A VSS) capacitor c=5.28196e-17
C46 (\12\:B VSS) capacitor c=7.40961e-17
C47 (\10\:CI VSS) capacitor c=6.05461e-17
C48 (\7\:COb VSS) capacitor c=2.17597e-17
C49 (\8\:A VSS) capacitor c=5.25819e-17
C50 (\9\:B VSS) capacitor c=5.53739e-17
C51 (\6\:CI VSS) capacitor c=5.77211e-17
C52 (\5\:A VSS) capacitor c=7.00569e-17
C53 (\6\:B VSS) capacitor c=1.53944e-17
C54 (\4\:CI VSS) capacitor c=3.65201e-17
C55 (\2\:B VSS) capacitor c=3.38688e-17
C56 (\2\:A VSS) capacitor c=2.33604e-17
C57 (\2\:COb VSS) capacitor c=1.51084e-17
C58 (\3\:S VSS) capacitor c=4.51829e-17
C59 (\10\:VDD VSS) capacitor c=5.23163e-17
C60 (\9\:Sb VSS) capacitor c=7.55176e-17
C61 (\11\:Sb VSS) capacitor c=4.75203e-17
C62 (\1\:VDD VSS) capacitor c=1.39726e-17
C63 (\3\:n5 VSS) capacitor c=7.21191e-17
C64 (\12\:VDD VSS) capacitor c=1.52904e-17
C65 (\9\:COb VSS) capacitor c=1.25819e-16
C66 (\12\:COb VSS) capacitor c=1.75956e-17
C67 (\3\:n3 VSS) capacitor c=9.51956e-17
C68 (\14\:VDD VSS) capacitor c=1.87241e-17
C69 (\1\:CO VSS) capacitor c=8.59855e-17
C70 (\16\:VDD VSS) capacitor c=4.11346e-17
C71 (\5\:VDD VSS) capacitor c=5.57341e-17
C72 (\1\:S VSS) capacitor c=4.00457e-17
C73 (\4\:Sb VSS) capacitor c=8.55668e-17
C74 (\6\:Sb VSS) capacitor c=5.29471e-17
C75 (\3\:n4 VSS) capacitor c=8.48154e-17
C76 (\16\:COb VSS) capacitor c=5.58905e-17
C77 (\19\:COb VSS) capacitor c=2.58285e-17
C78 (\3\:n2 VSS) capacitor c=7.90147e-17
C79 (\3\:CO VSS) capacitor c=4.27576e-17
C80 (\2\:CI VSS) capacitor c=2.67749e-17
C81 (\5\:B VSS) capacitor c=4.45459e-17
C82 (\5\:COb VSS) capacitor c=5.29551e-17
C83 (\8\:COb VSS) capacitor c=1.62865e-16
C84 (\11\:COb VSS) capacitor c=9.7195e-17
C85 (\14\:COb VSS) capacitor c=1.84611e-16
C86 (\15\:COb VSS) capacitor c=1.4463e-16
C87 (\18\:COb VSS) capacitor c=5.36275e-17
C88 (\12\:CI VSS) capacitor c=1.46338e-16
C89 (\13\:CI VSS) capacitor c=1.73872e-16
C90 (\14\:CI VSS) capacitor c=6.94829e-17
C91 (\14\:B VSS) capacitor c=8.74414e-17
C92 (\15\:B VSS) capacitor c=7.43439e-17
C93 (\16\:B VSS) capacitor c=1.85949e-16
C94 (\17\:B VSS) capacitor c=1.39712e-16
C95 (\13\:A VSS) capacitor c=1.16215e-16
C96 (\14\:A VSS) capacitor c=1.95134e-16
C97 (\15\:A VSS) capacitor c=2.06446e-16
C98 (\16\:A VSS) capacitor c=1.27683e-16
C99 (\8\:Sb VSS) capacitor c=1.72542e-16
C100 (\3\:VDD VSS) capacitor c=2.3361e-17
C101 (\4\:VDD VSS) capacitor c=2.65096e-17
C102 (\7\:VDD VSS) capacitor c=1.40667e-17
C103 (\8\:VDD VSS) capacitor c=1.20447e-17
Rk22 (A \13\:A) resistor r=0.05405 c=0
Rk23 (\13\:A \14\:A) resistor r=0.8074 c=0
Rk24 (\14\:A \15\:A) resistor r=0.5547 c=0
Rk25 (\15\:A \16\:A) resistor r=0.8886 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.1839 c=0
Rk44 (\3\:VSS \5\:VSS) resistor r=0.4887 c=0
Rk45 (\5\:VSS \6\:VSS) resistor r=0.0816 c=0
Rk47 (\7\:VSS VSS) resistor r=0.03466 c=0
Rk46 (\6\:VSS \7\:VSS) resistor r=0.4324 c=0
Rk48 (\3\:VSS \8\:VSS) resistor r=0.2052 c=0
Rk49 (\8\:VSS \10\:VSS) resistor r=0.1359 c=0
Rk50 (\6\:VSS \12\:VSS) resistor r=0.0433 c=0
Rk51 (\7\:VSS \14\:VSS) resistor r=0.274 c=0
Rk52 (\8\:VSS \15\:VSS) resistor r=0.4085 c=0
Rk53 (\15\:VSS \17\:VSS) resistor r=0.3685 c=0
Rk1 (\2\:CO CO) resistor r=0.4916 c=0
Rk2 (CO \4\:CO) resistor r=0.2015 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.07381 c=0
Rk33 (\3\:VDD \4\:VDD) resistor r=0.2344 c=0
Rk34 (\4\:VDD \6\:VDD) resistor r=0.4652 c=0
Rk35 (\6\:VDD \7\:VDD) resistor r=0.0816 c=0
Rk37 (\8\:VDD VDD) resistor r=0.03466 c=0
Rk36 (\7\:VDD \8\:VDD) resistor r=0.4324 c=0
Rk38 (\3\:VDD \9\:VDD) resistor r=0.401 c=0
Rk39 (\9\:VDD \11\:VDD) resistor r=0.4153 c=0
Rk40 (\4\:VDD \13\:VDD) resistor r=0.0433 c=0
Rk41 (\7\:VDD \15\:VDD) resistor r=0.0433 c=0
Rk42 (\8\:VDD \17\:VDD) resistor r=0.3385 c=0
Rk18 (\14\:B B) resistor r=0.3954 c=0
Rk19 (B \15\:B) resistor r=0.06271 c=0
Rk20 (\15\:B \16\:B) resistor r=0.5018 c=0
Rk21 (\16\:B \17\:B) resistor r=0.8662 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8837 c=0
Rk17 (\14\:CI CI) resistor r=0.01639 c=0
Rk16 (\13\:CI \14\:CI) resistor r=0.4688 c=0
Rk30 (S \2\:S) resistor r=0.07795 c=0
Rk31 (\2\:S \4\:S) resistor r=0.3675 c=0
Rk7 (\8\:COb \10\:COb) resistor r=1.1562 c=0
Rk8 (\10\:COb \11\:COb) resistor r=0.1576 c=0
Rk9 (\11\:COb \13\:COb) resistor r=0.04526 c=0
Rk10 (\11\:COb \14\:COb) resistor r=1.0324 c=0
Rk11 (\14\:COb \15\:COb) resistor r=0.9294 c=0
Rk12 (\15\:COb \17\:COb) resistor r=0.337 c=0
Rk13 (\14\:COb \18\:COb) resistor r=0.2088 c=0
Rk14 (\15\:COb \20\:COb) resistor r=0.07456 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.282 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2808 c=0
Rk26 (\5\:Sb \7\:Sb) resistor r=0.2103 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.6086 c=0
Rk28 (\8\:Sb \10\:Sb) resistor r=0.7525 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1267 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.4404 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2356 c=0
Rl29 (\10\:A \11\:A) resistor r=89.6174 c=0
Rl30 (\11\:A \12\:A) resistor r=93.4636 c=0
Rl20 (\8\:A \9\:A) resistor r=83.9406 c=0
Rl19 (\7\:A \8\:A) resistor r=99.2576 c=0
Rl14 (\5\:A \6\:A) resistor r=87.9121 c=0
Rl13 (\4\:A \5\:A) resistor r=100 c=0
Rl3 (\1\:A \2\:A) resistor r=68.4636 c=0
Rl4 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl27 (\11\:B \12\:B) resistor r=24.2328 c=0
Rl28 (\12\:B \13\:B) resistor r=158.848 c=0
Rl18 (\9\:B \10\:B) resistor r=24.2328 c=0
Rl17 (\8\:B \9\:B) resistor r=155.814 c=0
Rl5 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=87.2302 c=0
Rl12 (\5\:B \7\:B) resistor r=34.3295 c=0
Rl10 (\4\:B \5\:B) resistor r=180.049 c=0
Rl11 (\5\:B \6\:B) resistor r=4.3144 c=0
Rl16 (\6\:CI \7\:CI) resistor r=155.814 c=0
Rl15 (\5\:CI \6\:CI) resistor r=24.2328 c=0
Rl7 (\1\:CI \2\:CI) resistor r=99.0311 c=0
Rl8 (\2\:CI \3\:CI) resistor r=53.4552 c=0
Rl9 (\2\:CI \4\:CI) resistor r=89.3546 c=0
Rl26 (\9\:CI \11\:CI) resistor r=158.774 c=0
Rl24 (\8\:CI \9\:CI) resistor r=65.0471 c=0
Rl25 (\9\:CI \10\:CI) resistor r=15.0424 c=0
Rl1 (COb \2\:COb) resistor r=29.5379 c=0
Rl2 (\2\:COb \3\:COb) resistor r=44.9225 c=0
Rl22 (\5\:COb \6\:COb) resistor r=59.5933 c=0
Rl21 (\4\:COb \5\:COb) resistor r=166.989 c=0
Rl23 (\5\:COb \7\:COb) resistor r=79.5158 c=0
Rl31 (Sb \2\:Sb) resistor r=39.6174 c=0
Rl32 (\2\:Sb \3\:Sb) resistor r=24.2328 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz15 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz11 (\5\:VDD \6\:VDD) resistor r=6.25 c=0
Rz12 (\5\:VDD \9\:VDD) resistor r=7.5 c=0
Rz10 (\1\:S \2\:S) resistor r=75 c=0
Rz6 (\16\:COb \17\:COb) resistor r=75 c=0
Rz7 (\19\:COb \20\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry16 (\4\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry17 (\4\:VSS \15\:VSS) resistor r=6.2 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry10 (\3\:S \4\:S) resistor r=20.6667 c=0
Ry6 (\9\:COb \10\:COb) resistor r=31 c=0
Ry7 (\12\:COb \13\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\2\:B \14\:B) resistor r=45 c=0
Rx7 (\6\:B \15\:B) resistor r=45 c=0
Rx8 (\9\:B \16\:B) resistor r=45 c=0
Rx9 (\12\:B \17\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\7\:COb \8\:COb) resistor r=45 c=0
Rx2 (\2\:COb \18\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \8\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn13 (\1\:S \3\:Sb \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=4.94e-14 ps=1.42e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.70769e-07 sb=1.9e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\3\:n2 \3\:A \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=2.87e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn3 (n2 \3\:B \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=3.28e-14 ps=1.45e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn4 (\19\:COb \3\:CI n2 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn1 (\16\:COb \4\:B n0 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.125e-06 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn0 (n0 \4\:A \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.02e-06 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn7 (\3\:n4 \5\:CI \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.15e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn6 (\3\:n4 \8\:B \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.29e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.1e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn5 (n4 \7\:A \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.29e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn8 (\6\:Sb \4\:COb n4 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.12927e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 as=1.435e-14 \
        ad=1.23e-14 ps=5.5e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.07927e-07 sd=160n sca=8.14041 scb=0.00590656 \
        scc=0.000103269 m=(1)
mn9 (n6 \12\:A \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=1.435e-14 ps=1.42e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2.92927e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mp2 (n3 \1\:A \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1475e-13 ad=4.34e-14 ps=1.9e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.14113e-07 sd=160n sca=35.8226 \
        scb=0.0234328 scc=0.00420469 m=(1)
mp3 (\3\:n3 \1\:B \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1475e-13 ad=8.525e-14 ps=1.9e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.63306e-07 sb=4.6e-07 sd=160n sca=20.5825 \
        scb=0.0183783 scc=0.00199566 m=(1)
mp4 (\12\:COb \1\:CI \3\:n3 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.525e-14 ad=4.34e-14 ps=1.17e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.83306e-07 sb=1.4e-07 sd=160n sca=20.5825 \
        scb=0.0183783 scc=0.00199566 m=(1)
mp1 (\9\:COb \7\:B n1 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.135e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp0 (n1 \6\:A \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.066e-13 ad=1.86e-14 ps=1.7e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.03e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp7 (\3\:n5 \7\:CI \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.066e-13 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp6 (\3\:n5 \10\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.6e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp5 (n5 \9\:A \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=3.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.6e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=3.7e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19355e-07 sb=7.29194e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=2.17e-14 \
        ad=4.185e-14 ps=7.6e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.99355e-07 sb=5.49194e-07 sd=160n sca=13.9217 scb=0.012619 \
        scc=0.000630881 m=(1)
mp9 (n8 \10\:A \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=2.17e-14 ps=1.58e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.14355e-07 sb=4.34194e-07 sd=160n sca=14.3211 \
        scb=0.0128282 scc=0.000631006 m=(1)
ends ADDFHX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:11:55 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFHX2
// View name: extracted

simulator lang=spectre

subckt ADDFHX2 A B CI CO S VDD VSS
mp13 (\3\:S \3\:Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.61e-14 ad=7.8e-14 ps=1.08e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.31026e-07 sb=3.85e-07 sd=160n sca=16.3933 \
        scb=0.0147003 scc=0.000819495 m=(2)
mp12_1__rcx (\1\:CO COb VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (A VSS) capacitor c=1.25778e-16
C2 (VDD VSS) capacitor c=3.74976e-16
C3 (B VSS) capacitor c=2.44981e-17
C4 (CI VSS) capacitor c=3.36864e-17
C5 (S VSS) capacitor c=7.13637e-18
C6 (COb VSS) capacitor c=9.98523e-17
C7 (n2 VSS) capacitor c=8.7659e-17
C8 (n4 VSS) capacitor c=7.88499e-17
C9 (Sb VSS) capacitor c=5.58894e-17
C10 (n7 VSS) capacitor c=1.82656e-18
C11 (n6 VSS) capacitor c=2.35236e-18
C12 (n3 VSS) capacitor c=5.23113e-17
C13 (n1 VSS) capacitor c=2.05671e-18
C14 (n5 VSS) capacitor c=7.65666e-17
C15 (n9 VSS) capacitor c=4.13295e-18
C16 (n8 VSS) capacitor c=2.91847e-18
C17 (\10\:A VSS) capacitor c=8.34383e-17
C18 (\11\:B VSS) capacitor c=6.97594e-17
C19 (\11\:CI VSS) capacitor c=7.66651e-17
C20 (\10\:COb VSS) capacitor c=4.05381e-17
C21 (\9\:A VSS) capacitor c=7.31806e-17
C22 (\8\:B VSS) capacitor c=5.23706e-17
C23 (\5\:CI VSS) capacitor c=7.60649e-17
C24 (\4\:A VSS) capacitor c=8.96318e-17
C25 (\4\:B VSS) capacitor c=6.47699e-17
C26 (\1\:CI VSS) capacitor c=5.41441e-17
C27 (\1\:B VSS) capacitor c=4.93998e-17
C28 (\1\:A VSS) capacitor c=4.44801e-17
C29 (\12\:A VSS) capacitor c=5.68269e-17
C30 (\13\:B VSS) capacitor c=9.37909e-17
C31 (\8\:CI VSS) capacitor c=5.32767e-17
C32 (\8\:COb VSS) capacitor c=5.20343e-17
C33 (\7\:A VSS) capacitor c=4.63948e-17
C34 (\10\:B VSS) capacitor c=6.85723e-17
C35 (\7\:CI VSS) capacitor c=3.3731e-17
C36 (\6\:A VSS) capacitor c=6.67616e-17
C37 (\7\:B VSS) capacitor c=7.75515e-17
C38 (\3\:CI VSS) capacitor c=2.78338e-17
C39 (\3\:B VSS) capacitor c=5.31678e-17
C40 (\3\:A VSS) capacitor c=3.53336e-17
C41 (\3\:Sb VSS) capacitor c=8.91958e-17
C42 (\11\:A VSS) capacitor c=5.63424e-17
C43 (\12\:B VSS) capacitor c=7.30035e-17
C44 (\10\:CI VSS) capacitor c=2.83997e-17
C45 (\11\:COb VSS) capacitor c=3.29942e-17
C46 (\8\:A VSS) capacitor c=4.216e-17
C47 (\9\:B VSS) capacitor c=5.81709e-17
C48 (\6\:CI VSS) capacitor c=6.14185e-17
C49 (\5\:A VSS) capacitor c=6.40515e-17
C50 (\6\:B VSS) capacitor c=2.76054e-17
C51 (\4\:CI VSS) capacitor c=3.73913e-17
C52 (\2\:B VSS) capacitor c=4.15748e-17
C53 (\2\:A VSS) capacitor c=2.6096e-17
C54 (\6\:COb VSS) capacitor c=6.82882e-18
C55 (\1\:VDD VSS) capacitor c=1.21487e-16
C56 (\3\:S VSS) capacitor c=1.01315e-16
C57 (\12\:Sb VSS) capacitor c=5.30305e-17
C58 (\14\:Sb VSS) capacitor c=5.27413e-17
C59 (\11\:VDD VSS) capacitor c=1.53562e-17
C60 (\3\:n5 VSS) capacitor c=8.01537e-17
C61 (\13\:VDD VSS) capacitor c=1.49487e-17
C62 (\18\:COb VSS) capacitor c=2.60477e-17
C63 (\14\:COb VSS) capacitor c=1.24511e-16
C64 (\3\:n3 VSS) capacitor c=7.94896e-17
C65 (\15\:VDD VSS) capacitor c=1.63646e-17
C66 (\1\:CO VSS) capacitor c=7.34739e-17
C67 (\4\:VDD VSS) capacitor c=6.22019e-17
C68 (\1\:S VSS) capacitor c=4.68332e-17
C69 (\7\:Sb VSS) capacitor c=9.61341e-17
C70 (\9\:Sb VSS) capacitor c=5.74882e-17
C71 (\3\:n4 VSS) capacitor c=7.83852e-17
C72 (\21\:COb VSS) capacitor c=6.29031e-17
C73 (\23\:COb VSS) capacitor c=2.31595e-17
C74 (\3\:n2 VSS) capacitor c=7.82873e-17
C75 (\3\:CO VSS) capacitor c=2.9286e-17
C76 (\2\:CI VSS) capacitor c=3.2111e-17
C77 (\5\:B VSS) capacitor c=5.00511e-17
C78 (\9\:COb VSS) capacitor c=3.35865e-17
C79 (\9\:CI VSS) capacitor c=5.21494e-17
C80 (\12\:COb VSS) capacitor c=1.71829e-16
C81 (\13\:COb VSS) capacitor c=1.24255e-16
C82 (\16\:COb VSS) capacitor c=1.66191e-16
C83 (\17\:COb VSS) capacitor c=2.78998e-17
C84 (\20\:COb VSS) capacitor c=1.39556e-16
C85 (\12\:CI VSS) capacitor c=1.41352e-16
C86 (\13\:CI VSS) capacitor c=1.77925e-16
C87 (\14\:CI VSS) capacitor c=7.99081e-17
C88 (\14\:B VSS) capacitor c=1.26694e-16
C89 (\15\:B VSS) capacitor c=2.19519e-16
C90 (\16\:B VSS) capacitor c=6.49281e-17
C91 (\17\:B VSS) capacitor c=5.40935e-17
C92 (\18\:B VSS) capacitor c=7.56951e-17
C93 (\13\:A VSS) capacitor c=3.39408e-17
C94 (\14\:A VSS) capacitor c=1.73392e-16
C95 (\15\:A VSS) capacitor c=1.88419e-16
C96 (\16\:A VSS) capacitor c=1.46734e-16
C97 (\11\:Sb VSS) capacitor c=1.6759e-16
C98 (\6\:VDD VSS) capacitor c=1.9985e-17
C99 (\7\:VDD VSS) capacitor c=3.53909e-17
Rk23 (\13\:A A) resistor r=0.13 c=0
Rk24 (A \14\:A) resistor r=0.7218 c=0
Rk25 (\14\:A \15\:A) resistor r=0.5487 c=0
Rk26 (\15\:A \16\:A) resistor r=0.9631 c=0
Rk34 (\1\:VSS \5\:VSS) resistor r=0.2882 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.3559 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.2052 c=0
Rk41 (\8\:VSS VSS) resistor r=0.3433 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.6429 c=0
Rk39 (\6\:VSS \12\:VSS) resistor r=0.1025 c=0
Rk40 (\7\:VSS \14\:VSS) resistor r=0.2088 c=0
Rk43 (\8\:VSS \17\:VSS) resistor r=0.07146 c=0
Rk47 (\1\:VDD \5\:VDD) resistor r=0.2731 c=0
Rk48 (\5\:VDD \6\:VDD) resistor r=0.3107 c=0
Rk49 (\6\:VDD \7\:VDD) resistor r=0.2344 c=0
Rk55 (\8\:VDD VDD) resistor r=0.3433 c=0
Rk50 (\7\:VDD \8\:VDD) resistor r=0.657 c=0
Rk52 (\6\:VDD \12\:VDD) resistor r=0.07381 c=0
Rk53 (\7\:VDD \14\:VDD) resistor r=0.0433 c=0
Rk54 (\8\:VDD \16\:VDD) resistor r=0.07146 c=0
Rk18 (\14\:B \15\:B) resistor r=0.9002 c=0
Rk19 (\15\:B \16\:B) resistor r=0.6029 c=0
Rk22 (\17\:B B) resistor r=0.0525 c=0
Rk20 (\16\:B \17\:B) resistor r=0.06503 c=0
Rk21 (\17\:B \18\:B) resistor r=0.3682 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.7923 c=0
Rk17 (\14\:CI CI) resistor r=0.03871 c=0
Rk16 (\13\:CI \14\:CI) resistor r=0.5535 c=0
Rk1 (\2\:CO CO) resistor r=0.3167 c=0
Rk2 (CO \4\:CO) resistor r=0.05422 c=0
Rk31 (S \2\:S) resistor r=0.01262 c=0
Rk32 (\2\:S \4\:S) resistor r=0.5162 c=0
Rk7 (\12\:COb \13\:COb) resistor r=1.1197 c=0
Rk8 (\13\:COb \15\:COb) resistor r=0.3289 c=0
Rk9 (\15\:COb \16\:COb) resistor r=0.9704 c=0
Rk10 (\16\:COb \17\:COb) resistor r=0.2113 c=0
Rk11 (\13\:COb \19\:COb) resistor r=0.03584 c=0
Rk12 (\16\:COb \20\:COb) resistor r=0.8731 c=0
Rk13 (\20\:COb \22\:COb) resistor r=0.3793 c=0
Rk14 (\20\:COb \24\:COb) resistor r=0.06269 c=0
Rk4 (\2\:n2 \4\:n2) resistor r=0.282 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2776 c=0
Rk27 (\8\:Sb \10\:Sb) resistor r=0.2719 c=0
Rk28 (\8\:Sb \11\:Sb) resistor r=0.6913 c=0
Rk29 (\11\:Sb \13\:Sb) resistor r=0.6131 c=0
Rk30 (\13\:Sb \15\:Sb) resistor r=0.1267 c=0
Rk3 (\2\:n3 \4\:n3) resistor r=0.2522 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2356 c=0
Rl33 (\10\:A \11\:A) resistor r=125.692 c=0
Rl34 (\11\:A \12\:A) resistor r=77.6149 c=0
Rl24 (\8\:A \9\:A) resistor r=66.5405 c=0
Rl23 (\7\:A \8\:A) resistor r=65.6355 c=0
Rl17 (\4\:A \5\:A) resistor r=106.461 c=0
Rl18 (\5\:A \6\:A) resistor r=79.5379 c=0
Rl7 (\1\:A \2\:A) resistor r=51.1559 c=0
Rl8 (\2\:A \3\:A) resistor r=45.2671 c=0
Rl31 (\11\:B \12\:B) resistor r=74.2328 c=0
Rl32 (\12\:B \13\:B) resistor r=126.156 c=0
Rl21 (\8\:B \9\:B) resistor r=26.9231 c=0
Rl22 (\9\:B \10\:B) resistor r=160.292 c=0
Rl9 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl10 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl14 (\4\:B \5\:B) resistor r=51.1566 c=0
Rl16 (\5\:B \7\:B) resistor r=156.926 c=0
Rl15 (\5\:B \6\:B) resistor r=75.8374 c=0
Rl19 (\5\:CI \6\:CI) resistor r=160.584 c=0
Rl20 (\6\:CI \7\:CI) resistor r=26.3736 c=0
Rl11 (\1\:CI \2\:CI) resistor r=118.464 c=0
Rl12 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl13 (\2\:CI \4\:CI) resistor r=116.966 c=0
Rl30 (\9\:CI \11\:CI) resistor r=184.297 c=0
Rl28 (\8\:CI \9\:CI) resistor r=55.7471 c=0
Rl29 (\9\:CI \10\:CI) resistor r=46.9347 c=0
Rl5 (COb \6\:COb) resistor r=9.5287 c=0
Rl26 (\9\:COb \10\:COb) resistor r=27.9027 c=0
Rl25 (\9\:COb \8\:COb) resistor r=145.139 c=0
Rl27 (\9\:COb \11\:COb) resistor r=96.0333 c=0
Rl36 (\3\:Sb Sb) resistor r=23.4085 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\5\:VDD \4\:VDD) resistor r=6.25 c=0
Rz19 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\4\:CO \3\:CO) resistor r=75 c=0
Rz10 (\2\:S \1\:S) resistor r=75 c=0
Rz6 (\22\:COb \21\:COb) resistor r=75 c=0
Rz7 (\24\:COb \23\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\8\:Sb \7\:Sb) resistor r=75 c=0
Rz9 (\10\:Sb \9\:Sb) resistor r=75 c=0
Ry11 (\5\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry12 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\2\:CO \1\:CO) resistor r=20.6667 c=0
Ry10 (\4\:S \3\:S) resistor r=20.6667 c=0
Ry6 (\15\:COb \14\:COb) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=31 c=0
Ry8 (\13\:Sb \12\:Sb) resistor r=62 c=0
Ry9 (\15\:Sb \14\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\6\:B \16\:B) resistor r=45 c=0
Rx9 (\2\:B \18\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\12\:COb \11\:COb) resistor r=45 c=0
Rx2 (\17\:COb \6\:COb) resistor r=45 c=0
Rx14 (\11\:Sb \3\:Sb) resistor r=45 c=0
mn13_1__rcx (\1\:S Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.956e-14 ad=4.16e-14 ps=1.225e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn12 (\3\:CO COb VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\3\:n2 \3\:A \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.35e-14 ad=2.87e-14 ps=1.49e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn3 (n2 \3\:B \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.35e-14 ad=3.28e-14 ps=1.49e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn4 (\23\:COb \3\:CI n2 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn1 (\21\:COb \7\:B n0 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=1.11427e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn0 (n0 \6\:A \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.28415e-07 sb=1.00927e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn7 (\3\:n4 \7\:CI \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33415e-07 sb=8.04268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn6 (\3\:n4 \10\:B \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.28e-14 ps=1.25e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38415e-07 sb=5.99268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn5 (n4 \7\:A \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.28e-14 ps=1.25e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.03415e-07 sb=3.34268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn8 (\9\:Sb \8\:COb n4 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.65e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10841e-06 sb=1.29268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn11 (\7\:Sb \8\:CI n7 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=5.92805e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 as=1.64e-14 \
        ad=1.23e-14 ps=5.7e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28415e-07 sb=4.87805e-07 sd=160n sca=8.27167 scb=0.00612996 \
        scc=0.000112653 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.273e-14 ad=1.64e-14 ps=1.65e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.53415e-07 sb=3.62805e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mp2 (n3 \1\:A \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.343e-14 ad=4.34e-14 ps=1.97e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.29435e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp3 (\3\:n3 \1\:B \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.343e-14 ad=4.96e-14 ps=1.97e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.87258e-07 sb=3.45e-07 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(1)
mp4 (\14\:COb \1\:CI \3\:n3 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92258e-07 sb=1.4e-07 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(1)
mp1 (\18\:COb \4\:B n1 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.35806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp0 (n1 \4\:A \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.024e-13 ad=1.86e-14 ps=1.63e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.30806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp7 (\3\:n5 \5\:CI \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.024e-13 ad=4.96e-14 ps=1.63e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.65806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp6 (\3\:n5 \8\:B \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.59e-14 ad=4.96e-14 ps=1.9e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=3.60806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp5 (n5 \9\:A \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.59e-14 ad=5.16e-14 ps=1.9e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.57258e-07 sb=3.06935e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp8 (\14\:Sb \10\:COb n5 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.96e-14 ps=1.04e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.29194e-07 sb=1.6e-07 sd=160n sca=21.39 \
        scb=0.0188316 scc=0.00214554 m=(1)
mp11 (\12\:Sb \11\:CI n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.1e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32258e-07 sb=8.95e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=2.48e-14 \
        ad=4.185e-14 ps=7.8e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.12258e-07 sb=7.15e-07 sd=160n sca=11.9366 scb=0.0100265 \
        scc=0.000286595 m=(1)
mp9 (n8 \10\:A \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=2.48e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.37258e-07 sb=5.9e-07 sd=160n sca=12.3487 \
        scb=0.0102277 scc=0.000286701 m=(1)
ends ADDFHX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:11:56 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFHX4
// View name: extracted

simulator lang=spectre

subckt ADDFHX4 A B CI CO S VDD VSS
mp2 (n3 \1\:A \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.70769e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp3 (\3\:n3 \1\:B \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=6.24e-14 ps=1.9e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.86923e-07 sb=3.45e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp4 (\24\:COb \1\:CI \3\:n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.91923e-07 sb=1.4e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp1 (\18\:COb \7\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.20192e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp0 (n1 \6\:A \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=2.34e-14 ps=1.8e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.09692e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp7 (\3\:n5 \5\:CI \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.31923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp6 (\3\:n5 \11\:B \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.26923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp5 (n5 \7\:A \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.61923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp8 (\24\:Sb \13\:COb n5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.12e-14 ps=1.1e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.56923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp11 (\22\:Sb \12\:CI n9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=1.01e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.295e-06 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.485e-14 ps=9.6e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.135e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp9 (n8 \10\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=3.51e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp13_1__rcx (\6\:S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=7.55e-07 sd=160n sca=14.4678 \
        scb=0.0130219 scc=0.000814276 m=(4)
mp12_1__rcx (\1\:CO COb \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=37.1131 scb=0.03221 \
        scc=0.00363789 m=(4)
C1 (A VSS) capacitor c=1.06394e-16
C2 (CO VSS) capacitor c=1.34744e-17
C3 (S VSS) capacitor c=1.52666e-17
C4 (VDD VSS) capacitor c=2.6745e-16
C5 (B VSS) capacitor c=6.85253e-17
C6 (CI VSS) capacitor c=8.8949e-17
C7 (COb VSS) capacitor c=2.93584e-16
C8 (n2 VSS) capacitor c=8.94103e-17
C9 (n0 VSS) capacitor c=1.23995e-18
C10 (n4 VSS) capacitor c=8.08485e-17
C11 (Sb VSS) capacitor c=3.0296e-16
C12 (n7 VSS) capacitor c=1.61961e-18
C13 (n6 VSS) capacitor c=3.29036e-18
C14 (n3 VSS) capacitor c=6.39087e-17
C15 (n1 VSS) capacitor c=2.07034e-18
C16 (n5 VSS) capacitor c=8.06683e-17
C17 (n9 VSS) capacitor c=3.59321e-18
C18 (n8 VSS) capacitor c=3.22966e-18
C19 (\10\:A VSS) capacitor c=7.09646e-17
C20 (\12\:B VSS) capacitor c=7.08189e-17
C21 (\12\:CI VSS) capacitor c=7.6403e-17
C22 (\13\:COb VSS) capacitor c=3.57281e-17
C23 (\7\:A VSS) capacitor c=7.20271e-17
C24 (\11\:B VSS) capacitor c=5.50043e-17
C25 (\5\:CI VSS) capacitor c=7.21388e-17
C26 (\6\:A VSS) capacitor c=8.98701e-17
C27 (\7\:B VSS) capacitor c=7.18386e-17
C28 (\1\:CI VSS) capacitor c=5.43441e-17
C29 (\1\:B VSS) capacitor c=5.74577e-17
C30 (\1\:A VSS) capacitor c=6.01259e-17
C31 (\12\:A VSS) capacitor c=4.87399e-17
C32 (\14\:B VSS) capacitor c=9.41098e-17
C33 (\9\:CI VSS) capacitor c=6.0005e-17
C34 (\15\:COb VSS) capacitor c=6.03615e-17
C35 (\9\:A VSS) capacitor c=5.0202e-17
C36 (\10\:B VSS) capacitor c=6.05021e-17
C37 (\8\:CI VSS) capacitor c=3.82892e-17
C38 (\4\:A VSS) capacitor c=7.92377e-17
C39 (\4\:B VSS) capacitor c=8.94527e-17
C40 (\3\:CI VSS) capacitor c=3.31129e-17
C41 (\3\:B VSS) capacitor c=5.42085e-17
C42 (\3\:A VSS) capacitor c=4.10396e-17
C43 (\11\:A VSS) capacitor c=4.21019e-17
C44 (\13\:B VSS) capacitor c=5.9095e-17
C45 (\11\:CI VSS) capacitor c=3.38895e-17
C46 (\16\:COb VSS) capacitor c=3.40075e-17
C47 (\8\:A VSS) capacitor c=5.20734e-17
C48 (\8\:B VSS) capacitor c=2.98917e-17
C49 (\7\:CI VSS) capacitor c=5.28386e-17
C50 (\5\:A VSS) capacitor c=6.24656e-17
C51 (\6\:B VSS) capacitor c=1.63981e-17
C52 (\4\:CI VSS) capacitor c=4.10263e-17
C53 (\2\:B VSS) capacitor c=3.67442e-17
C54 (\2\:A VSS) capacitor c=2.62767e-17
C55 (\1\:VDD VSS) capacitor c=1.76775e-16
C56 (\22\:Sb VSS) capacitor c=7.46846e-17
C57 (\24\:Sb VSS) capacitor c=6.06525e-17
C58 (\19\:VDD VSS) capacitor c=1.73964e-17
C59 (\3\:n5 VSS) capacitor c=9.4874e-17
C60 (\21\:VDD VSS) capacitor c=1.56286e-17
C61 (\18\:COb VSS) capacitor c=1.25427e-16
C62 (\24\:COb VSS) capacitor c=3.43465e-17
C63 (\3\:n3 VSS) capacitor c=8.35584e-17
C64 (\23\:VDD VSS) capacitor c=1.64207e-17
C65 (\1\:CO VSS) capacitor c=1.94229e-16
C66 (\3\:VDD VSS) capacitor c=5.19165e-17
C67 (\2\:S VSS) capacitor c=1.12127e-16
C68 (\18\:Sb VSS) capacitor c=9.84188e-17
C69 (\20\:Sb VSS) capacitor c=5.8947e-17
C70 (\3\:n4 VSS) capacitor c=7.8415e-17
C71 (\27\:COb VSS) capacitor c=6.1148e-17
C72 (\29\:COb VSS) capacitor c=1.56147e-17
C73 (\3\:n2 VSS) capacitor c=7.77248e-17
C74 (\6\:CO VSS) capacitor c=1.04064e-16
C75 (\2\:CI VSS) capacitor c=3.43984e-17
C76 (\5\:B VSS) capacitor c=3.5978e-17
C77 (\9\:B VSS) capacitor c=2.74209e-17
C78 (\14\:COb VSS) capacitor c=3.50887e-17
C79 (\10\:CI VSS) capacitor c=4.79924e-17
C80 (\17\:COb VSS) capacitor c=1.74083e-16
C81 (\20\:COb VSS) capacitor c=1.02038e-16
C82 (\21\:COb VSS) capacitor c=1.89139e-16
C83 (\26\:COb VSS) capacitor c=1.51242e-16
C84 (\13\:CI VSS) capacitor c=1.50163e-16
C85 (\14\:CI VSS) capacitor c=1.86663e-16
C86 (\15\:B VSS) capacitor c=1.27692e-16
C87 (\16\:B VSS) capacitor c=2.07754e-16
C88 (\17\:B VSS) capacitor c=7.49019e-17
C89 (\18\:B VSS) capacitor c=7.70813e-17
C90 (\13\:A VSS) capacitor c=3.78398e-17
C91 (\14\:A VSS) capacitor c=1.83155e-16
C92 (\15\:A VSS) capacitor c=2.16499e-16
C93 (\16\:A VSS) capacitor c=1.38447e-16
C94 (\17\:Sb VSS) capacitor c=1.49807e-16
C95 (\1\:S VSS) capacitor c=2.98876e-17
C96 (\6\:S VSS) capacitor c=1.94739e-16
C97 (\8\:VDD VSS) capacitor c=1.26916e-17
C98 (\9\:VDD VSS) capacitor c=3.1028e-17
C99 (\10\:VDD VSS) capacitor c=2.7261e-17
C100 (\12\:VDD VSS) capacitor c=1.50598e-16
Rk27 (\13\:A A) resistor r=0.08561 c=0
Rk28 (A \14\:A) resistor r=0.7093 c=0
Rk29 (\14\:A \15\:A) resistor r=0.6289 c=0
Rk30 (\15\:A \16\:A) resistor r=0.9088 c=0
Rk46 (\1\:VSS \7\:VSS) resistor r=0.4512 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.1929 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.2053 c=0
Rk49 (\9\:VSS \10\:VSS) resistor r=0.5704 c=0
Rk50 (\10\:VSS \11\:VSS) resistor r=0.2321 c=0
Rk54 (\12\:VSS VSS) resistor r=0.03215 c=0
Rk51 (\11\:VSS \12\:VSS) resistor r=0.1026 c=0
Rk57 (\8\:VSS \20\:VSS) resistor r=0.1026 c=0
Rk58 (\9\:VSS \22\:VSS) resistor r=0.1742 c=0
Rk59 (\10\:VSS \24\:VSS) resistor r=0.04331 c=0
Rk2 (\1\:CO CO) resistor r=0.242 c=0
Rk4 (CO \6\:CO) resistor r=0.05252 c=0
Rk37 (S \1\:S) resistor r=0.007742 c=0
Rk38 (\1\:S \2\:S) resistor r=0.1493 c=0
Rk40 (\1\:S \6\:S) resistor r=0.324 c=0
Rk66 (\1\:VDD \7\:VDD) resistor r=0.4512 c=0
Rk67 (\7\:VDD \8\:VDD) resistor r=0.1769 c=0
Rk68 (\8\:VDD \9\:VDD) resistor r=0.2334 c=0
Rk69 (\9\:VDD \10\:VDD) resistor r=0.5554 c=0
Rk70 (\10\:VDD \11\:VDD) resistor r=0.233 c=0
Rk74 (\12\:VDD VDD) resistor r=0.03215 c=0
Rk71 (\11\:VDD \12\:VDD) resistor r=0.1177 c=0
Rk77 (\8\:VDD \20\:VDD) resistor r=0.04331 c=0
Rk78 (\9\:VDD \22\:VDD) resistor r=0.04331 c=0
Rk79 (\10\:VDD \24\:VDD) resistor r=0.07393 c=0
Rk24 (\16\:B B) resistor r=0.6363 c=0
Rk23 (\15\:B \16\:B) resistor r=0.814 c=0
Rk25 (B \17\:B) resistor r=0.06383 c=0
Rk26 (\17\:B \18\:B) resistor r=0.534 c=0
Rk20 (\14\:CI CI) resistor r=0.4248 c=0
Rk19 (\13\:CI \14\:CI) resistor r=0.8934 c=0
Rk21 (CI \15\:CI) resistor r=0.003053 c=0
Rk22 (\14\:CI \16\:CI) resistor r=0.04261 c=0
Rk10 (\17\:COb \19\:COb) resistor r=1.1276 c=0
Rk11 (\19\:COb \20\:COb) resistor r=0.2594 c=0
Rk13 (\21\:COb COb) resistor r=0.3988 c=0
Rk12 (\20\:COb \21\:COb) resistor r=0.8996 c=0
Rk15 (\20\:COb \25\:COb) resistor r=0.04927 c=0
Rk16 (\21\:COb \26\:COb) resistor r=0.949 c=0
Rk17 (\26\:COb \28\:COb) resistor r=0.3306 c=0
Rk18 (\26\:COb \30\:COb) resistor r=0.05759 c=0
Rk7 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk9 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk32 (Sb \17\:Sb) resistor r=0.1901 c=0
Rk33 (\17\:Sb \19\:Sb) resistor r=0.593 c=0
Rk34 (\19\:Sb \21\:Sb) resistor r=0.2807 c=0
Rk35 (\17\:Sb \23\:Sb) resistor r=0.7415 c=0
Rk36 (\23\:Sb \25\:Sb) resistor r=0.2136 c=0
Rk6 (\2\:n3 \4\:n3) resistor r=0.2734 c=0
Rk8 (\2\:n5 \4\:n5) resistor r=0.2822 c=0
Rl39 (\10\:A \11\:A) resistor r=108.384 c=0
Rl40 (\11\:A \12\:A) resistor r=44.9225 c=0
Rl29 (\7\:A \8\:A) resistor r=85.7713 c=0
Rl30 (\8\:A \9\:A) resistor r=62.6944 c=0
Rl22 (\5\:A \6\:A) resistor r=62.8119 c=0
Rl21 (\4\:A \5\:A) resistor r=82.2239 c=0
Rl11 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl12 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl37 (\12\:B \13\:B) resistor r=44.9225 c=0
Rl38 (\13\:B \14\:B) resistor r=108.384 c=0
Rl13 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl14 (\2\:B \3\:B) resistor r=75.6918 c=0
Rl20 (\5\:B \7\:B) resistor r=45.0334 c=0
Rl18 (\4\:B \5\:B) resistor r=127.291 c=0
Rl19 (\5\:B \6\:B) resistor r=3.1183 c=0
Rl28 (\9\:B \11\:B) resistor r=34.3295 c=0
Rl27 (\9\:B \10\:B) resistor r=134.329 c=0
Rl26 (\8\:B \9\:B) resistor r=11.5001 c=0
Rl15 (\1\:CI \2\:CI) resistor r=99.2335 c=0
Rl16 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl17 (\2\:CI \4\:CI) resistor r=132.351 c=0
Rl23 (\5\:CI \6\:CI) resistor r=134.329 c=0
Rl25 (\6\:CI \8\:CI) resistor r=34.3295 c=0
Rl24 (\6\:CI \7\:CI) resistor r=0.5166 c=0
Rl36 (\10\:CI \12\:CI) resistor r=134.297 c=0
Rl34 (\9\:CI \10\:CI) resistor r=48.0548 c=0
Rl35 (\10\:CI \11\:CI) resistor r=68.4415 c=0
Rl31 (\14\:COb \13\:COb) resistor r=28.0797 c=0
Rl32 (\14\:COb \15\:COb) resistor r=145.387 c=0
Rl33 (\14\:COb \16\:COb) resistor r=99.1945 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz22 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz23 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\28\:COb \27\:COb) resistor r=75 c=0
Rz8 (\30\:COb \29\:COb) resistor r=75 c=0
Rz3 (n2 \2\:n2) resistor r=75 c=0
Rz4 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz9 (\19\:Sb \18\:Sb) resistor r=75 c=0
Rz10 (\21\:Sb \20\:Sb) resistor r=75 c=0
Ry13 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry14 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=62 c=0
Ry8 (\25\:COb \24\:COb) resistor r=20.6667 c=0
Ry9 (\23\:Sb \22\:Sb) resistor r=62 c=0
Ry10 (\25\:Sb \24\:Sb) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n5 \2\:n5) resistor r=62 c=0
Ry6 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx11 (\11\:A \13\:A) resistor r=45 c=0
Rx12 (\8\:A \14\:A) resistor r=45 c=0
Rx13 (\5\:A \15\:A) resistor r=45 c=0
Rx14 (\2\:A \16\:A) resistor r=45 c=0
Rx7 (\13\:B \15\:B) resistor r=45 c=0
Rx8 (\8\:B \16\:B) resistor r=45 c=0
Rx9 (\6\:B \17\:B) resistor r=45 c=0
Rx10 (\2\:B \18\:B) resistor r=45 c=0
Rx4 (\11\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \15\:CI) resistor r=45 c=0
Rx6 (\7\:CI \16\:CI) resistor r=45 c=0
Rx1 (\17\:COb \16\:COb) resistor r=45 c=0
mn2 (\3\:n2 \3\:A \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.64e-14 ps=1.46e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn3 (n2 \3\:B \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=4.16e-14 ps=1.46e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn4 (\29\:COb \3\:CI n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn1 (\27\:COb \4\:B n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.14e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (n0 \4\:A \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.035e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn7 (\3\:n4 \8\:CI \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn6 (\3\:n4 \10\:B \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.25e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (n4 \9\:A \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn8 (\20\:Sb \15\:COb n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn11 (\18\:Sb \9\:CI n7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.22e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23846e-07 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (n7 \14\:B n6 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.56e-14 ps=7e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28846e-07 sb=1.145e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.34e-14 ps=9.2e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.63846e-07 sb=1.01e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn13_1__rcx (\2\:S Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.08846e-07 sb=7.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn12_1__rcx (\6\:CO COb \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
ends ADDFHX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:11:57 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFHXL
// View name: extracted

simulator lang=spectre

subckt ADDFHXL A B CI CO S VDD VSS
mp12 (\1\:CO COb \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.34e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.8293 scb=0.0353699 \
        scc=0.00464516 m=(1)
mp2 (n3 \1\:A \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.34e-14 ps=1.77e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55484e-07 sd=160n sca=19.2885 \
        scb=0.0175179 scc=0.00172295 m=(1)
mp3 (\3\:n3 \1\:B \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.96e-14 ps=1.77e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36452e-07 sb=3.45e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp4 (\12\:COb \1\:CI \3\:n3 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41452e-07 sb=1.4e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp1 (\9\:COb \6\:B n1 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.65e-14 ps=7.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=9.14839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp0 (n1 \6\:A \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=1.86e-14 ps=1.23e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=8.09839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp7 (\3\:n5 \5\:CI \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=4.96e-14 ps=1.23e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=4.59839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp6 (\3\:n5 \7\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.96e-14 ps=1.77e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.54839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp5 (n5 \9\:A \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=5.48e-14 ps=1.77e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.50323e-07 sb=2.19032e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=5.32e-14 ps=1.2e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.69355e-07 sb=1.71613e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=3.58e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=8.2e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp10 (n9 \10\:B n8 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=3.1e-14 \
        ad=4.185e-14 ps=8.2e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.95484e-07 sb=6.4e-07 sd=160n sca=11.4887 scb=0.00945 \
        scc=0.00022892 m=(1)
mp9 (n8 \10\:A \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=3.1e-14 ps=1.4e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.40484e-07 sb=4.95e-07 sd=160n sca=11.9282 \
        scb=0.00964102 scc=0.000229002 m=(1)
mp13 (\4\:S Sb \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=5.89e-14 ps=1.4e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45484e-07 sb=1.9e-07 sd=160n sca=14.4228 \
        scb=0.0128311 scc=0.000253304 m=(1)
C1 (VDD VSS) capacitor c=2.99258e-16
C2 (B VSS) capacitor c=1.39893e-16
C3 (CI VSS) capacitor c=6.0747e-17
C4 (CO VSS) capacitor c=6.4289e-17
C5 (S VSS) capacitor c=2.33964e-17
C6 (COb VSS) capacitor c=2.42014e-17
C7 (n2 VSS) capacitor c=7.81101e-17
C8 (n4 VSS) capacitor c=7.39192e-17
C9 (Sb VSS) capacitor c=4.18344e-17
C10 (n7 VSS) capacitor c=2.09961e-18
C11 (n6 VSS) capacitor c=3.49935e-18
C12 (n3 VSS) capacitor c=6.50969e-17
C13 (n1 VSS) capacitor c=1.71568e-18
C14 (n5 VSS) capacitor c=8.26506e-17
C15 (n9 VSS) capacitor c=3.83514e-18
C16 (n8 VSS) capacitor c=3.16792e-18
C17 (\10\:A VSS) capacitor c=6.16299e-17
C18 (\10\:B VSS) capacitor c=5.33096e-17
C19 (\11\:CI VSS) capacitor c=7.05701e-17
C20 (\6\:COb VSS) capacitor c=4.28184e-17
C21 (\9\:A VSS) capacitor c=6.83846e-17
C22 (\7\:B VSS) capacitor c=5.15558e-17
C23 (\5\:CI VSS) capacitor c=6.25839e-17
C24 (\6\:A VSS) capacitor c=7.80256e-17
C25 (\6\:B VSS) capacitor c=6.34952e-17
C26 (\1\:CI VSS) capacitor c=6.24736e-17
C27 (\1\:B VSS) capacitor c=5.14322e-17
C28 (\1\:A VSS) capacitor c=5.00304e-17
C29 (\3\:Sb VSS) capacitor c=2.5183e-17
C30 (\12\:A VSS) capacitor c=5.02258e-17
C31 (\12\:B VSS) capacitor c=8.75567e-17
C32 (\8\:CI VSS) capacitor c=5.10374e-17
C33 (\4\:COb VSS) capacitor c=5.2395e-17
C34 (\7\:A VSS) capacitor c=5.07578e-17
C35 (\9\:B VSS) capacitor c=6.05018e-17
C36 (\7\:CI VSS) capacitor c=3.37279e-17
C37 (\4\:A VSS) capacitor c=6.80535e-17
C38 (\4\:B VSS) capacitor c=1.03476e-16
C39 (\3\:CI VSS) capacitor c=3.23125e-17
C40 (\3\:B VSS) capacitor c=5.40402e-17
C41 (\3\:A VSS) capacitor c=4.68315e-17
C42 (\3\:COb VSS) capacitor c=3.09934e-17
C43 (\2\:Sb VSS) capacitor c=3.2719e-17
C44 (\11\:A VSS) capacitor c=4.59596e-17
C45 (\11\:B VSS) capacitor c=6.06031e-17
C46 (\10\:CI VSS) capacitor c=2.73445e-17
C47 (\7\:COb VSS) capacitor c=2.2357e-17
C48 (\8\:A VSS) capacitor c=4.76039e-17
C49 (\8\:B VSS) capacitor c=6.06154e-17
C50 (\6\:CI VSS) capacitor c=5.25396e-17
C51 (\5\:A VSS) capacitor c=7.23717e-17
C52 (\5\:B VSS) capacitor c=6.0704e-17
C53 (\4\:CI VSS) capacitor c=4.70164e-17
C54 (\2\:B VSS) capacitor c=5.44883e-17
C55 (\2\:A VSS) capacitor c=3.58522e-17
C56 (\2\:COb VSS) capacitor c=1.67311e-17
C57 (\4\:S VSS) capacitor c=5.11479e-17
C58 (\10\:VDD VSS) capacitor c=6.00986e-17
C59 (\9\:Sb VSS) capacitor c=8.81568e-17
C60 (\11\:Sb VSS) capacitor c=4.79826e-17
C61 (\1\:VDD VSS) capacitor c=2.89079e-17
C62 (\3\:n5 VSS) capacitor c=8.41487e-17
C63 (\12\:VDD VSS) capacitor c=4.72885e-17
C64 (\9\:COb VSS) capacitor c=1.7666e-16
C65 (\12\:COb VSS) capacitor c=2.94243e-17
C66 (\3\:n3 VSS) capacitor c=7.07553e-17
C67 (\14\:VDD VSS) capacitor c=2.42685e-17
C68 (\1\:CO VSS) capacitor c=9.0773e-17
C69 (\16\:VDD VSS) capacitor c=4.25392e-17
C70 (\5\:VDD VSS) capacitor c=6.67146e-17
C71 (\2\:S VSS) capacitor c=5.5611e-17
C72 (\4\:Sb VSS) capacitor c=7.22113e-17
C73 (\6\:Sb VSS) capacitor c=4.9118e-17
C74 (\3\:n4 VSS) capacitor c=7.14466e-17
C75 (\19\:COb VSS) capacitor c=5.36657e-17
C76 (\16\:COb VSS) capacitor c=1.43732e-17
C77 (\3\:n2 VSS) capacitor c=7.08557e-17
C78 (\3\:CO VSS) capacitor c=6.13067e-17
C79 (\2\:CI VSS) capacitor c=3.14316e-17
C80 (\5\:COb VSS) capacitor c=4.88869e-17
C81 (\9\:CI VSS) capacitor c=4.46223e-17
C82 (\8\:COb VSS) capacitor c=1.99e-16
C83 (\11\:COb VSS) capacitor c=1.22069e-16
C84 (\14\:COb VSS) capacitor c=2.07134e-16
C85 (\15\:COb VSS) capacitor c=1.10778e-16
C86 (\18\:COb VSS) capacitor c=4.97576e-17
C87 (\12\:CI VSS) capacitor c=1.44026e-16
C88 (\13\:CI VSS) capacitor c=1.44858e-16
C89 (\14\:CI VSS) capacitor c=3.85465e-17
C90 (\13\:B VSS) capacitor c=1.23834e-16
C91 (\14\:B VSS) capacitor c=2.10704e-16
C92 (\16\:B VSS) capacitor c=8.19519e-17
C93 (\13\:A VSS) capacitor c=1.37541e-16
C94 (\14\:A VSS) capacitor c=1.92826e-16
C95 (\15\:A VSS) capacitor c=1.90736e-16
C96 (\16\:A VSS) capacitor c=1.07257e-16
C97 (\8\:Sb VSS) capacitor c=1.78473e-16
C98 (\3\:VDD VSS) capacitor c=3.71556e-17
C99 (\4\:VDD VSS) capacitor c=3.23972e-17
C100 (\7\:VDD VSS) capacitor c=1.9723e-17
C101 (\8\:VDD VSS) capacitor c=1.43541e-17
Rk22 (A \13\:A) resistor r=0.003104 c=0
Rk23 (\13\:A \14\:A) resistor r=0.9007 c=0
Rk24 (\14\:A \15\:A) resistor r=0.5026 c=0
Rk25 (\15\:A \16\:A) resistor r=0.7694 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.2878 c=0
Rk45 (\3\:VSS \5\:VSS) resistor r=0.4337 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.1192 c=0
Rk48 (\7\:VSS VSS) resistor r=0.03466 c=0
Rk47 (\6\:VSS \7\:VSS) resistor r=0.3949 c=0
Rk49 (\3\:VSS \8\:VSS) resistor r=0.2103 c=0
Rk50 (\8\:VSS \10\:VSS) resistor r=0.1995 c=0
Rk51 (\6\:VSS \12\:VSS) resistor r=0.04331 c=0
Rk52 (\7\:VSS \14\:VSS) resistor r=0.2744 c=0
Rk53 (\8\:VSS \15\:VSS) resistor r=0.4587 c=0
Rk54 (\15\:VSS \17\:VSS) resistor r=0.4208 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.04331 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.2921 c=0
Rk35 (\4\:VDD \6\:VDD) resistor r=0.3659 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.1192 c=0
Rk38 (\8\:VDD VDD) resistor r=0.03466 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.3949 c=0
Rk39 (\3\:VDD \9\:VDD) resistor r=0.4427 c=0
Rk40 (\9\:VDD \11\:VDD) resistor r=0.3406 c=0
Rk41 (\4\:VDD \13\:VDD) resistor r=0.1857 c=0
Rk42 (\7\:VDD \15\:VDD) resistor r=0.04331 c=0
Rk43 (\8\:VDD \17\:VDD) resistor r=0.3628 c=0
Rk18 (\13\:B \14\:B) resistor r=0.9231 c=0
Rk20 (\15\:B B) resistor r=0.005207 c=0
Rk19 (\14\:B \15\:B) resistor r=0.5499 c=0
Rk21 (\15\:B \16\:B) resistor r=0.4236 c=0
Rk16 (\13\:CI CI) resistor r=0.3243 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8368 c=0
Rk17 (CI \14\:CI) resistor r=0.06635 c=0
Rk1 (\2\:CO CO) resistor r=0.4648 c=0
Rk2 (CO \4\:CO) resistor r=0.2836 c=0
Rk30 (S \1\:S) resistor r=0.07549 c=0
Rk31 (\1\:S \3\:S) resistor r=0.08787 c=0
Rk32 (\1\:S \5\:S) resistor r=0.4153 c=0
Rk7 (\8\:COb \10\:COb) resistor r=1.3892 c=0
Rk8 (\10\:COb \11\:COb) resistor r=0.1621 c=0
Rk9 (\11\:COb \13\:COb) resistor r=0.06391 c=0
Rk10 (\11\:COb \14\:COb) resistor r=1.0341 c=0
Rk11 (\14\:COb \15\:COb) resistor r=0.8971 c=0
Rk12 (\15\:COb \17\:COb) resistor r=0.03458 c=0
Rk13 (\14\:COb \18\:COb) resistor r=0.159 c=0
Rk14 (\15\:COb \20\:COb) resistor r=0.2602 c=0
Rk4 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2778 c=0
Rk26 (\5\:Sb \7\:Sb) resistor r=0.2431 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.5482 c=0
Rk28 (\8\:Sb \10\:Sb) resistor r=0.873 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1246 c=0
Rk3 (\2\:n3 \4\:n3) resistor r=0.2195 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2402 c=0
Rl28 (\10\:A \11\:A) resistor r=85.7713 c=0
Rl29 (\11\:A \12\:A) resistor r=64.6174 c=0
Rl19 (\8\:A \9\:A) resistor r=24.2328 c=0
Rl18 (\7\:A \8\:A) resistor r=100.539 c=0
Rl13 (\5\:A \6\:A) resistor r=114.01 c=0
Rl12 (\4\:A \5\:A) resistor r=84.6154 c=0
Rl3 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl4 (\2\:A \3\:A) resistor r=84.1695 c=0
Rl26 (\10\:B \11\:B) resistor r=24.2328 c=0
Rl27 (\11\:B \12\:B) resistor r=126.156 c=0
Rl16 (\7\:B \8\:B) resistor r=24.2328 c=0
Rl17 (\8\:B \9\:B) resistor r=158.848 c=0
Rl11 (\5\:B \6\:B) resistor r=39.6174 c=0
Rl10 (\4\:B \5\:B) resistor r=177.645 c=0
Rl5 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl6 (\2\:B \3\:B) resistor r=114.617 c=0
Rl14 (\5\:CI \6\:CI) resistor r=158.848 c=0
Rl15 (\6\:CI \7\:CI) resistor r=24.2328 c=0
Rl7 (\1\:CI \2\:CI) resistor r=135.772 c=0
Rl8 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl9 (\2\:CI \4\:CI) resistor r=97.9741 c=0
Rl25 (\9\:CI \11\:CI) resistor r=135.855 c=0
Rl23 (\8\:CI \9\:CI) resistor r=40.105 c=0
Rl24 (\9\:CI \10\:CI) resistor r=46.5525 c=0
Rl1 (COb \2\:COb) resistor r=29.5379 c=0
Rl2 (\2\:COb \3\:COb) resistor r=66.0764 c=0
Rl21 (\5\:COb \6\:COb) resistor r=53.824 c=0
Rl20 (\4\:COb \5\:COb) resistor r=143.912 c=0
Rl22 (\5\:COb \7\:COb) resistor r=85.285 c=0
Rl30 (Sb \2\:Sb) resistor r=126.156 c=0
Rl31 (\2\:Sb \3\:Sb) resistor r=24.2328 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz15 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz11 (\5\:VDD \6\:VDD) resistor r=6.25 c=0
Rz12 (\5\:VDD \9\:VDD) resistor r=7.5 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz10 (\2\:S \3\:S) resistor r=75 c=0
Rz6 (\16\:COb \17\:COb) resistor r=75 c=0
Rz7 (\19\:COb \20\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry16 (\4\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry17 (\4\:VSS \15\:VSS) resistor r=6.2 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry1 (\1\:CO \2\:CO) resistor r=31 c=0
Ry10 (\4\:S \5\:S) resistor r=31 c=0
Ry6 (\9\:COb \10\:COb) resistor r=31 c=0
Ry7 (\12\:COb \13\:COb) resistor r=31 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\7\:COb \8\:COb) resistor r=45 c=0
Rx2 (\2\:COb \18\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \8\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.87e-14 ps=6.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn2 (\3\:n2 \3\:A \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.01e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3 (n2 \3\:B \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.01e-14 ad=3.28e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\16\:COb \3\:CI n2 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn1 (\19\:COb \4\:B n0 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12329e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn0 (n0 \4\:A \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=1.23e-14 ps=7.5e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.01829e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn7 (\3\:n4 \7\:CI \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=3.28e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=8.03293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn6 (\3\:n4 \9\:B \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.01e-14 ad=3.28e-14 ps=1.1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=5.98293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn5 (n4 \7\:A \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.01e-14 ad=3.28e-14 ps=1.1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=3.33293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn8 (\6\:Sb \4\:COb n4 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.63e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.28293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=7.45e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn10 (n7 \12\:B n6 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 as=2.05e-14 \
        ad=1.23e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28415e-07 sb=6.4e-07 sd=160n sca=16.0682 scb=0.0166045 \
        scc=0.00126927 m=(1)
mn9 (n6 \12\:A \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=2.05e-14 ps=1.19e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.73415e-07 sb=4.95e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn13 (\2\:S \3\:Sb \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.895e-14 ps=1.19e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.78415e-07 sb=1.9e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
ends ADDFHXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:11:58 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFX1
// View name: extracted

simulator lang=spectre

subckt ADDFX1 A B CI CO S VDD VSS
mp12 (\1\:CO \4\:COb \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.615e-14 ad=5.46e-14 ps=1.33e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12821e-07 sd=160n sca=24.8923 \
        scb=0.0283314 scc=0.00161065 m=(1)
mp13 (\1\:S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=5.46e-14 ps=1.17e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15032e-06 sb=1.4e-07 sd=160n sca=26.7686 \
        scb=0.0307018 scc=0.00196241 m=(1)
C1 (A VSS) capacitor c=1.01999e-16
C2 (CO VSS) capacitor c=5.52841e-17
C3 (VDD VSS) capacitor c=2.32048e-16
C4 (B VSS) capacitor c=1.10238e-16
C5 (CI VSS) capacitor c=1.93031e-16
C6 (S VSS) capacitor c=5.97791e-17
C7 (COb VSS) capacitor c=1.31676e-17
C8 (n2 VSS) capacitor c=8.98264e-17
C9 (n4 VSS) capacitor c=7.94254e-17
C10 (Sb VSS) capacitor c=4.62147e-17
C11 (n7 VSS) capacitor c=1.78033e-18
C12 (n6 VSS) capacitor c=1.50273e-18
C13 (n3 VSS) capacitor c=6.36086e-17
C14 (n1 VSS) capacitor c=1.4721e-18
C15 (n5 VSS) capacitor c=6.90334e-17
C16 (\12\:A VSS) capacitor c=9.26743e-17
C17 (\12\:B VSS) capacitor c=9.39089e-17
C18 (\10\:CI VSS) capacitor c=1.07452e-16
C19 (\7\:COb VSS) capacitor c=3.23339e-17
C20 (\9\:A VSS) capacitor c=6.56997e-17
C21 (\7\:B VSS) capacitor c=3.94173e-17
C22 (\5\:CI VSS) capacitor c=6.47935e-17
C23 (\4\:A VSS) capacitor c=6.88815e-17
C24 (\4\:B VSS) capacitor c=5.10292e-17
C25 (\4\:CI VSS) capacitor c=5.65197e-17
C26 (\1\:B VSS) capacitor c=4.08861e-17
C27 (\1\:A VSS) capacitor c=5.19026e-17
C28 (\4\:COb VSS) capacitor c=3.78442e-17
C29 (\3\:Sb VSS) capacitor c=5.04827e-17
C30 (\10\:A VSS) capacitor c=5.8465e-17
C31 (\10\:B VSS) capacitor c=8.65976e-17
C32 (\8\:CI VSS) capacitor c=4.2949e-17
C33 (\5\:COb VSS) capacitor c=6.71707e-17
C34 (\7\:A VSS) capacitor c=3.8526e-17
C35 (\9\:B VSS) capacitor c=6.35541e-17
C36 (\7\:CI VSS) capacitor c=4.17523e-17
C37 (\6\:A VSS) capacitor c=7.57983e-17
C38 (\6\:B VSS) capacitor c=8.59046e-17
C39 (\3\:CI VSS) capacitor c=4.32155e-17
C40 (\3\:B VSS) capacitor c=6.41382e-17
C41 (\3\:A VSS) capacitor c=4.58444e-17
C42 (\3\:COb VSS) capacitor c=3.58924e-17
C43 (\2\:Sb VSS) capacitor c=4.40298e-17
C44 (\11\:A VSS) capacitor c=8.54228e-17
C45 (\11\:B VSS) capacitor c=1.01704e-16
C46 (\9\:CI VSS) capacitor c=8.81238e-17
C47 (\6\:COb VSS) capacitor c=7.7706e-17
C48 (\8\:A VSS) capacitor c=6.18142e-17
C49 (\8\:B VSS) capacitor c=6.55005e-17
C50 (\6\:CI VSS) capacitor c=6.87861e-17
C51 (\5\:A VSS) capacitor c=8.52733e-17
C52 (\5\:B VSS) capacitor c=9.3073e-17
C53 (\1\:CI VSS) capacitor c=3.20724e-17
C54 (\2\:B VSS) capacitor c=7.02887e-17
C55 (\2\:A VSS) capacitor c=5.80913e-17
C56 (\1\:S VSS) capacitor c=3.16251e-17
C57 (\1\:VDD VSS) capacitor c=5.66035e-17
C58 (\7\:Sb VSS) capacitor c=1.08087e-16
C59 (\6\:VDD VSS) capacitor c=1.31301e-17
C60 (\3\:n5 VSS) capacitor c=6.75843e-17
C61 (\9\:VDD VSS) capacitor c=7.59635e-18
C62 (\12\:COb VSS) capacitor c=2.37964e-17
C63 (\13\:VDD VSS) capacitor c=1.30474e-17
C64 (\3\:n3 VSS) capacitor c=5.91025e-17
C65 (\16\:VDD VSS) capacitor c=2.69513e-17
C66 (\1\:CO VSS) capacitor c=3.37004e-17
C67 (\3\:VDD VSS) capacitor c=4.67674e-17
C68 (\3\:S VSS) capacitor c=7.41156e-17
C69 (\4\:Sb VSS) capacitor c=1.28368e-16
C70 (\3\:n4 VSS) capacitor c=8.16894e-17
C71 (\14\:COb VSS) capacitor c=1.52776e-16
C72 (\3\:n2 VSS) capacitor c=9.46317e-17
C73 (\3\:CO VSS) capacitor c=4.54658e-17
C74 (\2\:COb VSS) capacitor c=1.87253e-17
C75 (\2\:CI VSS) capacitor c=4.51448e-17
C76 (\8\:COb VSS) capacitor c=1.80605e-16
C77 (\9\:COb VSS) capacitor c=2.01574e-16
C78 (\10\:COb VSS) capacitor c=1.90789e-16
C79 (\11\:COb VSS) capacitor c=5.10434e-17
C80 (\11\:CI VSS) capacitor c=1.57629e-16
C81 (\13\:CI VSS) capacitor c=7.2765e-17
C82 (\13\:B VSS) capacitor c=1.12492e-16
C83 (\14\:B VSS) capacitor c=1.09444e-16
C84 (\15\:B VSS) capacitor c=1.22764e-16
C85 (\16\:B VSS) capacitor c=6.8853e-17
C86 (\13\:A VSS) capacitor c=1.77265e-16
C87 (\14\:A VSS) capacitor c=9.08879e-17
C88 (\15\:A VSS) capacitor c=1.29404e-16
C89 (\16\:A VSS) capacitor c=1.46182e-16
C90 (\6\:Sb VSS) capacitor c=1.73037e-16
C91 (\5\:VDD VSS) capacitor c=2.2715e-17
C92 (\8\:VDD VSS) capacitor c=6.79515e-18
C93 (\12\:VDD VSS) capacitor c=1.19106e-17
C94 (\15\:VDD VSS) capacitor c=8.18917e-18
Rk20 (\13\:A A) resistor r=0.4796 c=0
Rk19 (\13\:A \14\:A) resistor r=0.7021 c=0
Rk21 (A \15\:A) resistor r=0.2359 c=0
Rk22 (\15\:A \16\:A) resistor r=0.7149 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.2377 c=0
Rk28 (\4\:VSS \5\:VSS) resistor r=0.4323 c=0
Rk29 (\5\:VSS \6\:VSS) resistor r=0.2207 c=0
Rk30 (\6\:VSS \7\:VSS) resistor r=0.1003 c=0
Rk31 (\7\:VSS \8\:VSS) resistor r=0.2611 c=0
Rk33 (\9\:VSS VSS) resistor r=0.1026 c=0
Rk32 (\8\:VSS \9\:VSS) resistor r=0.188 c=0
Rk34 (\5\:VSS \11\:VSS) resistor r=0.1087 c=0
Rk35 (\6\:VSS \13\:VSS) resistor r=0.189 c=0
Rk36 (\8\:VSS \15\:VSS) resistor r=0.1947 c=0
Rk37 (\9\:VSS \17\:VSS) resistor r=0.4242 c=0
Rk1 (\2\:CO CO) resistor r=0.168 c=0
Rk2 (CO \4\:CO) resistor r=0.3521 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.3917 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.4536 c=0
Rk40 (\5\:VDD \7\:VDD) resistor r=0.1133 c=0
Rk41 (\5\:VDD \8\:VDD) resistor r=0.1842 c=0
Rk42 (\8\:VDD \10\:VDD) resistor r=0.1188 c=0
Rk43 (\8\:VDD \11\:VDD) resistor r=0.1154 c=0
Rk44 (\11\:VDD \12\:VDD) resistor r=0.2862 c=0
Rk45 (\12\:VDD \14\:VDD) resistor r=0.1154 c=0
Rk48 (\15\:VDD VDD) resistor r=0.1026 c=0
Rk46 (\12\:VDD \15\:VDD) resistor r=0.1629 c=0
Rk47 (\15\:VDD \17\:VDD) resistor r=0.1706 c=0
Rk15 (\13\:B B) resistor r=0.5524 c=0
Rk16 (B \14\:B) resistor r=0.2651 c=0
Rk17 (\14\:B \15\:B) resistor r=0.5802 c=0
Rk18 (\15\:B \16\:B) resistor r=0.3774 c=0
Rk12 (\11\:CI CI) resistor r=0.8769 c=0
Rk13 (CI \12\:CI) resistor r=0.002725 c=0
Rk14 (CI \13\:CI) resistor r=0.364 c=0
Rk25 (\2\:S S) resistor r=0.1218 c=0
Rk26 (S \4\:S) resistor r=0.5035 c=0
Rk7 (\8\:COb \9\:COb) resistor r=1.113 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.6087 c=0
Rk9 (\10\:COb \11\:COb) resistor r=0.2346 c=0
Rk10 (\9\:COb \13\:COb) resistor r=0.0716 c=0
Rk11 (\10\:COb \15\:COb) resistor r=1.0491 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.5995 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.3718 c=0
Rk23 (\5\:Sb \6\:Sb) resistor r=0.7375 c=0
Rk24 (\6\:Sb \8\:Sb) resistor r=0.634 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.338 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.3676 c=0
Rl28 (\11\:A \12\:A) resistor r=150.223 c=0
Rl27 (\10\:A \11\:A) resistor r=81.8672 c=0
Rl20 (\8\:A \9\:A) resistor r=162.694 c=0
Rl19 (\7\:A \8\:A) resistor r=72.3097 c=0
Rl13 (\4\:A \5\:A) resistor r=74.2328 c=0
Rl14 (\5\:A \6\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=74.2328 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl26 (\11\:B \12\:B) resistor r=116.54 c=0
Rl25 (\10\:B \11\:B) resistor r=126.234 c=0
Rl17 (\7\:B \8\:B) resistor r=28.079 c=0
Rl18 (\8\:B \9\:B) resistor r=206.925 c=0
Rl11 (\4\:B \5\:B) resistor r=28.079 c=0
Rl12 (\5\:B \6\:B) resistor r=206.925 c=0
Rl6 (\1\:B \2\:B) resistor r=28.079 c=0
Rl7 (\2\:B \3\:B) resistor r=206.925 c=0
Rl24 (\9\:CI \10\:CI) resistor r=214.401 c=0
Rl23 (\8\:CI \9\:CI) resistor r=28.8462 c=0
Rl15 (\5\:CI \6\:CI) resistor r=139.56 c=0
Rl16 (\6\:CI \7\:CI) resistor r=91.4826 c=0
Rl10 (\2\:CI \4\:CI) resistor r=129.649 c=0
Rl9 (\2\:CI \3\:CI) resistor r=123.88 c=0
Rl8 (\1\:CI \2\:CI) resistor r=3.1216 c=0
Rl22 (\6\:COb \7\:COb) resistor r=37.6365 c=0
Rl21 (\5\:COb \6\:COb) resistor r=199.969 c=0
Rl3 (\2\:COb \4\:COb) resistor r=49.7141 c=0
Rl2 (\2\:COb \3\:COb) resistor r=113.176 c=0
Rl1 (COb \2\:COb) resistor r=2.0213 c=0
Rl29 (Sb \2\:Sb) resistor r=56.8672 c=0
Rl30 (\2\:Sb \3\:Sb) resistor r=110.713 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=37.5 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=25 c=0
Rz15 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz8 (\3\:S \4\:S) resistor r=37.5 c=0
Rz6 (\14\:COb \15\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz7 (\4\:Sb \5\:Sb) resistor r=75 c=0
Ry9 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry10 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry12 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry13 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry8 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry6 (\12\:COb \13\:COb) resistor r=62 c=0
Ry7 (\7\:Sb \8\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\5\:A \13\:A) resistor r=45 c=0
Rx11 (\2\:A \14\:A) resistor r=45 c=0
Rx12 (\8\:A \15\:A) resistor r=45 c=0
Rx13 (\11\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\9\:CI \11\:CI) resistor r=45 c=0
Rx4 (\6\:CI \12\:CI) resistor r=45 c=0
Rx5 (\1\:CI \13\:CI) resistor r=45 c=0
Rx1 (\6\:COb \8\:COb) resistor r=45 c=0
Rx2 (COb \11\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.22e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.23846e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn13 (\3\:S \3\:Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn2 (\3\:n2 \3\:A \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=1.93e-14 ps=9.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n2 \3\:B \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.38103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\14\:COb \3\:CI n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43103e-07 sb=1.95e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\14\:COb \6\:B n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.48103e-07 sb=1.745e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \6\:A \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=8.7e-15 ps=9.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.53103e-07 sb=1.64e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \7\:CI \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0581e-06 sb=1.435e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \9\:B \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2631e-06 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5281e-06 sb=9.65e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn8 (\4\:Sb \5\:COb n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7331e-06 sb=7.6e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9381e-06 sb=5.55e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn10 (n7 \10\:B n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=6.83173 scb=0.00357784 scc=2.82929e-05 \
        m=(1)
mn9 (n6 \10\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mp2 (\3\:n3 \1\:A \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.91e-14 ps=1.59e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35349e-07 sb=2e-06 sd=160n sca=14.1415 \
        scb=0.0126578 scc=0.000426771 m=(1)
mp3 (n3 \1\:B \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.44e-14 ps=1.59e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.30349e-07 sb=2e-06 sd=160n sca=13.1633 \
        scb=0.0118398 scc=0.00042523 m=(1)
mp4 (\12\:COb \4\:CI n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35349e-07 sb=1.95e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\12\:COb \4\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.40349e-07 sb=1.745e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (n1 \4\:A \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45349e-07 sb=1.64e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (\3\:n5 \5\:CI \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=3.44e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05035e-06 sb=1.435e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\3\:n5 \7\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25535e-06 sb=1.23e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (n5 \9\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=1e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp8 (\7\:Sb \7\:COb n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69035e-06 sb=7.95e-07 sd=160n sca=12.9421 \
        scb=0.0117495 scc=0.000425199 m=(1)
mp11 (\7\:Sb \10\:CI n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89535e-06 sb=5.9e-07 sd=160n sca=13.7253 \
        scb=0.0122307 scc=0.000425663 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.99593e-06 sb=4.85e-07 sd=160n sca=14.4668 scb=0.0130588 \
        scc=0.000428492 m=(1)
mp9 (n8 \12\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.29e-14 ps=1.17e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.8e-07 sd=160n sca=15.7217 scb=0.0149728 \
        scc=0.00044748 m=(1)
ends ADDFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:11:59 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFX2
// View name: extracted

simulator lang=spectre

subckt ADDFX2 A B CI CO S VDD VSS
mp13 (\3\:S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.44551e-07 sb=3.45e-07 sd=160n sca=17.8374 \
        scb=0.0170197 scc=0.000849186 m=(2)
mp12_1__rcx (\1\:CO COb VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.0983 \
        scb=0.0376779 scc=0.00400735 m=(2)
C1 (CO VSS) capacitor c=3.33229e-17
C2 (A VSS) capacitor c=3.34305e-17
C3 (S VSS) capacitor c=4.58073e-17
C4 (VDD VSS) capacitor c=3.56267e-16
C5 (B VSS) capacitor c=3.72615e-17
C6 (CI VSS) capacitor c=7.89726e-17
C7 (COb VSS) capacitor c=1.06072e-16
C8 (n2 VSS) capacitor c=6.60678e-17
C9 (n4 VSS) capacitor c=7.74034e-17
C10 (Sb VSS) capacitor c=7.06273e-17
C11 (n7 VSS) capacitor c=1.94584e-18
C12 (n6 VSS) capacitor c=2.26118e-18
C13 (n3 VSS) capacitor c=6.34467e-17
C14 (n5 VSS) capacitor c=7.29765e-17
C15 (n9 VSS) capacitor c=1.29749e-18
C16 (n8 VSS) capacitor c=1.94624e-18
C17 (\10\:A VSS) capacitor c=6.60446e-17
C18 (\11\:B VSS) capacitor c=8.65718e-17
C19 (\8\:CI VSS) capacitor c=1.25021e-16
C20 (\8\:COb VSS) capacitor c=2.22177e-17
C21 (\9\:A VSS) capacitor c=5.70405e-17
C22 (\10\:B VSS) capacitor c=4.31113e-17
C23 (\7\:CI VSS) capacitor c=5.28966e-17
C24 (\6\:A VSS) capacitor c=6.59819e-17
C25 (\7\:B VSS) capacitor c=4.93572e-17
C26 (\1\:CI VSS) capacitor c=4.99186e-17
C27 (\4\:B VSS) capacitor c=4.37965e-17
C28 (\1\:A VSS) capacitor c=3.89438e-17
C29 (\12\:A VSS) capacitor c=4.90267e-17
C30 (\13\:B VSS) capacitor c=8.7611e-17
C31 (\11\:CI VSS) capacitor c=4.56463e-17
C32 (\10\:COb VSS) capacitor c=5.3484e-17
C33 (\7\:A VSS) capacitor c=4.34393e-17
C34 (\8\:B VSS) capacitor c=5.48712e-17
C35 (\5\:CI VSS) capacitor c=2.64619e-17
C36 (\4\:A VSS) capacitor c=5.59087e-17
C37 (\5\:B VSS) capacitor c=8.58203e-17
C38 (\3\:CI VSS) capacitor c=2.65576e-17
C39 (\3\:B VSS) capacitor c=5.17245e-17
C40 (\3\:A VSS) capacitor c=3.84866e-17
C41 (\4\:Sb VSS) capacitor c=1.52325e-17
C42 (\11\:A VSS) capacitor c=6.83762e-17
C43 (\12\:B VSS) capacitor c=9.089e-17
C44 (\10\:CI VSS) capacitor c=2.04868e-17
C45 (\11\:COb VSS) capacitor c=4.91813e-17
C46 (\8\:A VSS) capacitor c=6.71098e-17
C47 (\9\:B VSS) capacitor c=5.78137e-17
C48 (\6\:CI VSS) capacitor c=4.43419e-17
C49 (\5\:A VSS) capacitor c=6.31171e-17
C50 (\6\:B VSS) capacitor c=5.61083e-17
C51 (\4\:CI VSS) capacitor c=3.89646e-17
C52 (\1\:B VSS) capacitor c=2.35634e-17
C53 (\2\:A VSS) capacitor c=2.8336e-17
C54 (\6\:COb VSS) capacitor c=7.40327e-18
C55 (\1\:VDD VSS) capacitor c=9.45295e-17
C56 (\3\:S VSS) capacitor c=5.45039e-17
C57 (\8\:Sb VSS) capacitor c=1.22985e-17
C58 (\16\:Sb VSS) capacitor c=4.37628e-17
C59 (\15\:VDD VSS) capacitor c=1.38272e-17
C60 (\3\:n5 VSS) capacitor c=7.42195e-17
C61 (\17\:VDD VSS) capacitor c=1.07441e-17
C62 (\17\:COb VSS) capacitor c=1.93089e-17
C63 (\19\:COb VSS) capacitor c=1.3071e-17
C64 (\19\:VDD VSS) capacitor c=1.15798e-17
C65 (\3\:n3 VSS) capacitor c=6.57698e-17
C66 (\1\:CO VSS) capacitor c=6.49112e-17
C67 (\4\:VDD VSS) capacitor c=5.4126e-17
C68 (\1\:S VSS) capacitor c=1.9044e-17
C69 (\12\:Sb VSS) capacitor c=7.80586e-17
C70 (\14\:Sb VSS) capacitor c=4.62149e-17
C71 (\3\:n4 VSS) capacitor c=7.45252e-17
C72 (\24\:COb VSS) capacitor c=6.19502e-17
C73 (\22\:COb VSS) capacitor c=4.05389e-17
C74 (\3\:n2 VSS) capacitor c=6.8621e-17
C75 (\4\:CO VSS) capacitor c=1.59265e-17
C76 (\2\:B VSS) capacitor c=3.19117e-17
C77 (\2\:CI VSS) capacitor c=3.44383e-17
C78 (\9\:COb VSS) capacitor c=3.84342e-17
C79 (\9\:CI VSS) capacitor c=5.826e-17
C80 (\3\:Sb VSS) capacitor c=6.70913e-17
C81 (\3\:CO VSS) capacitor c=1.76134e-17
C82 (\12\:COb VSS) capacitor c=1.99577e-16
C83 (\13\:COb VSS) capacitor c=1.28624e-16
C84 (\14\:COb VSS) capacitor c=1.07942e-16
C85 (\15\:COb VSS) capacitor c=1.59564e-16
C86 (\16\:COb VSS) capacitor c=2.42814e-17
C87 (\21\:COb VSS) capacitor c=1.3148e-16
C88 (\12\:CI VSS) capacitor c=1.43462e-16
C89 (\13\:CI VSS) capacitor c=1.89068e-16
C90 (\14\:CI VSS) capacitor c=3.04929e-17
C91 (\14\:B VSS) capacitor c=1.46739e-16
C92 (\15\:B VSS) capacitor c=1.69269e-16
C93 (\16\:B VSS) capacitor c=6.15861e-17
C94 (\17\:B VSS) capacitor c=7.24361e-17
C95 (\18\:B VSS) capacitor c=9.10858e-17
C96 (\13\:A VSS) capacitor c=1.32103e-16
C97 (\14\:A VSS) capacitor c=2.11599e-16
C98 (\15\:A VSS) capacitor c=2.0913e-16
C99 (\16\:A VSS) capacitor c=1.4046e-16
C100 (\10\:Sb VSS) capacitor c=8.46426e-17
C101 (\11\:Sb VSS) capacitor c=1.81641e-16
C102 (\6\:VDD VSS) capacitor c=2.19359e-17
C103 (\7\:VDD VSS) capacitor c=2.5277e-17
C104 (\9\:VDD VSS) capacitor c=8.77378e-18
Rk2 (\3\:CO CO) resistor r=0.1357 c=0
Rk1 (\2\:CO \3\:CO) resistor r=0.2202 c=0
Rk3 (\3\:CO \5\:CO) resistor r=0.1623 c=0
Rk25 (\13\:A A) resistor r=0.06557 c=0
Rk26 (\13\:A \14\:A) resistor r=0.7932 c=0
Rk27 (\14\:A \15\:A) resistor r=0.6933 c=0
Rk28 (\15\:A \16\:A) resistor r=0.8404 c=0
Rk34 (\2\:S S) resistor r=0.1254 c=0
Rk35 (S \4\:S) resistor r=0.2559 c=0
Rk37 (\1\:VDD \5\:VDD) resistor r=0.2054 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.4327 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.2419 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.4763 c=0
Rk42 (\9\:VDD VDD) resistor r=0.2353 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.1252 c=0
Rk46 (\6\:VDD \16\:VDD) resistor r=0.04331 c=0
Rk47 (\7\:VDD \18\:VDD) resistor r=0.07393 c=0
Rk48 (\9\:VDD \20\:VDD) resistor r=0.07393 c=0
Rk20 (\14\:B \15\:B) resistor r=0.8613 c=0
Rk24 (\16\:B B) resistor r=0.09945 c=0
Rk21 (\15\:B \16\:B) resistor r=0.4055 c=0
Rk22 (\16\:B \17\:B) resistor r=0.1781 c=0
Rk23 (\17\:B \18\:B) resistor r=0.4817 c=0
Rk18 (\13\:CI CI) resistor r=0.5487 c=0
Rk17 (\12\:CI \13\:CI) resistor r=0.8562 c=0
Rk19 (CI \14\:CI) resistor r=0.01762 c=0
Rk51 (\1\:VSS \5\:VSS) resistor r=0.2205 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.376 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.288 c=0
Rk58 (\8\:VSS VSS) resistor r=0.3471 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.4888 c=0
Rk56 (\6\:VSS \12\:VSS) resistor r=0.1026 c=0
Rk57 (\7\:VSS \14\:VSS) resistor r=0.2029 c=0
Rk60 (\8\:VSS \17\:VSS) resistor r=0.07147 c=0
Rk8 (\12\:COb \13\:COb) resistor r=1.326 c=0
Rk9 (\13\:COb \14\:COb) resistor r=0.2254 c=0
Rk10 (\14\:COb \15\:COb) resistor r=0.8921 c=0
Rk11 (\15\:COb \16\:COb) resistor r=0.1482 c=0
Rk12 (\13\:COb \18\:COb) resistor r=0.07468 c=0
Rk13 (\14\:COb \20\:COb) resistor r=0.07468 c=0
Rk14 (\15\:COb \21\:COb) resistor r=0.9012 c=0
Rk15 (\21\:COb \23\:COb) resistor r=0.115 c=0
Rk16 (\21\:COb \25\:COb) resistor r=0.2821 c=0
Rk5 (\2\:n2 \4\:n2) resistor r=0.2358 c=0
Rk7 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk29 (\9\:Sb \10\:Sb) resistor r=0.0279 c=0
Rk30 (\10\:Sb \11\:Sb) resistor r=0.789 c=0
Rk31 (\11\:Sb \13\:Sb) resistor r=0.6146 c=0
Rk32 (\13\:Sb \15\:Sb) resistor r=0.1664 c=0
Rk33 (\10\:Sb \17\:Sb) resistor r=0.1905 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.2358 c=0
Rk6 (\2\:n5 \4\:n5) resistor r=0.2358 c=0
Rl33 (\10\:A \11\:A) resistor r=162.23 c=0
Rl34 (\11\:A \12\:A) resistor r=100.692 c=0
Rl24 (\8\:A \9\:A) resistor r=132.669 c=0
Rl23 (\7\:A \8\:A) resistor r=84.4104 c=0
Rl18 (\5\:A \6\:A) resistor r=83.9406 c=0
Rl17 (\4\:A \5\:A) resistor r=89.6422 c=0
Rl7 (\1\:A \2\:A) resistor r=58.3841 c=0
Rl8 (\2\:A \3\:A) resistor r=29.5379 c=0
Rl31 (\11\:B \12\:B) resistor r=112.23 c=0
Rl32 (\12\:B \13\:B) resistor r=150.692 c=0
Rl22 (\9\:B \10\:B) resistor r=26.3736 c=0
Rl21 (\8\:B \9\:B) resistor r=151.923 c=0
Rl16 (\6\:B \7\:B) resistor r=24.2328 c=0
Rl15 (\5\:B \6\:B) resistor r=164.183 c=0
Rl11 (\2\:B \4\:B) resistor r=37.3411 c=0
Rl10 (\2\:B \3\:B) resistor r=96.9565 c=0
Rl9 (\1\:B \2\:B) resistor r=0.6084 c=0
Rl20 (\6\:CI \7\:CI) resistor r=149.451 c=0
Rl19 (\5\:CI \6\:CI) resistor r=28.8462 c=0
Rl12 (\1\:CI \2\:CI) resistor r=112.695 c=0
Rl13 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl14 (\2\:CI \4\:CI) resistor r=120.348 c=0
Rl28 (\8\:CI \9\:CI) resistor r=235.905 c=0
Rl30 (\9\:CI \11\:CI) resistor r=49.1216 c=0
Rl29 (\9\:CI \10\:CI) resistor r=10.5855 c=0
Rl5 (COb \6\:COb) resistor r=9.5287 c=0
Rl25 (\9\:COb \8\:COb) resistor r=35.772 c=0
Rl26 (\9\:COb \10\:COb) resistor r=187.695 c=0
Rl27 (\9\:COb \11\:COb) resistor r=97.2715 c=0
Rl36 (\3\:Sb Sb) resistor r=79.8492 c=0
Rl37 (\3\:Sb \4\:Sb) resistor r=4.3693 c=0
Rz1 (\5\:CO \4\:CO) resistor r=75 c=0
Rz10 (\2\:S \1\:S) resistor r=75 c=0
Rz11 (\5\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz12 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Rz15 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz6 (\23\:COb \22\:COb) resistor r=75 c=0
Rz7 (\25\:COb \24\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\13\:Sb \12\:Sb) resistor r=75 c=0
Rz9 (\15\:Sb \14\:Sb) resistor r=75 c=0
Ry1 (\2\:CO \1\:CO) resistor r=20.6667 c=0
Ry10 (\4\:S \3\:S) resistor r=62 c=0
Ry14 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry16 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\5\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry19 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry6 (\18\:COb \17\:COb) resistor r=62 c=0
Ry7 (\20\:COb \19\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \8\:Sb) resistor r=62 c=0
Ry9 (\17\:Sb \16\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\6\:B \17\:B) resistor r=45 c=0
Rx9 (\1\:B \18\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\12\:COb \11\:COb) resistor r=45 c=0
Rx2 (\16\:COb \6\:COb) resistor r=45 c=0
Rx14 (\11\:Sb \4\:Sb) resistor r=45 c=0
mn13_1__rcx (\1\:S \3\:Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.57e-14 ad=4.16e-14 ps=9.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.48558e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
mn12 (\4\:CO COb VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\3\:n2 \3\:A \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.48966e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn3 (n2 \3\:B \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=2.32e-14 ps=1.49e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.86379e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\22\:COb \3\:CI n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.91379e-07 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\24\:COb \5\:B n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn0 (n0 \4\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=8.7e-15 ps=8.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.185e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn7 (\3\:n4 \5\:CI \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=2.32e-14 ps=8.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=8.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn6 (\3\:n4 \8\:B \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.32e-14 ps=1.13e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn5 (n4 \7\:A \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.755e-14 ps=1.13e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=3.75e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn8 (\14\:Sb \10\:COb n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn11 (\12\:Sb \11\:CI n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.3e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.305e-14 \
        ad=8.7e-15 ps=4.7e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.25e-07 sd=160n sca=7.47547 scb=0.00467957 \
        scc=5.27432e-05 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.5e-14 ad=1.305e-14 ps=1.12e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.9e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mp2 (\3\:n3 \1\:A \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=3.01e-14 ps=2.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.37674e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp3 (n3 \4\:B \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=3.44e-14 ps=2.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80349e-07 sb=3.45e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp4 (\19\:COb \1\:CI n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.85349e-07 sb=1.4e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp1 (\17\:COb \7\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18907e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp0 (n1 \6\:A \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.723e-14 ad=1.29e-14 ps=2.11e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.08407e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp7 (\3\:n5 \7\:CI \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.723e-14 ad=3.44e-14 ps=2.11e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=7.3407e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp6 (\3\:n5 \10\:B \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=5.2907e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp5 (n5 \9\:A \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=7.202e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.24419e-07 sb=5.2e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp8 (\16\:Sb \8\:COb n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.202e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10442e-06 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp11 (\8\:Sb \8\:CI n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.3e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.935e-14 \
        ad=1.29e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.25e-07 sd=160n sca=10.46 scb=0.0077219 \
        scc=9.29465e-05 m=(1)
mp9 (n8 \10\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.2e-14 ad=1.935e-14 ps=1.38e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.9e-07 sd=160n sca=10.848 scb=0.0078767 \
        scc=9.30025e-05 m=(1)
ends ADDFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:00 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFX4
// View name: extracted

simulator lang=spectre

subckt ADDFX4 A B CI CO S VDD VSS
mp2 (n3 \1\:A \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.70769e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp3 (\3\:n3 \1\:B \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=6.24e-14 ps=1.9e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.86923e-07 sb=3.45e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp4 (\24\:COb \1\:CI \3\:n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.91923e-07 sb=1.4e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp1 (\18\:COb \7\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.20192e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp0 (n1 \6\:A \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=2.34e-14 ps=1.8e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.09692e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp7 (\3\:n5 \5\:CI \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.31923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp6 (\3\:n5 \11\:B \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.26923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp5 (n5 \7\:A \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.61923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp8 (\24\:Sb \13\:COb n5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.12e-14 ps=1.1e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.56923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp11 (\22\:Sb \12\:CI n9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=1.01e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.295e-06 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.485e-14 ps=9.6e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.135e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp9 (n8 \10\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=3.51e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp13_1__rcx (\6\:S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=7.55e-07 sd=160n sca=14.4678 \
        scb=0.0130219 scc=0.000814276 m=(4)
mp12_1__rcx (\1\:CO COb \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=37.1131 scb=0.03221 \
        scc=0.00363789 m=(4)
C1 (A VSS) capacitor c=1.06394e-16
C2 (CO VSS) capacitor c=1.34744e-17
C3 (S VSS) capacitor c=1.52666e-17
C4 (VDD VSS) capacitor c=2.6745e-16
C5 (B VSS) capacitor c=6.85253e-17
C6 (CI VSS) capacitor c=8.8949e-17
C7 (COb VSS) capacitor c=2.93584e-16
C8 (n2 VSS) capacitor c=8.94103e-17
C9 (n0 VSS) capacitor c=1.23995e-18
C10 (n4 VSS) capacitor c=8.08485e-17
C11 (Sb VSS) capacitor c=3.0296e-16
C12 (n7 VSS) capacitor c=1.61961e-18
C13 (n6 VSS) capacitor c=3.29036e-18
C14 (n3 VSS) capacitor c=6.39087e-17
C15 (n1 VSS) capacitor c=2.07034e-18
C16 (n5 VSS) capacitor c=8.06683e-17
C17 (n9 VSS) capacitor c=3.59321e-18
C18 (n8 VSS) capacitor c=3.22966e-18
C19 (\10\:A VSS) capacitor c=7.09646e-17
C20 (\12\:B VSS) capacitor c=7.08189e-17
C21 (\12\:CI VSS) capacitor c=7.6403e-17
C22 (\13\:COb VSS) capacitor c=3.57281e-17
C23 (\7\:A VSS) capacitor c=7.20271e-17
C24 (\11\:B VSS) capacitor c=5.50043e-17
C25 (\5\:CI VSS) capacitor c=7.21388e-17
C26 (\6\:A VSS) capacitor c=8.98701e-17
C27 (\7\:B VSS) capacitor c=7.18386e-17
C28 (\1\:CI VSS) capacitor c=5.43441e-17
C29 (\1\:B VSS) capacitor c=5.74577e-17
C30 (\1\:A VSS) capacitor c=6.01259e-17
C31 (\12\:A VSS) capacitor c=4.87399e-17
C32 (\14\:B VSS) capacitor c=9.41098e-17
C33 (\9\:CI VSS) capacitor c=6.0005e-17
C34 (\15\:COb VSS) capacitor c=6.03615e-17
C35 (\9\:A VSS) capacitor c=5.0202e-17
C36 (\10\:B VSS) capacitor c=6.05021e-17
C37 (\8\:CI VSS) capacitor c=3.82892e-17
C38 (\4\:A VSS) capacitor c=7.92377e-17
C39 (\4\:B VSS) capacitor c=8.94527e-17
C40 (\3\:CI VSS) capacitor c=3.31129e-17
C41 (\3\:B VSS) capacitor c=5.42085e-17
C42 (\3\:A VSS) capacitor c=4.10396e-17
C43 (\11\:A VSS) capacitor c=4.21019e-17
C44 (\13\:B VSS) capacitor c=5.9095e-17
C45 (\11\:CI VSS) capacitor c=3.38895e-17
C46 (\16\:COb VSS) capacitor c=3.40075e-17
C47 (\8\:A VSS) capacitor c=5.20734e-17
C48 (\8\:B VSS) capacitor c=2.98917e-17
C49 (\7\:CI VSS) capacitor c=5.28386e-17
C50 (\5\:A VSS) capacitor c=6.24656e-17
C51 (\6\:B VSS) capacitor c=1.63981e-17
C52 (\4\:CI VSS) capacitor c=4.10263e-17
C53 (\2\:B VSS) capacitor c=3.67442e-17
C54 (\2\:A VSS) capacitor c=2.62767e-17
C55 (\1\:VDD VSS) capacitor c=1.76775e-16
C56 (\22\:Sb VSS) capacitor c=7.46846e-17
C57 (\24\:Sb VSS) capacitor c=6.06525e-17
C58 (\19\:VDD VSS) capacitor c=1.73964e-17
C59 (\3\:n5 VSS) capacitor c=9.4874e-17
C60 (\21\:VDD VSS) capacitor c=1.56286e-17
C61 (\18\:COb VSS) capacitor c=1.25427e-16
C62 (\24\:COb VSS) capacitor c=3.43465e-17
C63 (\3\:n3 VSS) capacitor c=8.35584e-17
C64 (\23\:VDD VSS) capacitor c=1.64207e-17
C65 (\1\:CO VSS) capacitor c=1.94229e-16
C66 (\3\:VDD VSS) capacitor c=5.19165e-17
C67 (\2\:S VSS) capacitor c=1.12127e-16
C68 (\18\:Sb VSS) capacitor c=9.84188e-17
C69 (\20\:Sb VSS) capacitor c=5.8947e-17
C70 (\3\:n4 VSS) capacitor c=7.8415e-17
C71 (\27\:COb VSS) capacitor c=6.1148e-17
C72 (\29\:COb VSS) capacitor c=1.56147e-17
C73 (\3\:n2 VSS) capacitor c=7.77248e-17
C74 (\6\:CO VSS) capacitor c=1.04064e-16
C75 (\2\:CI VSS) capacitor c=3.43984e-17
C76 (\5\:B VSS) capacitor c=3.5978e-17
C77 (\9\:B VSS) capacitor c=2.74209e-17
C78 (\14\:COb VSS) capacitor c=3.50887e-17
C79 (\10\:CI VSS) capacitor c=4.79924e-17
C80 (\17\:COb VSS) capacitor c=1.74083e-16
C81 (\20\:COb VSS) capacitor c=1.02038e-16
C82 (\21\:COb VSS) capacitor c=1.89139e-16
C83 (\26\:COb VSS) capacitor c=1.51242e-16
C84 (\13\:CI VSS) capacitor c=1.50163e-16
C85 (\14\:CI VSS) capacitor c=1.86663e-16
C86 (\15\:B VSS) capacitor c=1.27692e-16
C87 (\16\:B VSS) capacitor c=2.07754e-16
C88 (\17\:B VSS) capacitor c=7.49019e-17
C89 (\18\:B VSS) capacitor c=7.70813e-17
C90 (\13\:A VSS) capacitor c=3.78398e-17
C91 (\14\:A VSS) capacitor c=1.83155e-16
C92 (\15\:A VSS) capacitor c=2.16499e-16
C93 (\16\:A VSS) capacitor c=1.38447e-16
C94 (\17\:Sb VSS) capacitor c=1.49807e-16
C95 (\1\:S VSS) capacitor c=2.98876e-17
C96 (\6\:S VSS) capacitor c=1.94739e-16
C97 (\8\:VDD VSS) capacitor c=1.26916e-17
C98 (\9\:VDD VSS) capacitor c=3.1028e-17
C99 (\10\:VDD VSS) capacitor c=2.7261e-17
C100 (\12\:VDD VSS) capacitor c=1.50598e-16
Rk27 (\13\:A A) resistor r=0.08561 c=0
Rk28 (A \14\:A) resistor r=0.7093 c=0
Rk29 (\14\:A \15\:A) resistor r=0.6289 c=0
Rk30 (\15\:A \16\:A) resistor r=0.9088 c=0
Rk46 (\1\:VSS \7\:VSS) resistor r=0.4512 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.1929 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.2053 c=0
Rk49 (\9\:VSS \10\:VSS) resistor r=0.5704 c=0
Rk50 (\10\:VSS \11\:VSS) resistor r=0.2321 c=0
Rk54 (\12\:VSS VSS) resistor r=0.03215 c=0
Rk51 (\11\:VSS \12\:VSS) resistor r=0.1026 c=0
Rk57 (\8\:VSS \20\:VSS) resistor r=0.1026 c=0
Rk58 (\9\:VSS \22\:VSS) resistor r=0.1742 c=0
Rk59 (\10\:VSS \24\:VSS) resistor r=0.04331 c=0
Rk2 (\1\:CO CO) resistor r=0.242 c=0
Rk4 (CO \6\:CO) resistor r=0.05252 c=0
Rk37 (S \1\:S) resistor r=0.007742 c=0
Rk38 (\1\:S \2\:S) resistor r=0.1493 c=0
Rk40 (\1\:S \6\:S) resistor r=0.324 c=0
Rk66 (\1\:VDD \7\:VDD) resistor r=0.4512 c=0
Rk67 (\7\:VDD \8\:VDD) resistor r=0.1769 c=0
Rk68 (\8\:VDD \9\:VDD) resistor r=0.2334 c=0
Rk69 (\9\:VDD \10\:VDD) resistor r=0.5554 c=0
Rk70 (\10\:VDD \11\:VDD) resistor r=0.233 c=0
Rk74 (\12\:VDD VDD) resistor r=0.03215 c=0
Rk71 (\11\:VDD \12\:VDD) resistor r=0.1177 c=0
Rk77 (\8\:VDD \20\:VDD) resistor r=0.04331 c=0
Rk78 (\9\:VDD \22\:VDD) resistor r=0.04331 c=0
Rk79 (\10\:VDD \24\:VDD) resistor r=0.07393 c=0
Rk24 (\16\:B B) resistor r=0.6363 c=0
Rk23 (\15\:B \16\:B) resistor r=0.814 c=0
Rk25 (B \17\:B) resistor r=0.06383 c=0
Rk26 (\17\:B \18\:B) resistor r=0.534 c=0
Rk20 (\14\:CI CI) resistor r=0.4248 c=0
Rk19 (\13\:CI \14\:CI) resistor r=0.8934 c=0
Rk21 (CI \15\:CI) resistor r=0.003053 c=0
Rk22 (\14\:CI \16\:CI) resistor r=0.04261 c=0
Rk10 (\17\:COb \19\:COb) resistor r=1.1276 c=0
Rk11 (\19\:COb \20\:COb) resistor r=0.2594 c=0
Rk13 (\21\:COb COb) resistor r=0.3988 c=0
Rk12 (\20\:COb \21\:COb) resistor r=0.8996 c=0
Rk15 (\20\:COb \25\:COb) resistor r=0.04927 c=0
Rk16 (\21\:COb \26\:COb) resistor r=0.949 c=0
Rk17 (\26\:COb \28\:COb) resistor r=0.3306 c=0
Rk18 (\26\:COb \30\:COb) resistor r=0.05759 c=0
Rk7 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk9 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk32 (Sb \17\:Sb) resistor r=0.1901 c=0
Rk33 (\17\:Sb \19\:Sb) resistor r=0.593 c=0
Rk34 (\19\:Sb \21\:Sb) resistor r=0.2807 c=0
Rk35 (\17\:Sb \23\:Sb) resistor r=0.7415 c=0
Rk36 (\23\:Sb \25\:Sb) resistor r=0.2136 c=0
Rk6 (\2\:n3 \4\:n3) resistor r=0.2734 c=0
Rk8 (\2\:n5 \4\:n5) resistor r=0.2822 c=0
Rl39 (\10\:A \11\:A) resistor r=108.384 c=0
Rl40 (\11\:A \12\:A) resistor r=44.9225 c=0
Rl29 (\7\:A \8\:A) resistor r=85.7713 c=0
Rl30 (\8\:A \9\:A) resistor r=62.6944 c=0
Rl22 (\5\:A \6\:A) resistor r=62.8119 c=0
Rl21 (\4\:A \5\:A) resistor r=82.2239 c=0
Rl11 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl12 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl37 (\12\:B \13\:B) resistor r=44.9225 c=0
Rl38 (\13\:B \14\:B) resistor r=108.384 c=0
Rl13 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl14 (\2\:B \3\:B) resistor r=75.6918 c=0
Rl20 (\5\:B \7\:B) resistor r=45.0334 c=0
Rl18 (\4\:B \5\:B) resistor r=127.291 c=0
Rl19 (\5\:B \6\:B) resistor r=3.1183 c=0
Rl28 (\9\:B \11\:B) resistor r=34.3295 c=0
Rl27 (\9\:B \10\:B) resistor r=134.329 c=0
Rl26 (\8\:B \9\:B) resistor r=11.5001 c=0
Rl15 (\1\:CI \2\:CI) resistor r=99.2335 c=0
Rl16 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl17 (\2\:CI \4\:CI) resistor r=132.351 c=0
Rl23 (\5\:CI \6\:CI) resistor r=134.329 c=0
Rl25 (\6\:CI \8\:CI) resistor r=34.3295 c=0
Rl24 (\6\:CI \7\:CI) resistor r=0.5166 c=0
Rl36 (\10\:CI \12\:CI) resistor r=134.297 c=0
Rl34 (\9\:CI \10\:CI) resistor r=48.0548 c=0
Rl35 (\10\:CI \11\:CI) resistor r=68.4415 c=0
Rl31 (\14\:COb \13\:COb) resistor r=28.0797 c=0
Rl32 (\14\:COb \15\:COb) resistor r=145.387 c=0
Rl33 (\14\:COb \16\:COb) resistor r=99.1945 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz22 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz23 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\28\:COb \27\:COb) resistor r=75 c=0
Rz8 (\30\:COb \29\:COb) resistor r=75 c=0
Rz3 (n2 \2\:n2) resistor r=75 c=0
Rz4 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz9 (\19\:Sb \18\:Sb) resistor r=75 c=0
Rz10 (\21\:Sb \20\:Sb) resistor r=75 c=0
Ry13 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry14 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=62 c=0
Ry8 (\25\:COb \24\:COb) resistor r=20.6667 c=0
Ry9 (\23\:Sb \22\:Sb) resistor r=62 c=0
Ry10 (\25\:Sb \24\:Sb) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n5 \2\:n5) resistor r=62 c=0
Ry6 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx11 (\11\:A \13\:A) resistor r=45 c=0
Rx12 (\8\:A \14\:A) resistor r=45 c=0
Rx13 (\5\:A \15\:A) resistor r=45 c=0
Rx14 (\2\:A \16\:A) resistor r=45 c=0
Rx7 (\13\:B \15\:B) resistor r=45 c=0
Rx8 (\8\:B \16\:B) resistor r=45 c=0
Rx9 (\6\:B \17\:B) resistor r=45 c=0
Rx10 (\2\:B \18\:B) resistor r=45 c=0
Rx4 (\11\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \15\:CI) resistor r=45 c=0
Rx6 (\7\:CI \16\:CI) resistor r=45 c=0
Rx1 (\17\:COb \16\:COb) resistor r=45 c=0
mn2 (\3\:n2 \3\:A \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.64e-14 ps=1.46e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn3 (n2 \3\:B \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=4.16e-14 ps=1.46e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn4 (\29\:COb \3\:CI n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn1 (\27\:COb \4\:B n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.14e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (n0 \4\:A \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.035e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn7 (\3\:n4 \8\:CI \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn6 (\3\:n4 \10\:B \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.25e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (n4 \9\:A \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn8 (\20\:Sb \15\:COb n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn11 (\18\:Sb \9\:CI n7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.22e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23846e-07 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (n7 \14\:B n6 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.56e-14 ps=7e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28846e-07 sb=1.145e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.34e-14 ps=9.2e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.63846e-07 sb=1.01e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn13_1__rcx (\2\:S Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.08846e-07 sb=7.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn12_1__rcx (\6\:CO COb \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
ends ADDFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:01 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDFXL
// View name: extracted

simulator lang=spectre

subckt ADDFXL A B CI CO S VDD VSS
mp12 (\1\:CO COb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.3093 \
        scb=0.0404867 scc=0.00500078 m=(1)
mp2 (\3\:n3 \1\:A \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.27442e-07 sd=160n sca=46.0095 \
        scb=0.0283849 scc=0.00588417 m=(1)
mp3 (n3 \1\:B \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.74884e-07 sb=3.45e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp4 (\11\:COb \1\:CI n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.79884e-07 sb=1.4e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp1 (\8\:COb \4\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.0407e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp0 (n1 \6\:A \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.9907e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp7 (\3\:n5 \7\:CI \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=3.44e-14 ps=1.82e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.22093e-07 sb=4.61047e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp6 (\3\:n5 \10\:B \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.322e-14 ad=3.44e-14 ps=2.14e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.27093e-07 sb=2.56047e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp5 (n5 \9\:A \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.322e-14 ad=4.407e-14 ps=2.14e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98256e-07 sb=4.9e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=5.16e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.48256e-07 sb=2.4e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=12.7748 scb=0.011453 \
        scc=0.000391592 m=(1)
mp10 (n9 \13\:B n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.332e-14 \
        ad=1.29e-14 ps=7.4e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.65e-07 sd=160n sca=13.1199 scb=0.0116197 \
        scc=0.000391676 m=(1)
mp9 (n8 \12\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.87e-14 ad=3.332e-14 ps=1.06e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=4.65e-07 sd=160n sca=14.3514 \
        scb=0.0128708 scc=0.000395547 m=(1)
mp13 (\1\:S Sb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.87e-14 ad=4.3e-14 ps=1.06e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=2e-07 sd=160n sca=20.6331 scb=0.0233447 \
        scc=0.000832054 m=(1)
C1 (CO VSS) capacitor c=5.92304e-17
C2 (A VSS) capacitor c=1.15492e-16
C3 (VDD VSS) capacitor c=2.64157e-16
C4 (B VSS) capacitor c=3.18855e-17
C5 (CI VSS) capacitor c=4.20199e-17
C6 (S VSS) capacitor c=5.75903e-17
C7 (COb VSS) capacitor c=2.51109e-17
C8 (n2 VSS) capacitor c=7.51999e-17
C9 (n4 VSS) capacitor c=8.15732e-17
C10 (Sb VSS) capacitor c=5.08651e-17
C11 (n7 VSS) capacitor c=1.88509e-18
C12 (n6 VSS) capacitor c=3.44312e-18
C13 (n3 VSS) capacitor c=7.22101e-17
C14 (n5 VSS) capacitor c=7.12991e-17
C15 (n9 VSS) capacitor c=2.0997e-18
C16 (n8 VSS) capacitor c=4.98975e-18
C17 (\12\:A VSS) capacitor c=3.87564e-17
C18 (\13\:B VSS) capacitor c=6.57695e-17
C19 (\11\:CI VSS) capacitor c=8.73568e-17
C20 (\6\:COb VSS) capacitor c=2.85908e-17
C21 (\9\:A VSS) capacitor c=6.23304e-17
C22 (\10\:B VSS) capacitor c=4.50597e-17
C23 (\7\:CI VSS) capacitor c=7.99434e-17
C24 (\6\:A VSS) capacitor c=8.63581e-17
C25 (\4\:B VSS) capacitor c=5.89493e-17
C26 (\1\:CI VSS) capacitor c=5.00394e-17
C27 (\1\:B VSS) capacitor c=4.34131e-17
C28 (\1\:A VSS) capacitor c=4.97674e-17
C29 (\3\:Sb VSS) capacitor c=2.97086e-17
C30 (\10\:A VSS) capacitor c=6.23267e-17
C31 (\11\:B VSS) capacitor c=7.63858e-17
C32 (\8\:CI VSS) capacitor c=5.07301e-17
C33 (\4\:COb VSS) capacitor c=6.44171e-17
C34 (\7\:A VSS) capacitor c=4.34836e-17
C35 (\7\:B VSS) capacitor c=5.66274e-17
C36 (\5\:CI VSS) capacitor c=3.42303e-17
C37 (\4\:A VSS) capacitor c=5.033e-17
C38 (\6\:B VSS) capacitor c=6.38832e-17
C39 (\3\:CI VSS) capacitor c=2.73473e-17
C40 (\3\:B VSS) capacitor c=5.45484e-17
C41 (\3\:A VSS) capacitor c=3.95715e-17
C42 (\3\:COb VSS) capacitor c=2.88839e-17
C43 (\2\:Sb VSS) capacitor c=4.13492e-17
C44 (\11\:A VSS) capacitor c=5.47823e-17
C45 (\12\:B VSS) capacitor c=7.91415e-17
C46 (\10\:CI VSS) capacitor c=7.3038e-17
C47 (\5\:COb VSS) capacitor c=5.86968e-17
C48 (\8\:A VSS) capacitor c=7.30792e-17
C49 (\9\:B VSS) capacitor c=2.74972e-17
C50 (\6\:CI VSS) capacitor c=5.89715e-17
C51 (\5\:A VSS) capacitor c=8.7176e-17
C52 (\5\:B VSS) capacitor c=7.27836e-17
C53 (\4\:CI VSS) capacitor c=4.97025e-17
C54 (\2\:B VSS) capacitor c=4.09472e-17
C55 (\2\:A VSS) capacitor c=2.81591e-17
C56 (\2\:COb VSS) capacitor c=2.60978e-17
C57 (\1\:S VSS) capacitor c=3.64496e-17
C58 (\1\:VDD VSS) capacitor c=3.96127e-17
C59 (\9\:Sb VSS) capacitor c=8.44494e-17
C60 (\11\:Sb VSS) capacitor c=3.67612e-17
C61 (\10\:VDD VSS) capacitor c=1.8728e-17
C62 (\3\:n5 VSS) capacitor c=7.52154e-17
C63 (\12\:VDD VSS) capacitor c=1.28115e-17
C64 (\8\:COb VSS) capacitor c=1.40367e-16
C65 (\11\:COb VSS) capacitor c=2.03762e-17
C66 (\14\:VDD VSS) capacitor c=9.91072e-18
C67 (\3\:n3 VSS) capacitor c=6.60625e-17
C68 (\1\:CO VSS) capacitor c=4.3977e-17
C69 (\16\:VDD VSS) capacitor c=3.06328e-17
C70 (\3\:VDD VSS) capacitor c=5.81461e-17
C71 (\3\:S VSS) capacitor c=2.60826e-17
C72 (\4\:Sb VSS) capacitor c=7.29068e-17
C73 (\7\:Sb VSS) capacitor c=3.81106e-17
C74 (\3\:n4 VSS) capacitor c=7.86417e-17
C75 (\18\:COb VSS) capacitor c=4.3181e-17
C76 (\15\:COb VSS) capacitor c=4.2072e-17
C77 (\3\:n2 VSS) capacitor c=7.14556e-17
C78 (\3\:CO VSS) capacitor c=8.5862e-17
C79 (\2\:CI VSS) capacitor c=3.06318e-17
C80 (\8\:B VSS) capacitor c=4.64474e-17
C81 (\7\:COb VSS) capacitor c=1.49516e-16
C82 (\10\:COb VSS) capacitor c=1.07987e-16
C83 (\13\:COb VSS) capacitor c=1.76965e-16
C84 (\14\:COb VSS) capacitor c=1.15276e-16
C85 (\17\:COb VSS) capacitor c=4.72469e-17
C86 (\12\:CI VSS) capacitor c=1.35547e-16
C87 (\13\:CI VSS) capacitor c=1.59429e-16
C88 (\14\:CI VSS) capacitor c=5.27051e-17
C89 (\14\:B VSS) capacitor c=1.29555e-16
C90 (\15\:B VSS) capacitor c=1.56784e-16
C91 (\16\:B VSS) capacitor c=7.95157e-17
C92 (\17\:B VSS) capacitor c=7.06063e-17
C93 (\13\:A VSS) capacitor c=2.11529e-16
C94 (\14\:A VSS) capacitor c=1.62071e-16
C95 (\15\:A VSS) capacitor c=1.26854e-16
C96 (\16\:A VSS) capacitor c=2.48829e-17
C97 (\6\:Sb VSS) capacitor c=1.53234e-16
C98 (\5\:VDD VSS) capacitor c=2.67076e-17
C99 (\6\:VDD VSS) capacitor c=2.07534e-17
C100 (\8\:VDD VSS) capacitor c=1.58187e-17
C101 (\9\:VDD VSS) capacitor c=5.9958e-18
Rk1 (\2\:CO CO) resistor r=0.2529 c=0
Rk2 (CO \4\:CO) resistor r=0.52 c=0
Rk22 (A \13\:A) resistor r=0.8877 c=0
Rk23 (\13\:A \14\:A) resistor r=0.578 c=0
Rk24 (\14\:A \15\:A) resistor r=0.7117 c=0
Rk25 (A \16\:A) resistor r=0.05411 c=0
Rk42 (\2\:VDD \4\:VDD) resistor r=0.4341 c=0
Rk43 (\4\:VDD \5\:VDD) resistor r=0.5382 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.109 c=0
Rk45 (\6\:VDD \7\:VDD) resistor r=0.3535 c=0
Rk46 (\7\:VDD \8\:VDD) resistor r=0.1378 c=0
Rk48 (\9\:VDD VDD) resistor r=0.01962 c=0
Rk47 (\8\:VDD \9\:VDD) resistor r=0.3935 c=0
Rk49 (\5\:VDD \11\:VDD) resistor r=0.04333 c=0
Rk50 (\6\:VDD \13\:VDD) resistor r=0.08012 c=0
Rk51 (\8\:VDD \15\:VDD) resistor r=0.07416 c=0
Rk52 (\9\:VDD \17\:VDD) resistor r=0.4025 c=0
Rk18 (\14\:B \15\:B) resistor r=0.8953 c=0
Rk21 (\16\:B B) resistor r=0.05733 c=0
Rk19 (\15\:B \16\:B) resistor r=0.3853 c=0
Rk20 (\16\:B \17\:B) resistor r=0.4344 c=0
Rk16 (\13\:CI CI) resistor r=0.2408 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8824 c=0
Rk17 (CI \14\:CI) resistor r=0.08714 c=0
Rk30 (\2\:S S) resistor r=0.3444 c=0
Rk31 (S \4\:S) resistor r=0.2115 c=0
Rk32 (\2\:VSS \4\:VSS) resistor r=0.4153 c=0
Rk33 (\4\:VSS \5\:VSS) resistor r=0.4188 c=0
Rk34 (\5\:VSS \6\:VSS) resistor r=0.2078 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.3761 c=0
Rk37 (\8\:VSS VSS) resistor r=0.448 c=0
Rk36 (\7\:VSS \8\:VSS) resistor r=0.1017 c=0
Rk38 (VSS \10\:VSS) resistor r=0.2036 c=0
Rk39 (\5\:VSS \12\:VSS) resistor r=0.1029 c=0
Rk40 (\6\:VSS \14\:VSS) resistor r=0.1851 c=0
Rk41 (\8\:VSS \16\:VSS) resistor r=0.04333 c=0
Rk7 (\7\:COb \9\:COb) resistor r=1.1789 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.1499 c=0
Rk9 (\10\:COb \12\:COb) resistor r=0.05483 c=0
Rk10 (\10\:COb \13\:COb) resistor r=0.9636 c=0
Rk11 (\13\:COb \14\:COb) resistor r=0.8694 c=0
Rk12 (\14\:COb \16\:COb) resistor r=0.1125 c=0
Rk13 (\13\:COb \17\:COb) resistor r=0.1933 c=0
Rk14 (\14\:COb \19\:COb) resistor r=0.1501 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.2374 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2862 c=0
Rk26 (\5\:Sb \6\:Sb) resistor r=0.5258 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.201 c=0
Rk28 (\6\:Sb \10\:Sb) resistor r=0.9101 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1293 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.2405 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2806 c=0
Rl29 (\11\:A \12\:A) resistor r=39.5604 c=0
Rl28 (\10\:A \11\:A) resistor r=192.308 c=0
Rl20 (\8\:A \9\:A) resistor r=161.516 c=0
Rl19 (\7\:A \8\:A) resistor r=97.872 c=0
Rl13 (\5\:A \6\:A) resistor r=141.758 c=0
Rl12 (\4\:A \5\:A) resistor r=103.846 c=0
Rl3 (\1\:A \2\:A) resistor r=64.1533 c=0
Rl4 (\2\:A \3\:A) resistor r=29.5379 c=0
Rl27 (\12\:B \13\:B) resistor r=76.3736 c=0
Rl26 (\11\:B \12\:B) resistor r=155.769 c=0
Rl10 (\4\:B \5\:B) resistor r=69.9225 c=0
Rl11 (\5\:B \6\:B) resistor r=173.769 c=0
Rl5 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=92.9995 c=0
Rl18 (\8\:B \10\:B) resistor r=23.7402 c=0
Rl16 (\7\:B \8\:B) resistor r=188.77 c=0
Rl17 (\8\:B \9\:B) resistor r=5.8511 c=0
Rl15 (\6\:CI \7\:CI) resistor r=149.451 c=0
Rl14 (\5\:CI \6\:CI) resistor r=42.3077 c=0
Rl7 (\1\:CI \2\:CI) resistor r=116.541 c=0
Rl8 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl9 (\2\:CI \4\:CI) resistor r=118.425 c=0
Rl25 (\9\:CI \11\:CI) resistor r=199.313 c=0
Rl23 (\8\:CI \9\:CI) resistor r=56.0256 c=0
Rl24 (\9\:CI \10\:CI) resistor r=8.1539 c=0
Rl22 (\5\:COb \6\:COb) resistor r=24.2328 c=0
Rl21 (\4\:COb \5\:COb) resistor r=257.246 c=0
Rl1 (COb \2\:COb) resistor r=73.7687 c=0
Rl2 (\2\:COb \3\:COb) resistor r=100.692 c=0
Rl30 (Sb \2\:Sb) resistor r=191.076 c=0
Rl31 (\2\:Sb \3\:Sb) resistor r=39.1533 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz16 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz17 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz10 (\3\:S \4\:S) resistor r=75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz15 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz6 (\15\:COb \16\:COb) resistor r=75 c=0
Rz7 (\18\:COb \19\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\7\:Sb \8\:Sb) resistor r=75 c=0
Ry1 (\1\:CO \2\:CO) resistor r=62 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry14 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry15 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry10 (\1\:S \2\:S) resistor r=62 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry12 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry6 (\8\:COb \9\:COb) resistor r=62 c=0
Ry7 (\11\:COb \12\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\8\:A \13\:A) resistor r=45 c=0
Rx11 (\5\:A \14\:A) resistor r=45 c=0
Rx12 (\2\:A \15\:A) resistor r=45 c=0
Rx13 (\11\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\5\:B \16\:B) resistor r=45 c=0
Rx9 (\2\:B \17\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\5\:COb \7\:COb) resistor r=45 c=0
Rx2 (\2\:COb \17\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.393e-14 ps=6.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\3\:n2 \3\:A \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.7931e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn3 (n2 \3\:B \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=2.32e-14 ps=1.46e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.02586e-07 sb=3.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn4 (\15\:COb \3\:CI n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.07586e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn1 (\18\:COb \6\:B n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \4\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.957e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=1.05e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \5\:CI \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=8.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \7\:B \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.392e-14 ps=1.06e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=6.35e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.682e-14 ps=1.06e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.7e-07 sd=160n sca=6.83173 scb=0.00357784 \
        scc=2.82929e-05 m=(1)
mn8 (\7\:Sb \4\:COb n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.4e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.95e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn10 (n7 \11\:B n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=8.7e-15 ps=5.6e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.9e-07 sd=160n sca=7.27658 scb=0.00433573 \
        scc=4.41722e-05 m=(1)
mn9 (n6 \10\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=1.958e-14 ps=6.2e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=4.1e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn13 (\3\:S \3\:Sb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.9e-14 ps=6.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
ends ADDFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:02 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDHX1
// View name: extracted

simulator lang=spectre

subckt ADDHX1 A B CO S VDD VSS
mp8 (\3\:CO \4\:COb \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=5.46e-14 ps=1.83e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.20513e-07 sd=160n sca=35.0084 \
        scb=0.0365133 scc=0.00352722 m=(1)
mp5 (\1\:S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.69103e-07 sb=1.4e-07 sd=160n sca=42.1543 \
        scb=0.0369591 scc=0.00437643 m=(1)
C1 (CO VSS) capacitor c=5.30398e-17
C2 (A VSS) capacitor c=5.13276e-17
C3 (VDD VSS) capacitor c=1.69882e-16
C4 (S VSS) capacitor c=3.98185e-17
C5 (B VSS) capacitor c=9.02611e-17
C6 (COb VSS) capacitor c=2.49001e-17
C7 (n4 VSS) capacitor c=1.28943e-18
C8 (n1 VSS) capacitor c=2.9067e-17
C9 (n0 VSS) capacitor c=9.36118e-17
C10 (Sb VSS) capacitor c=5.14355e-17
C11 (\3\:n1 VSS) capacitor c=5.9932e-17
C12 (\2\:B VSS) capacitor c=1.05988e-16
C13 (\4\:A VSS) capacitor c=5.09175e-17
C14 (\3\:B VSS) capacitor c=5.44924e-17
C15 (\8\:B VSS) capacitor c=2.97321e-17
C16 (\3\:A VSS) capacitor c=6.36827e-17
C17 (\4\:COb VSS) capacitor c=4.69258e-17
C18 (\3\:Sb VSS) capacitor c=4.02665e-17
C19 (\2\:n0 VSS) capacitor c=7.91487e-17
C20 (\1\:B VSS) capacitor c=1.03229e-16
C21 (\6\:A VSS) capacitor c=2.69589e-17
C22 (\7\:B VSS) capacitor c=2.80522e-17
C23 (\6\:B VSS) capacitor c=4.3536e-17
C24 (\1\:A VSS) capacitor c=3.99344e-17
C25 (\3\:COb VSS) capacitor c=5.09606e-17
C26 (\2\:Sb VSS) capacitor c=2.64741e-17
C27 (\3\:n0 VSS) capacitor c=3.72292e-17
C28 (\4\:n1 VSS) capacitor c=3.60883e-17
C29 (\2\:n1 VSS) capacitor c=4.37483e-17
C30 (\5\:A VSS) capacitor c=4.15101e-17
C31 (\5\:B VSS) capacitor c=5.34422e-17
C32 (\2\:A VSS) capacitor c=8.1875e-17
C33 (\1\:S VSS) capacitor c=3.16791e-17
C34 (\1\:VDD VSS) capacitor c=7.02594e-17
C35 (\8\:Sb VSS) capacitor c=6.48562e-17
C36 (\7\:n0 VSS) capacitor c=1.1182e-16
C37 (\5\:VDD VSS) capacitor c=7.28005e-17
C38 (\11\:n1 VSS) capacitor c=2.09575e-17
C39 (\8\:VDD VSS) capacitor c=1.17674e-17
C40 (\9\:COb VSS) capacitor c=2.19204e-17
C41 (\11\:VDD VSS) capacitor c=6.2452e-18
C42 (\3\:CO VSS) capacitor c=3.32149e-17
C43 (\3\:S VSS) capacitor c=3.58838e-17
C44 (\6\:Sb VSS) capacitor c=2.8983e-17
C45 (\5\:n0 VSS) capacitor c=1.46545e-16
C46 (\8\:n1 VSS) capacitor c=6.91697e-17
C47 (\5\:COb VSS) capacitor c=1.20806e-16
C48 (\1\:CO VSS) capacitor c=6.51832e-17
C49 (\2\:COb VSS) capacitor c=2.39798e-17
C50 (\4\:B VSS) capacitor c=3.00612e-17
C51 (\7\:COb VSS) capacitor c=1.1623e-16
C52 (\8\:COb VSS) capacitor c=7.54687e-17
C53 (\7\:A VSS) capacitor c=1.59066e-16
C54 (\8\:A VSS) capacitor c=1.4294e-16
C55 (\5\:n1 VSS) capacitor c=3.14433e-17
C56 (\6\:n1 VSS) capacitor c=1.44134e-16
C57 (\7\:n1 VSS) capacitor c=1.34096e-16
C58 (\10\:n1 VSS) capacitor c=1.30838e-16
C59 (\4\:n0 VSS) capacitor c=6.66217e-17
C60 (\4\:Sb VSS) capacitor c=4.54239e-17
C61 (\5\:Sb VSS) capacitor c=6.57713e-17
C62 (\4\:VDD VSS) capacitor c=5.42857e-17
C63 (\7\:VDD VSS) capacitor c=1.12195e-17
C64 (\10\:VDD VSS) capacitor c=9.51296e-18
Rk28 (\2\:VSS \4\:VSS) resistor r=0.7803 c=0
Rk29 (\4\:VSS \5\:VSS) resistor r=0.04 c=0
Rk31 (\6\:VSS VSS) resistor r=0.1016 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.3579 c=0
Rk32 (\5\:VSS \8\:VSS) resistor r=0.129 c=0
Rk33 (\6\:VSS \10\:VSS) resistor r=0.2133 c=0
Rk1 (\2\:CO CO) resistor r=0.4599 c=0
Rk2 (CO \4\:CO) resistor r=0.0513 c=0
Rk8 (\8\:A A) resistor r=0.06006 c=0
Rk7 (\7\:A \8\:A) resistor r=1.1293 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.7418 c=0
Rk22 (\4\:VDD \6\:VDD) resistor r=0.431 c=0
Rk23 (\4\:VDD \7\:VDD) resistor r=0.1838 c=0
Rk24 (\7\:VDD \9\:VDD) resistor r=0.129 c=0
Rk27 (\10\:VDD VDD) resistor r=0.08246 c=0
Rk25 (\7\:VDD \10\:VDD) resistor r=0.2358 c=0
Rk26 (\10\:VDD \12\:VDD) resistor r=0.0884 c=0
Rk19 (\2\:S S) resistor r=0.1429 c=0
Rk20 (S \4\:S) resistor r=0.2039 c=0
Rk3 (B \9\:B) resistor r=0.04302 c=0
Rk4 (\6\:COb \7\:COb) resistor r=0.6944 c=0
Rk5 (\7\:COb \8\:COb) resistor r=0.3126 c=0
Rk6 (\7\:COb \10\:COb) resistor r=0.14 c=0
Rk9 (\5\:n1 \6\:n1) resistor r=0.1405 c=0
Rk10 (\6\:n1 \7\:n1) resistor r=0.7645 c=0
Rk11 (\7\:n1 \9\:n1) resistor r=0.3294 c=0
Rk12 (\6\:n1 \10\:n1) resistor r=0.5446 c=0
Rk13 (\7\:n1 \12\:n1) resistor r=0.1051 c=0
Rk14 (\4\:n0 \6\:n0) resistor r=0.4938 c=0
Rk15 (\6\:n0 \8\:n0) resistor r=0.4481 c=0
Rk16 (\4\:Sb \5\:Sb) resistor r=0.2357 c=0
Rk17 (\5\:Sb \7\:Sb) resistor r=0.1233 c=0
Rk18 (\5\:Sb \9\:Sb) resistor r=0.3607 c=0
Rl6 (\4\:A \5\:A) resistor r=99.1749 c=0
Rl7 (\5\:A \6\:A) resistor r=29.9442 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=31.9251 c=0
Rl11 (\2\:B \3\:B) resistor r=328.412 c=0
Rl10 (\1\:B \2\:B) resistor r=204.9 c=0
Rl16 (\5\:B \8\:B) resistor r=93.4057 c=0
Rl14 (\5\:B \6\:B) resistor r=95.3288 c=0
Rl12 (\3\:B \4\:B) resistor r=80.0028 c=0
Rl15 (\4\:B \7\:B) resistor r=78.0797 c=0
Rl13 (\4\:B \5\:B) resistor r=123.856 c=0
Rl3 (\2\:COb \4\:COb) resistor r=37.3411 c=0
Rl2 (\2\:COb \3\:COb) resistor r=106.572 c=0
Rl1 (COb \2\:COb) resistor r=1.2334 c=0
Rl9 (\3\:n1 \4\:n1) resistor r=31.9251 c=0
Rl8 (n1 \2\:n1) resistor r=37.2302 c=0
Rl17 (n0 \2\:n0) resistor r=161.538 c=0
Rl18 (\2\:n0 \3\:n0) resistor r=74.2328 c=0
Rl19 (Sb \2\:Sb) resistor r=39.6174 c=0
Rl20 (\2\:Sb \3\:Sb) resistor r=26.1559 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\1\:CO \2\:CO) resistor r=37.5 c=0
Rz6 (\3\:S \4\:S) resistor r=37.5 c=0
Rz2 (\5\:COb \6\:COb) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz5 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry1 (\3\:CO \4\:CO) resistor r=20.6667 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry6 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry2 (\9\:COb \10\:COb) resistor r=62 c=0
Ry3 (\11\:n1 \12\:n1) resistor r=62 c=0
Ry4 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry5 (\8\:Sb \9\:Sb) resistor r=62 c=0
Rx3 (\5\:A \7\:A) resistor r=45 c=0
Rx4 (\2\:A \8\:A) resistor r=45 c=0
Rx1 (\5\:B \9\:B) resistor r=45 c=0
Rx2 (COb \8\:COb) resistor r=45 c=0
Rx5 (\4\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n1 \10\:n1) resistor r=45 c=0
Rx7 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Sb \4\:Sb) resistor r=45 c=0
mn8 (\1\:CO \3\:COb \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.11923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (\3\:S \3\:Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85577e-07 sb=1.4e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mn6 (n4 \1\:A \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.305e-14 ps=8.4e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn7 (\5\:COb \6\:B n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.03e-14 ps=4.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\8\:n1 \7\:B \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn0 (\5\:n0 \6\:A \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=3.335e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.35e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn4 (\6\:Sb n1 \5\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.393e-14 ps=7.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=6.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\6\:Sb \1\:B n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.4e-07 sb=4.5e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn2 (n2 \2\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mp6 (\9\:COb \3\:A \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.05e-07 sd=160n sca=15.3248 \
        scb=0.0144711 scc=0.000289176 m=(1)
mp7 (\9\:COb \8\:B \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.495e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1e-07 sd=160n sca=12.8165 scb=0.0106177 \
        scc=0.00024049 m=(1)
mp1 (\11\:n1 \3\:B \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=2.63e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.15e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (\7\:n0 \4\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.052e-14 ps=7.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.37326e-07 sb=9.35e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\8\:Sb \2\:B \7\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.17326e-07 sb=6.55e-07 sd=160n sca=13.327 \
        scb=0.0119299 scc=0.000425286 m=(1)
mp3 (\8\:Sb \3\:n1 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.22326e-07 sb=4.5e-07 sd=160n sca=14.6061 \
        scb=0.0132457 scc=0.000429538 m=(1)
mp2 (n3 n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=5.19e-14 \
        ad=1.29e-14 ps=1.1e-06 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.27326e-07 sb=3.45e-07 sd=160n sca=15.9702 scb=0.0153945 \
        scc=0.000454375 m=(1)
ends ADDHX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:03 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDHX2
// View name: extracted

simulator lang=spectre

subckt ADDHX2 A B CO S VDD VSS
mp7 (\7\:COb \1\:B \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.026 scb=0.0229138 \
        scc=0.00110307 m=(1)
mp6 (\7\:COb \4\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=3.762e-14 ps=1.32e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.99709e-06 sd=160n sca=17.3029 \
        scb=0.01671 scc=0.000962068 m=(1)
mp0 (\5\:n0 \6\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.998e-14 ad=4.3e-14 ps=1.66e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.42337e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp4 (\8\:Sb \4\:B \5\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.052e-14 ps=8.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.17837e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp3 (\8\:Sb n1 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.332e-14 \
        ad=5.052e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.555e-06 sb=8.98372e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp2 (n3 \2\:n0 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.075e-14 ad=3.332e-14 ps=1.38e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=6.98372e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp1 (\6\:n1 \8\:B \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12791e-06 sb=1.4e-07 sd=160n sca=50.7282 \
        scb=0.0349898 scc=0.00599471 m=(1)
C1 (S VSS) capacitor c=2.35573e-17
C2 (VDD VSS) capacitor c=1.71145e-16
C3 (B VSS) capacitor c=9.74319e-17
C4 (CO VSS) capacitor c=6.72865e-17
C5 (n4 VSS) capacitor c=1.29764e-18
C6 (COb VSS) capacitor c=1.98708e-16
C7 (n0 VSS) capacitor c=9.40438e-17
C8 (Sb VSS) capacitor c=1.88468e-16
C9 (n1 VSS) capacitor c=4.10422e-17
C10 (\8\:B VSS) capacitor c=4.99691e-17
C11 (\2\:n0 VSS) capacitor c=4.98324e-17
C12 (\4\:B VSS) capacitor c=5.21772e-17
C13 (\6\:A VSS) capacitor c=4.206e-17
C14 (\4\:A VSS) capacitor c=2.42975e-17
C15 (\1\:B VSS) capacitor c=3.34053e-17
C16 (\9\:B VSS) capacitor c=2.7117e-17
C17 (\6\:B VSS) capacitor c=8.03793e-17
C18 (\3\:n1 VSS) capacitor c=4.19314e-17
C19 (\5\:A VSS) capacitor c=5.35156e-17
C20 (\3\:A VSS) capacitor c=5.23265e-17
C21 (\3\:B VSS) capacitor c=1.9409e-17
C22 (\10\:B VSS) capacitor c=2.19294e-17
C23 (\3\:n0 VSS) capacitor c=3.21844e-17
C24 (\4\:n1 VSS) capacitor c=3.35379e-17
C25 (\7\:B VSS) capacitor c=2.94892e-17
C26 (\5\:B VSS) capacitor c=2.62693e-17
C27 (\7\:A VSS) capacitor c=3.88456e-17
C28 (\1\:A VSS) capacitor c=3.13562e-17
C29 (\2\:B VSS) capacitor c=3.36344e-17
C30 (\6\:n1 VSS) capacitor c=7.97432e-17
C31 (\3\:S VSS) capacitor c=6.78653e-17
C32 (\8\:Sb VSS) capacitor c=5.46899e-17
C33 (\5\:n0 VSS) capacitor c=1.1405e-16
C34 (\1\:CO VSS) capacitor c=4.31098e-17
C35 (\7\:COb VSS) capacitor c=2.79216e-17
C36 (\16\:VDD VSS) capacitor c=2.86125e-17
C37 (\1\:VDD VSS) capacitor c=4.26702e-17
C38 (\8\:n1 VSS) capacitor c=3.5028e-17
C39 (\1\:S VSS) capacitor c=3.82099e-17
C40 (\11\:Sb VSS) capacitor c=3.69193e-17
C41 (\7\:n0 VSS) capacitor c=8.38314e-17
C42 (\3\:CO VSS) capacitor c=9.8151e-17
C43 (\10\:COb VSS) capacitor c=5.47139e-17
C44 (\2\:A VSS) capacitor c=2.18427e-17
C45 (\2\:n1 VSS) capacitor c=4.37483e-17
C46 (\9\:COb VSS) capacitor c=9.42385e-17
C47 (\12\:COb VSS) capacitor c=7.10105e-17
C48 (\8\:A VSS) capacitor c=1.41458e-16
C49 (\9\:A VSS) capacitor c=7.63286e-17
C50 (\4\:n0 VSS) capacitor c=5.86701e-17
C51 (\10\:Sb VSS) capacitor c=6.50348e-17
C52 (\13\:Sb VSS) capacitor c=6.48401e-17
C53 (\11\:B VSS) capacitor c=7.52984e-17
C54 (\12\:B VSS) capacitor c=8.52556e-17
C55 (\13\:B VSS) capacitor c=1.45124e-16
C56 (\14\:B VSS) capacitor c=4.15656e-17
C57 (\15\:B VSS) capacitor c=2.30158e-17
C58 (\16\:B VSS) capacitor c=8.00398e-17
C59 (\5\:n1 VSS) capacitor c=1.33757e-16
C60 (\3\:VDD VSS) capacitor c=1.01673e-16
C61 (\5\:VDD VSS) capacitor c=5.68413e-17
C62 (\15\:VDD VSS) capacitor c=6.85754e-18
Rk13 (\2\:S S) resistor r=0.06584 c=0
Rk14 (S \4\:S) resistor r=0.1742 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.07249 c=0
Rk25 (\3\:VDD \5\:VDD) resistor r=0.4435 c=0
Rk33 (\15\:VDD VDD) resistor r=0.06723 c=0
Rk31 (\5\:VDD \15\:VDD) resistor r=0.2127 c=0
Rk32 (\15\:VDD \17\:VDD) resistor r=0.3331 c=0
Rk15 (\11\:B \12\:B) resistor r=0.6681 c=0
Rk17 (\13\:B B) resistor r=1.0327 c=0
Rk16 (\12\:B \13\:B) resistor r=0.2242 c=0
Rk18 (B \14\:B) resistor r=0.06992 c=0
Rk19 (\12\:B \15\:B) resistor r=0.0529 c=0
Rk20 (\13\:B \16\:B) resistor r=0.3772 c=0
Rk4 (\2\:CO CO) resistor r=0.1079 c=0
Rk5 (CO \4\:CO) resistor r=0.4183 c=0
Rk6 (\8\:A A) resistor r=0.008457 c=0
Rk7 (A \9\:A) resistor r=0.6088 c=0
Rk34 (\2\:VSS \3\:VSS) resistor r=0.09661 c=0
Rk36 (\3\:VSS \5\:VSS) resistor r=0.4175 c=0
Rk39 (\6\:VSS VSS) resistor r=0.2477 c=0
Rk37 (\5\:VSS \6\:VSS) resistor r=0.06653 c=0
Rk1 (\8\:COb \9\:COb) resistor r=0.1196 c=0
Rk2 (\9\:COb \11\:COb) resistor r=0.4804 c=0
Rk3 (\9\:COb \12\:COb) resistor r=0.4412 c=0
Rk8 (\4\:n0 \6\:n0) resistor r=0.5155 c=0
Rk9 (\6\:n0 \8\:n0) resistor r=0.3658 c=0
Rk10 (\9\:Sb \10\:Sb) resistor r=0.2687 c=0
Rk11 (\10\:Sb \12\:Sb) resistor r=0.1185 c=0
Rk12 (\10\:Sb \13\:Sb) resistor r=0.3284 c=0
Rk21 (\5\:n1 \7\:n1) resistor r=0.874 c=0
Rk22 (\7\:n1 \9\:n1) resistor r=0.2346 c=0
Rl26 (\8\:B \9\:B) resistor r=92.3077 c=0
Rl27 (\9\:B \10\:B) resistor r=44.9028 c=0
Rl14 (\6\:B \7\:B) resistor r=85.3072 c=0
Rl13 (\4\:B \5\:B) resistor r=31.8672 c=0
Rl1 (\1\:B \2\:B) resistor r=86.5385 c=0
Rl2 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl11 (\5\:A \6\:A) resistor r=143.15 c=0
Rl12 (\6\:A \7\:A) resistor r=39.2094 c=0
Rl5 (\2\:A \4\:A) resistor r=27.9498 c=0
Rl4 (\2\:A \3\:A) resistor r=120.314 c=0
Rl3 (\1\:A \2\:A) resistor r=17.3448 c=0
Rl18 (n0 \2\:n0) resistor r=141.873 c=0
Rl19 (\2\:n0 \3\:n0) resistor r=30.2349 c=0
Rl15 (n1 \2\:n1) resistor r=23.7402 c=0
Rl16 (\2\:n1 \3\:n1) resistor r=126.797 c=0
Rl17 (\2\:n1 \4\:n1) resistor r=5.1011 c=0
Rz5 (\2\:S \1\:S) resistor r=75 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz8 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\4\:CO \3\:CO) resistor r=75 c=0
Rz1 (\11\:COb \10\:COb) resistor r=75 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz4 (\12\:Sb \11\:Sb) resistor r=75 c=0
Rz6 (\8\:n1 \9\:n1) resistor r=75 c=0
Ry5 (\4\:S \3\:S) resistor r=62 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry2 (\2\:CO \1\:CO) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:COb \7\:COb) resistor r=62 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry4 (\9\:Sb \8\:Sb) resistor r=62 c=0
Ry6 (\6\:n1 \7\:n1) resistor r=62 c=0
Rx6 (\10\:B \11\:B) resistor r=45 c=0
Rx7 (\2\:B \14\:B) resistor r=45 c=0
Rx8 (\7\:B \15\:B) resistor r=45 c=0
Rx9 (\5\:B \16\:B) resistor r=45 c=0
Rx2 (\1\:A \8\:A) resistor r=45 c=0
Rx3 (\7\:A \9\:A) resistor r=45 c=0
Rx1 (\12\:COb COb) resistor r=45 c=0
Rx4 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx5 (\13\:Sb Sb) resistor r=45 c=0
Rx10 (\4\:n1 \5\:n1) resistor r=45 c=0
mn7 (\10\:COb \3\:B n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.755e-14 ps=7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (n4 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=2.973e-14 ps=1.6e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\7\:n0 \5\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=5.075e-14 ps=1.6e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=1.59e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\11\:Sb \3\:n1 \7\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.32e-14 ps=9.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.195e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\11\:Sb \6\:B n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=9.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n2 n0 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=8.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\8\:n1 \9\:B \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.13e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn5 (\1\:S Sb \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.058e-14 ad=4.16e-14 ps=1.61e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19058e-06 sb=5.11635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn8_1__rcx (\3\:CO COb \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.375e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.98365e-07 sb=1.28125e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp8_1__rcx (\1\:CO COb \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.651e-14 ad=6.24e-14 ps=1.49e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.20833e-07 sb=1.14481e-06 sd=160n sca=13.4335 \
        scb=0.0117789 scc=0.000556063 m=(2)
mp5_1__rcx (\3\:S Sb \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.233e-14 ad=6.24e-14 ps=1.415e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15641e-06 sb=4.35449e-07 sd=160n sca=31.0599 \
        scb=0.0204054 scc=0.00336104 m=(2)
ends ADDHX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:04 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDHX4
// View name: extracted

simulator lang=spectre

subckt ADDHX4 A B CO S VDD VSS
mp7 (\17\:COb \1\:B \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.95e-14 ad=7.02e-14 ps=1.34e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.58532e-06 sd=160n sca=31.1178 \
        scb=0.0283213 scc=0.00286476 m=(1)
mp6 (\17\:COb \1\:A \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.242e-13 ad=7.02e-14 ps=1.86e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.48436e-06 sd=160n sca=26.3799 \
        scb=0.0202838 scc=0.00260575 m=(1)
mp4 (\19\:Sb \8\:B \8\:n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1748e-13 ad=6.24e-14 ps=1.71e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=1.46006e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp3 (\19\:Sb \3\:n1 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23942e-06 sb=1.25506e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp2 (n3 n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2415e-13 ad=2.34e-14 ps=1.9e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28654e-06 sb=1.15006e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp8_1__rcx (\6\:CO COb \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.225e-13 ad=8.287e-14 ps=1.8425e-06 pd=1.205e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.36545e-06 sd=160n sca=24.8553 \
        scb=0.0187947 scc=0.00260102 m=(4)
mp5_1__rcx (S Sb \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1313e-13 ad=7.898e-14 ps=1.9e-06 pd=1.185e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35385e-06 sb=9.92308e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
C1 (S VSS) capacitor c=1.67966e-16
C2 (VDD VSS) capacitor c=1.99958e-16
C3 (B VSS) capacitor c=1.45092e-17
C4 (CO VSS) capacitor c=1.6934e-17
C5 (A VSS) capacitor c=1.60478e-16
C6 (n4 VSS) capacitor c=1.54183e-18
C7 (COb VSS) capacitor c=3.17065e-16
C8 (n0 VSS) capacitor c=7.68892e-17
C9 (Sb VSS) capacitor c=2.71785e-16
C10 (n1 VSS) capacitor c=4.10293e-17
C11 (n2 VSS) capacitor c=2.92218e-18
C12 (n3 VSS) capacitor c=2.24885e-18
C13 (\12\:B VSS) capacitor c=3.21816e-17
C14 (\3\:n1 VSS) capacitor c=7.47592e-17
C15 (\8\:B VSS) capacitor c=4.05972e-17
C16 (\4\:A VSS) capacitor c=5.02021e-17
C17 (\1\:A VSS) capacitor c=6.06051e-17
C18 (\1\:B VSS) capacitor c=2.48675e-17
C19 (\9\:B VSS) capacitor c=3.15259e-17
C20 (\3\:n0 VSS) capacitor c=6.38859e-17
C21 (\5\:B VSS) capacitor c=7.53313e-17
C22 (\6\:A VSS) capacitor c=2.66154e-17
C23 (\3\:A VSS) capacitor c=5.68583e-17
C24 (\4\:B VSS) capacitor c=5.76025e-17
C25 (\11\:B VSS) capacitor c=2.99643e-17
C26 (\8\:Sb VSS) capacitor c=3.32437e-17
C27 (\2\:n0 VSS) capacitor c=5.11785e-17
C28 (\4\:n1 VSS) capacitor c=5.45024e-17
C29 (\2\:n1 VSS) capacitor c=4.16339e-17
C30 (\7\:B VSS) capacitor c=4.26416e-17
C31 (\5\:A VSS) capacitor c=5.09847e-17
C32 (\2\:A VSS) capacitor c=5.61814e-17
C33 (\3\:B VSS) capacitor c=1.3865e-17
C34 (\5\:n1 VSS) capacitor c=4.11434e-17
C35 (\1\:VDD VSS) capacitor c=1.40299e-16
C36 (\19\:Sb VSS) capacitor c=1.16114e-16
C37 (\8\:n0 VSS) capacitor c=2.5508e-17
C38 (\17\:COb VSS) capacitor c=8.45752e-17
C39 (\22\:VDD VSS) capacitor c=3.72637e-17
C40 (\4\:VDD VSS) capacitor c=3.4142e-17
C41 (\7\:n1 VSS) capacitor c=1.74468e-16
C42 (\16\:Sb VSS) capacitor c=8.69137e-17
C43 (\6\:n0 VSS) capacitor c=7.34947e-17
C44 (\1\:CO VSS) capacitor c=1.30871e-16
C45 (\19\:COb VSS) capacitor c=4.8399e-17
C46 (\2\:B VSS) capacitor c=2.31527e-17
C47 (\6\:B VSS) capacitor c=6.77939e-17
C48 (\16\:COb VSS) capacitor c=4.01273e-17
C49 (\6\:CO VSS) capacitor c=1.18177e-16
C50 (\7\:A VSS) capacitor c=1.54614e-16
C51 (\8\:A VSS) capacitor c=3.37715e-17
C52 (\4\:n0 VSS) capacitor c=1.05671e-16
C53 (\5\:n0 VSS) capacitor c=9.12069e-17
C54 (\18\:Sb VSS) capacitor c=1.12328e-16
C55 (\5\:S VSS) capacitor c=1.15679e-16
C56 (\13\:B VSS) capacitor c=2.25226e-16
C57 (\14\:B VSS) capacitor c=3.47504e-16
C58 (\15\:B VSS) capacitor c=1.7586e-16
C59 (\16\:B VSS) capacitor c=4.00978e-17
C60 (\9\:n1 VSS) capacitor c=2.16872e-16
C61 (\10\:n1 VSS) capacitor c=5.62797e-17
C62 (\7\:VDD VSS) capacitor c=1.22218e-16
C63 (\10\:VDD VSS) capacitor c=7.31301e-18
Rk53 (\7\:VSS VSS) resistor r=0.2051 c=0
Rk47 (\1\:VSS \7\:VSS) resistor r=0.5476 c=0
Rk18 (S \5\:S) resistor r=0.157 c=0
Rk32 (\1\:VDD \7\:VDD) resistor r=0.5435 c=0
Rk36 (\10\:VDD VDD) resistor r=0.03465 c=0
Rk35 (\7\:VDD \10\:VDD) resistor r=0.2443 c=0
Rk43 (\10\:VDD \23\:VDD) resistor r=0.2133 c=0
Rk22 (\13\:B \14\:B) resistor r=1.8713 c=0
Rk24 (\15\:B B) resistor r=0.03023 c=0
Rk23 (\14\:B \15\:B) resistor r=1.527 c=0
Rk25 (\14\:B \16\:B) resistor r=0.3289 c=0
Rk5 (\1\:CO CO) resistor r=0.01536 c=0
Rk6 (CO \6\:CO) resistor r=0.1937 c=0
Rk9 (\7\:A A) resistor r=1.2891 c=0
Rk10 (A \8\:A) resistor r=0.04495 c=0
Rk1 (\16\:COb \18\:COb) resistor r=0.2544 c=0
Rk2 (\18\:COb \20\:COb) resistor r=0.3424 c=0
Rk11 (\4\:n0 \5\:n0) resistor r=0.5809 c=0
Rk12 (\5\:n0 \7\:n0) resistor r=0.4289 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.06399 c=0
Rk14 (\17\:Sb \18\:Sb) resistor r=0.4361 c=0
Rk15 (\18\:Sb \20\:Sb) resistor r=0.6442 c=0
Rk26 (\6\:n1 \8\:n1) resistor r=0.2725 c=0
Rk27 (\8\:n1 \9\:n1) resistor r=1.615 c=0
Rk28 (\9\:n1 \10\:n1) resistor r=0.2637 c=0
Rl1 (\1\:B \2\:B) resistor r=34.3295 c=0
Rl3 (\2\:B \4\:B) resistor r=65.0987 c=0
Rl2 (\2\:B \3\:B) resistor r=13.091 c=0
Rl25 (\6\:B \8\:B) resistor r=35.9003 c=0
Rl23 (\5\:B \6\:B) resistor r=133.089 c=0
Rl24 (\6\:B \7\:B) resistor r=156.691 c=0
Rl45 (\10\:B \12\:B) resistor r=34.4036 c=0
Rl43 (\9\:B \10\:B) resistor r=49.7882 c=0
Rl44 (\10\:B \11\:B) resistor r=4.5488 c=0
Rl20 (\4\:A \5\:A) resistor r=153.207 c=0
Rl21 (\5\:A \6\:A) resistor r=57.6695 c=0
Rl4 (\1\:A \2\:A) resistor r=57.6923 c=0
Rl5 (\2\:A \3\:A) resistor r=36.2311 c=0
Rl27 (n0 \2\:n0) resistor r=29.5379 c=0
Rl28 (\2\:n0 \3\:n0) resistor r=71.8456 c=0
Rl35 (Sb \8\:Sb) resistor r=6.6999 c=0
Rl26 (\3\:n1 \4\:n1) resistor r=24.2328 c=0
Rl22 (n1 \2\:n1) resistor r=24.2328 c=0
Rz9 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz10 (\7\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\20\:COb \19\:COb) resistor r=75 c=0
Rz4 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\17\:Sb \16\:Sb) resistor r=75 c=0
Rz8 (\7\:n1 \8\:n1) resistor r=75 c=0
Ry18 (\1\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry19 (\7\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry1 (\18\:COb \17\:COb) resistor r=62 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\20\:Sb \19\:Sb) resistor r=62 c=0
Ry9 (\5\:n1 \6\:n1) resistor r=62 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\3\:B \15\:B) resistor r=45 c=0
Rx8 (\7\:B \16\:B) resistor r=45 c=0
Rx2 (\5\:A \7\:A) resistor r=45 c=0
Rx3 (\2\:A \8\:A) resistor r=45 c=0
Rx1 (\16\:COb COb) resistor r=45 c=0
Rx4 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx5 (\18\:Sb \8\:Sb) resistor r=45 c=0
Rx9 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx10 (\4\:n1 \10\:n1) resistor r=45 c=0
mn7 (\19\:COb \4\:B n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67577e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn6 (n4 \3\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=1.56e-14 ps=8.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.62529e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn4 (\16\:Sb n1 \6\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=5.46e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13038e-06 sb=1.40038e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn3 (\16\:Sb \5\:B n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25298e-06 sb=1.14538e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn2 (n2 \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.435e-14 ad=2.34e-14 ps=1.62e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31788e-06 sb=1.01038e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn5_1__rcx (\5\:S Sb \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.385e-14 ad=4.29e-14 ps=1.605e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17058e-06 sb=9.86058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn8_1__rcx (\1\:CO COb \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.134e-14 ad=7.605e-14 ps=1.275e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=1.51712e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn0 (\6\:n0 \6\:A \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.355e-14 ad=6.95e-14 ps=1.1e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.67948e-06 sb=1.76845e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\7\:n1 \9\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46276e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp0 (\8\:n0 \4\:A \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.342e-13 ad=1.1748e-13 ps=1.79e-06 pd=1.71e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.96419e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp1 (\5\:n1 \12\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.515e-14 ad=3.118e-14 ps=1.9e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66547e-06 sb=1.45e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
ends ADDHX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:05 2013 )
// Library name: gsclib045_hvt
// Cell name: ADDHXL
// View name: extracted

simulator lang=spectre

subckt ADDHXL A B CO S VDD VSS
mp8 (\3\:CO \4\:COb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=15.3248 \
        scb=0.0144711 scc=0.000289176 m=(1)
mp6 (\7\:COb \1\:A \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.05e-07 sd=160n sca=12.7491 \
        scb=0.0105457 scc=0.000240287 m=(1)
mp7 (\7\:COb \8\:B \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1e-07 sd=160n sca=11.835 scb=0.00987003 \
        scc=0.000239311 m=(1)
mp1 (\11\:n1 \3\:B \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.345e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp0 (\7\:n0 \5\:A \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.697e-14 ps=8.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.1e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp4 (\8\:Sb \2\:B \7\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=6.558e-14 ps=9.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=7.9e-07 sd=160n sca=16.6855 \
        scb=0.0164031 scc=0.00112486 m=(1)
mp3 (\8\:Sb \3\:n1 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=4.4e-07 sd=160n sca=18.5655 \
        scb=0.0181901 scc=0.00113112 m=(1)
mp2 (n3 n0 \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.065e-14 ad=1.29e-14 ps=1.67e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=3.35e-07 sd=160n sca=20.0958 \
        scb=0.0206924 scc=0.00116659 m=(1)
mp5 (\1\:S Sb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.065e-14 ad=3.01e-14 ps=1.67e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.4e-07 sd=160n sca=29.0691 \
        scb=0.0342129 scc=0.00232071 m=(1)
C1 (CO VSS) capacitor c=3.94667e-17
C2 (A VSS) capacitor c=1.98671e-16
C3 (VDD VSS) capacitor c=2.04418e-16
C4 (S VSS) capacitor c=4.64102e-17
C5 (B VSS) capacitor c=6.72356e-17
C6 (COb VSS) capacitor c=2.80734e-17
C7 (n4 VSS) capacitor c=1.34709e-18
C8 (n1 VSS) capacitor c=4.83264e-17
C9 (n0 VSS) capacitor c=1.01071e-16
C10 (Sb VSS) capacitor c=4.27622e-17
C11 (n2 VSS) capacitor c=7.95925e-19
C12 (n3 VSS) capacitor c=2.22487e-18
C13 (\3\:n1 VSS) capacitor c=6.04183e-17
C14 (\2\:B VSS) capacitor c=8.8464e-17
C15 (\5\:A VSS) capacitor c=6.33085e-17
C16 (\3\:B VSS) capacitor c=6.17169e-17
C17 (\8\:B VSS) capacitor c=3.34725e-17
C18 (\1\:A VSS) capacitor c=7.53593e-17
C19 (\4\:COb VSS) capacitor c=3.1443e-17
C20 (\3\:Sb VSS) capacitor c=3.60049e-17
C21 (\2\:n0 VSS) capacitor c=5.17841e-17
C22 (\1\:B VSS) capacitor c=8.80476e-17
C23 (\6\:A VSS) capacitor c=2.67886e-17
C24 (\7\:B VSS) capacitor c=2.93342e-17
C25 (\6\:B VSS) capacitor c=3.86314e-17
C26 (\4\:A VSS) capacitor c=3.28574e-17
C27 (\3\:COb VSS) capacitor c=6.16312e-17
C28 (\2\:Sb VSS) capacitor c=3.34532e-17
C29 (\3\:n0 VSS) capacitor c=2.89371e-17
C30 (\4\:n1 VSS) capacitor c=4.57776e-17
C31 (\2\:n1 VSS) capacitor c=4.30565e-17
C32 (\7\:A VSS) capacitor c=2.01246e-17
C33 (\5\:B VSS) capacitor c=4.89237e-17
C34 (\3\:A VSS) capacitor c=3.18205e-17
C35 (\8\:VDD VSS) capacitor c=5.10491e-18
C36 (\8\:Sb VSS) capacitor c=6.42907e-17
C37 (\7\:n0 VSS) capacitor c=8.41115e-17
C38 (\10\:VDD VSS) capacitor c=5.59721e-17
C39 (\11\:n1 VSS) capacitor c=1.15326e-17
C40 (\12\:VDD VSS) capacitor c=1.03868e-17
C41 (\7\:COb VSS) capacitor c=1.06582e-16
C42 (\14\:VDD VSS) capacitor c=1.72423e-17
C43 (\3\:CO VSS) capacitor c=5.96473e-17
C44 (\1\:VDD VSS) capacitor c=1.33011e-17
C45 (\3\:S VSS) capacitor c=4.40115e-17
C46 (\6\:Sb VSS) capacitor c=8.45987e-17
C47 (\5\:n0 VSS) capacitor c=1.33278e-16
C48 (\8\:n1 VSS) capacitor c=8.40488e-17
C49 (\5\:COb VSS) capacitor c=1.32442e-16
C50 (\1\:CO VSS) capacitor c=2.75939e-17
C51 (\2\:COb VSS) capacitor c=2.98439e-17
C52 (\2\:A VSS) capacitor c=4.4747e-17
C53 (\4\:B VSS) capacitor c=3.58293e-17
C54 (\9\:B VSS) capacitor c=3.42802e-17
C55 (\9\:COb VSS) capacitor c=6.71845e-17
C56 (\9\:A VSS) capacitor c=2.12221e-16
C57 (\5\:n1 VSS) capacitor c=4.79573e-17
C58 (\6\:n1 VSS) capacitor c=1.13246e-16
C59 (\7\:n1 VSS) capacitor c=1.54989e-16
C60 (\10\:n1 VSS) capacitor c=4.05459e-17
C61 (\4\:n0 VSS) capacitor c=5.97285e-17
C62 (\4\:Sb VSS) capacitor c=2.00629e-17
C63 (\5\:Sb VSS) capacitor c=5.87023e-17
C64 (\3\:VDD VSS) capacitor c=1.87362e-17
C65 (\4\:VDD VSS) capacitor c=2.9657e-17
C66 (\6\:VDD VSS) capacitor c=1.07659e-17
C67 (\7\:VDD VSS) capacitor c=1.481e-17
Rk1 (CO \2\:CO) resistor r=0.1018 c=0
Rk2 (CO \4\:CO) resistor r=0.3023 c=0
Rk6 (A \8\:A) resistor r=0.01427 c=0
Rk7 (\8\:A \9\:A) resistor r=1.4976 c=0
Rk27 (\2\:VDD \3\:VDD) resistor r=0.03739 c=0
Rk28 (\3\:VDD \4\:VDD) resistor r=0.5358 c=0
Rk29 (\4\:VDD \5\:VDD) resistor r=0.1276 c=0
Rk30 (\5\:VDD \6\:VDD) resistor r=0.1251 c=0
Rk32 (\7\:VDD VDD) resistor r=0.215 c=0
Rk31 (\6\:VDD \7\:VDD) resistor r=0.2101 c=0
Rk33 (\3\:VDD \9\:VDD) resistor r=0.07334 c=0
Rk34 (\4\:VDD \11\:VDD) resistor r=0.3412 c=0
Rk35 (\6\:VDD \13\:VDD) resistor r=0.07334 c=0
Rk36 (\7\:VDD \15\:VDD) resistor r=0.07334 c=0
Rk18 (\2\:S S) resistor r=0.01796 c=0
Rk19 (S \4\:S) resistor r=0.4318 c=0
Rk20 (\2\:VSS \4\:VSS) resistor r=0.06647 c=0
Rk21 (\4\:VSS \5\:VSS) resistor r=0.5636 c=0
Rk22 (\5\:VSS \6\:VSS) resistor r=0.1376 c=0
Rk24 (\7\:VSS VSS) resistor r=0.215 c=0
Rk23 (\6\:VSS \7\:VSS) resistor r=0.3356 c=0
Rk25 (\5\:VSS \9\:VSS) resistor r=0.3446 c=0
Rk26 (\7\:VSS \11\:VSS) resistor r=0.2982 c=0
Rk3 (\9\:B B) resistor r=0.03907 c=0
Rk4 (\6\:COb \8\:COb) resistor r=0.818 c=0
Rk5 (\8\:COb \9\:COb) resistor r=0.3443 c=0
Rk8 (\5\:n1 \6\:n1) resistor r=0.1722 c=0
Rk9 (\6\:n1 \7\:n1) resistor r=0.9338 c=0
Rk10 (\7\:n1 \9\:n1) resistor r=0.4559 c=0
Rk11 (\6\:n1 \10\:n1) resistor r=0.113 c=0
Rk12 (\7\:n1 \12\:n1) resistor r=0.05386 c=0
Rk13 (\4\:n0 \6\:n0) resistor r=0.5134 c=0
Rk14 (\6\:n0 \8\:n0) resistor r=0.4043 c=0
Rk15 (\4\:Sb \5\:Sb) resistor r=0.07708 c=0
Rk16 (\5\:Sb \7\:Sb) resistor r=0.4079 c=0
Rk17 (\5\:Sb \9\:Sb) resistor r=0.4143 c=0
Rl7 (\5\:A \6\:A) resistor r=165.385 c=0
Rl8 (\6\:A \7\:A) resistor r=26.1559 c=0
Rl4 (\1\:A \2\:A) resistor r=166.187 c=0
Rl6 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl5 (\2\:A \3\:A) resistor r=4.3551 c=0
Rl11 (\2\:B \3\:B) resistor r=351.489 c=0
Rl10 (\1\:B \2\:B) resistor r=224.238 c=0
Rl16 (\5\:B \8\:B) resistor r=83.4251 c=0
Rl14 (\5\:B \6\:B) resistor r=95.9489 c=0
Rl12 (\3\:B \4\:B) resistor r=47.8734 c=0
Rl15 (\4\:B \7\:B) resistor r=116.199 c=0
Rl13 (\4\:B \5\:B) resistor r=206.184 c=0
Rl3 (\2\:COb \4\:COb) resistor r=34.3295 c=0
Rl2 (\2\:COb \3\:COb) resistor r=170.868 c=0
Rl1 (COb \2\:COb) resistor r=3.5213 c=0
Rl17 (\3\:n1 \4\:n1) resistor r=41.0764 c=0
Rl9 (n1 \2\:n1) resistor r=26.1559 c=0
Rl18 (n0 \2\:n0) resistor r=165.385 c=0
Rl19 (\2\:n0 \3\:n0) resistor r=35.7713 c=0
Rl20 (Sb \2\:Sb) resistor r=101.156 c=0
Rl21 (\2\:Sb \3\:Sb) resistor r=35.7713 c=0
Rz1 (\1\:CO \2\:CO) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz11 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz6 (\3\:S \4\:S) resistor r=75 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz9 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz2 (\5\:COb \6\:COb) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz5 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry1 (\3\:CO \4\:CO) resistor r=62 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry6 (\1\:S \2\:S) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=31 c=0
Ry8 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry2 (\7\:COb \8\:COb) resistor r=62 c=0
Ry3 (\11\:n1 \12\:n1) resistor r=62 c=0
Ry4 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry5 (\8\:Sb \9\:Sb) resistor r=62 c=0
Rx3 (\3\:A \8\:A) resistor r=45 c=0
Rx4 (\7\:A \9\:A) resistor r=45 c=0
Rx1 (\5\:B \9\:B) resistor r=45 c=0
Rx2 (COb \9\:COb) resistor r=45 c=0
Rx5 (\4\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n1 \10\:n1) resistor r=45 c=0
Rx7 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Sb \4\:Sb) resistor r=45 c=0
mn8 (\1\:CO \3\:COb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn6 (n4 \4\:A \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=1.523e-14 ps=6.3e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.05e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn7 (\5\:COb \6\:B n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.523e-14 ad=2.248e-14 ps=5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\8\:n1 \7\:B \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.355e-06 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\5\:n0 \6\:A \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.988e-14 ps=7.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.1e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn4 (\6\:Sb n1 \5\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=7.8e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn3 (\6\:Sb \1\:B n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.32e-14 ps=6.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=5.75e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn2 (n2 \2\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.055e-14 ad=2.827e-14 ps=1.49e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=3.35e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn5 (\3\:S \3\:Sb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.055e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
ends ADDHXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:06 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2X1
// View name: extracted

simulator lang=spectre

subckt AND2X1 A B VDD VSS Y
mp1 (\8\:n0 \4\:B \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=3.548e-14 ps=1.39e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-07 sb=5.55e-07 sd=160n sca=28.7776 \
        scb=0.0317346 scc=0.0021577 m=(1)
mp0 (\8\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.548e-14 ps=1.1e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=3.45e-07 sd=160n sca=18.926 \
        scb=0.0187755 scc=0.000316918 m=(1)
C1 (Y VSS) capacitor c=5.39034e-17
C2 (VDD VSS) capacitor c=7.01328e-17
C3 (A VSS) capacitor c=7.97774e-17
C4 (n0 VSS) capacitor c=4.97999e-17
C5 (\1\:A VSS) capacitor c=4.94423e-17
C6 (\4\:B VSS) capacitor c=4.16052e-17
C7 (\3\:n0 VSS) capacitor c=4.0145e-17
C8 (\3\:A VSS) capacitor c=5.93263e-17
C9 (\1\:B VSS) capacitor c=5.24568e-17
C10 (\2\:n0 VSS) capacitor c=3.36276e-17
C11 (\2\:A VSS) capacitor c=6.62669e-17
C12 (\3\:B VSS) capacitor c=1.51302e-17
C13 (\1\:Y VSS) capacitor c=5.15264e-17
C14 (\1\:VDD VSS) capacitor c=4.55278e-17
C15 (\8\:n0 VSS) capacitor c=6.4416e-17
C16 (\5\:VDD VSS) capacitor c=8.93502e-18
C17 (\3\:Y VSS) capacitor c=3.03564e-17
C18 (\6\:n0 VSS) capacitor c=3.39163e-17
C19 (\2\:B VSS) capacitor c=4.6336e-17
C20 (\5\:B VSS) capacitor c=3.52173e-17
C21 (\7\:B VSS) capacitor c=3.91733e-17
C22 (\4\:A VSS) capacitor c=5.76527e-17
C23 (\4\:n0 VSS) capacitor c=7.30519e-17
C24 (\5\:n0 VSS) capacitor c=9.47543e-17
C25 (\4\:VDD VSS) capacitor c=2.04796e-17
Rk14 (\4\:VSS VSS) resistor r=0.1503 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3451 c=0
Rk1 (\5\:B \6\:B) resistor r=0.001776 c=0
Rk2 (B \7\:B) resistor r=0.001658 c=0
Rk3 (\5\:B \7\:B) resistor r=0.03546 c=0
Rk8 (\2\:Y Y) resistor r=0.3325 c=0
Rk9 (Y \4\:Y) resistor r=0.1462 c=0
Rk11 (\4\:VDD VDD) resistor r=0.1511 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3363 c=0
Rk12 (VDD \6\:VDD) resistor r=0.06875 c=0
Rk4 (A \4\:A) resistor r=0.1436 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.2844 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.1371 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.4669 c=0
Rl3 (\2\:B \4\:B) resistor r=106.246 c=0
Rl1 (\1\:B \2\:B) resistor r=74.3274 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1529 c=0
Rl4 (\1\:A \2\:A) resistor r=89.5596 c=0
Rl5 (\2\:A \3\:A) resistor r=81.8672 c=0
Rl6 (n0 \2\:n0) resistor r=39.5596 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=64.5595 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (net127 \1\:B \6\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn1 (\1\:VSS \3\:A net127 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.438e-14 ps=4.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn2 (\3\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.64e-14 ps=9.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32404e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.39808e-07 sb=1.4e-07 sd=160n sca=35.5228 \
        scb=0.0370147 scc=0.0033854 m=(1)
ends AND2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:07 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2X2
// View name: extracted

simulator lang=spectre

subckt AND2X2 A B VDD VSS Y
mp1 (\11\:n0 \4\:B \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.48e-14 ad=3.44e-14 ps=1.37e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.7e-07 sd=160n sca=30.8503 scb=0.0332284 \
        scc=0.00283483 m=(1)
mp0 (\11\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=3.44e-14 ps=1.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.65e-07 sd=160n sca=16.7744 \
        scb=0.0157078 scc=0.000273548 m=(1)
C1 (B VSS) capacitor c=4.6605e-17
C2 (Y VSS) capacitor c=6.25083e-17
C3 (VDD VSS) capacitor c=7.86884e-17
C4 (A VSS) capacitor c=8.55645e-17
C5 (net73 VSS) capacitor c=1.40724e-18
C6 (n0 VSS) capacitor c=1.70551e-16
C7 (\1\:A VSS) capacitor c=5.95372e-17
C8 (\4\:B VSS) capacitor c=2.73636e-17
C9 (\3\:A VSS) capacitor c=5.51146e-17
C10 (\1\:B VSS) capacitor c=7.19542e-17
C11 (\2\:A VSS) capacitor c=6.59037e-17
C12 (\3\:B VSS) capacitor c=1.27195e-17
C13 (\1\:VDD VSS) capacitor c=1.0414e-16
C14 (\1\:Y VSS) capacitor c=8.99252e-17
C15 (\11\:n0 VSS) capacitor c=9.02575e-17
C16 (\7\:VDD VSS) capacitor c=3.70598e-18
C17 (\3\:Y VSS) capacitor c=4.86046e-17
C18 (\9\:n0 VSS) capacitor c=1.79346e-17
C19 (\2\:B VSS) capacitor c=4.53447e-17
C20 (\5\:B VSS) capacitor c=3.54639e-17
C21 (\4\:A VSS) capacitor c=6.49923e-17
C22 (\7\:n0 VSS) capacitor c=8.34614e-17
C23 (\8\:n0 VSS) capacitor c=8.40283e-17
Rk1 (B \5\:B) resistor r=0.09314 c=0
Rk6 (\2\:Y Y) resistor r=0.3407 c=0
Rk7 (Y \4\:Y) resistor r=0.1684 c=0
Rk10 (\1\:VDD VDD) resistor r=0.2015 c=0
Rk11 (VDD \8\:VDD) resistor r=0.07996 c=0
Rk2 (A \4\:A) resistor r=0.2134 c=0
Rk13 (\1\:VSS VSS) resistor r=0.2015 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3649 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.07427 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.5036 c=0
Rl3 (\2\:B \4\:B) resistor r=24.4619 c=0
Rl1 (\1\:B \2\:B) resistor r=189.894 c=0
Rl2 (\2\:B \3\:B) resistor r=4.5402 c=0
Rl4 (\1\:A \2\:A) resistor r=133.384 c=0
Rl5 (\2\:A \3\:A) resistor r=56.461 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\10\:n0 \9\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry5 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\12\:n0 \11\:n0) resistor r=62 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\9\:n0 \1\:B net73 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn0 (net73 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=8.7e-15 ps=1.41e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.65e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5e-14 \
        ad=4.16e-14 ps=1.105e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.14615e-07 sb=3.45e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(2)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=6.24e-14 ps=1.095e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.41026e-07 sb=3.45e-07 sd=160n sca=23.9894 \
        scb=0.0214998 scc=0.00175538 m=(2)
ends AND2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:08 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2X4
// View name: extracted

simulator lang=spectre

subckt AND2X4 A B VDD VSS Y
mp1 (\19\:net61 \4\:B \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=7.8e-14 ps=1.06e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26e-06 sd=160n sca=25.0495 \
        scb=0.0285542 scc=0.00163822 m=(1)
mp0 (\19\:net61 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=7.8e-14 ps=1.15e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.015e-06 sd=160n sca=14.3199 \
        scb=0.0126894 scc=0.000252227 m=(1)
mp2 (\1\:Y net61 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.727e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=7.85e-07 sd=160n sca=12.3494 \
        scb=0.00998202 scc=0.000232154 m=(4)
C1 (Y VSS) capacitor c=3.41146e-17
C2 (B VSS) capacitor c=3.37154e-17
C3 (A VSS) capacitor c=2.80231e-17
C4 (VDD VSS) capacitor c=1.04848e-16
C5 (net61 VSS) capacitor c=3.63441e-16
C6 (\1\:A VSS) capacitor c=4.83246e-17
C7 (\4\:B VSS) capacitor c=5.12021e-17
C8 (\3\:A VSS) capacitor c=7.71956e-17
C9 (\1\:B VSS) capacitor c=6.72361e-17
C10 (\2\:A VSS) capacitor c=5.3864e-17
C11 (\3\:B VSS) capacitor c=1.23925e-17
C12 (\1\:VDD VSS) capacitor c=2.01818e-16
C13 (\1\:Y VSS) capacitor c=1.8458e-16
C14 (\19\:net61 VSS) capacitor c=1.05685e-16
C15 (\7\:VDD VSS) capacitor c=4.47661e-17
C16 (\17\:net61 VSS) capacitor c=2.16518e-17
C17 (\2\:B VSS) capacitor c=3.7388e-17
C18 (\5\:B VSS) capacitor c=3.6042e-17
C19 (\4\:A VSS) capacitor c=4.08934e-17
C20 (\15\:net61 VSS) capacitor c=1.02061e-16
C21 (\16\:net61 VSS) capacitor c=1.16556e-17
C22 (\4\:Y VSS) capacitor c=1.76414e-16
Rk10 (\1\:Y Y) resistor r=0.3473 c=0
Rk11 (Y \4\:Y) resistor r=0.163 c=0
Rk1 (B \5\:B) resistor r=0.12 c=0
Rk25 (\1\:VSS VSS) resistor r=0.2252 c=0
Rk2 (A \4\:A) resistor r=0.135 c=0
Rk18 (\1\:VDD VDD) resistor r=0.2255 c=0
Rk19 (VDD \8\:VDD) resistor r=0.2871 c=0
Rk4 (net61 \15\:net61) resistor r=0.3696 c=0
Rk5 (\15\:net61 \16\:net61) resistor r=0.142 c=0
Rk6 (\16\:net61 \18\:net61) resistor r=0.1512 c=0
Rk7 (\15\:net61 \20\:net61) resistor r=0.4953 c=0
Rk8 (\16\:net61 \21\:net61) resistor r=0.03043 c=0
Rl3 (\2\:B \4\:B) resistor r=141.048 c=0
Rl1 (\1\:B \2\:B) resistor r=102.231 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl4 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl5 (\2\:A \3\:A) resistor r=105.002 c=0
Rz1 (\18\:net61 \17\:net61) resistor r=75 c=0
Rz2 (\21\:net61 \17\:net61) resistor r=75 c=0
Ry5 (\8\:VDD \7\:VDD) resistor r=20.6667 c=0
Ry1 (\20\:net61 \19\:net61) resistor r=20.6667 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
mn1 (\17\:net61 \1\:B net69 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn0 (net69 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=1.56e-14 ps=8.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.015e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\4\:Y net61 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=7.85e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
ends AND2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:09 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2X6
// View name: extracted

simulator lang=spectre

subckt AND2X6 A B VDD VSS Y
mp1_1__rcx (\19\:net61 \1\:B \14\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.575e-06 sd=160n \
        sca=19.4642 scb=0.0185905 scc=0.00114451 m=(2)
mp0_1__rcx (\19\:net61 \2\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.78e-06 sd=160n sca=29.498 \
        scb=0.0332632 scc=0.00250913 m=(2)
C1 (Y VSS) capacitor c=1.40792e-17
C2 (B VSS) capacitor c=3.17256e-17
C3 (VDD VSS) capacitor c=4.14809e-16
C4 (A VSS) capacitor c=1.41127e-17
C5 (net61 VSS) capacitor c=3.71972e-16
C6 (8 VSS) capacitor c=3.01608e-18
C7 (\1\:B VSS) capacitor c=1.25704e-16
C8 (\6\:A VSS) capacitor c=5.05167e-17
C9 (\5\:B VSS) capacitor c=3.8639e-17
C10 (\4\:B VSS) capacitor c=5.58512e-17
C11 (\1\:A VSS) capacitor c=5.69198e-17
C12 (\2\:A VSS) capacitor c=3.70307e-16
C13 (\1\:Y VSS) capacitor c=2.66394e-16
C14 (\14\:VDD VSS) capacitor c=6.72153e-17
C15 (\22\:net61 VSS) capacitor c=9.11791e-17
C16 (\8\:B VSS) capacitor c=4.34711e-17
C17 (\18\:net61 VSS) capacitor c=8.90207e-17
C18 (\19\:net61 VSS) capacitor c=2.28835e-16
C19 (\4\:Y VSS) capacitor c=2.0946e-16
Rk13 (\1\:Y Y) resistor r=0.0274 c=0
Rk14 (Y \4\:Y) resistor r=0.1844 c=0
Rk1 (\7\:B \8\:B) resistor r=0.005637 c=0
Rk2 (\9\:B B) resistor r=0.005637 c=0
Rk3 (\8\:B \9\:B) resistor r=0.04192 c=0
Rk35 (\7\:VSS VSS) resistor r=0.04971 c=0
Rk34 (\1\:VSS \7\:VSS) resistor r=0.3532 c=0
Rk38 (\7\:VSS \13\:VSS) resistor r=0.2777 c=0
Rk30 (VDD \15\:VDD) resistor r=0.3078 c=0
Rk5 (\2\:A A) resistor r=0.02629 c=0
Rk7 (net61 \18\:net61) resistor r=0.1702 c=0
Rk8 (\18\:net61 \19\:net61) resistor r=0.4053 c=0
Rk10 (\18\:net61 \23\:net61) resistor r=0.5215 c=0
Rl6 (\1\:B \5\:B) resistor r=76.1566 c=0
Rl5 (\1\:B \4\:B) resistor r=74.2328 c=0
Rl9 (\2\:A \6\:A) resistor r=29.9451 c=0
Rl1 (\2\:A \1\:A) resistor r=66.5539 c=0
Rz9 (\13\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\23\:net61 \22\:net61) resistor r=37.5 c=0
Ry10 (\15\:VDD \14\:VDD) resistor r=31 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
mn1_1__rcx (7 \1\:A \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.665e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn0_1__rcx (\22\:net61 \4\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.56e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn0 (\22\:net61 \5\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=4.16e-14 ps=7.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.355e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn1 (8 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.9e-14 \
        ad=2.73e-14 ps=1.02e-06 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=6e-07 sb=1.205e-06 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(1)
mn2_1__rcx (\4\:Y net61 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=4.836e-14 ps=9.56e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3129e-07 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp2_1__rcx (\1\:Y net61 VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.13617e-07 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:10 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2X8
// View name: extracted

simulator lang=spectre

subckt AND2X8 A B VDD VSS Y
mp1_1__rcx (\27\:n0 \1\:B \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.1462 scb=0.0152434 \
        scc=0.000513123 m=(2)
mp0_1__rcx (\27\:n0 \2\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.612e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=25.31 scb=0.0290957 \
        scc=0.00167407 m=(2)
C1 (Y VSS) capacitor c=1.66113e-17
C2 (B VSS) capacitor c=9.42672e-17
C3 (VDD VSS) capacitor c=5.12501e-16
C4 (A VSS) capacitor c=2.68405e-17
C5 (n0 VSS) capacitor c=5.84613e-16
C6 (8 VSS) capacitor c=1.77389e-18
C7 (\1\:B VSS) capacitor c=1.37391e-16
C8 (\6\:A VSS) capacitor c=6.28277e-17
C9 (\6\:B VSS) capacitor c=5.73994e-17
C10 (\5\:B VSS) capacitor c=5.31912e-17
C11 (\1\:A VSS) capacitor c=4.75057e-17
C12 (\2\:A VSS) capacitor c=3.64373e-16
C13 (\1\:Y VSS) capacitor c=3.78702e-16
C14 (\19\:VDD VSS) capacitor c=6.707e-17
C15 (\1\:VDD VSS) capacitor c=2.21237e-17
C16 (\30\:n0 VSS) capacitor c=8.99072e-17
C17 (\26\:n0 VSS) capacitor c=8.58609e-17
C18 (\27\:n0 VSS) capacitor c=2.18554e-16
C19 (\4\:Y VSS) capacitor c=3.96174e-16
Rk12 (\1\:Y Y) resistor r=0.1251 c=0
Rk13 (Y \4\:Y) resistor r=0.08761 c=0
Rk1 (\8\:B B) resistor r=0.003831 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.1855 c=0
Rk44 (\8\:VSS VSS) resistor r=0.04973 c=0
Rk43 (\3\:VSS \8\:VSS) resistor r=0.3509 c=0
Rk49 (\8\:VSS \18\:VSS) resistor r=0.2689 c=0
Rk25 (\2\:VDD VDD) resistor r=0.1579 c=0
Rk37 (VDD \20\:VDD) resistor r=0.2723 c=0
Rk3 (\2\:A A) resistor r=0.1048 c=0
Rk6 (n0 \26\:n0) resistor r=0.2209 c=0
Rk7 (\26\:n0 \27\:n0) resistor r=0.3448 c=0
Rk9 (\26\:n0 \31\:n0) resistor r=0.532 c=0
Rl7 (\1\:B \6\:B) resistor r=97.7911 c=0
Rl6 (\1\:B \5\:B) resistor r=97.7911 c=0
Rl10 (\2\:A \6\:A) resistor r=32.0055 c=0
Rl1 (\2\:A \1\:A) resistor r=32.6923 c=0
Rz12 (\18\:VSS \17\:VSS) resistor r=37.5 c=0
Rz7 (VDD \1\:VDD) resistor r=6.25 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz1 (\31\:n0 \30\:n0) resistor r=37.5 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry12 (\20\:VDD \19\:VDD) resistor r=31 c=0
Rx1 (\8\:B \1\:B) resistor r=45 c=0
mn0_1__rcx (7 \1\:A \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn1_1__rcx (\30\:n0 \5\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.955e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn1 (\30\:n0 \6\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=1.75e-06 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn0 (8 \6\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.47e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.645e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn2_1__rcx (\4\:Y n0 \3\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.97e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.56949e-07 sb=1.37e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mp2_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.212e-14 ad=6.993e-14 ps=1.21714e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.75618e-07 sb=1.37e-06 sd=160n \
        sca=15.1493 scb=0.013431 scc=0.000976912 m=(7)
ends AND2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:11 2013 )
// Library name: gsclib045_hvt
// Cell name: AND2XL
// View name: extracted

simulator lang=spectre

subckt AND2XL A B VDD VSS Y
mp1 (\9\:net57 \4\:B \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=1.47e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=31.2881 scb=0.0351388 \
        scc=0.00259704 m=(1)
mp0 (\9\:net57 \4\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.45e-07 sd=160n sca=20.7658 \
        scb=0.021645 scc=0.000601202 m=(1)
mp2 (\1\:Y net57 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=27.1972 \
        scb=0.0311782 scc=0.00169862 m=(1)
C1 (Y VSS) capacitor c=4.81311e-17
C2 (VDD VSS) capacitor c=7.41524e-17
C3 (A VSS) capacitor c=3.65295e-17
C4 (net73 VSS) capacitor c=1.08081e-18
C5 (net57 VSS) capacitor c=4.70951e-17
C6 (\4\:A VSS) capacitor c=3.60618e-17
C7 (\4\:B VSS) capacitor c=3.97775e-17
C8 (\4\:net57 VSS) capacitor c=2.8702e-17
C9 (\3\:A VSS) capacitor c=6.82603e-17
C10 (\1\:B VSS) capacitor c=4.67036e-17
C11 (\3\:net57 VSS) capacitor c=2.66671e-17
C12 (\1\:A VSS) capacitor c=2.66418e-17
C13 (\3\:B VSS) capacitor c=1.04529e-17
C14 (\1\:Y VSS) capacitor c=4.3802e-17
C15 (\1\:VDD VSS) capacitor c=3.13807e-17
C16 (\9\:net57 VSS) capacitor c=4.68833e-17
C17 (\5\:VDD VSS) capacitor c=4.48543e-18
C18 (\3\:Y VSS) capacitor c=1.79893e-17
C19 (\7\:net57 VSS) capacitor c=3.41293e-17
C20 (\2\:B VSS) capacitor c=3.43263e-17
C21 (\2\:A VSS) capacitor c=4.16506e-17
C22 (\2\:net57 VSS) capacitor c=2.93658e-17
C23 (\5\:B VSS) capacitor c=2.04077e-17
C24 (\7\:B VSS) capacitor c=3.62259e-17
C25 (\5\:A VSS) capacitor c=4.76732e-17
C26 (\5\:net57 VSS) capacitor c=4.72528e-17
C27 (\6\:net57 VSS) capacitor c=5.29676e-17
C28 (\4\:VDD VSS) capacitor c=1.60022e-17
Rk14 (\4\:VSS VSS) resistor r=0.1499 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3677 c=0
Rk1 (\5\:B \6\:B) resistor r=0.001154 c=0
Rk2 (B \7\:B) resistor r=0.001038 c=0
Rk3 (\5\:B \7\:B) resistor r=0.0269 c=0
Rk8 (\2\:Y Y) resistor r=0.3123 c=0
Rk9 (Y \4\:Y) resistor r=0.06276 c=0
Rk11 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3481 c=0
Rk12 (VDD \6\:VDD) resistor r=0.1178 c=0
Rk4 (A \5\:A) resistor r=0.05388 c=0
Rk5 (\5\:net57 \6\:net57) resistor r=0.1568 c=0
Rk6 (\6\:net57 \8\:net57) resistor r=0.1877 c=0
Rk7 (\6\:net57 \10\:net57) resistor r=0.3018 c=0
Rl3 (\2\:B \4\:B) resistor r=99.4619 c=0
Rl1 (\1\:B \2\:B) resistor r=76.4327 c=0
Rl2 (\2\:B \3\:B) resistor r=4.5402 c=0
Rl6 (\2\:A \4\:A) resistor r=52.7257 c=0
Rl5 (\2\:A \3\:A) resistor r=116.187 c=0
Rl4 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl7 (net57 \2\:net57) resistor r=121.957 c=0
Rl9 (\2\:net57 \4\:net57) resistor r=46.9565 c=0
Rl8 (\2\:net57 \3\:net57) resistor r=2.4801 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz1 (\7\:net57 \8\:net57) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\9\:net57 \10\:net57) resistor r=62 c=0
Rx1 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx3 (\3\:net57 \5\:net57) resistor r=45 c=0
mn1 (\7\:net57 \1\:B net73 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=2.03e-14 ps=4.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn0 (net73 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.43e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn2 (\3\:Y \4\:net57 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
ends AND2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:12 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3X1
// View name: extracted

simulator lang=spectre

subckt AND3X1 A B C VDD VSS Y
mp2 (\7\:net086 \4\:C \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.57e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=15.6848 \
        scb=0.0150605 scc=0.00022885 m=(1)
mp1 (\11\:net086 \1\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.57e-14 ad=5.913e-14 ps=1.41e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.3e-07 sd=160n sca=11.8763 \
        scb=0.00832069 scc=7.33429e-05 m=(1)
mp0 (\11\:net086 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=5.913e-14 ps=1.2e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=4.1e-07 sd=160n sca=12.6661 \
        scb=0.00970078 scc=8.28205e-05 m=(1)
C1 (B VSS) capacitor c=5.50045e-17
C2 (Y VSS) capacitor c=3.81307e-17
C3 (VDD VSS) capacitor c=1.39859e-16
C4 (C VSS) capacitor c=7.4176e-17
C5 (A VSS) capacitor c=1.07278e-16
C6 (net0106 VSS) capacitor c=3.45924e-18
C7 (net086 VSS) capacitor c=5.55202e-17
C8 (net0102 VSS) capacitor c=7.37195e-18
C9 (\1\:A VSS) capacitor c=3.53756e-17
C10 (\1\:B VSS) capacitor c=5.03372e-17
C11 (\4\:C VSS) capacitor c=3.64815e-17
C12 (\3\:net086 VSS) capacitor c=3.30483e-17
C13 (\3\:A VSS) capacitor c=4.83883e-17
C14 (\3\:B VSS) capacitor c=4.29988e-17
C15 (\1\:C VSS) capacitor c=5.49272e-17
C16 (\2\:net086 VSS) capacitor c=2.93631e-17
C17 (\2\:A VSS) capacitor c=4.19747e-17
C18 (\2\:B VSS) capacitor c=5.6811e-17
C19 (\3\:C VSS) capacitor c=1.74217e-17
C20 (\3\:Y VSS) capacitor c=5.55222e-17
C21 (\1\:VDD VSS) capacitor c=4.57657e-17
C22 (\11\:net086 VSS) capacitor c=1.53279e-17
C23 (\6\:VDD VSS) capacitor c=1.63619e-17
C24 (\7\:net086 VSS) capacitor c=3.46866e-17
C25 (\1\:Y VSS) capacitor c=1.80809e-17
C26 (\9\:net086 VSS) capacitor c=3.19277e-17
C27 (\2\:C VSS) capacitor c=5.24036e-17
C28 (\4\:B VSS) capacitor c=5.13344e-17
C29 (\4\:net086 VSS) capacitor c=6.40741e-17
C30 (\5\:net086 VSS) capacitor c=9.72727e-17
C31 (\6\:net086 VSS) capacitor c=8.45039e-17
C32 (\4\:VDD VSS) capacitor c=2.21709e-17
C33 (\5\:VDD VSS) capacitor c=9.00338e-18
Rk16 (\4\:VSS VSS) resistor r=0.2995 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.4236 c=0
Rk2 (\4\:B B) resistor r=0.1521 c=0
Rk9 (Y \2\:Y) resistor r=0.0806 c=0
Rk10 (Y \4\:Y) resistor r=0.3403 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.3956 c=0
Rk13 (\5\:VDD VDD) resistor r=0.1819 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1172 c=0
Rk14 (\5\:VDD \7\:VDD) resistor r=0.07288 c=0
Rk1 (\5\:C C) resistor r=0.003669 c=0
Rk3 (\4\:A A) resistor r=0.002985 c=0
Rk4 (\4\:net086 \5\:net086) resistor r=0.3756 c=0
Rk5 (\5\:net086 \6\:net086) resistor r=0.524 c=0
Rk6 (\6\:net086 \8\:net086) resistor r=0.3158 c=0
Rk7 (\5\:net086 \10\:net086) resistor r=0.2639 c=0
Rk8 (\6\:net086 \12\:net086) resistor r=0.05686 c=0
Rl4 (\1\:B \2\:B) resistor r=127.615 c=0
Rl5 (\2\:B \3\:B) resistor r=87.2302 c=0
Rl3 (\2\:C \4\:C) resistor r=49.4619 c=0
Rl1 (\1\:C \2\:C) resistor r=191.817 c=0
Rl2 (\2\:C \3\:C) resistor r=23.4547 c=0
Rl6 (\1\:A \2\:A) resistor r=55.7692 c=0
Rl7 (\2\:A \3\:A) resistor r=160.714 c=0
Rl8 (net086 \2\:net086) resistor r=114.56 c=0
Rl9 (\2\:net086 \3\:net086) resistor r=26.098 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\9\:net086 \10\:net086) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\7\:net086 \8\:net086) resistor r=62 c=0
Ry2 (\11\:net086 \12\:net086) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:net086 \4\:net086) resistor r=45 c=0
mn2 (\9\:net086 \1\:C net0106 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn1 (net0106 \3\:B net0102 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=7.3e-07 sd=160n sca=14.3814 scb=0.0152134 \
        scc=0.00088947 m=(1)
mn0 (net0102 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.452e-14 ad=3.19e-14 ps=1.05e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.65e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn3 (\1\:Y \3\:net086 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.452e-14 ad=4.03e-14 ps=1.05e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.49904e-07 sb=1.55e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mp3 (\3\:Y net086 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=6.045e-14 ps=1.2e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85128e-07 sb=1.55e-07 sd=160n sca=23.7459 \
        scb=0.0272453 scc=0.00137918 m=(1)
ends AND3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:13 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3X2
// View name: extracted

simulator lang=spectre

subckt AND3X2 A B C VDD VSS Y
mp2 (\12\:net95 \4\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=14.6753 \
        scb=0.0132849 scc=0.000158573 m=(1)
mp1 (\16\:net95 \1\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=11.6912 \
        scb=0.00845015 scc=7.57653e-05 m=(1)
mp0 (\16\:net95 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.308e-14 ad=4.73e-14 ps=1.39e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.95e-07 sd=160n sca=10.953 \
        scb=0.00760955 scc=7.37526e-05 m=(1)
C1 (B VSS) capacitor c=5.90587e-17
C2 (Y VSS) capacitor c=3.2634e-17
C3 (VDD VSS) capacitor c=1.3201e-16
C4 (C VSS) capacitor c=7.255e-17
C5 (net111 VSS) capacitor c=2.97085e-18
C6 (net95 VSS) capacitor c=1.57675e-16
C7 (net103 VSS) capacitor c=4.94232e-18
C8 (\1\:A VSS) capacitor c=3.13369e-17
C9 (\1\:B VSS) capacitor c=6.27434e-17
C10 (\4\:C VSS) capacitor c=4.33193e-17
C11 (\3\:A VSS) capacitor c=6.878e-17
C12 (\3\:B VSS) capacitor c=3.51583e-17
C13 (\1\:C VSS) capacitor c=4.8473e-17
C14 (\5\:net95 VSS) capacitor c=2.30571e-17
C15 (\2\:A VSS) capacitor c=4.67882e-17
C16 (\2\:B VSS) capacitor c=6.3209e-17
C17 (\3\:C VSS) capacitor c=1.89649e-17
C18 (\1\:VDD VSS) capacitor c=1.06568e-16
C19 (\1\:Y VSS) capacitor c=8.67248e-17
C20 (\16\:net95 VSS) capacitor c=2.73411e-17
C21 (\9\:VDD VSS) capacitor c=2.97318e-17
C22 (\12\:net95 VSS) capacitor c=4.14911e-17
C23 (\3\:Y VSS) capacitor c=2.20466e-17
C24 (\14\:net95 VSS) capacitor c=6.18669e-17
C25 (\2\:C VSS) capacitor c=5.67886e-17
C26 (\4\:B VSS) capacitor c=5.4692e-17
C27 (\4\:A VSS) capacitor c=1.09302e-16
C28 (\9\:net95 VSS) capacitor c=2.99105e-17
C29 (\10\:net95 VSS) capacitor c=7.69272e-17
C30 (\11\:net95 VSS) capacitor c=5.65291e-17
C31 (\5\:VDD VSS) capacitor c=1.73587e-17
C32 (\6\:VDD VSS) capacitor c=1.33619e-17
Rk19 (\5\:VSS VSS) resistor r=0.3495 c=0
Rk18 (\1\:VSS \5\:VSS) resistor r=0.08474 c=0
Rk2 (B \4\:B) resistor r=0.1673 c=0
Rk9 (\2\:Y Y) resistor r=0.3831 c=0
Rk10 (Y \4\:Y) resistor r=0.1549 c=0
Rk12 (\1\:VDD \5\:VDD) resistor r=0.1222 c=0
Rk14 (\6\:VDD VDD) resistor r=0.1844 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.1647 c=0
Rk16 (\6\:VDD \10\:VDD) resistor r=0.2114 c=0
Rk1 (\5\:C C) resistor r=0.003669 c=0
Rk3 (A \4\:A) resistor r=0.009655 c=0
Rk4 (\9\:net95 \10\:net95) resistor r=0.1692 c=0
Rk5 (\10\:net95 \11\:net95) resistor r=0.3417 c=0
Rk6 (\11\:net95 \13\:net95) resistor r=0.3168 c=0
Rk7 (\10\:net95 \15\:net95) resistor r=0.4695 c=0
Rk8 (\11\:net95 \17\:net95) resistor r=0.07812 c=0
Rl4 (\1\:B \2\:B) resistor r=212.23 c=0
Rl5 (\2\:B \3\:B) resistor r=39.1533 c=0
Rl3 (\2\:C \4\:C) resistor r=118.693 c=0
Rl1 (\1\:C \2\:C) resistor r=136.048 c=0
Rl2 (\2\:C \3\:C) resistor r=28.0599 c=0
Rl6 (\1\:A \2\:A) resistor r=41.0764 c=0
Rl7 (\2\:A \3\:A) resistor r=210.307 c=0
Rl11 (net95 \5\:net95) resistor r=9.7447 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz1 (\15\:net95 \14\:net95) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry6 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\13\:net95 \12\:net95) resistor r=62 c=0
Ry2 (\17\:net95 \16\:net95) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\9\:net95 \5\:net95) resistor r=45 c=0
mn2 (\14\:net95 \1\:C net111 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.005e-06 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn1 (net111 \3\:B net103 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=8.45e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn0 (net103 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.19e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=5.8e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn3 (\3\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.772e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.90385e-07 sb=3.45e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(2)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.884e-14 ad=6.24e-14 ps=1.225e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.74103e-07 sb=3.45e-07 sd=160n sca=16.4316 \
        scb=0.0156277 scc=0.000553705 m=(2)
ends AND3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:14 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3X4
// View name: extracted

simulator lang=spectre

subckt AND3X4 A B C VDD VSS Y
mp2 (\19\:net95 \4\:C \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.46e-06 sd=160n sca=20.2396 \
        scb=0.0225687 scc=0.000779912 m=(1)
mp1 (\24\:net95 \1\:B \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.02e-14 ps=1.1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.255e-06 sd=160n sca=14.1782 \
        scb=0.0124204 scc=0.000272457 m=(1)
mp0 (\24\:net95 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=7.02e-14 ps=1.24e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.03e-06 sd=160n sca=12.3454 \
        scb=0.0101149 scc=0.000258484 m=(1)
mp3 (\6\:Y net95 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.727e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=7.55e-07 sd=160n sca=11.834 \
        scb=0.00982597 scc=0.000258275 m=(4)
C1 (B VSS) capacitor c=3.36255e-17
C2 (VDD VSS) capacitor c=1.28885e-16
C3 (C VSS) capacitor c=3.59112e-17
C4 (A VSS) capacitor c=6.70501e-17
C5 (Y VSS) capacitor c=3.31237e-17
C6 (net111 VSS) capacitor c=2.13561e-18
C7 (net95 VSS) capacitor c=3.46903e-16
C8 (net107 VSS) capacitor c=9.55355e-18
C9 (\1\:A VSS) capacitor c=3.71455e-17
C10 (\1\:B VSS) capacitor c=5.82257e-17
C11 (\4\:C VSS) capacitor c=4.68257e-17
C12 (\3\:A VSS) capacitor c=5.9143e-17
C13 (\3\:B VSS) capacitor c=5.433e-17
C14 (\1\:C VSS) capacitor c=5.20043e-17
C15 (\2\:A VSS) capacitor c=3.39306e-17
C16 (\2\:B VSS) capacitor c=5.22365e-17
C17 (\3\:C VSS) capacitor c=1.55028e-17
C18 (\1\:VDD VSS) capacitor c=1.96193e-16
C19 (\24\:net95 VSS) capacitor c=3.2645e-17
C20 (\12\:VDD VSS) capacitor c=3.86605e-17
C21 (\19\:net95 VSS) capacitor c=4.28942e-17
C22 (\2\:Y VSS) capacitor c=1.20437e-16
C23 (\22\:net95 VSS) capacitor c=5.28087e-17
C24 (\2\:C VSS) capacitor c=3.30876e-17
C25 (\5\:C VSS) capacitor c=5.02829e-17
C26 (\4\:B VSS) capacitor c=8.1061e-17
C27 (\4\:A VSS) capacitor c=4.6668e-17
C28 (\17\:net95 VSS) capacitor c=1.21241e-16
C29 (\18\:net95 VSS) capacitor c=5.50785e-17
C30 (\1\:Y VSS) capacitor c=3.11646e-17
C31 (\6\:Y VSS) capacitor c=1.85948e-16
C32 (\7\:VDD VSS) capacitor c=1.53575e-17
Rk2 (\4\:B B) resistor r=0.08928 c=0
Rk28 (\1\:VSS VSS) resistor r=0.3256 c=0
Rk21 (\7\:VDD VDD) resistor r=0.1325 c=0
Rk20 (\1\:VDD \7\:VDD) resistor r=0.2153 c=0
Rk24 (\7\:VDD \13\:VDD) resistor r=0.1912 c=0
Rk1 (C \5\:C) resistor r=0.07811 c=0
Rk3 (\4\:A A) resistor r=0.09542 c=0
Rk11 (Y \1\:Y) resistor r=0.08517 c=0
Rk12 (\1\:Y \2\:Y) resistor r=0.242 c=0
Rk14 (\1\:Y \6\:Y) resistor r=0.2064 c=0
Rk5 (net95 \17\:net95) resistor r=0.3732 c=0
Rk6 (\17\:net95 \18\:net95) resistor r=0.3431 c=0
Rk7 (\18\:net95 \20\:net95) resistor r=0.3361 c=0
Rk9 (\17\:net95 \23\:net95) resistor r=0.5116 c=0
Rk10 (\18\:net95 \25\:net95) resistor r=0.08444 c=0
Rl4 (\1\:B \2\:B) resistor r=107.432 c=0
Rl5 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl3 (\2\:C \4\:C) resistor r=108.144 c=0
Rl1 (\1\:C \2\:C) resistor r=50.452 c=0
Rl2 (\2\:C \3\:C) resistor r=17.6672 c=0
Rl6 (\1\:A \2\:A) resistor r=28.079 c=0
Rl7 (\2\:A \3\:A) resistor r=104.568 c=0
Rz1 (\23\:net95 \22\:net95) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\20\:net95 \19\:net95) resistor r=31 c=0
Ry2 (\25\:net95 \24\:net95) resistor r=31 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
mn2 (\22\:net95 \1\:C net111 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (net111 \3\:B net107 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.31e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn0 (net107 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.045e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\2\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.582e-14 ad=4.355e-14 ps=8.725e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=8.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
ends AND3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:15 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3X6
// View name: extracted

simulator lang=spectre

subckt AND3X6 A B C VDD VSS Y
mp2_1__rcx (\28\:net95 \3\:C \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.78e-06 sd=160n sca=16.5772 \
        scb=0.0145683 scc=0.00110293 m=(2)
mp0_1__rcx (\20\:net95 \2\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.7336 scb=0.0242625 \
        scc=0.00139021 m=(2)
mp1_1__rcx (\20\:net95 \1\:B \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.985e-06 sd=160n sca=18.0437 \
        scb=0.0162495 scc=0.00111028 m=(2)
C1 (B VSS) capacitor c=3.04732e-17
C2 (Y VSS) capacitor c=1.71916e-17
C3 (VDD VSS) capacitor c=9.73785e-17
C4 (C VSS) capacitor c=6.77684e-17
C5 (A VSS) capacitor c=1.31641e-17
C6 (8 VSS) capacitor c=3.08927e-18
C7 (9 VSS) capacitor c=6.29784e-18
C8 (net95 VSS) capacitor c=3.67235e-16
C9 (10 VSS) capacitor c=4.80329e-18
C10 (11 VSS) capacitor c=5.23142e-18
C11 (\1\:B VSS) capacitor c=3.85788e-16
C12 (\6\:A VSS) capacitor c=5.10674e-17
C13 (\6\:B VSS) capacitor c=5.54611e-17
C14 (\1\:C VSS) capacitor c=4.60939e-17
C15 (\4\:C VSS) capacitor c=2.94407e-17
C16 (\3\:B VSS) capacitor c=4.7469e-17
C17 (\1\:A VSS) capacitor c=3.91749e-17
C18 (\3\:C VSS) capacitor c=9.02886e-17
C19 (\2\:A VSS) capacitor c=4.6768e-16
C20 (\1\:Y VSS) capacitor c=2.66547e-16
C21 (\20\:net95 VSS) capacitor c=2.4562e-16
C22 (\28\:net95 VSS) capacitor c=3.49665e-17
C23 (\1\:VDD VSS) capacitor c=2.0531e-17
C24 (\25\:net95 VSS) capacitor c=1.03002e-16
C25 (\2\:C VSS) capacitor c=3.26381e-17
C26 (\7\:C VSS) capacitor c=7.58069e-17
C27 (\19\:net95 VSS) capacitor c=1.18493e-16
C28 (\4\:Y VSS) capacitor c=2.03145e-16
C29 (\3\:VDD VSS) capacitor c=3.77976e-16
Rk2 (B \1\:B) resistor r=0.08417 c=0
Rk15 (\1\:Y Y) resistor r=0.03946 c=0
Rk16 (Y \4\:Y) resistor r=0.1341 c=0
Rk31 (\3\:VDD VDD) resistor r=0.04722 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.1277 c=0
Rk1 (C \7\:C) resistor r=0.03078 c=0
Rk5 (\2\:A A) resistor r=0.01856 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.1277 c=0
Rk41 (\3\:VSS \6\:VSS) resistor r=0.09669 c=0
Rk43 (\7\:VSS VSS) resistor r=0.06729 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.484 c=0
Rk47 (\7\:VSS \15\:VSS) resistor r=0.2202 c=0
Rk7 (net95 \19\:net95) resistor r=0.173 c=0
Rk8 (\19\:net95 \20\:net95) resistor r=0.3562 c=0
Rk11 (\19\:net95 \26\:net95) resistor r=0.7529 c=0
Rk13 (\20\:net95 \29\:net95) resistor r=0.06656 c=0
Rl11 (\1\:B \6\:B) resistor r=44.9225 c=0
Rl4 (\1\:B \3\:B) resistor r=33.3841 c=0
Rl5 (\2\:C \1\:C) resistor r=126.408 c=0
Rl7 (\2\:C \4\:C) resistor r=76.9865 c=0
Rl6 (\2\:C \3\:C) resistor r=6.3032 c=0
Rl13 (\2\:A \6\:A) resistor r=30.5643 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz10 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\26\:net95 \25\:net95) resistor r=75 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry15 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry4 (\29\:net95 \28\:net95) resistor r=31 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0_1__rcx (8 \1\:A \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.85615e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (8 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=2.34e-14 ps=9.3e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.82269e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\25\:net95 \4\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.57269e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (\25\:net95 \1\:C 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.36769e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (10 \6\:B 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.6e-14 \
        ad=2.99e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.9e-07 sb=1.20769e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0 (11 \6\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.12e-14 ad=2.6e-14 ps=1.59e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.06269e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (\4\:Y net95 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.792e-14 ad=4.836e-14 ps=1.07e-06 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.51613e-07 sb=9.6e-07 sd=160n sca=15.4364 \
        scb=0.0149022 scc=0.00127268 m=(5)
mp3_1__rcx (\1\:Y net95 \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15383e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND3X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:16 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3X8
// View name: extracted

simulator lang=spectre

subckt AND3X8 A B C VDD VSS Y
mp0_1__rcx (\26\:net95 A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.5202 scb=0.022579 \
        scc=0.00122627 m=(2)
mp1 (\26\:net95 \2\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.4295 scb=0.0156155 \
        scc=0.00102793 m=(2)
mp2_1__rcx (\34\:net95 \3\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=16.0917 scb=0.0141872 \
        scc=0.00102282 m=(2)
C1 (B VSS) capacitor c=2.56319e-17
C2 (Y VSS) capacitor c=1.38264e-17
C3 (VDD VSS) capacitor c=1.10739e-16
C4 (C VSS) capacitor c=4.14103e-17
C5 (A VSS) capacitor c=4.52852e-16
C6 (8 VSS) capacitor c=1.65755e-18
C7 (9 VSS) capacitor c=3.18662e-18
C8 (net95 VSS) capacitor c=4.91334e-16
C9 (10 VSS) capacitor c=4.80329e-18
C10 (11 VSS) capacitor c=4.63574e-18
C11 (\6\:A VSS) capacitor c=5.18361e-17
C12 (\6\:B VSS) capacitor c=5.83086e-17
C13 (\1\:C VSS) capacitor c=4.63633e-17
C14 (\4\:C VSS) capacitor c=4.10662e-17
C15 (\1\:B VSS) capacitor c=6.65424e-17
C16 (\1\:A VSS) capacitor c=7.24325e-17
C17 (\3\:C VSS) capacitor c=8.90002e-17
C18 (\2\:B VSS) capacitor c=3.64837e-16
C19 (\1\:Y VSS) capacitor c=3.80497e-16
C20 (\1\:VDD VSS) capacitor c=4.85905e-16
C21 (\26\:net95 VSS) capacitor c=2.35025e-16
C22 (\34\:net95 VSS) capacitor c=3.54448e-17
C23 (\28\:net95 VSS) capacitor c=1.03177e-16
C24 (\2\:C VSS) capacitor c=3.87272e-17
C25 (\7\:C VSS) capacitor c=4.53359e-17
C26 (\25\:net95 VSS) capacitor c=1.08174e-16
C27 (\4\:Y VSS) capacitor c=1.96477e-16
Rk2 (B \2\:B) resistor r=0.08401 c=0
Rk16 (\1\:Y Y) resistor r=0.1808 c=0
Rk17 (Y \4\:Y) resistor r=0.01238 c=0
Rk41 (\1\:VDD VDD) resistor r=0.05722 c=0
Rk1 (C \7\:C) resistor r=0.03357 c=0
Rk46 (\1\:VSS \8\:VSS) resistor r=0.1067 c=0
Rk48 (\9\:VSS VSS) resistor r=0.1375 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.4135 c=0
Rk52 (\9\:VSS \17\:VSS) resistor r=0.2193 c=0
Rk8 (net95 \25\:net95) resistor r=0.2269 c=0
Rk9 (\25\:net95 \26\:net95) resistor r=0.3525 c=0
Rk10 (\25\:net95 \29\:net95) resistor r=0.7173 c=0
Rk14 (\26\:net95 \35\:net95) resistor r=0.05786 c=0
Rl11 (\2\:B \6\:B) resistor r=44.9225 c=0
Rl3 (\2\:B \1\:B) resistor r=33.3841 c=0
Rl5 (\2\:C \1\:C) resistor r=128.331 c=0
Rl7 (\2\:C \4\:C) resistor r=78.9095 c=0
Rl6 (\2\:C \3\:C) resistor r=5.5053 c=0
Rl13 (A \6\:A) resistor r=29.2744 c=0
Rl1 (A \1\:A) resistor r=98.0541 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\29\:net95 \28\:net95) resistor r=75 c=0
Ry16 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry17 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry4 (\35\:net95 \34\:net95) resistor r=31 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0_1__rcx (8 \1\:A \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.75654e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (8 \1\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.73231e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\28\:net95 \4\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.69538e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (\28\:net95 \1\:C 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.60192e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (10 \6\:B 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=2.99e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 sa=7.7e-07 \
        sb=1.44192e-06 sd=160n sca=10.3222 scb=0.00938145 scc=0.000353946 \
        m=(1)
mn0 (11 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=2.34e-14 ps=1.62e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.30692e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (\4\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=5.379e-14 ad=4.636e-14 ps=1.01143e-06 pd=9.0429e-07 \
        nrd=1.16667 nrs=1.16667 sa=8.32203e-07 sb=1.37e-06 sd=160n \
        sca=16.4223 scb=0.0158966 scc=0.0014413 m=(7)
mp3_1__rcx (\1\:Y net95 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.21303e-06 sb=1.37e-06 sd=160n \
        sca=20.7359 scb=0.0165012 scc=0.00199728 m=(7)
ends AND3X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:17 2013 )
// Library name: gsclib045_hvt
// Cell name: AND3XL
// View name: extracted

simulator lang=spectre

subckt AND3XL A B C VDD VSS Y
mp2 (\7\:net87 \4\:C \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.75e-07 sd=160n sca=19.7407 \
        scb=0.0215266 scc=0.00071564 m=(1)
mp1 (\4\:net87 \1\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.7e-07 sd=160n sca=13.7568 \
        scb=0.0109184 scc=0.000115551 m=(1)
mp0 (\4\:net87 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.73e-14 ps=8.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.05e-07 sd=160n sca=13.5637 \
        scb=0.0105289 scc=0.000110426 m=(1)
mp3 (\3\:Y net87 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.655e-14 ps=8.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.7e-07 sd=160n sca=20.4171 \
        scb=0.0224816 scc=0.000827904 m=(1)
C1 (B VSS) capacitor c=4.33354e-17
C2 (Y VSS) capacitor c=6.91493e-17
C3 (VDD VSS) capacitor c=1.35109e-16
C4 (C VSS) capacitor c=7.1055e-17
C5 (A VSS) capacitor c=4.09845e-17
C6 (net107 VSS) capacitor c=1.79372e-18
C7 (net87 VSS) capacitor c=5.52244e-17
C8 (net103 VSS) capacitor c=6.25767e-18
C9 (\1\:A VSS) capacitor c=4.0129e-17
C10 (\1\:B VSS) capacitor c=5.21675e-17
C11 (\4\:C VSS) capacitor c=5.58638e-17
C12 (\3\:net87 VSS) capacitor c=2.87435e-17
C13 (\3\:A VSS) capacitor c=5.13462e-17
C14 (\3\:B VSS) capacitor c=6.01433e-17
C15 (\1\:C VSS) capacitor c=4.36383e-17
C16 (\2\:net87 VSS) capacitor c=4.6192e-17
C17 (\2\:A VSS) capacitor c=4.89283e-17
C18 (\2\:B VSS) capacitor c=5.86724e-17
C19 (\3\:C VSS) capacitor c=1.58032e-17
C20 (\3\:Y VSS) capacitor c=6.48958e-17
C21 (\1\:VDD VSS) capacitor c=2.73227e-17
C22 (\4\:net87 VSS) capacitor c=2.15585e-17
C23 (\6\:VDD VSS) capacitor c=2.33663e-17
C24 (\7\:net87 VSS) capacitor c=4.7985e-17
C25 (\10\:net87 VSS) capacitor c=3.31502e-17
C26 (\2\:C VSS) capacitor c=5.41769e-17
C27 (\4\:B VSS) capacitor c=6.51061e-17
C28 (\4\:A VSS) capacitor c=6.84496e-17
C29 (\6\:net87 VSS) capacitor c=6.14087e-17
C30 (\9\:net87 VSS) capacitor c=1.08324e-16
C31 (\12\:net87 VSS) capacitor c=4.9914e-17
C32 (\4\:VDD VSS) capacitor c=3.04549e-17
C33 (\5\:VDD VSS) capacitor c=1.00481e-17
Rk16 (\4\:VSS VSS) resistor r=0.2505 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.3877 c=0
Rk2 (\4\:B B) resistor r=0.04707 c=0
Rk9 (\2\:Y Y) resistor r=0.006001 c=0
Rk10 (Y \4\:Y) resistor r=0.5101 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.2876 c=0
Rk13 (\5\:VDD VDD) resistor r=0.1274 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1227 c=0
Rk14 (\5\:VDD \7\:VDD) resistor r=0.1739 c=0
Rk1 (\5\:C C) resistor r=0.003 c=0
Rk3 (\4\:A A) resistor r=0.09325 c=0
Rk4 (\5\:net87 \6\:net87) resistor r=0.07419 c=0
Rk5 (\6\:net87 \8\:net87) resistor r=0.3205 c=0
Rk6 (\6\:net87 \9\:net87) resistor r=0.4655 c=0
Rk7 (\9\:net87 \11\:net87) resistor r=0.3828 c=0
Rk8 (\9\:net87 \12\:net87) resistor r=0.2172 c=0
Rl4 (\1\:B \2\:B) resistor r=148.077 c=0
Rl5 (\2\:B \3\:B) resistor r=112.637 c=0
Rl3 (\2\:C \4\:C) resistor r=214.846 c=0
Rl1 (\1\:C \2\:C) resistor r=47.5865 c=0
Rl2 (\2\:C \3\:C) resistor r=15.5599 c=0
Rl6 (\1\:A \2\:A) resistor r=89.1533 c=0
Rl7 (\2\:A \3\:A) resistor r=169.923 c=0
Rl8 (net87 \2\:net87) resistor r=219.923 c=0
Rl9 (\2\:net87 \3\:net87) resistor r=36.5184 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\10\:net87 \11\:net87) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\4\:net87 \5\:net87) resistor r=62 c=0
Ry2 (\7\:net87 \8\:net87) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:net87 \12\:net87) resistor r=45 c=0
mn2 (\10\:net87 \1\:C net107 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (net107 \3\:B net103 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (net103 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\1\:Y \3\:net87 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
ends AND3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:18 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4X1
// View name: extracted

simulator lang=spectre

subckt AND4X1 A B C D VDD VSS Y
mp3 (\10\:net116 \3\:D \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
mp2 (\10\:net116 \1\:C \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.15e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp1 (\12\:net116 \1\:B \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.5e-07 sd=160n sca=12.5692 \
        scb=0.0096429 scc=0.000174148 m=(1)
mp0 (\12\:net116 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=3.45e-07 sd=160n sca=13.1799 \
        scb=0.0106657 scc=0.000178932 m=(1)
C1 (B VSS) capacitor c=7.03804e-17
C2 (Y VSS) capacitor c=2.12708e-17
C3 (VDD VSS) capacitor c=1.17629e-16
C4 (C VSS) capacitor c=4.14634e-17
C5 (D VSS) capacitor c=2.12307e-17
C6 (A VSS) capacitor c=4.70205e-17
C7 (net132 VSS) capacitor c=3.16837e-18
C8 (net116 VSS) capacitor c=6.22043e-17
C9 (net128 VSS) capacitor c=6.54738e-18
C10 (net124 VSS) capacitor c=2.75199e-18
C11 (\1\:A VSS) capacitor c=6.08709e-17
C12 (\1\:B VSS) capacitor c=5.7526e-17
C13 (\1\:C VSS) capacitor c=6.06036e-17
C14 (\3\:D VSS) capacitor c=4.8431e-17
C15 (\4\:net116 VSS) capacitor c=3.67017e-17
C16 (\3\:A VSS) capacitor c=4.38366e-17
C17 (\4\:B VSS) capacitor c=3.54822e-17
C18 (\3\:C VSS) capacitor c=3.45879e-17
C19 (\1\:D VSS) capacitor c=3.10519e-17
C20 (\3\:net116 VSS) capacitor c=3.87643e-17
C21 (\2\:A VSS) capacitor c=5.92011e-17
C22 (\3\:B VSS) capacitor c=2.57789e-17
C23 (\2\:C VSS) capacitor c=6.11853e-17
C24 (\2\:D VSS) capacitor c=6.11824e-17
C25 (\1\:Y VSS) capacitor c=5.07342e-17
C26 (\1\:VDD VSS) capacitor c=4.10705e-17
C27 (\12\:net116 VSS) capacitor c=2.12612e-17
C28 (\8\:VDD VSS) capacitor c=2.27885e-17
C29 (\10\:net116 VSS) capacitor c=4.14422e-17
C30 (\6\:VDD VSS) capacitor c=1.99155e-17
C31 (\3\:Y VSS) capacitor c=7.61503e-17
C32 (\7\:net116 VSS) capacitor c=5.77922e-17
C33 (\2\:B VSS) capacitor c=3.89797e-17
C34 (\4\:D VSS) capacitor c=4.18046e-17
C35 (\4\:C VSS) capacitor c=4.54973e-17
C36 (\5\:B VSS) capacitor c=8.62277e-17
C37 (\4\:A VSS) capacitor c=4.32841e-17
C38 (\5\:net116 VSS) capacitor c=7.91624e-17
C39 (\6\:net116 VSS) capacitor c=1.33777e-16
C40 (\9\:net116 VSS) capacitor c=8.27197e-17
C41 (\4\:VDD VSS) capacitor c=3.18161e-17
C42 (\5\:VDD VSS) capacitor c=8.59542e-18
Rk18 (\4\:VSS VSS) resistor r=0.3005 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.3464 c=0
Rk3 (\5\:B B) resistor r=0.245 c=0
Rk10 (Y \2\:Y) resistor r=0.03962 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5007 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.4161 c=0
Rk14 (\5\:VDD VDD) resistor r=0.2204 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.08001 c=0
Rk15 (VDD \7\:VDD) resistor r=0.2719 c=0
Rk16 (\5\:VDD \9\:VDD) resistor r=0.1568 c=0
Rk2 (\4\:C C) resistor r=0.1264 c=0
Rk1 (\4\:D D) resistor r=0.02417 c=0
Rk4 (\4\:A A) resistor r=0.07765 c=0
Rk5 (\5\:net116 \6\:net116) resistor r=0.3071 c=0
Rk6 (\6\:net116 \8\:net116) resistor r=0.4241 c=0
Rk7 (\6\:net116 \9\:net116) resistor r=0.5043 c=0
Rk8 (\9\:net116 \11\:net116) resistor r=0.2721 c=0
Rk9 (\9\:net116 \13\:net116) resistor r=0.06936 c=0
Rl5 (\1\:B \2\:B) resistor r=174.714 c=0
Rl7 (\2\:B \4\:B) resistor r=47.791 c=0
Rl6 (\2\:B \3\:B) resistor r=9.8995 c=0
Rl3 (\1\:C \2\:C) resistor r=168 c=0
Rl4 (\2\:C \3\:C) resistor r=37.2302 c=0
Rl2 (\2\:D \3\:D) resistor r=162.637 c=0
Rl1 (\1\:D \2\:D) resistor r=44.7751 c=0
Rl8 (\1\:A \2\:A) resistor r=150 c=0
Rl9 (\2\:A \3\:A) resistor r=56.8681 c=0
Rl10 (net116 \2\:net116) resistor r=120.868 c=0
Rl12 (\2\:net116 \4\:net116) resistor r=34.3295 c=0
Rl11 (\2\:net116 \3\:net116) resistor r=0.5166 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\7\:net116 \8\:net116) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\10\:net116 \11\:net116) resistor r=62 c=0
Ry2 (\12\:net116 \13\:net116) resistor r=62 c=0
Rx3 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\3\:net116 \5\:net116) resistor r=45 c=0
mn3 (\7\:net116 \1\:D net132 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net132 \3\:C net128 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=8.15e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn1 (net128 \4\:B net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=3.19e-14 ps=5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=5.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn0 (net124 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.727e-14 ad=1.522e-14 ps=9.5e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=4e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn4 (\3\:Y \4\:net116 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.728e-14 ad=3.64e-14 ps=9.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05673e-07 sb=1.4e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mp4 (\1\:Y net116 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.07179e-07 sb=1.4e-07 sd=160n sca=24.4649 \
        scb=0.024645 scc=0.00179971 m=(1)
ends AND4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:19 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4X2
// View name: extracted

simulator lang=spectre

subckt AND4X2 A B C D VDD VSS Y
mp3 (\13\:net100 \3\:D \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=3.548e-14 ps=1.36e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.355e-06 sd=160n sca=19.3616 \
        scb=0.0212916 scc=0.000644055 m=(1)
mp2 (\13\:net100 \1\:C \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=3.548e-14 ps=1.46e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.145e-06 sd=160n sca=13.6785 \
        scb=0.0116931 scc=0.000214399 m=(1)
mp1 (\11\:net100 \1\:B \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=5.913e-14 ps=1.46e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=9.5e-07 sd=160n sca=12.115 \
        scb=0.00975563 scc=0.000203878 m=(1)
mp0 (\11\:net100 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=5.913e-14 ps=1.16e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=6.3e-07 sd=160n sca=11.62 \
        scb=0.00944645 scc=0.000203609 m=(1)
C1 (B VSS) capacitor c=1.33514e-16
C2 (Y VSS) capacitor c=1.53861e-17
C3 (VDD VSS) capacitor c=9.56473e-17
C4 (C VSS) capacitor c=6.63874e-17
C5 (D VSS) capacitor c=5.43985e-17
C6 (A VSS) capacitor c=4.5751e-17
C7 (net132 VSS) capacitor c=2.92448e-18
C8 (net100 VSS) capacitor c=1.59044e-16
C9 (net124 VSS) capacitor c=5.97886e-18
C10 (net120 VSS) capacitor c=9.55244e-18
C11 (\1\:A VSS) capacitor c=4.25268e-17
C12 (\1\:B VSS) capacitor c=5.49735e-17
C13 (\1\:C VSS) capacitor c=6.26801e-17
C14 (\3\:D VSS) capacitor c=4.3058e-17
C15 (\3\:A VSS) capacitor c=4.10545e-17
C16 (\3\:B VSS) capacitor c=2.79181e-17
C17 (\3\:C VSS) capacitor c=4.6797e-17
C18 (\1\:D VSS) capacitor c=4.30628e-17
C19 (\2\:A VSS) capacitor c=4.0646e-17
C20 (\2\:B VSS) capacitor c=4.61441e-17
C21 (\2\:C VSS) capacitor c=5.81231e-17
C22 (\2\:D VSS) capacitor c=5.14774e-17
C23 (\1\:VDD VSS) capacitor c=9.23696e-17
C24 (\4\:Y VSS) capacitor c=8.41134e-17
C25 (\11\:net100 VSS) capacitor c=9.82284e-17
C26 (\10\:VDD VSS) capacitor c=1.14663e-17
C27 (\13\:net100 VSS) capacitor c=3.85623e-17
C28 (\2\:Y VSS) capacitor c=5.23223e-17
C29 (\9\:net100 VSS) capacitor c=4.8071e-17
C30 (\4\:D VSS) capacitor c=4.29367e-17
C31 (\4\:C VSS) capacitor c=6.75341e-17
C32 (\4\:A VSS) capacitor c=6.99691e-17
C33 (\7\:net100 VSS) capacitor c=6.8808e-17
C34 (\8\:net100 VSS) capacitor c=1.32166e-16
C35 (\1\:Y VSS) capacitor c=5.68304e-17
C36 (\5\:VDD VSS) capacitor c=1.07359e-17
C37 (\6\:VDD VSS) capacitor c=1.15492e-17
C38 (\7\:VDD VSS) capacitor c=9.3645e-18
Rk22 (\5\:VSS VSS) resistor r=0.4001 c=0
Rk21 (\1\:VSS \5\:VSS) resistor r=0.1149 c=0
Rk9 (Y \1\:Y) resistor r=0.01982 c=0
Rk10 (\1\:Y \3\:Y) resistor r=0.271 c=0
Rk11 (\1\:Y \5\:Y) resistor r=0.4146 c=0
Rk13 (\1\:VDD \5\:VDD) resistor r=0.0999 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.1424 c=0
Rk16 (\7\:VDD VDD) resistor r=0.05461 c=0
Rk15 (\6\:VDD \7\:VDD) resistor r=0.2023 c=0
Rk18 (\6\:VDD \11\:VDD) resistor r=0.07311 c=0
Rk19 (\7\:VDD \13\:VDD) resistor r=0.07311 c=0
Rk2 (C \4\:C) resistor r=0.2242 c=0
Rk1 (D \4\:D) resistor r=0.08954 c=0
Rk4 (A \4\:A) resistor r=0.02131 c=0
Rk5 (\7\:net100 \8\:net100) resistor r=0.3373 c=0
Rk6 (\8\:net100 \10\:net100) resistor r=0.4724 c=0
Rk7 (\8\:net100 \12\:net100) resistor r=0.5571 c=0
Rk8 (\12\:net100 \14\:net100) resistor r=0.2719 c=0
Rl5 (\1\:B \2\:B) resistor r=162.23 c=0
Rl6 (\2\:B \3\:B) resistor r=29.5379 c=0
Rl3 (\1\:C \2\:C) resistor r=160.307 c=0
Rl4 (\2\:C \3\:C) resistor r=31.461 c=0
Rl2 (\2\:D \3\:D) resistor r=147.872 c=0
Rl1 (\1\:D \2\:D) resistor r=44.208 c=0
Rl7 (\1\:A \2\:A) resistor r=93.4057 c=0
Rl8 (\2\:A \3\:A) resistor r=91.4826 c=0
Rz2 (\3\:Y \2\:Y) resistor r=75 c=0
Rz1 (\10\:net100 \9\:net100) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\12\:net100 \11\:net100) resistor r=62 c=0
Ry2 (\14\:net100 \13\:net100) resistor r=62 c=0
Rx3 (\2\:B B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\7\:net100 net100) resistor r=45 c=0
mn3 (\9\:net100 \1\:D net132 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn2 (net132 \3\:C net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=8.7e-15 ps=5.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.145e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (net124 \3\:B net120 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.175e-14 ps=8.4e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=9.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn0 (net120 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.988e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.3e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn4 (\2\:Y net100 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.653e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.16827e-07 sb=3.95e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(2)
mp4 (\4\:Y net100 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.622e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.29231e-07 sb=3.95e-07 sd=160n sca=21.3165 \
        scb=0.0178846 scc=0.00184501 m=(2)
ends AND4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:20 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4X4
// View name: extracted

simulator lang=spectre

subckt AND4X4 A B C D VDD VSS Y
mp3 (\20\:net100 \3\:D \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.62e-06 sd=160n sca=16.3241 \
        scb=0.0161972 scc=0.000342398 m=(1)
mp2 (\20\:net100 \1\:C \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.415e-06 sd=160n sca=13.0557 \
        scb=0.010793 scc=0.000234604 m=(1)
mp1 (\22\:net100 \1\:B \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.215e-14 ps=1.1e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.21e-06 sd=160n sca=11.9089 \
        scb=0.00972252 scc=0.000231915 m=(1)
mp0 (\22\:net100 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.215e-14 ps=1.14e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=9.8e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4_1__rcx (\6\:Y net100 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=7.55e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
C1 (Y VSS) capacitor c=2.7772e-17
C2 (B VSS) capacitor c=6.4069e-17
C3 (C VSS) capacitor c=1.32132e-16
C4 (D VSS) capacitor c=9.88453e-17
C5 (A VSS) capacitor c=7.3539e-17
C6 (VDD VSS) capacitor c=1.10849e-16
C7 (net132 VSS) capacitor c=4.07302e-18
C8 (net100 VSS) capacitor c=3.57971e-16
C9 (net124 VSS) capacitor c=9.19746e-18
C10 (net120 VSS) capacitor c=6.17703e-18
C11 (\1\:A VSS) capacitor c=4.62925e-17
C12 (\1\:B VSS) capacitor c=6.19324e-17
C13 (\1\:C VSS) capacitor c=6.85208e-17
C14 (\3\:D VSS) capacitor c=5.1808e-17
C15 (\3\:A VSS) capacitor c=6.74944e-17
C16 (\4\:B VSS) capacitor c=4.3816e-17
C17 (\3\:C VSS) capacitor c=4.2861e-17
C18 (\1\:D VSS) capacitor c=3.47552e-17
C19 (\2\:A VSS) capacitor c=4.22575e-17
C20 (\3\:B VSS) capacitor c=5.27307e-17
C21 (\2\:C VSS) capacitor c=5.95731e-17
C22 (\2\:D VSS) capacitor c=4.77132e-17
C23 (\1\:VDD VSS) capacitor c=1.96884e-16
C24 (\22\:net100 VSS) capacitor c=4.61547e-17
C25 (\11\:VDD VSS) capacitor c=5.48372e-17
C26 (\20\:net100 VSS) capacitor c=8.35213e-17
C27 (\14\:VDD VSS) capacitor c=5.06671e-17
C28 (\2\:Y VSS) capacitor c=1.19868e-16
C29 (\16\:net100 VSS) capacitor c=7.69851e-17
C30 (\6\:B VSS) capacitor c=8.9681e-17
C31 (\4\:A VSS) capacitor c=3.50192e-17
C32 (\15\:net100 VSS) capacitor c=1.36189e-16
C33 (\19\:net100 VSS) capacitor c=8.01442e-17
C34 (\1\:Y VSS) capacitor c=2.9106e-17
C35 (\6\:Y VSS) capacitor c=1.99103e-16
C36 (\10\:VDD VSS) capacitor c=2.04707e-17
C37 (\13\:VDD VSS) capacitor c=9.5412e-18
Rk14 (Y \1\:Y) resistor r=0.04645 c=0
Rk15 (\1\:Y \2\:Y) resistor r=0.1721 c=0
Rk17 (\1\:Y \6\:Y) resistor r=0.3252 c=0
Rk5 (B \6\:B) resistor r=0.027 c=0
Rk32 (\1\:VSS VSS) resistor r=0.4659 c=0
Rk2 (C \4\:C) resistor r=0.003974 c=0
Rk1 (D \4\:D) resistor r=0.003974 c=0
Rk6 (A \4\:A) resistor r=0.1169 c=0
Rk24 (\1\:VDD \10\:VDD) resistor r=0.2208 c=0
Rk25 (\10\:VDD \12\:VDD) resistor r=0.2256 c=0
Rk28 (\13\:VDD VDD) resistor r=0.07478 c=0
Rk26 (\10\:VDD \13\:VDD) resistor r=0.2052 c=0
Rk27 (\13\:VDD \15\:VDD) resistor r=0.2785 c=0
Rk8 (net100 \15\:net100) resistor r=0.3508 c=0
Rk9 (\15\:net100 \17\:net100) resistor r=0.6395 c=0
Rk11 (\15\:net100 \19\:net100) resistor r=0.3601 c=0
Rk12 (\19\:net100 \21\:net100) resistor r=0.3953 c=0
Rk13 (\19\:net100 \23\:net100) resistor r=0.1272 c=0
Rl5 (\1\:B \2\:B) resistor r=141.187 c=0
Rl7 (\2\:B \4\:B) resistor r=48.8796 c=0
Rl6 (\2\:B \3\:B) resistor r=0.6051 c=0
Rl3 (\1\:C \2\:C) resistor r=144.923 c=0
Rl4 (\2\:C \3\:C) resistor r=29.5379 c=0
Rl2 (\2\:D \3\:D) resistor r=147.31 c=0
Rl1 (\1\:D \2\:D) resistor r=31.7349 c=0
Rl8 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl9 (\2\:A \3\:A) resistor r=112.26 c=0
Rz1 (\17\:net100 \16\:net100) resistor r=75 c=0
Ry8 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry1 (\21\:net100 \20\:net100) resistor r=20.6667 c=0
Ry2 (\23\:net100 \22\:net100) resistor r=20.6667 c=0
Rx3 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
mn3 (\16\:net100 \1\:D net132 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.64e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn2 (net132 \3\:C net124 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.415e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn1 (net124 \4\:B net120 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.21e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn0 (net120 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.12e-14 ps=8.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.045e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn4_1__rcx (\2\:Y net100 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.582e-14 ad=4.355e-14 ps=8.725e-07 pd=8.55e-07 \
        nrd=1.16667 nrs=1.16667 sa=8.75e-07 sb=8.4e-07 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
ends AND4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:21 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4X6
// View name: extracted

simulator lang=spectre

subckt AND4X6 A B C D VDD VSS Y
mp0_1__rcx (\16\:net116 A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.1165e-13 ad=6.24e-14 ps=1.61e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98071e-06 sd=160n sca=18.0971 \
        scb=0.0181198 scc=0.000732406 m=(2)
mp1 (\16\:net116 B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96231e-06 sd=160n sca=15.113 \
        scb=0.013285 scc=0.000649598 m=(2)
mp2 (\16\:net116 \1\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.93853e-06 sd=160n sca=13.8524 \
        scb=0.01226 scc=0.000647526 m=(2)
mp3 (\16\:net116 \3\:D \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.92013e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
C1 (Y VSS) capacitor c=1.3871e-17
C2 (B VSS) capacitor c=5.35954e-16
C3 (VDD VSS) capacitor c=1.62836e-16
C4 (D VSS) capacitor c=4.43043e-17
C5 (A VSS) capacitor c=6.55864e-16
C6 (11 VSS) capacitor c=8.18896e-18
C7 (net116 VSS) capacitor c=2.84583e-16
C8 (12 VSS) capacitor c=2.27984e-18
C9 (13 VSS) capacitor c=8.35121e-18
C10 (14 VSS) capacitor c=2.26439e-18
C11 (\6\:A VSS) capacitor c=8.10804e-17
C12 (\6\:B VSS) capacitor c=7.53585e-17
C13 (\7\:C VSS) capacitor c=5.33809e-17
C14 (\1\:D VSS) capacitor c=6.33252e-17
C15 (\5\:D VSS) capacitor c=1.76577e-17
C16 (\3\:C VSS) capacitor c=3.95852e-17
C17 (\3\:B VSS) capacitor c=6.5123e-17
C18 (\1\:A VSS) capacitor c=5.99855e-17
C19 (\2\:D VSS) capacitor c=2.80293e-17
C20 (\1\:C VSS) capacitor c=4.13998e-16
C21 (\1\:Y VSS) capacitor c=2.45095e-16
C22 (\1\:VDD VSS) capacitor c=4.00377e-16
C23 (\16\:net116 VSS) capacitor c=3.71388e-16
C24 (\15\:VDD VSS) capacitor c=2.811e-17
C25 (\24\:net116 VSS) capacitor c=8.59358e-17
C26 (\3\:D VSS) capacitor c=1.1944e-16
C27 (\7\:D VSS) capacitor c=3.27801e-17
C28 (\14\:net116 VSS) capacitor c=7.61827e-17
C29 (\15\:net116 VSS) capacitor c=1.2307e-16
C30 (\4\:Y VSS) capacitor c=2.14436e-16
Rk15 (\1\:Y Y) resistor r=0.04656 c=0
Rk16 (Y \4\:Y) resistor r=0.1832 c=0
Rk40 (\1\:VSS \7\:VSS) resistor r=0.3782 c=0
Rk42 (\8\:VSS VSS) resistor r=0.1248 c=0
Rk41 (\7\:VSS \8\:VSS) resistor r=0.4258 c=0
Rk45 (\8\:VSS \14\:VSS) resistor r=0.2027 c=0
Rk36 (\1\:VDD VDD) resistor r=0.08224 c=0
Rk31 (\1\:VDD \16\:VDD) resistor r=0.148 c=0
Rk3 (\1\:C C) resistor r=0.009678 c=0
Rk1 (\7\:D D) resistor r=0.2106 c=0
Rk9 (\15\:net116 \16\:net116) resistor r=0.5321 c=0
Rk8 (\14\:net116 \15\:net116) resistor r=0.3077 c=0
Rk13 (\15\:net116 \25\:net116) resistor r=0.7326 c=0
Rl16 (B \6\:B) resistor r=126.098 c=0
Rl4 (B \3\:B) resistor r=110.713 c=0
Rl14 (\1\:C \7\:C) resistor r=45.3297 c=0
Rl6 (\1\:C \3\:C) resistor r=110.418 c=0
Rl8 (\2\:D \1\:D) resistor r=105.323 c=0
Rl11 (\2\:D \5\:D) resistor r=24.2328 c=0
Rl9 (\3\:D \2\:D) resistor r=87.3759 c=0
Rl18 (A \6\:A) resistor r=115.18 c=0
Rl1 (A \1\:A) resistor r=116.483 c=0
Rz10 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\25\:net116 \24\:net116) resistor r=75 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry16 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry12 (\16\:VDD \15\:VDD) resistor r=62 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
Rx8 (\14\:net116 net116) resistor r=22.5 c=0
mn0_1__rcx (9 \1\:A \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.95e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.72e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_1__rcx (10 \3\:C 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=5.72e-14 ps=1.04e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\24\:net116 \5\:D 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.99e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\24\:net116 \1\:D 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.69e-14 ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.785e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (12 \7\:C 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.69e-14 ps=1.07e-06 pd=6.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.145e-06 sb=1.675e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (14 \6\:B 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.465e-06 sb=1.355e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.87e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\4\:Y net116 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.342e-14 ad=4.836e-14 ps=9.74e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57613e-06 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp4_1__rcx (\1\:Y net116 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 \
        nf=1 as=9.39e-14 ad=7.332e-14 ps=1.44e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.53511e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND4X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:22 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4X8
// View name: extracted

simulator lang=spectre

subckt AND4X8 A B C D VDD VSS Y
mp3 (\29\:net116 \3\:D \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.86308e-06 sd=160n sca=13.679 \
        scb=0.0122069 scc=0.000647515 m=(2)
mp0_1__rcx (\29\:net116 A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.29e-14 ad=6.24e-14 ps=1.51e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96692e-06 sd=160n sca=24.3679 \
        scb=0.0278844 scc=0.00150868 m=(2)
mp1 (\29\:net116 \1\:B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.93538e-06 sd=160n sca=16.6587 \
        scb=0.0156 scc=0.000671901 m=(2)
mp2 (\29\:net116 \1\:C VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.89462e-06 sd=160n sca=14.3316 \
        scb=0.0125202 scc=0.000647698 m=(2)
C1 (Y VSS) capacitor c=1.28916e-17
C2 (B VSS) capacitor c=1.61757e-16
C3 (VDD VSS) capacitor c=6.39828e-16
C4 (C VSS) capacitor c=1.04295e-16
C5 (D VSS) capacitor c=2.88839e-17
C6 (A VSS) capacitor c=6.61334e-16
C7 (11 VSS) capacitor c=9.7715e-18
C8 (net116 VSS) capacitor c=4.85666e-16
C9 (12 VSS) capacitor c=1.35399e-18
C10 (13 VSS) capacitor c=8.8418e-18
C11 (14 VSS) capacitor c=2.0734e-18
C12 (\1\:C VSS) capacitor c=3.14201e-16
C13 (\1\:B VSS) capacitor c=4.01378e-16
C14 (\6\:A VSS) capacitor c=8.11276e-17
C15 (\6\:B VSS) capacitor c=6.84492e-17
C16 (\6\:C VSS) capacitor c=5.58909e-17
C17 (\1\:D VSS) capacitor c=6.50461e-17
C18 (\5\:D VSS) capacitor c=1.7781e-17
C19 (\3\:C VSS) capacitor c=3.89744e-17
C20 (\3\:B VSS) capacitor c=6.30635e-17
C21 (\1\:A VSS) capacitor c=5.96963e-17
C22 (\2\:D VSS) capacitor c=2.67366e-17
C23 (\1\:Y VSS) capacitor c=3.39951e-16
C24 (\29\:net116 VSS) capacitor c=3.7438e-16
C25 (\22\:VDD VSS) capacitor c=2.81093e-17
C26 (\37\:net116 VSS) capacitor c=9.16768e-17
C27 (\3\:D VSS) capacitor c=1.18109e-16
C28 (\7\:D VSS) capacitor c=7.08044e-17
C29 (\28\:net116 VSS) capacitor c=1.32566e-16
C30 (\4\:Y VSS) capacitor c=2.15805e-16
Rk17 (\1\:Y Y) resistor r=0.05089 c=0
Rk18 (Y \4\:Y) resistor r=0.2039 c=0
Rk5 (\1\:B B) resistor r=0.005636 c=0
Rk47 (\1\:VSS \8\:VSS) resistor r=0.3107 c=0
Rk49 (\9\:VSS VSS) resistor r=0.05721 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.4937 c=0
Rk53 (\9\:VSS \17\:VSS) resistor r=0.2036 c=0
Rk41 (VDD \23\:VDD) resistor r=0.1024 c=0
Rk2 (C \1\:C) resistor r=0.03168 c=0
Rk1 (\7\:D D) resistor r=0.145 c=0
Rk10 (net116 \28\:net116) resistor r=0.2198 c=0
Rk11 (\28\:net116 \29\:net116) resistor r=0.5551 c=0
Rk15 (\28\:net116 \38\:net116) resistor r=0.7024 c=0
Rl15 (\1\:B \6\:B) resistor r=96.8456 c=0
Rl4 (\1\:B \3\:B) resistor r=110.713 c=0
Rl13 (\1\:C \6\:C) resistor r=45.3297 c=0
Rl6 (\1\:C \3\:C) resistor r=102.615 c=0
Rl7 (\2\:D \1\:D) resistor r=105.323 c=0
Rl10 (\2\:D \5\:D) resistor r=31.9251 c=0
Rl8 (\3\:D \2\:D) resistor r=79.6836 c=0
Rl17 (A \6\:A) resistor r=115.18 c=0
Rl1 (A \1\:A) resistor r=116.483 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\38\:net116 \37\:net116) resistor r=75 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry18 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\23\:VDD \22\:VDD) resistor r=62 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0_1__rcx (9 \1\:A \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.95e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.72e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_1__rcx (10 \3\:C 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=5.72e-14 ps=1.05e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\37\:net116 \5\:D 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=4.16e-14 ps=1.05e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\37\:net116 \1\:D 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (12 \6\:C 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.145e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (14 \6\:B 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.465e-06 sb=1.75e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.645e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\4\:Y net116 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=4.95e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63797e-06 sb=1.37e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mp4_1__rcx (\1\:Y net116 VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.977e-14 ad=6.993e-14 ps=1.31714e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.50899e-06 sb=1.37e-06 sd=160n \
        sca=27.9404 scb=0.0185207 scc=0.00295096 m=(7)
ends AND4X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:23 2013 )
// Library name: gsclib045_hvt
// Cell name: AND4XL
// View name: extracted

simulator lang=spectre

subckt AND4XL A B C D VDD VSS Y
mp3 (\4\:net100 \3\:D \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06e-06 sd=160n sca=18.9752 \
        scb=0.0206746 scc=0.000592578 m=(1)
mp2 (\4\:net100 \1\:C \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.55e-07 sd=160n sca=13.6507 \
        scb=0.0115074 scc=0.000198787 m=(1)
mp1 (\6\:net100 \1\:B \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.515e-14 ps=1.45e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.6e-07 sd=160n sca=12.6747 \
        scb=0.00982871 scc=0.000188391 m=(1)
mp0 (\6\:net100 \4\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=4.515e-14 ps=1.45e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=4.05e-07 sd=160n sca=13.816 \
        scb=0.0118118 scc=0.000202165 m=(1)
mp4 (\1\:Y net100 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.4e-07 sd=160n sca=24.7768 \
        scb=0.0281397 scc=0.00159433 m=(1)
C1 (Y VSS) capacitor c=4.81416e-17
C2 (B VSS) capacitor c=8.86712e-17
C3 (VDD VSS) capacitor c=1.19206e-16
C4 (C VSS) capacitor c=9.26199e-17
C5 (D VSS) capacitor c=6.50188e-17
C6 (A VSS) capacitor c=7.33827e-17
C7 (net100 VSS) capacitor c=5.87237e-17
C8 (\4\:A VSS) capacitor c=3.61024e-17
C9 (\1\:B VSS) capacitor c=5.76225e-17
C10 (\1\:C VSS) capacitor c=6.00376e-17
C11 (\3\:D VSS) capacitor c=4.34052e-17
C12 (\3\:net100 VSS) capacitor c=3.00996e-17
C13 (\3\:A VSS) capacitor c=6.7283e-17
C14 (\3\:B VSS) capacitor c=4.30691e-17
C15 (\3\:C VSS) capacitor c=6.39853e-17
C16 (\1\:D VSS) capacitor c=5.43835e-17
C17 (\2\:net100 VSS) capacitor c=4.84552e-17
C18 (\1\:A VSS) capacitor c=2.57161e-17
C19 (\2\:B VSS) capacitor c=6.02132e-17
C20 (\2\:C VSS) capacitor c=7.06354e-17
C21 (\2\:D VSS) capacitor c=5.9763e-17
C22 (\1\:Y VSS) capacitor c=5.83631e-17
C23 (\1\:VDD VSS) capacitor c=3.3193e-17
C24 (\6\:net100 VSS) capacitor c=1.13209e-16
C25 (\7\:VDD VSS) capacitor c=1.06942e-17
C26 (\4\:net100 VSS) capacitor c=5.22809e-17
C27 (\9\:VDD VSS) capacitor c=1.71678e-17
C28 (\3\:Y VSS) capacitor c=3.53081e-17
C29 (\9\:net100 VSS) capacitor c=6.94182e-17
C30 (\2\:A VSS) capacitor c=3.76843e-17
C31 (\4\:D VSS) capacitor c=3.78975e-17
C32 (\4\:C VSS) capacitor c=5.38913e-17
C33 (\4\:B VSS) capacitor c=5.22009e-17
C34 (\5\:A VSS) capacitor c=4.96635e-17
C35 (\8\:net100 VSS) capacitor c=1.12526e-16
C36 (\11\:net100 VSS) capacitor c=4.24243e-17
C37 (\4\:VDD VSS) capacitor c=1.5326e-17
C38 (\5\:VDD VSS) capacitor c=6.64162e-18
C39 (\6\:VDD VSS) capacitor c=8.78609e-18
Rk11 (\2\:Y Y) resistor r=0.4497 c=0
Rk12 (Y \4\:Y) resistor r=0.1253 c=0
Rk5 (B \4\:B) resistor r=0.08971 c=0
Rk20 (\4\:VSS VSS) resistor r=0.3006 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.35 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.2575 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.07752 c=0
Rk16 (\6\:VDD VDD) resistor r=0.03716 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.1851 c=0
Rk17 (\5\:VDD \8\:VDD) resistor r=0.07369 c=0
Rk18 (\6\:VDD \10\:VDD) resistor r=0.2669 c=0
Rk4 (C \4\:C) resistor r=0.08971 c=0
Rk1 (\4\:D \5\:D) resistor r=0.001403 c=0
Rk2 (\6\:D D) resistor r=0.001473 c=0
Rk3 (\5\:D \6\:D) resistor r=0.09276 c=0
Rk6 (A \5\:A) resistor r=0.1977 c=0
Rk7 (\5\:net100 \7\:net100) resistor r=0.2737 c=0
Rk8 (\7\:net100 \8\:net100) resistor r=0.6003 c=0
Rk9 (\8\:net100 \10\:net100) resistor r=0.507 c=0
Rk10 (\8\:net100 \11\:net100) resistor r=0.1838 c=0
Rl5 (\1\:B \2\:B) resistor r=150.692 c=0
Rl6 (\2\:B \3\:B) resistor r=100.692 c=0
Rl3 (\1\:C \2\:C) resistor r=150.692 c=0
Rl4 (\2\:C \3\:C) resistor r=100.692 c=0
Rl2 (\2\:D \3\:D) resistor r=157.224 c=0
Rl1 (\1\:D \2\:D) resistor r=101.9 c=0
Rl9 (\2\:A \4\:A) resistor r=73.8796 c=0
Rl8 (\2\:A \3\:A) resistor r=193.694 c=0
Rl7 (\1\:A \2\:A) resistor r=6.3321 c=0
Rl10 (net100 \2\:net100) resistor r=215.648 c=0
Rl11 (\2\:net100 \3\:net100) resistor r=34.4104 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\9\:net100 \10\:net100) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\4\:net100 \5\:net100) resistor r=62 c=0
Ry2 (\6\:net100 \7\:net100) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\1\:A \5\:A) resistor r=45 c=0
Rx5 (\2\:net100 \11\:net100) resistor r=45 c=0
mn3 (\9\:net100 \1\:D net136 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (net136 \3\:C net128 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=8.7e-15 ps=5.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.6e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (net128 \3\:B net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.175e-14 ps=6.4e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=5.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (net124 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.538e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\3\:Y \3\:net100 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
ends AND4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:24 2013 )
// Library name: gsclib045_hvt
// Cell name: ANTENNA
// View name: extracted

simulator lang=spectre

subckt ANTENNA A VDD VSS
D1 (\3\:A VDD) g45pd1hvt area=1.888e-13 pj=1.82e-06 m=1
C1 (VDD VSS) capacitor c=9.59227e-18
C2 (A VSS) capacitor c=1.3745e-17
C3 (\3\:A VSS) capacitor c=1.26921e-17
Rk1 (A \2\:A) resistor r=0.02915 c=0
Rk2 (\2\:A \4\:A) resistor r=0.3207 c=0
Rz1 (\1\:A \2\:A) resistor r=37.5 c=0
Ry1 (\3\:A \4\:A) resistor r=20.6667 c=0
D0 (VSS \1\:A) g45nd1hvt area=1.551e-13 pj=1.6e-06 m=1
ends ANTENNA
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:25 2013 )
// Library name: gsclib045_hvt
// Cell name: AO21X1
// View name: extracted

simulator lang=spectre

subckt AO21X1 A0 A1 B0 VDD VSS Y
mp0 (\3\:net96 \3\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.01e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.79419e-07 sd=160n sca=25.6618 \
        scb=0.0302163 scc=0.00167813 m=(1)
mp1 (net96 \1\:A1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.978e-14 ps=7.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.64419e-07 sd=160n sca=18.1415 \
        scb=0.0180564 scc=0.000904054 m=(1)
mp2 (\8\:net049 \3\:B0 net96 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=2.89e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.34419e-07 sd=160n sca=16.8124 \
        scb=0.0157246 scc=0.000885849 m=(1)
C1 (B0 VSS) capacitor c=9.01364e-17
C2 (A1 VSS) capacitor c=4.85937e-17
C3 (A0 VSS) capacitor c=2.44537e-17
C4 (Y VSS) capacitor c=3.01491e-17
C5 (VDD VSS) capacitor c=9.34634e-17
C6 (net049 VSS) capacitor c=4.45599e-17
C7 (net96 VSS) capacitor c=6.32058e-17
C8 (\3\:B0 VSS) capacitor c=3.27866e-17
C9 (\1\:A1 VSS) capacitor c=4.05233e-17
C10 (\3\:A0 VSS) capacitor c=3.2789e-17
C11 (\3\:net049 VSS) capacitor c=3.85914e-17
C12 (\1\:B0 VSS) capacitor c=3.96102e-17
C13 (\3\:A1 VSS) capacitor c=4.59162e-17
C14 (\1\:A0 VSS) capacitor c=4.55614e-17
C15 (\2\:net049 VSS) capacitor c=4.15627e-17
C16 (\2\:B0 VSS) capacitor c=5.46084e-17
C17 (\2\:A1 VSS) capacitor c=5.31471e-17
C18 (\2\:A0 VSS) capacitor c=4.64147e-17
C19 (\1\:Y VSS) capacitor c=3.11907e-17
C20 (\1\:VDD VSS) capacitor c=2.63016e-17
C21 (\8\:net049 VSS) capacitor c=5.14948e-17
C22 (\6\:VDD VSS) capacitor c=4.08353e-17
C23 (\3\:net96 VSS) capacitor c=5.91539e-17
C24 (\3\:Y VSS) capacitor c=6.90478e-17
C25 (\6\:net049 VSS) capacitor c=7.3873e-17
C26 (\4\:A0 VSS) capacitor c=4.28882e-17
C27 (\4\:A1 VSS) capacitor c=5.84967e-17
C28 (\4\:net049 VSS) capacitor c=2.21881e-17
C29 (\5\:net049 VSS) capacitor c=6.86934e-17
C30 (\4\:VDD VSS) capacitor c=2.59209e-17
C31 (\5\:VDD VSS) capacitor c=6.65151e-18
Rk4 (\4\:B0 B0) resistor r=0.00268 c=0
Rk2 (A1 \4\:A1) resistor r=0.1877 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.3806 c=0
Rk16 (\5\:VSS VSS) resistor r=0.05687 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2415 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2828 c=0
Rk1 (A0 \4\:A0) resistor r=0.1132 c=0
Rk8 (\2\:Y Y) resistor r=0.106 c=0
Rk9 (Y \4\:Y) resistor r=0.3914 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3883 c=0
Rk12 (\5\:VDD VDD) resistor r=0.1192 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.1792 c=0
Rk13 (\5\:VDD \7\:VDD) resistor r=0.3259 c=0
Rk5 (\4\:net049 \5\:net049) resistor r=0.01521 c=0
Rk6 (\5\:net049 \7\:net049) resistor r=0.3496 c=0
Rk7 (\5\:net049 \9\:net049) resistor r=0.3248 c=0
Rk3 (\2\:net96 \4\:net96) resistor r=0.3509 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=64.5604 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=98.4743 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=62.6944 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=95.3867 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=51.9707 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=111.538 c=0
Rl7 (net049 \2\:net049) resistor r=108.746 c=0
Rl8 (\2\:net049 \3\:net049) resistor r=24.2328 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\6\:net049 \7\:net049) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\8\:net049 \9\:net049) resistor r=62 c=0
Ry1 (net96 \2\:net96) resistor r=62 c=0
Ry2 (\3\:net96 \4\:net96) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:net049 \4\:net049) resistor r=45 c=0
mn0 (net104 \1\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.305e-14 ps=5.7e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn1 (\6\:net049 \3\:A1 net104 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=3.988e-14 ps=4.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.65e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\6\:net049 \1\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.528e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (\3\:Y \3\:net049 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.528e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92596e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp3 (\1\:Y net049 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.4e-07 sd=160n sca=21.7112 \
        scb=0.0229031 scc=0.00124467 m=(1)
ends AO21X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:27 2013 )
// Library name: gsclib045_hvt
// Cell name: AO21X2
// View name: extracted

simulator lang=spectre

subckt AO21X2 A0 A1 B0 VDD VSS Y
mp0 (\3\:net84 \1\:A0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.01e-14 ps=1.57e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=16.4235 \
        scb=0.0160509 scc=0.000530362 m=(1)
mp1 (net84 \1\:A1 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.44e-14 ps=1.57e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.45e-07 sd=160n sca=14.3559 \
        scb=0.0130561 scc=0.000502004 m=(1)
mp2 (\11\:net100 \3\:B0 net84 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.4e-07 sd=160n sca=13.9642 scb=0.012601 \
        scc=0.000501242 m=(1)
C1 (B0 VSS) capacitor c=5.38724e-17
C2 (A1 VSS) capacitor c=5.59366e-17
C3 (VDD VSS) capacitor c=1.02626e-16
C4 (A0 VSS) capacitor c=5.05625e-17
C5 (Y VSS) capacitor c=5.58808e-17
C6 (net104 VSS) capacitor c=3.48915e-18
C7 (net100 VSS) capacitor c=8.90206e-17
C8 (net84 VSS) capacitor c=4.08669e-17
C9 (\3\:B0 VSS) capacitor c=4.78804e-17
C10 (\1\:A1 VSS) capacitor c=6.56769e-17
C11 (\1\:A0 VSS) capacitor c=5.02753e-17
C12 (\1\:B0 VSS) capacitor c=3.28028e-17
C13 (\3\:A1 VSS) capacitor c=3.53785e-17
C14 (\4\:A0 VSS) capacitor c=3.98146e-17
C15 (\4\:net100 VSS) capacitor c=4.12188e-17
C16 (\2\:B0 VSS) capacitor c=5.21886e-17
C17 (\2\:A1 VSS) capacitor c=5.2617e-17
C18 (\3\:A0 VSS) capacitor c=1.26758e-17
C19 (\1\:VDD VSS) capacitor c=9.48075e-17
C20 (\1\:Y VSS) capacitor c=1.0071e-16
C21 (\11\:net100 VSS) capacitor c=7.53974e-17
C22 (\9\:VDD VSS) capacitor c=1.22532e-17
C23 (\3\:net84 VSS) capacitor c=3.80014e-17
C24 (\3\:Y VSS) capacitor c=2.21591e-17
C25 (\8\:net100 VSS) capacitor c=5.81598e-17
C26 (\2\:A0 VSS) capacitor c=3.4707e-17
C27 (\3\:net100 VSS) capacitor c=5.78563e-17
C28 (\5\:A0 VSS) capacitor c=2.80831e-17
C29 (\4\:A1 VSS) capacitor c=4.26788e-17
C30 (\5\:B0 VSS) capacitor c=4.2228e-17
C31 (\10\:net100 VSS) capacitor c=1.02869e-16
C32 (\5\:VDD VSS) capacitor c=1.3714e-17
C33 (\6\:VDD VSS) capacitor c=1.0859e-17
Rk4 (\4\:B0 \5\:B0) resistor r=0.003877 c=0
Rk5 (\6\:B0 B0) resistor r=0.003963 c=0
Rk6 (\5\:B0 \6\:B0) resistor r=0.08164 c=0
Rk2 (\4\:A1 A1) resistor r=0.09547 c=0
Rk18 (\1\:VSS \5\:VSS) resistor r=0.1121 c=0
Rk20 (\6\:VSS VSS) resistor r=0.1119 c=0
Rk19 (\5\:VSS \6\:VSS) resistor r=0.2369 c=0
Rk22 (\6\:VSS \10\:VSS) resistor r=0.2653 c=0
Rk12 (\1\:VDD \5\:VDD) resistor r=0.1446 c=0
Rk14 (\6\:VDD VDD) resistor r=0.2292 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.1196 c=0
Rk16 (\6\:VDD \10\:VDD) resistor r=0.07277 c=0
Rk1 (A0 \5\:A0) resistor r=0.1223 c=0
Rk9 (\2\:Y Y) resistor r=0.3867 c=0
Rk10 (Y \4\:Y) resistor r=0.1837 c=0
Rk7 (\9\:net100 \10\:net100) resistor r=0.2925 c=0
Rk8 (\10\:net100 \12\:net100) resistor r=0.4742 c=0
Rk3 (\2\:net84 \4\:net84) resistor r=0.2387 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=129.945 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=57.6923 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=161.538 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=26.3736 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.649 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=46.9565 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=8.9604 c=0
Rl9 (\3\:net100 net100) resistor r=159.312 c=0
Rl10 (\3\:net100 \4\:net100) resistor r=3.3229 c=0
Rz6 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz1 (\9\:net100 \8\:net100) resistor r=75 c=0
Ry7 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry4 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry3 (\12\:net100 \11\:net100) resistor r=62 c=0
Ry1 (net84 \2\:net84) resistor r=62 c=0
Ry2 (\3\:net84 \4\:net84) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\10\:net100 \4\:net100) resistor r=45 c=0
mn0 (net104 \4\:A0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.087e-14 ps=5.7e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\8\:net100 \3\:A1 net104 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=4.205e-14 ps=4.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=9.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\8\:net100 \1\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.205e-14 ps=9.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=5.9e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y \3\:net100 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.075e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.30385e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp3 (\1\:Y net100 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=3.45e-07 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(2)
ends AO21X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:27 2013 )
// Library name: gsclib045_hvt
// Cell name: AO21X4
// View name: extracted

simulator lang=spectre

subckt AO21X4 A0 A1 B0 VDD VSS Y
mp0 (\3\:net88 \1\:A0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.3e-07 sd=160n sca=16.4723 \
        scb=0.0164029 scc=0.000368802 m=(1)
mp1 (net88 \1\:A1 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.25e-07 sd=160n sca=13.2039 \
        scb=0.0109987 scc=0.000261009 m=(1)
mp2 (\20\:net100 \1\:B0 net88 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.68e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.2e-07 sd=160n sca=12.0571 \
        scb=0.00992821 scc=0.00025832 m=(1)
mp3 (\6\:Y net100 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=7.55e-07 sd=160n sca=14.0824 \
        scb=0.0125149 scc=0.000698926 m=(4)
C1 (Y VSS) capacitor c=2.66989e-17
C2 (A0 VSS) capacitor c=6.81715e-17
C3 (VDD VSS) capacitor c=1.09953e-16
C4 (net100 VSS) capacitor c=3.65988e-16
C5 (net88 VSS) capacitor c=7.76282e-17
C6 (\1\:B0 VSS) capacitor c=5.09257e-17
C7 (\1\:A1 VSS) capacitor c=5.44342e-17
C8 (\1\:A0 VSS) capacitor c=5.45985e-17
C9 (\3\:B0 VSS) capacitor c=5.2714e-17
C10 (\3\:A1 VSS) capacitor c=6.10218e-17
C11 (\3\:A0 VSS) capacitor c=4.09915e-17
C12 (\2\:B0 VSS) capacitor c=4.04521e-17
C13 (\2\:A1 VSS) capacitor c=5.456e-17
C14 (\2\:A0 VSS) capacitor c=4.45578e-17
C15 (\1\:VDD VSS) capacitor c=2.1697e-16
C16 (\20\:net100 VSS) capacitor c=5.0494e-17
C17 (\11\:VDD VSS) capacitor c=4.03765e-17
C18 (\3\:net88 VSS) capacitor c=5.05879e-17
C19 (\2\:Y VSS) capacitor c=1.25616e-16
C20 (\18\:net100 VSS) capacitor c=3.80712e-17
C21 (\4\:A0 VSS) capacitor c=1.88755e-17
C22 (\4\:A1 VSS) capacitor c=1.25828e-16
C23 (\4\:B0 VSS) capacitor c=1.39644e-16
C24 (\17\:net100 VSS) capacitor c=7.36463e-17
C25 (\1\:Y VSS) capacitor c=4.58727e-17
C26 (\6\:Y VSS) capacitor c=2.34281e-16
C27 (\10\:VDD VSS) capacitor c=2.24347e-17
Rk6 (\4\:B0 B0) resistor r=0.003683 c=0
Rk4 (\4\:A1 A1) resistor r=0.003683 c=0
Rk11 (Y \1\:Y) resistor r=0.1369 c=0
Rk12 (\1\:Y \2\:Y) resistor r=0.2642 c=0
Rk14 (\1\:Y \6\:Y) resistor r=0.194 c=0
Rk3 (\4\:A0 A0) resistor r=0.00899 c=0
Rk28 (\7\:VSS VSS) resistor r=0.07475 c=0
Rk27 (\1\:VSS \7\:VSS) resistor r=0.2979 c=0
Rk31 (\7\:VSS \13\:VSS) resistor r=0.1734 c=0
Rk23 (\10\:VDD VDD) resistor r=0.1775 c=0
Rk21 (\1\:VDD \10\:VDD) resistor r=0.273 c=0
Rk22 (\10\:VDD \12\:VDD) resistor r=0.19 c=0
Rk8 (net100 \17\:net100) resistor r=0.1486 c=0
Rk9 (\17\:net100 \19\:net100) resistor r=0.2864 c=0
Rk10 (\17\:net100 \21\:net100) resistor r=0.3745 c=0
Rk5 (\2\:net88 \4\:net88) resistor r=0.4345 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=72.2449 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=120.685 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=76.9231 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=126.099 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=149.175 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=45.3288 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\19\:net100 \18\:net100) resistor r=75 c=0
Ry9 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\21\:net100 \20\:net100) resistor r=62 c=0
Ry1 (net88 \2\:net88) resistor r=31 c=0
Ry2 (\3\:net88 \4\:net88) resistor r=31 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net104 \3\:A0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.73e-14 ps=8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\18\:net100 \3\:A1 net104 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=5.07e-14 ps=7.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=1.2e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\18\:net100 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.07e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=9.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\2\:Y net100 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
ends AO21X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:29 2013 )
// Library name: gsclib045_hvt
// Cell name: AO21XL
// View name: extracted

simulator lang=spectre

subckt AO21XL A0 A1 B0 VDD VSS Y
mp0 (n2 \4\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.6e-07 sd=160n sca=20.0513 \
        scb=0.0219943 scc=0.000769518 m=(1)
mp1 (\3\:n2 \1\:A1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.55e-07 sd=160n sca=13.262 \
        scb=0.0108178 scc=0.00011707 m=(1)
mp2 (\4\:n0 \3\:B0 \3\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.5e-07 sd=160n sca=11.9601 \
        scb=0.00852872 scc=9.89728e-05 m=(1)
mp3 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=54.2014 scb=0.040719 \
        scc=0.00636357 m=(1)
C1 (B0 VSS) capacitor c=5.89732e-17
C2 (Y VSS) capacitor c=3.61469e-17
C3 (A1 VSS) capacitor c=6.83626e-17
C4 (VDD VSS) capacitor c=1.32332e-16
C5 (A0 VSS) capacitor c=8.58403e-17
C6 (n0 VSS) capacitor c=3.5474e-17
C7 (n2 VSS) capacitor c=5.71238e-17
C8 (\3\:B0 VSS) capacitor c=5.10734e-17
C9 (\1\:A1 VSS) capacitor c=6.85758e-17
C10 (\4\:A0 VSS) capacitor c=4.75694e-17
C11 (\3\:n0 VSS) capacitor c=2.69532e-17
C12 (\1\:B0 VSS) capacitor c=3.5666e-17
C13 (\3\:A1 VSS) capacitor c=4.42464e-17
C14 (\1\:A0 VSS) capacitor c=6.72524e-17
C15 (\2\:n0 VSS) capacitor c=3.83836e-17
C16 (\2\:B0 VSS) capacitor c=5.86422e-17
C17 (\2\:A1 VSS) capacitor c=8.14821e-17
C18 (\3\:A0 VSS) capacitor c=1.66822e-17
C19 (\1\:Y VSS) capacitor c=3.54509e-17
C20 (\1\:VDD VSS) capacitor c=3.19967e-17
C21 (\4\:n0 VSS) capacitor c=6.9637e-17
C22 (\3\:n2 VSS) capacitor c=6.49777e-17
C23 (\6\:VDD VSS) capacitor c=2.68021e-17
C24 (\3\:Y VSS) capacitor c=2.58273e-17
C25 (\7\:n0 VSS) capacitor c=5.48241e-17
C26 (\2\:A0 VSS) capacitor c=5.41085e-17
C27 (\4\:A1 VSS) capacitor c=4.1198e-17
C28 (\4\:B0 VSS) capacitor c=6.31732e-17
C29 (\9\:n0 VSS) capacitor c=1.09171e-16
C30 (\4\:VDD VSS) capacitor c=2.22991e-17
C31 (\5\:VDD VSS) capacitor c=1.23638e-17
Rk4 (B0 \4\:B0) resistor r=0.166 c=0
Rk8 (\2\:Y Y) resistor r=0.2372 c=0
Rk9 (Y \4\:Y) resistor r=0.1196 c=0
Rk2 (\4\:A1 A1) resistor r=0.1905 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.4115 c=0
Rk12 (\5\:VDD VDD) resistor r=0.1247 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.175 c=0
Rk13 (\5\:VDD \7\:VDD) resistor r=0.1724 c=0
Rk1 (\5\:A0 A0) resistor r=0.003674 c=0
Rk15 (\3\:VSS VSS) resistor r=0.07212 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.2716 c=0
Rk16 (\3\:VSS \5\:VSS) resistor r=0.2275 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.3546 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.4613 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.2556 c=0
Rk7 (\6\:n0 \9\:n0) resistor r=0.03268 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.307 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=181.446 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=84.1579 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=218.464 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=37.6944 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=138.143 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.286 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=29.2356 c=0
Rl8 (n0 \2\:n0) resistor r=145.708 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=26.1559 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry1 (n2 \2\:n2) resistor r=62 c=0
Ry2 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:n0 \9\:n0) resistor r=45 c=0
mn0 (n1 \1\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\7\:n0 \3\:A1 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\7\:n0 \1\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.698e-14 ps=6.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=3.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.6e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
ends AO21XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:30 2013 )
// Library name: gsclib045_hvt
// Cell name: AO22X1
// View name: extracted

simulator lang=spectre

subckt AO22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:n3 \3\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=24.7768 \
        scb=0.0281397 scc=0.00159433 m=(1)
mp1 (\3\:n3 \1\:A1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=14.9462 \
        scb=0.0138238 scc=0.000237852 m=(1)
mp3 (\8\:n0 \1\:B1 \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.4379 \
        scb=0.00997048 scc=0.000189166 m=(1)
mp2 (\8\:n0 \4\:B0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=11.9066 \
        scb=0.00936839 scc=0.000188025 m=(1)
C1 (B0 VSS) capacitor c=4.76196e-17
C2 (A0 VSS) capacitor c=4.55037e-17
C3 (VDD VSS) capacitor c=1.24273e-16
C4 (B1 VSS) capacitor c=2.61387e-17
C5 (A1 VSS) capacitor c=2.94026e-17
C6 (n0 VSS) capacitor c=3.87009e-17
C7 (n2 VSS) capacitor c=6.05147e-18
C8 (n3 VSS) capacitor c=6.31164e-17
C9 (\4\:B0 VSS) capacitor c=5.18147e-17
C10 (\1\:B1 VSS) capacitor c=5.66909e-17
C11 (\1\:A1 VSS) capacitor c=5.56438e-17
C12 (\3\:A0 VSS) capacitor c=5.40822e-17
C13 (\3\:n0 VSS) capacitor c=4.56462e-17
C14 (\3\:B0 VSS) capacitor c=2.46414e-17
C15 (\3\:B1 VSS) capacitor c=3.48344e-17
C16 (\3\:A1 VSS) capacitor c=6.64302e-17
C17 (\1\:A0 VSS) capacitor c=4.51009e-17
C18 (\2\:n0 VSS) capacitor c=2.91833e-17
C19 (\1\:B0 VSS) capacitor c=1.93955e-17
C20 (\2\:B1 VSS) capacitor c=5.09544e-17
C21 (\2\:A1 VSS) capacitor c=5.73712e-17
C22 (\2\:A0 VSS) capacitor c=5.03071e-17
C23 (\3\:Y VSS) capacitor c=8.75645e-17
C24 (\1\:VDD VSS) capacitor c=9.24865e-17
C25 (\8\:n0 VSS) capacitor c=4.18382e-17
C26 (\3\:n3 VSS) capacitor c=6.9561e-17
C27 (\6\:VDD VSS) capacitor c=1.12592e-17
C28 (\5\:n3 VSS) capacitor c=3.65746e-17
C29 (\1\:Y VSS) capacitor c=6.60863e-17
C30 (\6\:n0 VSS) capacitor c=8.41802e-17
C31 (\2\:B0 VSS) capacitor c=3.29247e-17
C32 (\4\:A0 VSS) capacitor c=5.40388e-17
C33 (\4\:A1 VSS) capacitor c=3.75748e-17
C34 (\4\:B1 VSS) capacitor c=6.5046e-17
C35 (\5\:B0 VSS) capacitor c=6.30741e-17
C36 (\4\:n0 VSS) capacitor c=4.79358e-17
C37 (\5\:n0 VSS) capacitor c=1.10407e-16
C38 (\4\:VDD VSS) capacitor c=4.13917e-17
C39 (\5\:VDD VSS) capacitor c=1.16592e-17
Rk6 (B0 \5\:B0) resistor r=0.1099 c=0
Rk1 (\4\:A0 A0) resistor r=0.2486 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.415 c=0
Rk18 (\5\:VSS VSS) resistor r=0.0446 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.3051 c=0
Rk19 (\5\:VSS \7\:VSS) resistor r=0.2782 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.4733 c=0
Rk14 (\5\:VDD VDD) resistor r=0.1172 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.2325 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.07311 c=0
Rk3 (B1 \4\:B1) resistor r=0.02602 c=0
Rk2 (A1 \4\:A1) resistor r=0.02681 c=0
Rk10 (\2\:Y Y) resistor r=0.5751 c=0
Rk11 (Y \4\:Y) resistor r=0.004834 c=0
Rk7 (\4\:n0 \5\:n0) resistor r=0.2796 c=0
Rk8 (\5\:n0 \7\:n0) resistor r=0.49 c=0
Rk9 (\5\:n0 \9\:n0) resistor r=0.1947 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3951 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.2726 c=0
Rl9 (\2\:B0 \4\:B0) resistor r=171.957 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=45.0334 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=5.0163 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=161.333 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=55.7464 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=156.461 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=44.9225 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=91.5405 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=106.925 c=0
Rl10 (n0 \2\:n0) resistor r=35.7713 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=133.848 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry5 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (n1 \1\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\6\:n0 \3\:A1 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.55e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\6\:n0 \3\:B1 n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.5e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=2.32e-14 ps=1.24e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.45e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=3.64e-14 ps=1.24e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.53077e-07 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp4 (\3\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2631 \
        scb=0.0157178 scc=0.000443168 m=(1)
ends AO22X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:31 2013 )
// Library name: gsclib045_hvt
// Cell name: AO22X2
// View name: extracted

simulator lang=spectre

subckt AO22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net111 \4\:A0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9e-07 sd=160n sca=24.7768 scb=0.0281397 \
        scc=0.00159433 m=(1)
mp1 (\3\:net111 \1\:A1 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=4.192e-14 ps=1.45e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.35e-07 sd=160n sca=13.7572 \
        scb=0.0118002 scc=0.000202164 m=(1)
mp3 (\12\:net128 \3\:B1 \3\:net111 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.192e-14 ad=4.515e-14 ps=8.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=3.95e-07 sd=160n sca=11.856 \
        scb=0.00944487 scc=0.000188136 m=(1)
mp2 (\12\:net128 \4\:B0 net111 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.4e-07 sd=160n sca=11.3991 scb=0.00920061 \
        scc=0.000187981 m=(1)
C1 (B0 VSS) capacitor c=3.93261e-17
C2 (A0 VSS) capacitor c=8.70006e-17
C3 (VDD VSS) capacitor c=1.57939e-16
C4 (B1 VSS) capacitor c=1.23903e-16
C5 (A1 VSS) capacitor c=4.83041e-17
C6 (Y VSS) capacitor c=5.15399e-17
C7 (net128 VSS) capacitor c=8.71314e-17
C8 (net132 VSS) capacitor c=6.0962e-18
C9 (net111 VSS) capacitor c=6.56962e-17
C10 (\4\:B0 VSS) capacitor c=3.17158e-17
C11 (\3\:B1 VSS) capacitor c=4.8075e-17
C12 (\1\:A1 VSS) capacitor c=4.68554e-17
C13 (\4\:A0 VSS) capacitor c=3.29479e-17
C14 (\3\:B0 VSS) capacitor c=4.92325e-17
C15 (\1\:B1 VSS) capacitor c=2.88307e-17
C16 (\3\:A1 VSS) capacitor c=6.25384e-17
C17 (\1\:A0 VSS) capacitor c=7.53278e-17
C18 (\4\:net128 VSS) capacitor c=3.18281e-17
C19 (\1\:B0 VSS) capacitor c=1.86447e-17
C20 (\2\:B1 VSS) capacitor c=4.60108e-17
C21 (\2\:A1 VSS) capacitor c=6.50997e-17
C22 (\3\:A0 VSS) capacitor c=1.35464e-17
C23 (\1\:VDD VSS) capacitor c=9.06369e-17
C24 (\3\:Y VSS) capacitor c=5.9449e-17
C25 (\12\:net128 VSS) capacitor c=9.75377e-17
C26 (\3\:net111 VSS) capacitor c=6.96778e-17
C27 (\9\:VDD VSS) capacitor c=1.19681e-17
C28 (\5\:net111 VSS) capacitor c=4.26113e-17
C29 (\1\:Y VSS) capacitor c=5.03799e-17
C30 (\10\:net128 VSS) capacitor c=3.61649e-17
C31 (\2\:A0 VSS) capacitor c=4.61252e-17
C32 (\2\:B0 VSS) capacitor c=2.69015e-17
C33 (\3\:net128 VSS) capacitor c=5.44837e-17
C34 (\4\:A1 VSS) capacitor c=5.15883e-17
C35 (\5\:B0 VSS) capacitor c=7.76559e-17
C36 (\8\:net128 VSS) capacitor c=7.05552e-17
C37 (\9\:net128 VSS) capacitor c=1.01401e-16
C38 (\5\:VDD VSS) capacitor c=2.85348e-17
C39 (\6\:VDD VSS) capacitor c=1.32263e-17
Rk6 (\5\:B0 B0) resistor r=0.005849 c=0
Rk1 (\5\:A0 A0) resistor r=0.003674 c=0
Rk19 (\1\:VSS \5\:VSS) resistor r=0.1925 c=0
Rk21 (\6\:VSS VSS) resistor r=0.07963 c=0
Rk20 (\5\:VSS \6\:VSS) resistor r=0.3201 c=0
Rk23 (\6\:VSS \10\:VSS) resistor r=0.2782 c=0
Rk13 (\1\:VDD \5\:VDD) resistor r=0.18 c=0
Rk15 (\6\:VDD VDD) resistor r=0.1172 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.2826 c=0
Rk17 (\6\:VDD \10\:VDD) resistor r=0.07311 c=0
Rk3 (\4\:B1 B1) resistor r=0.02017 c=0
Rk2 (\4\:A1 A1) resistor r=0.1211 c=0
Rk10 (\2\:Y Y) resistor r=0.373 c=0
Rk11 (Y \4\:Y) resistor r=0.1488 c=0
Rk7 (\8\:net128 \9\:net128) resistor r=0.3614 c=0
Rk8 (\9\:net128 \11\:net128) resistor r=0.2109 c=0
Rk9 (\9\:net128 \13\:net128) resistor r=0.4766 c=0
Rk4 (\2\:net111 \4\:net111) resistor r=0.4223 c=0
Rk5 (\4\:net111 \6\:net111) resistor r=0.3262 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=37.3411 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=179.649 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=5.6742 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=24.4619 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=224.51 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=6.4284 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=164.56 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=38.4615 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=81.9251 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.54 c=0
Rl12 (\3\:net128 net128) resistor r=131.714 c=0
Rl13 (\3\:net128 \4\:net128) resistor r=4.9601 c=0
Rz6 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz2 (\2\:Y \1\:Y) resistor r=75 c=0
Rz1 (\11\:net128 \10\:net128) resistor r=75 c=0
Ry8 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry5 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry4 (\13\:net128 \12\:net128) resistor r=62 c=0
Ry1 (net111 \2\:net111) resistor r=62 c=0
Ry2 (\3\:net111 \4\:net111) resistor r=62 c=0
Ry3 (\5\:net111 \6\:net111) resistor r=62 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\8\:net128 \4\:net128) resistor r=45 c=0
mn0 (net124 \1\:A0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\10\:net128 \3\:A1 net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.625e-14 ps=4.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.265e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\10\:net128 \1\:B1 net132 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=3.625e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=9.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (net132 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.248e-14 ps=1.28e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=7.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:net128 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.11635e-07 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp4 (\3\:Y net128 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=3.45e-07 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(2)
ends AO22X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:32 2013 )
// Library name: gsclib045_hvt
// Cell name: AO22X4
// View name: extracted

simulator lang=spectre

subckt AO22X4 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:n3 \1\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=18.7619 \
        scb=0.0191068 scc=0.000809457 m=(1)
mp1 (\3\:n3 \1\:A1 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=15.4935 \
        scb=0.0137026 scc=0.000701664 m=(1)
mp3 (\19\:n0 \1\:B1 \3\:n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=14.3467 \
        scb=0.0126321 scc=0.000698974 m=(1)
mp2 (\19\:n0 \4\:B0 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.8244 \
        scb=0.0124477 scc=0.000698915 m=(1)
mp4_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.076e-14 ad=6.24e-14 ps=1.2575e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.55e-07 sd=160n sca=26.0272 scb=0.019144 \
        scc=0.00277829 m=(4)
C1 (B0 VSS) capacitor c=6.45029e-17
C2 (A0 VSS) capacitor c=8.99733e-17
C3 (Y VSS) capacitor c=3.98225e-17
C4 (VDD VSS) capacitor c=9.5668e-17
C5 (B1 VSS) capacitor c=1.50948e-16
C6 (n1 VSS) capacitor c=1.95858e-18
C7 (n0 VSS) capacitor c=3.26823e-16
C8 (n2 VSS) capacitor c=6.9018e-18
C9 (n3 VSS) capacitor c=5.27882e-17
C10 (\4\:B0 VSS) capacitor c=5.01082e-17
C11 (\1\:B1 VSS) capacitor c=6.08453e-17
C12 (\1\:A1 VSS) capacitor c=5.04952e-17
C13 (\1\:A0 VSS) capacitor c=5.11663e-17
C14 (\3\:B0 VSS) capacitor c=4.76583e-17
C15 (\4\:B1 VSS) capacitor c=3.87366e-17
C16 (\3\:A1 VSS) capacitor c=5.50276e-17
C17 (\3\:A0 VSS) capacitor c=3.0127e-17
C18 (\1\:B0 VSS) capacitor c=1.92429e-17
C19 (\3\:B1 VSS) capacitor c=4.81485e-17
C20 (\2\:A1 VSS) capacitor c=4.4978e-17
C21 (\2\:A0 VSS) capacitor c=3.51039e-17
C22 (\1\:VDD VSS) capacitor c=1.49143e-16
C23 (\1\:Y VSS) capacitor c=1.75452e-16
C24 (\19\:n0 VSS) capacitor c=7.233e-17
C25 (\3\:n3 VSS) capacitor c=8.55288e-17
C26 (\12\:VDD VSS) capacitor c=4.58298e-17
C27 (\5\:n3 VSS) capacitor c=5.16738e-17
C28 (\4\:Y VSS) capacitor c=1.13843e-16
C29 (\17\:n0 VSS) capacitor c=5.8502e-17
C30 (\2\:B0 VSS) capacitor c=2.65359e-17
C31 (\4\:A1 VSS) capacitor c=1.21377e-16
C32 (\5\:B0 VSS) capacitor c=3.78018e-17
C33 (\16\:n0 VSS) capacitor c=1.07288e-16
C34 (\6\:VDD VSS) capacitor c=2.34155e-17
C35 (\7\:VDD VSS) capacitor c=2.16145e-17
Rk6 (\5\:B0 B0) resistor r=0.09861 c=0
Rk1 (A0 \4\:A0) resistor r=0.002995 c=0
Rk12 (\1\:Y Y) resistor r=0.1925 c=0
Rk13 (Y \4\:Y) resistor r=0.1889 c=0
Rk18 (\1\:VDD \6\:VDD) resistor r=0.07248 c=0
Rk20 (\7\:VDD VDD) resistor r=0.1775 c=0
Rk19 (\6\:VDD \7\:VDD) resistor r=0.3231 c=0
Rk23 (\7\:VDD \13\:VDD) resistor r=0.2363 c=0
Rk3 (\5\:B1 B1) resistor r=0.002995 c=0
Rk2 (\4\:A1 A1) resistor r=0.003681 c=0
Rk26 (\5\:VSS VSS) resistor r=0.07474 c=0
Rk25 (\1\:VSS \5\:VSS) resistor r=0.4264 c=0
Rk29 (\5\:VSS \10\:VSS) resistor r=0.2196 c=0
Rk8 (n0 \16\:n0) resistor r=0.3828 c=0
Rk9 (\16\:n0 \18\:n0) resistor r=0.3614 c=0
Rk10 (\16\:n0 \20\:n0) resistor r=0.3493 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3523 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.4372 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=59.3295 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=105.483 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=5.915 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=114.56 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.098 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=130.483 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=34.3295 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.5166 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=48.7687 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=98.7687 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\18\:n0 \17\:n0) resistor r=75 c=0
Ry10 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry4 (\20\:n0 \19\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=31 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=31 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B1 \5\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (n1 \3\:A0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.65e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (\17\:n0 \3\:A1 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.445e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (\17\:n0 \4\:B1 n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.24e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.29e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.03e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=8e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(4)
ends AO22X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:33 2013 )
// Library name: gsclib045_hvt
// Cell name: AO22XL
// View name: extracted

simulator lang=spectre

subckt AO22XL A0 A1 B0 B1 VDD VSS Y
mp0 (n3 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
mp1 (\3\:n3 \1\:A1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.7e-07 sd=160n sca=12.1773 \
        scb=0.00921403 scc=0.000102074 m=(1)
mp3 (\9\:n0 \3\:B1 \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.65e-07 sd=160n sca=11.1982 \
        scb=0.00806486 scc=9.85433e-05 m=(1)
mp2 (\9\:n0 \4\:B0 \5\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.4e-07 sd=160n sca=11.5366 \
        scb=0.00846388 scc=9.92084e-05 m=(1)
mp4 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=55.1271 scb=0.0420653 \
        scc=0.00650135 m=(1)
C1 (A0 VSS) capacitor c=7.70524e-17
C2 (Y VSS) capacitor c=3.72564e-17
C3 (VDD VSS) capacitor c=1.283e-16
C4 (B1 VSS) capacitor c=6.61071e-17
C5 (A1 VSS) capacitor c=1.09964e-16
C6 (n1 VSS) capacitor c=1.69272e-18
C7 (n0 VSS) capacitor c=4.8531e-17
C8 (n2 VSS) capacitor c=2.49646e-18
C9 (n3 VSS) capacitor c=4.77825e-17
C10 (\4\:B0 VSS) capacitor c=4.53564e-17
C11 (\3\:B1 VSS) capacitor c=6.43596e-17
C12 (\1\:A1 VSS) capacitor c=7.01315e-17
C13 (\1\:A0 VSS) capacitor c=5.65867e-17
C14 (\4\:n0 VSS) capacitor c=2.77436e-17
C15 (\3\:B0 VSS) capacitor c=5.11868e-17
C16 (\1\:B1 VSS) capacitor c=3.4545e-17
C17 (\3\:A1 VSS) capacitor c=2.98668e-17
C18 (\3\:A0 VSS) capacitor c=2.7334e-17
C19 (\3\:n0 VSS) capacitor c=5.16144e-17
C20 (\1\:B0 VSS) capacitor c=2.44816e-17
C21 (\2\:B1 VSS) capacitor c=6.73766e-17
C22 (\2\:A1 VSS) capacitor c=7.06267e-17
C23 (\2\:A0 VSS) capacitor c=5.03587e-17
C24 (\1\:Y VSS) capacitor c=4.06069e-17
C25 (\1\:VDD VSS) capacitor c=3.48461e-17
C26 (\5\:n3 VSS) capacitor c=7.79754e-17
C27 (\9\:n0 VSS) capacitor c=7.95465e-17
C28 (\3\:n3 VSS) capacitor c=8.67426e-17
C29 (\6\:VDD VSS) capacitor c=3.32137e-17
C30 (\3\:Y VSS) capacitor c=2.88157e-17
C31 (\7\:n0 VSS) capacitor c=5.65071e-17
C32 (\2\:B0 VSS) capacitor c=4.06684e-17
C33 (\4\:B1 VSS) capacitor c=5.36142e-17
C34 (\5\:B0 VSS) capacitor c=1.06937e-16
C35 (\5\:n0 VSS) capacitor c=5.57994e-17
C36 (\6\:n0 VSS) capacitor c=8.7695e-17
C37 (\4\:VDD VSS) capacitor c=5.99178e-17
C38 (\5\:VDD VSS) capacitor c=1.60321e-17
Rk6 (B0 \5\:B0) resistor r=0.0283 c=0
Rk1 (\4\:A0 A0) resistor r=0.002991 c=0
Rk10 (\2\:Y Y) resistor r=0.2466 c=0
Rk11 (Y \4\:Y) resistor r=0.1181 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.4412 c=0
Rk14 (\5\:VDD VDD) resistor r=0.1699 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.1801 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.1818 c=0
Rk3 (B1 \4\:B1) resistor r=0.1166 c=0
Rk2 (\4\:A1 A1) resistor r=0.002991 c=0
Rk17 (\3\:VSS VSS) resistor r=0.06717 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.272 c=0
Rk18 (\3\:VSS \5\:VSS) resistor r=0.2828 c=0
Rk19 (\5\:VSS \7\:VSS) resistor r=0.414 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.1549 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.2578 c=0
Rk9 (\6\:n0 \10\:n0) resistor r=0.5192 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3844 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.4773 c=0
Rl9 (\2\:B0 \4\:B0) resistor r=166.187 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=108.495 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=5.0163 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=219.923 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=39.1533 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=216.483 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=47.9962 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=218.464 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=37.6944 c=0
Rl10 (n0 \2\:n0) resistor r=166.216 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=28.208 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=14.3357 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (n1 \3\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\7\:n0 \3\:A1 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.117e-14 ps=6.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\7\:n0 \1\:B1 n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.117e-14 ps=5.4e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=5.15e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (n2 \3\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.812e-14 ps=6.1e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (\3\:Y \4\:n0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
ends AO22XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:34 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI211X1
// View name: extracted

simulator lang=spectre

subckt AOI211X1 A0 A1 B0 C0 VDD VSS Y
mp0 (\3\:net91 \1\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.25e-07 sd=160n sca=15.668 \
        scb=0.0150333 scc=0.000302999 m=(1)
mp1 (net91 \1\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.2e-07 sd=160n sca=13.1976 \
        scb=0.0106472 scc=0.00023361 m=(1)
mp2 (net82 \1\:B0 net91 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.07e-14 ps=1.1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.15e-07 sd=160n sca=13.0795 \
        scb=0.0104536 scc=0.000232888 m=(1)
mp3 (\5\:Y \1\:C0 net82 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=5.46e-14 ps=1.04e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.4e-07 sd=160n sca=14.4782 \
        scb=0.0129551 scc=0.000256244 m=(1)
C1 (C0 VSS) capacitor c=7.30775e-17
C2 (A0 VSS) capacitor c=9.56427e-17
C3 (Y VSS) capacitor c=9.38306e-17
C4 (B0 VSS) capacitor c=5.70251e-17
C5 (VDD VSS) capacitor c=1.0164e-16
C6 (A1 VSS) capacitor c=6.30463e-17
C7 (net91 VSS) capacitor c=6.97797e-17
C8 (\1\:C0 VSS) capacitor c=5.74001e-17
C9 (\1\:B0 VSS) capacitor c=7.09041e-17
C10 (\1\:A1 VSS) capacitor c=4.78234e-17
C11 (\1\:A0 VSS) capacitor c=6.19125e-17
C12 (\3\:C0 VSS) capacitor c=3.45564e-17
C13 (\3\:B0 VSS) capacitor c=3.35342e-17
C14 (\3\:A1 VSS) capacitor c=8.05233e-17
C15 (\4\:A0 VSS) capacitor c=5.25374e-17
C16 (\2\:C0 VSS) capacitor c=3.67887e-17
C17 (\2\:B0 VSS) capacitor c=4.48405e-17
C18 (\2\:A1 VSS) capacitor c=6.3434e-17
C19 (\3\:A0 VSS) capacitor c=1.01432e-17
C20 (\5\:Y VSS) capacitor c=9.08878e-17
C21 (\4\:VDD VSS) capacitor c=4.10994e-17
C22 (\3\:net91 VSS) capacitor c=6.28105e-17
C23 (\3\:Y VSS) capacitor c=5.97535e-17
C24 (\2\:A0 VSS) capacitor c=4.53732e-17
C25 (\4\:A1 VSS) capacitor c=5.8427e-17
C26 (\4\:B0 VSS) capacitor c=6.38039e-17
C27 (\4\:C0 VSS) capacitor c=3.34132e-17
C28 (\3\:VDD VSS) capacitor c=5.12885e-17
Rk5 (\4\:C0 C0) resistor r=0.1325 c=0
Rk1 (\5\:A0 A0) resistor r=0.002985 c=0
Rk6 (Y \2\:Y) resistor r=0.005069 c=0
Rk7 (\2\:Y \4\:Y) resistor r=0.3489 c=0
Rk8 (Y \6\:Y) resistor r=0.7916 c=0
Rk4 (B0 \4\:B0) resistor r=0.1064 c=0
Rk10 (\3\:VSS VSS) resistor r=0.08699 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.2114 c=0
Rk11 (\3\:VSS \5\:VSS) resistor r=0.2122 c=0
Rk12 (\5\:VSS \7\:VSS) resistor r=0.2963 c=0
Rk14 (\3\:VDD VDD) resistor r=0.1894 c=0
Rk15 (\3\:VDD \5\:VDD) resistor r=0.1817 c=0
Rk2 (A1 \4\:A1) resistor r=0.0597 c=0
Rk3 (\2\:net91 \4\:net91) resistor r=0.428 c=0
Rl8 (\1\:C0 \2\:C0) resistor r=137.23 c=0
Rl9 (\2\:C0 \3\:C0) resistor r=44.9225 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=160.418 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=37.3411 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=2.4801 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=145.329 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.9442 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=42.2849 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=138.257 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry3 (\5\:Y \6\:Y) resistor r=20.6667 c=0
Ry5 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (net91 \2\:net91) resistor r=31 c=0
Ry2 (\3\:net91 \4\:net91) resistor r=31 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (net95 \4\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.5e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1 (\3\:Y \3\:A1 net95 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=5.59e-14 ps=6.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn2 (\3\:Y \3\:B0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=5.59e-14 ps=8.7e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=3.85e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3 (\1\:Y \3\:C0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.29e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.65e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
ends AOI211X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:35 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI211X2
// View name: extracted

simulator lang=spectre

subckt AOI211X2 A0 A1 B0 C0 VDD VSS Y
mp0 (net91 \2\:A0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.712e-14 ad=6.24e-14 ps=1.335e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=28.3818 \
        scb=0.0323196 scc=0.00228512 m=(2)
mp3 (\1\:Y \1\:C0 net82 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=20.8676 \
        scb=0.019613 scc=0.00142067 m=(2)
mp2 (net82 \1\:B0 \6\:net91 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=17.5811 \
        scb=0.0153688 scc=0.00137895 m=(2)
mp1_1__rcx (net91 \3\:A1 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.1e-07 sd=160n sca=18.3481 \
        scb=0.0176469 scc=0.000920496 m=(2)
C1 (C0 VSS) capacitor c=3.23584e-17
C2 (B0 VSS) capacitor c=7.81757e-17
C3 (Y VSS) capacitor c=9.07934e-17
C4 (VDD VSS) capacitor c=2.49934e-16
C5 (A0 VSS) capacitor c=1.70158e-17
C6 (11 VSS) capacitor c=1.71309e-18
C7 (net91 VSS) capacitor c=1.61889e-16
C8 (net82 VSS) capacitor c=1.96601e-16
C9 (\1\:C0 VSS) capacitor c=1.51599e-16
C10 (\1\:B0 VSS) capacitor c=1.69855e-16
C11 (\6\:A0 VSS) capacitor c=5.37235e-17
C12 (\1\:A1 VSS) capacitor c=4.91087e-17
C13 (\4\:A1 VSS) capacitor c=4.26646e-17
C14 (\1\:A0 VSS) capacitor c=4.80516e-17
C15 (\3\:A1 VSS) capacitor c=1.10667e-16
C16 (\2\:A0 VSS) capacitor c=3.35101e-16
C17 (\1\:Y VSS) capacitor c=1.14439e-16
C18 (\6\:net91 VSS) capacitor c=9.37511e-17
C19 (\6\:VDD VSS) capacitor c=4.48313e-17
C20 (\8\:Y VSS) capacitor c=5.26868e-17
C21 (\6\:Y VSS) capacitor c=5.26484e-17
C22 (\4\:Y VSS) capacitor c=6.52784e-17
C23 (\2\:A1 VSS) capacitor c=4.35268e-17
C24 (\8\:A1 VSS) capacitor c=3.21928e-17
C25 (\9\:A1 VSS) capacitor c=6.73711e-17
C26 (\7\:B0 VSS) capacitor c=3.79136e-17
C27 (\3\:Y VSS) capacitor c=4.30019e-17
C28 (\7\:C0 VSS) capacitor c=4.26276e-17
Rk18 (C0 \7\:C0) resistor r=0.04844 c=0
Rk1 (\7\:A1 \8\:A1) resistor r=0.001734 c=0
Rk2 (\9\:A1 A1) resistor r=0.001734 c=0
Rk3 (\8\:A1 \9\:A1) resistor r=0.06012 c=0
Rk9 (\7\:B0 B0) resistor r=0.1081 c=0
Rk10 (\2\:Y Y) resistor r=0.7072 c=0
Rk11 (Y \3\:Y) resistor r=0.08439 c=0
Rk12 (\3\:Y \5\:Y) resistor r=0.3749 c=0
Rk13 (\3\:Y \7\:Y) resistor r=0.1174 c=0
Rk14 (\7\:Y \9\:Y) resistor r=0.3374 c=0
Rk29 (VDD \7\:VDD) resistor r=0.2473 c=0
Rk5 (\2\:A0 A0) resistor r=0.03871 c=0
Rk23 (\7\:VSS VSS) resistor r=0.09483 c=0
Rk22 (\1\:VSS \7\:VSS) resistor r=0.3005 c=0
Rk26 (\7\:VSS \13\:VSS) resistor r=0.2039 c=0
Rk8 (net91 \7\:net91) resistor r=0.4201 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=73.5354 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=54.3046 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.0112 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=33.3841 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=28.6412 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:Y \6\:Y) resistor r=75 c=0
Rz3 (\9\:Y \8\:Y) resistor r=75 c=0
Rz7 (\13\:VSS \12\:VSS) resistor r=75 c=0
Ry4 (\2\:Y \1\:Y) resistor r=31 c=0
Ry10 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\7\:net91 \6\:net91) resistor r=62 c=0
Rx5 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\7\:A1 \3\:A1) resistor r=45 c=0
Rx4 (\7\:B0 \1\:B0) resistor r=45 c=0
mn0_1__rcx (10 \1\:A0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.545e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (\4\:Y \4\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.43e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\4\:Y \1\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=1.225e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (11 \6\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.54e-14 ad=1.56e-14 ps=1.1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.12e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\8\:Y \1\:C0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2_1__rcx (\6\:Y \1\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
ends AOI211X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:36 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI211X4
// View name: extracted

simulator lang=spectre

subckt AOI211X4 A0 A1 B0 C0 VDD VSS Y
mp3_1__rcx (\1\:Y C0 net82 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59487e-07 sb=7.55e-07 sd=160n sca=12.5232 \
        scb=0.0108581 scc=0.000412418 m=(4)
mp2_1__rcx (net82 \1\:B0 \8\:net91 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.04e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39487e-07 sb=1.575e-06 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(4)
mp0_1__rcx (net91 A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.914e-14 ad=6.24e-14 ps=1.1925e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.535e-06 sd=160n sca=21.0705 \
        scb=0.0236471 scc=0.000934065 m=(4)
mp1_1__rcx (net91 A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.33e-06 sd=160n sca=15.0091 \
        scb=0.0134988 scc=0.00042661 m=(4)
C1 (C0 VSS) capacitor c=3.537e-16
C2 (A1 VSS) capacitor c=3.82381e-16
C3 (B0 VSS) capacitor c=2.06237e-17
C4 (Y VSS) capacitor c=1.29517e-17
C5 (VDD VSS) capacitor c=2.10804e-16
C6 (A0 VSS) capacitor c=6.37095e-16
C7 (11 VSS) capacitor c=1.7621e-18
C8 (12 VSS) capacitor c=1.7621e-18
C9 (13 VSS) capacitor c=1.7621e-18
C10 (net91 VSS) capacitor c=3.13515e-16
C11 (net82 VSS) capacitor c=3.50214e-16
C12 (\1\:B0 VSS) capacitor c=4.05906e-16
C13 (\12\:A0 VSS) capacitor c=5.82035e-17
C14 (\8\:A1 VSS) capacitor c=6.30801e-17
C15 (\11\:A1 VSS) capacitor c=5.57214e-17
C16 (\4\:A0 VSS) capacitor c=6.69829e-17
C17 (\6\:A0 VSS) capacitor c=4.79154e-17
C18 (\1\:A1 VSS) capacitor c=6.5802e-17
C19 (\4\:A1 VSS) capacitor c=4.62066e-17
C20 (\1\:A0 VSS) capacitor c=7.72677e-17
C21 (\1\:Y VSS) capacitor c=2.42865e-16
C22 (\8\:net91 VSS) capacitor c=2.03492e-16
C23 (\1\:VDD VSS) capacitor c=1.175e-16
C24 (\16\:Y VSS) capacitor c=1.23795e-16
C25 (\12\:Y VSS) capacitor c=6.14418e-17
C26 (\6\:Y VSS) capacitor c=9.86673e-17
C27 (\8\:Y VSS) capacitor c=6.95681e-17
C28 (\2\:A1 VSS) capacitor c=3.18911e-17
C29 (\9\:A1 VSS) capacitor c=3.50276e-17
C30 (\4\:Y VSS) capacitor c=1.36565e-16
C31 (\5\:Y VSS) capacitor c=6.75743e-17
C32 (\3\:VDD VSS) capacitor c=2.59681e-16
Rk6 (B0 \1\:B0) resistor r=0.03619 c=0
Rk27 (\12\:Y \16\:Y) resistor r=0.3006 c=0
Rk24 (\4\:Y Y) resistor r=0.003066 c=0
Rk19 (\1\:Y \4\:Y) resistor r=1.1187 c=0
Rk25 (\5\:Y \12\:Y) resistor r=0.05823 c=0
Rk20 (\4\:Y \5\:Y) resistor r=0.1072 c=0
Rk21 (\5\:Y \7\:Y) resistor r=0.3845 c=0
Rk22 (\7\:Y \9\:Y) resistor r=0.4656 c=0
Rk55 (\3\:VDD VDD) resistor r=0.02961 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.6359 c=0
Rk39 (\1\:VSS \8\:VSS) resistor r=0.2603 c=0
Rk40 (\8\:VSS \9\:VSS) resistor r=0.04989 c=0
Rk42 (\10\:VSS VSS) resistor r=0.2049 c=0
Rk41 (\9\:VSS \10\:VSS) resistor r=0.2951 c=0
Rk47 (\9\:VSS \20\:VSS) resistor r=0.1979 c=0
Rk48 (\10\:VSS \22\:VSS) resistor r=0.2024 c=0
Rk12 (net91 \8\:net91) resistor r=0.4445 c=0
Rl4 (\2\:A1 A1) resistor r=29.4415 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl15 (\9\:A1 A1) resistor r=6.3032 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=137.946 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=88.5249 c=0
Rl20 (A0 \12\:A0) resistor r=41.4835 c=0
Rl9 (A0 \4\:A0) resistor r=85.3597 c=0
Rl10 (A0 \6\:A0) resistor r=39.5284 c=0
Rl1 (A0 \1\:A0) resistor r=140.362 c=0
Rz1 (\7\:Y \6\:Y) resistor r=75 c=0
Rz2 (\9\:Y \8\:Y) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz13 (\22\:VSS \21\:VSS) resistor r=75 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry15 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (10 \1\:A0 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\8\:Y \4\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\8\:Y \1\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (11 \6\:A0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (12 \4\:A0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_3__rcx (\6\:Y \11\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\6\:Y \8\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.07e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (13 \12\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=1.56e-14 ps=9.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.95e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\16\:Y C0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.582e-14 ad=4.16e-14 ps=8.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn2_1__rcx (\12\:Y \1\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.492e-14 ad=4.225e-14 ps=9.425e-07 pd=8.45e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.42e-06 sb=1.705e-06 sd=160n \
        sca=9.14564 scb=0.00759168 scc=0.000213449 m=(4)
ends AOI211X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:37 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI211XL
// View name: extracted

simulator lang=spectre

subckt AOI211XL A0 A1 B0 C0 VDD VSS Y
mp0 (net91 \3\:A0 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.95e-07 sd=160n sca=21.1265 \
        scb=0.0233936 scc=0.000954114 m=(1)
mp1 (\3\:net91 \1\:A1 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.268e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.9e-07 sd=160n sca=13.9396 \
        scb=0.0112937 scc=0.000117391 m=(1)
mp2 (net82 \1\:B0 \3\:net91 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.268e-14 ad=3.44e-14 ps=9.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=4e-07 sd=160n sca=13.5585 scb=0.010525 \
        scc=0.000106027 m=(1)
mp3 (\1\:Y \1\:C0 net82 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.95e-07 sd=160n sca=18.7951 \
        scb=0.0200922 scc=0.000572349 m=(1)
C1 (C0 VSS) capacitor c=5.26787e-17
C2 (B0 VSS) capacitor c=3.89959e-17
C3 (VDD VSS) capacitor c=1.16235e-16
C4 (A1 VSS) capacitor c=5.4051e-17
C5 (Y VSS) capacitor c=5.07836e-17
C6 (net91 VSS) capacitor c=6.267e-17
C7 (\1\:C0 VSS) capacitor c=4.76361e-17
C8 (\1\:B0 VSS) capacitor c=5.43928e-17
C9 (\1\:A1 VSS) capacitor c=5.56121e-17
C10 (\3\:A0 VSS) capacitor c=5.46735e-17
C11 (\3\:C0 VSS) capacitor c=3.80707e-17
C12 (\3\:B0 VSS) capacitor c=3.43463e-17
C13 (\3\:A1 VSS) capacitor c=5.68629e-17
C14 (\1\:A0 VSS) capacitor c=6.96987e-17
C15 (\2\:C0 VSS) capacitor c=5.26859e-17
C16 (\2\:B0 VSS) capacitor c=5.77268e-17
C17 (\2\:A1 VSS) capacitor c=5.87627e-17
C18 (\2\:A0 VSS) capacitor c=5.32385e-17
C19 (\1\:Y VSS) capacitor c=1.59008e-17
C20 (\3\:net91 VSS) capacitor c=5.01604e-17
C21 (\4\:VDD VSS) capacitor c=3.17741e-17
C22 (\6\:Y VSS) capacitor c=2.80975e-17
C23 (\4\:Y VSS) capacitor c=6.70976e-17
C24 (\4\:A0 VSS) capacitor c=1.9679e-17
C25 (\6\:A0 VSS) capacitor c=7.83369e-17
C26 (\4\:A1 VSS) capacitor c=5.15877e-17
C27 (\4\:B0 VSS) capacitor c=7.06757e-17
C28 (\4\:C0 VSS) capacitor c=6.28574e-17
C29 (\3\:Y VSS) capacitor c=7.18478e-17
C30 (\3\:VDD VSS) capacitor c=3.11002e-17
Rk7 (C0 \4\:C0) resistor r=0.225 c=0
Rk1 (\4\:A0 \5\:A0) resistor r=0.002021 c=0
Rk2 (A0 \6\:A0) resistor r=0.001953 c=0
Rk3 (\4\:A0 \6\:A0) resistor r=0.05142 c=0
Rk6 (B0 \4\:B0) resistor r=0.1148 c=0
Rk13 (\3\:VSS VSS) resistor r=0.06475 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1939 c=0
Rk14 (\3\:VSS \5\:VSS) resistor r=0.1854 c=0
Rk15 (\5\:VSS \7\:VSS) resistor r=0.3057 c=0
Rk17 (\3\:VDD VDD) resistor r=0.1174 c=0
Rk18 (\3\:VDD \5\:VDD) resistor r=0.234 c=0
Rk4 (\4\:A1 A1) resistor r=0.1584 c=0
Rk8 (\2\:Y Y) resistor r=0.1267 c=0
Rk9 (Y \3\:Y) resistor r=0.4242 c=0
Rk10 (\3\:Y \5\:Y) resistor r=0.3839 c=0
Rk11 (\3\:Y \7\:Y) resistor r=0.0641 c=0
Rk5 (\2\:net91 \4\:net91) resistor r=0.3117 c=0
Rl7 (\1\:C0 \2\:C0) resistor r=181.461 c=0
Rl8 (\2\:C0 \3\:C0) resistor r=89.1533 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=225.722 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=105.323 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=193 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=77.6149 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=178.079 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=89.6174 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Ry5 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry1 (net91 \2\:net91) resistor r=62 c=0
Ry2 (\3\:net91 \4\:net91) resistor r=62 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\2\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (net95 \1\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (\4\:Y \3\:A1 net95 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.35e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\4\:Y \3\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.553e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn3 (\6\:Y \3\:C0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
ends AOI211XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:38 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI21X1
// View name: extracted

simulator lang=spectre

subckt AOI21X1 A0 A1 B0 VDD VSS Y
mp0 (\3\:net62 \1\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=26.2807 \
        scb=0.0297759 scc=0.00178997 m=(1)
mp1 (net62 \1\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.6e-07 sd=160n sca=17.2376 \
        scb=0.0159027 scc=0.000426763 m=(1)
mp2 (\1\:Y \1\:B0 net62 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.55e-07 sd=160n sca=17.5198 \
        scb=0.0164926 scc=0.000444164 m=(1)
C1 (Y VSS) capacitor c=7.99689e-17
C2 (B0 VSS) capacitor c=4.65527e-17
C3 (VDD VSS) capacitor c=7.53873e-17
C4 (net62 VSS) capacitor c=9.20627e-17
C5 (\1\:B0 VSS) capacitor c=5.61491e-17
C6 (\1\:A1 VSS) capacitor c=5.80643e-17
C7 (\1\:A0 VSS) capacitor c=5.87649e-17
C8 (\3\:B0 VSS) capacitor c=2.83551e-17
C9 (\3\:A1 VSS) capacitor c=7.76253e-17
C10 (\4\:A0 VSS) capacitor c=5.03821e-17
C11 (\2\:B0 VSS) capacitor c=4.04947e-17
C12 (\2\:A1 VSS) capacitor c=6.28628e-17
C13 (\3\:A0 VSS) capacitor c=1.08414e-17
C14 (\1\:Y VSS) capacitor c=3.01094e-17
C15 (\4\:VDD VSS) capacitor c=6.35667e-17
C16 (\3\:net62 VSS) capacitor c=5.57294e-17
C17 (\4\:Y VSS) capacitor c=1.10179e-16
C18 (\2\:A0 VSS) capacitor c=4.88563e-17
C19 (\5\:A0 VSS) capacitor c=3.15513e-17
C20 (\6\:A0 VSS) capacitor c=3.76508e-17
C21 (\4\:A1 VSS) capacitor c=5.28886e-17
C22 (\5\:A1 VSS) capacitor c=3.04925e-17
C23 (\4\:B0 VSS) capacitor c=6.69914e-17
C24 (\3\:VDD VSS) capacitor c=2.89113e-17
Rk4 (A1 \4\:A1) resistor r=0.004153 c=0
Rk6 (\4\:A1 \5\:A1) resistor r=0.05764 c=0
Rk5 (\5\:A1 \6\:A1) resistor r=0.004275 c=0
Rk1 (A0 \5\:A0) resistor r=0.003828 c=0
Rk3 (\5\:A0 \6\:A0) resistor r=0.07017 c=0
Rk2 (\6\:A0 \7\:A0) resistor r=0.00396 c=0
Rk9 (\2\:Y Y) resistor r=0.1567 c=0
Rk10 (Y \5\:Y) resistor r=0.7222 c=0
Rk13 (\4\:VSS VSS) resistor r=0.2005 c=0
Rk12 (\2\:VSS \4\:VSS) resistor r=0.2367 c=0
Rk14 (VSS \6\:VSS) resistor r=0.1819 c=0
Rk8 (B0 \4\:B0) resistor r=0.1453 c=0
Rk16 (\3\:VDD VDD) resistor r=0.1023 c=0
Rk17 (\3\:VDD \5\:VDD) resistor r=0.2595 c=0
Rk7 (\2\:net62 \4\:net62) resistor r=0.5608 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=94.208 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=94.0258 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=160.418 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=45.0334 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=3.1183 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=159.593 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=28.6412 c=0
Rz1 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\4\:VDD \5\:VDD) resistor r=31 c=0
Ry1 (net62 \2\:net62) resistor r=31 c=0
Ry2 (\3\:net62 \4\:net62) resistor r=31 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \7\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net78 \4\:A0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.89e-14 ad=1.56e-14 ps=1.1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\4\:Y \3\:A1 net78 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\4\:Y \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=4.16e-14 ps=1.1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
ends AOI21X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:39 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI21X2
// View name: extracted

simulator lang=spectre

subckt AOI21X2 A0 A1 B0 VDD VSS Y
mp1 (\8\:net70 \1\:A1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.015e-06 sd=160n sca=33.2136 \
        scb=0.0229892 scc=0.00337651 m=(2)
mp2 (\1\:Y \1\:B0 net70 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.922e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=3.45e-07 sd=160n sca=33.1443 \
        scb=0.0228772 scc=0.00337517 m=(2)
mp0 (net70 A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.922e-14 ps=1.1e-06 pd=1.135e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=39.514 \
        scb=0.0334743 scc=0.00392846 m=(2)
C1 (A0 VSS) capacitor c=3.23956e-16
C2 (Y VSS) capacitor c=3.75193e-17
C3 (A1 VSS) capacitor c=4.76384e-17
C4 (VDD VSS) capacitor c=5.37171e-17
C5 (B0 VSS) capacitor c=3.98842e-17
C6 (9 VSS) capacitor c=2.32326e-18
C7 (net70 VSS) capacitor c=2.1166e-16
C8 (\1\:B0 VSS) capacitor c=8.56094e-17
C9 (\1\:A1 VSS) capacitor c=8.51713e-17
C10 (\6\:A0 VSS) capacitor c=5.3629e-17
C11 (\6\:A1 VSS) capacitor c=4.73042e-17
C12 (\4\:A1 VSS) capacitor c=5.3509e-17
C13 (\1\:A0 VSS) capacitor c=5.27991e-17
C14 (\1\:Y VSS) capacitor c=5.85529e-17
C15 (\1\:VDD VSS) capacitor c=1.33871e-16
C16 (\8\:net70 VSS) capacitor c=3.40136e-17
C17 (\3\:Y VSS) capacitor c=5.27524e-17
C18 (\5\:Y VSS) capacitor c=6.79386e-17
C19 (\3\:A1 VSS) capacitor c=3.95375e-17
C20 (\4\:B0 VSS) capacitor c=6.71e-17
C21 (\9\:A1 VSS) capacitor c=4.64945e-17
C22 (\8\:B0 VSS) capacitor c=4.04119e-17
Rk6 (\2\:Y Y) resistor r=0.2816 c=0
Rk7 (Y \4\:Y) resistor r=0.1446 c=0
Rk8 (\4\:Y \6\:Y) resistor r=0.4409 c=0
Rk1 (\7\:A1 A1) resistor r=0.005392 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.0965 c=0
Rk2 (\8\:A1 \9\:A1) resistor r=0.005392 c=0
Rk15 (\1\:VSS \5\:VSS) resistor r=0.03487 c=0
Rk17 (\6\:VSS VSS) resistor r=0.07719 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.2728 c=0
Rk19 (\6\:VSS \10\:VSS) resistor r=0.1792 c=0
Rk23 (\1\:VDD VDD) resistor r=0.1298 c=0
Rk13 (B0 \8\:B0) resistor r=0.1159 c=0
Rk12 (net70 \9\:net70) resistor r=0.06065 c=0
Rl9 (A0 \6\:A0) resistor r=45.6044 c=0
Rl1 (A0 \1\:A0) resistor r=31.9251 c=0
Rl4 (\3\:A1 \1\:A1) resistor r=9.9515 c=0
Rl7 (\3\:A1 \6\:A1) resistor r=113.668 c=0
Rl5 (\3\:A1 \4\:A1) resistor r=70.6802 c=0
Rl12 (\4\:B0 \1\:B0) resistor r=26.8198 c=0
Rz1 (\4\:Y \3\:Y) resistor r=75 c=0
Rz2 (\6\:Y \5\:Y) resistor r=75 c=0
Rz5 (\10\:VSS \9\:VSS) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=62 c=0
Ry5 (\9\:net70 \8\:net70) resistor r=31 c=0
Rx1 (\8\:A1 \1\:A1) resistor r=45 c=0
Rx4 (\8\:B0 \1\:B0) resistor r=45 c=0
mn0_1__rcx (8 \1\:A0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1_1__rcx (\5\:Y \4\:A1 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.9e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (\5\:Y \6\:A1 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.21e-14 \
        ad=4.16e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.85e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn0 (9 \6\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=2.21e-14 ps=8.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=5.55e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (\3\:Y \4\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=4.16e-14 ps=8.25e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=3.45e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(2)
ends AOI21X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:41 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI21X4
// View name: extracted

simulator lang=spectre

subckt AOI21X4 A0 A1 B0 VDD VSS Y
mp0_1__rcx (net70 \2\:A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.142e-14 ps=1.1e-06 pd=1.095e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.7719 scb=0.023448 \
        scc=0.0017399 m=(4)
mp1_1__rcx (net70 A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=20.1813 scb=0.0174167 \
        scc=0.00159977 m=(4)
mp2_1__rcx (\10\:Y B0 net70 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.142e-14 ad=6.24e-14 ps=1.095e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=7.55e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
C1 (A0 VSS) capacitor c=3.72999e-17
C2 (Y VSS) capacitor c=6.06891e-17
C3 (A1 VSS) capacitor c=3.83932e-16
C4 (VDD VSS) capacitor c=1.0948e-16
C5 (B0 VSS) capacitor c=3.55175e-16
C6 (9 VSS) capacitor c=1.82117e-18
C7 (10 VSS) capacitor c=1.77435e-18
C8 (11 VSS) capacitor c=1.79527e-18
C9 (net70 VSS) capacitor c=4.78873e-16
C10 (\12\:A0 VSS) capacitor c=6.71688e-17
C11 (\12\:A1 VSS) capacitor c=6.2149e-17
C12 (\10\:A1 VSS) capacitor c=5.40382e-17
C13 (\4\:A0 VSS) capacitor c=5.30746e-17
C14 (\6\:A0 VSS) capacitor c=4.89127e-17
C15 (\1\:A1 VSS) capacitor c=6.83111e-17
C16 (\4\:A1 VSS) capacitor c=4.80598e-17
C17 (\1\:A0 VSS) capacitor c=5.49719e-17
C18 (\2\:A0 VSS) capacitor c=6.01214e-16
C19 (\10\:Y VSS) capacitor c=1.02015e-16
C20 (\1\:VDD VSS) capacitor c=5.06598e-17
C21 (\1\:Y VSS) capacitor c=1.04746e-16
C22 (\4\:Y VSS) capacitor c=8.814e-17
C23 (\6\:Y VSS) capacitor c=6.7645e-17
C24 (\2\:A1 VSS) capacitor c=3.09817e-17
C25 (\9\:A1 VSS) capacitor c=3.89699e-17
C26 (\3\:Y VSS) capacitor c=6.38825e-17
C27 (\3\:VDD VSS) capacitor c=2.20517e-16
Rk3 (A0 \2\:A0) resistor r=0.08359 c=0
Rk11 (Y \10\:Y) resistor r=0.0853 c=0
Rk10 (\3\:Y Y) resistor r=0.3437 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.04576 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.3361 c=0
Rk8 (\5\:Y \7\:Y) resistor r=0.4638 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.04477 c=0
Rk28 (\3\:VSS \6\:VSS) resistor r=0.2721 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.03728 c=0
Rk31 (\8\:VSS VSS) resistor r=0.2169 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.2944 c=0
Rk35 (\7\:VSS \16\:VSS) resistor r=0.197 c=0
Rk36 (\8\:VSS \18\:VSS) resistor r=0.2015 c=0
Rk42 (\3\:VDD VDD) resistor r=0.1694 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.5144 c=0
Rl19 (\2\:A0 \12\:A0) resistor r=55.0021 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=73.8213 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=51.7021 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=43.4636 c=0
Rl4 (\2\:A1 A1) resistor r=25.7773 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=86.2215 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=38.3697 c=0
Rl14 (\9\:A1 A1) resistor r=10.2925 c=0
Rl17 (\9\:A1 \12\:A1) resistor r=128.331 c=0
Rl15 (\9\:A1 \10\:A1) resistor r=78.9095 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz8 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz9 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry11 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (8 \1\:A0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\6\:Y \4\:A1 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.905e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\6\:Y \1\:A1 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.7e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (9 \6\:A0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.595e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (10 \4\:A0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.39e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\4\:Y \10\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\4\:Y \12\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.08e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (11 \12\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=9.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\1\:Y B0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=7.7e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
ends AOI21X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:42 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI21XL
// View name: extracted

simulator lang=spectre

subckt AOI21XL A0 A1 B0 VDD VSS Y
mp0 (net70 \3\:A0 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.01e-14 ps=1.23e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=17.8246 \
        scb=0.0177319 scc=0.000363007 m=(1)
mp1 (\3\:net70 \1\:A1 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.44e-14 ps=1.23e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=14.8802 \
        scb=0.0119982 scc=0.000102266 m=(1)
mp2 (\3\:Y \4\:B0 \3\:net70 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=21.4669 \
        scb=0.0232556 scc=0.000936595 m=(1)
C1 (A1 VSS) capacitor c=5.1829e-17
C2 (Y VSS) capacitor c=7.21436e-17
C3 (A0 VSS) capacitor c=3.94428e-17
C4 (VDD VSS) capacitor c=1.23011e-16
C5 (B0 VSS) capacitor c=7.66654e-17
C6 (net70 VSS) capacitor c=3.50324e-17
C7 (\4\:B0 VSS) capacitor c=4.71515e-17
C8 (\1\:A1 VSS) capacitor c=7.1343e-17
C9 (\3\:A0 VSS) capacitor c=5.79369e-17
C10 (\1\:B0 VSS) capacitor c=3.12685e-17
C11 (\3\:A1 VSS) capacitor c=4.05455e-17
C12 (\1\:A0 VSS) capacitor c=4.55908e-17
C13 (\3\:B0 VSS) capacitor c=5.6704e-17
C14 (\2\:A1 VSS) capacitor c=7.48503e-17
C15 (\2\:A0 VSS) capacitor c=4.68697e-17
C16 (\3\:Y VSS) capacitor c=5.84132e-17
C17 (\3\:net70 VSS) capacitor c=5.59033e-17
C18 (\4\:VDD VSS) capacitor c=2.68757e-17
C19 (\1\:Y VSS) capacitor c=7.57838e-17
C20 (\4\:A0 VSS) capacitor c=3.73037e-17
C21 (\4\:A1 VSS) capacitor c=6.52974e-17
C22 (\5\:B0 VSS) capacitor c=2.90975e-17
C23 (\3\:VDD VSS) capacitor c=3.68269e-17
Rk2 (A1 \4\:A1) resistor r=0.2094 c=0
Rk7 (\2\:Y Y) resistor r=0.2871 c=0
Rk8 (Y \4\:Y) resistor r=0.4296 c=0
Rk1 (\4\:A0 A0) resistor r=0.09189 c=0
Rk10 (\3\:VSS VSS) resistor r=0.08721 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.2882 c=0
Rk11 (\3\:VSS \5\:VSS) resistor r=0.1125 c=0
Rk12 (\5\:VSS \7\:VSS) resistor r=0.4421 c=0
Rk14 (\3\:VDD VDD) resistor r=0.1648 c=0
Rk15 (\3\:VDD \5\:VDD) resistor r=0.07323 c=0
Rk6 (\5\:B0 B0) resistor r=0.03888 c=0
Rk3 (\2\:net70 \4\:net70) resistor r=0.2768 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=218.312 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.9451 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=203.641 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=55.7464 c=0
Rl7 (\2\:B0 \4\:B0) resistor r=168.236 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=98.4889 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=2.0644 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry5 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (net70 \2\:net70) resistor r=62 c=0
Ry2 (\3\:net70 \4\:net70) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B0 \5\:B0) resistor r=45 c=0
mn0 (net74 \1\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.35e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\1\:Y \3\:A1 net74 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\1\:Y \1\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.553e-14 ps=5.7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
ends AOI21XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:43 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI221X1
// View name: extracted

simulator lang=spectre

subckt AOI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\3\:net111 \3\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.05e-07 sd=160n sca=40.7758 \
        scb=0.038454 scc=0.00437052 m=(1)
mp1 (\3\:net111 \1\:A1 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=6.24e-14 ps=1.78e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-07 sd=160n sca=30.7421 scb=0.0237813 \
        scc=0.0030059 m=(1)
mp3 (\3\:net108 \1\:B1 net111 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=28.7609 scb=0.020281 \
        scc=0.00296496 m=(1)
mp2 (net108 \1\:B0 net111 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=30.4607 \
        scb=0.0232925 scc=0.00299608 m=(1)
mp4 (\4\:Y \1\:C0 net108 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=39.2278 \
        scb=0.0367431 scc=0.00406631 m=(1)
C1 (A0 VSS) capacitor c=2.97989e-17
C2 (Y VSS) capacitor c=4.10303e-17
C3 (VDD VSS) capacitor c=6.17573e-17
C4 (net128 VSS) capacitor c=1.68696e-18
C5 (net120 VSS) capacitor c=3.08887e-18
C6 (net111 VSS) capacitor c=9.31927e-17
C7 (net108 VSS) capacitor c=7.03119e-17
C8 (\1\:C0 VSS) capacitor c=4.54404e-17
C9 (\1\:B0 VSS) capacitor c=4.8345e-17
C10 (\1\:B1 VSS) capacitor c=5.7665e-17
C11 (\1\:A1 VSS) capacitor c=5.57769e-17
C12 (\3\:A0 VSS) capacitor c=4.67489e-17
C13 (\3\:C0 VSS) capacitor c=3.885e-17
C14 (\3\:B0 VSS) capacitor c=7.0818e-17
C15 (\4\:B1 VSS) capacitor c=5.34304e-17
C16 (\3\:A1 VSS) capacitor c=4.52751e-17
C17 (\1\:A0 VSS) capacitor c=3.7681e-17
C18 (\2\:C0 VSS) capacitor c=3.62648e-17
C19 (\2\:B0 VSS) capacitor c=5.53929e-17
C20 (\3\:B1 VSS) capacitor c=4.9841e-17
C21 (\2\:A1 VSS) capacitor c=3.80539e-17
C22 (\2\:A0 VSS) capacitor c=3.89199e-17
C23 (\4\:Y VSS) capacitor c=2.65774e-17
C24 (\3\:net108 VSS) capacitor c=6.50594e-17
C25 (\6\:VDD VSS) capacitor c=1.18976e-17
C26 (\3\:net111 VSS) capacitor c=5.76187e-17
C27 (\4\:VDD VSS) capacitor c=3.57731e-17
C28 (\6\:Y VSS) capacitor c=2.70432e-17
C29 (\1\:Y VSS) capacitor c=7.52161e-17
C30 (\4\:A0 VSS) capacitor c=4.18223e-17
C31 (\4\:A1 VSS) capacitor c=6.18813e-17
C32 (\6\:B1 VSS) capacitor c=6.01841e-17
C33 (\7\:B1 VSS) capacitor c=4.1422e-17
C34 (\4\:B0 VSS) capacitor c=7.1584e-17
C35 (\6\:B0 VSS) capacitor c=3.2288e-17
C36 (\4\:C0 VSS) capacitor c=4.55041e-17
C37 (\6\:C0 VSS) capacitor c=3.83502e-17
C38 (\3\:Y VSS) capacitor c=8.01942e-17
C39 (\3\:VDD VSS) capacitor c=4.02359e-17
Rk11 (C0 \4\:C0) resistor r=0.002852 c=0
Rk13 (\4\:C0 \6\:C0) resistor r=0.007527 c=0
Rk12 (\5\:C0 \6\:C0) resistor r=0.002852 c=0
Rk2 (\4\:A1 A1) resistor r=0.03258 c=0
Rk7 (\4\:B0 \5\:B0) resistor r=0.001408 c=0
Rk8 (B0 \6\:B0) resistor r=0.001314 c=0
Rk9 (\4\:B0 \6\:B0) resistor r=0.04218 c=0
Rk1 (A0 \4\:A0) resistor r=0.07948 c=0
Rk15 (\3\:Y Y) resistor r=0.4127 c=0
Rk14 (\2\:Y \3\:Y) resistor r=0.4174 c=0
Rk16 (Y \5\:Y) resistor r=0.03477 c=0
Rk17 (\3\:Y \7\:Y) resistor r=0.08872 c=0
Rk23 (\3\:VDD VDD) resistor r=0.2204 c=0
Rk24 (VDD \5\:VDD) resistor r=0.3929 c=0
Rk25 (\3\:VDD \7\:VDD) resistor r=0.1563 c=0
Rk19 (\3\:VSS VSS) resistor r=0.01709 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.2127 c=0
Rk20 (\3\:VSS \5\:VSS) resistor r=0.283 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.3165 c=0
Rk3 (\5\:B1 \6\:B1) resistor r=0.001878 c=0
Rk4 (B1 \7\:B1) resistor r=0.001784 c=0
Rk5 (\5\:B1 \7\:B1) resistor r=0.1097 c=0
Rk6 (\2\:net111 \4\:net111) resistor r=0.4022 c=0
Rk10 (\2\:net108 \4\:net108) resistor r=0.3777 c=0
Rl10 (\1\:C0 \2\:C0) resistor r=79.0433 c=0
Rl11 (\2\:C0 \3\:C0) resistor r=60.989 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=73.7687 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=62.2302 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=41.3798 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=94.0258 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=106.868 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=91.1873 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=60.4181 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.6051 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry5 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry7 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (net111 \2\:net111) resistor r=62 c=0
Ry2 (\3\:net111 \4\:net111) resistor r=62 c=0
Ry3 (net108 \2\:net108) resistor r=31 c=0
Ry4 (\3\:net108 \4\:net108) resistor r=62 c=0
Rx5 (\2\:C0 \5\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
mn0 (net128 \1\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=2.34e-14 ps=8.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=1.03e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\1\:Y \3\:A1 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.32e-14 ps=7e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=8.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \4\:B1 net120 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=8.32e-14 ps=6.6e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=5.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net120 \3\:B0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.82e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=4.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\6\:Y \3\:C0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.46e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
ends AOI221X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:44 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI221X2
// View name: extracted

simulator lang=spectre

subckt AOI221X2 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\5\:net103 \2\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=22.5802 \
        scb=0.0254567 scc=0.001215 m=(2)
mp3_1__rcx (\9\:net104 \1\:B1 net103 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp2 (net104 B0 net103 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\8\:Y \1\:C0 net104 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=16.4248 \
        scb=0.0152088 scc=0.000666128 m=(2)
mp1_1__rcx (\5\:net103 \4\:A1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=16.2799 \
        scb=0.0149716 scc=0.000663053 m=(2)
C1 (C0 VSS) capacitor c=3.55628e-17
C2 (B0 VSS) capacitor c=3.97195e-16
C3 (A1 VSS) capacitor c=5.18034e-17
C4 (Y VSS) capacitor c=1.70774e-16
C5 (VDD VSS) capacitor c=1.51094e-16
C6 (12 VSS) capacitor c=1.69916e-18
C7 (13 VSS) capacitor c=1.73762e-18
C8 (14 VSS) capacitor c=1.71625e-18
C9 (net103 VSS) capacitor c=2.03895e-16
C10 (net104 VSS) capacitor c=2.79148e-16
C11 (\1\:C0 VSS) capacitor c=9.33139e-17
C12 (\1\:B1 VSS) capacitor c=9.26749e-17
C13 (\6\:B0 VSS) capacitor c=6.98541e-17
C14 (\6\:B1 VSS) capacitor c=6.182e-17
C15 (\5\:B1 VSS) capacitor c=5.77348e-17
C16 (\3\:B0 VSS) capacitor c=5.68858e-17
C17 (\6\:A0 VSS) capacitor c=5.73917e-17
C18 (\1\:A1 VSS) capacitor c=4.71776e-17
C19 (\6\:A1 VSS) capacitor c=5.16238e-17
C20 (\1\:A0 VSS) capacitor c=6.89553e-17
C21 (\3\:B1 VSS) capacitor c=5.22545e-17
C22 (\3\:A1 VSS) capacitor c=2.04499e-17
C23 (\2\:A0 VSS) capacitor c=3.12228e-16
C24 (\8\:Y VSS) capacitor c=1.55811e-16
C25 (\9\:net104 VSS) capacitor c=3.92808e-18
C26 (\5\:net103 VSS) capacitor c=1.79971e-16
C27 (\9\:VDD VSS) capacitor c=3.98897e-17
C28 (\1\:VDD VSS) capacitor c=9.97667e-17
C29 (\1\:Y VSS) capacitor c=5.84242e-17
C30 (\3\:Y VSS) capacitor c=7.16823e-17
C31 (\6\:Y VSS) capacitor c=5.51949e-17
C32 (\2\:A1 VSS) capacitor c=4.17249e-17
C33 (\4\:A1 VSS) capacitor c=9.3314e-17
C34 (\3\:C0 VSS) capacitor c=8.59612e-17
C35 (\7\:B1 VSS) capacitor c=1.4094e-16
C36 (\5\:Y VSS) capacitor c=7.65051e-17
C37 (\7\:C0 VSS) capacitor c=5.49211e-17
C38 (\4\:VDD VSS) capacitor c=1.0787e-16
Rk20 (C0 \7\:C0) resistor r=0.189 c=0
Rk3 (\2\:A0 A0) resistor r=0.002375 c=0
Rk1 (\8\:A1 A1) resistor r=0.002995 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.4227 c=0
Rk13 (\5\:Y Y) resistor r=0.2422 c=0
Rk11 (\4\:Y \5\:Y) resistor r=0.3149 c=0
Rk12 (\5\:Y \7\:Y) resistor r=0.3374 c=0
Rk14 (Y \9\:Y) resistor r=0.9701 c=0
Rk31 (\2\:VDD \3\:VDD) resistor r=0.6516 c=0
Rk35 (\4\:VDD VDD) resistor r=0.02712 c=0
Rk32 (\3\:VDD \4\:VDD) resistor r=0.1276 c=0
Rk37 (\4\:VDD \10\:VDD) resistor r=0.2206 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.09253 c=0
Rk23 (\3\:VSS \5\:VSS) resistor r=0.3231 c=0
Rk24 (\5\:VSS \6\:VSS) resistor r=0.1126 c=0
Rk26 (\7\:VSS VSS) resistor r=0.1274 c=0
Rk25 (\6\:VSS \7\:VSS) resistor r=0.3104 c=0
Rk29 (\6\:VSS \13\:VSS) resistor r=0.1885 c=0
Rk30 (\7\:VSS \15\:VSS) resistor r=0.213 c=0
Rk9 (B1 \7\:B1) resistor r=0.002695 c=0
Rk5 (net103 \5\:net103) resistor r=0.4835 c=0
Rk19 (net104 \10\:net104) resistor r=0.0153 c=0
Rl21 (\3\:C0 \1\:C0) resistor r=30.2393 c=0
Rl10 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=71.2234 c=0
Rl19 (B0 \6\:B0) resistor r=65.3618 c=0
Rl12 (B0 \3\:B0) resistor r=31.461 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=54.3046 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=73.5354 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.2612 c=0
Rl5 (\4\:A1 \3\:A1) resistor r=8.9152 c=0
Rl14 (\1\:B1 \3\:B1) resistor r=9.4152 c=0
Rl17 (\3\:B1 \6\:B1) resistor r=129.041 c=0
Rl16 (\3\:B1 \5\:B1) resistor r=107.643 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz6 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\15\:VSS \14\:VSS) resistor r=75 c=0
Ry5 (\9\:Y \8\:Y) resistor r=62 c=0
Ry13 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\10\:net104 \9\:net104) resistor r=62 c=0
Rx7 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
Rx6 (\7\:B1 \3\:B1) resistor r=45 c=0
mn0_1__rcx (11 \1\:A0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.895e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1_1__rcx (\6\:Y \6\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.79e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1 (\6\:Y \1\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.585e-06 sd=160n sca=9.69565 scb=0.00844644 \
        scc=0.000275168 m=(1)
mn0 (12 \6\:A0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.102e-13 ad=1.56e-14 ps=1.4e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.48e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn2_1__rcx (\12\:VSS \3\:B0 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=1.102e-13 ps=6.4e-07 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.025e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3_1__rcx (13 \5\:B1 \3\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=9.2e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3 (14 \6\:B1 \3\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.32e-06 sb=7.15e-07 sd=160n sca=9.69565 scb=0.00844644 \
        scc=0.000275168 m=(1)
mn2 (\3\:VSS \6\:B0 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.08e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=6.1e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn4_1__rcx (\1\:Y \3\:C0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.86e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69e-06 sb=3.45e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
ends AOI221X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:45 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI221X4
// View name: extracted

simulator lang=spectre

subckt AOI221X4 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (net107 A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=22.272 \
        scb=0.025008 scc=0.00116916 m=(4)
mp1_1__rcx (net107 A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=16.2105 \
        scb=0.0148596 scc=0.000661709 m=(4)
mp4_1__rcx (\15\:Y C0 net104 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=7.55e-07 sd=160n sca=13.8524 \
        scb=0.01226 scc=0.000647526 m=(4)
mp2_1__rcx (net104 \1\:B0 \9\:net107 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp3_1__rcx (net104 B1 \9\:net107 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
C1 (C0 VSS) capacitor c=3.52023e-16
C2 (A0 VSS) capacitor c=6.20055e-16
C3 (B0 VSS) capacitor c=3.6344e-17
C4 (A1 VSS) capacitor c=3.89484e-16
C5 (Y VSS) capacitor c=1.2169e-17
C6 (VDD VSS) capacitor c=2.4899e-16
C7 (B1 VSS) capacitor c=4.37493e-16
C8 (12 VSS) capacitor c=1.7621e-18
C9 (13 VSS) capacitor c=1.7621e-18
C10 (14 VSS) capacitor c=1.7621e-18
C11 (15 VSS) capacitor c=4.45741e-18
C12 (16 VSS) capacitor c=5.16334e-18
C13 (17 VSS) capacitor c=3.10511e-18
C14 (18 VSS) capacitor c=2.07007e-18
C15 (net107 VSS) capacitor c=3.83599e-16
C16 (net104 VSS) capacitor c=5.0711e-16
C17 (\1\:B0 VSS) capacitor c=6.27719e-16
C18 (\12\:B0 VSS) capacitor c=5.64927e-17
C19 (\13\:B1 VSS) capacitor c=5.93777e-17
C20 (\12\:B1 VSS) capacitor c=4.11068e-17
C21 (\9\:B0 VSS) capacitor c=4.62908e-17
C22 (\8\:B0 VSS) capacitor c=2.63704e-17
C23 (\7\:B1 VSS) capacitor c=2.43835e-17
C24 (\5\:B1 VSS) capacitor c=3.78421e-17
C25 (\3\:B0 VSS) capacitor c=3.02809e-17
C26 (\12\:A0 VSS) capacitor c=5.18572e-17
C27 (\8\:A1 VSS) capacitor c=6.31997e-17
C28 (\11\:A1 VSS) capacitor c=5.57545e-17
C29 (\4\:A0 VSS) capacitor c=6.69895e-17
C30 (\6\:A0 VSS) capacitor c=4.79609e-17
C31 (\1\:A1 VSS) capacitor c=6.58025e-17
C32 (\4\:A1 VSS) capacitor c=4.62066e-17
C33 (\1\:A0 VSS) capacitor c=7.73589e-17
C34 (\15\:Y VSS) capacitor c=3.13177e-16
C35 (\9\:net107 VSS) capacitor c=3.99378e-16
C36 (\1\:VDD VSS) capacitor c=1.80239e-16
C37 (\1\:Y VSS) capacitor c=1.35437e-16
C38 (\3\:Y VSS) capacitor c=1.06678e-16
C39 (\5\:Y VSS) capacitor c=9.72968e-17
C40 (\8\:Y VSS) capacitor c=9.84804e-17
C41 (\10\:Y VSS) capacitor c=6.93512e-17
C42 (\2\:A1 VSS) capacitor c=3.18665e-17
C43 (\9\:A1 VSS) capacitor c=3.39458e-17
C44 (\4\:B1 VSS) capacitor c=1.91516e-17
C45 (\7\:Y VSS) capacitor c=5.67653e-17
C46 (\14\:Y VSS) capacitor c=2.13076e-16
C47 (\3\:VDD VSS) capacitor c=2.94022e-16
Rk15 (B0 \1\:B0) resistor r=0.1258 c=0
Rk20 (\1\:Y \4\:Y) resistor r=0.3923 c=0
Rk21 (\4\:Y \6\:Y) resistor r=0.5694 c=0
Rk22 (\6\:Y \7\:Y) resistor r=0.3618 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.3734 c=0
Rk24 (\9\:Y \11\:Y) resistor r=0.4686 c=0
Rk27 (\14\:Y Y) resistor r=0.003075 c=0
Rk28 (\14\:Y \15\:Y) resistor r=1.7225 c=0
Rk26 (\7\:Y \14\:Y) resistor r=0.1119 c=0
Rk61 (\3\:VDD VDD) resistor r=0.02964 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.8674 c=0
Rk44 (\1\:VSS \8\:VSS) resistor r=0.3463 c=0
Rk45 (\8\:VSS \9\:VSS) resistor r=0.5462 c=0
Rk46 (\9\:VSS \10\:VSS) resistor r=0.2606 c=0
Rk47 (\10\:VSS \11\:VSS) resistor r=0.04995 c=0
Rk49 (\12\:VSS VSS) resistor r=0.2052 c=0
Rk48 (\11\:VSS \12\:VSS) resistor r=0.2955 c=0
Rk51 (\8\:VSS \16\:VSS) resistor r=0.1993 c=0
Rk52 (\9\:VSS \18\:VSS) resistor r=0.1993 c=0
Rk53 (\11\:VSS \20\:VSS) resistor r=0.1993 c=0
Rk54 (\12\:VSS \22\:VSS) resistor r=0.2039 c=0
Rk11 (net107 \9\:net107) resistor r=0.4915 c=0
Rl20 (A0 \12\:A0) resistor r=41.4835 c=0
Rl9 (A0 \4\:A0) resistor r=85.3597 c=0
Rl10 (A0 \6\:A0) resistor r=39.5284 c=0
Rl1 (A0 \1\:A0) resistor r=140.362 c=0
Rl40 (\1\:B0 \12\:B0) resistor r=50.8402 c=0
Rl33 (\1\:B0 \9\:B0) resistor r=90.1033 c=0
Rl32 (\1\:B0 \8\:B0) resistor r=44.5244 c=0
Rl22 (\1\:B0 \3\:B0) resistor r=44.9225 c=0
Rl4 (\2\:A1 A1) resistor r=29.4415 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl15 (\9\:A1 A1) resistor r=6.3032 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=137.946 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=88.5249 c=0
Rl38 (B1 \13\:B1) resistor r=151.642 c=0
Rl37 (B1 \12\:B1) resistor r=106.063 c=0
Rl25 (\4\:B1 B1) resistor r=67.233 c=0
Rl28 (\4\:B1 \7\:B1) resistor r=35.772 c=0
Rl26 (\4\:B1 \5\:B1) resistor r=100.426 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\6\:Y \5\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\11\:Y \10\:Y) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz10 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz13 (\22\:VSS \21\:VSS) resistor r=75 c=0
Ry18 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry19 (\10\:VSS \4\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (11 \1\:A0 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\10\:Y \4\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\10\:Y \1\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (12 \6\:A0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (13 \4\:A0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_3__rcx (\8\:Y \11\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\8\:Y \8\:A1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.07e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \12\:A0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=1.56e-14 ps=1.38e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (15 \3\:B0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=4.16e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\5\:Y \5\:B1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\5\:Y \7\:B1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.885e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (16 \8\:B0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (17 \9\:B0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.73e-14 ps=8.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.475e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (\3\:Y \12\:B1 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=4.16e-14 ps=7.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.325e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\3\:Y \13\:B1 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.12e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (18 \12\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=1.82e-14 ps=8.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\1\:Y C0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.517e-14 ad=4.16e-14 ps=8.675e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
ends AOI221X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:46 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI221XL
// View name: extracted

simulator lang=spectre

subckt AOI221XL A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\3\:net107 \3\:A0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=19.0229 scb=0.0208122 \
        scc=0.00061956 m=(1)
mp1 (\3\:net107 \1\:A1 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.04e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=14.333 scb=0.0127992 \
        scc=0.000339629 m=(1)
mp3 (\3\:net104 \1\:B1 net107 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=4.515e-14 ps=7.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=7.9e-07 sd=160n sca=12.2475 \
        scb=0.0108235 scc=0.000332112 m=(1)
mp2 (net104 \1\:B0 net107 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=7.31e-14 ps=7.7e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=5.75e-07 sd=160n sca=12.9588 \
        scb=0.011186 scc=0.000332355 m=(1)
mp4 (\5\:Y \1\:C0 net104 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=4.085e-14 ps=1.11e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.9e-07 sd=160n sca=18.8069 \
        scb=0.0204563 scc=0.000595877 m=(1)
C1 (C0 VSS) capacitor c=6.53922e-17
C2 (A1 VSS) capacitor c=5.15315e-17
C3 (VDD VSS) capacitor c=1.54886e-16
C4 (Y VSS) capacitor c=1.35613e-17
C5 (B1 VSS) capacitor c=6.9473e-17
C6 (net124 VSS) capacitor c=1.22498e-18
C7 (net107 VSS) capacitor c=1.22898e-16
C8 (net104 VSS) capacitor c=8.05548e-17
C9 (\1\:C0 VSS) capacitor c=2.51489e-17
C10 (\1\:B0 VSS) capacitor c=3.38978e-17
C11 (\1\:B1 VSS) capacitor c=3.81935e-17
C12 (\1\:A1 VSS) capacitor c=4.56957e-17
C13 (\3\:A0 VSS) capacitor c=3.21731e-17
C14 (\3\:C0 VSS) capacitor c=2.70191e-17
C15 (\3\:B0 VSS) capacitor c=4.38615e-17
C16 (\3\:B1 VSS) capacitor c=4.30997e-17
C17 (\3\:A1 VSS) capacitor c=3.76165e-17
C18 (\1\:A0 VSS) capacitor c=5.43831e-17
C19 (\2\:C0 VSS) capacitor c=3.1897e-17
C20 (\2\:B0 VSS) capacitor c=4.68352e-17
C21 (\2\:B1 VSS) capacitor c=4.17499e-17
C22 (\2\:A1 VSS) capacitor c=4.80866e-17
C23 (\2\:A0 VSS) capacitor c=4.93389e-17
C24 (\5\:Y VSS) capacitor c=2.40203e-17
C25 (\3\:net104 VSS) capacitor c=9.35809e-17
C26 (\5\:VDD VSS) capacitor c=2.48977e-17
C27 (\3\:net107 VSS) capacitor c=9.13681e-17
C28 (\7\:VDD VSS) capacitor c=3.19865e-18
C29 (\7\:Y VSS) capacitor c=1.08484e-17
C30 (\3\:Y VSS) capacitor c=7.75944e-17
C31 (\4\:A0 VSS) capacitor c=2.40155e-17
C32 (\6\:A0 VSS) capacitor c=3.09208e-17
C33 (\4\:A1 VSS) capacitor c=3.87268e-17
C34 (\4\:B1 VSS) capacitor c=4.00226e-17
C35 (\4\:B0 VSS) capacitor c=1.16137e-16
C36 (\4\:C0 VSS) capacitor c=4.71166e-17
C37 (\1\:Y VSS) capacitor c=4.04137e-17
C38 (\2\:Y VSS) capacitor c=7.84124e-17
C39 (\3\:VDD VSS) capacitor c=7.641e-17
C40 (\4\:VDD VSS) capacitor c=8.22682e-18
Rk9 (\4\:C0 C0) resistor r=0.2039 c=0
Rk4 (\4\:A1 A1) resistor r=0.2264 c=0
Rk8 (B0 \4\:B0) resistor r=0.004101 c=0
Rk1 (\4\:A0 \5\:A0) resistor r=0.004428 c=0
Rk2 (A0 \6\:A0) resistor r=0.004302 c=0
Rk3 (\4\:A0 \6\:A0) resistor r=0.0628 c=0
Rk16 (\3\:VSS VSS) resistor r=0.09707 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.3369 c=0
Rk17 (\3\:VSS \5\:VSS) resistor r=0.3523 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.4976 c=0
Rk21 (\4\:VDD VDD) resistor r=0.06706 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.1996 c=0
Rk22 (\3\:VDD \6\:VDD) resistor r=0.149 c=0
Rk23 (\4\:VDD \8\:VDD) resistor r=0.073 c=0
Rk10 (Y \1\:Y) resistor r=0.01014 c=0
Rk11 (\1\:Y \2\:Y) resistor r=0.2246 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.6366 c=0
Rk13 (\1\:Y \6\:Y) resistor r=0.2289 c=0
Rk14 (\2\:Y \8\:Y) resistor r=0.07365 c=0
Rk5 (\4\:B1 B1) resistor r=0.1112 c=0
Rk6 (\2\:net107 \4\:net107) resistor r=0.7271 c=0
Rk7 (\2\:net104 \4\:net104) resistor r=0.4817 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=76.9231 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=89.5604 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=135.307 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=71.1538 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=95.6044 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=72.3097 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=107.408 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=58.3841 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=106.461 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:Y \8\:Y) resistor r=75 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\5\:Y \6\:Y) resistor r=62 c=0
Ry1 (net107 \2\:net107) resistor r=62 c=0
Ry2 (\3\:net107 \4\:net107) resistor r=62 c=0
Ry3 (net104 \2\:net104) resistor r=62 c=0
Ry4 (\3\:net104 \4\:net104) resistor r=62 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (net124 \1\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn1 (\3\:Y \3\:A1 net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=7.975e-14 ps=4.1e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.28e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn3 (\3\:Y \3\:B1 net116 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.378e-14 ad=7.975e-14 ps=4.8e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=6.85e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn2 (net116 \3\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=1.378e-14 ps=1.01e-06 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=5.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn4 (\7\:Y \3\:C0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.03e-14 ps=1.01e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
ends AOI221XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:47 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI222X1
// View name: extracted

simulator lang=spectre

subckt AOI222X1 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (net122 \3\:A0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.9913 \
        scb=0.020688 scc=0.00060344 m=(1)
mp1 (net122 \1\:A1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.7713 \
        scb=0.0118072 scc=0.000241734 m=(1)
mp3 (\5\:net118 \1\:B1 \3\:net122 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=11.6444 \
        scb=0.00959467 scc=0.000231862 m=(1)
mp2 (\3\:net118 \1\:B0 \3\:net122 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=12.1511 \
        scb=0.00987528 scc=0.000232041 m=(1)
mp4 (\5\:Y \1\:C0 \3\:net118 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=13.6523 \
        scb=0.011626 scc=0.000240092 m=(1)
mp5 (\5\:Y \1\:C1 net118 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=18.5104 \
        scb=0.0199204 scc=0.000545053 m=(1)
C1 (Y VSS) capacitor c=8.22238e-17
C2 (A1 VSS) capacitor c=4.15491e-17
C3 (VDD VSS) capacitor c=1.22546e-16
C4 (B0 VSS) capacitor c=6.69818e-17
C5 (A0 VSS) capacitor c=3.78683e-17
C6 (net139 VSS) capacitor c=6.24372e-18
C7 (net147 VSS) capacitor c=1.55458e-18
C8 (net155 VSS) capacitor c=1.3325e-18
C9 (net122 VSS) capacitor c=8.08621e-17
C10 (net118 VSS) capacitor c=5.51375e-17
C11 (\1\:C1 VSS) capacitor c=5.1478e-17
C12 (\1\:C0 VSS) capacitor c=5.46398e-17
C13 (\1\:B0 VSS) capacitor c=5.21059e-17
C14 (\1\:B1 VSS) capacitor c=6.51785e-17
C15 (\1\:A1 VSS) capacitor c=6.83205e-17
C16 (\3\:A0 VSS) capacitor c=5.37946e-17
C17 (\3\:C1 VSS) capacitor c=5.96802e-17
C18 (\3\:C0 VSS) capacitor c=7.59479e-17
C19 (\3\:B0 VSS) capacitor c=7.25568e-17
C20 (\4\:B1 VSS) capacitor c=5.20046e-17
C21 (\3\:A1 VSS) capacitor c=4.96193e-17
C22 (\1\:A0 VSS) capacitor c=5.37514e-17
C23 (\2\:C1 VSS) capacitor c=5.49522e-17
C24 (\2\:C0 VSS) capacitor c=5.4583e-17
C25 (\2\:B0 VSS) capacitor c=6.87775e-17
C26 (\3\:B1 VSS) capacitor c=2.39133e-17
C27 (\2\:A1 VSS) capacitor c=5.33354e-17
C28 (\2\:A0 VSS) capacitor c=4.88469e-17
C29 (\5\:Y VSS) capacitor c=6.72231e-17
C30 (\3\:net118 VSS) capacitor c=7.67993e-17
C31 (\3\:net122 VSS) capacitor c=9.72062e-17
C32 (\5\:net118 VSS) capacitor c=6.28868e-17
C33 (\5\:VDD VSS) capacitor c=4.27686e-17
C34 (\7\:VDD VSS) capacitor c=3.47031e-17
C35 (\3\:Y VSS) capacitor c=9.98564e-17
C36 (\1\:Y VSS) capacitor c=7.42746e-17
C37 (\2\:B1 VSS) capacitor c=4.9891e-17
C38 (\4\:A0 VSS) capacitor c=3.76665e-17
C39 (\4\:A1 VSS) capacitor c=6.7884e-17
C40 (\5\:B1 VSS) capacitor c=3.2092e-17
C41 (\7\:B1 VSS) capacitor c=7.56554e-17
C42 (\4\:B0 VSS) capacitor c=5.13188e-17
C43 (\4\:C0 VSS) capacitor c=1.23936e-16
C44 (\5\:C1 VSS) capacitor c=3.85663e-17
C45 (\6\:C1 VSS) capacitor c=8.56998e-17
C46 (\3\:VDD VSS) capacitor c=9.3184e-17
C47 (\4\:VDD VSS) capacitor c=1.07494e-17
Rk11 (\4\:C1 \5\:C1) resistor r=0.002024 c=0
Rk12 (\6\:C1 C1) resistor r=0.002091 c=0
Rk13 (\5\:C1 \6\:C1) resistor r=0.09482 c=0
Rk17 (\4\:Y Y) resistor r=0.4959 c=0
Rk16 (\2\:Y \4\:Y) resistor r=0.4841 c=0
Rk18 (Y \6\:Y) resistor r=0.32 c=0
Rk5 (\5\:B1 \6\:B1) resistor r=0.002024 c=0
Rk6 (B1 \7\:B1) resistor r=0.001956 c=0
Rk7 (\5\:B1 \7\:B1) resistor r=0.09482 c=0
Rk10 (\4\:C0 C0) resistor r=0.01234 c=0
Rk4 (A1 \4\:A1) resistor r=0.1891 c=0
Rk25 (\4\:VDD VDD) resistor r=0.03969 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.2053 c=0
Rk26 (\3\:VDD \6\:VDD) resistor r=0.1845 c=0
Rk27 (\4\:VDD \8\:VDD) resistor r=0.2793 c=0
Rk9 (\4\:B0 B0) resistor r=0.0767 c=0
Rk3 (\4\:A0 A0) resistor r=0.01803 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.288 c=0
Rk21 (\5\:VSS VSS) resistor r=0.08985 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.3108 c=0
Rk22 (\5\:VSS \7\:VSS) resistor r=0.1871 c=0
Rk8 (\2\:net122 \4\:net122) resistor r=0.5158 c=0
Rk14 (\2\:net118 \4\:net118) resistor r=0.295 c=0
Rk15 (\4\:net118 \6\:net118) resistor r=0.295 c=0
Rl12 (\1\:C1 \2\:C1) resistor r=143.464 c=0
Rl13 (\2\:C1 \3\:C1) resistor r=79.2614 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=152.726 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=64.2642 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=14.8815 c=0
Rl10 (\1\:C0 \2\:C0) resistor r=79.5379 c=0
Rl11 (\2\:C0 \3\:C0) resistor r=121.846 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=171.846 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=65.782 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=137.637 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=157.487 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry6 (\5\:Y \6\:Y) resistor r=62 c=0
Ry8 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry1 (net122 \2\:net122) resistor r=31 c=0
Ry2 (\3\:net122 \4\:net122) resistor r=62 c=0
Ry3 (net118 \2\:net118) resistor r=62 c=0
Ry4 (\3\:net118 \4\:net118) resistor r=62 c=0
Ry5 (\5\:net118 \6\:net118) resistor r=62 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net139 \1\:A0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (\1\:Y \3\:A1 net139 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=9.36e-14 ps=6.4e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.06e-06 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn3 (\1\:Y \4\:B1 net147 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=9.36e-14 ps=6.6e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=6.55e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (net147 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=1.82e-14 ps=1.02e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.4e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn4 (net155 \3\:C0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=2.45e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn5 (\3\:Y \3\:C1 net155 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
ends AOI222X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:48 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI222X2
// View name: extracted

simulator lang=spectre

subckt AOI222X2 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp2 (net134 B0 \5\:net126 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=5.85e-14 ps=1.11e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.585e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp5_1__rcx (\8\:Y \1\:C1 \8\:net134 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=5.5e-07 sd=160n sca=14.7281 \
        scb=0.0128603 scc=0.000648267 m=(2)
mp4 (\8\:Y \1\:C0 net134 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=7.55e-07 sd=160n sca=13.8663 \
        scb=0.0122652 scc=0.000647528 m=(2)
mp1_1__rcx (net126 \4\:A1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=15.1941 \
        scb=0.0133849 scc=0.00065002 m=(2)
mp3_1__rcx (\12\:net134 \1\:B1 \5\:net126 VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.55e-07 sb=1.37e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(2)
mp0_1__rcx (net126 \2\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=18.3639 \
        scb=0.0185931 scc=0.000748758 m=(2)
C1 (C0 VSS) capacitor c=2.82341e-17
C2 (B1 VSS) capacitor c=3.46974e-17
C3 (A0 VSS) capacitor c=2.46253e-17
C4 (C1 VSS) capacitor c=5.94513e-17
C5 (Y VSS) capacitor c=1.62918e-16
C6 (B0 VSS) capacitor c=3.73781e-16
C7 (A1 VSS) capacitor c=6.10716e-17
C8 (VDD VSS) capacitor c=1.67067e-16
C9 (13 VSS) capacitor c=1.68035e-18
C10 (14 VSS) capacitor c=3.13109e-18
C11 (15 VSS) capacitor c=2.99523e-18
C12 (16 VSS) capacitor c=2.87924e-18
C13 (net126 VSS) capacitor c=2.1306e-16
C14 (net134 VSS) capacitor c=3.21612e-16
C15 (\1\:C1 VSS) capacitor c=1.06178e-16
C16 (\1\:C0 VSS) capacitor c=3.13149e-16
C17 (\1\:B1 VSS) capacitor c=8.74262e-17
C18 (\6\:C0 VSS) capacitor c=5.62162e-17
C19 (\4\:C1 VSS) capacitor c=4.71963e-17
C20 (\6\:C1 VSS) capacitor c=4.68199e-17
C21 (\3\:C0 VSS) capacitor c=4.79172e-17
C22 (\6\:B0 VSS) capacitor c=4.78464e-17
C23 (\7\:B1 VSS) capacitor c=4.54012e-17
C24 (\5\:B1 VSS) capacitor c=3.08947e-17
C25 (\3\:B0 VSS) capacitor c=3.98643e-17
C26 (\6\:A0 VSS) capacitor c=5.56546e-17
C27 (\1\:A1 VSS) capacitor c=5.06685e-17
C28 (\6\:A1 VSS) capacitor c=4.79998e-17
C29 (\1\:A0 VSS) capacitor c=5.36335e-17
C30 (\3\:B1 VSS) capacitor c=1.81999e-17
C31 (\3\:A1 VSS) capacitor c=1.68451e-17
C32 (\2\:A0 VSS) capacitor c=3.22352e-16
C33 (\8\:net134 VSS) capacitor c=2.96264e-18
C34 (\8\:Y VSS) capacitor c=2.15215e-16
C35 (\12\:net134 VSS) capacitor c=4.09942e-18
C36 (\5\:net126 VSS) capacitor c=2.2626e-16
C37 (\9\:VDD VSS) capacitor c=4.27304e-17
C38 (\1\:VDD VSS) capacitor c=1.29749e-16
C39 (\1\:Y VSS) capacitor c=8.71951e-17
C40 (\3\:Y VSS) capacitor c=1.05461e-16
C41 (\6\:Y VSS) capacitor c=6.45148e-17
C42 (\2\:A1 VSS) capacitor c=4.05585e-17
C43 (\4\:A1 VSS) capacitor c=9.20292e-17
C44 (\4\:B1 VSS) capacitor c=3.37444e-17
C45 (\3\:C1 VSS) capacitor c=2.79323e-17
C46 (\9\:B1 VSS) capacitor c=1.08417e-16
C47 (\5\:Y VSS) capacitor c=7.31226e-17
C48 (\4\:VDD VSS) capacitor c=1.21989e-16
Rk20 (\1\:C0 C0) resistor r=0.02444 c=0
Rk11 (B1 \9\:B1) resistor r=0.01466 c=0
Rk3 (\2\:A0 A0) resistor r=0.1022 c=0
Rk12 (\7\:C1 C1) resistor r=0.005083 c=0
Rk17 (Y \8\:Y) resistor r=0.9775 c=0
Rk13 (\2\:Y \4\:Y) resistor r=0.6027 c=0
Rk16 (\5\:Y Y) resistor r=0.234 c=0
Rk14 (\4\:Y \5\:Y) resistor r=0.3576 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.4032 c=0
Rk1 (A1 \8\:A1) resistor r=0.004597 c=0
Rk28 (\2\:VSS \4\:VSS) resistor r=0.2926 c=0
Rk29 (\4\:VSS \5\:VSS) resistor r=0.3256 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.4759 c=0
Rk31 (\6\:VSS \7\:VSS) resistor r=0.06245 c=0
Rk33 (\8\:VSS VSS) resistor r=0.1775 c=0
Rk32 (\7\:VSS \8\:VSS) resistor r=0.3103 c=0
Rk34 (\5\:VSS \10\:VSS) resistor r=0.1882 c=0
Rk35 (\7\:VSS \12\:VSS) resistor r=0.1882 c=0
Rk36 (\8\:VSS \14\:VSS) resistor r=0.2293 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.8018 c=0
Rk41 (\4\:VDD VDD) resistor r=0.07723 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.07748 c=0
Rk43 (\4\:VDD \10\:VDD) resistor r=0.2216 c=0
Rk5 (net126 \5\:net126) resistor r=0.5745 c=0
Rk25 (net134 \9\:net134) resistor r=0.0153 c=0
Rk27 (net134 \13\:net134) resistor r=0.0153 c=0
Rl29 (\1\:C0 \6\:C0) resistor r=65.3618 c=0
Rl22 (\1\:C0 \3\:C0) resistor r=29.5379 c=0
Rl14 (\1\:B1 \3\:B1) resistor r=9.6652 c=0
Rl18 (\4\:B1 \7\:B1) resistor r=82.1768 c=0
Rl16 (\4\:B1 \5\:B1) resistor r=32.7557 c=0
Rl15 (\4\:B1 \3\:B1) resistor r=23.3085 c=0
Rl10 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=49.5597 c=0
Rl24 (\3\:C1 \1\:C1) resistor r=23.8563 c=0
Rl25 (\3\:C1 \4\:C1) resistor r=32.7557 c=0
Rl27 (\3\:C1 \6\:C1) resistor r=82.1768 c=0
Rl20 (B0 \6\:B0) resistor r=24.7951 c=0
Rl12 (B0 \3\:B0) resistor r=29.5379 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=64.2686 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=31.8259 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=19.3454 c=0
Rl5 (\4\:A1 \3\:A1) resistor r=5.8921 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry13 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry15 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\9\:net134 \8\:net134) resistor r=62 c=0
Ry11 (\13\:net134 \12\:net134) resistor r=62 c=0
Rx6 (\9\:B1 \3\:B1) resistor r=45 c=0
Rx7 (\7\:C1 \1\:C1) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
mn0_1__rcx (12 \1\:A0 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\6\:Y \6\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\6\:Y \1\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (13 \6\:A0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.418e-13 ad=1.56e-14 ps=1.67e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.99e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_1__rcx (14 \3\:B0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.418e-13 ad=2.99e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.425e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3_1__rcx (\3\:Y \5\:B1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28e-06 sb=1.265e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (\3\:Y \7\:B1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.6e-14 \
        ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.485e-06 sb=1.06e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (15 \6\:B0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.81e-14 ad=2.6e-14 ps=1.18e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=9.15e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4_1__rcx (16 \3\:C0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.81e-14 ad=2.6e-14 ps=1.18e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=5.95e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn5_1__rcx (\1\:Y \6\:C1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.6e-14 ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn5 (\1\:Y \4\:C1 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn4 (17 \6\:C0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends AOI222X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:49 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI222X4
// View name: extracted

simulator lang=spectre

subckt AOI222X4 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp2_1__rcx (net122 \1\:B0 net130 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp3_1__rcx (net122 B1 net130 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp4_1__rcx (\15\:Y C0 net122 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp5_1__rcx (\15\:Y C1 net122 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.37e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp0_1__rcx (\9\:net130 A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=21.9778 \
        scb=0.0245713 scc=0.00112692 m=(4)
mp1_1__rcx (\9\:net130 \3\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n \
        sca=16.1431 scb=0.0147518 scc=0.000660481 m=(4)
C1 (C0 VSS) capacitor c=6.53123e-16
C2 (B1 VSS) capacitor c=4.29417e-16
C3 (A0 VSS) capacitor c=6.45907e-16
C4 (C1 VSS) capacitor c=4.35886e-16
C5 (Y VSS) capacitor c=1.08197e-17
C6 (B0 VSS) capacitor c=3.8249e-17
C7 (A1 VSS) capacitor c=2.1242e-17
C8 (VDD VSS) capacitor c=2.94936e-16
C9 (13 VSS) capacitor c=1.75543e-18
C10 (14 VSS) capacitor c=1.75543e-18
C11 (15 VSS) capacitor c=1.75543e-18
C12 (16 VSS) capacitor c=3.05999e-18
C13 (17 VSS) capacitor c=1.75543e-18
C14 (18 VSS) capacitor c=9.92029e-18
C15 (19 VSS) capacitor c=4.50319e-18
C16 (20 VSS) capacitor c=3.05317e-18
C17 (21 VSS) capacitor c=1.75543e-18
C18 (22 VSS) capacitor c=2.07885e-18
C19 (net130 VSS) capacitor c=4.00474e-16
C20 (net122 VSS) capacitor c=6.1325e-16
C21 (\1\:B0 VSS) capacitor c=6.62173e-16
C22 (\12\:C0 VSS) capacitor c=7.08418e-17
C23 (\13\:C1 VSS) capacitor c=4.71552e-17
C24 (\11\:C1 VSS) capacitor c=6.61577e-17
C25 (\8\:C0 VSS) capacitor c=4.85519e-17
C26 (\9\:C0 VSS) capacitor c=6.53982e-17
C27 (\4\:C1 VSS) capacitor c=5.37114e-17
C28 (\6\:C1 VSS) capacitor c=4.67028e-17
C29 (\3\:C0 VSS) capacitor c=4.56304e-17
C30 (\12\:B0 VSS) capacitor c=3.92575e-17
C31 (\13\:B1 VSS) capacitor c=3.80217e-17
C32 (\12\:B1 VSS) capacitor c=1.8349e-17
C33 (\8\:B0 VSS) capacitor c=2.10939e-17
C34 (\9\:B0 VSS) capacitor c=6.64266e-17
C35 (\6\:B1 VSS) capacitor c=4.59948e-17
C36 (\4\:B1 VSS) capacitor c=4.92754e-17
C37 (\3\:B0 VSS) capacitor c=3.45806e-17
C38 (\12\:A0 VSS) capacitor c=5.00574e-17
C39 (\8\:A1 VSS) capacitor c=6.09819e-17
C40 (\11\:A1 VSS) capacitor c=5.38719e-17
C41 (\4\:A0 VSS) capacitor c=6.62894e-17
C42 (\8\:A0 VSS) capacitor c=4.68283e-17
C43 (\1\:A1 VSS) capacitor c=6.52722e-17
C44 (\4\:A1 VSS) capacitor c=4.69371e-17
C45 (\1\:A0 VSS) capacitor c=5.72869e-17
C46 (\3\:A1 VSS) capacitor c=3.77636e-16
C47 (\15\:Y VSS) capacitor c=4.34641e-16
C48 (\9\:net130 VSS) capacitor c=3.93281e-16
C49 (\1\:VDD VSS) capacitor c=2.3988e-16
C50 (\12\:Y VSS) capacitor c=6.83758e-17
C51 (\1\:Y VSS) capacitor c=1.3125e-16
C52 (\3\:Y VSS) capacitor c=1.4248e-16
C53 (\5\:Y VSS) capacitor c=1.27548e-16
C54 (\8\:Y VSS) capacitor c=1.07071e-16
C55 (\10\:Y VSS) capacitor c=7.54023e-17
C56 (\2\:A1 VSS) capacitor c=2.80048e-17
C57 (\9\:A1 VSS) capacitor c=3.24257e-17
C58 (\3\:B1 VSS) capacitor c=2.40494e-17
C59 (\11\:B1 VSS) capacitor c=1.46614e-17
C60 (\3\:C1 VSS) capacitor c=3.60096e-17
C61 (\10\:C1 VSS) capacitor c=2.77305e-17
C62 (\7\:Y VSS) capacitor c=6.30303e-17
C63 (\14\:Y VSS) capacitor c=2.45895e-16
C64 (\4\:VDD VSS) capacitor c=3.00594e-16
Rk21 (\2\:Y \4\:Y) resistor r=0.5586 c=0
Rk22 (\4\:Y \6\:Y) resistor r=0.641 c=0
Rk23 (\6\:Y \7\:Y) resistor r=0.3405 c=0
Rk24 (\7\:Y \9\:Y) resistor r=0.3668 c=0
Rk25 (\9\:Y \11\:Y) resistor r=0.4668 c=0
Rk26 (\2\:Y \13\:Y) resistor r=0.4605 c=0
Rk28 (\14\:Y Y) resistor r=0.00307 c=0
Rk29 (\14\:Y \15\:Y) resistor r=1.6097 c=0
Rk27 (\7\:Y \14\:Y) resistor r=0.2256 c=0
Rk18 (\1\:B0 B0) resistor r=0.1119 c=0
Rk2 (\3\:A1 A1) resistor r=0.02665 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.3254 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.3613 c=0
Rk54 (\3\:VSS \7\:VSS) resistor r=0.223 c=0
Rk55 (\4\:VSS \9\:VSS) resistor r=0.2184 c=0
Rk56 (\5\:VSS \10\:VSS) resistor r=0.4584 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.4833 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.2604 c=0
Rk59 (\12\:VSS \13\:VSS) resistor r=0.04993 c=0
Rk61 (\14\:VSS VSS) resistor r=0.2051 c=0
Rk60 (\13\:VSS \14\:VSS) resistor r=0.2953 c=0
Rk62 (\5\:VSS \16\:VSS) resistor r=0.2645 c=0
Rk63 (\10\:VSS \18\:VSS) resistor r=0.2184 c=0
