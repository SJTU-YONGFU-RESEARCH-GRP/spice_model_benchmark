Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\37\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \10\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\2\:SEb \8\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (Q qbint \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn12 (net490 \4\:SI \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.25e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn13 (\6\:dbp \4\:SE net490 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41635e-07 sb=5.2e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn11 (\8\:db \3\:SEb \6\:dbp VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.63e-14 ps=9.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.06635e-07 sb=2.55e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn1 (net498 \1\:D0 \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.985e-14 ad=6.11e-14 ps=9e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.56442e-07 sb=9.66058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.36442e-07 sb=6.86058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.41442e-07 sb=4.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (net510 \3\:D1 \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=1.56e-14 ps=1.28e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.46442e-07 sb=3.76058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn45_1__rcx (\26\:qbint n30 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.132e-14 ps=1.47e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn21 (\16\:CKbb \10\:CKb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn10 (\10\:SEb \5\:SE \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.985e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.11276e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn0 (\4\:S0b \5\:S0 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=2.465e-14 ps=1.28e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21931e-06 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn50 (net482 \24\:qbint \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=2.767e-14 ps=1.47e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.995e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn51 (\12\:n30 CKb net482 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=3.69e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1878e-07 sb=1.815e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn40 (\8\:mout CKbb \12\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=1.0455e-13 ps=7.7e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4378e-07 sb=1.59e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn30 (\8\:mout \3\:n20 \22\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.915e-14 ad=1.0455e-13 ps=1.18e-06 pd=1.43e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.39878e-06 sb=1.035e-06 sd=160n \
        sca=13.0797 scb=0.0132969 scc=0.000723565 m=(1)
mn35 (net474 \4\:mout \22\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.915e-14 ad=1.23e-14 ps=1.18e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71378e-06 sb=7.2e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn36 (\8\:n20 \5\:CKbb net474 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.227e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81878e-06 sb=6.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.227e-14 ad=6.457e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9561e-06 sb=3.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mp12 (net417 \1\:SI \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=4.57692e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp13 (dbp SEb net417 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.40064e-07 sb=3.52692e-07 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp11 (dbp \6\:SE \4\:db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45064e-07 sb=1.47692e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp1 (net425 \4\:D0 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.27372e-07 sb=9.48974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (\6\:db \2\:S0 net425 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.32372e-07 sb=8.43974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp4 (\6\:db S0b net429 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=7.02e-14 ps=1.24e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.57372e-07 sb=6.18974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (net429 \1\:D1 \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.438e-14 ad=8.97e-14 ps=1.43e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.32372e-07 sb=3.43974e-07 sd=160n sca=14.2873 \
        scb=0.012489 scc=0.000647666 m=(1)
mp45_1__rcx (\26\:qbint n30 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.98e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.745e-14 ad=3.01e-14 ps=1.46e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=33.2772 scb=0.0257934 \
        scc=0.00427133 m=(1)
mp21 (\14\:CKbb \5\:CKb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp10 (\5\:SEb \1\:SE \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.71e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26047e-07 sb=1.01884e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp0 (\6\:S0b \7\:S0 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.438e-14 ad=3.01e-14 ps=1.43e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11314e-06 sb=1.4e-07 sd=160n sca=21.7017 \
        scb=0.0235322 scc=0.00125657 m=(1)
mp50 (net409 \22\:qbint \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.745e-14 ad=3.565e-14 ps=1.46e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=1.91e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\14\:n30 \3\:CKbb net409 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.44e-14 ps=8.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92984e-07 sb=1.75e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\14\:n30 \3\:CKb \5\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2865e-13 ad=7.44e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.77984e-07 sb=1.465e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp30 (\5\:mout n20 \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.101e-13 ad=1.2865e-13 ps=1.6e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23798e-06 sb=1.005e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (net393 mout \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.101e-13 ad=5.115e-14 ps=1.6e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55298e-06 sb=6.9e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.115e-14 ad=6.2e-14 ps=9.5e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.76298e-06 sb=4.8e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:dbp VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=6.2e-14 ps=1.09e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9525e-06 sb=2.35e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
ends SMDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:30 2013 )
// Library name: gsclib045_hvt
// Cell name: HOLDX1
// View name: extracted

simulator lang=spectre

subckt HOLDX1 VDD VSS Y
mp0 (\13\:n0 \1\:Y \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.8109e-07 sd=160n sca=36.9908 \
        scb=0.0284138 scc=0.00351818 m=(1)
C1 (Y VSS) capacitor c=1.93182e-17
C2 (VDD VSS) capacitor c=5.03748e-17
C3 (n0 VSS) capacitor c=1.75557e-17
C4 (p2 VSS) capacitor c=1.96408e-18
C5 (p1 VSS) capacitor c=1.96408e-18
C6 (\7\:n0 VSS) capacitor c=8.79857e-18
C7 (\9\:n0 VSS) capacitor c=2.59812e-17
C8 (\1\:Y VSS) capacitor c=3.86134e-17
C9 (\5\:n0 VSS) capacitor c=1.29407e-17
C10 (\6\:n0 VSS) capacitor c=5.62188e-18
C11 (\8\:n0 VSS) capacitor c=1.96049e-17
C12 (\3\:Y VSS) capacitor c=3.64698e-17
C13 (\4\:n0 VSS) capacitor c=2.77436e-17
C14 (\2\:Y VSS) capacitor c=3.13957e-17
C15 (\6\:Y VSS) capacitor c=2.41824e-17
C16 (\1\:VDD VSS) capacitor c=2.07303e-17
C17 (\13\:n0 VSS) capacitor c=4.75593e-17
C18 (\4\:Y VSS) capacitor c=1.65152e-17
C19 (\11\:n0 VSS) capacitor c=3.43495e-17
C20 (\2\:n0 VSS) capacitor c=7.10338e-18
C21 (\3\:n0 VSS) capacitor c=2.69776e-18
C22 (\10\:n0 VSS) capacitor c=4.32279e-17
C23 (\8\:Y VSS) capacitor c=7.64111e-17
C24 (\4\:VDD VSS) capacitor c=1.80976e-17
Rk3 (\5\:Y Y) resistor r=0.1558 c=0
Rk4 (Y \7\:Y) resistor r=0.06457 c=0
Rk5 (\7\:Y \8\:Y) resistor r=0.4701 c=0
Rk7 (\4\:VDD VDD) resistor r=0.1979 c=0
Rk6 (\2\:VDD \4\:VDD) resistor r=0.2694 c=0
Rk9 (\4\:VSS VSS) resistor r=0.1979 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.1169 c=0
Rk1 (\10\:n0 \12\:n0) resistor r=0.3069 c=0
Rk2 (\12\:n0 \14\:n0) resistor r=0.352 c=0
Rl1 (\1\:Y \2\:Y) resistor r=24.2328 c=0
Rl2 (\2\:Y \3\:Y) resistor r=39.6174 c=0
Rl10 (\4\:n0 \9\:n0) resistor r=39.6174 c=0
Rl9 (\4\:n0 \8\:n0) resistor r=24.2328 c=0
Rl3 (n0 \2\:n0) resistor r=60.772 c=0
Rl6 (\2\:n0 \5\:n0) resistor r=28.0797 c=0
Rl8 (\3\:n0 \7\:n0) resistor r=59.2509 c=0
Rl7 (\3\:n0 \6\:n0) resistor r=26.5586 c=0
Rl5 (\3\:n0 \4\:n0) resistor r=34.9837 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=30.0863 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\11\:n0 \12\:n0) resistor r=75 c=0
Ry2 (\6\:Y \7\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\13\:n0 \14\:n0) resistor r=20.6667 c=0
Rx2 (\2\:Y \8\:Y) resistor r=45 c=0
Rx1 (\4\:n0 \10\:n0) resistor r=45 c=0
mn0 (\11\:n0 \3\:Y \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.64e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.81635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (n2 \8\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=8.7e-15 ps=1.72e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=3.5e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n1 \6\:n0 n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=5e-07 \
        sb=2.45e-07 sd=160n sca=23.279 scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\4\:Y \5\:n0 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.05e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp3 (p2 \9\:n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=3.5e-07 sd=160n sca=50.7542 \
        scb=0.0334718 scc=0.00592392 m=(1)
mp2 (p1 \7\:n0 p2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.2e-07 sb=2.45e-07 sd=160n sca=53.0765 scb=0.0380162 \
        scc=0.00612638 m=(1)
mp1 (\6\:Y n0 p1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.25e-07 sb=1.4e-07 sd=160n sca=59.8576 scb=0.0474724 \
        scc=0.00729056 m=(1)
ends HOLDX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:32 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX1
// View name: extracted

simulator lang=spectre

subckt INVX1 A VDD VSS Y
mp0 (\1\:Y \1\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.84e-14 ad=5.46e-14 ps=1.82e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=1.4e-07 sd=160n sca=58.4044 \
        scb=0.0588257 scc=0.00629162 m=(1)
C1 (Y VSS) capacitor c=3.28574e-17
C2 (A VSS) capacitor c=1.7651e-17
C3 (VDD VSS) capacitor c=2.99386e-17
C4 (\1\:A VSS) capacitor c=2.81441e-17
C5 (\4\:A VSS) capacitor c=2.218e-17
C6 (\3\:A VSS) capacitor c=1.22938e-17
C7 (\1\:Y VSS) capacitor c=1.46563e-17
C8 (\3\:VDD VSS) capacitor c=3.69633e-18
C9 (\3\:Y VSS) capacitor c=2.2502e-17
C10 (\2\:A VSS) capacitor c=1.03435e-17
C11 (\7\:A VSS) capacitor c=3.79958e-17
Rk4 (\2\:Y Y) resistor r=0.2245 c=0
Rk5 (Y \4\:Y) resistor r=0.1802 c=0
Rk1 (\5\:A A) resistor r=0.006551 c=0
Rk3 (\5\:A \7\:A) resistor r=0.01182 c=0
Rk2 (\6\:A \7\:A) resistor r=0.006551 c=0
Rk9 (VSS \4\:VSS) resistor r=0.07884 c=0
Rk7 (VDD \4\:VDD) resistor r=0.1117 c=0
Rl1 (\1\:A \2\:A) resistor r=61.2526 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=2.7666 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\3\:VDD \4\:VDD) resistor r=62 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
mn0 (\3\:Y \4\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=3.64e-14 ps=1.46e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=1.4e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
ends INVX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:33 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX12
// View name: extracted

simulator lang=spectre

subckt INVX12 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.52e-14 ps=1.252e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(10)
C1 (A VSS) capacitor c=2.14951e-17
C2 (VDD VSS) capacitor c=5.13192e-16
C3 (Y VSS) capacitor c=3.05473e-17
C4 (\1\:A VSS) capacitor c=8.53911e-16
C5 (\16\:A VSS) capacitor c=2.26462e-17
C6 (\1\:Y VSS) capacitor c=6.37448e-16
C7 (\40\:A VSS) capacitor c=4.39399e-17
C8 (\4\:Y VSS) capacitor c=1.18726e-17
C9 (\5\:Y VSS) capacitor c=5.02575e-16
Rk5 (\40\:A A) resistor r=0.01622 c=0
Rk4 (\1\:A \40\:A) resistor r=0.2896 c=0
Rk17 (\4\:Y Y) resistor r=0.112 c=0
Rk7 (\1\:Y \4\:Y) resistor r=0.1589 c=0
Rk8 (\4\:Y \5\:Y) resistor r=0.07485 c=0
Rl15 (\1\:A \16\:A) resistor r=3.1164 c=0
Rx5 (\40\:A \16\:A) resistor r=45 c=0
mn0 (\5\:Y \1\:A VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=4.96e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(10)
ends INVX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:34 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX16
// View name: extracted

simulator lang=spectre

subckt INVX16 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (A VSS) capacitor c=2.14865e-17
C2 (VDD VSS) capacitor c=6.91739e-16
C3 (Y VSS) capacitor c=3.03275e-17
C4 (\1\:A VSS) capacitor c=1.24326e-15
C5 (\22\:A VSS) capacitor c=2.29307e-17
C6 (\1\:Y VSS) capacitor c=9.08652e-16
C7 (\56\:A VSS) capacitor c=4.26718e-17
C8 (\4\:Y VSS) capacitor c=1.30412e-17
C9 (\5\:Y VSS) capacitor c=7.24622e-16
Rk7 (\56\:A A) resistor r=0.01623 c=0
Rk6 (\1\:A \56\:A) resistor r=0.29 c=0
Rk23 (\4\:Y Y) resistor r=0.1123 c=0
Rk9 (\1\:Y \4\:Y) resistor r=0.1594 c=0
Rk10 (\4\:Y \5\:Y) resistor r=0.07507 c=0
Rl21 (\1\:A \22\:A) resistor r=3.1164 c=0
Rx7 (\56\:A \22\:A) resistor r=45 c=0
mn0 (\5\:Y \1\:A VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
ends INVX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:35 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX2
// View name: extracted

simulator lang=spectre

subckt INVX2 A VDD VSS Y
mp0 (\4\:Y \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.848e-14 ad=6.24e-14 ps=1.435e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=3.45e-07 sd=160n sca=48.9834 \
        scb=0.0447567 scc=0.00505417 m=(2)
C1 (Y VSS) capacitor c=3.09291e-17
C2 (A VSS) capacitor c=1.57508e-17
C3 (VDD VSS) capacitor c=9.26155e-17
C4 (\1\:A VSS) capacitor c=1.01606e-16
C5 (\4\:A VSS) capacitor c=1.14819e-17
C6 (\4\:Y VSS) capacitor c=5.12821e-17
C7 (\2\:Y VSS) capacitor c=4.98307e-17
C8 (\10\:A VSS) capacitor c=4.05196e-17
C9 (\1\:Y VSS) capacitor c=2.92032e-17
Rk4 (Y \1\:Y) resistor r=0.09405 c=0
Rk5 (\1\:Y \3\:Y) resistor r=0.1734 c=0
Rk6 (\1\:Y \5\:Y) resistor r=0.2275 c=0
Rk1 (A \8\:A) resistor r=0.00395 c=0
Rk3 (\8\:A \10\:A) resistor r=0.0157 c=0
Rk2 (\9\:A \10\:A) resistor r=0.00395 c=0
Rl3 (\1\:A \4\:A) resistor r=4.3044 c=0
Rz1 (\3\:Y \2\:Y) resistor r=37.5 c=0
Ry1 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Rx1 (\9\:A \4\:A) resistor r=45 c=0
mn0 (\2\:Y \1\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=4.16e-14 ps=1.135e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
ends INVX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:36 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX20
// View name: extracted

simulator lang=spectre

subckt INVX20 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.306e-14 ad=7.306e-14 ps=1.23765e-06 pd=1.23765e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.0128 \
        scb=0.0371513 scc=0.00426262 m=(17)
C1 (A VSS) capacitor c=2.14865e-17
C2 (VDD VSS) capacitor c=8.13177e-16
C3 (Y VSS) capacitor c=1.30845e-17
C4 (\1\:A VSS) capacitor c=1.60524e-15
C5 (\27\:A VSS) capacitor c=2.29427e-17
C6 (\1\:Y VSS) capacitor c=1.14352e-15
C7 (\69\:A VSS) capacitor c=4.26853e-17
C8 (\4\:Y VSS) capacitor c=9.22617e-16
Rk9 (\69\:A A) resistor r=0.01623 c=0
Rk8 (\1\:A \69\:A) resistor r=0.29 c=0
Rk11 (\1\:Y Y) resistor r=0.1076 c=0
Rk12 (Y \4\:Y) resistor r=0.06532 c=0
Rl26 (\1\:A \27\:A) resistor r=3.1164 c=0
Rx9 (\69\:A \27\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1hvt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.844e-14 ps=9.2765e-07 pd=9.2765e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
ends INVX20
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:37 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX3
// View name: extracted

simulator lang=spectre

subckt INVX3 A VDD VSS Y
mp0 (Y \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.92e-14 \
        ad=5.98e-14 ps=1.34e-06 pd=1.08667e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.25e-07 sb=5.5e-07 sd=160n sca=47.2615 scb=0.0418019 \
        scc=0.00515049 m=(3)
C1 (Y VSS) capacitor c=2.39041e-16
C2 (VDD VSS) capacitor c=1.52509e-16
C3 (\1\:A VSS) capacitor c=1.55107e-16
C4 (\5\:A VSS) capacitor c=9.11424e-18
C5 (\11\:A VSS) capacitor c=1.83106e-17
C6 (\12\:A VSS) capacitor c=3.30933e-17
Rk1 (A \11\:A) resistor r=0.006611 c=0
Rk3 (\11\:A \12\:A) resistor r=0.00973 c=0
Rk2 (\12\:A \13\:A) resistor r=0.006611 c=0
Rl4 (\1\:A \5\:A) resistor r=4.0454 c=0
Rx1 (\13\:A \5\:A) resistor r=45 c=0
mn0 (Y \1\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.868e-14 \
        ad=3.987e-14 ps=1.06667e-06 pd=8.2667e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.25e-07 sb=5.5e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(3)
ends INVX3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:38 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX4
// View name: extracted

simulator lang=spectre

subckt INVX4 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.337e-14 ad=6.24e-14 ps=1.2475e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(4)
C1 (Y VSS) capacitor c=3.96579e-17
C2 (A VSS) capacitor c=1.98621e-17
C3 (VDD VSS) capacitor c=2.0947e-16
C4 (\1\:A VSS) capacitor c=1.93698e-16
C5 (\8\:A VSS) capacitor c=2.73049e-17
C6 (\1\:Y VSS) capacitor c=2.09269e-16
C7 (\16\:A VSS) capacitor c=6.14442e-17
C8 (\17\:A VSS) capacitor c=7.43301e-17
C9 (\18\:A VSS) capacitor c=2.72679e-17
C10 (\4\:Y VSS) capacitor c=1.69559e-16
Rk5 (\1\:Y Y) resistor r=0.232 c=0
Rk6 (Y \4\:Y) resistor r=0.1856 c=0
Rk1 (\16\:A \17\:A) resistor r=0.299 c=0
Rk3 (\18\:A A) resistor r=0.01632 c=0
Rk2 (\17\:A \18\:A) resistor r=0.287 c=0
Rl7 (\1\:A \8\:A) resistor r=3.1164 c=0
Rx1 (\16\:A \1\:A) resistor r=45 c=0
Rx2 (\17\:A \1\:A) resistor r=45 c=0
Rx3 (\18\:A \8\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.529e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
ends INVX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:39 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX6
// View name: extracted

simulator lang=spectre

subckt INVX6 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.332e-14 ps=1.252e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(5)
C1 (A VSS) capacitor c=1.70375e-17
C2 (Y VSS) capacitor c=1.17759e-17
C3 (VDD VSS) capacitor c=2.8255e-16
C4 (\1\:A VSS) capacitor c=2.52638e-16
C5 (\9\:A VSS) capacitor c=2.06753e-17
C6 (\1\:Y VSS) capacitor c=3.29362e-16
C7 (\19\:A VSS) capacitor c=8.16692e-17
C8 (\20\:A VSS) capacitor c=1.02402e-16
C9 (\21\:A VSS) capacitor c=4.01831e-17
C10 (\4\:Y VSS) capacitor c=2.56229e-16
Rk1 (\19\:A \20\:A) resistor r=0.417 c=0
Rk3 (\21\:A A) resistor r=0.0229 c=0
Rk2 (\20\:A \21\:A) resistor r=0.3307 c=0
Rk5 (\1\:Y Y) resistor r=0.09507 c=0
Rk6 (Y \4\:Y) resistor r=0.06503 c=0
Rl8 (\1\:A \9\:A) resistor r=3.4936 c=0
Rx1 (\19\:A \1\:A) resistor r=45 c=0
Rx2 (\20\:A \1\:A) resistor r=45 c=0
Rx3 (\21\:A \9\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=4.836e-14 ps=9.32e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
ends INVX6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:40 2013 )
// Library name: gsclib045_hvt
// Cell name: INVX8
// View name: extracted

simulator lang=spectre

subckt INVX8 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.993e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=41.6034 \
        scb=0.0375368 scc=0.00435732 m=(7)
C1 (A VSS) capacitor c=1.70241e-17
C2 (VDD VSS) capacitor c=3.57377e-16
C3 (Y VSS) capacitor c=1.10796e-17
C4 (\1\:A VSS) capacitor c=6.26165e-16
C5 (\23\:A VSS) capacitor c=2.06565e-17
C6 (\1\:Y VSS) capacitor c=4.45708e-16
C7 (\28\:A VSS) capacitor c=5.32629e-17
C8 (\4\:Y VSS) capacitor c=3.73396e-16
Rk4 (\28\:A A) resistor r=0.02293 c=0
Rk3 (\1\:A \28\:A) resistor r=0.4537 c=0
Rk6 (\1\:Y Y) resistor r=0.09525 c=0
Rk7 (Y \4\:Y) resistor r=0.06282 c=0
Rl22 (\1\:A \23\:A) resistor r=3.4936 c=0
Rx4 (\28\:A \23\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.636e-14 ps=9.0429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
ends INVX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:41 2013 )
// Library name: gsclib045_hvt
// Cell name: INVXL
// View name: extracted

simulator lang=spectre

subckt INVXL A VDD VSS Y
mp0 (\3\:Y \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.962e-14 ad=2.87e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.33488e-07 sd=160n sca=40.8937 \
        scb=0.0499242 scc=0.00347111 m=(1)
C1 (VDD VSS) capacitor c=4.64864e-17
C2 (A VSS) capacitor c=1.56261e-17
C3 (Y VSS) capacitor c=4.25547e-17
C4 (\1\:A VSS) capacitor c=3.25884e-17
C5 (\3\:A VSS) capacitor c=2.17731e-17
C6 (\2\:A VSS) capacitor c=3.41794e-17
C7 (\3\:Y VSS) capacitor c=1.83815e-17
C8 (\1\:VDD VSS) capacitor c=6.8192e-18
C9 (\1\:Y VSS) capacitor c=2.3558e-17
C10 (\4\:A VSS) capacitor c=3.66346e-17
Rk4 (\2\:VDD VDD) resistor r=0.07089 c=0
Rk1 (A \4\:A) resistor r=0.01335 c=0
Rk7 (VSS \4\:VSS) resistor r=0.08469 c=0
Rk2 (Y \2\:Y) resistor r=0.1764 c=0
Rk3 (Y \4\:Y) resistor r=0.2302 c=0
Rl1 (\1\:A \2\:A) resistor r=117.519 c=0
Rl2 (\2\:A \3\:A) resistor r=67.5189 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \3\:A \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.86e-14 ad=2.32e-14 ps=1.23e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.6e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
ends INVXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:42 2013 )
// Library name: gsclib045_hvt
// Cell name: BMXIX2
// View name: extracted

simulator lang=spectre

subckt BMXIX2 A M0 M1 PPN S VDD VSS X2
mp0 (\11\:M0b \1\:M0 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7886e-06 sd=160n sca=16.5061 \
        scb=0.0165824 scc=0.000331714 m=(1)
mp3 (n4 \1\:S \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.935e-14 ps=7.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.61372e-06 sd=160n sca=12.9155 \
        scb=0.0105511 scc=0.000191587 m=(1)
mp4 (\9\:n0 \6\:M0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=6.128e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.47872e-06 sd=160n sca=11.9971 \
        scb=0.00955136 scc=0.000188264 m=(1)
mp6 (\9\:n0 \3\:M0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.14872e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp5 (n6 \5\:A \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=1.29e-14 ps=1.45e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.04372e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp9 (n10 \1\:A \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.78721e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp10 (\4\:n1 M1b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.56e-14 ps=7.8e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.58721e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp8 (\4\:n1 \1\:M1 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.56e-14 ps=7.2e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=4.68837e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp7 (n8 \4\:S \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.32e-14 ad=3.117e-14 ps=1.81e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2.78837e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp1 (\5\:M1b \4\:M1 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.32e-14 ad=5.697e-14 ps=1.81e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.72791e-07 sb=2.65e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp11 (\11\:net293 X2b n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.547e-14 ps=9.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=3.5e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp12 (n1 \6\:X2 \11\:net293 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp2 (\5\:X2b \1\:X2 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.942e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=18.9525 \
        scb=0.0183104 scc=0.0014243 m=(1)
C1 (M0 VSS) capacitor c=6.48898e-17
C2 (M1 VSS) capacitor c=3.32044e-17
C3 (S VSS) capacitor c=1.65719e-16
C4 (VDD VSS) capacitor c=3.36717e-16
C5 (PPN VSS) capacitor c=2.36872e-17
C6 (X2 VSS) capacitor c=5.33086e-17
C7 (A VSS) capacitor c=5.15966e-17
C8 (M0b VSS) capacitor c=6.19923e-17
C9 (n3 VSS) capacitor c=7.26019e-19
C10 (n0 VSS) capacitor c=2.5896e-17
C11 (n5 VSS) capacitor c=3.40937e-18
C12 (n1 VSS) capacitor c=1.06569e-16
C13 (M1b VSS) capacitor c=5.64069e-17
C14 (net293 VSS) capacitor c=1.25912e-16
C15 (X2b VSS) capacitor c=4.89867e-17
C16 (n4 VSS) capacitor c=3.60548e-18
C17 (n10 VSS) capacitor c=4.35927e-19
C18 (n8 VSS) capacitor c=4.21134e-18
C19 (\1\:X2 VSS) capacitor c=3.38947e-17
C20 (\6\:X2 VSS) capacitor c=3.15874e-17
C21 (\4\:M1 VSS) capacitor c=4.13005e-17
C22 (\4\:S VSS) capacitor c=6.07146e-17
C23 (\1\:M1 VSS) capacitor c=6.74269e-17
C24 (\1\:A VSS) capacitor c=3.37974e-17
C25 (\5\:A VSS) capacitor c=5.47219e-17
C26 (\3\:M0b VSS) capacitor c=6.39208e-17
C27 (\6\:M0 VSS) capacitor c=4.82931e-17
C28 (\1\:S VSS) capacitor c=4.04462e-17
C29 (\1\:M0 VSS) capacitor c=3.88944e-17
C30 (\5\:X2 VSS) capacitor c=3.59065e-17
C31 (\3\:X2b VSS) capacitor c=5.24641e-17
C32 (\4\:X2 VSS) capacitor c=4.88138e-17
C33 (\6\:M1 VSS) capacitor c=3.85822e-17
C34 (\6\:S VSS) capacitor c=9.3944e-17
C35 (\3\:M1b VSS) capacitor c=6.51682e-17
C36 (\3\:M1 VSS) capacitor c=5.38677e-17
C37 (\6\:A VSS) capacitor c=1.64922e-17
C38 (\4\:A VSS) capacitor c=3.26334e-17
C39 (\4\:M0 VSS) capacitor c=4.79078e-17
C40 (\3\:S VSS) capacitor c=7.94875e-17
C41 (\3\:M0 VSS) capacitor c=3.7844e-17
C42 (\4\:net293 VSS) capacitor c=1.26553e-17
C43 (\2\:X2 VSS) capacitor c=5.22664e-17
C44 (\4\:X2b VSS) capacitor c=4.94202e-17
C45 (\2\:X2b VSS) capacitor c=2.48964e-17
C46 (\5\:M1 VSS) capacitor c=2.57765e-17
C47 (\5\:S VSS) capacitor c=2.73388e-17
C48 (\4\:M1b VSS) capacitor c=5.40581e-17
C49 (\2\:M1 VSS) capacitor c=7.42758e-17
C50 (\2\:M1b VSS) capacitor c=4.49346e-17
C51 (\2\:A VSS) capacitor c=5.37989e-17
C52 (\4\:M0b VSS) capacitor c=4.96157e-17
C53 (\5\:M0 VSS) capacitor c=5.03364e-17
C54 (\2\:M0b VSS) capacitor c=4.86142e-17
C55 (\2\:S VSS) capacitor c=6.61409e-17
C56 (\2\:M0 VSS) capacitor c=4.73302e-17
C57 (\1\:VDD VSS) capacitor c=1.2366e-16
C58 (\3\:PPN VSS) capacitor c=8.02206e-17
C59 (\5\:X2b VSS) capacitor c=2.99849e-17
C60 (\11\:net293 VSS) capacitor c=7.59475e-17
C61 (\5\:M1b VSS) capacitor c=5.07036e-17
C62 (\10\:VDD VSS) capacitor c=2.13e-17
C63 (\4\:n1 VSS) capacitor c=1.64172e-16
C64 (\12\:VDD VSS) capacitor c=2.36532e-17
C65 (\9\:n0 VSS) capacitor c=2.38479e-17
C66 (\15\:VDD VSS) capacitor c=5.15042e-17
C67 (\11\:M0b VSS) capacitor c=4.86554e-17
C68 (\4\:VDD VSS) capacitor c=1.04175e-16
C69 (\1\:PPN VSS) capacitor c=3.69103e-17
C70 (\10\:X2b VSS) capacitor c=4.12592e-17
C71 (\6\:n1 VSS) capacitor c=7.60569e-17
C72 (\9\:net293 VSS) capacitor c=1.58038e-16
C73 (\7\:n0 VSS) capacitor c=6.8781e-17
C74 (\10\:M1b VSS) capacitor c=4.77774e-17
C75 (\8\:n1 VSS) capacitor c=1.74803e-16
C76 (\5\:n0 VSS) capacitor c=9.71123e-17
C77 (\8\:M0b VSS) capacitor c=1.79253e-17
C78 (\3\:A VSS) capacitor c=1.52232e-17
C79 (\3\:X2 VSS) capacitor c=6.58407e-17
C80 (\7\:M0 VSS) capacitor c=7.3642e-17
C81 (\5\:M0b VSS) capacitor c=1.40415e-16
C82 (\6\:M0b VSS) capacitor c=1.30123e-16
C83 (\7\:M0b VSS) capacitor c=5.82999e-17
C84 (\10\:M0b VSS) capacitor c=2.34287e-17
C85 (\7\:A VSS) capacitor c=5.52908e-17
C86 (\7\:S VSS) capacitor c=1.52163e-16
C87 (\7\:M1 VSS) capacitor c=5.17071e-17
C88 (\8\:M1 VSS) capacitor c=2.78164e-17
C89 (\7\:M1b VSS) capacitor c=6.12837e-17
C90 (\8\:M1b VSS) capacitor c=9.39555e-17
C91 (\9\:M1b VSS) capacitor c=4.80871e-17
C92 (\3\:n0 VSS) capacitor c=2.32956e-16
C93 (\4\:n0 VSS) capacitor c=1.8902e-16
C94 (\3\:n1 VSS) capacitor c=3.47633e-16
C95 (\7\:X2b VSS) capacitor c=8.16821e-17
C96 (\8\:X2b VSS) capacitor c=5.74674e-17
C97 (\9\:X2b VSS) capacitor c=7.53527e-17
C98 (\7\:X2 VSS) capacitor c=4.43267e-17
C99 (\8\:net293 VSS) capacitor c=1.23064e-16
C100 (\6\:VDD VSS) capacitor c=5.21577e-17
C101 (\14\:VDD VSS) capacitor c=2.34979e-17
Rk1 (\7\:M0 M0) resistor r=0.2478 c=0
Rk11 (\7\:M1 M1) resistor r=0.1922 c=0
Rk12 (M1 \8\:M1) resistor r=0.0364 c=0
Rk46 (\1\:VSS \5\:VSS) resistor r=0.2272 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.6387 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.463 c=0
Rk50 (\6\:VSS \11\:VSS) resistor r=0.04334 c=0
Rk52 (\12\:VSS VSS) resistor r=0.1325 c=0
Rk51 (\7\:VSS \12\:VSS) resistor r=0.4192 c=0
Rk53 (\7\:VSS \14\:VSS) resistor r=0.3714 c=0
Rk54 (\12\:VSS \16\:VSS) resistor r=0.3281 c=0
Rk10 (\8\:S S) resistor r=0.00755 c=0
Rk9 (\7\:S \8\:S) resistor r=1.2624 c=0
Rk36 (\1\:VDD \5\:VDD) resistor r=0.2256 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.6387 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.4641 c=0
Rk40 (\6\:VDD \11\:VDD) resistor r=0.04334 c=0
Rk41 (\7\:VDD \13\:VDD) resistor r=0.07151 c=0
Rk44 (\14\:VDD VDD) resistor r=0.1702 c=0
Rk42 (\7\:VDD \14\:VDD) resistor r=0.3812 c=0
Rk43 (\14\:VDD \16\:VDD) resistor r=0.2808 c=0
Rk33 (PPN \2\:PPN) resistor r=0.1534 c=0
Rk34 (PPN \4\:PPN) resistor r=0.1444 c=0
Rk30 (X2 \7\:X2) resistor r=0.1414 c=0
Rk8 (A \7\:A) resistor r=0.02572 c=0
Rk3 (\5\:M0b \6\:M0b) resistor r=0.9383 c=0
Rk4 (\6\:M0b \7\:M0b) resistor r=0.2916 c=0
Rk5 (\7\:M0b \9\:M0b) resistor r=0.09782 c=0
Rk6 (\6\:M0b \10\:M0b) resistor r=0.072 c=0
Rk7 (\7\:M0b \12\:M0b) resistor r=0.4752 c=0
Rk17 (\2\:n0 \3\:n0) resistor r=0.02033 c=0
Rk18 (\3\:n0 \4\:n0) resistor r=1.4965 c=0
Rk19 (\4\:n0 \6\:n0) resistor r=0.5347 c=0
Rk20 (\3\:n0 \8\:n0) resistor r=0.4151 c=0
Rk21 (\4\:n0 \10\:n0) resistor r=0.06984 c=0
Rk22 (\2\:n1 \3\:n1) resistor r=0.4252 c=0
Rk23 (\3\:n1 \5\:n1) resistor r=1.0478 c=0
Rk24 (\2\:n1 \7\:n1) resistor r=0.4278 c=0
Rk25 (\3\:n1 \9\:n1) resistor r=1.5837 c=0
Rk13 (\6\:M1b \7\:M1b) resistor r=0.2551 c=0
Rk14 (\7\:M1b \8\:M1b) resistor r=0.4766 c=0
Rk15 (\8\:M1b \9\:M1b) resistor r=0.299 c=0
Rk16 (\7\:M1b \11\:M1b) resistor r=0.2465 c=0
Rk31 (\8\:net293 \10\:net293) resistor r=1.0046 c=0
Rk32 (\10\:net293 \12\:net293) resistor r=0.4278 c=0
Rk26 (\6\:X2b \7\:X2b) resistor r=0.1086 c=0
Rk27 (\7\:X2b \8\:X2b) resistor r=0.2904 c=0
Rk28 (\7\:X2b \9\:X2b) resistor r=0.5037 c=0
Rk29 (\8\:X2b \11\:X2b) resistor r=0.1523 c=0
Rl7 (\5\:M0 \6\:M0) resistor r=84.0659 c=0
Rl6 (\4\:M0 \5\:M0) resistor r=109.181 c=0
Rl1 (\1\:M0 \2\:M0) resistor r=84.6154 c=0
Rl2 (\2\:M0 \3\:M0) resistor r=101.374 c=0
Rl20 (\4\:M1 \5\:M1) resistor r=24.2328 c=0
Rl21 (\5\:M1 \6\:M1) resistor r=76.1559 c=0
Rl15 (\1\:M1 \2\:M1) resistor r=81.9251 c=0
Rl16 (\2\:M1 \3\:M1) resistor r=122.264 c=0
Rl19 (\4\:S \6\:S) resistor r=198.077 c=0
Rl18 (\4\:S \5\:S) resistor r=25.2509 c=0
Rl3 (\1\:S \2\:S) resistor r=26.9231 c=0
Rl4 (\2\:S \3\:S) resistor r=159.066 c=0
Rl24 (\1\:X2 \2\:X2) resistor r=24.848 c=0
Rl27 (\2\:X2 \5\:X2) resistor r=76.2482 c=0
Rl28 (\3\:X2 \6\:X2) resistor r=30.4507 c=0
Rl26 (\3\:X2 \4\:X2) resistor r=153.39 c=0
Rl25 (\2\:X2 \3\:X2) resistor r=179.178 c=0
Rl9 (\1\:A \2\:A) resistor r=96.131 c=0
Rl12 (\2\:A \5\:A) resistor r=80.7464 c=0
Rl13 (\3\:A \6\:A) resistor r=44.2087 c=0
Rl11 (\3\:A \4\:A) resistor r=88.4394 c=0
Rl10 (\2\:A \3\:A) resistor r=72.5535 c=0
Rl8 (\3\:M0b \4\:M0b) resistor r=102.615 c=0
Rl5 (M0b \2\:M0b) resistor r=26.1559 c=0
Rl17 (\3\:M1b \4\:M1b) resistor r=26.1559 c=0
Rl14 (M1b \2\:M1b) resistor r=102.615 c=0
Rl31 (net293 \4\:net293) resistor r=4.8851 c=0
Rl23 (\3\:X2b \4\:X2b) resistor r=120.667 c=0
Rl22 (X2b \2\:X2b) resistor r=76.7653 c=0
Rz14 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz10 (\5\:VDD \4\:VDD) resistor r=7.5 c=0
Rz11 (\7\:VDD \4\:VDD) resistor r=6.25 c=0
Rz9 (\2\:PPN \1\:PPN) resistor r=75 c=0
Rz1 (\8\:M0b \9\:M0b) resistor r=75 c=0
Rz3 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz4 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz2 (\10\:M1b \11\:M1b) resistor r=75 c=0
Rz8 (\10\:net293 \9\:net293) resistor r=75 c=0
Rz7 (\10\:X2b \11\:X2b) resistor r=75 c=0
Ry15 (\5\:VSS \4\:VSS) resistor r=6.2 c=0
Ry16 (\7\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry12 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry9 (\4\:PPN \3\:PPN) resistor r=20.6667 c=0
Ry1 (\11\:M0b \12\:M0b) resistor r=62 c=0
Ry3 (n0 \2\:n0) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry5 (n1 \2\:n1) resistor r=62 c=0
Ry6 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry2 (\5\:M1b \6\:M1b) resistor r=62 c=0
Ry8 (\12\:net293 \11\:net293) resistor r=62 c=0
Ry7 (\5\:X2b \6\:X2b) resistor r=62 c=0
Rx2 (\2\:M0 M0) resistor r=45 c=0
Rx1 (\5\:M0 \7\:M0) resistor r=45 c=0
Rx8 (\5\:M1 \7\:M1) resistor r=45 c=0
Rx9 (\2\:M1 \8\:M1) resistor r=45 c=0
Rx6 (\5\:S \7\:S) resistor r=45 c=0
Rx7 (\2\:S \8\:S) resistor r=45 c=0
Rx14 (\2\:X2 \7\:X2) resistor r=45 c=0
Rx5 (\2\:A \7\:A) resistor r=45 c=0
Rx3 (\4\:M0b \5\:M0b) resistor r=45 c=0
Rx4 (\2\:M0b \10\:M0b) resistor r=45 c=0
Rx10 (\4\:M1b \8\:M1b) resistor r=45 c=0
Rx11 (\2\:M1b \9\:M1b) resistor r=45 c=0
Rx15 (\8\:net293 \4\:net293) resistor r=45 c=0
Rx12 (\4\:X2b \8\:X2b) resistor r=45 c=0
Rx13 (\2\:X2b \9\:X2b) resistor r=45 c=0
mn0 (\8\:M0b \3\:M0 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.97931e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (n3 \3\:S \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.88138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (\5\:n0 M0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.77638e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn6 (\5\:n0 \4\:M0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.9e-14 ps=7.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.53138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (n5 \4\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.25638e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn9 (n9 \6\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.93e-14 ps=6.1e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.05138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\8\:n1 \3\:M1 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.32e-14 ps=9.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=6.66379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn8 (\8\:n1 \3\:M1b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=4.61379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn7 (n7 \6\:S \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=3.56379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn1 (\10\:M1b \6\:M1 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6069e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (\9\:net293 \4\:X2 \7\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.697e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (\6\:n1 \3\:X2b \9\:net293 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\10\:X2b \5\:X2 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.045e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=6.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn13_1__rcx (\1\:PPN net293 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=4.16e-14 ps=1.25e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67981e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp13 (\3\:PPN net293 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.701e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.54359e-07 sb=3.45e-07 sd=160n sca=34.0333 \
        scb=0.0243751 scc=0.00339915 m=(2)
ends BMXIX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:43 2013 )
// Library name: gsclib045_hvt
// Cell name: BMXIX4
// View name: extracted

simulator lang=spectre

subckt BMXIX4 A M0 M1 PPN S VDD VSS X2
mp0 (\11\:M0b \1\:M0 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.276e-13 ad=3.44e-14 ps=2.05e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=44.4931 scb=0.0420172 \
        scc=0.00520661 m=(1)
mp3 (n4 \1\:S \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.276e-13 ad=5.053e-14 ps=2.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=34.6718 scb=0.0267184 \
        scc=0.00427277 m=(1)
mp4 (\6\:n0 \4\:M0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.73e-06 sd=160n sca=33.4709 \
        scb=0.0258398 scc=0.00427134 m=(1)
mp6 (\6\:n0 \3\:M0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.525e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp5 (n6 \5\:A \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.42e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp9 (n10 \1\:A \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=5.483e-14 ps=1.85e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.225e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp10 (\3\:n1 \3\:M1b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61e-06 sb=9.25e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp8 (\3\:n1 \3\:M1 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=7.2e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp7 (n8 \5\:S \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3835e-13 ad=1.29e-14 ps=2.15e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=6.15e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp1 (\7\:M1b \7\:M1 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3835e-13 ad=4.3e-14 ps=2.15e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=33.2772 scb=0.0257934 \
        scc=0.00427133 m=(1)
mp2 (\5\:X2b \3\:X2 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.605e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
C1 (M0 VSS) capacitor c=8.21772e-17
C2 (M1 VSS) capacitor c=6.1837e-17
C3 (PPN VSS) capacitor c=2.5799e-16
C4 (S VSS) capacitor c=1.9167e-16
C5 (VDD VSS) capacitor c=2.98273e-16
C6 (X2 VSS) capacitor c=9.3282e-17
C7 (A VSS) capacitor c=3.09218e-17
C8 (M0b VSS) capacitor c=6.45388e-17
C9 (n0 VSS) capacitor c=7.04878e-17
C10 (n5 VSS) capacitor c=2.40959e-18
C11 (n1 VSS) capacitor c=9.76882e-17
C12 (M1b VSS) capacitor c=3.29135e-17
C13 (net293 VSS) capacitor c=2.18053e-16
C14 (X2b VSS) capacitor c=5.31012e-17
C15 (n4 VSS) capacitor c=2.52684e-18
C16 (n6 VSS) capacitor c=1.68863e-18
C17 (n10 VSS) capacitor c=4.47851e-18
C18 (n8 VSS) capacitor c=1.39476e-18
C19 (\3\:X2 VSS) capacitor c=3.22391e-17
C20 (\5\:X2 VSS) capacitor c=6.93209e-17
C21 (\4\:X2b VSS) capacitor c=5.1023e-17
C22 (\7\:M1 VSS) capacitor c=3.34264e-17
C23 (\5\:S VSS) capacitor c=1.20386e-16
C24 (\3\:M1 VSS) capacitor c=7.36917e-17
C25 (\3\:M1b VSS) capacitor c=8.07422e-17
C26 (\1\:A VSS) capacitor c=2.3944e-17
C27 (\5\:A VSS) capacitor c=5.46861e-17
C28 (\3\:M0b VSS) capacitor c=7.36352e-17
C29 (\4\:M0 VSS) capacitor c=5.79648e-17
C30 (\1\:S VSS) capacitor c=2.90609e-17
C31 (\1\:M0 VSS) capacitor c=2.46997e-17
C32 (\6\:X2 VSS) capacitor c=3.71014e-17
C33 (\3\:X2b VSS) capacitor c=3.3467e-17
C34 (\2\:X2 VSS) capacitor c=3.94626e-17
C35 (\5\:M1 VSS) capacitor c=3.34144e-17
C36 (\4\:S VSS) capacitor c=8.3457e-17
C37 (\1\:M1 VSS) capacitor c=4.76448e-17
C38 (\4\:A VSS) capacitor c=2.95317e-17
C39 (\6\:A VSS) capacitor c=2.93899e-17
C40 (\5\:M0 VSS) capacitor c=5.77878e-17
C41 (\3\:S VSS) capacitor c=7.63379e-17
C42 (\3\:M0 VSS) capacitor c=4.62464e-17
C43 (\6\:net293 VSS) capacitor c=2.22152e-17
C44 (\7\:X2 VSS) capacitor c=1.81558e-17
C45 (\1\:X2 VSS) capacitor c=3.1642e-17
C46 (\6\:M1 VSS) capacitor c=2.70097e-17
C47 (\2\:M1b VSS) capacitor c=8.63625e-17
C48 (\6\:S VSS) capacitor c=3.04223e-17
C49 (\4\:M1 VSS) capacitor c=4.99136e-17
C50 (\2\:M1 VSS) capacitor c=2.15507e-17
C51 (\2\:A VSS) capacitor c=2.7715e-17
C52 (\4\:M0b VSS) capacitor c=3.58138e-17
C53 (\6\:M0 VSS) capacitor c=3.16274e-17
C54 (\2\:M0b VSS) capacitor c=3.26941e-17
C55 (\2\:S VSS) capacitor c=5.48357e-17
C56 (\2\:M0 VSS) capacitor c=4.29784e-17
C57 (\1\:VDD VSS) capacitor c=1.87401e-16
C58 (\5\:X2b VSS) capacitor c=3.91558e-17
C59 (\7\:n1 VSS) capacitor c=9.05502e-17
C60 (\15\:net293 VSS) capacitor c=1.50963e-16
C61 (\3\:n0 VSS) capacitor c=2.95593e-16
C62 (\7\:M1b VSS) capacitor c=6.33166e-17
C63 (\16\:VDD VSS) capacitor c=2.40243e-17
C64 (\3\:n1 VSS) capacitor c=3.22252e-16
C65 (\18\:VDD VSS) capacitor c=1.72928e-17
C66 (\6\:n0 VSS) capacitor c=3.10742e-16
C67 (\20\:VDD VSS) capacitor c=1.36952e-17
C68 (\11\:M0b VSS) capacitor c=4.6435e-17
C69 (\3\:VDD VSS) capacitor c=9.05561e-17
C70 (\9\:X2b VSS) capacitor c=2.65736e-17
C71 (\5\:n1 VSS) capacitor c=2.5163e-16
C72 (\17\:net293 VSS) capacitor c=1.01854e-16
C73 (\4\:M1b VSS) capacitor c=5.89671e-17
C74 (\8\:n0 VSS) capacitor c=1.13976e-16
C75 (\8\:M0b VSS) capacitor c=2.0979e-17
C76 (\3\:A VSS) capacitor c=2.92124e-17
C77 (\2\:X2b VSS) capacitor c=3.35976e-17
C78 (\4\:X2 VSS) capacitor c=5.58272e-17
C79 (\7\:M0 VSS) capacitor c=7.30551e-17
C80 (\8\:M0 VSS) capacitor c=5.18334e-17
C81 (\5\:M0b VSS) capacitor c=1.52428e-16
C82 (\6\:M0b VSS) capacitor c=1.38602e-16
C83 (\7\:M0b VSS) capacitor c=4.11995e-17
C84 (\10\:M0b VSS) capacitor c=2.35668e-17
C85 (\7\:A VSS) capacitor c=5.35239e-17
C86 (\7\:S VSS) capacitor c=1.45992e-16
C87 (\8\:S VSS) capacitor c=5.77937e-17
C88 (\8\:M1 VSS) capacitor c=7.78361e-17
C89 (\9\:M1 VSS) capacitor c=8.03732e-17
C90 (\10\:M1 VSS) capacitor c=1.03755e-16
C91 (\6\:M1b VSS) capacitor c=5.06216e-17
C92 (\8\:X2 VSS) capacitor c=1.30922e-16
C93 (\7\:X2b VSS) capacitor c=2.26138e-17
C94 (\8\:X2b VSS) capacitor c=1.87493e-17
C95 (\14\:net293 VSS) capacitor c=1.19189e-16
C96 (\8\:VDD VSS) capacitor c=4.60389e-17
C97 (\9\:VDD VSS) capacitor c=1.592e-17
C98 (\11\:VDD VSS) capacitor c=2.47691e-17
Rk1 (\7\:M0 M0) resistor r=0.5202 c=0
Rk2 (M0 \8\:M0) resistor r=0.2854 c=0
Rk11 (\8\:M1 M1) resistor r=0.3572 c=0
Rk12 (M1 \9\:M1) resistor r=0.01532 c=0
Rk13 (\9\:M1 \10\:M1) resistor r=0.6634 c=0
Rk9 (\7\:S S) resistor r=1.1385 c=0
Rk10 (S \8\:S) resistor r=0.3351 c=0
Rk39 (\1\:VDD \7\:VDD) resistor r=0.2255 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.7037 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.4392 c=0
Rk42 (\9\:VDD \10\:VDD) resistor r=0.05654 c=0
Rk44 (\11\:VDD VDD) resistor r=0.129 c=0
Rk43 (\10\:VDD \11\:VDD) resistor r=0.4202 c=0
Rk47 (\8\:VDD \17\:VDD) resistor r=0.04332 c=0
Rk48 (\9\:VDD \19\:VDD) resistor r=0.04332 c=0
Rk49 (\11\:VDD \21\:VDD) resistor r=0.04332 c=0
Rk21 (\9\:X2 X2) resistor r=0.003305 c=0
Rk20 (\8\:X2 \9\:X2) resistor r=0.6718 c=0
Rk8 (A \7\:A) resistor r=0.03906 c=0
Rk53 (\1\:VSS \7\:VSS) resistor r=0.2406 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.6168 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.5881 c=0
Rk57 (\10\:VSS VSS) resistor r=0.1149 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.4365 c=0
Rk60 (\8\:VSS \16\:VSS) resistor r=0.07405 c=0
Rk61 (\9\:VSS \18\:VSS) resistor r=0.1618 c=0
Rk62 (\10\:VSS \20\:VSS) resistor r=0.1967 c=0
Rk3 (\5\:M0b \6\:M0b) resistor r=1.049 c=0
Rk4 (\6\:M0b \7\:M0b) resistor r=0.3176 c=0
Rk5 (\7\:M0b \9\:M0b) resistor r=0.1435 c=0
Rk6 (\6\:M0b \10\:M0b) resistor r=0.08444 c=0
Rk7 (\7\:M0b \12\:M0b) resistor r=0.325 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.3782 c=0
Rk17 (\4\:n0 \5\:n0) resistor r=0.1747 c=0
Rk18 (\5\:n0 \7\:n0) resistor r=1.6976 c=0
Rk19 (\7\:n0 \9\:n0) resistor r=0.6814 c=0
Rk22 (\2\:n1 \4\:n1) resistor r=0.5269 c=0
Rk23 (\4\:n1 \6\:n1) resistor r=1.8847 c=0
Rk24 (\6\:n1 \8\:n1) resistor r=0.511 c=0
Rk14 (\5\:M1b \6\:M1b) resistor r=0.3062 c=0
Rk15 (\5\:M1b \8\:M1b) resistor r=0.2797 c=0
Rk28 (\14\:net293 \16\:net293) resistor r=0.8735 c=0
Rk29 (\16\:net293 \18\:net293) resistor r=0.5134 c=0
Rk25 (\6\:X2b \7\:X2b) resistor r=0.1599 c=0
Rk26 (\7\:X2b \8\:X2b) resistor r=0.07445 c=0
Rk27 (\7\:X2b \10\:X2b) resistor r=0.0638 c=0
Rl6 (\4\:M0 \5\:M0) resistor r=200 c=0
Rl7 (\4\:M0 \6\:M0) resistor r=87.2302 c=0
Rl1 (\1\:M0 \2\:M0) resistor r=24.2328 c=0
Rl2 (\2\:M0 \3\:M0) resistor r=147.31 c=0
Rl21 (\6\:M1 \7\:M1) resistor r=32.4874 c=0
Rl20 (\5\:M1 \6\:M1) resistor r=44.4893 c=0
Rl15 (\3\:M1 \4\:M1) resistor r=35.7713 c=0
Rl14 (\1\:M1 \2\:M1) resistor r=24.2328 c=0
Rl18 (\4\:S \5\:S) resistor r=278.412 c=0
Rl19 (\5\:S \6\:S) resistor r=49.2328 c=0
Rl3 (\1\:S \2\:S) resistor r=65.3618 c=0
Rl4 (\2\:S \3\:S) resistor r=130.564 c=0
Rl29 (\5\:X2 \7\:X2) resistor r=26.1559 c=0
Rl22 (\1\:X2 \2\:X2) resistor r=49.2922 c=0
Rl26 (\3\:X2 \4\:X2) resistor r=28.0797 c=0
Rl27 (\4\:X2 \5\:X2) resistor r=221.58 c=0
Rl28 (\4\:X2 \6\:X2) resistor r=60.772 c=0
Rl9 (\1\:A \2\:A) resistor r=46.1884 c=0
Rl12 (\2\:A \5\:A) resistor r=63.6565 c=0
Rl11 (\3\:A \4\:A) resistor r=105.833 c=0
Rl13 (\3\:A \6\:A) resistor r=155.254 c=0
Rl10 (\2\:A \3\:A) resistor r=11.0904 c=0
Rl8 (\3\:M0b \4\:M0b) resistor r=24.2328 c=0
Rl5 (M0b \2\:M0b) resistor r=73.0541 c=0
Rl17 (\2\:M1b \3\:M1b) resistor r=236.093 c=0
Rl16 (M1b \2\:M1b) resistor r=74.2328 c=0
Rl34 (net293 \6\:net293) resistor r=4.6806 c=0
Rl25 (\2\:X2b \4\:X2b) resistor r=76.1566 c=0
Rl24 (\2\:X2b \3\:X2b) resistor r=28.0797 c=0
Rl23 (X2b \2\:X2b) resistor r=154.219 c=0
Rz11 (\1\:VDD \3\:VDD) resistor r=75 c=0
Rz12 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz13 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz19 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\8\:M0b \9\:M0b) resistor r=75 c=0
Rz3 (n0 \2\:n0) resistor r=75 c=0
Rz4 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz5 (n1 \2\:n1) resistor r=75 c=0
Rz6 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz2 (\4\:M1b \5\:M1b) resistor r=75 c=0
Rz8 (\18\:net293 \17\:net293) resistor r=75 c=0
Rz7 (\9\:X2b \10\:X2b) resistor r=75 c=0
Ry15 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry19 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\11\:M0b \12\:M0b) resistor r=62 c=0
Ry3 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry4 (\3\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\3\:n1 \4\:n1) resistor r=62 c=0
Ry7 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry2 (\7\:M1b \8\:M1b) resistor r=62 c=0
Ry9 (\16\:net293 \15\:net293) resistor r=31 c=0
Ry8 (\5\:X2b \6\:X2b) resistor r=62 c=0
Rx1 (\6\:M0 \7\:M0) resistor r=45 c=0
Rx2 (\2\:M0 \8\:M0) resistor r=45 c=0
Rx8 (\6\:M1 \8\:M1) resistor r=45 c=0
Rx9 (\4\:M1 \9\:M1) resistor r=45 c=0
Rx10 (\2\:M1 \10\:M1) resistor r=45 c=0
Rx6 (\6\:S \7\:S) resistor r=45 c=0
Rx7 (\2\:S \8\:S) resistor r=45 c=0
Rx12 (\1\:X2 \8\:X2) resistor r=45 c=0
Rx13 (\7\:X2 \9\:X2) resistor r=45 c=0
Rx5 (\2\:A \7\:A) resistor r=45 c=0
Rx3 (\4\:M0b \5\:M0b) resistor r=45 c=0
Rx4 (\2\:M0b \10\:M0b) resistor r=45 c=0
Rx11 (\2\:M1b \6\:M1b) resistor r=45 c=0
Rx15 (\14\:net293 \6\:net293) resistor r=45 c=0
Rx14 (X2b \8\:X2b) resistor r=45 c=0
mn0 (\8\:M0b \3\:M0 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn3 (n3 \3\:S \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.905e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\8\:n0 M0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=4.205e-14 ps=4.1e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.7e-07 sb=1.8e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn6 (\8\:n0 \5\:M0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=4.205e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.465e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn5 (n5 \6\:A \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.21e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn9 (n9 \4\:A \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.005e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn10 (n1 \1\:M1 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.537e-14 \
        ad=6.67e-14 ps=6.4e-07 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.485e-06 sb=7.85e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn8 (n1 M1b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=6.67e-14 ps=5.6e-07 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.99e-06 sb=2.8e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn7 (n7 \4\:S \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.957e-14 ps=1.6e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn1 (\4\:M1b \5\:M1 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\9\:X2b \6\:X2 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn11 (\17\:net293 \2\:X2 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.30385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn12 (\5\:n1 \3\:X2b \17\:net293 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.26e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.25385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn13_1__rcx (PPN net293 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.858e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp11 (\15\:net293 \4\:X2b \3\:n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.945e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp12 (\7\:n1 \5\:X2 \15\:net293 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp13_1__rcx (PPN net293 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.136e-14 ad=6.24e-14 ps=1.1825e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35962e-07 sb=7.55e-07 sd=160n sca=30.8435 \
        scb=0.0202998 scc=0.00336099 m=(4)
ends BMXIX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:45 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2X1
// View name: extracted

simulator lang=spectre

subckt MX2X1 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=23.8245 \
        scb=0.0263954 scc=0.00148173 m=(1)
mp1 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=13.7907 \
        scb=0.0117228 scc=0.000117112 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.85e-07 sd=160n sca=12.4179 \
        scb=0.00925643 scc=8.16416e-05 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=11.7188 \
        scb=0.00807876 scc=7.57808e-05 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=1.29e-14 ps=1.59e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=11.9962 \
        scb=0.00852763 scc=7.72908e-05 m=(1)
C1 (S0 VSS) capacitor c=5.02697e-17
C2 (A VSS) capacitor c=4.19641e-17
C3 (Y VSS) capacitor c=5.40293e-17
C4 (VDD VSS) capacitor c=1.29127e-16
C5 (B VSS) capacitor c=4.09465e-17
C6 (S0b VSS) capacitor c=6.0297e-17
C7 (n0 VSS) capacitor c=5.98209e-17
C8 (n5 VSS) capacitor c=1.32841e-18
C9 (n6 VSS) capacitor c=2.03262e-18
C10 (\4\:B VSS) capacitor c=8.27148e-17
C11 (\3\:S0b VSS) capacitor c=5.70056e-17
C12 (\6\:S0 VSS) capacitor c=7.3222e-17
C13 (\1\:A VSS) capacitor c=7.87573e-17
C14 (\1\:S0 VSS) capacitor c=3.36914e-17
C15 (\4\:n0 VSS) capacitor c=3.50731e-17
C16 (\3\:B VSS) capacitor c=7.57168e-17
C17 (\4\:S0 VSS) capacitor c=1.01326e-16
C18 (\3\:A VSS) capacitor c=8.18254e-17
C19 (\3\:S0 VSS) capacitor c=5.95297e-17
C20 (\3\:n0 VSS) capacitor c=2.70482e-17
C21 (\1\:B VSS) capacitor c=3.09821e-17
C22 (\4\:S0b VSS) capacitor c=5.45625e-17
C23 (\2\:S0b VSS) capacitor c=6.00215e-17
C24 (\5\:S0 VSS) capacitor c=1.16712e-16
C25 (\2\:A VSS) capacitor c=9.2426e-17
C26 (\2\:S0 VSS) capacitor c=5.56737e-17
C27 (\1\:Y VSS) capacitor c=7.81971e-17
C28 (\1\:VDD VSS) capacitor c=6.15178e-17
C29 (\9\:n0 VSS) capacitor c=9.67927e-17
C30 (\6\:VDD VSS) capacitor c=3.94208e-17
C31 (\10\:S0b VSS) capacitor c=7.72516e-17
C32 (\3\:Y VSS) capacitor c=3.72037e-17
C33 (\7\:n0 VSS) capacitor c=6.63793e-17
C34 (\8\:S0b VSS) capacitor c=2.03033e-17
C35 (\2\:B VSS) capacitor c=8.05009e-17
C36 (\2\:n0 VSS) capacitor c=2.93184e-17
C37 (\4\:A VSS) capacitor c=3.12079e-17
C38 (\7\:S0 VSS) capacitor c=5.18622e-17
C39 (\8\:S0 VSS) capacitor c=7.18788e-17
C40 (\5\:S0b VSS) capacitor c=8.37489e-17
C41 (\6\:S0b VSS) capacitor c=1.22859e-16
C42 (\7\:S0b VSS) capacitor c=7.82407e-17
C43 (\5\:n0 VSS) capacitor c=3.30244e-17
C44 (\6\:n0 VSS) capacitor c=1.32284e-16
C45 (\5\:B VSS) capacitor c=6.70242e-17
C46 (\4\:VDD VSS) capacitor c=3.89346e-17
C47 (\5\:VDD VSS) capacitor c=1.0542e-17
Rk2 (\7\:S0 S0) resistor r=0.1251 c=0
Rk3 (S0 \8\:S0) resistor r=0.3191 c=0
Rk1 (A \4\:A) resistor r=0.02702 c=0
Rk12 (\2\:Y Y) resistor r=0.6143 c=0
Rk13 (Y \4\:Y) resistor r=0.04477 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.3994 c=0
Rk16 (\5\:VDD VDD) resistor r=0.1029 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.199 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2261 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.294 c=0
Rk20 (\5\:VSS VSS) resistor r=0.1029 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.199 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.1819 c=0
Rk11 (B \5\:B) resistor r=0.07529 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4035 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.387 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.1398 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6367 c=0
Rk8 (\5\:n0 \6\:n0) resistor r=0.1099 c=0
Rk9 (\6\:n0 \8\:n0) resistor r=0.3304 c=0
Rk10 (\6\:n0 \10\:n0) resistor r=0.7659 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=103.079 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=248.616 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=243 c=0
Rl3 (\1\:A \2\:A) resistor r=121.846 c=0
Rl4 (\2\:A \3\:A) resistor r=169.923 c=0
Rl11 (\2\:B \4\:B) resistor r=157.406 c=0
Rl10 (\2\:B \3\:B) resistor r=151.637 c=0
Rl9 (\1\:B \2\:B) resistor r=6.7128 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=35.7134 c=0
Rl5 (S0b \2\:S0b) resistor r=89.5596 c=0
Rl12 (n0 \2\:n0) resistor r=163.176 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=34.3295 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=5.9102 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (n3 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.85e-07 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=8.7e-15 ps=1.2e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=3.64e-14 ps=1.2e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.99135e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp5 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=5.46e-14 ps=1.59e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.93397e-07 sb=1.4e-07 sd=160n sca=18.3406 \
        scb=0.0188689 scc=0.000687762 m=(1)
ends MX2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:46 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2X2
// View name: extracted

simulator lang=spectre

subckt MX2X2 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=15.5214 \
        scb=0.0147757 scc=0.000215748 m=(1)
mp1 (n4 \1\:A \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.977e-14 ps=7.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=11.7983 \
        scb=0.00857189 scc=7.47494e-05 m=(1)
mp2 (\12\:n0 \6\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=9.5e-07 sd=160n sca=10.5655 \
        scb=0.0074576 scc=7.20375e-05 m=(1)
mp4 (\12\:n0 \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.73e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.85e-07 sd=160n sca=10.707 \
        scb=0.00753257 scc=7.20801e-05 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.935e-14 ps=1.1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=11.3858 \
        scb=0.0080918 scc=7.29969e-05 m=(1)
C1 (S0 VSS) capacitor c=2.90938e-17
C2 (A VSS) capacitor c=5.58589e-17
C3 (Y VSS) capacitor c=2.80318e-17
C4 (VDD VSS) capacitor c=1.70637e-16
C5 (S0b VSS) capacitor c=6.79703e-17
C6 (n0 VSS) capacitor c=1.69293e-16
C7 (n5 VSS) capacitor c=5.94741e-18
C8 (n6 VSS) capacitor c=1.61012e-18
C9 (\4\:B VSS) capacitor c=6.951e-17
C10 (\3\:S0b VSS) capacitor c=4.76678e-17
C11 (\6\:S0 VSS) capacitor c=4.00511e-17
C12 (\1\:A VSS) capacitor c=4.19649e-17
C13 (\1\:S0 VSS) capacitor c=3.16105e-17
C14 (\3\:B VSS) capacitor c=5.60282e-17
C15 (\4\:S0 VSS) capacitor c=6.09393e-17
C16 (\3\:A VSS) capacitor c=9.14968e-17
C17 (\3\:S0 VSS) capacitor c=5.66864e-17
C18 (\4\:n0 VSS) capacitor c=4.35991e-17
C19 (\1\:B VSS) capacitor c=2.36277e-17
C20 (\4\:S0b VSS) capacitor c=4.56261e-17
C21 (\5\:S0 VSS) capacitor c=8.07146e-17
C22 (\2\:S0b VSS) capacitor c=5.59097e-17
C23 (\2\:A VSS) capacitor c=7.1716e-17
C24 (\2\:S0 VSS) capacitor c=5.50439e-17
C25 (\1\:VDD VSS) capacitor c=1.135e-16
C26 (\4\:Y VSS) capacitor c=1.01047e-16
C27 (\12\:n0 VSS) capacitor c=9.43155e-17
C28 (\9\:VDD VSS) capacitor c=3.71143e-17
C29 (\10\:S0b VSS) capacitor c=9.35684e-17
C30 (\2\:Y VSS) capacitor c=3.0196e-17
C31 (\10\:n0 VSS) capacitor c=5.572e-17
C32 (\8\:S0b VSS) capacitor c=2.07457e-17
C33 (\2\:B VSS) capacitor c=5.15356e-17
C34 (\4\:A VSS) capacitor c=6.08691e-17
C35 (\7\:S0 VSS) capacitor c=8.22889e-17
C36 (\8\:S0 VSS) capacitor c=7.28826e-17
C37 (\5\:S0b VSS) capacitor c=7.67003e-17
C38 (\6\:S0b VSS) capacitor c=1.21534e-16
C39 (\7\:S0b VSS) capacitor c=8.12973e-17
C40 (\5\:B VSS) capacitor c=1.23449e-16
C41 (\8\:n0 VSS) capacitor c=3.24213e-17
C42 (\9\:n0 VSS) capacitor c=1.11192e-16
C43 (\1\:Y VSS) capacitor c=4.75549e-17
C44 (\5\:VDD VSS) capacitor c=2.3638e-17
C45 (\6\:VDD VSS) capacitor c=1.60853e-17
Rk3 (\8\:S0 S0) resistor r=0.02104 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.417 c=0
Rk22 (\1\:VSS \5\:VSS) resistor r=0.1955 c=0
Rk24 (\6\:VSS VSS) resistor r=0.1701 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.2306 c=0
Rk26 (\6\:VSS \10\:VSS) resistor r=0.194 c=0
Rk1 (A \4\:A) resistor r=0.07467 c=0
Rk12 (Y \1\:Y) resistor r=0.111 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.1478 c=0
Rk14 (\1\:Y \5\:Y) resistor r=0.502 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.1955 c=0
Rk18 (\6\:VDD VDD) resistor r=0.1701 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.2306 c=0
Rk20 (\6\:VDD \10\:VDD) resistor r=0.2093 c=0
Rk8 (B \5\:B) resistor r=0.006762 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4511 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3941 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09765 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7268 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.1576 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.4052 c=0
Rk11 (\9\:n0 \13\:n0) resistor r=0.5968 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=236.093 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=41.0764 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=248.769 c=0
Rl3 (\1\:A \2\:A) resistor r=76.1559 c=0
Rl4 (\2\:A \3\:A) resistor r=210.771 c=0
Rl11 (\2\:B \4\:B) resistor r=128.56 c=0
Rl10 (\2\:B \3\:B) resistor r=178.56 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=62.9746 c=0
Rl5 (S0b \2\:S0b) resistor r=83.8482 c=0
Rl14 (n0 \4\:n0) resistor r=4.1351 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\3\:Y \2\:Y) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\8\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn1 (n3 \3\:A \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=1.075e-06 sd=160n sca=7.00131 scb=0.00386446 \
        scc=3.38236e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.7e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn5 (\2\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.10673e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp5 (\4\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.03654e-07 sb=3.45e-07 sd=160n sca=15.9948 \
        scb=0.0151656 scc=0.000454155 m=(2)
ends MX2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:47 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2X4
// View name: extracted

simulator lang=spectre

subckt MX2X4 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=3.01e-14 ps=9.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
C1 (S0 VSS) capacitor c=1.14626e-16
C2 (Y VSS) capacitor c=4.10688e-17
C3 (A VSS) capacitor c=3.56282e-17
C4 (VDD VSS) capacitor c=2.05199e-16
C5 (B VSS) capacitor c=6.49146e-17
C6 (S0b VSS) capacitor c=4.67312e-17
C7 (n0 VSS) capacitor c=3.24935e-16
C8 (n5 VSS) capacitor c=2.39347e-18
C9 (n4 VSS) capacitor c=3.94347e-18
C10 (n6 VSS) capacitor c=3.57588e-18
C11 (\3\:B VSS) capacitor c=5.27198e-17
C12 (\3\:S0b VSS) capacitor c=4.52502e-17
C13 (\6\:S0 VSS) capacitor c=5.23195e-17
C14 (\3\:A VSS) capacitor c=5.53014e-17
C15 (\1\:S0 VSS) capacitor c=4.28813e-17
C16 (\1\:B VSS) capacitor c=7.31339e-17
C17 (\4\:S0 VSS) capacitor c=9.03348e-17
C18 (\2\:S0b VSS) capacitor c=4.41485e-17
C19 (\1\:A VSS) capacitor c=6.74533e-17
C20 (\3\:S0 VSS) capacitor c=5.62537e-17
C21 (\4\:B VSS) capacitor c=2.82171e-17
C22 (\4\:S0b VSS) capacitor c=4.74711e-17
C23 (\5\:S0 VSS) capacitor c=9.17897e-17
C24 (\2\:A VSS) capacitor c=7.03949e-17
C25 (\2\:S0 VSS) capacitor c=5.69752e-17
C26 (\1\:VDD VSS) capacitor c=1.88934e-16
C27 (\1\:Y VSS) capacitor c=1.56525e-16
C28 (\16\:n0 VSS) capacitor c=8.96735e-17
C29 (\12\:VDD VSS) capacitor c=3.80015e-17
C30 (\10\:S0b VSS) capacitor c=1.0384e-16
C31 (\18\:n0 VSS) capacitor c=5.96136e-17
C32 (\8\:S0b VSS) capacitor c=1.32478e-17
C33 (\2\:B VSS) capacitor c=4.769e-17
C34 (\4\:A VSS) capacitor c=8.17975e-17
C35 (\8\:S0 VSS) capacitor c=9.44219e-17
C36 (\5\:S0b VSS) capacitor c=6.51666e-17
C37 (\6\:S0b VSS) capacitor c=9.61538e-17
C38 (\7\:S0b VSS) capacitor c=9.91061e-17
C39 (\5\:B VSS) capacitor c=5.31854e-17
C40 (\14\:n0 VSS) capacitor c=4.45405e-17
C41 (\15\:n0 VSS) capacitor c=1.09415e-16
C42 (\4\:Y VSS) capacitor c=7.8567e-17
C43 (\6\:VDD VSS) capacitor c=2.07995e-17
C44 (\7\:VDD VSS) capacitor c=2.44378e-17
Rk4 (\7\:S0 S0) resistor r=0.002995 c=0
Rk5 (S0 \8\:S0) resistor r=0.6145 c=0
Rk15 (\1\:Y Y) resistor r=0.001906 c=0
Rk16 (Y \4\:Y) resistor r=0.3586 c=0
Rk3 (\4\:A A) resistor r=0.005989 c=0
Rk32 (\8\:VSS VSS) resistor r=0.185 c=0
Rk31 (\1\:VSS \8\:VSS) resistor r=0.3657 c=0
Rk34 (\8\:VSS \12\:VSS) resistor r=0.1864 c=0
Rk22 (\1\:VDD \6\:VDD) resistor r=0.03489 c=0
Rk24 (\7\:VDD VDD) resistor r=0.1765 c=0
Rk23 (\6\:VDD \7\:VDD) resistor r=0.3723 c=0
Rk27 (\7\:VDD \13\:VDD) resistor r=0.1185 c=0
Rk10 (\5\:B B) resistor r=0.06791 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.3117 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.4883 c=0
Rk8 (\7\:S0b \9\:S0b) resistor r=0.05422 c=0
Rk9 (\7\:S0b \11\:S0b) resistor r=0.7841 c=0
Rk11 (\14\:n0 \15\:n0) resistor r=0.2366 c=0
Rk12 (\15\:n0 \17\:n0) resistor r=0.5687 c=0
Rk13 (\15\:n0 \19\:n0) resistor r=0.348 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=266.862 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=73.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=212.23 c=0
Rl4 (\2\:A \3\:A) resistor r=52.1808 c=0
Rl3 (\1\:A \2\:A) resistor r=206.148 c=0
Rl10 (\2\:B \3\:B) resistor r=78.3537 c=0
Rl9 (\1\:B \2\:B) resistor r=187.375 c=0
Rl11 (\2\:B \4\:B) resistor r=5.7469 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=41.3047 c=0
Rl5 (S0b \2\:S0b) resistor r=60.6943 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\17\:n0 \16\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\4\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\14\:n0 n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (n3 \1\:A \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.69e-14 ps=7.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.635e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn2 (\18\:n0 \2\:S0b n3 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.28e-14 ps=7.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3122e-07 sb=1.41e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn4 (\18\:n0 \4\:S0 n5 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=3.28e-14 ps=6.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3622e-07 sb=1.205e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn3 (n5 \1\:B \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.46e-14 ps=8.4e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0122e-07 sb=1.04e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn5_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.948e-14 ad=5.2e-14 ps=8.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93365e-07 sb=8.35e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
mp1 (n4 \3\:A \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=4.185e-14 ps=9.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80323e-07 sb=1.65e-06 sd=160n sca=12.241 \
        scb=0.00942952 scc=0.00011999 m=(1)
mp2 (\16\:n0 \6\:S0 n4 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60323e-07 sb=1.47e-06 sd=160n sca=11.1885 \
        scb=0.00841332 scc=0.000117337 m=(1)
mp4 (\16\:n0 \3\:S0b n6 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65323e-07 sb=1.265e-06 sd=160n sca=10.6105 \
        scb=0.00818197 scc=0.000117242 m=(1)
mp3 (n6 \3\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.65e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.60323e-07 sb=1.07e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.238e-14 ad=7.8e-14 ps=1.105e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99359e-07 sb=8.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
ends MX2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:48 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2X6
// View name: extracted

simulator lang=spectre

subckt MX2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \3\:S0 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=4.085e-14 ps=1.24e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=16.964 scb=0.0172681 \
        scc=0.000351906 m=(1)
C1 (S0 VSS) capacitor c=6.12246e-17
C2 (Y VSS) capacitor c=5.29618e-16
C3 (A VSS) capacitor c=4.14989e-17
C4 (VDD VSS) capacitor c=1.51052e-16
C5 (B VSS) capacitor c=1.0741e-16
C6 (S0b VSS) capacitor c=6.86241e-17
C7 (n0 VSS) capacitor c=3.26515e-16
C8 (n5 VSS) capacitor c=4.74361e-18
C9 (n4 VSS) capacitor c=4.30967e-18
C10 (n6 VSS) capacitor c=2.50176e-18
C11 (\1\:B VSS) capacitor c=5.01493e-17
C12 (\3\:S0b VSS) capacitor c=4.34362e-17
C13 (\6\:S0 VSS) capacitor c=4.14711e-17
C14 (\1\:A VSS) capacitor c=5.68635e-17
C15 (\3\:S0 VSS) capacitor c=3.2369e-17
C16 (\3\:B VSS) capacitor c=5.37035e-17
C17 (\4\:S0 VSS) capacitor c=6.39571e-17
C18 (\3\:A VSS) capacitor c=8.39622e-17
C19 (\1\:S0 VSS) capacitor c=4.62822e-17
C20 (\2\:B VSS) capacitor c=4.33859e-17
C21 (\4\:S0b VSS) capacitor c=4.2688e-17
C22 (\5\:S0 VSS) capacitor c=9.06271e-17
C23 (\2\:S0b VSS) capacitor c=5.61979e-17
C24 (\2\:A VSS) capacitor c=6.14321e-17
C25 (\2\:S0 VSS) capacitor c=4.43725e-17
C26 (\23\:n0 VSS) capacitor c=9.80213e-17
C27 (\14\:VDD VSS) capacitor c=2.90837e-17
C28 (\8\:S0b VSS) capacitor c=7.33764e-17
C29 (\1\:VDD VSS) capacitor c=3.09951e-17
C30 (\21\:n0 VSS) capacitor c=4.265e-17
C31 (\10\:S0b VSS) capacitor c=1.20888e-17
C32 (\4\:A VSS) capacitor c=7.65191e-17
C33 (\7\:S0 VSS) capacitor c=8.74935e-17
C34 (\8\:S0 VSS) capacitor c=3.64404e-17
C35 (\5\:S0b VSS) capacitor c=7.20062e-17
C36 (\6\:S0b VSS) capacitor c=8.60604e-17
C37 (\7\:S0b VSS) capacitor c=7.73479e-17
C38 (\19\:n0 VSS) capacitor c=6.13884e-17
C39 (\20\:n0 VSS) capacitor c=1.10144e-16
C40 (\3\:VDD VSS) capacitor c=2.71829e-16
C41 (\7\:VDD VSS) capacitor c=1.86157e-17
Rk2 (\7\:S0 S0) resistor r=0.424 c=0
Rk3 (S0 \8\:S0) resistor r=0.03791 c=0
Rk1 (A \4\:A) resistor r=0.03583 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.1227 c=0
Rk34 (\3\:VSS \6\:VSS) resistor r=0.08256 c=0
Rk36 (\7\:VSS VSS) resistor r=0.2278 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.3233 c=0
Rk40 (\7\:VSS \15\:VSS) resistor r=0.1775 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk24 (\3\:VDD \6\:VDD) resistor r=0.1302 c=0
Rk26 (\7\:VDD VDD) resistor r=0.1525 c=0
Rk25 (\6\:VDD \7\:VDD) resistor r=0.3985 c=0
Rk30 (\7\:VDD \15\:VDD) resistor r=0.231 c=0
Rk8 (B \4\:B) resistor r=0.003002 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.337 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5013 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.6219 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.05463 c=0
Rk9 (\19\:n0 \20\:n0) resistor r=0.3487 c=0
Rk10 (\20\:n0 \22\:n0) resistor r=0.3306 c=0
Rk11 (\20\:n0 \24\:n0) resistor r=0.5496 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=29.5379 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=229.104 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=66.4835 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=194.231 c=0
Rl3 (\1\:A \2\:A) resistor r=77.6148 c=0
Rl4 (\2\:A \3\:A) resistor r=144.923 c=0
Rl9 (\1\:B \2\:B) resistor r=73.7687 c=0
Rl10 (\2\:B \3\:B) resistor r=148.769 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=55.2823 c=0
Rl5 (S0b \2\:S0b) resistor r=68.4636 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz7 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=75 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\24\:n0 \23\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\19\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \1\:S0 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.79977 scb=0.00524357 \
        scc=6.87485e-05 m=(1)
mn1 (n3 \3\:A \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52195e-07 sb=1.84e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (\21\:n0 S0b n3 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 as=1.23e-14 \
        ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.57195e-07 sb=1.735e-06 sd=160n sca=7.24218 scb=0.00437101 \
        scc=5.12051e-05 m=(1)
mn4 (\21\:n0 \4\:S0 n5 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.28e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.62195e-07 sb=1.53e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn3 (n5 \3\:B \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.74e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57195e-07 sb=1.235e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn5_1__rcx (Y n0 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.916e-14 ad=5.456e-14 ps=9.48e-07 pd=9.72e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15645e-07 sb=1.01e-06 sd=160n sca=8.89324 \
        scb=0.00718666 scc=0.00021338 m=(5)
mp1 (n4 \1\:A \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=3.875e-14 ps=1.24e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08629e-07 sb=1.865e-06 sd=160n sca=12.5498 \
        scb=0.0102845 scc=0.000266006 m=(1)
mp2 (\23\:n0 \6\:S0 n4 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=6.2e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78629e-07 sb=1.695e-06 sd=160n sca=11.8758 \
        scb=0.0098568 scc=0.000265591 m=(1)
mp4 (\23\:n0 \3\:S0b n6 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=6.2e-14 ps=9.1e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=1.45e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp3 (n6 \1\:B \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01363e-06 sb=1.26e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp5_1__rcx (Y n0 \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.917e-14 ad=7.332e-14 ps=1.298e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.00479e-07 sb=9.6e-07 sd=160n sca=21.0172 \
        scb=0.0163249 scc=0.00202715 m=(5)
ends MX2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:50 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2X8
// View name: extracted

simulator lang=spectre

subckt MX2X8 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.837e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.0095 scb=0.0106782 \
        scc=0.000192315 m=(1)
C1 (S0 VSS) capacitor c=5.04117e-17
C2 (Y VSS) capacitor c=4.70565e-16
C3 (VDD VSS) capacitor c=2.0849e-16
C4 (B VSS) capacitor c=3.45246e-17
C5 (S0b VSS) capacitor c=3.61488e-17
C6 (n0 VSS) capacitor c=3.59768e-16
C7 (n5 VSS) capacitor c=3.99956e-18
C8 (n4 VSS) capacitor c=5.90288e-18
C9 (n6 VSS) capacitor c=4.68461e-18
C10 (\1\:B VSS) capacitor c=3.85855e-17
C11 (\6\:S0 VSS) capacitor c=4.38874e-17
C12 (\1\:A VSS) capacitor c=6.24986e-17
C13 (\1\:S0 VSS) capacitor c=3.55211e-17
C14 (\3\:B VSS) capacitor c=4.52189e-17
C15 (\4\:S0 VSS) capacitor c=7.09373e-17
C16 (\3\:S0b VSS) capacitor c=3.01833e-17
C17 (\3\:A VSS) capacitor c=4.20689e-17
C18 (\3\:S0 VSS) capacitor c=5.14822e-17
C19 (\2\:B VSS) capacitor c=4.06175e-17
C20 (\2\:S0b VSS) capacitor c=3.90523e-17
C21 (\4\:S0b VSS) capacitor c=4.42922e-17
C22 (\5\:S0 VSS) capacitor c=8.43306e-17
C23 (\2\:A VSS) capacitor c=4.88704e-17
C24 (\2\:S0 VSS) capacitor c=3.87788e-17
C25 (\1\:VDD VSS) capacitor c=2.88853e-16
C26 (\26\:n0 VSS) capacitor c=8.34007e-17
C27 (\16\:VDD VSS) capacitor c=3.92118e-17
C28 (\8\:S0b VSS) capacitor c=9.63085e-17
C29 (\3\:VDD VSS) capacitor c=5.38824e-17
C30 (\23\:n0 VSS) capacitor c=4.39629e-17
C31 (\5\:S0b VSS) capacitor c=1.19429e-17
C32 (\4\:A VSS) capacitor c=4.6387e-17
C33 (\6\:A VSS) capacitor c=6.82336e-17
C34 (\7\:S0 VSS) capacitor c=9.99281e-17
C35 (\8\:S0 VSS) capacitor c=8.61653e-17
C36 (\7\:S0b VSS) capacitor c=1.06624e-16
C37 (\10\:S0b VSS) capacitor c=7.6679e-17
C38 (\11\:S0b VSS) capacitor c=5.4737e-17
C39 (\4\:B VSS) capacitor c=5.89686e-17
C40 (\25\:n0 VSS) capacitor c=1.13995e-16
C41 (\28\:n0 VSS) capacitor c=6.10018e-17
C42 (\9\:VDD VSS) capacitor c=1.83406e-17
Rk4 (S0 \7\:S0) resistor r=0.07534 c=0
Rk5 (\7\:S0 \8\:S0) resistor r=0.6924 c=0
Rk1 (\4\:A \5\:A) resistor r=0.003456 c=0
Rk2 (A \6\:A) resistor r=0.003369 c=0
Rk3 (\4\:A \6\:A) resistor r=0.1037 c=0
Rk40 (\1\:VSS \8\:VSS) resistor r=0.2027 c=0
Rk42 (\9\:VSS VSS) resistor r=0.2826 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.2678 c=0
Rk46 (\9\:VSS \17\:VSS) resistor r=0.2422 c=0
Rk29 (\1\:VDD \8\:VDD) resistor r=0.2953 c=0
Rk31 (\9\:VDD VDD) resistor r=0.2675 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.2828 c=0
Rk35 (\9\:VDD \17\:VDD) resistor r=0.1979 c=0
Rk10 (B \4\:B) resistor r=0.1626 c=0
Rk6 (\6\:S0b \7\:S0b) resistor r=0.05402 c=0
Rk7 (\7\:S0b \9\:S0b) resistor r=0.7964 c=0
Rk8 (\7\:S0b \10\:S0b) resistor r=0.5536 c=0
Rk9 (\10\:S0b \11\:S0b) resistor r=0.2331 c=0
Rk11 (\24\:n0 \25\:n0) resistor r=0.3054 c=0
Rk12 (\25\:n0 \27\:n0) resistor r=0.5835 c=0
Rk13 (\25\:n0 \28\:n0) resistor r=0.3686 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=169.923 c=0
Rl3 (\1\:A \2\:A) resistor r=133.384 c=0
Rl4 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl9 (\1\:B \2\:B) resistor r=81.461 c=0
Rl10 (\2\:B \3\:B) resistor r=117.999 c=0
Rl5 (S0b \2\:S0b) resistor r=33.8482 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=66.8207 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz8 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\5\:S0b \6\:S0b) resistor r=75 c=0
Rz2 (\24\:n0 \23\:n0) resistor r=75 c=0
Ry12 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry13 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\27\:n0 \26\:n0) resistor r=31 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \10\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \11\:S0b) resistor r=45 c=0
Rx7 (\28\:n0 n0) resistor r=45 c=0
mn0 (\5\:S0b \3\:S0 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.1906 scb=0.0108717 \
        scc=0.000387468 m=(1)
mn1 (n3 \3\:A \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=4.817e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn2 (\23\:n0 \3\:S0b n3 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.715e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn4 (\23\:n0 \4\:S0 n5 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.715e-14 ps=7.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6122e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.357e-14 ad=3.382e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07122e-06 sb=1.8e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn5_1__rcx (Y n0 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.097e-14 ad=5.226e-14 ps=9.5429e-07 pd=9.4429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02508e-06 sb=1.44e-06 sd=160n sca=13.5379 \
        scb=0.0132414 scc=0.000904444 m=(7)
mp1 (n4 \1\:A \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=5.735e-14 ps=1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61935e-07 sb=2e-06 sd=160n sca=11.3406 \
        scb=0.00879396 scc=0.000154509 m=(1)
mp2 (\26\:n0 \6\:S0 n4 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.425e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp4 (\26\:n0 S0b n6 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=8.37e-14 \
        ad=5.425e-14 ps=1.16e-06 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.11935e-07 sb=2e-06 sd=160n sca=10.8361 scb=0.00861907 \
        scc=0.000154455 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=8.37e-14 ps=1.52e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12694e-06 sb=1.8e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp5_1__rcx (Y n0 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.691e-14 ad=7.883e-14 ps=1.25429e-06 pd=1.24429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.06618e-06 sb=1.44e-06 sd=160n \
        sca=14.4925 scb=0.0129103 scc=0.000843152 m=(7)
ends MX2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:51 2013 )
// Library name: gsclib045_hvt
// Cell name: MX2XL
// View name: extracted

simulator lang=spectre

subckt MX2XL A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
mp1 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.613e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=3.548e-14 ps=5.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.05e-07 sd=160n sca=13.1421 \
        scb=0.0105991 scc=0.000178477 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=3.548e-14 ps=6.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.95e-07 sd=160n sca=12.581 \
        scb=0.00966143 scc=0.000174195 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.258e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=13.2602 \
        scb=0.0108078 scc=0.000179977 m=(1)
mp5 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=17.479 \
        scb=0.0182451 scc=0.000415696 m=(1)
C1 (S0 VSS) capacitor c=4.21635e-17
C2 (Y VSS) capacitor c=5.97795e-17
C3 (VDD VSS) capacitor c=1.41782e-16
C4 (B VSS) capacitor c=4.16681e-17
C5 (S0b VSS) capacitor c=5.07525e-17
C6 (n0 VSS) capacitor c=2.99106e-17
C7 (n5 VSS) capacitor c=2.33876e-18
C8 (n6 VSS) capacitor c=3.31583e-18
C9 (\4\:B VSS) capacitor c=8.18783e-17
C10 (\3\:S0b VSS) capacitor c=4.41917e-17
C11 (\6\:S0 VSS) capacitor c=5.84257e-17
C12 (\1\:A VSS) capacitor c=7.29592e-17
C13 (\1\:S0 VSS) capacitor c=3.03229e-17
C14 (\4\:n0 VSS) capacitor c=6.40071e-17
C15 (\3\:B VSS) capacitor c=3.58965e-17
C16 (\4\:S0 VSS) capacitor c=6.34834e-17
C17 (\3\:A VSS) capacitor c=5.97168e-17
C18 (\3\:S0 VSS) capacitor c=4.95774e-17
C19 (\3\:n0 VSS) capacitor c=2.69303e-17
C20 (\1\:B VSS) capacitor c=2.7807e-17
C21 (\4\:S0b VSS) capacitor c=4.70346e-17
C22 (\2\:S0b VSS) capacitor c=3.92753e-17
C23 (\5\:S0 VSS) capacitor c=8.78504e-17
C24 (\2\:A VSS) capacitor c=6.7301e-17
C25 (\2\:S0 VSS) capacitor c=4.27888e-17
C26 (\1\:Y VSS) capacitor c=7.24362e-17
C27 (\1\:VDD VSS) capacitor c=3.64848e-17
C28 (\9\:n0 VSS) capacitor c=2.75e-17
C29 (\6\:VDD VSS) capacitor c=3.60742e-17
C30 (\10\:S0b VSS) capacitor c=7.19169e-17
C31 (\3\:Y VSS) capacitor c=1.96505e-17
C32 (\7\:n0 VSS) capacitor c=1.20966e-16
C33 (\8\:S0b VSS) capacitor c=1.93391e-17
C34 (\2\:B VSS) capacitor c=4.4162e-17
C35 (\2\:n0 VSS) capacitor c=2.92215e-17
C36 (\5\:A VSS) capacitor c=4.7481e-17
C37 (\6\:A VSS) capacitor c=4.1063e-17
C38 (\7\:S0 VSS) capacitor c=4.09847e-17
C39 (\8\:S0 VSS) capacitor c=7.11238e-17
C40 (\5\:S0b VSS) capacitor c=8.54158e-17
C41 (\6\:S0b VSS) capacitor c=1.1077e-16
C42 (\7\:S0b VSS) capacitor c=7.5337e-17
C43 (\5\:n0 VSS) capacitor c=4.40488e-17
C44 (\6\:n0 VSS) capacitor c=9.38087e-17
C45 (\5\:B VSS) capacitor c=4.78823e-17
C46 (\4\:VDD VSS) capacitor c=3.70654e-17
C47 (\5\:VDD VSS) capacitor c=7.32806e-18
Rk4 (\7\:S0 S0) resistor r=0.1314 c=0
Rk5 (S0 \8\:S0) resistor r=0.1615 c=0
Rk14 (\2\:Y Y) resistor r=0.5118 c=0
Rk15 (Y \4\:Y) resistor r=0.05349 c=0
Rk1 (\4\:A \5\:A) resistor r=0.01269 c=0
Rk2 (A \6\:A) resistor r=0.01254 c=0
Rk3 (\4\:A \6\:A) resistor r=0.03203 c=0
Rk20 (\2\:VSS \4\:VSS) resistor r=0.4231 c=0
Rk22 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk21 (\4\:VSS \5\:VSS) resistor r=0.1981 c=0
Rk23 (\5\:VSS \7\:VSS) resistor r=0.278 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.4143 c=0
Rk18 (\5\:VDD VDD) resistor r=0.1025 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.1981 c=0
Rk19 (\5\:VDD \7\:VDD) resistor r=0.2712 c=0
Rk13 (B \5\:B) resistor r=0.07283 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.3322 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.3175 c=0
Rk8 (\7\:S0b \9\:S0b) resistor r=0.1206 c=0
Rk9 (\7\:S0b \11\:S0b) resistor r=0.5113 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.1792 c=0
Rk11 (\6\:n0 \8\:n0) resistor r=0.6176 c=0
Rk12 (\6\:n0 \10\:n0) resistor r=0.2318 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=79.9442 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=169.15 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=26.098 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=176.098 c=0
Rl3 (\1\:A \2\:A) resistor r=129.538 c=0
Rl4 (\2\:A \3\:A) resistor r=79.5379 c=0
Rl11 (\2\:B \4\:B) resistor r=174.714 c=0
Rl10 (\2\:B \3\:B) resistor r=51.6372 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=42.9995 c=0
Rl5 (S0b \2\:S0b) resistor r=29.5379 c=0
Rl12 (n0 \2\:n0) resistor r=35.0798 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=190.849 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=0.8823 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (n3 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.42e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=9.42e-15 \
        ad=2.32e-14 ps=4.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=7.15e-07 sd=160n sca=10.2779 scb=0.00944477 \
        scc=0.000275883 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=2.32e-14 ps=5.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=5.1e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn5 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
ends MX2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:52 2013 )
// Library name: gsclib045_hvt
// Cell name: MX3X1
// View name: extracted

simulator lang=spectre

subckt MX3X1 A B C S0 S1 VDD VSS Y
mp9 (\1\:Y n1 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.46e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.53462e-07 sd=160n sca=27.0845 \
        scb=0.0288142 scc=0.0021178 m=(1)
C1 (A VSS) capacitor c=1.31599e-16
C2 (C VSS) capacitor c=3.07539e-17
C3 (VDD VSS) capacitor c=2.13668e-16
C4 (B VSS) capacitor c=3.97371e-17
C5 (S0 VSS) capacitor c=4.72491e-17
C6 (Y VSS) capacitor c=7.83284e-17
C7 (S1 VSS) capacitor c=4.57309e-17
C8 (n1 VSS) capacitor c=5.21839e-17
C9 (n0 VSS) capacitor c=9.77913e-17
C10 (S1b VSS) capacitor c=4.98868e-17
C11 (net234 VSS) capacitor c=3.56205e-18
C12 (S0b VSS) capacitor c=4.01446e-17
C13 (\6\:S0 VSS) capacitor c=2.84631e-17
C14 (\3\:A VSS) capacitor c=6.52756e-17
C15 (\1\:S0 VSS) capacitor c=4.71224e-17
C16 (\3\:B VSS) capacitor c=6.3578e-17
C17 (\6\:S1 VSS) capacitor c=4.65371e-17
C18 (\7\:S1 VSS) capacitor c=3.51906e-17
C19 (\2\:S1b VSS) capacitor c=6.98266e-17
C20 (\1\:C VSS) capacitor c=5.45086e-17
C21 (\4\:S0 VSS) capacitor c=4.876e-17
C22 (\1\:A VSS) capacitor c=6.67728e-17
C23 (\3\:S0b VSS) capacitor c=6.5531e-17
C24 (\3\:S0 VSS) capacitor c=6.82451e-17
C25 (\1\:B VSS) capacitor c=3.94369e-17
C26 (\1\:S1 VSS) capacitor c=2.79623e-17
C27 (\3\:S1b VSS) capacitor c=2.4713e-17
C28 (\5\:S1 VSS) capacitor c=9.51732e-17
C29 (\3\:C VSS) capacitor c=7.63404e-17
C30 (\3\:n1 VSS) capacitor c=3.35642e-17
C31 (\5\:S0 VSS) capacitor c=4.2343e-17
C32 (\2\:A VSS) capacitor c=6.7182e-17
C33 (\4\:S0b VSS) capacitor c=5.23334e-17
C34 (\2\:S0 VSS) capacitor c=7.05269e-17
C35 (\2\:S0b VSS) capacitor c=4.60892e-17
C36 (\2\:B VSS) capacitor c=5.69619e-17
C37 (\3\:S1 VSS) capacitor c=2.46366e-17
C38 (\4\:S1b VSS) capacitor c=4.75588e-17
C39 (\2\:C VSS) capacitor c=6.12251e-17
C40 (\2\:n1 VSS) capacitor c=3.01236e-17
C41 (\10\:S0b VSS) capacitor c=7.66435e-17
C42 (\7\:VDD VSS) capacitor c=3.07601e-17
C43 (\6\:n0 VSS) capacitor c=4.69648e-17
C44 (\9\:VDD VSS) capacitor c=4.1845e-17
C45 (\10\:S1b VSS) capacitor c=9.57974e-17
C46 (\4\:n0 VSS) capacitor c=1.35248e-16
C47 (\8\:n1 VSS) capacitor c=7.86587e-17
C48 (\11\:VDD VSS) capacitor c=3.30708e-17
C49 (\1\:Y VSS) capacitor c=5.0074e-17
C50 (\1\:VDD VSS) capacitor c=5.17006e-17
C51 (\5\:S0b VSS) capacitor c=2.24262e-17
C52 (\5\:S1b VSS) capacitor c=1.32652e-16
C53 (\8\:n0 VSS) capacitor c=1.06197e-16
C54 (\6\:n1 VSS) capacitor c=3.24483e-17
C55 (\2\:S1 VSS) capacitor c=5.04746e-17
C56 (\4\:S1 VSS) capacitor c=7.95087e-17
C57 (\4\:C VSS) capacitor c=6.67889e-17
C58 (\4\:n1 VSS) capacitor c=7.32645e-17
C59 (\5\:n1 VSS) capacitor c=6.69473e-17
C60 (\8\:S1 VSS) capacitor c=7.04027e-17
C61 (\7\:S1b VSS) capacitor c=1.39273e-16
C62 (\9\:S1b VSS) capacitor c=1.17891e-16
C63 (\4\:B VSS) capacitor c=7.33147e-17
C64 (\3\:n0 VSS) capacitor c=1.27458e-16
C65 (\7\:S0 VSS) capacitor c=4.62065e-17
C66 (\8\:S0 VSS) capacitor c=5.77639e-17
C67 (\7\:S0b VSS) capacitor c=8.27479e-17
C68 (\8\:S0b VSS) capacitor c=1.09211e-16
C69 (\9\:S0b VSS) capacitor c=6.43272e-17
C70 (\3\:VDD VSS) capacitor c=1.75688e-17
C71 (\4\:VDD VSS) capacitor c=2.20622e-17
C72 (\6\:VDD VSS) capacitor c=1.40264e-17
Rk17 (\4\:A A) resistor r=0.004385 c=0
Rk3 (C \4\:C) resistor r=0.114 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.1252 c=0
Rk25 (\3\:VSS \4\:VSS) resistor r=0.3883 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.238 c=0
Rk28 (\6\:VSS VSS) resistor r=0.1174 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.4336 c=0
Rk29 (\3\:VSS \8\:VSS) resistor r=0.2699 c=0
Rk30 (\4\:VSS \10\:VSS) resistor r=0.2948 c=0
Rk31 (\6\:VSS \12\:VSS) resistor r=0.1993 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.1578 c=0
Rk33 (\3\:VDD \4\:VDD) resistor r=0.3933 c=0
Rk34 (\4\:VDD \5\:VDD) resistor r=0.2004 c=0
Rk36 (\6\:VDD VDD) resistor r=0.1324 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.4185 c=0
Rk37 (\3\:VDD \8\:VDD) resistor r=0.254 c=0
Rk38 (\4\:VDD \10\:VDD) resistor r=0.2584 c=0
Rk39 (\6\:VDD \12\:VDD) resistor r=0.2684 c=0
Rk12 (\4\:B B) resistor r=0.09819 c=0
Rk18 (S0 \7\:S0) resistor r=0.08731 c=0
Rk19 (\7\:S0 \8\:S0) resistor r=0.2524 c=0
Rk1 (\2\:Y Y) resistor r=0.5031 c=0
Rk2 (Y \4\:Y) resistor r=0.01452 c=0
Rk7 (S1 \8\:S1) resistor r=0.111 c=0
Rk4 (\4\:n1 \5\:n1) resistor r=0.3394 c=0
Rk5 (\5\:n1 \7\:n1) resistor r=0.09065 c=0
Rk6 (\5\:n1 \9\:n1) resistor r=0.4248 c=0
Rk13 (\2\:n0 \3\:n0) resistor r=0.7164 c=0
Rk14 (\3\:n0 \5\:n0) resistor r=0.5029 c=0
Rk15 (\3\:n0 \7\:n0) resistor r=0.2271 c=0
Rk16 (\5\:n0 \9\:n0) resistor r=0.6093 c=0
Rk8 (\6\:S1b \7\:S1b) resistor r=0.8529 c=0
Rk9 (\7\:S1b \8\:S1b) resistor r=0.2218 c=0
Rk10 (\8\:S1b \9\:S1b) resistor r=0.01531 c=0
Rk11 (\8\:S1b \11\:S1b) resistor r=0.7038 c=0
Rk20 (\6\:S0b \7\:S0b) resistor r=0.2634 c=0
Rk21 (\7\:S0b \8\:S0b) resistor r=0.486 c=0
Rk22 (\8\:S0b \9\:S0b) resistor r=0.3832 c=0
Rk23 (\7\:S0b \11\:S0b) resistor r=0.5822 c=0
Rl20 (\2\:A \3\:A) resistor r=101.718 c=0
Rl19 (\1\:A \2\:A) resistor r=109.879 c=0
Rl3 (\1\:C \2\:C) resistor r=24.2328 c=0
Rl4 (\2\:C \3\:C) resistor r=147.31 c=0
Rl14 (\2\:B \3\:B) resistor r=128.207 c=0
Rl13 (\1\:B \2\:B) resistor r=111.516 c=0
Rl22 (\5\:S0 \6\:S0) resistor r=29.9451 c=0
Rl21 (\4\:S0 \5\:S0) resistor r=184.615 c=0
Rl16 (\1\:S0 \2\:S0) resistor r=34.6154 c=0
Rl17 (\2\:S0 \3\:S0) resistor r=183.738 c=0
Rl11 (\2\:S1 \6\:S1) resistor r=170.387 c=0
Rl7 (\1\:S1 \2\:S1) resistor r=75.7223 c=0
Rl8 (\2\:S1 \3\:S1) resistor r=59.9887 c=0
Rl12 (\4\:S1 \7\:S1) resistor r=91.9892 c=0
Rl10 (\4\:S1 \5\:S1) resistor r=234.593 c=0
Rl9 (\3\:S1 \4\:S1) resistor r=94.1561 c=0
Rl1 (n1 \2\:n1) resistor r=108.848 c=0
Rl2 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl6 (\3\:S1b \4\:S1b) resistor r=51.2042 c=0
Rl5 (S1b \2\:S1b) resistor r=105.282 c=0
Rl18 (\3\:S0b \4\:S0b) resistor r=32.5403 c=0
Rl15 (S0b \2\:S0b) resistor r=74.2328 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz11 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz6 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry8 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry6 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx7 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx8 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx9 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx3 (\3\:S1 \8\:S1) resistor r=45 c=0
Rx2 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\4\:S1b \7\:S1b) resistor r=45 c=0
Rx5 (S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\3\:Y \3\:n1 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=3.64e-14 ps=9.6e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.42885e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn7 (net245 \3\:C \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn8 (\6\:n1 \5\:S1 net245 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.857e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.2e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn6 (\6\:n1 \3\:S1b \8\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.857e-14 ps=5.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn1 (\5\:S1b \1\:S1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (net234 \1\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.552e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.552e-14 ad=2.32e-14 ps=7.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=6.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.5e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (net229 \1\:A \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\5\:S0b \4\:S0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp7 (net202 \1\:C \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=1.29e-14 ps=1.22e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=26.7541 \
        scb=0.0241209 scc=0.00281164 m=(1)
mp8 (\8\:n1 \2\:S1b net202 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.095e-14 ps=5.5e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.2e-07 sd=160n sca=25.94 scb=0.0231463 \
        scc=0.00280756 m=(1)
mp6 (\4\:n0 \7\:S1 \8\:n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.095e-14 ad=3.118e-14 ps=1.09e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.45e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp1 (\10\:S1b \6\:S1 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.17e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp4 (net190 \3\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.65e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp5 (\6\:n0 S0b net190 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=4.515e-14 ps=7.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.55e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp3 (\6\:n0 \1\:S0 net189 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.515e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=5e-07 sd=160n sca=11.0172 scb=0.0085015 \
        scc=0.000138145 m=(1)
mp2 (net189 \3\:A \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=1.505e-14 ps=8.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=3.85e-07 sd=160n sca=11.4166 \
        scb=0.00871068 scc=0.00013827 m=(1)
mp0 (\10\:S0b \6\:S0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=1.4e-07 sd=160n sca=13.294 \
        scb=0.0109881 scc=0.000151098 m=(1)
ends MX3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:53 2013 )
// Library name: gsclib045_hvt
// Cell name: MX3X2
// View name: extracted

simulator lang=spectre

subckt MX3X2 A B C S0 S1 VDD VSS Y
mp9_1__rcx (\1\:Y n1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.594e-14 ad=9.36e-14 ps=1.105e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.26026e-07 sd=160n sca=18.9913 \
        scb=0.020688 scc=0.00060344 m=(2)
C1 (A VSS) capacitor c=2.89849e-17
C2 (C VSS) capacitor c=7.32148e-17
C3 (VDD VSS) capacitor c=2.41223e-16
C4 (B VSS) capacitor c=6.55326e-17
C5 (Y VSS) capacitor c=1.43884e-17
C6 (S1 VSS) capacitor c=6.21667e-17
C7 (n1 VSS) capacitor c=1.77733e-16
C8 (net245 VSS) capacitor c=4.22375e-18
C9 (n0 VSS) capacitor c=1.07664e-16
C10 (S1b VSS) capacitor c=5.34284e-17
C11 (net234 VSS) capacitor c=7.85343e-18
C12 (S0b VSS) capacitor c=4.08977e-17
C13 (net202 VSS) capacitor c=2.23411e-18
C14 (net190 VSS) capacitor c=5.78225e-18
C15 (\4\:S0 VSS) capacitor c=3.11151e-17
C16 (\1\:A VSS) capacitor c=5.80604e-17
C17 (\1\:S0 VSS) capacitor c=3.49447e-17
C18 (\1\:B VSS) capacitor c=6.32236e-17
C19 (\1\:S1 VSS) capacitor c=3.65795e-17
C20 (\7\:S1 VSS) capacitor c=3.40889e-17
C21 (\2\:S1b VSS) capacitor c=3.94935e-17
C22 (\3\:C VSS) capacitor c=5.15327e-17
C23 (\6\:S0 VSS) capacitor c=5.58148e-17
C24 (\3\:A VSS) capacitor c=6.9657e-17
C25 (\3\:S0b VSS) capacitor c=5.99602e-17
C26 (\3\:S0 VSS) capacitor c=6.11777e-17
C27 (\3\:B VSS) capacitor c=2.94823e-17
C28 (\6\:S1 VSS) capacitor c=5.35063e-17
C29 (\3\:S1b VSS) capacitor c=3.39149e-17
C30 (\5\:S1 VSS) capacitor c=5.86596e-17
C31 (\1\:C VSS) capacitor c=3.96429e-17
C32 (\5\:S0 VSS) capacitor c=5.15245e-17
C33 (\2\:A VSS) capacitor c=7.0728e-17
C34 (\4\:S0b VSS) capacitor c=6.56723e-17
C35 (\2\:S0 VSS) capacitor c=8.3342e-17
C36 (\2\:S0b VSS) capacitor c=4.22695e-17
C37 (\2\:B VSS) capacitor c=4.85863e-17
C38 (\3\:S1 VSS) capacitor c=2.09168e-17
C39 (\4\:S1b VSS) capacitor c=3.92404e-17
C40 (\2\:C VSS) capacitor c=4.37715e-17
C41 (\10\:S0b VSS) capacitor c=7.98846e-17
C42 (\1\:VDD VSS) capacitor c=3.45978e-17
C43 (\7\:n0 VSS) capacitor c=3.22027e-17
C44 (\6\:VDD VSS) capacitor c=3.72402e-17
C45 (\5\:S1b VSS) capacitor c=8.23209e-17
C46 (\5\:n0 VSS) capacitor c=2.73984e-17
C47 (\11\:n1 VSS) capacitor c=8.22902e-17
C48 (\1\:Y VSS) capacitor c=8.18252e-17
C49 (\3\:VDD VSS) capacitor c=6.87191e-17
C50 (\5\:S0b VSS) capacitor c=3.27703e-17
C51 (\10\:S1b VSS) capacitor c=7.74799e-17
C52 (\9\:n0 VSS) capacitor c=7.93697e-17
C53 (\7\:n1 VSS) capacitor c=4.07938e-17
C54 (\4\:Y VSS) capacitor c=4.43448e-17
C55 (\2\:S1 VSS) capacitor c=3.48559e-17
C56 (\4\:S1 VSS) capacitor c=7.29944e-17
C57 (\3\:Y VSS) capacitor c=5.79918e-17
C58 (\4\:C VSS) capacitor c=3.95161e-17
C59 (\9\:n1 VSS) capacitor c=6.28248e-17
C60 (\10\:n1 VSS) capacitor c=6.51315e-17
C61 (\7\:S1b VSS) capacitor c=7.18813e-17
C62 (\8\:S1b VSS) capacitor c=7.8189e-17
C63 (\9\:S1b VSS) capacitor c=3.44868e-17
C64 (\8\:S1 VSS) capacitor c=6.701e-17
C65 (\4\:B VSS) capacitor c=5.25119e-17
C66 (\3\:n0 VSS) capacitor c=1.53829e-16
C67 (\4\:n0 VSS) capacitor c=9.40289e-17
C68 (\4\:A VSS) capacitor c=8.70364e-17
C69 (\7\:S0 VSS) capacitor c=7.4756e-17
C70 (\8\:S0 VSS) capacitor c=4.33171e-17
C71 (\7\:S0b VSS) capacitor c=5.34112e-17
C72 (\8\:S0b VSS) capacitor c=1.13628e-16
C73 (\9\:S0b VSS) capacitor c=6.88101e-17
C74 (\5\:VDD VSS) capacitor c=3.46385e-17
C75 (\9\:VDD VSS) capacitor c=1.17553e-16
Rk19 (A \4\:A) resistor r=0.05431 c=0
Rk35 (\2\:VSS \4\:VSS) resistor r=0.2691 c=0
Rk36 (\4\:VSS \5\:VSS) resistor r=0.4667 c=0
Rk37 (\5\:VSS \6\:VSS) resistor r=0.3357 c=0
Rk40 (\7\:VSS VSS) resistor r=0.03967 c=0
Rk38 (\6\:VSS \7\:VSS) resistor r=0.2806 c=0
Rk41 (\5\:VSS \10\:VSS) resistor r=0.2247 c=0
Rk4 (\4\:C C) resistor r=0.1387 c=0
Rk26 (\2\:VDD \4\:VDD) resistor r=0.2758 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.4667 c=0
Rk28 (\5\:VDD \7\:VDD) resistor r=0.227 c=0
Rk29 (\5\:VDD \8\:VDD) resistor r=0.3357 c=0
Rk34 (\9\:VDD VDD) resistor r=0.03967 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.2655 c=0
Rk13 (\4\:B B) resistor r=0.1633 c=0
Rk20 (S0 \7\:S0) resistor r=0.003678 c=0
Rk21 (\7\:S0 \8\:S0) resistor r=0.2739 c=0
Rk3 (\3\:Y Y) resistor r=0.006072 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.4965 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.1492 c=0
Rk12 (S1 \8\:S1) resistor r=0.1439 c=0
Rk5 (\8\:n1 \9\:n1) resistor r=0.1339 c=0
Rk6 (\9\:n1 \10\:n1) resistor r=0.3252 c=0
Rk7 (\9\:n1 \12\:n1) resistor r=0.4177 c=0
Rk14 (\2\:n0 \3\:n0) resistor r=0.7843 c=0
Rk15 (\3\:n0 \4\:n0) resistor r=0.4274 c=0
Rk16 (\4\:n0 \6\:n0) resistor r=0.06409 c=0
Rk17 (\3\:n0 \8\:n0) resistor r=0.253 c=0
Rk18 (\4\:n0 \10\:n0) resistor r=0.4005 c=0
Rk8 (\6\:S1b \7\:S1b) resistor r=0.553 c=0
Rk9 (\7\:S1b \8\:S1b) resistor r=0.1773 c=0
Rk10 (\7\:S1b \9\:S1b) resistor r=0.1128 c=0
Rk11 (\8\:S1b \11\:S1b) resistor r=0.6017 c=0
Rk22 (\6\:S0b \7\:S0b) resistor r=0.2086 c=0
Rk23 (\7\:S0b \8\:S0b) resistor r=0.3729 c=0
Rk24 (\8\:S0b \9\:S0b) resistor r=0.4497 c=0
Rk25 (\7\:S0b \11\:S0b) resistor r=0.5381 c=0
Rl22 (\1\:A \2\:A) resistor r=146.846 c=0
Rl23 (\2\:A \3\:A) resistor r=112.23 c=0
Rl7 (\2\:C \3\:C) resistor r=81.9251 c=0
Rl6 (\1\:C \2\:C) resistor r=53.4495 c=0
Rl16 (\1\:B \2\:B) resistor r=219.923 c=0
Rl17 (\2\:B \3\:B) resistor r=39.1533 c=0
Rl24 (\4\:S0 \5\:S0) resistor r=29.5379 c=0
Rl25 (\5\:S0 \6\:S0) resistor r=229.538 c=0
Rl19 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl20 (\2\:S0 \3\:S0) resistor r=235.337 c=0
Rl10 (\1\:S1 \2\:S1) resistor r=103.56 c=0
Rl14 (\2\:S1 \6\:S1) resistor r=172.791 c=0
Rl11 (\2\:S1 \3\:S1) resistor r=1.2666 c=0
Rl15 (\4\:S1 \7\:S1) resistor r=58.8489 c=0
Rl13 (\4\:S1 \5\:S1) resistor r=162.261 c=0
Rl12 (\3\:S1 \4\:S1) resistor r=171.264 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=37.2302 c=0
Rl8 (S1b \2\:S1b) resistor r=57.6695 c=0
Rl21 (\3\:S0b \4\:S0b) resistor r=39.1533 c=0
Rl18 (S0b \2\:S0b) resistor r=73.7687 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz8 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\8\:n1 \7\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz6 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry11 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry12 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry7 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\12\:n1 \11\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry5 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry6 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx7 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx8 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx9 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx5 (\3\:S1 \8\:S1) resistor r=45 c=0
Rx2 (\10\:n1 n1) resistor r=45 c=0
Rx3 (\4\:S1b \8\:S1b) resistor r=45 c=0
Rx4 (S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9_1__rcx (\4\:Y n1 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.002e-14 ad=6.24e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.68365e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn7 (net245 \1\:C \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.393e-14 ps=9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn8 (\7\:n1 \5\:S1 net245 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.77e-14 ps=6.2e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (\7\:n1 \3\:S1b \9\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=3.77e-14 ps=6.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\10\:S1b \6\:S1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn4 (net234 \3\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.712e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03e-06 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.712e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.6e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=4.55e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (net229 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=8.7e-15 ps=6.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.5e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn0 (\5\:S0b \6\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=1.4e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mp7 (net202 \3\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.795e-14 ps=1.15e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.7e-07 sd=160n sca=12.5284 \
        scb=0.0109224 scc=0.000332139 m=(1)
mp8 (\11\:n1 \2\:S1b net202 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=4.193e-14 ps=6.9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=4.95e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp6 (\5\:n0 \7\:S1 \11\:n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.193e-14 ad=5.483e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2.55e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (\5\:S1b \1\:S1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp4 (net190 \1\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03e-06 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=7.65e-07 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=5.6e-07 sd=160n sca=10.7836 \
        scb=0.00772993 scc=8.40702e-05 m=(1)
mp2 (net189 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.548e-14 ps=7.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.5e-07 sd=160n sca=11.9995 \
        scb=0.0089032 scc=8.73074e-05 m=(1)
mp0 (\10\:S0b \4\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=1.4e-07 sd=160n sca=15.6354 \
        scb=0.0149943 scc=0.000227751 m=(1)
ends MX3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:55 2013 )
// Library name: gsclib045_hvt
// Cell name: MX3X4
// View name: extracted

simulator lang=spectre

subckt MX3X4 A B C S0 S1 VDD VSS Y
mp7 (net202 \1\:C \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=3.12e-14 ps=1.13e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=6.15e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp8 (\17\:n1 \2\:S1b net202 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=1.1895e-13 ps=9.4e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=4.9e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp6 (\5\:n0 \6\:S1 \17\:n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1895e-13 ad=5.46e-14 ps=1.39e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp9_1__rcx (\1\:Y n1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.289e-14 ad=7.8e-14 ps=1.1025e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.53e-06 sd=160n sca=16.3392 \
        scb=0.0152106 scc=0.000622257 m=(4)
C1 (A VSS) capacitor c=3.16474e-17
C2 (C VSS) capacitor c=5.55387e-17
C3 (Y VSS) capacitor c=1.88538e-17
C4 (B VSS) capacitor c=8.65368e-17
C5 (VDD VSS) capacitor c=2.25499e-16
C6 (S1 VSS) capacitor c=7.49696e-17
C7 (n1 VSS) capacitor c=2.49769e-16
C8 (net245 VSS) capacitor c=5.3414e-18
C9 (n0 VSS) capacitor c=1.07511e-16
C10 (S1b VSS) capacitor c=5.03697e-17
C11 (net234 VSS) capacitor c=1.83395e-19
C12 (S0b VSS) capacitor c=4.40057e-17
C13 (net190 VSS) capacitor c=3.7823e-18
C14 (\4\:S0 VSS) capacitor c=2.69357e-17
C15 (\1\:A VSS) capacitor c=5.19035e-17
C16 (\1\:S0 VSS) capacitor c=3.1483e-17
C17 (\1\:B VSS) capacitor c=6.17388e-17
C18 (\5\:S1 VSS) capacitor c=3.68566e-17
C19 (\6\:S1 VSS) capacitor c=3.10166e-17
C20 (\2\:S1b VSS) capacitor c=7.28281e-17
C21 (\1\:C VSS) capacitor c=6.86517e-17
C22 (\6\:S0 VSS) capacitor c=5.06667e-17
C23 (\3\:A VSS) capacitor c=5.52631e-17
C24 (\3\:S0b VSS) capacitor c=5.98772e-17
C25 (\3\:S0 VSS) capacitor c=6.07972e-17
C26 (\3\:B VSS) capacitor c=3.43427e-17
C27 (\1\:S1 VSS) capacitor c=5.36219e-17
C28 (\3\:S1b VSS) capacitor c=3.10794e-17
C29 (\4\:S1 VSS) capacitor c=6.53992e-17
C30 (\3\:C VSS) capacitor c=3.60855e-17
C31 (\5\:S0 VSS) capacitor c=4.51536e-17
C32 (\2\:A VSS) capacitor c=6.16135e-17
C33 (\4\:S0b VSS) capacitor c=4.96142e-17
C34 (\2\:S0 VSS) capacitor c=7.99977e-17
C35 (\2\:S0b VSS) capacitor c=4.69517e-17
C36 (\2\:B VSS) capacitor c=5.36086e-17
C37 (\2\:S1 VSS) capacitor c=5.83464e-17
C38 (\4\:S1b VSS) capacitor c=4.6545e-17
C39 (\2\:C VSS) capacitor c=4.06854e-17
C40 (\10\:S0b VSS) capacitor c=5.0353e-17
C41 (\7\:VDD VSS) capacitor c=2.44838e-17
C42 (\7\:n0 VSS) capacitor c=2.51479e-17
C43 (\1\:VDD VSS) capacitor c=3.81688e-17
C44 (\5\:S1b VSS) capacitor c=8.88547e-17
C45 (\5\:n0 VSS) capacitor c=4.34479e-17
C46 (\17\:n1 VSS) capacitor c=1.04432e-16
C47 (\1\:Y VSS) capacitor c=1.60756e-16
C48 (\4\:VDD VSS) capacitor c=6.93186e-17
C49 (\5\:S0b VSS) capacitor c=1.95372e-17
C50 (\10\:S1b VSS) capacitor c=7.427e-17
C51 (\9\:n0 VSS) capacitor c=9.88784e-17
C52 (\13\:n1 VSS) capacitor c=4.12737e-17
C53 (\4\:Y VSS) capacitor c=9.7259e-17
C54 (\3\:S1 VSS) capacitor c=7.46894e-17
C55 (\4\:C VSS) capacitor c=4.65908e-17
C56 (\15\:n1 VSS) capacitor c=6.81845e-17
C57 (\16\:n1 VSS) capacitor c=6.4717e-17
C58 (\8\:S1b VSS) capacitor c=9.4616e-17
C59 (\9\:S1b VSS) capacitor c=8.16163e-17
C60 (\12\:S1b VSS) capacitor c=2.26346e-17
C61 (\7\:S1 VSS) capacitor c=5.61468e-17
C62 (\4\:B VSS) capacitor c=3.62572e-17
C63 (\3\:n0 VSS) capacitor c=1.40708e-16
C64 (\4\:n0 VSS) capacitor c=9.12829e-17
C65 (\7\:S0 VSS) capacitor c=6.85764e-17
C66 (\8\:S0 VSS) capacitor c=4.57614e-17
C67 (\4\:A VSS) capacitor c=8.53788e-17
C68 (\7\:S0b VSS) capacitor c=8.16688e-17
C69 (\8\:S0b VSS) capacitor c=1.11669e-16
C70 (\9\:S0b VSS) capacitor c=6.81104e-17
C71 (\3\:VDD VSS) capacitor c=3.71858e-17
C72 (\5\:VDD VSS) capacitor c=1.68419e-16
Rk26 (A \4\:A) resistor r=0.07281 c=0
Rk6 (C \4\:C) resistor r=0.03635 c=0
Rk2 (\1\:Y Y) resistor r=0.265 c=0
Rk3 (Y \4\:Y) resistor r=0.04446 c=0
Rk18 (\4\:B B) resistor r=0.01496 c=0
Rk24 (S0 \7\:S0) resistor r=0.005081 c=0
Rk25 (\7\:S0 \8\:S0) resistor r=0.2852 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.325 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.3281 c=0
Rk37 (\6\:VSS VSS) resistor r=0.1198 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.6243 c=0
Rk34 (\5\:VSS \8\:VSS) resistor r=0.2005 c=0
Rk41 (\2\:VDD \3\:VDD) resistor r=0.2492 c=0
Rk50 (\5\:VDD VDD) resistor r=0.1148 c=0
Rk42 (\3\:VDD \5\:VDD) resistor r=0.6218 c=0
Rk43 (\3\:VDD \6\:VDD) resistor r=0.3306 c=0
Rk44 (\6\:VDD \8\:VDD) resistor r=0.3771 c=0
Rk15 (S1 \7\:S1) resistor r=0.1437 c=0
Rk7 (\14\:n1 \15\:n1) resistor r=0.1246 c=0
Rk8 (\15\:n1 \16\:n1) resistor r=0.3577 c=0
Rk9 (\15\:n1 \18\:n1) resistor r=0.4624 c=0
Rk19 (\2\:n0 \3\:n0) resistor r=0.7805 c=0
Rk20 (\3\:n0 \4\:n0) resistor r=0.3842 c=0
Rk21 (\4\:n0 \6\:n0) resistor r=0.1486 c=0
Rk22 (\3\:n0 \8\:n0) resistor r=0.2267 c=0
Rk23 (\4\:n0 \10\:n0) resistor r=0.4084 c=0
Rk10 (\6\:S1b \7\:S1b) resistor r=0.5988 c=0
Rk11 (\7\:S1b \8\:S1b) resistor r=0.04598 c=0
Rk12 (\7\:S1b \9\:S1b) resistor r=0.1976 c=0
Rk13 (\9\:S1b \11\:S1b) resistor r=0.5988 c=0
Rk14 (\9\:S1b \12\:S1b) resistor r=0.02782 c=0
Rk27 (\6\:S0b \7\:S0b) resistor r=0.1368 c=0
Rk28 (\7\:S0b \8\:S0b) resistor r=0.4793 c=0
Rk29 (\8\:S0b \9\:S0b) resistor r=0.3825 c=0
Rk30 (\7\:S0b \11\:S0b) resistor r=0.4507 c=0
Rl27 (\1\:A \2\:A) resistor r=160.307 c=0
Rl28 (\2\:A \3\:A) resistor r=98.7687 c=0
Rl12 (\1\:C \2\:C) resistor r=74.2328 c=0
Rl13 (\2\:C \3\:C) resistor r=43.4636 c=0
Rl21 (\1\:B \2\:B) resistor r=181.925 c=0
Rl22 (\2\:B \3\:B) resistor r=74.2328 c=0
Rl29 (\4\:S0 \5\:S0) resistor r=29.5379 c=0
Rl30 (\5\:S0 \6\:S0) resistor r=229.538 c=0
Rl24 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl25 (\2\:S0 \3\:S0) resistor r=233.414 c=0
Rl19 (\2\:S1 \5\:S1) resistor r=77.6559 c=0
Rl16 (\1\:S1 \2\:S1) resistor r=171.32 c=0
Rl20 (\3\:S1 \6\:S1) resistor r=28.0797 c=0
Rl18 (\3\:S1 \4\:S1) resistor r=179.568 c=0
Rl17 (\2\:S1 \3\:S1) resistor r=162.376 c=0
Rl15 (\3\:S1b \4\:S1b) resistor r=48.7687 c=0
Rl14 (S1b \2\:S1b) resistor r=98.0541 c=0
Rl26 (\3\:S0b \4\:S0b) resistor r=80.0021 c=0
Rl23 (S0b \2\:S0b) resistor r=90.1003 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz9 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz13 (\5\:VDD \4\:VDD) resistor r=6.25 c=0
Rz14 (\6\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz3 (\14\:n1 \13\:n1) resistor r=75 c=0
Rz5 (n0 \2\:n0) resistor r=75 c=0
Rz6 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz4 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz7 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry8 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry9 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry10 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry11 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\18\:n1 \17\:n1) resistor r=20.6667 c=0
Ry5 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry6 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry4 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry7 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx9 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx7 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx8 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx5 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx2 (\16\:n1 n1) resistor r=45 c=0
Rx3 (S1b \8\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \12\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn7 (net245 \3\:C \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=5.59e-14 ps=8.7e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=7.2e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn8 (\13\:n1 \4\:S1 net245 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=7.15e-14 ps=9.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn6 (\13\:n1 \3\:S1b \9\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=7.15e-14 ps=8e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=1.4e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn9_1__rcx (\4\:Y n1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.127e-14 ad=5.2e-14 ps=8.375e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.635e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn1 (\10\:S1b \1\:S1 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.365e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn4 (net234 \3\:B \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.785e-14 ps=6.1e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.16e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=2.32e-14 ps=9.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=7.85e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=2.32e-14 ps=4.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=5.8e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (net229 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.16e-14 ps=7.3e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=4.55e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn0 (\5\:S0b \6\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.755e-14 ps=7.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.9e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mp1 (\5\:S1b \5\:S1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp4 (net190 \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.19e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=9.7e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=7.65e-07 sd=160n sca=10.9501 \
        scb=0.00835862 scc=0.000128423 m=(1)
mp2 (net189 \1\:A \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.052e-14 ps=8.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=4.85e-07 sd=160n sca=12.393 \
        scb=0.00963865 scc=0.000131709 m=(1)
mp0 (\10\:S0b \4\:S0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.73e-14 ps=8.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=2.2e-07 sd=160n sca=18.2413 \
        scb=0.0194209 scc=0.000499991 m=(1)
ends MX3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:56 2013 )
// Library name: gsclib045_hvt
// Cell name: MX3XL
// View name: extracted

simulator lang=spectre

subckt MX3XL A B C S0 S1 VDD VSS Y
mp9 (\1\:Y \3\:n1 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=8.5e-07 sd=160n sca=20.5682 \
        scb=0.0225705 scc=0.000868063 m=(1)
mp7 (net202 \4\:C \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.72e-14 ps=7.5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.45e-07 sd=160n sca=13.1728 \
        scb=0.010661 scc=9.76612e-05 m=(1)
mp8 (\9\:n1 \2\:S1b net202 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.73e-14 ps=5.9e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=5.2e-07 sd=160n sca=11.7475 \
        scb=0.00853026 scc=7.76573e-05 m=(1)
mp6 (\5\:n0 \6\:S1 \9\:n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.483e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.55e-07 sd=160n sca=10.4608 \
        scb=0.00746151 scc=7.53855e-05 m=(1)
mp1 (\5\:S1b \1\:S1 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp4 (net190 \1\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.762e-14 ps=7.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=8.95e-07 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.762e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=6.75e-07 sd=160n sca=10.666 \
        scb=0.00755422 scc=7.54245e-05 m=(1)
mp2 (net189 \1\:A \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.407e-14 ps=8.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.25e-07 sd=160n sca=12.2076 \
        scb=0.00914458 scc=8.10906e-05 m=(1)
mp0 (\5\:S0b \4\:S0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.085e-14 ps=8.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.9e-07 sd=160n sca=17.7662 \
        scb=0.0185292 scc=0.000446955 m=(1)
C1 (A VSS) capacitor c=3.29042e-17
C2 (Y VSS) capacitor c=8.03123e-17
C3 (C VSS) capacitor c=6.34375e-17
C4 (B VSS) capacitor c=3.63148e-17
C5 (S0 VSS) capacitor c=7.83268e-17
C6 (VDD VSS) capacitor c=2.50226e-16
C7 (S1 VSS) capacitor c=6.61442e-17
C8 (n1 VSS) capacitor c=2.77287e-17
C9 (n0 VSS) capacitor c=1.08494e-16
C10 (S1b VSS) capacitor c=5.52384e-17
C11 (net234 VSS) capacitor c=6.47174e-18
C12 (S0b VSS) capacitor c=3.99777e-17
C13 (net202 VSS) capacitor c=1.41866e-18
C14 (net190 VSS) capacitor c=5.16041e-18
C15 (\4\:S0 VSS) capacitor c=3.34389e-17
C16 (\1\:A VSS) capacitor c=5.43029e-17
C17 (\1\:S0 VSS) capacitor c=4.86951e-17
C18 (\1\:B VSS) capacitor c=6.47171e-17
C19 (\1\:S1 VSS) capacitor c=3.39327e-17
C20 (\6\:S1 VSS) capacitor c=3.29887e-17
C21 (\2\:S1b VSS) capacitor c=4.82232e-17
C22 (\4\:C VSS) capacitor c=6.80162e-17
C23 (\3\:n1 VSS) capacitor c=5.56952e-17
C24 (\6\:S0 VSS) capacitor c=4.8499e-17
C25 (\3\:A VSS) capacitor c=4.25305e-17
C26 (\3\:S0b VSS) capacitor c=4.84332e-17
C27 (\3\:S0 VSS) capacitor c=4.96652e-17
C28 (\4\:B VSS) capacitor c=3.69891e-17
C29 (\5\:S1 VSS) capacitor c=6.03532e-17
C30 (\3\:S1b VSS) capacitor c=3.39651e-17
C31 (\4\:S1 VSS) capacitor c=5.7252e-17
C32 (\1\:C VSS) capacitor c=5.00236e-17
C33 (\5\:S0 VSS) capacitor c=4.72226e-17
C34 (\2\:A VSS) capacitor c=5.6199e-17
C35 (\4\:S0b VSS) capacitor c=4.27543e-17
C36 (\2\:S0 VSS) capacitor c=7.34506e-17
C37 (\2\:S0b VSS) capacitor c=4.0019e-17
C38 (\3\:B VSS) capacitor c=2.21784e-17
C39 (\2\:S1 VSS) capacitor c=5.58581e-17
C40 (\4\:S1b VSS) capacitor c=2.61913e-17
C41 (\3\:C VSS) capacitor c=6.99393e-17
C42 (\5\:S0b VSS) capacitor c=5.99727e-17
C43 (\7\:VDD VSS) capacitor c=2.5699e-17
C44 (\7\:n0 VSS) capacitor c=3.31436e-17
C45 (\9\:VDD VSS) capacitor c=3.55145e-17
C46 (\5\:S1b VSS) capacitor c=8.47815e-17
C47 (\5\:n0 VSS) capacitor c=3.09108e-17
C48 (\9\:n1 VSS) capacitor c=8.08269e-17
C49 (\11\:VDD VSS) capacitor c=2.46917e-17
C50 (\1\:Y VSS) capacitor c=6.56396e-17
C51 (\1\:VDD VSS) capacitor c=4.92731e-17
C52 (\10\:S0b VSS) capacitor c=1.66242e-17
C53 (\10\:S1b VSS) capacitor c=8.32587e-17
C54 (\9\:n0 VSS) capacitor c=1.10202e-16
C55 (\5\:n1 VSS) capacitor c=5.96039e-17
C56 (\2\:n1 VSS) capacitor c=6.38891e-17
C57 (\3\:S1 VSS) capacitor c=7.60802e-17
C58 (\2\:B VSS) capacitor c=3.5378e-17
C59 (\5\:C VSS) capacitor c=7.30431e-17
C60 (\7\:n1 VSS) capacitor c=6.01785e-17
C61 (\8\:n1 VSS) capacitor c=4.76281e-17
C62 (\7\:S1b VSS) capacitor c=9.01094e-17
C63 (\8\:S1b VSS) capacitor c=3.16113e-17
C64 (\9\:S1b VSS) capacitor c=1.15561e-16
C65 (\7\:S1 VSS) capacitor c=7.01813e-17
C66 (\5\:B VSS) capacitor c=1.0304e-16
C67 (\3\:n0 VSS) capacitor c=1.51396e-16
C68 (\4\:n0 VSS) capacitor c=1.14033e-16
C69 (\8\:S0 VSS) capacitor c=9.42079e-17
C70 (\4\:A VSS) capacitor c=8.47502e-17
C71 (\7\:S0b VSS) capacitor c=7.7084e-17
C72 (\8\:S0b VSS) capacitor c=1.20408e-16
C73 (\9\:S0b VSS) capacitor c=7.92428e-17
C74 (\3\:VDD VSS) capacitor c=1.96376e-17
C75 (\4\:VDD VSS) capacitor c=2.8489e-17
C76 (\6\:VDD VSS) capacitor c=2.51179e-17
Rk20 (A \4\:A) resistor r=0.05447 c=0
Rk1 (\2\:Y Y) resistor r=0.5594 c=0
Rk2 (Y \4\:Y) resistor r=0.002711 c=0
Rk3 (\5\:C C) resistor r=0.1532 c=0
Rk12 (B \5\:B) resistor r=0.02911 c=0
Rk18 (\7\:S0 S0) resistor r=0.003006 c=0
Rk19 (S0 \8\:S0) resistor r=0.46 c=0
Rk33 (\2\:VSS \3\:VSS) resistor r=0.1077 c=0
Rk34 (\3\:VSS \4\:VSS) resistor r=0.4487 c=0
Rk35 (\4\:VSS \5\:VSS) resistor r=0.1453 c=0
Rk37 (\6\:VSS VSS) resistor r=0.13 c=0
Rk36 (\5\:VSS \6\:VSS) resistor r=0.4213 c=0
Rk38 (\3\:VSS \8\:VSS) resistor r=0.2585 c=0
Rk39 (\4\:VSS \10\:VSS) resistor r=0.2707 c=0
Rk40 (\6\:VSS \12\:VSS) resistor r=0.2802 c=0
Rk25 (\2\:VDD \3\:VDD) resistor r=0.1077 c=0
Rk26 (\3\:VDD \4\:VDD) resistor r=0.4487 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.1453 c=0
Rk29 (\6\:VDD VDD) resistor r=0.12 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.4313 c=0
Rk30 (\3\:VDD \8\:VDD) resistor r=0.1948 c=0
Rk31 (\4\:VDD \10\:VDD) resistor r=0.1993 c=0
Rk32 (\6\:VDD \12\:VDD) resistor r=0.2182 c=0
Rk11 (S1 \7\:S1) resistor r=0.2063 c=0
Rk4 (\6\:n1 \7\:n1) resistor r=0.2815 c=0
Rk5 (\7\:n1 \8\:n1) resistor r=0.1706 c=0
Rk6 (\7\:n1 \10\:n1) resistor r=0.4986 c=0
Rk13 (\2\:n0 \3\:n0) resistor r=0.7347 c=0
Rk14 (\3\:n0 \4\:n0) resistor r=0.3683 c=0
Rk15 (\4\:n0 \6\:n0) resistor r=0.1019 c=0
Rk16 (\3\:n0 \8\:n0) resistor r=0.2158 c=0
Rk17 (\4\:n0 \10\:n0) resistor r=0.5591 c=0
Rk7 (\6\:S1b \7\:S1b) resistor r=0.5426 c=0
Rk8 (\7\:S1b \8\:S1b) resistor r=0.1133 c=0
Rk9 (\7\:S1b \9\:S1b) resistor r=0.3033 c=0
Rk10 (\9\:S1b \11\:S1b) resistor r=0.6316 c=0
Rk21 (\6\:S0b \7\:S0b) resistor r=0.4896 c=0
Rk22 (\7\:S0b \8\:S0b) resistor r=0.4543 c=0
Rk23 (\8\:S0b \9\:S0b) resistor r=0.4612 c=0
Rk24 (\7\:S0b \11\:S0b) resistor r=0.1248 c=0
Rl21 (\1\:A \2\:A) resistor r=164.617 c=0
Rl22 (\2\:A \3\:A) resistor r=89.6174 c=0
Rl6 (\2\:C \4\:C) resistor r=145.872 c=0
Rl4 (\1\:C \2\:C) resistor r=115.103 c=0
Rl5 (\2\:C \3\:C) resistor r=7.2644 c=0
Rl14 (\1\:B \2\:B) resistor r=195.868 c=0
Rl16 (\2\:B \4\:B) resistor r=78.5603 c=0
Rl15 (\2\:B \3\:B) resistor r=4.3144 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=62.2302 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=194.923 c=0
Rl18 (\1\:S0 \2\:S0) resistor r=133.848 c=0
Rl19 (\2\:S0 \3\:S0) resistor r=148.616 c=0
Rl9 (\1\:S1 \2\:S1) resistor r=78.8233 c=0
Rl12 (\2\:S1 \5\:S1) resistor r=180.13 c=0
Rl13 (\3\:S1 \6\:S1) resistor r=56.9258 c=0
Rl11 (\3\:S1 \4\:S1) resistor r=244.953 c=0
Rl10 (\2\:S1 \3\:S1) resistor r=162.376 c=0
Rl2 (\2\:n1 \3\:n1) resistor r=218.949 c=0
Rl1 (n1 \2\:n1) resistor r=42.0262 c=0
Rl3 (\2\:n1 \4\:n1) resistor r=7.2644 c=0
Rl8 (\3\:S1b \4\:S1b) resistor r=48.7687 c=0
Rl7 (S1b \2\:S1b) resistor r=60.5801 c=0
Rl20 (\3\:S0b \4\:S0b) resistor r=48.7687 c=0
Rl17 (S0b \2\:S0b) resistor r=68.2278 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz2 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz6 (\10\:S0b \11\:S0b) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry10 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry11 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry2 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry5 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry6 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx9 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx6 (\3\:B \5\:B) resistor r=45 c=0
Rx7 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx8 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx5 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx2 (\4\:n1 \8\:n1) resistor r=45 c=0
Rx3 (S1b \8\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\3\:Y n1 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=8.65e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn7 (net245 \1\:C \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=6.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn8 (\5\:n1 \4\:S1 net245 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.335e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn6 (\5\:n1 \3\:S1b \9\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.335e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.85e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\10\:S1b \5\:S1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn4 (net234 \4\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.262e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.262e-14 ad=2.392e-14 ps=7.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=8.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.392e-14 ps=6.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=6.35e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (net229 \3\:A \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.392e-14 ps=6.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.25e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\10\:S0b \6\:S0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.755e-14 ps=6.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.9e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
ends MX3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:57 2013 )
// Library name: gsclib045_hvt
// Cell name: MX4X1
// View name: extracted

simulator lang=spectre

subckt MX4X1 A B C D S0 S1 VDD VSS Y
mp12 (\1\:Y n2 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=5.46e-14 ps=1.41e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.38462e-07 sd=160n sca=26.2357 \
        scb=0.0296246 scc=0.00188388 m=(1)
C1 (S1 VSS) capacitor c=3.50601e-17
C2 (B VSS) capacitor c=7.95876e-17
C3 (S0 VSS) capacitor c=5.66056e-17
C4 (VDD VSS) capacitor c=2.79045e-16
C5 (C VSS) capacitor c=4.91679e-17
C6 (D VSS) capacitor c=5.23358e-17
C7 (A VSS) capacitor c=1.42792e-16
C8 (n2 VSS) capacitor c=4.84138e-17
C9 (S1b VSS) capacitor c=4.63968e-17
C10 (n1 VSS) capacitor c=4.70416e-17
C11 (n0 VSS) capacitor c=7.0575e-17
C12 (n9 VSS) capacitor c=1.7621e-18
C13 (S0b VSS) capacitor c=6.17517e-17
C14 (n5 VSS) capacitor c=1.40393e-18
C15 (n3 VSS) capacitor c=1.13596e-18
C16 (n10 VSS) capacitor c=2.34734e-18
C17 (n8 VSS) capacitor c=4.79338e-18
C18 (n6 VSS) capacitor c=5.26964e-18
C19 (n4 VSS) capacitor c=2.08453e-18
C20 (\7\:S0 VSS) capacitor c=2.83561e-17
C21 (\1\:A VSS) capacitor c=5.63138e-17
C22 (\4\:S0 VSS) capacitor c=3.07022e-17
C23 (\5\:S0b VSS) capacitor c=4.39852e-17
C24 (\1\:B VSS) capacitor c=4.24262e-17
C25 (\3\:C VSS) capacitor c=4.08658e-17
C26 (\2\:S0 VSS) capacitor c=5.2736e-17
C27 (\2\:S0b VSS) capacitor c=5.95993e-17
C28 (\4\:D VSS) capacitor c=4.13629e-17
C29 (\1\:S1 VSS) capacitor c=5.17402e-17
C30 (\6\:S1 VSS) capacitor c=3.2518e-17
C31 (\9\:S0 VSS) capacitor c=4.16839e-17
C32 (\3\:A VSS) capacitor c=3.41034e-17
C33 (\7\:S0b VSS) capacitor c=6.39369e-17
C34 (\6\:S0 VSS) capacitor c=8.22765e-17
C35 (\3\:B VSS) capacitor c=4.27794e-17
C36 (\1\:C VSS) capacitor c=6.77652e-17
C37 (\3\:S0b VSS) capacitor c=6.40149e-17
C38 (\1\:S0 VSS) capacitor c=8.96166e-17
C39 (\1\:D VSS) capacitor c=7.23635e-17
C40 (\3\:S1b VSS) capacitor c=3.93298e-17
C41 (\4\:S1 VSS) capacitor c=2.84763e-17
C42 (\5\:S1 VSS) capacitor c=2.11525e-17
C43 (\3\:n2 VSS) capacitor c=2.80521e-17
C44 (\8\:S0 VSS) capacitor c=3.43276e-17
C45 (\2\:A VSS) capacitor c=5.10767e-17
C46 (\5\:S0 VSS) capacitor c=6.91367e-17
C47 (\8\:S0b VSS) capacitor c=2.28481e-17
C48 (\6\:S0b VSS) capacitor c=4.45725e-17
C49 (\2\:B VSS) capacitor c=4.47178e-17
C50 (\2\:C VSS) capacitor c=5.23247e-17
C51 (\4\:S0b VSS) capacitor c=4.34835e-17
C52 (\3\:S0 VSS) capacitor c=2.64212e-17
C53 (\3\:D VSS) capacitor c=1.88976e-17
C54 (\4\:S1b VSS) capacitor c=2.7409e-17
C55 (\2\:S1b VSS) capacitor c=1.88762e-17
C56 (\3\:S1 VSS) capacitor c=4.55952e-17
C57 (\2\:n2 VSS) capacitor c=2.89928e-17
C58 (\15\:S0b VSS) capacitor c=9.45691e-17
C59 (\1\:VDD VSS) capacitor c=4.9544e-17
C60 (\3\:n0 VSS) capacitor c=2.48479e-16
C61 (\9\:VDD VSS) capacitor c=2.39945e-17
C62 (\4\:n1 VSS) capacitor c=7.91763e-17
C63 (\11\:VDD VSS) capacitor c=3.61237e-17
C64 (\5\:n0 VSS) capacitor c=2.41242e-16
C65 (\5\:n2 VSS) capacitor c=2.60036e-16
C66 (\8\:n1 VSS) capacitor c=7.88815e-17
C67 (\7\:S1b VSS) capacitor c=1.12093e-16
C68 (\13\:VDD VSS) capacitor c=5.18424e-17
C69 (\1\:Y VSS) capacitor c=5.52783e-17
C70 (\3\:VDD VSS) capacitor c=8.57312e-17
C71 (\9\:S0b VSS) capacitor c=1.35985e-16
C72 (\7\:n0 VSS) capacitor c=8.46263e-17
C73 (\7\:n2 VSS) capacitor c=7.9201e-17
C74 (\6\:n1 VSS) capacitor c=1.49394e-16
C75 (\5\:S1b VSS) capacitor c=9.30989e-17
C76 (\3\:Y VSS) capacitor c=6.64421e-17
C77 (\2\:S1 VSS) capacitor c=5.61224e-17
C78 (\2\:D VSS) capacitor c=3.86182e-17
C79 (\7\:S1 VSS) capacitor c=7.47471e-17
C80 (\4\:n2 VSS) capacitor c=2.3664e-16
C81 (\9\:S1b VSS) capacitor c=1.16409e-16
C82 (\10\:S1b VSS) capacitor c=1.16244e-16
C83 (\5\:D VSS) capacitor c=6.63032e-17
C84 (\3\:n1 VSS) capacitor c=1.69974e-16
C85 (\4\:C VSS) capacitor c=6.45547e-17
C86 (\4\:B VSS) capacitor c=3.51502e-17
C87 (\10\:S0 VSS) capacitor c=1.72451e-16
C88 (\11\:S0 VSS) capacitor c=1.49324e-16
C89 (\12\:S0 VSS) capacitor c=4.98943e-17
C90 (\11\:S0b VSS) capacitor c=1.22209e-16
C91 (\12\:S0b VSS) capacitor c=7.00078e-17
C92 (\13\:S0b VSS) capacitor c=6.31072e-17
C93 (\14\:S0b VSS) capacitor c=5.12574e-17
C94 (\17\:S0b VSS) capacitor c=2.98176e-17
C95 (\5\:VDD VSS) capacitor c=3.64182e-17
C96 (\6\:VDD VSS) capacitor c=2.51485e-17
C97 (\8\:VDD VSS) capacitor c=1.50767e-17
Rk29 (\2\:VSS \4\:VSS) resistor r=0.3913 c=0
Rk30 (\4\:VSS \5\:VSS) resistor r=0.2783 c=0
Rk31 (\5\:VSS \6\:VSS) resistor r=0.3408 c=0
Rk32 (\6\:VSS \7\:VSS) resistor r=0.484 c=0
Rk34 (\8\:VSS VSS) resistor r=0.1024 c=0
Rk33 (\7\:VSS \8\:VSS) resistor r=0.4489 c=0
Rk35 (\5\:VSS \10\:VSS) resistor r=0.292 c=0
Rk36 (\6\:VSS \12\:VSS) resistor r=0.2035 c=0
Rk37 (\8\:VSS \14\:VSS) resistor r=0.2016 c=0
Rk3 (\7\:S1 S1) resistor r=0.05938 c=0
Rk15 (\4\:B B) resistor r=0.0927 c=0
Rk20 (\10\:S0 \11\:S0) resistor r=1.1716 c=0
Rk22 (\12\:S0 S0) resistor r=0.1892 c=0
Rk21 (\11\:S0 \12\:S0) resistor r=0.2512 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.5672 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.2924 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.4452 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.3636 c=0
Rk43 (\8\:VDD VDD) resistor r=0.1175 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.4338 c=0
Rk44 (\5\:VDD \10\:VDD) resistor r=0.04333 c=0
Rk45 (\6\:VDD \12\:VDD) resistor r=0.235 c=0
Rk46 (\8\:VDD \14\:VDD) resistor r=0.3147 c=0
Rk14 (\4\:C C) resistor r=0.2112 c=0
Rk9 (\5\:D D) resistor r=0.1182 c=0
Rk19 (\4\:A A) resistor r=0.02718 c=0
Rk1 (\2\:Y Y) resistor r=0.4944 c=0
Rk2 (Y \4\:Y) resistor r=0.003006 c=0
Rk4 (\4\:n2 \6\:n2) resistor r=1.7328 c=0
Rk5 (\6\:n2 \8\:n2) resistor r=0.3971 c=0
Rk6 (\6\:S1b \8\:S1b) resistor r=0.551 c=0
Rk7 (\8\:S1b \9\:S1b) resistor r=0.5008 c=0
Rk8 (\9\:S1b \10\:S1b) resistor r=0.6589 c=0
Rk10 (\2\:n1 \3\:n1) resistor r=0.2905 c=0
Rk11 (\3\:n1 \5\:n1) resistor r=0.4164 c=0
Rk12 (\3\:n1 \7\:n1) resistor r=0.9758 c=0
Rk13 (\7\:n1 \9\:n1) resistor r=0.3686 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.4084 c=0
Rk17 (\4\:n0 \6\:n0) resistor r=1.5563 c=0
Rk18 (\6\:n0 \8\:n0) resistor r=0.4897 c=0
Rk23 (\10\:S0b \11\:S0b) resistor r=0.6473 c=0
Rk24 (\11\:S0b \12\:S0b) resistor r=0.5164 c=0
Rk25 (\12\:S0b \13\:S0b) resistor r=0.3326 c=0
Rk26 (\13\:S0b \14\:S0b) resistor r=0.2974 c=0
Rk27 (\10\:S0b \16\:S0b) resistor r=0.8032 c=0
Rk28 (\12\:S0b \17\:S0b) resistor r=0.08726 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=101.718 c=0
Rl7 (\3\:S1 \5\:S1) resistor r=36.3335 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=124.543 c=0
Rl6 (\2\:S1 \4\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=248.466 c=0
Rl19 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl20 (\2\:B \3\:B) resistor r=108.384 c=0
Rl14 (\1\:S0 \2\:S0) resistor r=161.909 c=0
Rl27 (\7\:S0 \8\:S0) resistor r=29.5379 c=0
Rl28 (\8\:S0 \9\:S0) resistor r=108.384 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=24.2328 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=195.274 c=0
Rl15 (\2\:S0 \3\:S0) resistor r=58.3841 c=0
Rl18 (\2\:C \3\:C) resistor r=30.2198 c=0
Rl17 (\1\:C \2\:C) resistor r=109.615 c=0
Rl12 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl10 (\1\:D \2\:D) resistor r=202.291 c=0
Rl11 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl25 (\1\:A \2\:A) resistor r=94.0258 c=0
Rl26 (\2\:A \3\:A) resistor r=44.208 c=0
Rl1 (n2 \2\:n2) resistor r=110.771 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=33.8482 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=26.1559 c=0
Rl3 (S1b \2\:S1b) resistor r=58.3841 c=0
Rl22 (\7\:S0b \8\:S0b) resistor r=56.9251 c=0
Rl21 (\5\:S0b \6\:S0b) resistor r=58.3841 c=0
Rl16 (\3\:S0b \4\:S0b) resistor r=33.8482 c=0
Rl13 (S0b \2\:S0b) resistor r=84.5926 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:n2 \8\:n2) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (n0 \2\:n0) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz8 (\9\:S0b \10\:S0b) resistor r=75 c=0
Ry9 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry10 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\5\:n2 \6\:n2) resistor r=62 c=0
Ry3 (\7\:S1b \8\:S1b) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry6 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry7 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry8 (\15\:S0b \16\:S0b) resistor r=62 c=0
Rx1 (\3\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx9 (\3\:S0 \10\:S0) resistor r=45 c=0
Rx10 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx11 (\8\:S0 \12\:S0) resistor r=45 c=0
Rx6 (\2\:C \4\:C) resistor r=45 c=0
Rx5 (\3\:D \5\:D) resistor r=45 c=0
Rx8 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:n2 \4\:n2) resistor r=45 c=0
Rx3 (\2\:S1b \9\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \10\:S1b) resistor r=45 c=0
Rx12 (\8\:S0b \11\:S0b) resistor r=45 c=0
Rx13 (\4\:S0b \13\:S0b) resistor r=45 c=0
Rx14 (S0b \14\:S0b) resistor r=45 c=0
Rx15 (\6\:S0b \17\:S0b) resistor r=45 c=0
mn12 (\3\:Y \3\:n2 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.177e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.51923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\5\:S1b \5\:S1 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.177e-14 ad=2.32e-14 ps=1.15e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.6e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (\7\:n2 \4\:S1 \6\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn10 (\7\:n2 \3\:S1b \7\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn8 (n9 \1\:D \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=8.7e-15 ps=8.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.675e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn9 (n1 \1\:S0 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.57e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn7 (n1 \3\:S0b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=1.365e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn6 (n7 \1\:C \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.26e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (n5 \3\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.755e-14 ps=6.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.055e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (n0 \6\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.755e-14 \
        ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.025e-06 sb=8.2e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn3 (n0 \7\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.393e-14 \
        ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.23e-06 sb=6.15e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn2 (n3 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.393e-14 ps=9.9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=4.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\9\:S0b \9\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp1 (\7\:S1b \6\:S1 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=1.4e-07 sd=160n sca=21.1359 scb=0.020206 \
        scc=0.00179608 m=(1)
mp11 (\8\:n1 S1b \5\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp10 (\5\:n2 \1\:S1 \5\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp8 (n10 \4\:D \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.505e-14 ps=1.17e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.945e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp9 (\4\:n1 \2\:S0b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.73e-14 ps=5.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.83e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp7 (\4\:n1 \2\:S0 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.565e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp6 (n8 \3\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.093e-14 ad=3.977e-14 ps=1.92e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.335e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp4 (n6 \1\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.093e-14 ad=3.44e-14 ps=1.92e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.055e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp5 (\3\:n0 \5\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.805e-14 ps=7.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=8.5e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp3 (\3\:n0 \4\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=5.805e-14 ps=7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58e-06 sb=5.35e-07 sd=160n sca=21.2369 \
        scb=0.0203411 scc=0.00208843 m=(1)
mp2 (n4 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=2.902e-14 ps=7.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=3.55e-07 sd=160n sca=21.7372 \
        scb=0.0205342 scc=0.0020885 m=(1)
mp0 (\15\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.01e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=1.4e-07 sd=160n sca=23.0263 \
        scb=0.0218192 scc=0.0020924 m=(1)
ends MX4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:58 2013 )
// Library name: gsclib045_hvt
// Cell name: MX4X2
// View name: extracted

simulator lang=spectre

subckt MX4X2 A B C D S0 S1 VDD VSS Y
mp10 (\9\:n2 \4\:S1 \4\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=3.45e-07 sd=160n sca=44.5479 \
        scb=0.0294091 scc=0.00553812 m=(1)
mp11 (\5\:n1 \5\:S1b \9\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.4e-07 sd=160n sca=43.2688 \
        scb=0.0280932 scc=0.00553387 m=(1)
mp1 (\8\:S1b \1\:S1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.093e-13 ad=3.01e-14 ps=2.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.6e-07 sd=160n sca=42.6522 \
        scb=0.0278545 scc=0.00553378 m=(1)
mp2 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0353e-13 ad=4.73e-14 ps=1.7e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.12674e-07 sb=2e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp3 (\6\:n0 \1\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.515e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.77674e-07 sb=2e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp5 (\6\:n0 S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.408e-14 \
        ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.13267e-06 sb=2e-06 sd=160n sca=10.9013 scb=0.00874909 \
        scc=0.000160703 m=(1)
mp4 (n6 \3\:B \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1745e-13 ad=4.408e-14 ps=1.77e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38267e-06 sb=1.86e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp6 (n8 \1\:C \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1745e-13 ad=3.763e-14 ps=1.77e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81767e-06 sb=1.425e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp7 (\7\:n1 \8\:S0 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=9.783e-14 ps=7.8e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.93349e-06 sb=1.205e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp9 (\7\:n1 \6\:S0b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=9.783e-14 ps=5.7e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.05e-07 sd=160n sca=11.0244 \
        scb=0.00877578 scc=0.000160706 m=(1)
mp8 (n10 \1\:D \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.708e-14 ad=1.505e-14 ps=1.24e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.9e-07 sd=160n sca=11.3376 scb=0.00888972 \
        scc=0.00016074 m=(1)
mp0 (\8\:S0b \9\:S0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.708e-14 ad=3.01e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=16.2936 scb=0.0162078 \
        scc=0.00030445 m=(1)
C1 (S1 VSS) capacitor c=3.03135e-17
C2 (C VSS) capacitor c=5.89194e-17
C3 (S0 VSS) capacitor c=5.05854e-17
C4 (VDD VSS) capacitor c=3.64229e-16
C5 (B VSS) capacitor c=5.35605e-17
C6 (D VSS) capacitor c=7.52301e-17
C7 (A VSS) capacitor c=4.53854e-17
C8 (Y VSS) capacitor c=4.17646e-17
C9 (n2 VSS) capacitor c=1.66162e-16
C10 (S1b VSS) capacitor c=3.27637e-17
C11 (n0 VSS) capacitor c=1.38309e-16
C12 (n1 VSS) capacitor c=3.5461e-16
C13 (n3 VSS) capacitor c=7.21662e-18
C14 (S0b VSS) capacitor c=2.59494e-17
C15 (n5 VSS) capacitor c=4.71508e-19
C16 (n7 VSS) capacitor c=1.02499e-17
C17 (n4 VSS) capacitor c=8.22888e-18
C18 (n6 VSS) capacitor c=5.22066e-18
C19 (n10 VSS) capacitor c=1.44701e-19
C20 (\9\:S0 VSS) capacitor c=3.72407e-17
C21 (\1\:D VSS) capacitor c=6.17538e-17
C22 (\6\:S0b VSS) capacitor c=5.12034e-17
C23 (\8\:S0 VSS) capacitor c=3.77279e-17
C24 (\1\:C VSS) capacitor c=3.72744e-17
C25 (\3\:B VSS) capacitor c=3.00478e-17
C26 (\1\:S0 VSS) capacitor c=3.64099e-17
C27 (\1\:A VSS) capacitor c=4.9018e-17
C28 (\1\:S1 VSS) capacitor c=4.18059e-17
C29 (\5\:S1b VSS) capacitor c=3.46653e-17
C30 (\4\:S1 VSS) capacitor c=6.02821e-17
C31 (\11\:S0 VSS) capacitor c=1.95059e-17
C32 (\3\:D VSS) capacitor c=4.02086e-17
C33 (\5\:S0 VSS) capacitor c=3.20619e-17
C34 (\4\:S0b VSS) capacitor c=4.05942e-17
C35 (\3\:C VSS) capacitor c=4.02775e-17
C36 (\1\:B VSS) capacitor c=8.20868e-17
C37 (\3\:S0 VSS) capacitor c=6.58262e-17
C38 (\3\:S0b VSS) capacitor c=5.39876e-17
C39 (\3\:A VSS) capacitor c=2.84391e-17
C40 (\5\:S1 VSS) capacitor c=2.38565e-17
C41 (\6\:S1 VSS) capacitor c=2.28106e-17
C42 (\10\:S0 VSS) capacitor c=2.88049e-17
C43 (\2\:D VSS) capacitor c=4.59045e-17
C44 (\7\:S0b VSS) capacitor c=3.46285e-17
C45 (\6\:S0 VSS) capacitor c=6.65703e-17
C46 (\5\:S0b VSS) capacitor c=3.80151e-17
C47 (\7\:S0 VSS) capacitor c=6.40273e-17
C48 (\2\:C VSS) capacitor c=4.69178e-17
C49 (\2\:B VSS) capacitor c=4.41742e-17
C50 (\4\:S0 VSS) capacitor c=4.14976e-17
C51 (\2\:S0b VSS) capacitor c=4.7716e-17
C52 (\2\:S0 VSS) capacitor c=3.16081e-17
C53 (\2\:A VSS) capacitor c=3.29075e-17
C54 (\2\:S1 VSS) capacitor c=5.61893e-17
C55 (\3\:S1b VSS) capacitor c=4.4254e-17
C56 (\4\:S1b VSS) capacitor c=4.82849e-17
C57 (\2\:S1b VSS) capacitor c=2.34723e-17
C58 (\8\:S0b VSS) capacitor c=8.8745e-18
C59 (\9\:VDD VSS) capacitor c=4.33854e-17
C60 (\7\:n1 VSS) capacitor c=1.17298e-16
C61 (\11\:VDD VSS) capacitor c=3.24796e-17
C62 (\6\:n0 VSS) capacitor c=3.2839e-17
C63 (\1\:Y VSS) capacitor c=7.1067e-17
C64 (\8\:S1b VSS) capacitor c=5.80819e-17
C65 (\5\:n1 VSS) capacitor c=8.90701e-17
C66 (\9\:n2 VSS) capacitor c=1.88379e-16
C67 (\4\:n0 VSS) capacitor c=2.18826e-16
C68 (\1\:VDD VSS) capacitor c=8.62528e-17
C69 (\14\:S0b VSS) capacitor c=5.73979e-17
C70 (\3\:Y VSS) capacitor c=3.32595e-17
C71 (\11\:S1b VSS) capacitor c=6.33625e-17
C72 (\3\:n1 VSS) capacitor c=3.41271e-16
C73 (\11\:n2 VSS) capacitor c=9.15842e-17
C74 (\8\:n0 VSS) capacitor c=6.20326e-17
C75 (\3\:S1 VSS) capacitor c=5.68542e-17
C76 (\6\:S1b VSS) capacitor c=1.47833e-16
C77 (\7\:S1b VSS) capacitor c=1.1811e-16
C78 (\10\:S1b VSS) capacitor c=5.73696e-17
C79 (\7\:S1 VSS) capacitor c=7.88409e-17
C80 (\8\:n2 VSS) capacitor c=1.49059e-16
C81 (\4\:A VSS) capacitor c=5.1485e-17
C82 (\3\:n0 VSS) capacitor c=2.81283e-16
C83 (\4\:B VSS) capacitor c=5.65839e-17
C84 (\4\:C VSS) capacitor c=2.45936e-17
C85 (\12\:S0 VSS) capacitor c=8.24824e-17
C86 (\13\:S0 VSS) capacitor c=9.20341e-17
C87 (\14\:S0 VSS) capacitor c=6.9139e-17
C88 (\4\:D VSS) capacitor c=4.4904e-17
C89 (\15\:S0 VSS) capacitor c=6.35834e-17
C90 (\16\:S0 VSS) capacitor c=7.79906e-17
C91 (\10\:S0b VSS) capacitor c=7.45014e-17
C92 (\11\:S0b VSS) capacitor c=1.07957e-16
C93 (\12\:S0b VSS) capacitor c=1.75561e-16
C94 (\13\:S0b VSS) capacitor c=1.33944e-16
C95 (\16\:S0b VSS) capacitor c=2.47153e-17
C96 (\17\:S0b VSS) capacitor c=9.53017e-17
C97 (\3\:VDD VSS) capacitor c=2.72385e-17
C98 (\5\:VDD VSS) capacitor c=4.12621e-17
C99 (\6\:VDD VSS) capacitor c=1.05216e-16
Rk4 (S1 \7\:S1) resistor r=0.01942 c=0
Rk15 (\4\:C C) resistor r=0.09804 c=0
Rk16 (\12\:S0 \13\:S0) resistor r=0.5455 c=0
Rk17 (\13\:S0 \14\:S0) resistor r=0.4359 c=0
Rk22 (S0 \15\:S0) resistor r=0.143 c=0
Rk23 (\15\:S0 \16\:S0) resistor r=0.4525 c=0
Rk31 (\2\:VDD \3\:VDD) resistor r=0.2932 c=0
Rk32 (\3\:VDD \4\:VDD) resistor r=0.3584 c=0
Rk33 (\4\:VDD \5\:VDD) resistor r=0.2622 c=0
Rk34 (\5\:VDD \6\:VDD) resistor r=0.6056 c=0
Rk37 (\8\:VDD VDD) resistor r=0.5515 c=0
Rk36 (\6\:VDD \8\:VDD) resistor r=0.1117 c=0
Rk38 (\3\:VDD \10\:VDD) resistor r=0.2729 c=0
Rk39 (\5\:VDD \12\:VDD) resistor r=0.04331 c=0
Rk14 (B \4\:B) resistor r=0.01225 c=0
Rk21 (D \4\:D) resistor r=0.01986 c=0
Rk9 (\4\:A A) resistor r=0.1913 c=0
Rk7 (\2\:Y Y) resistor r=0.1971 c=0
Rk8 (Y \4\:Y) resistor r=0.1065 c=0
Rk42 (\2\:VSS \3\:VSS) resistor r=0.3083 c=0
Rk43 (\3\:VSS \4\:VSS) resistor r=0.3434 c=0
Rk44 (\4\:VSS \5\:VSS) resistor r=0.2155 c=0
Rk45 (\5\:VSS \6\:VSS) resistor r=0.5664 c=0
Rk48 (\8\:VSS VSS) resistor r=0.5515 c=0
Rk47 (\6\:VSS \8\:VSS) resistor r=0.09009 c=0
Rk49 (\3\:VSS \10\:VSS) resistor r=0.2831 c=0
Rk50 (\5\:VSS \12\:VSS) resistor r=0.2007 c=0
Rk5 (\8\:n2 \10\:n2) resistor r=1.0286 c=0
Rk6 (\10\:n2 \12\:n2) resistor r=0.4267 c=0
Rk1 (\6\:S1b \7\:S1b) resistor r=0.8716 c=0
Rk2 (\9\:S1b \10\:S1b) resistor r=0.1566 c=0
Rk3 (\10\:S1b \12\:S1b) resistor r=0.1913 c=0
Rk10 (\2\:n0 \3\:n0) resistor r=0.8572 c=0
Rk11 (\3\:n0 \5\:n0) resistor r=1.6974 c=0
Rk12 (\3\:n0 \7\:n0) resistor r=0.1728 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.4869 c=0
Rk18 (\2\:n1 \4\:n1) resistor r=2.6238 c=0
Rk19 (\4\:n1 \6\:n1) resistor r=0.4302 c=0
Rk20 (\2\:n1 \8\:n1) resistor r=0.6204 c=0
Rk24 (\9\:S0b \10\:S0b) resistor r=0.04795 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.5069 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.4962 c=0
Rk27 (\12\:S0b \13\:S0b) resistor r=0.9893 c=0
Rk28 (\10\:S0b \15\:S0b) resistor r=0.5141 c=0
Rk29 (\11\:S0b \16\:S0b) resistor r=0.1247 c=0
Rk30 (\12\:S0b \17\:S0b) resistor r=0.5379 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=72.3097 c=0
Rl7 (\2\:S1 \5\:S1) resistor r=37.6944 c=0
Rl6 (\3\:S1 \4\:S1) resistor r=124.611 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=211.505 c=0
Rl23 (\1\:C \2\:C) resistor r=77.6148 c=0
Rl24 (\2\:C \3\:C) resistor r=123.769 c=0
Rl32 (\9\:S0 \10\:S0) resistor r=171.846 c=0
Rl33 (\10\:S0 \11\:S0) resistor r=29.5379 c=0
Rl27 (\5\:S0 \6\:S0) resistor r=26.1559 c=0
Rl29 (\7\:S0 \8\:S0) resistor r=116.54 c=0
Rl28 (\6\:S0 \7\:S0) resistor r=201.031 c=0
Rl20 (\3\:S0 \4\:S0) resistor r=39.1533 c=0
Rl17 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl22 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl21 (\1\:B \2\:B) resistor r=173.077 c=0
Rl30 (\1\:D \2\:D) resistor r=112.23 c=0
Rl31 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl15 (\1\:A \2\:A) resistor r=148.769 c=0
Rl16 (\2\:A \3\:A) resistor r=52.6149 c=0
Rl3 (\4\:S1b \5\:S1b) resistor r=26.1559 c=0
Rl2 (\3\:S1b \4\:S1b) resistor r=92.2733 c=0
Rl1 (S1b \2\:S1b) resistor r=29.5379 c=0
Rl26 (\6\:S0b \7\:S0b) resistor r=29.5379 c=0
Rl25 (\4\:S0b \5\:S0b) resistor r=39.1533 c=0
Rl18 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl19 (\2\:S0b \3\:S0b) resistor r=172.68 c=0
Rz9 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz10 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz11 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\4\:Y \3\:Y) resistor r=75 c=0
Rz12 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz2 (\12\:n2 \11\:n2) resistor r=75 c=0
Rz1 (\11\:S1b \12\:S1b) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz6 (n1 \2\:n1) resistor r=75 c=0
Rz7 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz8 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry9 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\2\:Y \1\:Y) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\10\:n2 \9\:n2) resistor r=62 c=0
Ry1 (\8\:S1b \9\:S1b) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry7 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry8 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx4 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx9 (\7\:S0 \12\:S0) resistor r=45 c=0
Rx10 (\4\:S0 \13\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \14\:S0) resistor r=45 c=0
Rx13 (\10\:S0 \15\:S0) resistor r=45 c=0
Rx14 (\6\:S0 \16\:S0) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx6 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\8\:n2 n2) resistor r=45 c=0
Rx1 (\4\:S1b \6\:S1b) resistor r=45 c=0
Rx2 (\2\:S1b \7\:S1b) resistor r=45 c=0
Rx3 (\3\:S1b \10\:S1b) resistor r=45 c=0
Rx15 (\2\:S0b \13\:S0b) resistor r=45 c=0
Rx16 (\7\:S0b \16\:S0b) resistor r=45 c=0
Rx17 (\5\:S0b \17\:S0b) resistor r=45 c=0
mn10 (\11\:n2 S1b \8\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.553e-14 ps=6.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.45e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn11 (\11\:n2 \6\:S1 \3\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=3.553e-14 ps=8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\11\:S1b \5\:S1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0468e-13 ad=2.61e-14 ps=1.63e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn2 (n3 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.815e-14 ps=1.58e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn3 (n0 \3\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=6.815e-14 \
        ad=2.32e-14 ps=1.23e-06 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.665e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn5 (n0 \3\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.87e-06 sb=1.995e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn4 (n5 \1\:B \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.418e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=1.89e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (n7 \3\:C \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.418e-14 ad=5.148e-14 ps=1.22e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.51e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn7 (n1 \4\:S0b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=5.148e-14 \
        ad=3.045e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=1.11e-06 sd=160n sca=11.4452 scb=0.0112553 scc=0.00042156 m=(1)
mn9 (n1 \5\:S0 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.958e-14 \
        ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.55e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn8 (n9 \3\:D \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.873e-14 ad=1.958e-14 ps=1.1e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.75e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn0 (\14\:S0b \11\:S0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.873e-14 ad=3.263e-14 ps=1.1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn12_1__rcx (\3\:Y n2 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.0401e-13 ad=4.16e-14 ps=1.605e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33462e-07 sb=1.32769e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mp12 (\1\:Y n2 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0641e-13 ad=6.24e-14 ps=1.955e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17756e-07 sb=1.00038e-06 sd=160n sca=28.7024 \
        scb=0.0198217 scc=0.00315848 m=(2)
ends MX4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:16:59 2013 )
// Library name: gsclib045_hvt
// Cell name: MX4X4
// View name: extracted

simulator lang=spectre

subckt MX4X4 A B C D S0 S1 VDD VSS Y
mp10 (\17\:n2 \4\:S1 \4\:n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=3.7e-07 sd=160n sca=32.1279 \
        scb=0.0214025 scc=0.00336348 m=(1)
mp11 (\7\:n1 \3\:S1b \17\:n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.65e-07 sd=160n sca=31.0054 \
        scb=0.0203755 scc=0.00336103 m=(1)
mp12_1__rcx (Y n2 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.509e-14 ad=6.24e-14 ps=1.525e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=1.16763e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
C1 (S1 VSS) capacitor c=5.97094e-17
C2 (C VSS) capacitor c=5.2864e-17
C3 (S0 VSS) capacitor c=4.63725e-17
C4 (VDD VSS) capacitor c=3.52212e-16
C5 (B VSS) capacitor c=5.14754e-17
C6 (D VSS) capacitor c=4.77497e-17
C7 (A VSS) capacitor c=3.3173e-17
C8 (Y VSS) capacitor c=2.10679e-16
C9 (n2 VSS) capacitor c=2.78254e-16
C10 (S1b VSS) capacitor c=2.9089e-17
C11 (n0 VSS) capacitor c=1.44429e-16
C12 (n1 VSS) capacitor c=3.63391e-16
C13 (n3 VSS) capacitor c=5.43409e-18
C14 (S0b VSS) capacitor c=3.84525e-17
C15 (n5 VSS) capacitor c=1.48975e-18
C16 (n7 VSS) capacitor c=8.48361e-18
C17 (n9 VSS) capacitor c=7.08461e-20
C18 (n4 VSS) capacitor c=5.34832e-18
C19 (n6 VSS) capacitor c=5.45315e-18
C20 (n8 VSS) capacitor c=1.14135e-17
C21 (\10\:S0 VSS) capacitor c=3.71468e-17
C22 (\1\:D VSS) capacitor c=5.4382e-17
C23 (\6\:S0b VSS) capacitor c=5.36646e-17
C24 (\9\:S0 VSS) capacitor c=3.77538e-17
C25 (\3\:C VSS) capacitor c=3.90582e-17
C26 (\3\:B VSS) capacitor c=4.75264e-17
C27 (\1\:S0 VSS) capacitor c=3.78048e-17
C28 (\1\:A VSS) capacitor c=5.49286e-17
C29 (\1\:S1 VSS) capacitor c=3.93411e-17
C30 (\3\:S1b VSS) capacitor c=4.62e-17
C31 (\4\:S1 VSS) capacitor c=5.76924e-17
C32 (\12\:S0 VSS) capacitor c=2.21568e-17
C33 (\3\:D VSS) capacitor c=3.77231e-17
C34 (\5\:S0 VSS) capacitor c=2.8574e-17
C35 (\4\:S0b VSS) capacitor c=4.15854e-17
C36 (\1\:C VSS) capacitor c=3.91692e-17
C37 (\1\:B VSS) capacitor c=6.78245e-17
C38 (\3\:S0 VSS) capacitor c=6.75286e-17
C39 (\3\:S0b VSS) capacitor c=6.42737e-17
C40 (\3\:A VSS) capacitor c=3.03826e-17
C41 (\5\:S1 VSS) capacitor c=3.25022e-17
C42 (\6\:S1 VSS) capacitor c=3.26964e-17
C43 (\11\:S0 VSS) capacitor c=3.17304e-17
C44 (\2\:D VSS) capacitor c=4.4525e-17
C45 (\7\:S0b VSS) capacitor c=3.39916e-17
C46 (\6\:S0 VSS) capacitor c=4.35236e-17
C47 (\5\:S0b VSS) capacitor c=3.686e-17
C48 (\8\:S0 VSS) capacitor c=3.62532e-17
C49 (\2\:C VSS) capacitor c=5.88386e-17
C50 (\2\:B VSS) capacitor c=6.4045e-17
C51 (\4\:S0 VSS) capacitor c=4.83758e-17
C52 (\2\:S0b VSS) capacitor c=5.68923e-17
C53 (\2\:S0 VSS) capacitor c=3.3703e-17
C54 (\2\:A VSS) capacitor c=4.0223e-17
C55 (\8\:n2 VSS) capacitor c=1.32458e-17
C56 (\2\:S1 VSS) capacitor c=6.06527e-17
C57 (\6\:S1b VSS) capacitor c=4.0023e-17
C58 (\5\:S1b VSS) capacitor c=3.07656e-17
C59 (\2\:S1b VSS) capacitor c=2.82223e-17
C60 (\8\:S0b VSS) capacitor c=8.83952e-18
C61 (\10\:VDD VSS) capacitor c=3.51329e-17
C62 (\5\:n1 VSS) capacitor c=1.059e-16
C63 (\12\:VDD VSS) capacitor c=3.91869e-17
C64 (\8\:n0 VSS) capacitor c=4.80204e-17
C65 (\9\:S1b VSS) capacitor c=6.61128e-17
C66 (\7\:n1 VSS) capacitor c=9.49108e-17
C67 (\17\:n2 VSS) capacitor c=1.90568e-16
C68 (\4\:n0 VSS) capacitor c=2.41988e-16
C69 (\1\:VDD VSS) capacitor c=8.4438e-17
C70 (\14\:S0b VSS) capacitor c=9.66266e-17
C71 (\13\:S1b VSS) capacitor c=5.34815e-17
C72 (\3\:n1 VSS) capacitor c=3.54553e-16
C73 (\19\:n2 VSS) capacitor c=9.63739e-17
C74 (\6\:n0 VSS) capacitor c=6.78676e-17
C75 (\4\:S1b VSS) capacitor c=2.2579e-17
C76 (\3\:S1 VSS) capacitor c=7.06763e-17
C77 (\7\:S0 VSS) capacitor c=4.29397e-17
C78 (\7\:S1b VSS) capacitor c=1.49488e-16
C79 (\8\:S1b VSS) capacitor c=1.21885e-16
C80 (\12\:S1b VSS) capacitor c=6.81972e-17
C81 (\7\:S1 VSS) capacitor c=6.41994e-17
C82 (\16\:n2 VSS) capacitor c=1.34912e-16
C83 (\4\:A VSS) capacitor c=7.48756e-17
C84 (\3\:n0 VSS) capacitor c=3.08886e-16
C85 (\5\:B VSS) capacitor c=5.27146e-17
C86 (\13\:S0 VSS) capacitor c=1.06881e-16
C87 (\14\:S0 VSS) capacitor c=1.05679e-16
C88 (\15\:S0 VSS) capacitor c=7.92813e-17
C89 (\4\:C VSS) capacitor c=6.74165e-17
C90 (\4\:D VSS) capacitor c=4.43121e-17
C91 (\17\:S0 VSS) capacitor c=7.78734e-17
C92 (\18\:S0 VSS) capacitor c=6.02417e-17
C93 (\10\:S0b VSS) capacitor c=8.70172e-17
C94 (\11\:S0b VSS) capacitor c=9.5418e-17
C95 (\12\:S0b VSS) capacitor c=1.62788e-16
C96 (\13\:S0b VSS) capacitor c=1.25208e-16
C97 (\16\:S0b VSS) capacitor c=2.40422e-17
C98 (\17\:S0b VSS) capacitor c=8.34683e-17
C99 (\3\:VDD VSS) capacitor c=2.86056e-17
C100 (\5\:VDD VSS) capacitor c=2.10962e-17
C101 (\6\:VDD VSS) capacitor c=1.48944e-16
Rk5 (\7\:S1 S1) resistor r=0.1159 c=0
Rk24 (C \4\:C) resistor r=0.2114 c=0
Rk22 (\13\:S0 \14\:S0) resistor r=0.4736 c=0
Rk23 (\14\:S0 \15\:S0) resistor r=0.4382 c=0
Rk29 (S0 \16\:S0) resistor r=0.1443 c=0
Rk30 (\16\:S0 \17\:S0) resistor r=0.5237 c=0
Rk31 (\16\:S0 \18\:S0) resistor r=0.02672 c=0
Rk39 (\2\:VDD \3\:VDD) resistor r=0.2957 c=0
Rk40 (\3\:VDD \4\:VDD) resistor r=0.4562 c=0
Rk41 (\4\:VDD \5\:VDD) resistor r=0.1352 c=0
Rk42 (\5\:VDD \6\:VDD) resistor r=0.4835 c=0
Rk46 (\9\:VDD VDD) resistor r=0.5514 c=0
Rk45 (\6\:VDD \9\:VDD) resistor r=0.1267 c=0
Rk47 (\3\:VDD \11\:VDD) resistor r=0.244 c=0
Rk48 (\5\:VDD \13\:VDD) resistor r=0.1792 c=0
Rk19 (\4\:B \5\:B) resistor r=0.003606 c=0
Rk20 (\6\:B B) resistor r=0.003709 c=0
Rk21 (\5\:B \6\:B) resistor r=0.1016 c=0
Rk28 (D \4\:D) resistor r=0.1552 c=0
Rk14 (A \4\:A) resistor r=0.027 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.3107 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.4411 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.0675 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.5362 c=0
Rk59 (\9\:VSS VSS) resistor r=0.5514 c=0
Rk58 (\6\:VSS \9\:VSS) resistor r=0.1267 c=0
Rk60 (\3\:VSS \11\:VSS) resistor r=0.2894 c=0
Rk61 (\5\:VSS \13\:VSS) resistor r=0.2171 c=0
Rk6 (\16\:n2 \18\:n2) resistor r=0.9507 c=0
Rk7 (\18\:n2 \20\:n2) resistor r=0.4982 c=0
Rk1 (\7\:S1b \8\:S1b) resistor r=0.8625 c=0
Rk2 (\10\:S1b \11\:S1b) resistor r=0.1861 c=0
Rk3 (\11\:S1b \12\:S1b) resistor r=0.01531 c=0
Rk4 (\11\:S1b \14\:S1b) resistor r=0.1821 c=0
Rk15 (\2\:n0 \3\:n0) resistor r=0.8047 c=0
Rk16 (\3\:n0 \5\:n0) resistor r=1.8858 c=0
Rk17 (\5\:n0 \7\:n0) resistor r=0.5293 c=0
Rk18 (\3\:n0 \9\:n0) resistor r=0.1867 c=0
Rk25 (\2\:n1 \4\:n1) resistor r=2.4956 c=0
Rk26 (\2\:n1 \6\:n1) resistor r=0.566 c=0
Rk27 (\4\:n1 \8\:n1) resistor r=0.4539 c=0
Rk32 (\9\:S0b \10\:S0b) resistor r=0.04786 c=0
Rk33 (\10\:S0b \11\:S0b) resistor r=0.4929 c=0
Rk34 (\11\:S0b \12\:S0b) resistor r=0.552 c=0
Rk35 (\12\:S0b \13\:S0b) resistor r=0.7466 c=0
Rk36 (\10\:S0b \15\:S0b) resistor r=0.8241 c=0
Rk37 (\11\:S0b \16\:S0b) resistor r=0.05728 c=0
Rk38 (\12\:S0b \17\:S0b) resistor r=0.4298 c=0
Rl5 (\1\:S1 \2\:S1) resistor r=65.1797 c=0
Rl8 (\2\:S1 \5\:S1) resistor r=33.4251 c=0
Rl7 (\3\:S1 \4\:S1) resistor r=119.209 c=0
Rl9 (\3\:S1 \6\:S1) resistor r=30.4507 c=0
Rl6 (\2\:S1 \3\:S1) resistor r=233.082 c=0
Rl33 (\2\:C \3\:C) resistor r=102.615 c=0
Rl32 (\1\:C \2\:C) resistor r=109.98 c=0
Rl42 (\10\:S0 \11\:S0) resistor r=169.923 c=0
Rl43 (\11\:S0 \12\:S0) resistor r=39.1533 c=0
Rl35 (\5\:S0 \6\:S0) resistor r=26.1559 c=0
Rl29 (\3\:S0 \4\:S0) resistor r=31.9251 c=0
Rl26 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl38 (\7\:S0 \9\:S0) resistor r=115.066 c=0
Rl36 (\6\:S0 \7\:S0) resistor r=114.917 c=0
Rl37 (\7\:S0 \8\:S0) resistor r=92.233 c=0
Rl31 (\2\:B \3\:B) resistor r=103.297 c=0
Rl30 (\1\:B \2\:B) resistor r=107.692 c=0
Rl40 (\1\:D \2\:D) resistor r=98.7687 c=0
Rl41 (\2\:D \3\:D) resistor r=110.307 c=0
Rl24 (\1\:A \2\:A) resistor r=162.23 c=0
Rl25 (\2\:A \3\:A) resistor r=46.8456 c=0
Rl16 (n2 \8\:n2) resistor r=1.2301 c=0
Rl1 (S1b \2\:S1b) resistor r=26.1559 c=0
Rl2 (\3\:S1b \4\:S1b) resistor r=27.5863 c=0
Rl4 (\4\:S1b \6\:S1b) resistor r=85.3353 c=0
Rl3 (\4\:S1b \5\:S1b) resistor r=5.8511 c=0
Rl39 (\6\:S0b \7\:S0b) resistor r=28.079 c=0
Rl34 (\4\:S0b \5\:S0b) resistor r=44.9225 c=0
Rl27 (S0b \2\:S0b) resistor r=56.9251 c=0
Rl28 (\2\:S0b \3\:S0b) resistor r=149.816 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz13 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz2 (\20\:n2 \19\:n2) resistor r=75 c=0
Rz1 (\13\:S1b \14\:S1b) resistor r=75 c=0
Rz5 (n0 \2\:n0) resistor r=75 c=0
Rz6 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz7 (n1 \2\:n1) resistor r=75 c=0
Rz8 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz9 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry10 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry16 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\18\:n2 \17\:n2) resistor r=31 c=0
Ry1 (\9\:S1b \10\:S1b) resistor r=62 c=0
Ry5 (\4\:n0 \5\:n0) resistor r=20.6667 c=0
Ry6 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry7 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry8 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry9 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx4 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx11 (\2\:C \4\:C) resistor r=45 c=0
Rx8 (\8\:S0 \13\:S0) resistor r=45 c=0
Rx9 (\4\:S0 \14\:S0) resistor r=45 c=0
Rx10 (\2\:S0 \15\:S0) resistor r=45 c=0
Rx13 (\6\:S0 \17\:S0) resistor r=45 c=0
Rx14 (\11\:S0 \18\:S0) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx6 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\16\:n2 \8\:n2) resistor r=45 c=0
Rx1 (\5\:S1b \7\:S1b) resistor r=45 c=0
Rx2 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx3 (\6\:S1b \12\:S1b) resistor r=45 c=0
Rx15 (\2\:S0b \13\:S0b) resistor r=45 c=0
Rx16 (\7\:S0b \16\:S0b) resistor r=45 c=0
Rx17 (\5\:S0b \17\:S0b) resistor r=45 c=0
mn10 (\19\:n2 S1b \6\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.8e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn11 (\19\:n2 \6\:S1 \3\:n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=4.68e-14 ps=1.03e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn12_1__rcx (Y n2 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.844e-14 ad=4.16e-14 ps=1.4525e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65192e-07 sb=1.45817e-06 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn1 (\13\:S1b \5\:S1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.523e-14 ad=2.9e-14 ps=1.5e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn2 (n3 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=5.945e-14 ps=1.53e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn3 (n0 \3\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=5.945e-14 \
        ad=2.465e-14 ps=1.11e-06 pd=6.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.915e-06 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn5 (n0 \3\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.845e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn4 (n5 \1\:B \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.57e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.74e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn6 (n7 \1\:C \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.57e-14 ad=4.495e-14 ps=9.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.475e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn7 (n1 \4\:S0b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=4.495e-14 \
        ad=3.045e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.12e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn9 (n1 \5\:S0 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.683e-14 \
        ad=3.045e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.65e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn8 (n9 \3\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=2.683e-14 ps=1.19e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn0 (\14\:S0b \12\:S0 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=2.03e-14 ps=1.19e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mp1 (\9\:S1b \1\:S1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1785e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp2 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.93e-14 ad=4.945e-14 ps=1.4e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.16512e-07 sb=2e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp3 (\8\:n0 \1\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.655e-14 ps=8.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.91512e-07 sb=2e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp5 (\8\:n0 S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.548e-14 \
        ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.20651e-06 sb=2e-06 sd=160n sca=10.4315 scb=0.0078915 \
        scc=0.00010471 m=(1)
mp4 (n6 \3\:B \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=3.548e-14 ps=1.14e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41651e-06 sb=1.815e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp6 (n8 \3\:C \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=8.493e-14 ps=1.14e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65884e-06 sb=1.5e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp7 (\5\:n1 \9\:S0 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.493e-14 ad=5.483e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84302e-06 sb=1.06e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp9 (\5\:n1 \6\:S0b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.483e-14 ps=5.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9686e-06 sb=7.6e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp8 (n10 \1\:D \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=1.72e-14 ps=1.33e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=10.4315 scb=0.0078915 \
        scc=0.00010471 m=(1)
mp0 (\8\:S0b \10\:S0 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.6973 scb=0.00997937 \
        scc=0.000112947 m=(1)
ends MX4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:01 2013 )
// Library name: gsclib045_hvt
// Cell name: MX4XL
// View name: extracted

simulator lang=spectre

subckt MX4XL A B C D S0 S1 VDD VSS Y
mp12 (\3\:Y n2 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.623e-14 ad=3.87e-14 ps=1.46e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.35e-07 sd=160n sca=53.9205 \
        scb=0.0402944 scc=0.00632464 m=(1)
mp1 (\7\:S1b \4\:S1 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.623e-14 ad=5.053e-14 ps=1.46e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2.35e-07 sd=160n sca=48.3666 \
        scb=0.0308994 scc=0.00589713 m=(1)
mp11 (\8\:n1 S1b \4\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp10 (\4\:n2 \1\:S1 \5\:n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp8 (n10 \4\:D \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.505e-14 ps=1.53e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.985e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp9 (\4\:n1 \2\:S0b n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.87e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp7 (\4\:n1 \2\:S0 n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.665e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp6 (n8 \3\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=4.085e-14 ps=2.09e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.43e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp4 (n6 \1\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=2.365e-14 ps=2.09e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.085e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp5 (\3\:n0 \5\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=4.73e-14 ps=6.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=9.3e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp3 (\3\:n0 \7\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.73e-14 ps=9.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=6.65e-07 sd=160n sca=25.0948 \
        scb=0.0225758 scc=0.00280689 m=(1)
mp2 (n4 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=5.16e-14 ps=8.2e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=3.8e-07 sd=160n sca=26.5217 \
        scb=0.023809 scc=0.00280989 m=(1)
mp0 (\13\:S0b \8\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=3.01e-14 ps=8.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=31.0858 scb=0.0314787 \
        scc=0.00302884 m=(1)
C1 (Y VSS) capacitor c=2.43711e-17
C2 (S1 VSS) capacitor c=4.50705e-17
C3 (S0 VSS) capacitor c=2.8628e-17
C4 (VDD VSS) capacitor c=2.81108e-16
C5 (C VSS) capacitor c=6.55919e-17
C6 (D VSS) capacitor c=7.66563e-17
C7 (A VSS) capacitor c=9.15232e-17
C8 (n2 VSS) capacitor c=4.38006e-17
C9 (S1b VSS) capacitor c=4.88259e-17
C10 (n1 VSS) capacitor c=4.56115e-17
C11 (n0 VSS) capacitor c=8.60591e-17
C12 (n9 VSS) capacitor c=3.69657e-18
C13 (S0b VSS) capacitor c=5.79165e-17
C14 (n5 VSS) capacitor c=1.47257e-18
C15 (n3 VSS) capacitor c=3.08146e-20
C16 (n10 VSS) capacitor c=1.03247e-18
C17 (n8 VSS) capacitor c=8.51558e-19
C18 (n4 VSS) capacitor c=2.23739e-18
C19 (\8\:S0 VSS) capacitor c=2.65022e-17
C20 (\1\:A VSS) capacitor c=4.81467e-17
C21 (\7\:S0 VSS) capacitor c=2.62778e-17
C22 (\5\:S0b VSS) capacitor c=4.70601e-17
C23 (\1\:B VSS) capacitor c=4.34423e-17
C24 (\3\:C VSS) capacitor c=3.43759e-17
C25 (\2\:S0 VSS) capacitor c=6.48719e-17
C26 (\2\:S0b VSS) capacitor c=5.81515e-17
C27 (\4\:D VSS) capacitor c=4.71591e-17
C28 (\1\:S1 VSS) capacitor c=6.23696e-17
C29 (\4\:S1 VSS) capacitor c=3.26766e-17
C30 (\10\:S0 VSS) capacitor c=4.28489e-17
C31 (\3\:A VSS) capacitor c=5.76751e-17
C32 (\7\:S0b VSS) capacitor c=8.60641e-17
C33 (\6\:S0 VSS) capacitor c=5.66638e-17
C34 (\3\:B VSS) capacitor c=3.9343e-17
C35 (\1\:C VSS) capacitor c=6.64482e-17
C36 (\3\:S0b VSS) capacitor c=6.83801e-17
C37 (\1\:S0 VSS) capacitor c=8.51597e-17
C38 (\1\:D VSS) capacitor c=3.16554e-17
C39 (\3\:S1b VSS) capacitor c=3.82413e-17
C40 (\5\:S1 VSS) capacitor c=3.26768e-17
C41 (\6\:S1 VSS) capacitor c=3.33789e-17
C42 (\3\:n2 VSS) capacitor c=2.23488e-17
C43 (\9\:S0 VSS) capacitor c=3.92726e-17
C44 (\2\:A VSS) capacitor c=6.05779e-17
C45 (\4\:S0 VSS) capacitor c=3.3797e-17
C46 (\8\:S0b VSS) capacitor c=3.11579e-17
C47 (\6\:S0b VSS) capacitor c=4.0546e-17
C48 (\2\:B VSS) capacitor c=4.34067e-17
C49 (\2\:C VSS) capacitor c=6.04384e-17
C50 (\4\:S0b VSS) capacitor c=5.92279e-17
C51 (\3\:S0 VSS) capacitor c=2.69854e-17
C52 (\3\:D VSS) capacitor c=1.83359e-17
C53 (\4\:S1b VSS) capacitor c=3.6733e-17
C54 (\2\:S1b VSS) capacitor c=1.98805e-17
C55 (\3\:S1 VSS) capacitor c=4.06659e-17
C56 (\2\:n2 VSS) capacitor c=2.94039e-17
C57 (\13\:S0b VSS) capacitor c=6.04691e-17
C58 (\1\:VDD VSS) capacitor c=5.69034e-17
C59 (\3\:n0 VSS) capacitor c=2.56203e-16
C60 (\9\:VDD VSS) capacitor c=3.39988e-17
C61 (\4\:n1 VSS) capacitor c=8.07526e-17
C62 (\11\:VDD VSS) capacitor c=3.18828e-17
C63 (\5\:n0 VSS) capacitor c=1.98567e-16
C64 (\4\:n2 VSS) capacitor c=2.59748e-16
C65 (\8\:n1 VSS) capacitor c=7.47597e-17
C66 (\7\:S1b VSS) capacitor c=1.12564e-16
C67 (\13\:VDD VSS) capacitor c=1.74669e-17
C68 (\3\:Y VSS) capacitor c=2.268e-17
C69 (\3\:VDD VSS) capacitor c=9.91151e-17
C70 (\9\:S0b VSS) capacitor c=1.21933e-17
C71 (\7\:n0 VSS) capacitor c=6.91849e-17
C72 (\7\:n2 VSS) capacitor c=6.51371e-17
C73 (\6\:n1 VSS) capacitor c=1.3198e-16
C74 (\9\:S1b VSS) capacitor c=8.94535e-17
C75 (\1\:Y VSS) capacitor c=6.03537e-17
C76 (\2\:S1 VSS) capacitor c=5.41315e-17
C77 (\2\:D VSS) capacitor c=4.20024e-17
C78 (\5\:S0 VSS) capacitor c=5.90507e-17
C79 (\7\:S1 VSS) capacitor c=6.78369e-17
C80 (\6\:n2 VSS) capacitor c=2.29154e-16
C81 (\5\:S1b VSS) capacitor c=1.22086e-16
C82 (\6\:S1b VSS) capacitor c=1.31817e-16
C83 (\5\:D VSS) capacitor c=3.70003e-17
C84 (\3\:n1 VSS) capacitor c=1.81031e-16
C85 (\4\:C VSS) capacitor c=4.32301e-17
C86 (\4\:B VSS) capacitor c=1.12813e-16
C87 (\11\:S0 VSS) capacitor c=3.30851e-17
C88 (\12\:S0 VSS) capacitor c=1.35459e-16
C89 (\13\:S0 VSS) capacitor c=2.09152e-16
C90 (\4\:A VSS) capacitor c=5.3019e-17
C91 (\11\:S0b VSS) capacitor c=1.1545e-16
C92 (\12\:S0b VSS) capacitor c=1.36198e-16
C93 (\15\:S0b VSS) capacitor c=7.83175e-17
C94 (\16\:S0b VSS) capacitor c=7.72241e-17
C95 (\17\:S0b VSS) capacitor c=5.65528e-17
C96 (\18\:S0b VSS) capacitor c=2.26852e-17
C97 (\5\:VDD VSS) capacitor c=4.15846e-17
C98 (\6\:VDD VSS) capacitor c=3.36537e-17
C99 (\8\:VDD VSS) capacitor c=1.83218e-17
Rk1 (\2\:Y Y) resistor r=0.2486 c=0
Rk2 (Y \4\:Y) resistor r=0.06089 c=0
Rk3 (\7\:S1 S1) resistor r=0.1247 c=0
Rk15 (B \4\:B) resistor r=0.008026 c=0
Rk20 (\11\:S0 S0) resistor r=0.02706 c=0
Rk19 (\11\:S0 \12\:S0) resistor r=0.2477 c=0
Rk21 (\12\:S0 \13\:S0) resistor r=1.314 c=0
Rk32 (\2\:VDD \4\:VDD) resistor r=0.6365 c=0
Rk33 (\4\:VDD \5\:VDD) resistor r=0.2497 c=0
Rk34 (\5\:VDD \6\:VDD) resistor r=0.4452 c=0
Rk35 (\6\:VDD \7\:VDD) resistor r=0.356 c=0
Rk37 (\8\:VDD VDD) resistor r=0.1175 c=0
Rk36 (\7\:VDD \8\:VDD) resistor r=0.4338 c=0
Rk38 (\5\:VDD \10\:VDD) resistor r=0.04333 c=0
Rk39 (\6\:VDD \12\:VDD) resistor r=0.1278 c=0
Rk40 (\8\:VDD \14\:VDD) resistor r=0.225 c=0
Rk14 (C \4\:C) resistor r=0.1893 c=0
Rk9 (D \5\:D) resistor r=0.07516 c=0
Rk24 (\4\:A A) resistor r=0.05441 c=0
Rk41 (\2\:VSS \4\:VSS) resistor r=0.4194 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.2758 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.3809 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.3962 c=0
Rk46 (\8\:VSS VSS) resistor r=0.1175 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.4338 c=0
Rk47 (\5\:VSS \10\:VSS) resistor r=0.235 c=0
Rk48 (\6\:VSS \12\:VSS) resistor r=0.2303 c=0
Rk49 (\8\:VSS \14\:VSS) resistor r=0.07416 c=0
Rk4 (\5\:n2 \6\:n2) resistor r=1.721 c=0
Rk5 (\5\:n2 \8\:n2) resistor r=0.3677 c=0
Rk6 (\5\:S1b \6\:S1b) resistor r=0.6762 c=0
Rk7 (\6\:S1b \8\:S1b) resistor r=0.5886 c=0
Rk8 (\8\:S1b \10\:S1b) resistor r=0.4207 c=0
Rk10 (\2\:n1 \3\:n1) resistor r=0.3281 c=0
Rk11 (\3\:n1 \5\:n1) resistor r=0.4304 c=0
Rk12 (\3\:n1 \7\:n1) resistor r=0.944 c=0
Rk13 (\7\:n1 \9\:n1) resistor r=0.3878 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.5144 c=0
Rk17 (\4\:n0 \6\:n0) resistor r=1.5187 c=0
Rk18 (\6\:n0 \8\:n0) resistor r=0.3984 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.04478 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.5759 c=0
Rk27 (\11\:S0b \14\:S0b) resistor r=0.5839 c=0
Rk28 (\12\:S0b \15\:S0b) resistor r=0.591 c=0
Rk29 (\15\:S0b \16\:S0b) resistor r=0.4074 c=0
Rk30 (\16\:S0b \17\:S0b) resistor r=0.2894 c=0
Rk31 (\15\:S0b \18\:S0b) resistor r=0.06119 c=0
Rl6 (\3\:S1 \4\:S1) resistor r=22.4021 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=82.5403 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=139.928 c=0
Rl7 (\2\:S1 \5\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=219.844 c=0
Rl19 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl20 (\2\:B \3\:B) resistor r=133.384 c=0
Rl14 (\1\:S0 \2\:S0) resistor r=193.864 c=0
Rl28 (\8\:S0 \9\:S0) resistor r=30.7692 c=0
Rl29 (\9\:S0 \10\:S0) resistor r=132.881 c=0
Rl15 (\2\:S0 \3\:S0) resistor r=98.7687 c=0
Rl25 (\5\:S0 \7\:S0) resistor r=34.3295 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=197.357 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=14.6916 c=0
Rl18 (\2\:C \3\:C) resistor r=37.6944 c=0
Rl17 (\1\:C \2\:C) resistor r=134.169 c=0
Rl12 (\2\:D \4\:D) resistor r=81.5719 c=0
Rl10 (\1\:D \2\:D) resistor r=109.984 c=0
Rl11 (\2\:D \3\:D) resistor r=10.9341 c=0
Rl26 (\1\:A \2\:A) resistor r=103.846 c=0
Rl27 (\2\:A \3\:A) resistor r=60.989 c=0
Rl1 (n2 \2\:n2) resistor r=79.5379 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=29.5379 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl3 (S1b \2\:S1b) resistor r=60.3072 c=0
Rl22 (\7\:S0b \8\:S0b) resistor r=31.9251 c=0
Rl21 (\5\:S0b \6\:S0b) resistor r=71.8456 c=0
Rl16 (\3\:S0b \4\:S0b) resistor r=58.8482 c=0
Rl13 (S0b \2\:S0b) resistor r=60.819 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz10 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz2 (\7\:n2 \8\:n2) resistor r=75 c=0
Rz3 (\9\:S1b \10\:S1b) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (n0 \2\:n0) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz8 (\9\:S0b \10\:S0b) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry13 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry14 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:n2 \5\:n2) resistor r=62 c=0
Ry3 (\7\:S1b \8\:S1b) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry6 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry7 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry8 (\13\:S0b \14\:S0b) resistor r=62 c=0
Rx1 (\3\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx8 (\9\:S0 \11\:S0) resistor r=45 c=0
Rx9 (\4\:S0 \12\:S0) resistor r=45 c=0
Rx10 (\3\:S0 \13\:S0) resistor r=45 c=0
Rx6 (\2\:C \4\:C) resistor r=45 c=0
Rx5 (\3\:D \5\:D) resistor r=45 c=0
Rx11 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:n2 \6\:n2) resistor r=45 c=0
Rx3 (\4\:S1b \5\:S1b) resistor r=45 c=0
Rx4 (\2\:S1b \6\:S1b) resistor r=45 c=0
Rx12 (\8\:S0b \12\:S0b) resistor r=45 c=0
Rx13 (\4\:S0b \16\:S0b) resistor r=45 c=0
Rx14 (S0b \17\:S0b) resistor r=45 c=0
Rx15 (\6\:S0b \18\:S0b) resistor r=45 c=0
mn12 (\1\:Y \3\:n2 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=2.03e-14 ps=1.54e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.35e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (\9\:S1b \6\:S1 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\7\:n2 \5\:S1 \6\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn10 (\7\:n2 \3\:S1b \7\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.61e-14 ps=7.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn8 (n9 \1\:D \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.465e-14 ps=5.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn9 (n1 \1\:S0 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.465e-14 \
        ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.55e-07 sb=1.64e-06 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn7 (n1 \3\:S0b n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.6e-07 sb=1.435e-06 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn6 (n7 \1\:C \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=8.7e-15 ps=7.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.33e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn4 (n5 \3\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.827e-14 ps=7.9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.035e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn5 (n0 \6\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.827e-14 \
        ad=3.48e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.2e-06 sb=7.95e-07 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn3 (n0 \7\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=3.48e-14 ps=4.1e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.485e-06 sb=5.1e-07 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn2 (n3 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.73e-14 ad=8.7e-15 ps=8.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=4.05e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn0 (\9\:S0b \10\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.73e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1.4e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
ends MX4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:02 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2X1
// View name: extracted

simulator lang=spectre

subckt MXI2X1 A B S0 VDD VSS Y
mp1 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.265e-14 ps=1.06e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.60064e-07 sd=160n sca=20.3163 \
        scb=0.0196633 scc=0.0012482 m=(1)
mp2 (\3\:Y \1\:S0 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.58e-14 ps=1.05e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=6.80064e-07 sd=160n sca=17.8529 \
        scb=0.0157306 scc=0.0011909 m=(1)
mp4 (\3\:Y S0b n6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=8.58e-14 ps=1.05e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.85e-07 sb=4.15064e-07 sd=160n sca=17.0707 scb=0.0148367 \
        scc=0.00118868 m=(1)
mp3 (n6 \3\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.265e-14 ps=1.1e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.35064e-07 sd=160n sca=17.6981 \
        scb=0.0155463 scc=0.00119019 m=(1)
C1 (A VSS) capacitor c=3.33196e-17
C2 (S0 VSS) capacitor c=3.55351e-17
C3 (Y VSS) capacitor c=7.68884e-17
C4 (VDD VSS) capacitor c=9.23079e-17
C5 (B VSS) capacitor c=9.15165e-17
C6 (n3 VSS) capacitor c=1.35888e-17
C7 (S0b VSS) capacitor c=4.19564e-17
C8 (n5 VSS) capacitor c=2.2582e-18
C9 (n4 VSS) capacitor c=5.69431e-20
C10 (n6 VSS) capacitor c=4.31185e-18
C11 (\7\:S0 VSS) capacitor c=5.66826e-17
C12 (\3\:B VSS) capacitor c=6.20545e-17
C13 (\1\:S0 VSS) capacitor c=4.33548e-17
C14 (\1\:A VSS) capacitor c=5.20019e-17
C15 (\5\:S0 VSS) capacitor c=3.26088e-17
C16 (\1\:B VSS) capacitor c=8.5146e-17
C17 (\3\:S0 VSS) capacitor c=6.52807e-17
C18 (\3\:S0b VSS) capacitor c=6.3189e-17
C19 (\4\:A VSS) capacitor c=2.54998e-17
C20 (\6\:S0 VSS) capacitor c=5.05031e-17
C21 (\2\:B VSS) capacitor c=6.14814e-17
C22 (\4\:S0 VSS) capacitor c=4.65513e-17
C23 (\2\:S0b VSS) capacitor c=5.21375e-17
C24 (\2\:S0 VSS) capacitor c=3.42074e-17
C25 (\3\:A VSS) capacitor c=1.2991e-17
C26 (\8\:S0b VSS) capacitor c=1.32558e-17
C27 (\1\:VDD VSS) capacitor c=3.53454e-17
C28 (\3\:Y VSS) capacitor c=5.49837e-17
C29 (\6\:VDD VSS) capacitor c=3.88171e-17
C30 (\4\:S0b VSS) capacitor c=8.10236e-17
C31 (\1\:Y VSS) capacitor c=7.19034e-17
C32 (\2\:A VSS) capacitor c=2.18344e-17
C33 (\6\:A VSS) capacitor c=5.94556e-17
C34 (\8\:S0 VSS) capacitor c=2.93923e-17
C35 (\9\:S0 VSS) capacitor c=1.16717e-16
C36 (\10\:S0 VSS) capacitor c=1.30381e-16
C37 (\11\:S0 VSS) capacitor c=3.64628e-17
C38 (\4\:B VSS) capacitor c=4.47182e-17
C39 (\6\:S0b VSS) capacitor c=1.02659e-16
C40 (\7\:S0b VSS) capacitor c=8.41076e-17
C41 (\4\:VDD VSS) capacitor c=3.73791e-17
C42 (\5\:VDD VSS) capacitor c=8.75646e-18
Rk3 (A \6\:A) resistor r=0.01196 c=0
Rk6 (\8\:S0 \9\:S0) resistor r=0.0744 c=0
Rk7 (\9\:S0 \10\:S0) resistor r=0.8995 c=0
Rk9 (\11\:S0 S0) resistor r=0.04523 c=0
Rk8 (\9\:S0 \11\:S0) resistor r=0.1786 c=0
Rk4 (\2\:Y Y) resistor r=0.319 c=0
Rk5 (Y \4\:Y) resistor r=0.2225 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.4078 c=0
Rk20 (\5\:VDD VDD) resistor r=0.09222 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.2578 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.2853 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4799 c=0
Rk16 (\5\:VSS VSS) resistor r=0.09222 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2578 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2294 c=0
Rk10 (\4\:B B) resistor r=0.01392 c=0
Rk11 (\5\:S0b \6\:S0b) resistor r=0.7007 c=0
Rk12 (\6\:S0b \7\:S0b) resistor r=0.5033 c=0
Rk13 (\6\:S0b \9\:S0b) resistor r=0.0474 c=0
Rl1 (\1\:A \2\:A) resistor r=106.572 c=0
Rl3 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl2 (\2\:A \3\:A) resistor r=3.7301 c=0
Rl11 (\6\:S0 \7\:S0) resistor r=163.441 c=0
Rl10 (\5\:S0 \6\:S0) resistor r=39.1533 c=0
Rl7 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl4 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl9 (\2\:B \3\:B) resistor r=37.7434 c=0
Rl8 (\1\:B \2\:B) resistor r=86.3335 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl6 (\2\:S0b \3\:S0b) resistor r=129.889 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
Rx2 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx4 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx5 (\2\:B \4\:B) resistor r=45 c=0
Rx6 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn1 (n3 \4\:A \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=6.76e-14 ps=8e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.87212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (\1\:Y \3\:S0b n3 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.94e-14 ps=1.04e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=5.82212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (\1\:Y \3\:S0 n5 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 sa=6.8e-07 \
        sb=3.47212e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 \
        m=(1)
mn3 (n5 \1\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.4e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mp0 (\8\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=14.8 scb=0.0135568 \
        scc=0.000193521 m=(1)
ends MXI2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:03 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2X2
// View name: extracted

simulator lang=spectre

subckt MXI2X2 A B S0 VDD VSS Y
mp0 (\7\:S0b \1\:S0 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.74e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.80058e-06 sd=160n sca=16.624 \
        scb=0.0167866 scc=0.000347328 m=(1)
mp1 (n4 \1\:A \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.74e-14 ad=1.72e-14 ps=1.15e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.40395e-06 sd=160n sca=11.8288 \
        scb=0.0095548 scc=0.000203669 m=(1)
mp2 (\7\:n0 \4\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.267e-14 ps=5.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.27895e-06 sd=160n sca=11.4379 \
        scb=0.00937809 scc=0.000203588 m=(1)
mp4 (\7\:n0 S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=5.375e-14 \
        ad=5.267e-14 ps=9.3e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.6e-07 sb=9.88953e-07 sd=160n sca=11.2317 scb=0.00932789 \
        scc=0.000203581 m=(1)
mp3 (n6 \1\:B \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.985e-14 ad=5.375e-14 ps=1.36e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=6.93953e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp5 (\8\:n1 \3\:n0 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.157e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.23837e-07 sb=1.4e-07 sd=160n sca=31.9266 \
        scb=0.030013 scc=0.00334115 m=(1)
C1 (S0 VSS) capacitor c=7.24376e-17
C2 (VDD VSS) capacitor c=1.72203e-16
C3 (A VSS) capacitor c=5.285e-17
C4 (Y VSS) capacitor c=4.51994e-17
C5 (S0b VSS) capacitor c=6.3486e-17
C6 (n0 VSS) capacitor c=2.04007e-17
C7 (n5 VSS) capacitor c=3.92499e-18
C8 (n1 VSS) capacitor c=1.59399e-16
C9 (n6 VSS) capacitor c=5.64219e-19
C10 (\3\:n0 VSS) capacitor c=4.80801e-17
C11 (\1\:B VSS) capacitor c=3.93663e-17
C12 (\4\:S0 VSS) capacitor c=4.88926e-17
C13 (\1\:A VSS) capacitor c=5.75951e-17
C14 (\1\:S0 VSS) capacitor c=2.35855e-17
C15 (\2\:n0 VSS) capacitor c=3.44083e-17
C16 (\3\:B VSS) capacitor c=4.04887e-17
C17 (\6\:S0 VSS) capacitor c=4.013e-17
C18 (\3\:S0b VSS) capacitor c=2.9125e-17
C19 (\3\:A VSS) capacitor c=3.38158e-17
C20 (\3\:S0 VSS) capacitor c=4.18213e-17
C21 (\6\:n1 VSS) capacitor c=2.20469e-17
C22 (\2\:B VSS) capacitor c=4.46222e-17
C23 (\7\:S0 VSS) capacitor c=5.74167e-17
C24 (\2\:S0b VSS) capacitor c=7.89824e-17
C25 (\5\:S0 VSS) capacitor c=5.00861e-17
C26 (\2\:A VSS) capacitor c=4.90384e-17
C27 (\2\:S0 VSS) capacitor c=3.67069e-17
C28 (\8\:n1 VSS) capacitor c=2.02249e-17
C29 (\1\:Y VSS) capacitor c=7.0431e-17
C30 (\7\:n0 VSS) capacitor c=9.24161e-17
C31 (\11\:VDD VSS) capacitor c=3.94125e-17
C32 (\7\:S0b VSS) capacitor c=7.66945e-17
C33 (\1\:VDD VSS) capacitor c=2.72522e-17
C34 (\12\:n1 VSS) capacitor c=2.60877e-17
C35 (\3\:Y VSS) capacitor c=3.54246e-17
C36 (\4\:n0 VSS) capacitor c=3.134e-17
C37 (\4\:S0b VSS) capacitor c=1.94534e-17
C38 (\4\:A VSS) capacitor c=6.02084e-17
C39 (\6\:S0b VSS) capacitor c=8.58679e-17
C40 (\9\:S0b VSS) capacitor c=6.22152e-17
C41 (\8\:S0 VSS) capacitor c=5.79251e-17
C42 (\9\:S0 VSS) capacitor c=8.83948e-17
C43 (\10\:S0 VSS) capacitor c=2.44544e-17
C44 (\4\:B VSS) capacitor c=1.012e-16
C45 (\6\:n0 VSS) capacitor c=1.6969e-16
C46 (\9\:n0 VSS) capacitor c=1.14693e-16
C47 (\10\:n1 VSS) capacitor c=2.33682e-17
C48 (\11\:n1 VSS) capacitor c=2.63321e-17
C49 (\3\:VDD VSS) capacitor c=1.0257e-16
C50 (\6\:VDD VSS) capacitor c=1.51345e-17
Rk8 (B \4\:B) resistor r=0.001511 c=0
Rk6 (\9\:S0 S0) resistor r=0.5672 c=0
Rk5 (\8\:S0 \9\:S0) resistor r=0.2739 c=0
Rk7 (S0 \10\:S0) resistor r=0.0209 c=0
Rk25 (\2\:VDD \3\:VDD) resistor r=0.2022 c=0
Rk27 (\3\:VDD \5\:VDD) resistor r=0.2421 c=0
Rk29 (\6\:VDD VDD) resistor r=0.1694 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.3795 c=0
Rk32 (\6\:VDD \12\:VDD) resistor r=0.2719 c=0
Rk1 (\4\:A A) resistor r=0.1204 c=0
Rk9 (\2\:Y Y) resistor r=0.317 c=0
Rk10 (Y \4\:Y) resistor r=0.0913 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.1947 c=0
Rk19 (\3\:VSS \5\:VSS) resistor r=0.1772 c=0
Rk21 (\6\:VSS VSS) resistor r=0.1694 c=0
Rk20 (\5\:VSS \6\:VSS) resistor r=0.3795 c=0
Rk24 (\6\:VSS \12\:VSS) resistor r=0.2338 c=0
Rk2 (\5\:S0b \6\:S0b) resistor r=0.09588 c=0
Rk3 (\6\:S0b \8\:S0b) resistor r=0.6018 c=0
Rk4 (\6\:S0b \9\:S0b) resistor r=0.5047 c=0
Rk11 (\5\:n0 \6\:n0) resistor r=0.2474 c=0
Rk12 (\6\:n0 \8\:n0) resistor r=0.6275 c=0
Rk13 (\6\:n0 \9\:n0) resistor r=0.8381 c=0
Rk14 (\9\:n1 \10\:n1) resistor r=0.2095 c=0
Rk15 (\10\:n1 \11\:n1) resistor r=0.13 c=0
Rk16 (\10\:n1 \13\:n1) resistor r=0.1223 c=0
Rl9 (\1\:B \2\:B) resistor r=105.002 c=0
Rl10 (\2\:B \3\:B) resistor r=118.464 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=99.2328 c=0
Rl5 (\4\:S0 \5\:S0) resistor r=71.8456 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=196.846 c=0
Rl3 (\1\:A \2\:A) resistor r=125.692 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl6 (S0b \2\:S0b) resistor r=220.344 c=0
Rl7 (\2\:S0b \3\:S0b) resistor r=39.6664 c=0
Rl18 (\2\:n0 \3\:n0) resistor r=140.385 c=0
Rl17 (n0 \2\:n0) resistor r=31.9846 c=0
Rl15 (n1 \6\:n1) resistor r=13.9496 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz7 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\4\:S0b \5\:S0b) resistor r=75 c=0
Rz3 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz4 (\13\:n1 \12\:n1) resistor r=75 c=0
Ry9 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry6 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\7\:S0b \8\:S0b) resistor r=62 c=0
Ry3 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry4 (\9\:n1 \8\:n1) resistor r=62 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\7\:S0 \8\:S0) resistor r=45 c=0
Rx4 (\5\:S0 \9\:S0) resistor r=45 c=0
Rx5 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:S0b \9\:S0b) resistor r=45 c=0
Rx7 (n0 \9\:n0) resistor r=45 c=0
Rx8 (\11\:n1 \6\:n1) resistor r=45 c=0
mn0 (\4\:S0b \3\:S0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.03e-14 ps=1.01e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.84931e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn1 (n3 \3\:A \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=3.118e-14 ps=1.01e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.45362e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn2 (\4\:n0 \3\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.32e-14 ps=7.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.19362e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn4 (\4\:n0 \6\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=9.88621e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn3 (n5 \3\:B \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=2.9e-14 ps=1.07e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.43621e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn5 (\12\:n1 \2\:n0 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.025e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65862e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn6 (\3\:Y n1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.581e-14 ad=4.16e-14 ps=1.255e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.22596e-07 sb=5.06058e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mp6_1__rcx (\1\:Y n1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=6.24e-14 ps=1.275e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2141e-07 sb=4.64872e-07 sd=160n sca=20.0881 \
        scb=0.0168391 scc=0.00184274 m=(2)
ends MXI2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:04 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2X4
// View name: extracted

simulator lang=spectre

subckt MXI2X4 A B S0 VDD VSS Y
mp0 (\6\:S0b \3\:S0 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.655e-14 ps=8.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=18.506 scb=0.019899 \
        scc=0.000532288 m=(1)
mp1 (n4 \1\:A \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=4.837e-14 ps=8.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=12.703 scb=0.0101766 \
        scc=0.000164323 m=(1)
mp2 (\6\:n0 \4\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=3.655e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.85e-06 sd=160n sca=11.2588 \
        scb=0.00885445 scc=0.000160725 m=(1)
mp4 (\6\:n0 S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=7.955e-14 \
        ad=3.655e-14 ps=1.17e-06 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.15e-07 sb=1.635e-06 sd=160n sca=10.9013 scb=0.00874909 \
        scc=0.000160703 m=(1)
mp3 (n6 \1\:B \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=7.955e-14 ps=1.16e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.33e-06 sb=1.22e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
C1 (Y VSS) capacitor c=2.13716e-16
C2 (VDD VSS) capacitor c=1.69641e-16
C3 (A VSS) capacitor c=6.19858e-17
C4 (S0b VSS) capacitor c=4.14344e-17
C5 (n0 VSS) capacitor c=3.55143e-17
C6 (n5 VSS) capacitor c=3.47383e-18
C7 (n1 VSS) capacitor c=3.12759e-16
C8 (n6 VSS) capacitor c=1.14139e-17
C9 (\3\:n0 VSS) capacitor c=5.74692e-17
C10 (\1\:B VSS) capacitor c=4.07188e-17
C11 (\4\:S0 VSS) capacitor c=4.37419e-17
C12 (\1\:A VSS) capacitor c=5.09972e-17
C13 (\3\:S0 VSS) capacitor c=2.52428e-17
C14 (\3\:B VSS) capacitor c=6.08874e-17
C15 (\6\:S0 VSS) capacitor c=5.49286e-17
C16 (\3\:S0b VSS) capacitor c=4.11969e-17
C17 (\3\:A VSS) capacitor c=3.87401e-17
C18 (\1\:S0 VSS) capacitor c=5.72726e-17
C19 (\2\:n0 VSS) capacitor c=5.07969e-17
C20 (\2\:B VSS) capacitor c=5.90001e-17
C21 (\7\:S0 VSS) capacitor c=4.1061e-17
C22 (\2\:S0b VSS) capacitor c=5.09499e-17
C23 (\5\:S0 VSS) capacitor c=2.79369e-17
C24 (\2\:A VSS) capacitor c=5.21695e-17
C25 (\2\:S0 VSS) capacitor c=5.21991e-17
C26 (\20\:n1 VSS) capacitor c=4.49428e-17
C27 (\6\:n0 VSS) capacitor c=9.64661e-17
C28 (\15\:VDD VSS) capacitor c=3.45776e-17
C29 (\6\:S0b VSS) capacitor c=5.97159e-17
C30 (\1\:VDD VSS) capacitor c=4.19189e-17
C31 (\16\:n1 VSS) capacitor c=4.77859e-17
C32 (\1\:Y VSS) capacitor c=1.29046e-16
C33 (\8\:n0 VSS) capacitor c=3.19024e-17
C34 (\8\:S0b VSS) capacitor c=2.07262e-17
C35 (\4\:A VSS) capacitor c=5.49372e-17
C36 (\4\:S0b VSS) capacitor c=9.30638e-17
C37 (\5\:S0b VSS) capacitor c=1.19605e-16
C38 (\8\:S0 VSS) capacitor c=8.70748e-17
C39 (\9\:S0 VSS) capacitor c=1.07591e-16
C40 (\10\:S0 VSS) capacitor c=6.99689e-17
C41 (\4\:B VSS) capacitor c=1.1232e-16
C42 (\4\:n0 VSS) capacitor c=1.85805e-16
C43 (\5\:n0 VSS) capacitor c=2.73961e-16
C44 (\18\:n1 VSS) capacitor c=4.59679e-17
C45 (\19\:n1 VSS) capacitor c=2.97299e-17
C46 (\3\:VDD VSS) capacitor c=2.33755e-16
C47 (\7\:VDD VSS) capacitor c=1.70592e-17
Rk8 (B \4\:B) resistor r=0.002509 c=0
Rk6 (\9\:S0 S0) resistor r=0.4955 c=0
Rk5 (\8\:S0 \9\:S0) resistor r=0.4997 c=0
Rk7 (S0 \10\:S0) resistor r=0.01199 c=0
Rk10 (\1\:Y Y) resistor r=0.2301 c=0
Rk30 (\2\:VDD \3\:VDD) resistor r=0.1402 c=0
Rk33 (\3\:VDD \6\:VDD) resistor r=0.1878 c=0
Rk35 (\7\:VDD VDD) resistor r=0.1425 c=0
Rk34 (\6\:VDD \7\:VDD) resistor r=0.4084 c=0
Rk40 (\7\:VDD \16\:VDD) resistor r=0.2606 c=0
Rk1 (\4\:A A) resistor r=0.03938 c=0
Rk24 (\1\:VSS \7\:VSS) resistor r=0.1402 c=0
Rk26 (\8\:VSS VSS) resistor r=0.17 c=0
Rk25 (\7\:VSS \8\:VSS) resistor r=0.3809 c=0
Rk29 (\8\:VSS \14\:VSS) resistor r=0.1962 c=0
Rk2 (\4\:S0b \5\:S0b) resistor r=0.7698 c=0
Rk3 (\5\:S0b \7\:S0b) resistor r=0.5832 c=0
Rk4 (\5\:S0b \9\:S0b) resistor r=0.097 c=0
Rk15 (\4\:n0 \5\:n0) resistor r=1.2614 c=0
Rk16 (\5\:n0 \7\:n0) resistor r=0.807 c=0
Rk17 (\5\:n0 \9\:n0) resistor r=0.263 c=0
Rk18 (\17\:n1 \18\:n1) resistor r=0.4226 c=0
Rk19 (\18\:n1 \19\:n1) resistor r=0.1829 c=0
Rk20 (\18\:n1 \21\:n1) resistor r=0.2118 c=0
Rl9 (\1\:B \2\:B) resistor r=91.5405 c=0
Rl10 (\2\:B \3\:B) resistor r=189.939 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=81.9251 c=0
Rl5 (\4\:S0 \5\:S0) resistor r=44.9225 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=29.9451 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=226.923 c=0
Rl3 (\1\:A \2\:A) resistor r=154.538 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl6 (S0b \2\:S0b) resistor r=107.692 c=0
Rl7 (\2\:S0b \3\:S0b) resistor r=149.176 c=0
Rl26 (\2\:n0 \3\:n0) resistor r=106.925 c=0
Rl25 (n0 \2\:n0) resistor r=96.6933 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz4 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz5 (\17\:n1 \16\:n1) resistor r=75 c=0
Ry12 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry6 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry7 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\6\:S0b \7\:S0b) resistor r=62 c=0
Ry4 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry5 (\21\:n1 \20\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\7\:S0 \8\:S0) resistor r=45 c=0
Rx4 (\5\:S0 \9\:S0) resistor r=45 c=0
Rx5 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:S0b \4\:S0b) resistor r=45 c=0
Rx7 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\19\:n1 n1) resistor r=45 c=0
mn0 (\8\:S0b \1\:S0 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn1 (n3 \3\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.582e-14 ps=6.1e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\8\:n0 \3\:S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.582e-14 ad=2.61e-14 ps=1.06e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.95e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\8\:n0 \6\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.61e-14 ps=5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.725e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.007e-14 ad=1.522e-14 ps=1.19e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.575e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn5 (\16\:n1 n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.32e-14 ad=3.64e-14 ps=1.16e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62625e-06 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn6_1__rcx (\1\:Y n1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.522e-14 ad=4.355e-14 ps=1.2475e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.975e-07 sb=1.195e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(4)
mp5 (\20\:n1 \3\:n0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5266e-06 sb=1.4e-07 sd=160n sca=20.2961 \
        scb=0.018091 scc=0.00149586 m=(1)
mp6_1__rcx (Y n1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.139e-14 ad=6.727e-14 ps=1.115e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.07628e-07 sb=9.85e-07 sd=160n sca=17.7856 \
        scb=0.015626 scc=0.00148402 m=(4)
ends MXI2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:05 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2X6
// View name: extracted

simulator lang=spectre

subckt MXI2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=15.1724 scb=0.0141966 \
        scc=0.000199699 m=(1)
mp1 (n4 \1\:A \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.945e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=12.0026 scb=0.00898843 \
        scc=0.000100961 m=(1)
mp2 (\7\:n0 \6\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=4.515e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=2e-06 sd=160n sca=10.6609 \
        scb=0.00786354 scc=9.84678e-05 m=(1)
mp4 (\7\:n0 \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.515e-14 ps=6.8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.825e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=2.687e-14 ps=1.16e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=1.655e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
C1 (B VSS) capacitor c=7.96265e-17
C2 (S0 VSS) capacitor c=3.46407e-17
C3 (Y VSS) capacitor c=5.20307e-16
C4 (VDD VSS) capacitor c=2.20178e-16
C5 (A VSS) capacitor c=4.13234e-17
C6 (S0b VSS) capacitor c=6.05487e-17
C7 (n0 VSS) capacitor c=2.15866e-16
C8 (n5 VSS) capacitor c=5.14908e-18
C9 (n1 VSS) capacitor c=3.17056e-16
C10 (n4 VSS) capacitor c=2.35833e-20
C11 (n6 VSS) capacitor c=1.6215e-18
C12 (\1\:B VSS) capacitor c=6.34296e-17
C13 (\3\:S0b VSS) capacitor c=4.15491e-17
C14 (\6\:S0 VSS) capacitor c=4.23141e-17
C15 (\1\:A VSS) capacitor c=5.09757e-17
C16 (\1\:S0 VSS) capacitor c=3.29336e-17
C17 (\3\:B VSS) capacitor c=4.46456e-17
C18 (\4\:S0 VSS) capacitor c=6.50665e-17
C19 (\3\:A VSS) capacitor c=7.86671e-17
C20 (\3\:S0 VSS) capacitor c=5.8575e-17
C21 (\7\:n1 VSS) capacitor c=1.70402e-17
C22 (\2\:B VSS) capacitor c=5.53386e-17
C23 (\4\:S0b VSS) capacitor c=4.52741e-17
C24 (\5\:S0 VSS) capacitor c=7.64821e-17
C25 (\2\:S0b VSS) capacitor c=4.9765e-17
C26 (\2\:A VSS) capacitor c=6.34185e-17
C27 (\2\:S0 VSS) capacitor c=5.46193e-17
C28 (\1\:VDD VSS) capacitor c=3.33797e-16
C29 (\21\:n1 VSS) capacitor c=9.0269e-17
C30 (\7\:n0 VSS) capacitor c=9.27529e-17
C31 (\16\:VDD VSS) capacitor c=2.31658e-17
C32 (\8\:S0b VSS) capacitor c=7.99197e-17
C33 (\3\:VDD VSS) capacitor c=4.82167e-17
C34 (\19\:n1 VSS) capacitor c=3.97657e-17
C35 (\10\:n0 VSS) capacitor c=5.67127e-17
C36 (\10\:S0b VSS) capacitor c=3.37458e-17
C37 (\4\:A VSS) capacitor c=6.51288e-17
C38 (\7\:S0 VSS) capacitor c=6.93341e-17
C39 (\8\:S0 VSS) capacitor c=8.04948e-17
C40 (\5\:S0b VSS) capacitor c=8.77153e-17
C41 (\6\:S0b VSS) capacitor c=1.35558e-16
C42 (\7\:S0b VSS) capacitor c=5.51981e-17
C43 (\4\:B VSS) capacitor c=2.70692e-17
C44 (\9\:n0 VSS) capacitor c=1.37055e-16
C45 (\12\:n0 VSS) capacitor c=5.07046e-17
C46 (\17\:n1 VSS) capacitor c=1.98901e-17
C47 (\18\:n1 VSS) capacitor c=5.49041e-17
C48 (\15\:VDD VSS) capacitor c=2.55161e-17
Rk10 (\4\:B B) resistor r=0.02104 c=0
Rk3 (\8\:S0 S0) resistor r=0.03714 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.5576 c=0
Rk33 (\1\:VDD \14\:VDD) resistor r=0.09764 c=0
Rk36 (\15\:VDD VDD) resistor r=0.1802 c=0
Rk34 (\14\:VDD \15\:VDD) resistor r=0.3711 c=0
Rk35 (\15\:VDD \17\:VDD) resistor r=0.1747 c=0
Rk1 (A \4\:A) resistor r=0.007123 c=0
Rk41 (\1\:VSS \8\:VSS) resistor r=0.08259 c=0
Rk43 (\9\:VSS VSS) resistor r=0.1802 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.3711 c=0
Rk47 (\9\:VSS \17\:VSS) resistor r=0.2175 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4999 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4517 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.5592 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.2257 c=0
Rk11 (\8\:n0 \9\:n0) resistor r=0.6162 c=0
Rk12 (\9\:n0 \11\:n0) resistor r=0.3903 c=0
Rk13 (\9\:n0 \12\:n0) resistor r=0.2571 c=0
Rk14 (\17\:n1 \18\:n1) resistor r=0.1017 c=0
Rk15 (\18\:n1 \20\:n1) resistor r=0.2507 c=0
Rk16 (\18\:n1 \22\:n1) resistor r=0.4472 c=0
Rl9 (\1\:B \2\:B) resistor r=158.384 c=0
Rl10 (\2\:B \3\:B) resistor r=135.307 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=80.0021 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=46.8456 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=246.846 c=0
Rl3 (\1\:A \2\:A) resistor r=146.846 c=0
Rl4 (\2\:A \3\:A) resistor r=146.846 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=57.0048 c=0
Rl5 (S0b \2\:S0b) resistor r=66.8207 c=0
Rl21 (n1 \7\:n1) resistor r=9.5197 c=0
Rz7 (\1\:VDD \3\:VDD) resistor r=25 c=0
Rz8 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\20\:n1 \19\:n1) resistor r=75 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry12 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry13 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\22\:n1 \21\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\12\:n0 n0) resistor r=45 c=0
Rx8 (\17\:n1 \7\:n1) resistor r=45 c=0
mn0 (\10\:S0b \3\:S0 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn1 (n3 \3\:A \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=3.19e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.985e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=4.133e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.655e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn5 (\19\:n1 n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.933e-14 ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.58077e-07 sb=1.42e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn6_1__rcx (Y n1 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.836e-14 ps=9.6e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03774e-06 sb=9.6e-07 sd=160n sca=11.2536 \
        scb=0.0105131 scc=0.000532331 m=(5)
mp5_1__rcx (\21\:n1 n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.412e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.97372e-07 sb=1.42e-06 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(2)
mp6_1__rcx (Y n1 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.814e-14 ad=7.332e-14 ps=1.28e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06037e-06 sb=9.6e-07 sd=160n sca=13.3727 \
        scb=0.0119208 scc=0.000609828 m=(5)
ends MXI2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:06 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2X8
// View name: extracted

simulator lang=spectre

subckt MXI2X8 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.9313 scb=0.0137374 \
        scc=0.000173804 m=(1)
mp1 (n4 \1\:A \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.7616 \
        scb=0.00852924 scc=7.50663e-05 m=(1)
mp2 (\7\:n0 \6\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.655e-14 ps=7.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=10.5874 \
        scb=0.00747601 scc=7.25996e-05 m=(1)
mp4 (\7\:n0 \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.655e-14 ps=8.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2e-06 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=4.73e-14 ps=1.22e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2e-06 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
C1 (S0 VSS) capacitor c=9.9353e-17
C2 (Y VSS) capacitor c=4.75477e-16
C3 (VDD VSS) capacitor c=2.21755e-16
C4 (A VSS) capacitor c=6.08266e-17
C5 (S0b VSS) capacitor c=4.85138e-17
C6 (n0 VSS) capacitor c=2.02097e-16
C7 (n5 VSS) capacitor c=5.73861e-18
C8 (n1 VSS) capacitor c=4.00666e-16
C9 (n6 VSS) capacitor c=6.10308e-18
C10 (\1\:B VSS) capacitor c=4.77173e-17
C11 (\3\:S0b VSS) capacitor c=4.45148e-17
C12 (\6\:S0 VSS) capacitor c=4.46984e-17
C13 (\1\:A VSS) capacitor c=6.05572e-17
C14 (\1\:S0 VSS) capacitor c=3.37217e-17
C15 (\3\:B VSS) capacitor c=4.71729e-17
C16 (\4\:S0 VSS) capacitor c=5.88773e-17
C17 (\3\:A VSS) capacitor c=4.77193e-17
C18 (\3\:S0 VSS) capacitor c=5.95161e-17
C19 (\9\:n1 VSS) capacitor c=1.79325e-17
C20 (\2\:B VSS) capacitor c=5.04386e-17
C21 (\4\:S0b VSS) capacitor c=4.19511e-17
C22 (\5\:S0 VSS) capacitor c=8.4611e-17
C23 (\2\:S0b VSS) capacitor c=4.49556e-17
C24 (\2\:A VSS) capacitor c=6.19038e-17
C25 (\2\:S0 VSS) capacitor c=5.44423e-17
C26 (\1\:VDD VSS) capacitor c=3.82076e-16
C27 (\27\:n1 VSS) capacitor c=9.17053e-17
C28 (\7\:n0 VSS) capacitor c=9.63503e-17
C29 (\19\:VDD VSS) capacitor c=3.81592e-17
C30 (\10\:S0b VSS) capacitor c=8.85201e-17
C31 (\3\:VDD VSS) capacitor c=5.1227e-17
C32 (\25\:n1 VSS) capacitor c=3.78545e-17
C33 (\10\:n0 VSS) capacitor c=4.20241e-17
C34 (\8\:S0b VSS) capacitor c=3.19633e-17
C35 (\4\:A VSS) capacitor c=5.68875e-17
C36 (\7\:S0 VSS) capacitor c=8.78803e-17
C37 (\5\:S0b VSS) capacitor c=6.56721e-17
C38 (\6\:S0b VSS) capacitor c=1.14789e-16
C39 (\7\:S0b VSS) capacitor c=8.60401e-17
C40 (\4\:B VSS) capacitor c=1.04842e-16
C41 (\9\:n0 VSS) capacitor c=1.42642e-16
C42 (\12\:n0 VSS) capacitor c=4.72608e-17
C43 (\23\:n1 VSS) capacitor c=2.27074e-17
C44 (\24\:n1 VSS) capacitor c=5.46801e-17
C45 (\10\:VDD VSS) capacitor c=2.40327e-17
Rk8 (\4\:B B) resistor r=0.002995 c=0
Rk3 (\8\:S0 S0) resistor r=0.002702 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.4715 c=0
Rk32 (\1\:VDD \9\:VDD) resistor r=0.1126 c=0
Rk34 (\10\:VDD VDD) resistor r=0.18 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.3707 c=0
Rk39 (\10\:VDD \20\:VDD) resistor r=0.2141 c=0
Rk1 (\4\:A A) resistor r=0.04728 c=0
Rk45 (\1\:VSS \9\:VSS) resistor r=0.08251 c=0
Rk47 (\10\:VSS VSS) resistor r=0.18 c=0
Rk46 (\9\:VSS \10\:VSS) resistor r=0.3707 c=0
Rk52 (\10\:VSS \20\:VSS) resistor r=0.2008 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.3979 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5535 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.2007 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6499 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.7092 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.3288 c=0
Rk11 (\9\:n0 \12\:n0) resistor r=0.2772 c=0
Rk12 (\23\:n1 \24\:n1) resistor r=0.1007 c=0
Rk13 (\24\:n1 \26\:n1) resistor r=0.2117 c=0
Rk14 (\24\:n1 \28\:n1) resistor r=0.4765 c=0
Rl9 (\1\:B \2\:B) resistor r=125.692 c=0
Rl10 (\2\:B \3\:B) resistor r=156.461 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=92.1028 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=221.131 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=233.384 c=0
Rl3 (\1\:A \2\:A) resistor r=181.461 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=56.461 c=0
Rl5 (S0b \2\:S0b) resistor r=85.3072 c=0
Rl23 (n1 \9\:n1) resistor r=9.5287 c=0
Rz8 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz9 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\26\:n1 \25\:n1) resistor r=75 c=0
Ry13 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry15 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\28\:n1 \27\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\12\:n0 n0) resistor r=45 c=0
Rx8 (\23\:n1 \9\:n1) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn1 (n3 \3\:A \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=2e-06 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=3.625e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn5 (\25\:n1 n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=4.16e-14 ps=9.85e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74808e-07 sb=1.83e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn6_1__rcx (Y n1 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.876e-14 ad=4.636e-14 ps=9.2429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10017e-06 sb=1.37e-06 sd=160n sca=8.43155 \
        scb=0.00645789 scc=0.000159377 m=(7)
mp5_1__rcx (\27\:n1 n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.96e-14 ad=6.24e-14 ps=1.265e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.83e-06 sd=160n sca=12.7076 \
        scb=0.0112318 scc=0.000478212 m=(2)
mp6_1__rcx (Y n1 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.351e-14 ad=6.993e-14 ps=1.22429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.10348e-06 sb=1.37e-06 sd=160n \
        sca=15.1493 scb=0.013431 scc=0.000976912 m=(7)
ends MXI2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:07 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI2XL
// View name: extracted

simulator lang=spectre

subckt MXI2XL A B S0 VDD VSS Y
mp1 (n4 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.055e-06 sd=160n sca=19.4817 \
        scb=0.0210827 scc=0.000690865 m=(1)
mp2 (\3\:Y \3\:S0 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=8.35e-07 sd=160n sca=12.7904 \
        scb=0.00993072 scc=8.66491e-05 m=(1)
mp4 (\3\:Y \3\:S0b n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=6.3e-07 sd=160n sca=11.7062 \
        scb=0.00805323 scc=7.41039e-05 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=4.5e-07 sd=160n sca=12.1787 \
        scb=0.00883398 scc=7.73084e-05 m=(1)
mp0 (\5\:S0b \4\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.268e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=2.45e-07 sd=160n sca=15.5376 \
        scb=0.0148069 scc=0.000217426 m=(1)
C1 (A VSS) capacitor c=1.54941e-17
C2 (VDD VSS) capacitor c=1.33717e-16
C3 (S0 VSS) capacitor c=4.55049e-17
C4 (Y VSS) capacitor c=1.01517e-16
C5 (B VSS) capacitor c=9.78852e-17
C6 (n3 VSS) capacitor c=9.13171e-18
C7 (S0b VSS) capacitor c=6.08095e-17
C8 (n4 VSS) capacitor c=1.13263e-17
C9 (\4\:S0 VSS) capacitor c=4.44329e-17
C10 (\1\:B VSS) capacitor c=4.26155e-17
C11 (\3\:S0b VSS) capacitor c=5.14825e-17
C12 (\3\:S0 VSS) capacitor c=6.74815e-17
C13 (\1\:A VSS) capacitor c=3.36569e-17
C14 (\6\:S0 VSS) capacitor c=3.65159e-17
C15 (\3\:B VSS) capacitor c=7.64975e-17
C16 (\1\:S0 VSS) capacitor c=5.20656e-17
C17 (\4\:A VSS) capacitor c=5.90863e-17
C18 (\5\:S0 VSS) capacitor c=4.44865e-17
C19 (\2\:B VSS) capacitor c=6.50046e-17
C20 (\2\:S0 VSS) capacitor c=7.64296e-17
C21 (\4\:S0b VSS) capacitor c=4.29632e-17
C22 (\2\:S0b VSS) capacitor c=2.78821e-17
C23 (\3\:A VSS) capacitor c=1.23576e-17
C24 (\5\:S0b VSS) capacitor c=5.64993e-17
C25 (\1\:VDD VSS) capacitor c=3.32399e-17
C26 (\3\:Y VSS) capacitor c=8.47158e-17
C27 (\6\:VDD VSS) capacitor c=1.98465e-17
C28 (\10\:S0b VSS) capacitor c=1.57558e-17
C29 (\1\:Y VSS) capacitor c=4.17746e-17
C30 (\2\:A VSS) capacitor c=3.69449e-17
C31 (\5\:A VSS) capacitor c=7.06086e-17
C32 (\7\:S0 VSS) capacitor c=6.28755e-17
C33 (\8\:S0 VSS) capacitor c=6.97662e-17
C34 (\7\:S0b VSS) capacitor c=9.14183e-17
C35 (\8\:S0b VSS) capacitor c=9.82352e-17
C36 (\9\:S0b VSS) capacitor c=8.34482e-17
C37 (\12\:S0b VSS) capacitor c=7.17777e-17
C38 (\4\:VDD VSS) capacitor c=3.77632e-17
C39 (\5\:VDD VSS) capacitor c=8.86154e-18
Rk1 (\5\:A A) resistor r=0.01024 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.345 c=0
Rk14 (\5\:VDD VDD) resistor r=0.02462 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.2756 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.2136 c=0
Rk5 (S0 \7\:S0) resistor r=0.1109 c=0
Rk6 (\7\:S0 \8\:S0) resistor r=0.2269 c=0
Rk17 (\3\:VSS VSS) resistor r=0.04468 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.07369 c=0
Rk18 (\3\:VSS \5\:VSS) resistor r=0.2555 c=0
Rk19 (\5\:VSS \7\:VSS) resistor r=0.4504 c=0
Rk2 (\2\:Y Y) resistor r=0.2037 c=0
Rk3 (Y \4\:Y) resistor r=0.5727 c=0
Rk4 (\4\:B B) resistor r=0.001659 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.4994 c=0
Rk8 (\7\:S0b \8\:S0b) resistor r=0.4095 c=0
Rk9 (\8\:S0b \9\:S0b) resistor r=0.4314 c=0
Rk10 (\7\:S0b \11\:S0b) resistor r=0.07479 c=0
Rk11 (\8\:S0b \12\:S0b) resistor r=0.4225 c=0
Rl1 (\1\:A \2\:A) resistor r=112.341 c=0
Rl3 (\2\:A \4\:A) resistor r=112.341 c=0
Rl2 (\2\:A \3\:A) resistor r=6.9867 c=0
Rl10 (\4\:S0 \5\:S0) resistor r=119.922 c=0
Rl11 (\5\:S0 \6\:S0) resistor r=89.1533 c=0
Rl7 (\2\:S0 \3\:S0) resistor r=192.847 c=0
Rl6 (\1\:S0 \2\:S0) resistor r=83.8482 c=0
Rl8 (\1\:B \2\:B) resistor r=49.2328 c=0
Rl9 (\2\:B \3\:B) resistor r=156.925 c=0
Rl5 (\3\:S0b \4\:S0b) resistor r=49.2328 c=0
Rl4 (S0b \2\:S0b) resistor r=67.9995 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\10\:S0b \11\:S0b) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx4 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx5 (\2\:S0b \9\:S0b) resistor r=45 c=0
Rx6 (\4\:S0b \12\:S0b) resistor r=45 c=0
mn1 (n3 \4\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.14e-14 ad=8.7e-15 ps=1.37e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=9.5e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn2 (\1\:Y S0b n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.05e-07 sb=8.45e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn4 (\1\:Y \1\:S0 n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=6e-07 sb=4.5e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn3 (n5 \3\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=3.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn0 (\10\:S0b \6\:S0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
ends MXI2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:08 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI3X1
// View name: extracted

simulator lang=spectre

subckt MXI3X1 A B C S0 S1 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.5351 scb=0.0231851 \
        scc=0.000811514 m=(1)
mp2 (n3 \1\:A \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.0105e-13 ps=7.5e-07 pd=1.37e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.7004 scb=0.0133656 \
        scc=0.000345077 m=(1)
mp3 (\8\:n0 \4\:S0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=3.44e-14 ps=1.37e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.72e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp5 (\8\:n0 \3\:S0b n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.515e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp4 (n5 \1\:B \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.295e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp7 (n7 n0 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=1.09e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp8 (\6\:n1 \3\:S1 n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=4.837e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=8.65e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp10 (\6\:n1 \3\:S1b n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.837e-14 ps=7.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=5.95e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp9 (n9 \3\:Cp \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.118e-14 ps=1.52e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp1 (\10\:S1b \6\:S1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp6 (\9\:Cp \3\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=3.655e-14 ps=1.51e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.05e-07 sd=160n sca=48.3011 \
        scb=0.0307957 scc=0.00589601 m=(1)
C1 (Y VSS) capacitor c=2.45502e-17
C2 (B VSS) capacitor c=1.04995e-16
C3 (S0 VSS) capacitor c=8.47188e-17
C4 (VDD VSS) capacitor c=2.79795e-16
C5 (C VSS) capacitor c=9.18552e-17
C6 (A VSS) capacitor c=9.27813e-17
C7 (S1 VSS) capacitor c=7.83532e-17
C8 (S0b VSS) capacitor c=4.603e-17
C9 (n2 VSS) capacitor c=1.71371e-19
C10 (n0 VSS) capacitor c=5.97778e-17
C11 (n4 VSS) capacitor c=1.01178e-17
C12 (n1 VSS) capacitor c=2.67299e-17
C13 (S1b VSS) capacitor c=4.78284e-17
C14 (n8 VSS) capacitor c=1.47936e-18
C15 (Cp VSS) capacitor c=2.73066e-17
C16 (n3 VSS) capacitor c=6.88945e-19
C17 (n5 VSS) capacitor c=4.75484e-18
C18 (n7 VSS) capacitor c=1.00082e-18
C19 (n9 VSS) capacitor c=4.30211e-18
C20 (\3\:C VSS) capacitor c=3.34124e-17
C21 (\6\:S1 VSS) capacitor c=4.05422e-17
C22 (\3\:Cp VSS) capacitor c=7.17339e-17
C23 (\3\:S1b VSS) capacitor c=4.46059e-17
C24 (\3\:S1 VSS) capacitor c=7.67014e-17
C25 (\1\:B VSS) capacitor c=3.35252e-17
C26 (\3\:S0b VSS) capacitor c=3.93495e-17
C27 (\4\:S0 VSS) capacitor c=2.66701e-17
C28 (\1\:A VSS) capacitor c=3.90336e-17
C29 (\1\:S0 VSS) capacitor c=3.2263e-17
C30 (\4\:n1 VSS) capacitor c=4.26701e-17
C31 (\1\:C VSS) capacitor c=3.08221e-17
C32 (\4\:S1 VSS) capacitor c=4.08115e-17
C33 (\4\:Cp VSS) capacitor c=3.74588e-17
C34 (\1\:S1 VSS) capacitor c=3.32336e-17
C35 (\3\:n0 VSS) capacitor c=3.4489e-17
C36 (\3\:B VSS) capacitor c=4.90846e-17
C37 (\6\:S0 VSS) capacitor c=5.29826e-17
C38 (\3\:A VSS) capacitor c=3.83956e-17
C39 (\3\:S0 VSS) capacitor c=4.30653e-17
C40 (\3\:n1 VSS) capacitor c=1.53716e-17
C41 (\2\:C VSS) capacitor c=2.94288e-17
C42 (\5\:S1 VSS) capacitor c=6.2742e-17
C43 (\2\:S1 VSS) capacitor c=7.48661e-17
C44 (\4\:S1b VSS) capacitor c=3.59824e-17
C45 (\2\:S1b VSS) capacitor c=2.24225e-17
C46 (\2\:n0 VSS) capacitor c=5.09039e-17
C47 (\2\:B VSS) capacitor c=4.93255e-17
C48 (\4\:S0b VSS) capacitor c=4.26777e-17
C49 (\5\:S0 VSS) capacitor c=4.70627e-17
C50 (\2\:S0b VSS) capacitor c=3.54751e-17
C51 (\2\:A VSS) capacitor c=4.56087e-17
C52 (\2\:S0 VSS) capacitor c=4.4395e-17
C53 (\3\:Y VSS) capacitor c=5.66186e-17
C54 (\9\:VDD VSS) capacitor c=2.62257e-17
C55 (\9\:Cp VSS) capacitor c=6.00078e-17
C56 (\10\:S1b VSS) capacitor c=9.85695e-17
C57 (\1\:VDD VSS) capacitor c=1.91319e-17
C58 (\6\:n1 VSS) capacitor c=2.38696e-16
C59 (\11\:VDD VSS) capacitor c=4.14429e-17
C60 (\8\:n0 VSS) capacitor c=5.72825e-17
C61 (\13\:VDD VSS) capacitor c=4.00462e-17
C62 (\10\:S0b VSS) capacitor c=6.64642e-17
C63 (\5\:VDD VSS) capacitor c=6.14972e-17
C64 (\1\:Y VSS) capacitor c=1.13542e-17
C65 (\5\:Cp VSS) capacitor c=6.71422e-17
C66 (\5\:S1b VSS) capacitor c=1.21678e-16
C67 (\8\:n1 VSS) capacitor c=7.79706e-17
C68 (\6\:n0 VSS) capacitor c=6.87197e-17
C69 (\8\:S0b VSS) capacitor c=1.92741e-17
C70 (\2\:Cp VSS) capacitor c=5.57302e-17
C71 (\2\:n1 VSS) capacitor c=1.25614e-17
C72 (\4\:A VSS) capacitor c=4.34801e-17
C73 (\7\:S0 VSS) capacitor c=6.21927e-17
C74 (\8\:S0 VSS) capacitor c=2.13974e-17
C75 (\5\:S0b VSS) capacitor c=7.63005e-17
C76 (\6\:S0b VSS) capacitor c=1.0109e-16
C77 (\7\:S0b VSS) capacitor c=9.23995e-17
C78 (\4\:n0 VSS) capacitor c=3.85292e-17
C79 (\5\:n0 VSS) capacitor c=1.08629e-16
C80 (\7\:S1 VSS) capacitor c=6.8221e-17
C81 (\7\:S1b VSS) capacitor c=9.12887e-17
C82 (\8\:S1b VSS) capacitor c=5.32284e-17
C83 (\9\:S1b VSS) capacitor c=1.35984e-16
C84 (\7\:Cp VSS) capacitor c=1.12894e-16
C85 (\8\:Cp VSS) capacitor c=6.89853e-17
C86 (\4\:C VSS) capacitor c=2.00646e-17
C87 (\5\:n1 VSS) capacitor c=1.98457e-16
C88 (\3\:VDD VSS) capacitor c=3.42821e-17
C89 (\4\:VDD VSS) capacitor c=2.13196e-17
C90 (\7\:VDD VSS) capacitor c=1.33858e-17
Rk24 (Y \2\:Y) resistor r=0.03898 c=0
Rk25 (Y \4\:Y) resistor r=0.2579 c=0
Rk11 (\4\:B B) resistor r=0.01575 c=0
Rk2 (\7\:S0 S0) resistor r=0.3907 c=0
Rk3 (S0 \8\:S0) resistor r=0.08178 c=0
Rk26 (\2\:VSS \4\:VSS) resistor r=0.4832 c=0
Rk27 (\4\:VSS \5\:VSS) resistor r=0.2831 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.511 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.1577 c=0
Rk31 (\8\:VSS VSS) resistor r=0.1199 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.431 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.2925 c=0
Rk33 (\6\:VSS \12\:VSS) resistor r=0.2872 c=0
Rk34 (\8\:VSS \14\:VSS) resistor r=0.2827 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.04329 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.4599 c=0
Rk37 (\4\:VDD \6\:VDD) resistor r=0.1577 c=0
Rk39 (\7\:VDD VDD) resistor r=0.1349 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.416 c=0
Rk40 (\3\:VDD \8\:VDD) resistor r=0.3323 c=0
Rk41 (\8\:VDD \10\:VDD) resistor r=0.3761 c=0
Rk42 (\4\:VDD \12\:VDD) resistor r=0.2903 c=0
Rk43 (\7\:VDD \14\:VDD) resistor r=0.2947 c=0
Rk21 (\4\:C C) resistor r=0.02497 c=0
Rk1 (A \4\:A) resistor r=0.02686 c=0
Rk12 (\7\:S1 S1) resistor r=0.2648 c=0
Rk13 (S1 \8\:S1) resistor r=0.0121 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4094 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4976 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09145 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.5395 c=0
Rk8 (\4\:n0 \5\:n0) resistor r=0.1904 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.4553 c=0
Rk10 (\5\:n0 \9\:n0) resistor r=0.5159 c=0
Rk22 (\5\:n1 \7\:n1) resistor r=1.5381 c=0
Rk23 (\7\:n1 \9\:n1) resistor r=0.5362 c=0
Rk14 (\6\:S1b \7\:S1b) resistor r=0.7859 c=0
Rk15 (\7\:S1b \8\:S1b) resistor r=0.2234 c=0
Rk16 (\7\:S1b \9\:S1b) resistor r=0.4751 c=0
Rk17 (\9\:S1b \11\:S1b) resistor r=0.5587 c=0
Rk18 (\6\:Cp \7\:Cp) resistor r=0.4613 c=0
Rk19 (\7\:Cp \8\:Cp) resistor r=0.2969 c=0
Rk20 (\7\:Cp \10\:Cp) resistor r=0.3676 c=0
Rl9 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl10 (\2\:B \3\:B) resistor r=156.925 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=24.2328 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=156.925 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=39.1533 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=144.923 c=0
Rl23 (\2\:C \3\:C) resistor r=72.2527 c=0
Rl22 (\1\:C \2\:C) resistor r=40.3846 c=0
Rl3 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl4 (\2\:A \3\:A) resistor r=87.2302 c=0
Rl21 (\5\:S1 \6\:S1) resistor r=74.5541 c=0
Rl20 (\4\:S1 \5\:S1) resistor r=137.694 c=0
Rl16 (\2\:S1 \3\:S1) resistor r=238.016 c=0
Rl15 (\1\:S1 \2\:S1) resistor r=95.3867 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=60.4896 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl11 (n0 \2\:n0) resistor r=144.923 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rl24 (n1 \2\:n1) resistor r=34.3295 c=0
Rl26 (\2\:n1 \4\:n1) resistor r=49.7141 c=0
Rl25 (\2\:n1 \3\:n1) resistor r=1.2666 c=0
Rl14 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl13 (S1b \2\:S1b) resistor r=51.1559 c=0
Rl18 (\2\:Cp \3\:Cp) resistor r=158.895 c=0
Rl19 (\2\:Cp \4\:Cp) resistor r=86.2526 c=0
Rl17 (Cp \2\:Cp) resistor r=2.0213 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz11 (\5\:VDD \6\:VDD) resistor r=6.25 c=0
Rz12 (\5\:VDD \8\:VDD) resistor r=10.7143 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (\5\:Cp \6\:Cp) resistor r=75 c=0
Ry6 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry4 (\9\:Cp \10\:Cp) resistor r=62 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx13 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx8 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx9 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx10 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx11 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx12 (Cp \8\:Cp) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn2 (n2 \3\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.842e-14 ps=6.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn3 (\6\:n0 S0b n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=3.842e-14 \
        ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.55e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn5 (\6\:n0 \6\:S0 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.82e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (n4 \3\:B \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.51e-14 ps=6.1e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.395e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn7 (n6 \3\:n0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.175e-14 ps=6.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=1.19e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn8 (\8\:n1 S1b n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.175e-14 \
        ad=5.8e-14 ps=5.9e-07 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.685e-06 sb=9.95e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn10 (\8\:n1 \1\:S1 n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.8e-14 ps=6.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn9 (n8 \4\:Cp \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn1 (\5\:S1b \4\:S1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn6 (\5\:Cp \1\:C \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=2.03e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn11 (\1\:Y \4\:n1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=3.64e-14 ps=8.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.39423e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp11 (\3\:Y n1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=5.46e-14 ps=1.51e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.1609e-07 sb=1.4e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
ends MXI3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:09 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI3X2
// View name: extracted

simulator lang=spectre

subckt MXI3X2 A B C S0 S1 VDD VSS Y
mp6 (\4\:Cp \1\:C \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.6e-07 sd=160n sca=19.7685 \
        scb=0.0219319 scc=0.000700056 m=(1)
mp1 (\9\:S1b \4\:S1 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87349e-06 sd=160n sca=15.3753 \
        scb=0.0145715 scc=0.000753786 m=(1)
mp9 (n9 \3\:Cp \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=2.472e-14 ps=1.62e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.77488e-06 sd=160n sca=14.5741 \
        scb=0.0142021 scc=0.000753562 m=(1)
mp10 (\8\:n1 \4\:S1b n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=8.17e-14 ps=6.6e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.71535e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp8 (\8\:n1 \7\:S1 n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.257e-14 ad=8.17e-14 ps=6.4e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.5007e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp7 (n7 n0 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.875e-14 ad=2.258e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.3507e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp2 (n3 \1\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=2.472e-14 ps=1.22e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4357e-06 sb=9.75e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp3 (\4\:n0 \1\:S0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.44e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54233e-06 sb=8.15e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp5 (\4\:n0 S0b n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.73e-14 \
        ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.6186e-06 sb=6.1e-07 sd=160n sca=11.2412 scb=0.00932961 \
        scc=0.000203582 m=(1)
mp4 (n5 \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71721e-06 sb=3.45e-07 sd=160n sca=12.0423 \
        scb=0.00969901 scc=0.000203806 m=(1)
mp0 (\8\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79349e-06 sb=1.4e-07 sd=160n sca=13.6165 \
        scb=0.011597 scc=0.00021346 m=(1)
C1 (A VSS) capacitor c=3.59441e-17
C2 (S0 VSS) capacitor c=3.73906e-17
C3 (VDD VSS) capacitor c=2.38235e-16
C4 (S1 VSS) capacitor c=3.85272e-17
C5 (Y VSS) capacitor c=3.64478e-17
C6 (C VSS) capacitor c=5.33199e-17
C7 (Cp VSS) capacitor c=2.75724e-17
C8 (S1b VSS) capacitor c=7.73254e-17
C9 (n1 VSS) capacitor c=1.75203e-16
C10 (n0 VSS) capacitor c=6.60631e-17
C11 (n2 VSS) capacitor c=7.72649e-18
C12 (S0b VSS) capacitor c=3.19964e-17
C13 (n9 VSS) capacitor c=2.57998e-18
C14 (n7 VSS) capacitor c=5.16138e-18
C15 (n3 VSS) capacitor c=4.46733e-18
C16 (\7\:S0 VSS) capacitor c=6.4509e-17
C17 (\1\:B VSS) capacitor c=4.43511e-17
C18 (\1\:S0 VSS) capacitor c=4.83228e-17
C19 (\1\:A VSS) capacitor c=5.39435e-17
C20 (\7\:S1 VSS) capacitor c=4.8061e-17
C21 (\4\:S1b VSS) capacitor c=3.69558e-17
C22 (\3\:Cp VSS) capacitor c=7.51112e-17
C23 (\4\:S1 VSS) capacitor c=3.53023e-17
C24 (\1\:C VSS) capacitor c=3.5655e-17
C25 (\5\:S0 VSS) capacitor c=2.26516e-17
C26 (\3\:B VSS) capacitor c=7.47866e-17
C27 (\3\:S0 VSS) capacitor c=6.21359e-17
C28 (\3\:S0b VSS) capacitor c=6.93956e-17
C29 (\4\:A VSS) capacitor c=4.44509e-17
C30 (\2\:n0 VSS) capacitor c=4.78841e-17
C31 (\5\:S1 VSS) capacitor c=5.05635e-17
C32 (\2\:Cp VSS) capacitor c=4.35343e-17
C33 (\3\:S1 VSS) capacitor c=4.84206e-17
C34 (\3\:C VSS) capacitor c=2.55401e-17
C35 (\6\:S0 VSS) capacitor c=5.28874e-17
C36 (\2\:B VSS) capacitor c=6.25876e-17
C37 (\4\:S0 VSS) capacitor c=6.10427e-17
C38 (\2\:S0b VSS) capacitor c=7.22851e-17
C39 (\2\:S0 VSS) capacitor c=4.5254e-17
C40 (\3\:A VSS) capacitor c=2.88375e-17
C41 (\4\:n1 VSS) capacitor c=1.62052e-17
C42 (\3\:n0 VSS) capacitor c=2.94282e-17
C43 (\8\:S1 VSS) capacitor c=4.09468e-17
C44 (\6\:S1 VSS) capacitor c=4.74851e-17
C45 (\3\:S1b VSS) capacitor c=3.08981e-17
C46 (\1\:S1 VSS) capacitor c=1.90381e-17
C47 (\2\:C VSS) capacitor c=2.57752e-17
C48 (\8\:S0b VSS) capacitor c=1.18287e-17
C49 (\1\:VDD VSS) capacitor c=3.09448e-17
C50 (\4\:n0 VSS) capacitor c=1.03386e-16
C51 (\3\:Y VSS) capacitor c=8.43376e-17
C52 (\8\:n1 VSS) capacitor c=7.2416e-17
C53 (\14\:VDD VSS) capacitor c=1.01451e-17
C54 (\9\:S1b VSS) capacitor c=4.971e-17
C55 (\4\:Cp VSS) capacitor c=7.04356e-17
C56 (\16\:VDD VSS) capacitor c=2.26538e-17
C57 (\3\:VDD VSS) capacitor c=5.69407e-17
C58 (\4\:S0b VSS) capacitor c=8.77301e-17
C59 (\8\:n0 VSS) capacitor c=5.49003e-17
C60 (\1\:Y VSS) capacitor c=4.81583e-17
C61 (\11\:n1 VSS) capacitor c=3.74024e-17
C62 (\7\:S1b VSS) capacitor c=2.84225e-17
C63 (\6\:Cp VSS) capacitor c=1.13654e-16
C64 (\2\:S1 VSS) capacitor c=2.04562e-17
C65 (\2\:S1b VSS) capacitor c=5.51012e-17
C66 (\2\:A VSS) capacitor c=4.23629e-17
C67 (\4\:C VSS) capacitor c=3.49625e-17
C68 (\8\:Cp VSS) capacitor c=5.63348e-17
C69 (\5\:S1b VSS) capacitor c=7.06684e-17
C70 (\6\:S1b VSS) capacitor c=6.67255e-17
C71 (\9\:S1 VSS) capacitor c=5.41968e-17
C72 (\10\:S1 VSS) capacitor c=3.64545e-17
C73 (\11\:S1 VSS) capacitor c=4.82166e-17
C74 (\12\:S1 VSS) capacitor c=4.24454e-17
C75 (\10\:n1 VSS) capacitor c=6.70733e-17
C76 (\13\:n1 VSS) capacitor c=4.15572e-17
C77 (\5\:A VSS) capacitor c=9.58299e-17
C78 (\6\:n0 VSS) capacitor c=1.79878e-16
C79 (\7\:n0 VSS) capacitor c=7.61067e-17
C80 (\4\:B VSS) capacitor c=1.05268e-16
C81 (\8\:S0 VSS) capacitor c=1.17965e-17
C82 (\9\:S0 VSS) capacitor c=7.64572e-17
C83 (\10\:S0 VSS) capacitor c=5.75236e-17
C84 (\11\:S0 VSS) capacitor c=5.92737e-17
C85 (\6\:S0b VSS) capacitor c=9.20347e-17
C86 (\7\:S0b VSS) capacitor c=5.07503e-17
C87 (\5\:VDD VSS) capacitor c=1.77991e-16
C88 (\8\:VDD VSS) capacitor c=1.1423e-17
C89 (\9\:VDD VSS) capacitor c=8.83105e-18
Rk16 (\5\:A A) resistor r=0.04353 c=0
Rk21 (\8\:S0 \9\:S0) resistor r=0.05586 c=0
Rk24 (\10\:S0 S0) resistor r=0.06973 c=0
Rk22 (\9\:S0 \10\:S0) resistor r=0.4053 c=0
Rk23 (\9\:S0 \11\:S0) resistor r=0.4552 c=0
Rk28 (\2\:VDD \4\:VDD) resistor r=0.3253 c=0
Rk29 (\4\:VDD \5\:VDD) resistor r=0.393 c=0
Rk31 (\5\:VDD \7\:VDD) resistor r=0.3529 c=0
Rk32 (\7\:VDD \8\:VDD) resistor r=0.1876 c=0
Rk34 (\9\:VDD VDD) resistor r=0.03211 c=0
Rk33 (\8\:VDD \9\:VDD) resistor r=0.3302 c=0
Rk37 (\8\:VDD \15\:VDD) resistor r=0.07323 c=0
Rk38 (\9\:VDD \17\:VDD) resistor r=0.272 c=0
Rk8 (\10\:S1 S1) resistor r=0.2464 c=0
Rk7 (\9\:S1 \10\:S1) resistor r=0.2684 c=0
Rk9 (S1 \11\:S1) resistor r=0.1675 c=0
Rk10 (\10\:S1 \12\:S1) resistor r=0.17 c=0
Rk14 (Y \2\:Y) resistor r=0.1477 c=0
Rk15 (Y \4\:Y) resistor r=0.1705 c=0
Rk39 (\2\:VSS \4\:VSS) resistor r=0.2557 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.377 c=0
Rk42 (\5\:VSS \7\:VSS) resistor r=0.337 c=0
Rk44 (\8\:VSS VSS) resistor r=0.3632 c=0
Rk43 (\7\:VSS \8\:VSS) resistor r=0.1876 c=0
Rk45 (VSS \10\:VSS) resistor r=0.362 c=0
Rk48 (\8\:VSS \16\:VSS) resistor r=0.07323 c=0
Rk1 (\4\:C C) resistor r=0.1907 c=0
Rk20 (\4\:B B) resistor r=0.01192 c=0
Rk2 (\5\:Cp \7\:Cp) resistor r=0.4443 c=0
Rk3 (\7\:Cp \8\:Cp) resistor r=0.5282 c=0
Rk4 (\5\:S1b \6\:S1b) resistor r=0.3871 c=0
Rk5 (\6\:S1b \8\:S1b) resistor r=0.1189 c=0
Rk6 (\6\:S1b \10\:S1b) resistor r=0.2832 c=0
Rk11 (\9\:n1 \10\:n1) resistor r=0.469 c=0
Rk12 (\10\:n1 \12\:n1) resistor r=0.2827 c=0
Rk13 (\10\:n1 \13\:n1) resistor r=0.1751 c=0
Rk17 (\5\:n0 \6\:n0) resistor r=0.8156 c=0
Rk18 (\6\:n0 \7\:n0) resistor r=0.599 c=0
Rk19 (\6\:n0 \9\:n0) resistor r=0.2811 c=0
Rk25 (\5\:S0b \6\:S0b) resistor r=0.7703 c=0
Rk26 (\6\:S0b \7\:S0b) resistor r=0.4323 c=0
Rk27 (\6\:S0b \9\:S0b) resistor r=0.0474 c=0
Rl21 (\1\:A \2\:A) resistor r=129.649 c=0
Rl23 (\2\:A \4\:A) resistor r=131.572 c=0
Rl22 (\2\:A \3\:A) resistor r=10.9341 c=0
Rl31 (\6\:S0 \7\:S0) resistor r=261.516 c=0
Rl30 (\5\:S0 \6\:S0) resistor r=24.7951 c=0
Rl27 (\3\:S0 \4\:S0) resistor r=69.4451 c=0
Rl24 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl12 (\7\:S1 \8\:S1) resistor r=29.5379 c=0
Rl8 (\5\:S1 \6\:S1) resistor r=29.5379 c=0
Rl5 (\2\:S1 \4\:S1) resistor r=34.3295 c=0
Rl4 (\2\:S1 \3\:S1) resistor r=103.56 c=0
Rl3 (\1\:S1 \2\:S1) resistor r=1.2713 c=0
Rl1 (\1\:C \2\:C) resistor r=110.771 c=0
Rl2 (\2\:C \3\:C) resistor r=37.6944 c=0
Rl28 (\1\:B \2\:B) resistor r=91.0764 c=0
Rl29 (\2\:B \3\:B) resistor r=154.538 c=0
Rl7 (\2\:Cp \3\:Cp) resistor r=146.154 c=0
Rl6 (Cp \2\:Cp) resistor r=31.0981 c=0
Rl11 (\2\:S1b \4\:S1b) resistor r=51.8781 c=0
Rl9 (S1b \2\:S1b) resistor r=217.124 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=8.9152 c=0
Rl17 (n1 \4\:n1) resistor r=7.924 c=0
Rl13 (n0 \2\:n0) resistor r=146.154 c=0
Rl14 (\2\:n0 \3\:n0) resistor r=68.4636 c=0
Rl25 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl26 (\2\:S0b \3\:S0b) resistor r=228.4 c=0
Rz7 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz8 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\6\:Cp \7\:Cp) resistor r=75 c=0
Rz2 (\7\:S1b \8\:S1b) resistor r=75 c=0
Rz3 (\12\:n1 \11\:n1) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz6 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry7 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry10 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry4 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry12 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry13 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:Cp \5\:Cp) resistor r=62 c=0
Ry2 (\9\:S1b \10\:S1b) resistor r=62 c=0
Ry3 (\9\:n1 \8\:n1) resistor r=62 c=0
Ry5 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry6 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx8 (\3\:A \5\:A) resistor r=45 c=0
Rx11 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx12 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx13 (\2\:S0 \11\:S0) resistor r=45 c=0
Rx4 (\8\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\1\:S1 \11\:S1) resistor r=45 c=0
Rx6 (\6\:S1 \12\:S1) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx10 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (Cp \8\:Cp) resistor r=45 c=0
Rx3 (\3\:S1b \5\:S1b) resistor r=45 c=0
Rx7 (\13\:n1 \4\:n1) resistor r=45 c=0
Rx9 (\3\:n0 \7\:n0) resistor r=45 c=0
Rx14 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn6 (\6\:Cp \3\:C \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=1.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn1 (\7\:S1b \3\:S1 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.62e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn9 (n8 \2\:Cp \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=3.19e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.355e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\11\:n1 \5\:S1 n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.553e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.09e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn8 (\11\:n1 S1b n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn7 (n6 \2\:n0 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=1.958e-14 ps=1.7e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=6.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n2 \4\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.18621e-07 sb=1.13e-06 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn3 (\8\:n0 \3\:S0b n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.38621e-07 sb=8.1e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn5 (\8\:n0 \3\:S0 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.43621e-07 sb=6.05e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn4 (n4 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=8.7e-15 ps=9.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.48621e-07 sb=5e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20862e-06 sb=1.4e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn11 (\1\:Y n1 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.49e-14 ad=4.16e-14 ps=1.65e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.86635e-07 sb=3.79712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp11_1__rcx (\3\:Y n1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.528e-14 ad=6.24e-14 ps=1.27e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.55192e-07 sb=9.5141e-07 sd=160n sca=19.7306 \
        scb=0.0167337 scc=0.00184272 m=(2)
ends MXI3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:10 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI3X4
// View name: extracted

simulator lang=spectre

subckt MXI3X4 A B C S0 S1 VDD VSS Y
mp6 (\7\:Cp \1\:C \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
mp1 (\8\:S1b \1\:S1 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96907e-06 sd=160n sca=14.9846 \
        scb=0.0143333 scc=0.000753595 m=(1)
mp2 (n3 \4\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.15e-14 ps=1.16e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96907e-06 sb=9.7e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp3 (\7\:n0 \2\:S0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp5 (\7\:n0 S0b n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.515e-14 \
        ad=3.87e-14 ps=8.5e-07 pd=7.9e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=6e-07 sd=160n sca=11.7777 scb=0.00984784 scc=0.000239304 m=(1)
mp4 (n5 \3\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=12.9609 scb=0.0107808 \
        scc=0.000241025 m=(1)
mp0 (\8\:S0b \7\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.7738 scb=0.0152661 \
        scc=0.000310434 m=(1)
C1 (Y VSS) capacitor c=1.53613e-17
C2 (S0 VSS) capacitor c=8.0565e-17
C3 (VDD VSS) capacitor c=2.34349e-16
C4 (S1 VSS) capacitor c=2.1001e-17
C5 (C VSS) capacitor c=5.56812e-17
C6 (B VSS) capacitor c=7.11293e-17
C7 (Cp VSS) capacitor c=7.17417e-17
C8 (S1b VSS) capacitor c=6.67401e-17
C9 (n1 VSS) capacitor c=3.16835e-16
C10 (n0 VSS) capacitor c=1.98471e-17
C11 (n2 VSS) capacitor c=5.87324e-18
C12 (S0b VSS) capacitor c=3.04138e-17
C13 (n9 VSS) capacitor c=1.74349e-19
C14 (n7 VSS) capacitor c=4.42758e-18
C15 (n3 VSS) capacitor c=2.42348e-18
C16 (\7\:S0 VSS) capacitor c=4.95478e-17
C17 (\3\:B VSS) capacitor c=4.0631e-17
C18 (\2\:S0 VSS) capacitor c=4.60745e-17
C19 (\4\:A VSS) capacitor c=5.71962e-17
C20 (\4\:n0 VSS) capacitor c=6.91075e-17
C21 (\6\:S1 VSS) capacitor c=4.96602e-17
C22 (\3\:S1b VSS) capacitor c=4.22967e-17
C23 (\3\:Cp VSS) capacitor c=7.96937e-17
C24 (\1\:S1 VSS) capacitor c=4.33122e-17
C25 (\1\:C VSS) capacitor c=2.83511e-17
C26 (\5\:S0 VSS) capacitor c=2.8538e-17
C27 (\1\:B VSS) capacitor c=7.46121e-17
C28 (\3\:S0 VSS) capacitor c=6.1736e-17
C29 (\3\:S0b VSS) capacitor c=6.09835e-17
C30 (\1\:A VSS) capacitor c=4.70642e-17
C31 (\3\:n0 VSS) capacitor c=2.68286e-17
C32 (\4\:S1 VSS) capacitor c=6.44865e-17
C33 (\3\:S1 VSS) capacitor c=4.56313e-17
C34 (\4\:C VSS) capacitor c=1.88726e-17
C35 (\6\:S0 VSS) capacitor c=4.74827e-17
C36 (\2\:B VSS) capacitor c=6.25008e-17
C37 (\4\:S0 VSS) capacitor c=6.02518e-17
C38 (\2\:S0b VSS) capacitor c=6.6485e-17
C39 (\1\:S0 VSS) capacitor c=5.52812e-17
C40 (\3\:A VSS) capacitor c=2.5013e-17
C41 (\7\:S1 VSS) capacitor c=3.486e-17
C42 (\2\:S1b VSS) capacitor c=5.8361e-17
C43 (\5\:S1 VSS) capacitor c=6.63249e-17
C44 (\2\:Cp VSS) capacitor c=7.60412e-17
C45 (\2\:S1 VSS) capacitor c=5.59491e-17
C46 (\3\:C VSS) capacitor c=1.09946e-17
C47 (\8\:S0b VSS) capacitor c=1.27954e-17
C48 (\1\:VDD VSS) capacitor c=3.10652e-17
C49 (\7\:n0 VSS) capacitor c=1.03679e-16
C50 (\23\:n1 VSS) capacitor c=5.32742e-17
C51 (\18\:VDD VSS) capacitor c=2.4007e-17
C52 (\8\:S1b VSS) capacitor c=1.37218e-17
C53 (\7\:Cp VSS) capacitor c=5.41236e-17
C54 (\20\:VDD VSS) capacitor c=2.54073e-17
C55 (\3\:VDD VSS) capacitor c=5.57411e-17
C56 (\4\:S0b VSS) capacitor c=4.81709e-17
C57 (\9\:n0 VSS) capacitor c=4.55614e-17
C58 (\1\:Y VSS) capacitor c=1.28333e-16
C59 (\21\:n1 VSS) capacitor c=5.73526e-17
C60 (\6\:S1b VSS) capacitor c=8.38065e-17
C61 (\5\:Cp VSS) capacitor c=1.29937e-16
C62 (\2\:C VSS) capacitor c=1.12628e-17
C63 (\2\:n0 VSS) capacitor c=2.9739e-17
C64 (\2\:A VSS) capacitor c=4.61e-17
C65 (\5\:C VSS) capacitor c=3.96941e-17
C66 (\4\:Cp VSS) capacitor c=1.08978e-16
C67 (\4\:S1b VSS) capacitor c=6.31468e-17
C68 (\5\:S1b VSS) capacitor c=1.06993e-16
C69 (\8\:S1 VSS) capacitor c=7.65574e-17
C70 (\9\:S1 VSS) capacitor c=7.13443e-17
C71 (\10\:S1 VSS) capacitor c=5.83852e-17
C72 (\19\:n1 VSS) capacitor c=3.77693e-17
C73 (\20\:n1 VSS) capacitor c=1.21342e-16
C74 (\4\:Y VSS) capacitor c=1.90081e-16
C75 (\5\:A VSS) capacitor c=1.2718e-16
C76 (\5\:n0 VSS) capacitor c=1.37097e-16
C77 (\6\:n0 VSS) capacitor c=2.08973e-16
C78 (\8\:S0 VSS) capacitor c=4.80371e-17
C79 (\10\:S0 VSS) capacitor c=6.17435e-17
C80 (\4\:B VSS) capacitor c=6.1617e-17
C81 (\6\:S0b VSS) capacitor c=9.64675e-17
C82 (\7\:S0b VSS) capacitor c=6.33574e-17
C83 (\5\:VDD VSS) capacitor c=2.40636e-16
C84 (\9\:VDD VSS) capacitor c=1.31893e-17
C85 (\10\:VDD VSS) capacitor c=9.22548e-18
Rk20 (\5\:A A) resistor r=0.002995 c=0
Rk19 (\4\:Y Y) resistor r=0.02589 c=0
Rk14 (\1\:Y \4\:Y) resistor r=0.2624 c=0
Rk24 (\8\:S0 S0) resistor r=0.26 c=0
Rk25 (S0 \9\:S0) resistor r=0.002412 c=0
Rk26 (\9\:S0 \10\:S0) resistor r=0.381 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.4377 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.2705 c=0
Rk48 (\5\:VDD \8\:VDD) resistor r=0.2805 c=0
Rk49 (\8\:VDD \9\:VDD) resistor r=0.1376 c=0
Rk51 (\10\:VDD VDD) resistor r=0.03965 c=0
Rk50 (\9\:VDD \10\:VDD) resistor r=0.373 c=0
Rk56 (\9\:VDD \19\:VDD) resistor r=0.2595 c=0
Rk57 (\10\:VDD \21\:VDD) resistor r=0.4157 c=0
Rk8 (\9\:S1 S1) resistor r=0.01708 c=0
Rk7 (\8\:S1 \9\:S1) resistor r=0.3487 c=0
Rk9 (\9\:S1 \10\:S1) resistor r=0.2158 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.4784 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2069 c=0
Rk35 (\5\:VSS \8\:VSS) resistor r=0.2655 c=0
Rk36 (\8\:VSS \9\:VSS) resistor r=0.1326 c=0
Rk38 (\10\:VSS VSS) resistor r=0.0597 c=0
Rk37 (\9\:VSS \10\:VSS) resistor r=0.358 c=0
Rk42 (\9\:VSS \18\:VSS) resistor r=0.2274 c=0
Rk43 (\10\:VSS \20\:VSS) resistor r=0.07346 c=0
Rk1 (\5\:C C) resistor r=0.1909 c=0
Rk27 (B \4\:B) resistor r=0.1568 c=0
Rk2 (\4\:Cp \6\:Cp) resistor r=0.7733 c=0
Rk3 (\6\:Cp \8\:Cp) resistor r=0.3027 c=0
Rk4 (\4\:S1b \5\:S1b) resistor r=0.3889 c=0
Rk5 (\5\:S1b \7\:S1b) resistor r=0.5109 c=0
Rk6 (\5\:S1b \9\:S1b) resistor r=0.06419 c=0
Rk10 (\19\:n1 \20\:n1) resistor r=0.1995 c=0
Rk11 (\20\:n1 \22\:n1) resistor r=0.4986 c=0
Rk12 (\20\:n1 \24\:n1) resistor r=0.4603 c=0
Rk21 (\5\:n0 \6\:n0) resistor r=1.0741 c=0
Rk22 (\6\:n0 \8\:n0) resistor r=0.6335 c=0
Rk23 (\6\:n0 \10\:n0) resistor r=0.2743 c=0
Rk28 (\5\:S0b \6\:S0b) resistor r=0.5308 c=0
Rk29 (\6\:S0b \7\:S0b) resistor r=0.4335 c=0
Rk30 (\6\:S0b \9\:S0b) resistor r=0.04758 c=0
Rl35 (\2\:A \4\:A) resistor r=82.1542 c=0
Rl33 (\1\:A \2\:A) resistor r=141.817 c=0
Rl34 (\2\:A \3\:A) resistor r=7.6652 c=0
Rl43 (\6\:S0 \7\:S0) resistor r=154.945 c=0
Rl42 (\5\:S0 \6\:S0) resistor r=36.5385 c=0
Rl39 (\3\:S0 \4\:S0) resistor r=49.9772 c=0
Rl36 (\1\:S0 \2\:S0) resistor r=53.733 c=0
Rl11 (\6\:S1 \7\:S1) resistor r=31.461 c=0
Rl8 (\4\:S1 \5\:S1) resistor r=86.5156 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=73.0769 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=108.791 c=0
Rl1 (\1\:C \2\:C) resistor r=59.3295 c=0
Rl3 (\2\:C \4\:C) resistor r=34.3295 c=0
Rl2 (\2\:C \3\:C) resistor r=1.2666 c=0
Rl41 (\2\:B \3\:B) resistor r=70.3297 c=0
Rl40 (\1\:B \2\:B) resistor r=121.154 c=0
Rl7 (\2\:Cp \3\:Cp) resistor r=168.591 c=0
Rl6 (Cp \2\:Cp) resistor r=78.8233 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=26.098 c=0
Rl9 (S1b \2\:S1b) resistor r=177.587 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=163.176 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=34.3295 c=0
Rl12 (n0 \2\:n0) resistor r=8.3086 c=0
Rl37 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl38 (\2\:S0b \3\:S0b) resistor r=162.694 c=0
Rz14 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz15 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz13 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\5\:Cp \6\:Cp) resistor r=75 c=0
Rz2 (\6\:S1b \7\:S1b) resistor r=75 c=0
Rz3 (\22\:n1 \21\:n1) resistor r=75 c=0
Rz6 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz7 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry10 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry8 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry9 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\7\:Cp \8\:Cp) resistor r=62 c=0
Ry2 (\8\:S1b \9\:S1b) resistor r=62 c=0
Ry3 (\24\:n1 \23\:n1) resistor r=31 c=0
Ry6 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry7 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx8 (\3\:A \5\:A) resistor r=45 c=0
Rx10 (\6\:S0 \8\:S0) resistor r=45 c=0
Rx11 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx12 (\1\:S0 \10\:S0) resistor r=45 c=0
Rx4 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx5 (\5\:S1 \9\:S1) resistor r=45 c=0
Rx6 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx13 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:Cp \4\:Cp) resistor r=45 c=0
Rx3 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\19\:n1 n1) resistor r=45 c=0
Rx9 (n0 \5\:n0) resistor r=45 c=0
Rx14 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn6 (\5\:Cp \4\:C \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.03e-14 ps=1.45e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn1 (\6\:S1b \3\:S1 \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.755e-14 ps=9.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mn2 (n2 \1\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.715e-14 ad=2.9e-14 ps=1.4e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70672e-06 sb=1.02e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (\9\:n0 \3\:S0b n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78276e-06 sb=7.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (\9\:n0 \3\:S0 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84638e-06 sb=5.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (n4 \1\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87897e-06 sb=4.65e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.77e-14 ps=6.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94259e-06 sb=2.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn9 (n8 Cp \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.87561e-07 sb=1.88988e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn10 (\21\:n1 \4\:S1 n8 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.793e-14 ps=5.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92561e-07 sb=1.8361e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn8 (\21\:n1 S1b n6 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=3.793e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.22561e-07 sb=1.71829e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn7 (n6 \3\:n0 \5\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=4.305e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.77561e-07 sb=1.58768e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn11_1__rcx (\1\:Y n1 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.733e-14 ad=4.355e-14 ps=1.325e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05606e-06 sb=1.47913e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(4)
mp9 (n9 \3\:Cp \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.02984e-07 sb=1.89887e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp10 (\23\:n1 \3\:S1b n9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.07984e-07 sb=1.83605e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp8 (\23\:n1 \6\:S1 n7 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=4.96e-14 ps=9.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12984e-07 sb=1.77323e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp7 (n7 \4\:n0 \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.495e-14 ps=1.16e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02984e-07 sb=1.715e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp11 (\4\:Y n1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.506e-14 ad=7.8e-14 ps=1.13e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.33269e-07 sb=1.42212e-06 sd=160n sca=17.7856 \
        scb=0.015626 scc=0.00148402 m=(4)
ends MXI3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:11 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI3XL
// View name: extracted

simulator lang=spectre

subckt MXI3XL A B C S0 S1 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.0659 scb=0.012282 \
        scc=0.000178056 m=(1)
mp2 (n3 \1\:A \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.875e-06 sd=160n sca=11.9366 \
        scb=0.00922608 scc=0.000149558 m=(1)
mp3 (\8\:n0 \8\:S0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.63e-06 sd=160n sca=10.9876 \
        scb=0.00862138 scc=0.000148876 m=(1)
mp5 (\8\:n0 \3\:S0b n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.425e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp4 (n5 \4\:B \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.762e-14 ps=7.7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.205e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp7 (n7 n0 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.72e-14 ps=7.7e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=9.9e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp8 (\5\:n1 \3\:S1 n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.837e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=8.65e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp10 (\5\:n1 \3\:S1b n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.837e-14 ps=7.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=5.95e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp9 (n9 \3\:Cp \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=3.117e-14 ps=1.42e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=4.05e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp1 (\10\:S1b \6\:S1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=3.01e-14 ps=1.42e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp6 (\9\:Cp \3\:C \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.892e-14 ad=3.44e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.2e-07 sd=160n sca=48.1151 \
        scb=0.0305074 scc=0.00589319 m=(1)
mp11 (\3\:Y n1 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.892e-14 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.4e-07 sd=160n sca=58.393 scb=0.0461946 \
        scc=0.00708003 m=(1)
C1 (Y VSS) capacitor c=1.70484e-17
C2 (B VSS) capacitor c=5.1486e-17
C3 (S0 VSS) capacitor c=8.37237e-17
C4 (VDD VSS) capacitor c=2.83672e-16
C5 (C VSS) capacitor c=6.31372e-17
C6 (A VSS) capacitor c=4.06195e-17
C7 (S0b VSS) capacitor c=6.85834e-17
C8 (n0 VSS) capacitor c=8.63547e-17
C9 (n4 VSS) capacitor c=9.23329e-18
C10 (n1 VSS) capacitor c=2.55835e-17
C11 (S1b VSS) capacitor c=7.36089e-17
C12 (Cp VSS) capacitor c=2.7365e-17
C13 (n5 VSS) capacitor c=5.73212e-18
C14 (n7 VSS) capacitor c=2.94524e-19
C15 (n9 VSS) capacitor c=4.32567e-18
C16 (\3\:C VSS) capacitor c=3.85446e-17
C17 (\6\:S1 VSS) capacitor c=4.75609e-17
C18 (\3\:Cp VSS) capacitor c=6.67317e-17
C19 (\3\:S1b VSS) capacitor c=4.4867e-17
C20 (\3\:S1 VSS) capacitor c=9.40424e-17
C21 (\4\:B VSS) capacitor c=3.34044e-17
C22 (\3\:S0b VSS) capacitor c=4.17573e-17
C23 (\8\:S0 VSS) capacitor c=3.31366e-17
C24 (\1\:A VSS) capacitor c=4.71848e-17
C25 (\1\:S0 VSS) capacitor c=3.26952e-17
C26 (\2\:n1 VSS) capacitor c=3.81385e-17
C27 (\1\:C VSS) capacitor c=2.7132e-17
C28 (\4\:S1 VSS) capacitor c=4.31402e-17
C29 (\4\:Cp VSS) capacitor c=3.7002e-17
C30 (\1\:S1 VSS) capacitor c=3.28557e-17
C31 (\3\:n0 VSS) capacitor c=4.82376e-17
C32 (\3\:B VSS) capacitor c=5.09758e-17
C33 (\5\:S0 VSS) capacitor c=5.0055e-17
C34 (\3\:A VSS) capacitor c=6.45288e-17
C35 (\4\:S0 VSS) capacitor c=4.61499e-17
C36 (\3\:n1 VSS) capacitor c=1.81383e-17
C37 (\2\:C VSS) capacitor c=2.47056e-17
C38 (\5\:S1 VSS) capacitor c=6.40231e-17
C39 (\2\:S1 VSS) capacitor c=6.57938e-17
C40 (\4\:S1b VSS) capacitor c=3.51389e-17
C41 (\2\:S1b VSS) capacitor c=2.96124e-17
C42 (\2\:n0 VSS) capacitor c=6.7049e-17
C43 (\1\:B VSS) capacitor c=2.72887e-17
C44 (\4\:S0b VSS) capacitor c=3.8293e-17
C45 (\7\:S0 VSS) capacitor c=6.79226e-17
C46 (\2\:S0b VSS) capacitor c=4.49779e-17
C47 (\2\:A VSS) capacitor c=6.19956e-17
C48 (\3\:S0 VSS) capacitor c=1.77368e-17
C49 (\3\:Y VSS) capacitor c=3.94898e-17
C50 (\9\:VDD VSS) capacitor c=4.43695e-17
C51 (\9\:Cp VSS) capacitor c=3.22831e-17
C52 (\10\:S1b VSS) capacitor c=9.66528e-17
C53 (\1\:VDD VSS) capacitor c=2.43011e-17
C54 (\5\:n1 VSS) capacitor c=2.29233e-16
C55 (\11\:VDD VSS) capacitor c=3.65732e-17
C56 (\8\:n0 VSS) capacitor c=6.00733e-17
C57 (\13\:VDD VSS) capacitor c=2.73899e-17
C58 (\10\:S0b VSS) capacitor c=9.03862e-17
C59 (\5\:VDD VSS) capacitor c=5.09511e-17
C60 (\1\:Y VSS) capacitor c=1.86461e-17
C61 (\5\:Cp VSS) capacitor c=4.35708e-17
C62 (\5\:S1b VSS) capacitor c=9.80568e-17
C63 (\7\:n1 VSS) capacitor c=8.40576e-17
C64 (\6\:n0 VSS) capacitor c=5.91073e-17
C65 (\8\:S0b VSS) capacitor c=1.90697e-17
C66 (\2\:S0 VSS) capacitor c=3.4856e-17
C67 (\2\:B VSS) capacitor c=3.63563e-17
C68 (\2\:Cp VSS) capacitor c=5.56159e-17
C69 (\9\:S0 VSS) capacitor c=5.97655e-17
C70 (\4\:A VSS) capacitor c=1.06948e-16
C71 (\5\:S0b VSS) capacitor c=7.50277e-17
C72 (\6\:S0b VSS) capacitor c=8.60172e-17
C73 (\7\:S0b VSS) capacitor c=7.54826e-17
C74 (\4\:n0 VSS) capacitor c=4.33664e-17
C75 (\5\:n0 VSS) capacitor c=1.08079e-16
C76 (\5\:B VSS) capacitor c=6.70422e-17
C77 (\7\:S1 VSS) capacitor c=6.06468e-17
C78 (\8\:S1 VSS) capacitor c=8.04786e-17
C79 (\7\:S1b VSS) capacitor c=8.67145e-17
C80 (\8\:S1b VSS) capacitor c=7.10925e-17
C81 (\9\:S1b VSS) capacitor c=1.15399e-16
C82 (\7\:Cp VSS) capacitor c=4.71764e-17
C83 (\8\:Cp VSS) capacitor c=7.70889e-17
C84 (\4\:C VSS) capacitor c=6.50105e-17
C85 (\4\:n1 VSS) capacitor c=1.58772e-16
C86 (\3\:VDD VSS) capacitor c=3.63188e-17
C87 (\4\:VDD VSS) capacitor c=1.97333e-17
C88 (\7\:VDD VSS) capacitor c=1.8857e-17
Rk26 (\2\:VSS \4\:VSS) resistor r=0.4682 c=0
Rk27 (\4\:VSS \5\:VSS) resistor r=0.2831 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.481 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.08756 c=0
Rk31 (\8\:VSS VSS) resistor r=0.2152 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.3358 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.3029 c=0
Rk33 (\6\:VSS \12\:VSS) resistor r=0.3048 c=0
Rk34 (\8\:VSS \14\:VSS) resistor r=0.31 c=0
Rk24 (Y \2\:Y) resistor r=0.05101 c=0
Rk25 (Y \4\:Y) resistor r=0.177 c=0
Rk11 (B \5\:B) resistor r=0.0276 c=0
Rk1 (\9\:S0 S0) resistor r=0.323 c=0
Rk2 (S0 \10\:S0) resistor r=0.002758 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.0433 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.4149 c=0
Rk37 (\4\:VDD \6\:VDD) resistor r=0.1026 c=0
Rk39 (\7\:VDD VDD) resistor r=0.2152 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.3358 c=0
Rk40 (\3\:VDD \8\:VDD) resistor r=0.3323 c=0
Rk41 (\8\:VDD \10\:VDD) resistor r=0.2761 c=0
Rk42 (\4\:VDD \12\:VDD) resistor r=0.2573 c=0
Rk43 (\7\:VDD \14\:VDD) resistor r=0.2581 c=0
Rk21 (C \4\:C) resistor r=0.03245 c=0
Rk3 (\4\:A A) resistor r=0.06271 c=0
Rk13 (\8\:S1 S1) resistor r=0.0121 c=0
Rk12 (\7\:S1 \8\:S1) resistor r=0.2673 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4039 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3352 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.1005 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6663 c=0
Rk8 (\4\:n0 \5\:n0) resistor r=0.1725 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.4141 c=0
Rk10 (\5\:n0 \9\:n0) resistor r=0.5343 c=0
Rk22 (\4\:n1 \6\:n1) resistor r=1.2541 c=0
Rk23 (\6\:n1 \8\:n1) resistor r=0.5517 c=0
Rk14 (\6\:S1b \7\:S1b) resistor r=0.562 c=0
Rk15 (\7\:S1b \8\:S1b) resistor r=0.4261 c=0
Rk16 (\7\:S1b \9\:S1b) resistor r=0.3089 c=0
Rk17 (\9\:S1b \11\:S1b) resistor r=0.5595 c=0
Rk18 (\6\:Cp \7\:Cp) resistor r=0.2093 c=0
Rk19 (\7\:Cp \8\:Cp) resistor r=0.3341 c=0
Rk20 (\7\:Cp \10\:Cp) resistor r=0.1198 c=0
Rl13 (\2\:B \4\:B) resistor r=34.3295 c=0
Rl12 (\2\:B \3\:B) resistor r=174.714 c=0
Rl11 (\1\:B \2\:B) resistor r=3.5213 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=43.9449 c=0
Rl3 (\2\:S0 \4\:S0) resistor r=165.099 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=13.091 c=0
Rl9 (\6\:S0 \8\:S0) resistor r=73.2449 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=193.751 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=1.2666 c=0
Rl26 (\2\:C \3\:C) resistor r=26.3736 c=0
Rl25 (\1\:C \2\:C) resistor r=42.3077 c=0
Rl4 (\1\:A \2\:A) resistor r=100.692 c=0
Rl5 (\2\:A \3\:A) resistor r=91.0764 c=0
Rl24 (\5\:S1 \6\:S1) resistor r=82.2464 c=0
Rl23 (\4\:S1 \5\:S1) resistor r=137.694 c=0
Rl19 (\2\:S1 \3\:S1) resistor r=226.477 c=0
Rl18 (\1\:S1 \2\:S1) resistor r=103.079 c=0
Rl10 (\3\:S0b \4\:S0b) resistor r=71.8456 c=0
Rl6 (S0b \2\:S0b) resistor r=29.5379 c=0
Rl14 (n0 \2\:n0) resistor r=159.79 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=29.5379 c=0
Rl27 (n1 \2\:n1) resistor r=92.3077 c=0
Rl28 (n1 \3\:n1) resistor r=24.2328 c=0
Rl17 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl16 (S1b \2\:S1b) resistor r=48.7687 c=0
Rl21 (\2\:Cp \3\:Cp) resistor r=166.588 c=0
Rl22 (\2\:Cp \4\:Cp) resistor r=86.2526 c=0
Rl20 (Cp \2\:Cp) resistor r=2.0213 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz11 (\5\:VDD \6\:VDD) resistor r=6.25 c=0
Rz12 (\5\:VDD \8\:VDD) resistor r=15 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (\5\:Cp \6\:Cp) resistor r=75 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry6 (\3\:Y \4\:Y) resistor r=62 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry4 (\9\:Cp \10\:Cp) resistor r=62 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx1 (\7\:S0 \9\:S0) resistor r=45 c=0
Rx2 (\3\:S0 \10\:S0) resistor r=45 c=0
Rx13 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx8 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx9 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx10 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx11 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx12 (Cp \8\:Cp) resistor r=45 c=0
mn0 (\8\:S0b \4\:S0 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn2 (n2 \3\:A \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.975e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\6\:n0 S0b n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.87e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn5 (\6\:n0 \5\:S0 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.665e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (n4 \3\:B \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.567e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.305e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn7 (n6 \3\:n0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.1e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn8 (\7\:n1 S1b n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.365e-14 ps=4.1e-07 pd=1.03e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.325e-06 sb=9.95e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn10 (\7\:n1 \1\:S1 n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=5.365e-14 ps=6.7e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=5.8e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn9 (n8 \4\:Cp \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.755e-14 ps=6.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\5\:S1b \4\:S1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn6 (\5\:Cp \1\:C \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (\1\:Y \2\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends MXI3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:12 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI4X1
// View name: extracted

simulator lang=spectre

subckt MXI4X1 A B C D S0 S1 VDD VSS Y
mp14 (\1\:Y \4\:n2 \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=5.46e-14 ps=1.3e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.47885e-07 sd=160n sca=26.6306 \
        scb=0.0275086 scc=0.00208721 m=(1)
C1 (S0 VSS) capacitor c=2.55605e-17
C2 (Y VSS) capacitor c=1.46138e-17
C3 (C VSS) capacitor c=4.17375e-17
C4 (D VSS) capacitor c=6.47081e-17
C5 (A VSS) capacitor c=3.77742e-17
C6 (VDD VSS) capacitor c=2.98245e-16
C7 (S1 VSS) capacitor c=7.96316e-17
C8 (B VSS) capacitor c=5.78253e-17
C9 (n2 VSS) capacitor c=2.30724e-17
C10 (S1b VSS) capacitor c=6.77704e-17
C11 (n1 VSS) capacitor c=8.46543e-17
C12 (net329 VSS) capacitor c=1.53557e-18
C13 (n0 VSS) capacitor c=6.4958e-17
C14 (net377 VSS) capacitor c=2.8562e-18
C15 (S0b VSS) capacitor c=6.57428e-17
C16 (net361 VSS) capacitor c=4.41776e-18
C17 (net284 VSS) capacitor c=2.09059e-18
C18 (net280 VSS) capacitor c=3.76654e-18
C19 (net320 VSS) capacitor c=2.0124e-18
C20 (net312 VSS) capacitor c=1.92492e-18
C21 (net304 VSS) capacitor c=3.32179e-18
C22 (\11\:S0 VSS) capacitor c=3.9446e-17
C23 (\3\:A VSS) capacitor c=4.92549e-17
C24 (\4\:S0 VSS) capacitor c=6.68896e-17
C25 (\5\:S0b VSS) capacitor c=3.8971e-17
C26 (\3\:B VSS) capacitor c=4.56708e-17
C27 (\1\:C VSS) capacitor c=4.02686e-17
C28 (\1\:S0 VSS) capacitor c=4.41211e-17
C29 (\1\:D VSS) capacitor c=6.45318e-17
C30 (\6\:S1 VSS) capacitor c=4.74666e-17
C31 (\3\:S1b VSS) capacitor c=4.65181e-17
C32 (\2\:n1 VSS) capacitor c=5.22059e-17
C33 (\1\:S1 VSS) capacitor c=3.66554e-17
C34 (\4\:n2 VSS) capacitor c=4.14685e-17
C35 (\9\:S0 VSS) capacitor c=3.58917e-17
C36 (\1\:A VSS) capacitor c=6.34792e-17
C37 (\7\:S0b VSS) capacitor c=5.28648e-17
C38 (\8\:S0 VSS) capacitor c=4.07647e-17
C39 (\1\:B VSS) capacitor c=6.23532e-17
C40 (\3\:C VSS) capacitor c=7.19817e-17
C41 (\3\:S0b VSS) capacitor c=6.56938e-17
C42 (\3\:S0 VSS) capacitor c=4.16024e-17
C43 (\4\:D VSS) capacitor c=3.17804e-17
C44 (\2\:n0 VSS) capacitor c=4.89457e-17
C45 (\4\:S1 VSS) capacitor c=8.89925e-17
C46 (\3\:S1 VSS) capacitor c=2.87222e-17
C47 (\3\:n2 VSS) capacitor c=3.4542e-17
C48 (\10\:S0 VSS) capacitor c=3.89378e-17
C49 (\2\:A VSS) capacitor c=7.09666e-17
C50 (\5\:S0 VSS) capacitor c=5.35026e-17
C51 (\8\:S0b VSS) capacitor c=1.99946e-17
C52 (\6\:S0b VSS) capacitor c=4.14971e-17
C53 (\7\:S0 VSS) capacitor c=4.93938e-17
C54 (\2\:B VSS) capacitor c=7.57659e-17
C55 (\2\:C VSS) capacitor c=5.20885e-17
C56 (\2\:S0 VSS) capacitor c=5.32773e-17
C57 (\4\:S0b VSS) capacitor c=2.7012e-17
C58 (\2\:S0b VSS) capacitor c=3.25325e-17
C59 (\3\:D VSS) capacitor c=1.09913e-17
C60 (\3\:n0 VSS) capacitor c=2.49549e-17
C61 (\7\:S1 VSS) capacitor c=4.32568e-17
C62 (\5\:S1 VSS) capacitor c=3.19486e-17
C63 (\2\:S1b VSS) capacitor c=6.73739e-17
C64 (\3\:n1 VSS) capacitor c=2.6682e-17
C65 (\2\:S1 VSS) capacitor c=3.39904e-17
C66 (\16\:S0b VSS) capacitor c=5.87882e-17
C67 (\1\:VDD VSS) capacitor c=3.36396e-17
C68 (\5\:n0 VSS) capacitor c=1.94854e-16
C69 (\10\:VDD VSS) capacitor c=3.11325e-17
C70 (\6\:n1 VSS) capacitor c=1.67738e-16
C71 (\12\:VDD VSS) capacitor c=3.03007e-17
C72 (\9\:n2 VSS) capacitor c=1.82491e-16
C73 (\14\:VDD VSS) capacitor c=4.22579e-17
C74 (\6\:S1b VSS) capacitor c=2.34987e-17
C75 (\16\:VDD VSS) capacitor c=4.13684e-17
C76 (\1\:Y VSS) capacitor c=6.73309e-17
C77 (\3\:VDD VSS) capacitor c=7.88557e-17
C78 (\14\:S0b VSS) capacitor c=8.43427e-17
C79 (\7\:n0 VSS) capacitor c=9.11958e-17
C80 (\4\:n1 VSS) capacitor c=9.45426e-17
C81 (\5\:n2 VSS) capacitor c=6.86669e-17
C82 (\8\:S1b VSS) capacitor c=4.0073e-17
C83 (\3\:Y VSS) capacitor c=4.1326e-17
C84 (\2\:n2 VSS) capacitor c=1.67701e-17
C85 (\2\:D VSS) capacitor c=3.35971e-17
C86 (\6\:S0 VSS) capacitor c=3.25537e-17
C87 (\4\:S1b VSS) capacitor c=5.77426e-17
C88 (\5\:S1b VSS) capacitor c=4.79769e-17
C89 (\8\:n2 VSS) capacitor c=1.39343e-16
C90 (\8\:S1 VSS) capacitor c=8.60886e-17
C91 (\9\:S1 VSS) capacitor c=1.17992e-16
C92 (\10\:S1 VSS) capacitor c=4.243e-17
C93 (\5\:D VSS) capacitor c=3.91002e-17
C94 (\8\:n1 VSS) capacitor c=1.29969e-16
C95 (\4\:C VSS) capacitor c=7.0806e-17
C96 (\5\:B VSS) capacitor c=3.38035e-17
C97 (\12\:S0 VSS) capacitor c=1.0591e-16
C98 (\13\:S0 VSS) capacitor c=8.99931e-17
C99 (\4\:n0 VSS) capacitor c=1.52103e-16
C100 (\4\:A VSS) capacitor c=7.86103e-17
C101 (\14\:S0 VSS) capacitor c=3.28367e-17
C102 (\15\:S0 VSS) capacitor c=4.21116e-17
C103 (\9\:S0b VSS) capacitor c=7.56424e-17
C104 (\10\:S0b VSS) capacitor c=1.31086e-16
C105 (\11\:S0b VSS) capacitor c=1.58793e-16
C106 (\12\:S0b VSS) capacitor c=1.01155e-16
C107 (\13\:S0b VSS) capacitor c=1.18523e-16
C108 (\5\:VDD VSS) capacitor c=3.31713e-17
C109 (\6\:VDD VSS) capacitor c=4.54988e-17
C110 (\8\:VDD VSS) capacitor c=8.44549e-18
C111 (\9\:VDD VSS) capacitor c=8.82111e-18
Rk19 (\12\:S0 \13\:S0) resistor r=0.4155 c=0
Rk23 (\14\:S0 S0) resistor r=0.08682 c=0
Rk24 (S0 \15\:S0) resistor r=0.1415 c=0
Rk2 (\4\:Y Y) resistor r=0.03725 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.3362 c=0
Rk15 (\4\:C C) resistor r=0.1378 c=0
Rk12 (\5\:D D) resistor r=0.1397 c=0
Rk22 (A \4\:A) resistor r=0.01935 c=0
Rk42 (\2\:VDD \4\:VDD) resistor r=0.3906 c=0
Rk43 (\4\:VDD \5\:VDD) resistor r=0.2506 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.4752 c=0
Rk45 (\6\:VDD \7\:VDD) resistor r=0.3249 c=0
Rk46 (\7\:VDD \8\:VDD) resistor r=0.208 c=0
Rk48 (\9\:VDD VDD) resistor r=0.1275 c=0
Rk47 (\8\:VDD \9\:VDD) resistor r=0.2153 c=0
Rk49 (\5\:VDD \11\:VDD) resistor r=0.1296 c=0
Rk50 (\6\:VDD \13\:VDD) resistor r=0.04332 c=0
Rk51 (\8\:VDD \15\:VDD) resistor r=0.2679 c=0
Rk52 (\9\:VDD \17\:VDD) resistor r=0.2656 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.2958 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2632 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.5414 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.2481 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.1493 c=0
Rk37 (\9\:VSS VSS) resistor r=0.1566 c=0
Rk36 (\8\:VSS \9\:VSS) resistor r=0.241 c=0
Rk38 (\5\:VSS \11\:VSS) resistor r=0.1952 c=0
Rk39 (\6\:VSS \13\:VSS) resistor r=0.3204 c=0
Rk40 (\8\:VSS \15\:VSS) resistor r=0.04332 c=0
Rk41 (\9\:VSS \17\:VSS) resistor r=0.04332 c=0
Rk10 (\9\:S1 S1) resistor r=0.5652 c=0
Rk9 (\8\:S1 \9\:S1) resistor r=0.5927 c=0
Rk11 (S1 \10\:S1) resistor r=0.2106 c=0
Rk16 (\4\:B \5\:B) resistor r=0.004455 c=0
Rk17 (\6\:B B) resistor r=0.004583 c=0
Rk18 (\5\:B \6\:B) resistor r=0.02633 c=0
Rk6 (\6\:n2 \7\:n2) resistor r=0.464 c=0
Rk7 (\7\:n2 \8\:n2) resistor r=0.9623 c=0
Rk8 (\7\:n2 \10\:n2) resistor r=0.04435 c=0
Rk3 (\4\:S1b \5\:S1b) resistor r=0.3065 c=0
Rk4 (\5\:S1b \7\:S1b) resistor r=0.07551 c=0
Rk5 (\5\:S1b \9\:S1b) resistor r=0.2355 c=0
Rk13 (\5\:n1 \7\:n1) resistor r=0.5786 c=0
Rk14 (\7\:n1 \8\:n1) resistor r=1.0167 c=0
Rk20 (\4\:n0 \6\:n0) resistor r=1.1895 c=0
Rk21 (\6\:n0 \8\:n0) resistor r=0.6104 c=0
Rk25 (\9\:S0b \10\:S0b) resistor r=0.3971 c=0
Rk26 (\10\:S0b \11\:S0b) resistor r=0.7041 c=0
Rk27 (\11\:S0b \12\:S0b) resistor r=0.7498 c=0
Rk28 (\10\:S0b \13\:S0b) resistor r=0.4034 c=0
Rk29 (\13\:S0b \15\:S0b) resistor r=0.6977 c=0
Rk30 (\15\:S0b \17\:S0b) resistor r=0.5124 c=0
Rl34 (\10\:S0 \11\:S0) resistor r=122.253 c=0
Rl33 (\9\:S0 \10\:S0) resistor r=59.6154 c=0
Rl27 (\4\:S0 \5\:S0) resistor r=112.694 c=0
Rl18 (\1\:S0 \2\:S0) resistor r=74.2328 c=0
Rl19 (\2\:S0 \3\:S0) resistor r=113.016 c=0
Rl30 (\6\:S0 \8\:S0) resistor r=91.9892 c=0
Rl28 (\5\:S0 \6\:S0) resistor r=82.6587 c=0
Rl29 (\6\:S0 \7\:S0) resistor r=92.233 c=0
Rl21 (\1\:C \2\:C) resistor r=39.1533 c=0
Rl22 (\2\:C \3\:C) resistor r=112.23 c=0
Rl14 (\1\:D \2\:D) resistor r=38.1757 c=0
Rl16 (\2\:D \4\:D) resistor r=130.483 c=0
Rl15 (\2\:D \3\:D) resistor r=1.2666 c=0
Rl32 (\2\:A \3\:A) resistor r=26.3736 c=0
Rl31 (\1\:A \2\:A) resistor r=186.538 c=0
Rl11 (\6\:S1 \7\:S1) resistor r=67.9995 c=0
Rl8 (\4\:S1 \5\:S1) resistor r=47.3097 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=37.2302 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=29.5379 c=0
Rl24 (\2\:B \3\:B) resistor r=74.4505 c=0
Rl23 (\1\:B \2\:B) resistor r=175.704 c=0
Rl3 (\2\:n2 \4\:n2) resistor r=53.5603 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=49.7141 c=0
Rl1 (n2 \2\:n2) resistor r=1.2713 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=24.2328 c=0
Rl9 (S1b \2\:S1b) resistor r=158.735 c=0
Rl6 (n1 \2\:n1) resistor r=173.661 c=0
Rl7 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl12 (n0 \2\:n0) resistor r=173.077 c=0
Rl13 (n0 \3\:n0) resistor r=49.2328 c=0
Rl26 (\7\:S0b \8\:S0b) resistor r=77.6148 c=0
Rl25 (\5\:S0b \6\:S0b) resistor r=66.5405 c=0
Rl20 (\3\:S0b \4\:S0b) resistor r=86.8284 c=0
Rl17 (S0b \2\:S0b) resistor r=31.461 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz13 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz3 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz2 (\8\:S1b \9\:S1b) resistor r=75 c=0
Rz4 (\4\:n1 \5\:n1) resistor r=75 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz6 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry3 (\9\:n2 \10\:n2) resistor r=62 c=0
Ry2 (\6\:S1b \7\:S1b) resistor r=62 c=0
Ry4 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry5 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry6 (\16\:S0b \17\:S0b) resistor r=62 c=0
Rx10 (\7\:S0 \12\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx14 (\10\:S0 \14\:S0) resistor r=45 c=0
Rx15 (\5\:S0 \15\:S0) resistor r=45 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\3\:D \5\:D) resistor r=45 c=0
Rx13 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\5\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx9 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (n2 \8\:n2) resistor r=45 c=0
Rx1 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx12 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx16 (\6\:S0b \9\:S0b) resistor r=45 c=0
Rx17 (\4\:S0b \11\:S0b) resistor r=45 c=0
Rx18 (\2\:S0b \12\:S0b) resistor r=45 c=0
Rx19 (\8\:S0b \13\:S0b) resistor r=45 c=0
mn14 (\3\:Y \3\:n2 \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.64e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.97981e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\8\:S1b \3\:S1 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.9e-14 ps=1.72e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn12 (net345 n1 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.725e-14 ad=8.7e-15 ps=1.34e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (\5\:n2 \4\:S1 net345 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn11 (\5\:n2 S1b net329 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn10 (net329 \2\:n0 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=2.972e-14 ps=9.8e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn8 (net377 \4\:D \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=3.625e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.8869e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn9 (\4\:n1 \3\:S0 net377 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.63224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn7 (\4\:n1 \3\:S0b net369 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62e-06 sb=1.42724e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn6 (net369 \3\:C \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.267e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=1.32224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (net361 \1\:B \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.267e-14 ad=3.625e-14 ps=1.22e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.00224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (\7\:n0 \8\:S0 net361 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.07241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\7\:n0 \7\:S0b net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.02241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (net349 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.85e-14 ad=2.247e-14 ps=1.6e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.02241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\14\:S0b \9\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.85e-14 ad=2.9e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.51724e-07 sb=2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\6\:S1b \1\:S1 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.26395e-07 sb=1.4e-07 sd=160n sca=47.6387 \
        scb=0.0298205 scc=0.00588813 m=(1)
mp12 (net284 \2\:n1 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=2.903e-14 ps=1.06e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27907e-07 sb=1.71581e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp13 (\9\:n2 \3\:S1b net284 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07907e-07 sb=1.57767e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp11 (\9\:n2 \6\:S1 net280 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.515e-14 ps=6.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.62907e-07 sb=1.38198e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp10 (net280 n0 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1842e-13 ad=2.473e-14 ps=1.89e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.22907e-07 sb=1.25919e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp8 (net320 \1\:D \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1842e-13 ad=1.29e-14 ps=1.89e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07035e-06 sb=1.05942e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp9 (\6\:n1 S0b net320 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.698e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17535e-06 sb=9.54419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp7 (\6\:n1 \1\:S0 net312 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=5.698e-14 ps=7.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=6.44419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp6 (net312 \1\:C \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.365e-14 ad=3.118e-14 ps=1.54e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67535e-06 sb=4.54419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp4 (net304 \3\:B \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.365e-14 ad=2.795e-14 ps=1.54e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38372e-07 sb=1.055e-06 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp5 (\5\:n0 \5\:S0b net304 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=6.558e-14 ps=6.9e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.72674e-07 sb=8.8e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp3 (\5\:n0 \4\:S0 net296 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04128e-06 sb=5.3e-07 sd=160n sca=10.6702 \
        scb=0.0075867 scc=7.76926e-05 m=(1)
mp2 (net296 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=1.29e-14 ps=9.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12186e-06 sb=4.25e-07 sd=160n sca=11.1175 \
        scb=0.00789061 scc=7.80015e-05 m=(1)
mp0 (\16\:S0b \11\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.01e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34035e-06 sb=1.4e-07 sd=160n sca=14.3466 \
        scb=0.0127067 scc=0.000142758 m=(1)
ends MXI4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:13 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI4X2
// View name: extracted

simulator lang=spectre

subckt MXI4X2 A B C D S0 S1 VDD VSS Y
mp0 (\19\:S0b \1\:S0 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.6555 scb=0.0150784 \
        scc=0.000248672 m=(1)
mp2 (net296 \1\:A \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=12.3871 \
        scb=0.00967424 scc=0.000140878 m=(1)
mp3 (\5\:n0 \7\:S0 net296 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.525e-14 ps=5.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=11.6786 scb=0.00891131 \
        scc=0.000138523 m=(1)
mp5 (\5\:n0 \3\:S0b net304 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=7.525e-14 ps=7.2e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.91826e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp4 (net304 \3\:B \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.227e-13 ad=3.117e-14 ps=1.81e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.75477e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp6 (net312 \1\:C \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.227e-13 ad=6.88e-14 ps=1.81e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.35465e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp7 (\4\:n1 \8\:S0 net312 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=9.783e-14 ps=1.07e-06 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=1.04058e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp9 (\4\:n1 \10\:S0b net320 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=9.782e-14 ps=9.1e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.10349e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp8 (net320 \1\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.845e-14 ad=5.16e-14 ps=1.92e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65116e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (net280 n0 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.845e-14 ad=4.73e-14 ps=1.92e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25349e-07 sb=1.96291e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp11 (\13\:n2 \3\:S1 net280 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.268e-14 ps=8.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.53372e-07 sb=1.76488e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp13 (\13\:n2 \3\:S1b net284 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=5.267e-14 ps=9.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02907e-07 sb=1.47488e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp12 (net284 n1 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6305e-13 ad=5.16e-14 ps=2.71e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14814e-06 sb=1.18988e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp1 (\5\:S1b \6\:S1 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1585e-13 ad=3.01e-14 ps=2.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64314e-06 sb=1.4e-07 sd=160n sca=48.554 \
        scb=0.0361963 scc=0.00572043 m=(1)
C1 (C VSS) capacitor c=1.1684e-16
C2 (S1 VSS) capacitor c=1.98851e-16
C3 (D VSS) capacitor c=1.14881e-16
C4 (VDD VSS) capacitor c=4.07843e-16
C5 (B VSS) capacitor c=1.32307e-16
C6 (S0 VSS) capacitor c=3.66188e-17
C7 (A VSS) capacitor c=2.41983e-17
C8 (Y VSS) capacitor c=4.6693e-17
C9 (S0b VSS) capacitor c=5.71673e-17
C10 (net349 VSS) capacitor c=9.72303e-19
C11 (n0 VSS) capacitor c=3.087e-17
C12 (net369 VSS) capacitor c=1.35355e-21
C13 (n1 VSS) capacitor c=4.17738e-17
C14 (net377 VSS) capacitor c=1.27379e-17
C15 (net329 VSS) capacitor c=4.37195e-19
C16 (n2 VSS) capacitor c=1.20375e-16
C17 (S1b VSS) capacitor c=4.69876e-17
C18 (net345 VSS) capacitor c=5.09667e-18
C19 (net304 VSS) capacitor c=3.44319e-18
C20 (net312 VSS) capacitor c=3.17899e-18
C21 (net320 VSS) capacitor c=4.09697e-18
C22 (net280 VSS) capacitor c=7.14473e-18
C23 (net284 VSS) capacitor c=8.54713e-18
C24 (\6\:S1 VSS) capacitor c=1.7851e-17
C25 (\3\:S1b VSS) capacitor c=3.98738e-17
C26 (\3\:S1 VSS) capacitor c=2.74018e-17
C27 (\1\:D VSS) capacitor c=4.33872e-17
C28 (\10\:S0b VSS) capacitor c=3.46878e-17
C29 (\8\:S0 VSS) capacitor c=2.73402e-17
C30 (\1\:C VSS) capacitor c=2.56316e-17
C31 (\3\:B VSS) capacitor c=3.48789e-17
C32 (\3\:S0b VSS) capacitor c=3.90959e-17
C33 (\7\:S0 VSS) capacitor c=6.75674e-17
C34 (\1\:A VSS) capacitor c=5.68242e-17
C35 (\1\:S0 VSS) capacitor c=5.02379e-17
C36 (\4\:S1 VSS) capacitor c=2.24267e-17
C37 (\3\:n1 VSS) capacitor c=1.93707e-17
C38 (\1\:S1 VSS) capacitor c=5.40379e-17
C39 (\3\:n0 VSS) capacitor c=4.737e-17
C40 (\3\:D VSS) capacitor c=3.72758e-17
C41 (\10\:S0 VSS) capacitor c=3.19568e-17
C42 (\6\:S0b VSS) capacitor c=1.55299e-17
C43 (\3\:C VSS) capacitor c=7.43396e-17
C44 (\1\:B VSS) capacitor c=6.10987e-17
C45 (\4\:S0 VSS) capacitor c=3.67543e-17
C46 (\3\:A VSS) capacitor c=7.96952e-17
C47 (\3\:S0 VSS) capacitor c=3.02297e-17
C48 (\5\:S1 VSS) capacitor c=2.26821e-17
C49 (\7\:n2 VSS) capacitor c=3.08395e-17
C50 (\2\:n1 VSS) capacitor c=3.98153e-17
C51 (\4\:S1b VSS) capacitor c=3.11565e-17
C52 (\2\:S1 VSS) capacitor c=4.74594e-17
C53 (\2\:S1b VSS) capacitor c=4.44306e-17
C54 (\2\:n0 VSS) capacitor c=3.34026e-17
C55 (\2\:D VSS) capacitor c=3.62069e-17
C56 (\11\:S0b VSS) capacitor c=1.84065e-17
C57 (\11\:S0 VSS) capacitor c=4.29901e-17
C58 (\8\:S0b VSS) capacitor c=4.67802e-17
C59 (\9\:S0b VSS) capacitor c=3.86235e-17
C60 (\9\:S0 VSS) capacitor c=4.0258e-17
C61 (\5\:S0b VSS) capacitor c=3.122e-17
C62 (\7\:S0b VSS) capacitor c=2.16702e-17
C63 (\2\:C VSS) capacitor c=4.39709e-17
C64 (\2\:B VSS) capacitor c=5.42478e-17
C65 (\5\:S0 VSS) capacitor c=6.43642e-17
C66 (\4\:S0b VSS) capacitor c=4.42548e-17
C67 (\6\:S0 VSS) capacitor c=6.491e-17
C68 (\2\:S0b VSS) capacitor c=2.34134e-17
C69 (\2\:A VSS) capacitor c=7.57464e-17
C70 (\2\:S0 VSS) capacitor c=4.26927e-17
C71 (\5\:S1b VSS) capacitor c=4.74432e-17
C72 (\1\:Y VSS) capacitor c=2.87427e-17
C73 (\13\:n2 VSS) capacitor c=1.73422e-16
C74 (\14\:VDD VSS) capacitor c=2.61587e-17
C75 (\4\:n1 VSS) capacitor c=1.35131e-16
C76 (\16\:VDD VSS) capacitor c=2.69191e-17
C77 (\5\:n0 VSS) capacitor c=3.15564e-16
C78 (\18\:VDD VSS) capacitor c=3.55379e-17
C79 (\19\:S0b VSS) capacitor c=6.5957e-17
C80 (\1\:VDD VSS) capacitor c=7.68927e-17
C81 (\7\:S1b VSS) capacitor c=2.1969e-16
C82 (\3\:Y VSS) capacitor c=5.09386e-17
C83 (\10\:n2 VSS) capacitor c=1.37739e-16
C84 (\7\:n1 VSS) capacitor c=2.92738e-17
C85 (\7\:n0 VSS) capacitor c=1.09461e-16
C86 (\15\:S0b VSS) capacitor c=1.07933e-16
C87 (\12\:S0 VSS) capacitor c=8.24141e-17
C88 (\13\:S0 VSS) capacitor c=6.2019e-17
C89 (\4\:A VSS) capacitor c=8.20004e-17
C90 (\12\:S0b VSS) capacitor c=6.86086e-17
C91 (\13\:S0b VSS) capacitor c=9.70066e-17
C92 (\14\:S0b VSS) capacitor c=7.24439e-17
C93 (\17\:S0b VSS) capacitor c=9.27513e-17
C94 (\18\:S0b VSS) capacitor c=2.70389e-17
C95 (\21\:S0b VSS) capacitor c=4.83273e-17
C96 (\22\:S0b VSS) capacitor c=4.08772e-17
C97 (\14\:S0 VSS) capacitor c=1.54711e-17
C98 (\15\:S0 VSS) capacitor c=1.09258e-16
C99 (\16\:S0 VSS) capacitor c=5.98645e-17
C100 (\17\:S0 VSS) capacitor c=8.63368e-17
C101 (\23\:S0b VSS) capacitor c=7.36766e-17
C102 (\24\:S0b VSS) capacitor c=4.8479e-17
C103 (\4\:n0 VSS) capacitor c=2.52564e-16
C104 (\6\:n1 VSS) capacitor c=2.03791e-16
C105 (\9\:n1 VSS) capacitor c=1.64378e-16
C106 (\9\:n2 VSS) capacitor c=1.1931e-16
C107 (\12\:n2 VSS) capacitor c=1.68367e-16
C108 (\7\:S1 VSS) capacitor c=3.02297e-17
C109 (\8\:S1 VSS) capacitor c=2.52952e-16
C110 (\9\:S1b VSS) capacitor c=2.86088e-16
C111 (\10\:S1b VSS) capacitor c=6.02595e-17
C112 (\3\:VDD VSS) capacitor c=8.45914e-17
C113 (\6\:VDD VSS) capacitor c=5.83377e-17
C114 (\7\:VDD VSS) capacitor c=4.89725e-17
C115 (\9\:VDD VSS) capacitor c=1.50181e-17
Rk11 (\4\:C C) resistor r=0.004024 c=0
Rk27 (\7\:S1 S1) resistor r=0.02903 c=0
Rk28 (S1 \8\:S1) resistor r=1.8942 c=0
Rk17 (\4\:D D) resistor r=0.003004 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.04244 c=0
Rk34 (\3\:VDD \5\:VDD) resistor r=0.4212 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.3024 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.8088 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.0901 c=0
Rk39 (\9\:VDD VDD) resistor r=0.1776 c=0
Rk38 (\8\:VDD \9\:VDD) resistor r=0.3735 c=0
Rk42 (\6\:VDD \15\:VDD) resistor r=0.04332 c=0
Rk43 (\7\:VDD \17\:VDD) resistor r=0.07405 c=0
Rk44 (\9\:VDD \19\:VDD) resistor r=0.2547 c=0
Rk4 (\4\:B B) resistor r=0.004054 c=0
Rk2 (\13\:S0 S0) resistor r=0.08435 c=0
Rk1 (\12\:S0 \13\:S0) resistor r=0.2795 c=0
Rk13 (\14\:S0 \15\:S0) resistor r=0.04804 c=0
Rk14 (\15\:S0 \16\:S0) resistor r=0.3039 c=0
Rk15 (\15\:S0 \17\:S0) resistor r=0.6578 c=0
Rk3 (A \4\:A) resistor r=0.03639 c=0
Rk25 (\2\:Y Y) resistor r=0.06314 c=0
Rk26 (Y \4\:Y) resistor r=0.1488 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.04244 c=0
Rk47 (\3\:VSS \5\:VSS) resistor r=0.2682 c=0
Rk48 (\5\:VSS \6\:VSS) resistor r=0.3033 c=0
Rk49 (\6\:VSS \7\:VSS) resistor r=0.7721 c=0
Rk50 (\7\:VSS \8\:VSS) resistor r=0.1277 c=0
Rk52 (\9\:VSS VSS) resistor r=0.1626 c=0
Rk51 (\8\:VSS \9\:VSS) resistor r=0.3886 c=0
Rk55 (\6\:VSS \15\:VSS) resistor r=0.1276 c=0
Rk56 (\7\:VSS \17\:VSS) resistor r=0.07405 c=0
Rk57 (\9\:VSS \19\:VSS) resistor r=0.1384 c=0
Rk5 (\12\:S0b \13\:S0b) resistor r=0.5985 c=0
Rk6 (\13\:S0b \14\:S0b) resistor r=0.2057 c=0
Rk7 (\14\:S0b \16\:S0b) resistor r=0.5189 c=0
Rk8 (\13\:S0b \17\:S0b) resistor r=0.4804 c=0
Rk9 (\14\:S0b \18\:S0b) resistor r=0.05533 c=0
Rk10 (\16\:S0b \20\:S0b) resistor r=0.5874 c=0
Rk12 (\21\:S0b \22\:S0b) resistor r=0.2283 c=0
Rk16 (\23\:S0b \24\:S0b) resistor r=0.1685 c=0
Rk18 (\4\:n0 \6\:n0) resistor r=2.2175 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.5216 c=0
Rk20 (\5\:n1 \6\:n1) resistor r=0.742 c=0
Rk21 (\6\:n1 \8\:n1) resistor r=0.2571 c=0
Rk22 (\6\:n1 \9\:n1) resistor r=1.2301 c=0
Rk23 (\9\:n2 \11\:n2) resistor r=0.8101 c=0
Rk24 (\12\:n2 \14\:n2) resistor r=1.0663 c=0
Rk29 (\6\:S1b \8\:S1b) resistor r=0.3648 c=0
Rk30 (\8\:S1b \9\:S1b) resistor r=1.7769 c=0
Rk31 (\9\:S1b \10\:S1b) resistor r=0.3459 c=0
Rl12 (\1\:C \2\:C) resistor r=30.7692 c=0
Rl13 (\2\:C \3\:C) resistor r=176.099 c=0
Rl38 (\5\:S1 \6\:S1) resistor r=24.7951 c=0
Rl37 (\4\:S1 \5\:S1) resistor r=37.8119 c=0
Rl26 (\2\:S1 \3\:S1) resistor r=27.9704 c=0
Rl25 (\1\:S1 \2\:S1) resistor r=101.282 c=0
Rl20 (\1\:D \2\:D) resistor r=100.692 c=0
Rl21 (\2\:D \3\:D) resistor r=104.538 c=0
Rl11 (\2\:B \3\:B) resistor r=26.3736 c=0
Rl10 (\1\:B \2\:B) resistor r=180.769 c=0
Rl18 (\10\:S0 \11\:S0) resistor r=93.4636 c=0
Rl16 (\8\:S0 \9\:S0) resistor r=71.8456 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=83.8482 c=0
Rl9 (\6\:S0 \7\:S0) resistor r=118.464 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=150.528 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=155.769 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=39.1379 c=0
Rl3 (\1\:A \2\:A) resistor r=45.3867 c=0
Rl4 (\2\:A \3\:A) resistor r=156.925 c=0
Rl19 (\10\:S0b \11\:S0b) resistor r=24.2328 c=0
Rl17 (\8\:S0b \9\:S0b) resistor r=122.246 c=0
Rl14 (\5\:S0b \6\:S0b) resistor r=33.8482 c=0
Rl15 (\6\:S0b \7\:S0b) resistor r=43.4636 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=56.9251 c=0
Rl5 (S0b \2\:S0b) resistor r=66.5405 c=0
Rl22 (n0 \2\:n0) resistor r=29.5379 c=0
Rl23 (\2\:n0 \3\:n0) resistor r=104.538 c=0
Rl28 (n1 \2\:n1) resistor r=106.925 c=0
Rl29 (\2\:n1 \3\:n1) resistor r=78.4003 c=0
Rl35 (\7\:n2 n2) resistor r=46.5267 c=0
Rl27 (\3\:S1b \4\:S1b) resistor r=42.9995 c=0
Rl24 (S1b \2\:S1b) resistor r=28.0211 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz8 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz9 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz5 (\4\:Y \3\:Y) resistor r=75 c=0
Rz12 (\15\:VSS \14\:VSS) resistor r=37.5 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz14 (\19\:VSS \18\:VSS) resistor r=37.5 c=0
Rz1 (\15\:S0b \16\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz4 (\11\:n2 \10\:n2) resistor r=75 c=0
Rz6 (\7\:S1b \8\:S1b) resistor r=75 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry10 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry11 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry5 (\2\:Y \1\:Y) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\19\:S0b \20\:S0b) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry3 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry4 (\14\:n2 \13\:n2) resistor r=62 c=0
Ry6 (\5\:S1b \6\:S1b) resistor r=62 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx21 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx22 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx16 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\6\:S0 \12\:S0) resistor r=45 c=0
Rx2 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx11 (\9\:S0 \14\:S0) resistor r=45 c=0
Rx12 (\11\:S0 \16\:S0) resistor r=45 c=0
Rx13 (\5\:S0 \17\:S0) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\7\:S0b \12\:S0b) resistor r=45 c=0
Rx6 (\4\:S0b \17\:S0b) resistor r=45 c=0
Rx7 (\2\:S0b \18\:S0b) resistor r=45 c=0
Rx9 (\9\:S0b \21\:S0b) resistor r=45 c=0
Rx10 (\5\:S0b \22\:S0b) resistor r=45 c=0
Rx14 (\11\:S0b \23\:S0b) resistor r=45 c=0
Rx15 (\8\:S0b \24\:S0b) resistor r=45 c=0
Rx17 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx18 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx19 (\9\:n2 \7\:n2) resistor r=45 c=0
Rx20 (\12\:n2 n2) resistor r=45 c=0
Rx23 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx24 (\2\:S1b \10\:S1b) resistor r=45 c=0
mn0 (\15\:S0b \3\:S0 \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.6069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net349 \3\:A \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=8.7e-15 ps=1.43e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.56379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (\7\:n0 S0b net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.61379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (\7\:n0 \4\:S0 net361 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=6.307e-14 ps=5.6e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.41379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (net361 \1\:B \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.045e-14 ad=1.957e-14 ps=1.51e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12138e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (net369 \3\:C \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.045e-14 ad=1.957e-14 ps=1.51e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45638e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn7 (\7\:n1 \6\:S0b net369 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=8.337e-14 ps=5.6e-07 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63638e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn9 (\7\:n1 \10\:S0 net377 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=8.337e-14 ps=1.01e-06 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn8 (net377 \3\:D \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=5.22e-14 ps=1.37e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn10 (net329 \3\:n0 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.94052e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn11 (\10\:n2 S1b net329 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78862e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn13 (\10\:n2 \1\:S1 net345 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.35e-14 ad=2.32e-14 ps=8.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.58362e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn12 (net345 \3\:n1 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0648e-13 ad=4.35e-14 ps=1.83e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.23862e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn1 (\7\:S1b \4\:S1 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.1975e-13 ad=2.03e-14 ps=1.83e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57069e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn14 (\3\:Y n2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.1311e-13 ad=4.16e-14 ps=1.83e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=6.21058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp14_1__rcx (\1\:Y n2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3945e-13 ad=6.24e-14 ps=2.405e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.64808e-07 sb=5.39551e-07 sd=160n sca=29.0159 \
        scb=0.0199093 scc=0.0031585 m=(2)
ends MXI4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:14 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI4X4
// View name: extracted

simulator lang=spectre

subckt MXI4X4 A B C D S0 S1 VDD VSS Y
mp0 (\15\:S0b \1\:S0 \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.9686e-06 sd=160n sca=15.5268 \
        scb=0.0147861 scc=0.000216306 m=(1)
mp2 (net296 \1\:A \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.45e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96384e-06 sd=160n sca=11.9362 \
        scb=0.00875484 scc=7.61791e-05 m=(1)
mp3 (\5\:n0 \7\:S0 net296 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=5.875e-14 ps=1.03e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.74093e-06 sd=160n sca=10.2921 \
        scb=0.00736325 scc=7.25636e-05 m=(1)
mp5 (\5\:n0 \3\:S0b net304 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=5.875e-14 ps=7.2e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.88837e-07 sb=1.53953e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp4 (net304 \3\:B \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.117e-14 ad=3.117e-14 ps=1.3e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17884e-06 sb=1.39372e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp6 (net312 \1\:C \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.117e-14 ad=1.505e-14 ps=1.3e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52884e-06 sb=1.12512e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp7 (\6\:n1 \8\:S0 net312 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64384e-06 sb=1.03686e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp9 (\6\:n1 \5\:S0b net320 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.988e-14 ad=3.44e-14 ps=1.08e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84884e-06 sb=8.79535e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp8 (net320 \1\:D \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=6.988e-14 ps=1.71e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98442e-06 sb=5.95581e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp1 (\5\:S1b \5\:S1 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3438e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=29.3395 scb=0.0284356 \
        scc=0.00289177 m=(1)
C1 (C VSS) capacitor c=1.30527e-16
C2 (S1 VSS) capacitor c=1.79584e-17
C3 (B VSS) capacitor c=1.1154e-16
C4 (S0 VSS) capacitor c=1.07769e-16
C5 (Y VSS) capacitor c=3.85591e-16
C6 (VDD VSS) capacitor c=3.45412e-16
C7 (S0b VSS) capacitor c=6.57292e-17
C8 (n0 VSS) capacitor c=4.03626e-17
C9 (net361 VSS) capacitor c=9.03112e-19
C10 (n1 VSS) capacitor c=5.4593e-17
C11 (net377 VSS) capacitor c=5.06927e-18
C12 (net329 VSS) capacitor c=2.28165e-18
C13 (n2 VSS) capacitor c=3.08504e-16
C14 (S1b VSS) capacitor c=3.96832e-17
C15 (net345 VSS) capacitor c=3.53517e-18
C16 (net304 VSS) capacitor c=3.79836e-18
C17 (net312 VSS) capacitor c=1.37987e-18
C18 (net320 VSS) capacitor c=9.18287e-18
C19 (net280 VSS) capacitor c=4.85195e-18
C20 (net284 VSS) capacitor c=7.74883e-18
C21 (\5\:S1 VSS) capacitor c=2.11617e-17
C22 (\3\:S1b VSS) capacitor c=3.10508e-17
C23 (\4\:S1 VSS) capacitor c=2.61166e-17
C24 (\1\:D VSS) capacitor c=2.89429e-17
C25 (\5\:S0b VSS) capacitor c=6.68372e-17
C26 (\8\:S0 VSS) capacitor c=6.15482e-17
C27 (\1\:C VSS) capacitor c=5.57462e-17
C28 (\3\:B VSS) capacitor c=4.42859e-17
C29 (\3\:S0b VSS) capacitor c=4.26035e-17
C30 (\7\:S0 VSS) capacitor c=3.99617e-17
C31 (\1\:A VSS) capacitor c=3.56921e-17
C32 (\1\:S0 VSS) capacitor c=4.36244e-17
C33 (\8\:S1 VSS) capacitor c=3.61249e-17
C34 (\3\:n1 VSS) capacitor c=2.66793e-17
C35 (\1\:S1 VSS) capacitor c=5.75278e-17
C36 (\3\:n0 VSS) capacitor c=4.71229e-17
C37 (\3\:D VSS) capacitor c=5.59132e-17
C38 (\10\:S0 VSS) capacitor c=4.59616e-17
C39 (\6\:S0b VSS) capacitor c=8.0519e-17
C40 (\3\:C VSS) capacitor c=7.24446e-17
C41 (\1\:B VSS) capacitor c=7.98744e-17
C42 (\4\:S0 VSS) capacitor c=2.90116e-17
C43 (\3\:A VSS) capacitor c=8.58798e-17
C44 (\3\:S0 VSS) capacitor c=4.10533e-17
C45 (\7\:S1 VSS) capacitor c=1.69661e-17
C46 (\8\:n2 VSS) capacitor c=1.91023e-17
C47 (\2\:n1 VSS) capacitor c=4.43775e-17
C48 (\4\:S1b VSS) capacitor c=3.3087e-17
C49 (\2\:S1b VSS) capacitor c=5.92797e-17
C50 (\3\:S1 VSS) capacitor c=3.47474e-17
C51 (\2\:n0 VSS) capacitor c=4.73311e-17
C52 (\2\:D VSS) capacitor c=4.19812e-17
C53 (\11\:S0 VSS) capacitor c=3.81858e-17
C54 (\9\:S0 VSS) capacitor c=4.86572e-17
C55 (\7\:S0b VSS) capacitor c=3.47051e-17
C56 (\2\:C VSS) capacitor c=6.10283e-17
C57 (\2\:B VSS) capacitor c=5.83685e-17
C58 (\5\:S0 VSS) capacitor c=6.21095e-17
C59 (\4\:S0b VSS) capacitor c=4.32816e-17
C60 (\6\:S0 VSS) capacitor c=5.23097e-17
C61 (\2\:S0b VSS) capacitor c=2.59252e-17
C62 (\2\:A VSS) capacitor c=5.94505e-17
C63 (\2\:S0 VSS) capacitor c=5.31097e-17
C64 (\5\:S1b VSS) capacitor c=2.60694e-17
C65 (\20\:n2 VSS) capacitor c=1.93384e-16
C66 (\17\:VDD VSS) capacitor c=2.97481e-17
C67 (\6\:n1 VSS) capacitor c=9.32785e-17
C68 (\19\:VDD VSS) capacitor c=3.5412e-17
C69 (\5\:n0 VSS) capacitor c=2.37567e-16
C70 (\21\:VDD VSS) capacitor c=2.84276e-17
C71 (\15\:S0b VSS) capacitor c=6.84063e-17
C72 (\1\:VDD VSS) capacitor c=6.8555e-17
C73 (\10\:S1b VSS) capacitor c=1.91661e-17
C74 (\17\:n2 VSS) capacitor c=1.08085e-16
C75 (\8\:n1 VSS) capacitor c=4.28016e-17
C76 (\7\:n0 VSS) capacitor c=1.23769e-16
C77 (\12\:S0b VSS) capacitor c=1.78552e-17
C78 (\2\:S1 VSS) capacitor c=5.63965e-17
C79 (\6\:S1 VSS) capacitor c=1.81264e-17
C80 (\4\:A VSS) capacitor c=4.14106e-17
C81 (\6\:A VSS) capacitor c=3.32526e-17
C82 (\12\:S0 VSS) capacitor c=8.31967e-17
C83 (\8\:S0b VSS) capacitor c=7.57435e-17
C84 (\9\:S0b VSS) capacitor c=1.38995e-16
C85 (\10\:S0b VSS) capacitor c=1.0002e-16
C86 (\11\:S0b VSS) capacitor c=1.155e-16
C87 (\14\:S0b VSS) capacitor c=7.27443e-17
C88 (\14\:S0 VSS) capacitor c=4.83079e-17
C89 (\15\:S0 VSS) capacitor c=6.87463e-17
C90 (\16\:S0 VSS) capacitor c=5.12109e-17
C91 (\17\:S0 VSS) capacitor c=5.56038e-17
C92 (\4\:D VSS) capacitor c=1.22401e-16
C93 (\4\:n0 VSS) capacitor c=2.4392e-16
C94 (\4\:n1 VSS) capacitor c=1.75228e-16
C95 (\5\:n1 VSS) capacitor c=2.39831e-16
C96 (\16\:n2 VSS) capacitor c=1.17641e-16
C97 (\19\:n2 VSS) capacitor c=1.75648e-16
C98 (\9\:S1 VSS) capacitor c=2.12928e-17
C99 (\10\:S1 VSS) capacitor c=2.38739e-16
C100 (\11\:S1 VSS) capacitor c=2.52861e-16
C101 (\7\:S1b VSS) capacitor c=3.33503e-16
C102 (\8\:S1b VSS) capacitor c=3.62456e-16
C103 (\9\:S1b VSS) capacitor c=4.83038e-17
C104 (\3\:VDD VSS) capacitor c=1.36423e-16
C105 (\7\:VDD VSS) capacitor c=5.47212e-17
C106 (\8\:VDD VSS) capacitor c=3.46913e-17
C107 (\10\:VDD VSS) capacitor c=1.57277e-17
Rk38 (\2\:VSS \3\:VSS) resistor r=0.03493 c=0
Rk41 (\3\:VSS \6\:VSS) resistor r=0.0851 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.5316 c=0
Rk43 (\7\:VSS \8\:VSS) resistor r=0.4537 c=0
Rk44 (\8\:VSS \9\:VSS) resistor r=0.2181 c=0
Rk46 (\10\:VSS VSS) resistor r=0.1551 c=0
Rk45 (\9\:VSS \10\:VSS) resistor r=0.3962 c=0
Rk50 (\7\:VSS \18\:VSS) resistor r=0.2704 c=0
Rk51 (\8\:VSS \20\:VSS) resistor r=0.07416 c=0
Rk52 (\10\:VSS \22\:VSS) resistor r=0.2425 c=0
Rk7 (\4\:C C) resistor r=0.002443 c=0
Rk33 (\10\:S1 S1) resistor r=0.02569 c=0
Rk31 (\9\:S1 \10\:S1) resistor r=0.1493 c=0
Rk32 (\10\:S1 \11\:S1) resistor r=2.0957 c=0
Rk17 (D \4\:D) resistor r=0.006814 c=0
Rk6 (B \4\:B) resistor r=0.003983 c=0
Rk5 (\13\:S0 S0) resistor r=0.003006 c=0
Rk4 (\12\:S0 \13\:S0) resistor r=0.4711 c=0
Rk14 (\14\:S0 \15\:S0) resistor r=0.2491 c=0
Rk15 (\15\:S0 \16\:S0) resistor r=0.3712 c=0
Rk16 (\15\:S0 \17\:S0) resistor r=0.2689 c=0
Rk1 (\4\:A \5\:A) resistor r=0.001415 c=0
Rk2 (A \6\:A) resistor r=0.001321 c=0
Rk3 (\4\:A \6\:A) resistor r=0.0301 c=0
Rk53 (\2\:VDD \3\:VDD) resistor r=0.193 c=0
Rk56 (\3\:VDD \6\:VDD) resistor r=0.05154 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.5316 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.5214 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.1503 c=0
Rk61 (\10\:VDD VDD) resistor r=0.1701 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.3811 c=0
Rk65 (\7\:VDD \18\:VDD) resistor r=0.123 c=0
Rk66 (\8\:VDD \20\:VDD) resistor r=0.123 c=0
Rk67 (\10\:VDD \22\:VDD) resistor r=0.2115 c=0
Rk8 (\8\:S0b \9\:S0b) resistor r=0.5022 c=0
Rk9 (\9\:S0b \10\:S0b) resistor r=0.4435 c=0
Rk10 (\10\:S0b \11\:S0b) resistor r=0.5528 c=0
Rk11 (\11\:S0b \13\:S0b) resistor r=0.07531 c=0
Rk12 (\9\:S0b \14\:S0b) resistor r=0.4543 c=0
Rk13 (\11\:S0b \16\:S0b) resistor r=0.647 c=0
Rk18 (\4\:n0 \6\:n0) resistor r=1.7103 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.6765 c=0
Rk20 (\4\:n1 \5\:n1) resistor r=1.4011 c=0
Rk21 (\5\:n1 \7\:n1) resistor r=0.7032 c=0
Rk22 (\5\:n1 \9\:n1) resistor r=0.3068 c=0
Rk23 (\16\:n2 \18\:n2) resistor r=0.7155 c=0
Rk24 (\19\:n2 \21\:n2) resistor r=1.207 c=0
Rk34 (\6\:S1b \7\:S1b) resistor r=0.2934 c=0
Rk35 (\7\:S1b \8\:S1b) resistor r=2.7243 c=0
Rk36 (\8\:S1b \9\:S1b) resistor r=0.2807 c=0
Rk37 (\7\:S1b \11\:S1b) resistor r=0.124 c=0
Rl12 (\1\:C \2\:C) resistor r=50.6918 c=0
Rl13 (\2\:C \3\:C) resistor r=189.153 c=0
Rl25 (\2\:S1 \4\:S1) resistor r=32.3738 c=0
Rl23 (\1\:S1 \2\:S1) resistor r=176.901 c=0
Rl24 (\2\:S1 \3\:S1) resistor r=35.0048 c=0
Rl43 (\5\:S1 \6\:S1) resistor r=37.3411 c=0
Rl45 (\6\:S1 \8\:S1) resistor r=129.649 c=0
Rl44 (\6\:S1 \7\:S1) resistor r=5.013 c=0
Rl18 (\1\:D \2\:D) resistor r=49.2328 c=0
Rl19 (\2\:D \3\:D) resistor r=187.694 c=0
Rl11 (\2\:B \3\:B) resistor r=76.9003 c=0
Rl10 (\1\:B \2\:B) resistor r=197.872 c=0
Rl17 (\10\:S0 \11\:S0) resistor r=44.9225 c=0
Rl14 (\8\:S0 \9\:S0) resistor r=71.8456 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=24.7951 c=0
Rl9 (\6\:S0 \7\:S0) resistor r=109.41 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=232.647 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=125.692 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=129.538 c=0
Rl3 (\1\:A \2\:A) resistor r=73.7687 c=0
Rl4 (\2\:A \3\:A) resistor r=181.461 c=0
Rl15 (\5\:S0b \6\:S0b) resistor r=283.747 c=0
Rl16 (\6\:S0b \7\:S0b) resistor r=24.2328 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=71.8456 c=0
Rl5 (S0b \2\:S0b) resistor r=31.9251 c=0
Rl20 (n0 \2\:n0) resistor r=29.5379 c=0
Rl21 (\2\:n0 \3\:n0) resistor r=110.307 c=0
Rl27 (n1 \2\:n1) resistor r=112.694 c=0
Rl28 (\2\:n1 \3\:n1) resistor r=78.4003 c=0
Rl35 (\8\:n2 n2) resistor r=10.9879 c=0
Rl26 (\3\:S1b \4\:S1b) resistor r=35.3072 c=0
Rl22 (S1b \2\:S1b) resistor r=61.5157 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz13 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz15 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz16 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\12\:S0b \13\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\18\:n2 \17\:n2) resistor r=75 c=0
Rz7 (\10\:S1b \11\:S1b) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry9 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry10 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry16 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry1 (\15\:S0b \16\:S0b) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\21\:n2 \20\:n2) resistor r=62 c=0
Ry7 (\5\:S1b \6\:S1b) resistor r=62 c=0
Rx5 (\2\:C \4\:C) resistor r=45 c=0
Rx17 (\7\:S1 \9\:S1) resistor r=45 c=0
Rx18 (\3\:S1 \11\:S1) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\6\:S0 \12\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx9 (\11\:S0 \14\:S0) resistor r=45 c=0
Rx10 (\5\:S0 \16\:S0) resistor r=45 c=0
Rx11 (\9\:S0 \17\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx6 (\7\:S0b \8\:S0b) resistor r=45 c=0
Rx7 (\2\:S0b \10\:S0b) resistor r=45 c=0
Rx8 (\4\:S0b \14\:S0b) resistor r=45 c=0
Rx13 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx15 (\16\:n2 \8\:n2) resistor r=45 c=0
Rx16 (\19\:n2 n2) resistor r=45 c=0
Rx19 (\4\:S1b \8\:S1b) resistor r=45 c=0
Rx20 (\2\:S1b \9\:S1b) resistor r=45 c=0
mn0 (\12\:S0b \3\:S0 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82259e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn2 (net349 \3\:A \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7731e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn3 (\7\:n0 S0b net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=9.425e-14 ps=4.1e-07 pd=1.59e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.74776e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn5 (\7\:n0 \4\:S0 net361 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=9.425e-14 ps=5.2e-07 pd=1.59e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.58e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn4 (net361 \1\:B \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=1.667e-14 ps=1.41e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.54138e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn6 (net369 \3\:C \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=1.957e-14 ps=1.41e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=2e-06 sd=160n sca=10.0732 scb=0.00911402 \
        scc=0.000253284 m=(1)
mn7 (\8\:n1 \6\:S0b net369 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn9 (\8\:n1 \10\:S0 net377 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.045e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=1.97103e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn8 (net377 \3\:D \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=3.045e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70793e-06 sb=1.93586e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\10\:S1b \8\:S1 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.137e-14 ad=2.03e-14 ps=1.07e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn10 (net329 \3\:n0 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=3.588e-14 ps=9.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28768e-06 sb=1.92585e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn11 (\17\:n2 S1b net329 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=3.28e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38963e-06 sb=1.90439e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn13 (\17\:n2 \1\:S1 net345 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=3.28e-14 ps=9.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48463e-06 sb=1.8561e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn12 (net345 \3\:n1 \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=5.432e-14 ps=1.24e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62829e-06 sb=1.69817e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn14_1__rcx (Y n2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.077e-14 ad=6.78e-14 ps=1.2075e-06 pd=1.075e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42269e-06 sb=1.26077e-06 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(4)
mp10 (net280 n0 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=6.82e-14 ps=1.71e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.00403e-07 sb=2e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp11 (\20\:n2 \4\:S1 net280 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=8.525e-14 ps=1.06e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.26935e-07 sb=1.9625e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp13 (\20\:n2 \3\:S1b net284 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=8.525e-14 ps=1.04e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.97097e-07 sb=1.86444e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp12 (net284 n1 \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.892e-13 ad=6.51e-14 ps=2.29e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.11097e-06 sb=1.64758e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp14_1__rcx (Y n2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4389e-13 ad=6.24e-14 ps=1.975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24128e-06 sb=1.10615e-06 sd=160n sca=28.7024 \
        scb=0.0198217 scc=0.00315848 m=(4)
ends MXI4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:15 2013 )
// Library name: gsclib045_hvt
// Cell name: MXI4XL
// View name: extracted

simulator lang=spectre

subckt MXI4XL A B C D S0 S1 VDD VSS Y
mp14 (\1\:Y n2 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.375e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.75e-07 sd=160n sca=52.2659 \
        scb=0.0376451 scc=0.00612616 m=(1)
mp1 (\6\:S1b \1\:S1 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.375e-14 ad=3.01e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.4e-07 sd=160n sca=47.5923 \
        scb=0.0297582 scc=0.00588779 m=(1)
mp12 (net284 \2\:n1 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.902e-14 ps=1.05e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27907e-07 sb=1.77872e-06 sd=160n sca=15.0112 \
        scb=0.0146307 scc=0.000816974 m=(1)
mp13 (\6\:n2 \3\:S1b net284 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07907e-07 sb=1.73267e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp11 (\6\:n2 \6\:S1 net280 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.3e-14 ps=6.6e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.52907e-07 sb=1.65128e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp10 (net280 n0 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0688e-13 ad=2.473e-14 ps=1.76e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12907e-07 sb=1.5843e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp8 (net320 \1\:D \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0688e-13 ad=1.613e-14 ps=1.76e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04291e-06 sb=1.44616e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp9 (\6\:n1 S0b net320 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=5.98e-14 ps=5.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16291e-06 sb=1.39593e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp7 (\6\:n1 \1\:S0 net312 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=5.98e-14 ps=7e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1586e-06 sb=1.62826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp6 (net312 \3\:C \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.333e-14 ad=2.903e-14 ps=1.32e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3386e-06 sb=1.44826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp4 (net304 \1\:B \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.333e-14 ad=5.16e-14 ps=1.32e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65209e-06 sb=1.08826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp5 (\6\:n0 \5\:S0b net304 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=6.01e-14 ps=9.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=8.03256e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp3 (\6\:n0 \4\:S0 net296 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.01e-14 ps=5.5e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.50267e-06 sb=6e-07 sd=160n sca=11.7109 \
        scb=0.00935053 scc=0.000188054 m=(1)
mp2 (net296 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=1.29e-14 ps=9.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54663e-06 sb=4.95e-07 sd=160n sca=12.2145 \
        scb=0.00974237 scc=0.000188593 m=(1)
mp0 (\16\:S0b \10\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.515e-14 ps=9.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66593e-06 sb=2.1e-07 sd=160n sca=16.0514 \
        scb=0.0157827 scc=0.00029851 m=(1)
C1 (S0 VSS) capacitor c=3.26166e-17
C2 (C VSS) capacitor c=5.58842e-17
C3 (D VSS) capacitor c=4.97577e-17
C4 (A VSS) capacitor c=4.21725e-17
C5 (VDD VSS) capacitor c=2.87466e-16
C6 (Y VSS) capacitor c=1.50258e-17
C7 (S1 VSS) capacitor c=6.91369e-17
C8 (B VSS) capacitor c=7.52501e-17
C9 (n2 VSS) capacitor c=2.8953e-17
C10 (S1b VSS) capacitor c=5.44214e-17
C11 (n1 VSS) capacitor c=7.89316e-17
C12 (net329 VSS) capacitor c=1.59848e-18
C13 (n0 VSS) capacitor c=5.81387e-17
C14 (net377 VSS) capacitor c=3.34855e-18
C15 (net369 VSS) capacitor c=4.71563e-19
C16 (S0b VSS) capacitor c=5.68199e-17
C17 (net284 VSS) capacitor c=1.73501e-18
C18 (net280 VSS) capacitor c=3.96567e-18
C19 (net320 VSS) capacitor c=2.31214e-18
C20 (net312 VSS) capacitor c=2.69754e-18
C21 (net304 VSS) capacitor c=7.31421e-18
C22 (\10\:S0 VSS) capacitor c=3.59669e-17
C23 (\3\:A VSS) capacitor c=4.84257e-17
C24 (\4\:S0 VSS) capacitor c=6.66714e-17
C25 (\5\:S0b VSS) capacitor c=4.50472e-17
C26 (\1\:B VSS) capacitor c=4.1684e-17
C27 (\3\:C VSS) capacitor c=4.66676e-17
C28 (\1\:S0 VSS) capacitor c=5.48783e-17
C29 (\1\:D VSS) capacitor c=5.13855e-17
C30 (\6\:S1 VSS) capacitor c=5.67128e-17
C31 (\3\:S1b VSS) capacitor c=4.70601e-17
C32 (\2\:n1 VSS) capacitor c=5.06302e-17
C33 (\1\:S1 VSS) capacitor c=3.87568e-17
C34 (\8\:S0 VSS) capacitor c=3.91862e-17
C35 (\1\:A VSS) capacitor c=5.86254e-17
C36 (\7\:S0b VSS) capacitor c=4.80192e-17
C37 (\7\:S0 VSS) capacitor c=2.76146e-17
C38 (\3\:B VSS) capacitor c=5.51643e-17
C39 (\1\:C VSS) capacitor c=8.19211e-17
C40 (\3\:S0b VSS) capacitor c=5.69611e-17
C41 (\3\:S0 VSS) capacitor c=3.94243e-17
C42 (\4\:D VSS) capacitor c=3.57025e-17
C43 (\2\:n0 VSS) capacitor c=4.84097e-17
C44 (\5\:S1 VSS) capacitor c=7.69363e-17
C45 (\3\:S1 VSS) capacitor c=2.83982e-17
C46 (\3\:n2 VSS) capacitor c=2.90438e-17
C47 (\9\:S0 VSS) capacitor c=4.44892e-17
C48 (\2\:A VSS) capacitor c=7.11622e-17
C49 (\5\:S0 VSS) capacitor c=7.89166e-17
C50 (\8\:S0b VSS) capacitor c=1.83868e-17
C51 (\6\:S0b VSS) capacitor c=3.47968e-17
C52 (\6\:S0 VSS) capacitor c=7.22639e-17
C53 (\2\:B VSS) capacitor c=6.16038e-17
C54 (\2\:C VSS) capacitor c=5.78304e-17
C55 (\4\:S0b VSS) capacitor c=3.95608e-17
C56 (\2\:S0 VSS) capacitor c=5.09454e-17
C57 (\2\:S0b VSS) capacitor c=3.41697e-17
C58 (\3\:D VSS) capacitor c=1.33092e-17
C59 (\3\:n0 VSS) capacitor c=3.07441e-17
C60 (\7\:S1 VSS) capacitor c=3.87367e-17
C61 (\4\:S1 VSS) capacitor c=2.54929e-17
C62 (\2\:S1b VSS) capacitor c=7.23617e-17
C63 (\3\:n1 VSS) capacitor c=2.80199e-17
C64 (\2\:S1 VSS) capacitor c=3.10948e-17
C65 (\2\:n2 VSS) capacitor c=3.28283e-17
C66 (\16\:S0b VSS) capacitor c=7.01578e-17
C67 (\1\:VDD VSS) capacitor c=3.78734e-17
C68 (\6\:n0 VSS) capacitor c=2.20136e-16
C69 (\10\:VDD VSS) capacitor c=4.05005e-17
C70 (\6\:n1 VSS) capacitor c=1.82287e-16
C71 (\12\:VDD VSS) capacitor c=1.77125e-17
C72 (\6\:n2 VSS) capacitor c=1.70052e-16
C73 (\14\:VDD VSS) capacitor c=4.41228e-17
C74 (\6\:S1b VSS) capacitor c=2.31748e-17
C75 (\16\:VDD VSS) capacitor c=1.84282e-17
C76 (\1\:Y VSS) capacitor c=3.22723e-17
C77 (\3\:VDD VSS) capacitor c=7.18574e-17
C78 (\14\:S0b VSS) capacitor c=7.56907e-17
C79 (\4\:n0 VSS) capacitor c=8.06008e-17
C80 (\4\:n1 VSS) capacitor c=1.12679e-16
C81 (\4\:n2 VSS) capacitor c=6.11305e-17
C82 (\8\:S1b VSS) capacitor c=4.08361e-17
C83 (\3\:Y VSS) capacitor c=3.64855e-17
C84 (\2\:D VSS) capacitor c=3.84483e-17
C85 (\4\:S1b VSS) capacitor c=4.18567e-17
C86 (\5\:S1b VSS) capacitor c=4.36e-17
C87 (\8\:n2 VSS) capacitor c=1.1955e-16
C88 (\8\:S1 VSS) capacitor c=8.47871e-17
C89 (\9\:S1 VSS) capacitor c=1.13809e-16
C90 (\10\:S1 VSS) capacitor c=4.95234e-17
C91 (\5\:D VSS) capacitor c=4.4575e-17
C92 (\8\:n1 VSS) capacitor c=1.35832e-16
C93 (\4\:C VSS) capacitor c=6.47332e-17
C94 (\4\:B VSS) capacitor c=4.13956e-17
C95 (\11\:S0 VSS) capacitor c=7.25311e-17
C96 (\12\:S0 VSS) capacitor c=9.36821e-17
C97 (\8\:n0 VSS) capacitor c=1.8168e-16
C98 (\6\:A VSS) capacitor c=8.3667e-17
C99 (\13\:S0 VSS) capacitor c=3.82875e-17
C100 (\14\:S0 VSS) capacitor c=3.55748e-17
C101 (\9\:S0b VSS) capacitor c=7.68839e-17
C102 (\10\:S0b VSS) capacitor c=1.2339e-16
C103 (\11\:S0b VSS) capacitor c=1.53404e-16
C104 (\12\:S0b VSS) capacitor c=9.59566e-17
C105 (\13\:S0b VSS) capacitor c=7.9041e-17
C106 (\5\:VDD VSS) capacitor c=3.09245e-17
C107 (\6\:VDD VSS) capacitor c=3.48243e-17
C108 (\8\:VDD VSS) capacitor c=1.02042e-17
C109 (\9\:VDD VSS) capacitor c=8.44466e-18
Rk16 (\11\:S0 \12\:S0) resistor r=0.4241 c=0
Rk22 (\13\:S0 S0) resistor r=0.1047 c=0
Rk23 (S0 \14\:S0) resistor r=0.1233 c=0
Rk14 (\4\:C C) resistor r=0.09376 c=0
Rk11 (\5\:D D) resistor r=0.1539 c=0
Rk19 (\4\:A A) resistor r=0.001419 c=0
Rk21 (\4\:A \6\:A) resistor r=0.04881 c=0
Rk20 (\5\:A \6\:A) resistor r=0.001419 c=0
Rk30 (\2\:VSS \4\:VSS) resistor r=0.3105 c=0
Rk31 (\4\:VSS \5\:VSS) resistor r=0.2957 c=0
Rk32 (\5\:VSS \6\:VSS) resistor r=0.5437 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.2129 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.1493 c=0
Rk36 (\9\:VSS VSS) resistor r=0.1691 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.2284 c=0
Rk37 (\5\:VSS \11\:VSS) resistor r=0.07381 c=0
Rk38 (\6\:VSS \13\:VSS) resistor r=0.2506 c=0
Rk39 (\8\:VSS \15\:VSS) resistor r=0.0433 c=0
Rk40 (\9\:VSS \17\:VSS) resistor r=0.0433 c=0
Rk41 (\2\:VDD \4\:VDD) resistor r=0.4516 c=0
Rk42 (\4\:VDD \5\:VDD) resistor r=0.3333 c=0
Rk43 (\5\:VDD \6\:VDD) resistor r=0.4735 c=0
Rk44 (\6\:VDD \7\:VDD) resistor r=0.2455 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.223 c=0
Rk47 (\9\:VDD VDD) resistor r=0.155 c=0
Rk46 (\8\:VDD \9\:VDD) resistor r=0.1726 c=0
Rk48 (\5\:VDD \11\:VDD) resistor r=0.1993 c=0
Rk49 (\6\:VDD \13\:VDD) resistor r=0.07381 c=0
Rk50 (\8\:VDD \15\:VDD) resistor r=0.2671 c=0
Rk51 (\9\:VDD \17\:VDD) resistor r=0.2193 c=0
Rk2 (\4\:Y Y) resistor r=0.03964 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.2247 c=0
Rk9 (\9\:S1 S1) resistor r=0.5261 c=0
Rk8 (\8\:S1 \9\:S1) resistor r=0.5827 c=0
Rk10 (S1 \10\:S1) resistor r=0.2148 c=0
Rk15 (B \4\:B) resistor r=0.1814 c=0
Rk6 (\5\:n2 \7\:n2) resistor r=0.3975 c=0
Rk7 (\7\:n2 \8\:n2) resistor r=0.8497 c=0
Rk3 (\4\:S1b \5\:S1b) resistor r=0.2305 c=0
Rk4 (\5\:S1b \7\:S1b) resistor r=0.07054 c=0
Rk5 (\5\:S1b \9\:S1b) resistor r=0.2173 c=0
Rk12 (\5\:n1 \7\:n1) resistor r=0.6958 c=0
Rk13 (\7\:n1 \8\:n1) resistor r=0.9523 c=0
Rk17 (\5\:n0 \7\:n0) resistor r=0.5881 c=0
Rk18 (\7\:n0 \8\:n0) resistor r=1.358 c=0
Rk24 (\9\:S0b \10\:S0b) resistor r=0.4953 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.6319 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.6957 c=0
Rk27 (\10\:S0b \13\:S0b) resistor r=0.2614 c=0
Rk28 (\13\:S0b \15\:S0b) resistor r=0.6283 c=0
Rk29 (\15\:S0b \17\:S0b) resistor r=0.5378 c=0
Rl32 (\9\:S0 \10\:S0) resistor r=95.3297 c=0
Rl31 (\8\:S0 \9\:S0) resistor r=115.385 c=0
Rl26 (\4\:S0 \5\:S0) resistor r=85.7713 c=0
Rl28 (\6\:S0 \7\:S0) resistor r=24.2328 c=0
Rl27 (\5\:S0 \6\:S0) resistor r=239.172 c=0
Rl17 (\1\:S0 \2\:S0) resistor r=128.079 c=0
Rl18 (\2\:S0 \3\:S0) resistor r=103.4 c=0
Rl21 (\2\:C \3\:C) resistor r=88.0156 c=0
Rl20 (\1\:C \2\:C) resistor r=147.31 c=0
Rl13 (\1\:D \2\:D) resistor r=34.3295 c=0
Rl15 (\2\:D \4\:D) resistor r=167.022 c=0
Rl14 (\2\:D \3\:D) resistor r=2.0166 c=0
Rl30 (\2\:A \3\:A) resistor r=26.3736 c=0
Rl29 (\1\:A \2\:A) resistor r=184.615 c=0
Rl10 (\6\:S1 \7\:S1) resistor r=39.1533 c=0
Rl7 (\4\:S1 \5\:S1) resistor r=84.1943 c=0
Rl3 (\1\:S1 \2\:S1) resistor r=37.2302 c=0
Rl4 (\2\:S1 \3\:S1) resistor r=29.5379 c=0
Rl22 (\1\:B \2\:B) resistor r=93.4057 c=0
Rl23 (\2\:B \3\:B) resistor r=95.3288 c=0
Rl1 (n2 \2\:n2) resistor r=24.2328 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=39.6174 c=0
Rl9 (\2\:S1b \3\:S1b) resistor r=26.098 c=0
Rl8 (S1b \2\:S1b) resistor r=131.504 c=0
Rl5 (n1 \2\:n1) resistor r=147.643 c=0
Rl6 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl11 (n0 \2\:n0) resistor r=144.231 c=0
Rl12 (n0 \3\:n0) resistor r=24.2328 c=0
Rl25 (\7\:S0b \8\:S0b) resistor r=47.3097 c=0
Rl24 (\5\:S0b \6\:S0b) resistor r=29.5379 c=0
Rl19 (\3\:S0b \4\:S0b) resistor r=61.996 c=0
Rl16 (S0b \2\:S0b) resistor r=66.5405 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz13 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\4\:n2 \5\:n2) resistor r=75 c=0
Rz2 (\8\:S1b \9\:S1b) resistor r=75 c=0
Rz4 (\4\:n1 \5\:n1) resistor r=75 c=0
Rz5 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz6 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\6\:n2 \7\:n2) resistor r=62 c=0
Ry2 (\6\:S1b \7\:S1b) resistor r=62 c=0
Ry4 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\16\:S0b \17\:S0b) resistor r=62 c=0
Rx10 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \12\:S0) resistor r=45 c=0
Rx14 (\9\:S0 \13\:S0) resistor r=45 c=0
Rx15 (\5\:S0 \14\:S0) resistor r=45 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\3\:D \5\:D) resistor r=45 c=0
Rx13 (\2\:A \5\:A) resistor r=45 c=0
Rx3 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\4\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx9 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:n2 \8\:n2) resistor r=45 c=0
Rx1 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx12 (\3\:n0 \8\:n0) resistor r=45 c=0
Rx16 (\6\:S0b \9\:S0b) resistor r=45 c=0
Rx17 (\4\:S0b \11\:S0b) resistor r=45 c=0
Rx18 (\2\:S0b \12\:S0b) resistor r=45 c=0
Rx19 (\8\:S0b \13\:S0b) resistor r=45 c=0
mn14 (\3\:Y \3\:n2 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.32e-14 ps=1.68e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.3e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (\8\:S1b \3\:S1 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.828e-14 ps=1.68e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (net345 n1 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6.3e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn13 (\4\:n2 \5\:S1 net345 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=5.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (\4\:n2 S1b net329 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=3.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn10 (net329 \2\:n0 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.983e-14 ad=2.538e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn8 (net377 \4\:D \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.983e-14 ad=4.785e-14 ps=1.2e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.80259e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn9 (\4\:n1 \3\:S0 net377 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=3.335e-14 ps=9.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.65931e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn7 (\4\:n1 \3\:S0b net369 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.38431e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn6 (net369 \1\:C \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.27931e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn4 (net361 \3\:B \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=1.958e-14 ps=1.39e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03103e-06 sb=1.29e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (\4\:n0 \7\:S0 net361 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=5.365e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21103e-06 sb=1.11e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\4\:n0 \7\:S0b net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=5.365e-14 ps=6.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62603e-06 sb=6.95e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (net349 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=2.683e-14 ps=1.45e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81466e-06 sb=4.65e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\14\:S0b \8\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=2.9e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86034e-06 sb=2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
ends MXI4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:16 2013 )
// Library name: gsclib045_hvt
// Cell name: ACHCONX2
// View name: extracted

simulator lang=spectre

subckt ACHCONX2 A B CI CON VDD VSS
mp11_1__rcx (\20\:n13 \3\:B VDD VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=1.182e-13 ad=9.19e-14 ps=1.855e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.02727e-07 sb=3.93701e-07 sd=160n sca=30.7686 \
        scb=0.0203743 scc=0.00340396 m=(2)
mp6_1__rcx (\13\:n15 \1\:A VDD VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=1.1355e-13 ad=6.16e-14 ps=1.86e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.10695e-06 sd=160n sca=41.5694 \
        scb=0.0360757 scc=0.00426513 m=(2)
mp10 (net0370 \1\:CI \1\:VDD VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=8.345e-14 ad=6.16e-14 ps=1.41e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=13.8213 \
        scb=0.011888 scc=0.000231499 m=(2)
mp9_1__rcx (\8\:n12 n10 \8\:CON VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=6.16e-14 ps=1.07e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp7_1__rcx (\6\:n12 \23\:B \7\:VDD VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=1.0265e-13 ad=9.13e-14 ps=1.73e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=21.496 \
        scb=0.0176393 scc=0.00214786 m=(2)
mp8_1__rcx (\4\:net0370 n9 \8\:CON VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=6.353e-14 ad=8.47e-14 ps=1.1e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4.35e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp3 (\11\:n9 \1\:B \22\:n15 VDD) g45p1hvt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=6.737e-14 ps=1.07e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp2_1__rcx (\22\:n15 \4\:n13 \12\:n10 VDD) g45p1hvt w=(3.85e-07) \
        l=4.5e-08 nf=1 as=9.73e-14 ad=5.775e-14 ps=1.42e-06 pd=1.07e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.65e-07 sb=4.05e-07 sd=160n \
        sca=15.5058 scb=0.0140133 scc=0.00103524 m=(2)
C1 (CON VSS) capacitor c=5.72431e-17
C2 (B VSS) capacitor c=3.843e-17
C3 (VDD VSS) capacitor c=6.10679e-16
C4 (CI VSS) capacitor c=2.84387e-17
C5 (n15 VSS) capacitor c=1.12385e-16
C6 (n11 VSS) capacitor c=2.8316e-16
C7 (n13 VSS) capacitor c=6.91692e-17
C8 (n9 VSS) capacitor c=1.29719e-16
C9 (n10 VSS) capacitor c=1.12045e-16
C10 (n12 VSS) capacitor c=1.12216e-16
C11 (net0370 VSS) capacitor c=2.78258e-17
C12 (\1\:CI VSS) capacitor c=1.18556e-16
C13 (\23\:B VSS) capacitor c=1.6904e-16
C14 (\13\:n13 VSS) capacitor c=1.58783e-16
C15 (\16\:B VSS) capacitor c=1.43921e-16
C16 (\1\:B VSS) capacitor c=1.07439e-16
C17 (\1\:A VSS) capacitor c=1.18331e-16
C18 (\4\:n10 VSS) capacitor c=1.02541e-16
C19 (\20\:B VSS) capacitor c=9.11674e-17
C20 (\10\:B VSS) capacitor c=8.21312e-17
C21 (\6\:n10 VSS) capacitor c=3.73557e-17
C22 (\5\:n9 VSS) capacitor c=3.06097e-17
C23 (\22\:B VSS) capacitor c=1.91751e-17
C24 (\15\:n13 VSS) capacitor c=3.79321e-17
C25 (\3\:n13 VSS) capacitor c=4.52832e-17
C26 (\14\:B VSS) capacitor c=2.88565e-17
C27 (\13\:B VSS) capacitor c=4.42683e-17
C28 (\8\:n13 VSS) capacitor c=1.68756e-17
C29 (\3\:B VSS) capacitor c=1.62813e-16
C30 (\4\:n15 VSS) capacitor c=1.24255e-17
C31 (\4\:A VSS) capacitor c=1.12583e-17
C32 (\1\:VDD VSS) capacitor c=3.61319e-17
C33 (\4\:net0370 VSS) capacitor c=6.23161e-17
C34 (\8\:n12 VSS) capacitor c=9.32851e-17
C35 (\6\:n12 VSS) capacitor c=1.2429e-16
C36 (\9\:n9 VSS) capacitor c=3.28432e-16
C37 (\8\:n11 VSS) capacitor c=6.19325e-16
C38 (\10\:n10 VSS) capacitor c=3.03466e-16
C39 (\12\:n10 VSS) capacitor c=1.50238e-16
C40 (\11\:n9 VSS) capacitor c=3.05601e-16
C41 (\22\:n15 VSS) capacitor c=3.57088e-16
C42 (\20\:n13 VSS) capacitor c=7.37296e-17
C43 (\15\:n11 VSS) capacitor c=2.47183e-16
C44 (\13\:n15 VSS) capacitor c=5.18732e-17
C45 (\3\:VDD VSS) capacitor c=1.64082e-16
C46 (\9\:net0370 VSS) capacitor c=3.17373e-17
C47 (\1\:CON VSS) capacitor c=2.30438e-16
C48 (\7\:net0370 VSS) capacitor c=6.04549e-17
C49 (\4\:n12 VSS) capacitor c=5.78564e-17
C50 (\16\:n9 VSS) capacitor c=1.91224e-16
C51 (\16\:n10 VSS) capacitor c=1.13233e-16
C52 (\15\:n15 VSS) capacitor c=2.7574e-16
C53 (\14\:n10 VSS) capacitor c=1.23313e-16
C54 (\13\:n9 VSS) capacitor c=1.04283e-16
C55 (\18\:n13 VSS) capacitor c=8.53368e-17
C56 (\17\:n11 VSS) capacitor c=4.15241e-17
C57 (\11\:n15 VSS) capacitor c=1.43326e-17
C58 (\4\:n13 VSS) capacitor c=1.72058e-16
C59 (\6\:n13 VSS) capacitor c=1.12499e-16
C60 (\8\:A VSS) capacitor c=4.33572e-17
C61 (\10\:A VSS) capacitor c=2.07527e-17
C62 (\11\:A VSS) capacitor c=2.10568e-17
C63 (\9\:n15 VSS) capacitor c=2.19965e-17
C64 (\10\:n15 VSS) capacitor c=3.77943e-17
C65 (\3\:n9 VSS) capacitor c=1.26238e-16
C66 (\29\:B VSS) capacitor c=4.36218e-17
C67 (\17\:n13 VSS) capacitor c=5.59663e-17
C68 (\30\:B VSS) capacitor c=7.24595e-17
C69 (\31\:B VSS) capacitor c=6.58457e-17
C70 (\21\:n15 VSS) capacitor c=1.5816e-16
C71 (\24\:n15 VSS) capacitor c=1.97525e-17
C72 (\32\:B VSS) capacitor c=9.10088e-17
C73 (\33\:B VSS) capacitor c=8.88495e-17
C74 (\22\:n13 VSS) capacitor c=8.61267e-17
C75 (\23\:n13 VSS) capacitor c=7.75637e-17
C76 (\34\:B VSS) capacitor c=6.86317e-17
C77 (\35\:B VSS) capacitor c=5.60193e-17
C78 (\15\:n9 VSS) capacitor c=1.40901e-16
C79 (\3\:n12 VSS) capacitor c=9.76193e-17
C80 (\8\:n10 VSS) capacitor c=7.3032e-17
C81 (\9\:n10 VSS) capacitor c=2.39319e-16
C82 (\8\:CON VSS) capacitor c=2.06533e-16
C83 (\3\:net0370 VSS) capacitor c=7.44982e-17
C84 (\6\:net0370 VSS) capacitor c=6.30808e-17
C85 (\7\:CI VSS) capacitor c=5.10125e-17
C86 (\7\:VDD VSS) capacitor c=8.47997e-17
Rk47 (\1\:CON CON) resistor r=0.3565 c=0
Rk48 (CON \8\:CON) resistor r=0.1487 c=0
Rk9 (B \29\:B) resistor r=0.02495 c=0
Rk12 (\30\:B \31\:B) resistor r=0.3431 c=0
Rk20 (\32\:B \33\:B) resistor r=0.5279 c=0
Rk32 (\34\:B \35\:B) resistor r=0.3668 c=0
Rk1 (\8\:A \9\:A) resistor r=0.004315 c=0
Rk2 (A \10\:A) resistor r=0.002981 c=0
Rk3 (\8\:A \10\:A) resistor r=0.131 c=0
Rk4 (A \11\:A) resistor r=0.004237 c=0
Rk5 (\10\:A \11\:A) resistor r=0.003925 c=0
Rk80 (\1\:VSS \6\:VSS) resistor r=0.395 c=0
Rk81 (\6\:VSS \7\:VSS) resistor r=0.3875 c=0
Rk84 (\9\:VSS VSS) resistor r=0.9441 c=0
Rk83 (\7\:VSS \9\:VSS) resistor r=0.548 c=0
Rk63 (\1\:VDD \6\:VDD) resistor r=0.396 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.3875 c=0
Rk67 (\9\:VDD VDD) resistor r=0.9441 c=0
Rk66 (\7\:VDD \9\:VDD) resistor r=0.548 c=0
Rk58 (\7\:CI CI) resistor r=0.03134 c=0
Rk57 (\6\:CI \7\:CI) resistor r=0.001404 c=0
Rk6 (\9\:n15 \10\:n15) resistor r=0.1936 c=0
Rk7 (\10\:n15 \12\:n15) resistor r=0.14 c=0
Rk8 (\10\:n15 \14\:n15) resistor r=0.2545 c=0
Rk16 (\21\:n15 \22\:n15) resistor r=0.9409 c=0
Rk15 (\15\:n15 \21\:n15) resistor r=0.8016 c=0
Rk17 (\21\:n15 \24\:n15) resistor r=0.1413 c=0
Rk27 (n11 \9\:n11) resistor r=0.584 c=0
Rk30 (\8\:n11 \16\:n11) resistor r=2.0288 c=0
Rk31 (\16\:n11 \18\:n11) resistor r=0.2864 c=0
Rk10 (\17\:n13 \19\:n13) resistor r=0.3752 c=0
Rk11 (\19\:n13 \21\:n13) resistor r=0.359 c=0
Rk21 (\22\:n13 \23\:n13) resistor r=0.4623 c=0
Rk22 (\10\:n9 \12\:n9) resistor r=1.6127 c=0
Rk23 (\12\:n9 \14\:n9) resistor r=0.7132 c=0
Rk33 (\15\:n9 \17\:n9) resistor r=1.0916 c=0
Rk34 (\17\:n9 \18\:n9) resistor r=0.369 c=0
Rk39 (\8\:n10 \9\:n10) resistor r=0.307 c=0
Rk40 (\9\:n10 \11\:n10) resistor r=1.6899 c=0
Rk41 (\11\:n10 \13\:n10) resistor r=0.7903 c=0
Rk42 (\13\:n10 \15\:n10) resistor r=0.3355 c=0
Rk43 (\15\:n10 \17\:n10) resistor r=0.5938 c=0
Rk35 (\2\:n12 \3\:n12) resistor r=0.678 c=0
Rk36 (\3\:n12 \5\:n12) resistor r=0.2445 c=0
Rk37 (\3\:n12 \7\:n12) resistor r=0.1129 c=0
Rk38 (\9\:n12 \10\:n12) resistor r=0.6006 c=0
Rk52 (\2\:net0370 \3\:net0370) resistor r=0.218 c=0
Rk53 (\3\:net0370 \5\:net0370) resistor r=0.3714 c=0
Rk54 (\3\:net0370 \6\:net0370) resistor r=0.3912 c=0
Rk55 (\6\:net0370 \8\:net0370) resistor r=0.2749 c=0
Rk56 (\6\:net0370 \10\:net0370) resistor r=0.2546 c=0
Rl44 (\16\:B \20\:B) resistor r=277.645 c=0
Rl46 (\22\:B \20\:B) resistor r=33.8482 c=0
Rl25 (\14\:B \10\:B) resistor r=19.1561 c=0
Rl24 (\13\:B \10\:B) resistor r=16.4898 c=0
Rl15 (\3\:B \1\:B) resistor r=194.964 c=0
Rl3 (\1\:A \4\:A) resistor r=4.3693 c=0
Rl11 (n15 \6\:n15) resistor r=2.9484 c=0
Rl9 (n15 \4\:n15) resistor r=4.8851 c=0
Rl39 (\13\:n13 \15\:n13) resistor r=28.1587 c=0
Rl28 (\3\:n13 n13) resistor r=33.8482 c=0
Rl29 (\4\:n13 \3\:n13) resistor r=194.748 c=0
Rl33 (\6\:n13 \8\:n13) resistor r=13.7341 c=0
Rl31 (\6\:n13 \4\:n13) resistor r=154.981 c=0
Rl55 (\3\:n9 n9) resistor r=156.469 c=0
Rl57 (\3\:n9 \5\:n9) resistor r=101.848 c=0
Rl62 (\6\:n10 \4\:n10) resistor r=15.3298 c=0
Rz24 (VDD \3\:VDD) resistor r=6.25 c=0
Rz21 (\1\:VDD \3\:VDD) resistor r=75 c=0
Rz22 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\12\:n15 \11\:n15) resistor r=75 c=0
Rz10 (\18\:n11 \17\:n11) resistor r=75 c=0
Rz2 (\19\:n13 \18\:n13) resistor r=75 c=0
Rz6 (\14\:n9 \13\:n9) resistor r=75 c=0
Rz11 (\17\:n9 \16\:n9) resistor r=75 c=0
Rz14 (\15\:n10 \14\:n10) resistor r=75 c=0
Rz15 (\17\:n10 \16\:n10) resistor r=75 c=0
Rz12 (\2\:n12 n12) resistor r=75 c=0
Rz13 (\5\:n12 \4\:n12) resistor r=75 c=0
Rz19 (\8\:net0370 \7\:net0370) resistor r=75 c=0
Rz20 (\10\:net0370 \9\:net0370) resistor r=75 c=0
Ry35 (VSS \3\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry33 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry34 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\14\:n15 \13\:n15) resistor r=20.6667 c=0
Ry8 (\9\:n11 \8\:n11) resistor r=62 c=0
Ry12 (\16\:n11 \15\:n11) resistor r=31 c=0
Ry2 (\21\:n13 \20\:n13) resistor r=62 c=0
Ry6 (\10\:n9 \9\:n9) resistor r=62 c=0
Ry7 (\12\:n9 \11\:n9) resistor r=62 c=0
Ry13 (\18\:n9 \9\:n9) resistor r=62 c=0
Ry17 (\11\:n10 \10\:n10) resistor r=62 c=0
Ry18 (\13\:n10 \12\:n10) resistor r=62 c=0
Ry14 (\7\:n12 \6\:n12) resistor r=62 c=0
Ry15 (\9\:n12 \8\:n12) resistor r=62 c=0
Ry16 (\10\:n12 \6\:n12) resistor r=62 c=0
Ry22 (\2\:net0370 net0370) resistor r=62 c=0
Ry23 (\5\:net0370 \4\:net0370) resistor r=62 c=0
Rx3 (\29\:B \3\:B) resistor r=45 c=0
Rx5 (\30\:B \13\:B) resistor r=45 c=0
Rx6 (\31\:B \1\:B) resistor r=45 c=0
Rx8 (\32\:B \14\:B) resistor r=45 c=0
Rx9 (\33\:B \16\:B) resistor r=45 c=0
Rx12 (\34\:B \23\:B) resistor r=22.5 c=0
Rx13 (\35\:B \22\:B) resistor r=45 c=0
Rx1 (\9\:A \4\:A) resistor r=45 c=0
Rx17 (\6\:CI \1\:CI) resistor r=22.5 c=0
Rx2 (\9\:n15 \4\:n15) resistor r=45 c=0
Rx7 (\24\:n15 \6\:n15) resistor r=45 c=0
Rx4 (\17\:n13 \8\:n13) resistor r=45 c=0
Rx10 (\22\:n13 \3\:n13) resistor r=45 c=0
Rx11 (\23\:n13 \15\:n13) resistor r=45 c=0
Rx14 (\15\:n9 \5\:n9) resistor r=45 c=0
Rx15 (\8\:n10 \6\:n10) resistor r=45 c=0
Rx16 (\9\:n10 n10) resistor r=45 c=0
mn11_1__rcx (\18\:n13 \3\:B VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=9.151e-14 ad=4.29e-14 ps=1.635e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04987e-06 sb=4.35e-07 sd=160n sca=20.3563 \
        scb=0.0203131 scc=0.00210921 m=(2)
mn6_1__rcx (\11\:n15 \1\:A VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=8.343e-14 ad=3.12e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.28513e-06 sd=160n sca=20.3563 \
        scb=0.0203131 scc=0.00210921 m=(2)
mn7_1__rcx (\4\:n12 \23\:B \7\:VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=6.255e-14 ad=4.29e-14 ps=1.22e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=9.4847 \
        scb=0.00814735 scc=0.000215444 m=(2)
mn10_1__rcx (\9\:net0370 \1\:CI \1\:VSS VSS) g45n1hvt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=7.635e-14 ad=3.12e-14 ps=1.45e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=16.9754 \
        scb=0.0175701 scc=0.00143458 m=(2)
mn9_1__rcx (n12 \3\:n9 \1\:CON VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.522e-14 ad=4.59e-14 ps=9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.03e-06 sd=160n sca=10.7156 \
        scb=0.0100774 scc=0.000358522 m=(2)
mn3 (\13\:n9 \6\:n13 \15\:n15 VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.982e-14 ad=4.95e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.65e-07 sd=160n sca=7.87233 \
        scb=0.00543612 scc=8.31178e-05 m=(2)
mn2 (\15\:n15 \10\:B \14\:n10 VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.95e-14 ad=4.163e-14 ps=9.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=4.35e-07 sd=160n sca=7.87233 \
        scb=0.00543612 scc=8.31178e-05 m=(2)
mn8 (\7\:net0370 \4\:n10 \1\:CON VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=4.522e-14 ad=6.217e-14 ps=9e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=5e-07 sd=160n sca=10.7156 scb=0.0100774 \
        scc=0.000358522 m=(2)
mn5_1__rcx (\17\:n11 n15 VSS VSS) g45n1hvt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=9.539e-14 ad=3.41e-14 ps=1.685e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.05e-06 sd=160n sca=22.6209 \
        scb=0.0224923 scc=0.0025451 m=(2)
mn4 (n11 \20\:B \16\:n9 VSS) g45n1hvt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=3.71e-14 ad=5.772e-14 ps=8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=4.35e-07 sd=160n sca=9.18993 \
        scb=0.00765118 scc=0.000170292 m=(2)
mn1_1__rcx (\16\:n10 n13 n11 VSS) g45n1hvt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=5.772e-14 ad=3.71e-14 ps=1.1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.165e-06 sd=160n sca=9.18993 \
        scb=0.00765118 scc=0.000170292 m=(2)
mp5 (\15\:n11 n15 VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.283e-13 ad=6.24e-14 ps=1.965e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=9.88846e-07 sd=160n sca=41.048 \
        scb=0.0261997 scc=0.00496428 m=(2)
mp4_1__rcx (\8\:n11 \13\:n13 \9\:n9 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.035e-13 ad=8.07e-14 ps=1.51e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.87885e-07 sb=5.3e-07 sd=160n sca=12.7937 \
        scb=0.0116617 scc=0.000458138 m=(2)
mp1 (\10\:n10 \16\:B \8\:n11 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.4e-14 ad=5.72e-14 ps=1.465e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.27788e-07 sd=160n sca=16.2062 \
        scb=0.015669 scc=0.00110578 m=(2)
ends ACHCONX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:17 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2BX1
// View name: extracted

simulator lang=spectre

subckt NAND2BX1 AN B VDD VSS Y
mp2 (\1\:Y \4\:B \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=6.24e-14 ps=1.75e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=4.30321e-07 sd=160n sca=40.0601 \
        scb=0.0398737 scc=0.00422188 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2.25321e-07 sd=160n sca=30.8677 \
        scb=0.0275043 scc=0.00252863 m=(1)
C1 (Y VSS) capacitor c=6.97971e-17
C2 (VDD VSS) capacitor c=7.09556e-17
