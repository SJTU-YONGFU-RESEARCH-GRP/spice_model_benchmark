Rl18 (\5\:CKb \6\:CKb) resistor r=414.95 c=0
Rl22 (\8\:CKb \10\:CKb) resistor r=50.6918 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=71.8456 c=0
Rl5 (CKb \2\:CKb) resistor r=91.4826 c=0
Rl21 (\7\:CKb \9\:CKb) resistor r=142.286 c=0
Rl20 (\7\:CKb \8\:CKb) resistor r=153.824 c=0
Rl19 (\6\:CKb \7\:CKb) resistor r=90.0661 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rl11 (n20 \2\:n20) resistor r=114.183 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=257.95 c=0
Rl7 (CKbb \2\:CKbb) resistor r=29.5379 c=0
Rl17 (\5\:CKbb \7\:CKbb) resistor r=118.912 c=0
Rl15 (\4\:CKbb \5\:CKbb) resistor r=80.7471 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=40.3099 c=0
Rl10 (\2\:mout \3\:mout) resistor r=97.6132 c=0
Rl9 (mout \2\:mout) resistor r=117.103 c=0
Rl31 (n35 \6\:n35) resistor r=1.2301 c=0
Rl61 (\19\:qbint \20\:qbint) resistor r=47.3097 c=0
Rl60 (\19\:qbint \18\:qbint) resistor r=59.5201 c=0
Rl23 (\2\:qbint qbint) resistor r=137.694 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=26.1559 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz20 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz21 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz22 (\1\:VDD \3\:VDD) resistor r=9.375 c=0
Rz23 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz2 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz1 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz3 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz4 (\4\:mout \5\:mout) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:n35 \12\:n35) resistor r=75 c=0
Rz11 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz12 (\17\:net331 \16\:net331) resistor r=75 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=3.1 c=0
Ry17 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry24 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry25 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry26 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry27 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry2 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry3 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\11\:n35 \10\:n35) resistor r=62 c=0
Ry13 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry14 (\21\:net331 \20\:net331) resistor r=20.6667 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\3\:SN \8\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx4 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx5 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx7 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:mout \13\:mout) resistor r=45 c=0
Rx12 (\8\:n35 \6\:n35) resistor r=45 c=0
Rx13 (\21\:qbint \19\:qbint) resistor r=45 c=0
Rx14 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx15 (\26\:qbint \4\:qbint) resistor r=45 c=0
Rx16 (\19\:net331 net331) resistor r=45 c=0
mn20 (\17\:CKb \1\:CK \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.03e-14 ps=7.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn25 (n21 \3\:D \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=1.088e-14 ps=7.4e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=7.3e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn26 (\6\:n20 CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=3.988e-14 ps=4.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=6.1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn35 (\6\:n20 CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.103e-14 ad=3.988e-14 ps=5.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn36 (n30 mout \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=2.103e-14 ps=9.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn31 (\11\:mout n20 n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.55e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn30 (n25 \2\:SN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.081e-13 ad=2.393e-14 ps=1.9e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=6.45e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn21 (\12\:CKbb \6\:CKb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.081e-13 ad=2.03e-14 ps=1.9e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn40 (\12\:n35 \4\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn52 (\12\:n35 \5\:CKb n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn51 (n40 \3\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.858e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn50 (n42 \6\:SN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn45_1__rcx (\29\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.554e-14 ad=3.28e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.61341e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn56 (\16\:net331 \18\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=3.64e-14 ps=1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.717e-14 ad=4.16e-14 ps=1.4675e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03538e-06 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN net331 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.73e-14 ad=4.615e-14 ps=1.45e-06 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69654e-06 sb=1.135e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp45 (\27\:qbint n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.829e-14 ad=4.96e-14 ps=1.155e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05726e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp56 (\20\:net331 \20\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=24.44 \
        scb=0.022002 scc=0.00203224 m=(1)
mp57 (\5\:QN net331 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60045e-06 sb=9.6e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp55 (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.432e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.80449e-07 sb=1.78e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
ends DFFSX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:55 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFSXL
// View name: extracted

simulator lang=spectre

subckt DFFSXL CK D Q QN SN VDD VSS
mp57 (\1\:QN \4\:net331 \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=49.323 \
        scb=0.0325052 scc=0.00592234 m=(1)
mp56 (\5\:net331 \7\:qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.17326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\13\:qbint n35 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=2.63e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (\3\:n41 \8\:qbint \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.09e-14 ad=5.482e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32558e-07 sb=8.7e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp50 (\3\:n41 \5\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=5.482e-14 ps=1.38e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.32558e-07 sb=5.7e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp30 (\14\:mout \1\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.79e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.97558e-07 sb=3.05e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp31 (\14\:mout \2\:n20 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.34e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02558e-07 sb=1e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp52 (\8\:n35 \3\:CKbb n41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\8\:n35 \3\:CKb \7\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp21 (\13\:CKbb \5\:CKb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.662e-14 ad=3.01e-14 ps=2.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp35 (n31 \4\:mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.662e-14 ad=4.73e-14 ps=2.32e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=9.45e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp36 (\6\:n20 \8\:CKb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=6.8e-07 sd=160n sca=23.0812 \
        scb=0.0214629 scc=0.00242443 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=4.75e-07 sd=160n sca=23.8644 \
        scb=0.0219441 scc=0.00242489 m=(1)
mp25 (n22 \3\:D \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.827e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=24.8442 \
        scb=0.0230968 scc=0.00242964 m=(1)
mp20 (\20\:CKb \3\:CK \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=28.9348 \
        scb=0.0300604 scc=0.00262798 m=(1)
C1 (SN VSS) capacitor c=4.90056e-17
C2 (CK VSS) capacitor c=4.30643e-17
C3 (D VSS) capacitor c=1.32767e-16
C4 (QN VSS) capacitor c=2.2078e-17
C5 (VDD VSS) capacitor c=2.65891e-16
C6 (Q VSS) capacitor c=3.66927e-17
C7 (net331 VSS) capacitor c=1.99323e-17
C8 (qbint VSS) capacitor c=3.4239e-17
C9 (n35 VSS) capacitor c=4.29402e-17
C10 (n42 VSS) capacitor c=1.75543e-18
C11 (n40 VSS) capacitor c=3.70039e-17
C12 (n25 VSS) capacitor c=7.38748e-18
C13 (mout VSS) capacitor c=4.5602e-17
C14 (n20 VSS) capacitor c=2.35722e-17
C15 (CKb VSS) capacitor c=3.24345e-17
C16 (CKbb VSS) capacitor c=3.96875e-17
C17 (n30 VSS) capacitor c=1.80955e-18
C18 (n21 VSS) capacitor c=2.10073e-19
C19 (n41 VSS) capacitor c=1.3277e-16
C20 (n31 VSS) capacitor c=4.38396e-18
C21 (\3\:CK VSS) capacitor c=3.83905e-17
C22 (\3\:D VSS) capacitor c=4.56277e-17
C23 (\5\:CKbb VSS) capacitor c=6.31384e-17
C24 (\8\:CKb VSS) capacitor c=4.33208e-17
C25 (\4\:mout VSS) capacitor c=3.94124e-17
C26 (\5\:CKb VSS) capacitor c=6.50477e-17
C27 (\3\:CKb VSS) capacitor c=3.66611e-17
C28 (\3\:CKbb VSS) capacitor c=6.57005e-17
C29 (\2\:n20 VSS) capacitor c=4.03683e-17
C30 (\1\:SN VSS) capacitor c=4.45245e-17
C31 (\5\:SN VSS) capacitor c=2.10595e-17
C32 (\8\:qbint VSS) capacitor c=2.62243e-17
C33 (\7\:qbint VSS) capacitor c=3.70891e-17
C34 (\4\:net331 VSS) capacitor c=3.75828e-17
C35 (\1\:CK VSS) capacitor c=2.89402e-17
C36 (\1\:D VSS) capacitor c=6.70674e-17
C37 (\10\:CKb VSS) capacitor c=6.62522e-17
C38 (\8\:CKbb VSS) capacitor c=2.91469e-17
C39 (\6\:CKb VSS) capacitor c=4.98529e-17
C40 (\2\:CKb VSS) capacitor c=3.71492e-17
C41 (\3\:n20 VSS) capacitor c=5.16192e-17
C42 (\4\:SN VSS) capacitor c=1.92655e-17
C43 (\3\:SN VSS) capacitor c=5.12151e-17
C44 (\11\:qbint VSS) capacitor c=5.5805e-17
C45 (\3\:n35 VSS) capacitor c=3.50163e-17
C46 (\5\:qbint VSS) capacitor c=2.62154e-17
C47 (\4\:qbint VSS) capacitor c=2.69211e-17
C48 (\3\:net331 VSS) capacitor c=3.05307e-17
C49 (\2\:CK VSS) capacitor c=3.45141e-17
C50 (\2\:D VSS) capacitor c=4.30015e-17
C51 (\11\:CKb VSS) capacitor c=2.46078e-17
C52 (\9\:CKb VSS) capacitor c=5.24375e-17
C53 (\7\:CKbb VSS) capacitor c=5.69603e-17
C54 (\3\:mout VSS) capacitor c=2.51435e-17
C55 (\7\:CKb VSS) capacitor c=2.09898e-17
C56 (\4\:CKbb VSS) capacitor c=4.25625e-17
C57 (\4\:CKb VSS) capacitor c=4.15195e-17
C58 (\2\:n40 VSS) capacitor c=4.07916e-17
C59 (\2\:SN VSS) capacitor c=5.03517e-17
C60 (\10\:qbint VSS) capacitor c=1.73153e-17
C61 (\2\:n35 VSS) capacitor c=4.06786e-17
C62 (\6\:qbint VSS) capacitor c=4.23989e-17
C63 (\20\:CKb VSS) capacitor c=6.0908e-17
C64 (\10\:VDD VSS) capacitor c=3.75266e-17
C65 (\6\:n20 VSS) capacitor c=2.20322e-16
C66 (\12\:VDD VSS) capacitor c=8.37741e-18
C67 (\13\:CKbb VSS) capacitor c=5.79223e-17
C68 (\7\:mout VSS) capacitor c=6.16556e-17
C69 (\8\:n35 VSS) capacitor c=5.48827e-17
C70 (\14\:VDD VSS) capacitor c=1.9991e-17
C71 (\14\:mout VSS) capacitor c=4.18604e-17
C72 (\16\:VDD VSS) capacitor c=2.69274e-17
C73 (\3\:n41 VSS) capacitor c=8.19464e-17
C74 (\18\:VDD VSS) capacitor c=3.07689e-17
C75 (\13\:qbint VSS) capacitor c=4.89474e-17
C76 (\20\:VDD VSS) capacitor c=7.93713e-18
C77 (\3\:Q VSS) capacitor c=4.35151e-17
C78 (\5\:net331 VSS) capacitor c=2.45251e-17
C79 (\23\:VDD VSS) capacitor c=4.51146e-18
C80 (\1\:QN VSS) capacitor c=1.55551e-17
C81 (\1\:VDD VSS) capacitor c=5.76287e-17
C82 (\18\:CKb VSS) capacitor c=8.17321e-17
C83 (\4\:n20 VSS) capacitor c=8.57037e-17
C84 (\11\:CKbb VSS) capacitor c=3.34945e-17
C85 (\5\:mout VSS) capacitor c=8.23242e-17
C86 (\4\:n35 VSS) capacitor c=4.4035e-17
C87 (\6\:n40 VSS) capacitor c=5.30721e-17
C88 (\11\:mout VSS) capacitor c=6.12136e-17
C89 (\3\:n40 VSS) capacitor c=7.49783e-17
C90 (\16\:qbint VSS) capacitor c=3.91614e-17
C91 (\1\:Q VSS) capacitor c=3.11565e-17
C92 (\9\:net331 VSS) capacitor c=2.7707e-17
C93 (\3\:QN VSS) capacitor c=3.40494e-17
C94 (\2\:net331 VSS) capacitor c=1.25586e-17
C95 (\3\:qbint VSS) capacitor c=3.76131e-17
C96 (\9\:qbint VSS) capacitor c=2.87924e-17
C97 (\2\:CKbb VSS) capacitor c=4.92721e-17
C98 (\2\:mout VSS) capacitor c=3.76139e-17
C99 (\6\:CKbb VSS) capacitor c=5.68762e-17
C100 (\7\:net331 VSS) capacitor c=2.94854e-17
C101 (\8\:net331 VSS) capacitor c=2.85445e-17
C102 (\12\:qbint VSS) capacitor c=3.57958e-17
C103 (\15\:qbint VSS) capacitor c=7.23525e-17
C104 (\5\:n40 VSS) capacitor c=8.65344e-17
C105 (\6\:SN VSS) capacitor c=6.20163e-17
C106 (\8\:n40 VSS) capacitor c=5.59267e-17
C107 (\6\:n35 VSS) capacitor c=2.5514e-16
C108 (\7\:n35 VSS) capacitor c=2.68585e-16
C109 (\9\:mout VSS) capacitor c=1.71957e-16
C110 (\10\:mout VSS) capacitor c=1.25927e-16
C111 (\13\:mout VSS) capacitor c=1.01118e-16
C112 (\9\:CKbb VSS) capacitor c=7.53288e-17
C113 (\10\:CKbb VSS) capacitor c=6.27349e-17
C114 (\8\:n20 VSS) capacitor c=1.84728e-16
C115 (\4\:CK VSS) capacitor c=8.67561e-17
C116 (\12\:CKb VSS) capacitor c=2.69655e-17
C117 (\13\:CKb VSS) capacitor c=6.3759e-17
C118 (\14\:CKb VSS) capacitor c=6.4537e-17
C119 (\15\:CKb VSS) capacitor c=6.44006e-17
C120 (\16\:CKb VSS) capacitor c=6.41427e-17
C121 (\17\:CKb VSS) capacitor c=1.98259e-17
C122 (\22\:CKb VSS) capacitor c=7.58942e-17
C123 (\23\:CKb VSS) capacitor c=8.13776e-17
C124 (\3\:VDD VSS) capacitor c=1.47368e-17
C125 (\4\:VDD VSS) capacitor c=1.6041e-17
C126 (\6\:VDD VSS) capacitor c=3.25611e-17
C127 (\7\:VDD VSS) capacitor c=1.6215e-17
C128 (\8\:VDD VSS) capacitor c=1.03089e-17
C129 (\22\:VDD VSS) capacitor c=1.10413e-17
Rk12 (\6\:SN SN) resistor r=0.09718 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.4248 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.1091 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.8445 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.3582 c=0
Rk45 (\3\:VSS \9\:VSS) resistor r=0.07358 c=0
Rk46 (\4\:VSS \11\:VSS) resistor r=0.04328 c=0
Rk47 (\6\:VSS \13\:VSS) resistor r=0.07358 c=0
Rk49 (\14\:VSS VSS) resistor r=0.2226 c=0
Rk48 (\7\:VSS \14\:VSS) resistor r=0.3287 c=0
Rk50 (\7\:VSS \16\:VSS) resistor r=0.1198 c=0
Rk51 (\14\:VSS \18\:VSS) resistor r=0.07358 c=0
Rk30 (CK \4\:CK) resistor r=0.07791 c=0
Rk2 (\4\:QN QN) resistor r=0.08316 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2244 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.1602 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.2478 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.2429 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5102 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.2343 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.2829 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.1728 c=0
Rk59 (\3\:VDD \11\:VDD) resistor r=0.3774 c=0
Rk60 (\4\:VDD \13\:VDD) resistor r=0.07358 c=0
Rk61 (\6\:VDD \15\:VDD) resistor r=0.04328 c=0
Rk62 (\7\:VDD \17\:VDD) resistor r=0.2166 c=0
Rk63 (\8\:VDD \19\:VDD) resistor r=0.373 c=0
Rk64 (\9\:VDD \21\:VDD) resistor r=0.2695 c=0
Rk67 (\22\:VDD VDD) resistor r=0.2226 c=0
Rk65 (\9\:VDD \22\:VDD) resistor r=0.3287 c=0
Rk66 (\22\:VDD \24\:VDD) resistor r=0.2233 c=0
Rk6 (Q \2\:Q) resistor r=0.06892 c=0
Rk7 (Q \4\:Q) resistor r=0.1768 c=0
Rk3 (\6\:net331 \7\:net331) resistor r=0.1176 c=0
Rk4 (\7\:net331 \8\:net331) resistor r=0.1192 c=0
Rk5 (\7\:net331 \10\:net331) resistor r=0.1056 c=0
Rk8 (\12\:qbint \14\:qbint) resistor r=0.1911 c=0
Rk9 (\14\:qbint \15\:qbint) resistor r=0.2773 c=0
Rk10 (\15\:qbint \17\:qbint) resistor r=0.2776 c=0
Rk15 (\5\:n35 \6\:n35) resistor r=0.1616 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=1.8334 c=0
Rk17 (\6\:n35 \9\:n35) resistor r=0.201 c=0
Rk11 (\4\:n40 \5\:n40) resistor r=0.5256 c=0
Rk14 (\7\:n40 \8\:n40) resistor r=0.1367 c=0
Rk18 (\6\:mout \8\:mout) resistor r=0.4467 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.07096 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.8266 c=0
Rk21 (\10\:mout \12\:mout) resistor r=0.2619 c=0
Rk22 (\9\:mout \13\:mout) resistor r=0.5864 c=0
Rk23 (\10\:mout \15\:mout) resistor r=0.1203 c=0
Rk27 (\5\:n20 \7\:n20) resistor r=0.4473 c=0
Rk28 (\7\:n20 \8\:n20) resistor r=1.4774 c=0
Rk31 (\12\:CKb \13\:CKb) resistor r=0.05541 c=0
Rk32 (\13\:CKb \14\:CKb) resistor r=0.1884 c=0
Rk33 (\14\:CKb \15\:CKb) resistor r=0.3843 c=0
Rk34 (\15\:CKb \16\:CKb) resistor r=0.3044 c=0
Rk35 (\16\:CKb \17\:CKb) resistor r=0.06828 c=0
Rk36 (\13\:CKb \19\:CKb) resistor r=0.49 c=0
Rk37 (\19\:CKb \21\:CKb) resistor r=0.4556 c=0
Rk38 (\14\:CKb \22\:CKb) resistor r=0.3774 c=0
Rk39 (\16\:CKb \23\:CKb) resistor r=0.3613 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.4535 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.142 c=0
Rk26 (\10\:CKbb \14\:CKbb) resistor r=0.2187 c=0
Rk13 (\2\:n41 \4\:n41) resistor r=0.6891 c=0
Rl15 (\1\:SN \2\:SN) resistor r=139.939 c=0
Rl18 (\2\:SN \5\:SN) resistor r=24.2328 c=0
Rl17 (\2\:SN \4\:SN) resistor r=76.1559 c=0
Rl16 (\2\:SN \3\:SN) resistor r=114.001 c=0
Rl40 (\2\:CK \3\:CK) resistor r=79.9451 c=0
Rl39 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl38 (\2\:D \3\:D) resistor r=29.0109 c=0
Rl37 (\1\:D \2\:D) resistor r=75.6797 c=0
Rl3 (\2\:net331 \4\:net331) resistor r=49.7141 c=0
Rl2 (\2\:net331 \3\:net331) resistor r=34.3295 c=0
Rl1 (net331 \2\:net331) resistor r=0.5213 c=0
Rl4 (qbint \2\:qbint) resistor r=68.0527 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=4.1351 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=162.491 c=0
Rl12 (\8\:qbint \9\:qbint) resistor r=34.3295 c=0
Rl14 (\9\:qbint \11\:qbint) resistor r=86.2526 c=0
Rl13 (\9\:qbint \10\:qbint) resistor r=9.1017 c=0
Rl10 (n35 \2\:n35) resistor r=56.9251 c=0
Rl11 (\2\:n35 \3\:n35) resistor r=26.1559 c=0
Rl21 (n40 \2\:n40) resistor r=232.153 c=0
Rl31 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl29 (mout \2\:mout) resistor r=90.4693 c=0
Rl30 (\2\:mout \3\:mout) resistor r=1.2666 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=141.873 c=0
Rl19 (n20 \2\:n20) resistor r=58.3841 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=132.718 c=0
Rl36 (\10\:CKb \11\:CKb) resistor r=93.4636 c=0
Rl32 (\8\:CKb \9\:CKb) resistor r=29.5379 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=30.0021 c=0
Rl23 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl22 (CKb \2\:CKb) resistor r=64.0094 c=0
Rl25 (\2\:CKbb \3\:CKbb) resistor r=168.774 c=0
Rl24 (CKbb \2\:CKbb) resistor r=30.4507 c=0
Rl26 (\2\:CKbb \4\:CKbb) resistor r=88.851 c=0
Rl33 (\5\:CKbb \6\:CKbb) resistor r=114.928 c=0
Rl35 (\6\:CKbb \8\:CKbb) resistor r=30.4507 c=0
Rl34 (\6\:CKbb \7\:CKbb) resistor r=104.516 c=0
Rz13 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz14 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz20 (\1\:VDD \9\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz2 (\9\:net331 \10\:net331) resistor r=75 c=0
Rz4 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz7 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz6 (\6\:n40 \7\:n40) resistor r=75 c=0
Rz8 (\5\:mout \6\:mout) resistor r=75 c=0
Rz9 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz12 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz10 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Ry13 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry14 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry15 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry18 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry19 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry20 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry2 (\5\:net331 \6\:net331) resistor r=62 c=0
Ry4 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\14\:mout \15\:mout) resistor r=62 c=0
Ry11 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry12 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx5 (\2\:SN \6\:SN) resistor r=45 c=0
Rx13 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D D) resistor r=45 c=0
Rx1 (net331 \8\:net331) resistor r=45 c=0
Rx2 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx3 (\6\:qbint \15\:qbint) resistor r=45 c=0
Rx7 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\2\:n40 \5\:n40) resistor r=45 c=0
Rx6 (n40 \8\:n40) resistor r=45 c=0
Rx8 (\3\:mout \13\:mout) resistor r=45 c=0
Rx11 (n20 \8\:n20) resistor r=45 c=0
Rx14 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \15\:CKb) resistor r=45 c=0
Rx16 (CKb \17\:CKb) resistor r=45 c=0
Rx17 (\9\:CKb \22\:CKb) resistor r=45 c=0
Rx18 (\4\:CKb \23\:CKb) resistor r=45 c=0
Rx9 (\7\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \10\:CKbb) resistor r=45 c=0
mn57 (\3\:QN \3\:net331 \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net331 \4\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.537e-14 ps=1.5e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn45 (\16\:qbint \3\:n35 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.94e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn51 (\3\:n40 \11\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn50 (n42 \3\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn30 (n25 \4\:SN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.002e-14 ps=1.5e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=5.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\11\:mout \3\:n20 n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn52 (\4\:n35 \2\:CKb \6\:n40 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.277e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn40 (\4\:n35 CKbb \5\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.277e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn21 (\11\:CKbb \6\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.965e-14 ad=2.03e-14 ps=1.51e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn36 (n30 mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.965e-14 ad=4.35e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.025e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn35 (\4\:n20 \8\:CKbb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.35e-14 ad=2.32e-14 ps=8.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=6.8e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn26 (\4\:n20 \10\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=4.75e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn25 (n21 \1\:D \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.037e-14 ad=8.7e-15 ps=1.52e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.7e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn20 (\18\:CKb \1\:CK \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.037e-14 ad=2.465e-14 ps=1.52e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.7e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
ends DFFSXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:56 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFTRX1
// View name: extracted

simulator lang=spectre

subckt DFFTRX1 CK D Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
mp55 (\1\:Q \5\:qbint \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=5.46e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.24679e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
C1 (D VSS) capacitor c=4.76998e-17
C2 (QN VSS) capacitor c=2.29669e-17
C3 (RN VSS) capacitor c=4.42755e-17
C4 (Q VSS) capacitor c=9.13894e-17
C5 (VDD VSS) capacitor c=2.99106e-16
C6 (CK VSS) capacitor c=5.55136e-17
C7 (qint VSS) capacitor c=2.19377e-17
C8 (qbint VSS) capacitor c=2.921e-17
C9 (CKb VSS) capacitor c=2.43494e-17
C10 (n30 VSS) capacitor c=3.30798e-17
C11 (mout VSS) capacitor c=7.47807e-17
C12 (CKbb VSS) capacitor c=5.58375e-17
C13 (n20 VSS) capacitor c=2.7287e-17
C14 (Db VSS) capacitor c=6.17971e-17
C15 (n36 VSS) capacitor c=2.57935e-18
C16 (\1\:D VSS) capacitor c=3.28273e-17
C17 (\1\:RN VSS) capacitor c=4.32444e-17
C18 (\8\:CKb VSS) capacitor c=4.29506e-17
C19 (\7\:CKbb VSS) capacitor c=4.61914e-17
C20 (\7\:CKb VSS) capacitor c=6.82886e-17
C21 (\4\:n20 VSS) capacitor c=3.84918e-17
C22 (\2\:CKb VSS) capacitor c=6.31568e-17
C23 (\8\:qbint VSS) capacitor c=5.59343e-17
C24 (\1\:CK VSS) capacitor c=2.95553e-17
C25 (\5\:qbint VSS) capacitor c=4.30904e-17
C26 (\7\:qbint VSS) capacitor c=3.3153e-17
C27 (\4\:qint VSS) capacitor c=4.29284e-17
C28 (\3\:D VSS) capacitor c=2.5836e-17
C29 (\3\:RN VSS) capacitor c=3.13918e-17
C30 (\4\:CKb VSS) capacitor c=2.10809e-17
C31 (\9\:CKb VSS) capacitor c=2.81262e-17
C32 (\5\:CKbb VSS) capacitor c=8.71901e-17
C33 (\3\:mout VSS) capacitor c=5.15967e-17
C34 (\3\:n20 VSS) capacitor c=4.55029e-17
C35 (\3\:CKbb VSS) capacitor c=3.77107e-17
C36 (\3\:CKb VSS) capacitor c=7.58464e-17
C37 (\11\:qbint VSS) capacitor c=2.88693e-17
C38 (\3\:n30 VSS) capacitor c=3.52478e-17
C39 (\3\:CK VSS) capacitor c=4.25522e-17
C40 (\4\:qbint VSS) capacitor c=2.83145e-17
C41 (\3\:qint VSS) capacitor c=3.87011e-17
C42 (\2\:D VSS) capacitor c=3.10115e-17
C43 (\2\:RN VSS) capacitor c=3.27414e-17
C44 (\8\:CKbb VSS) capacitor c=4.95697e-17
C45 (\10\:CKb VSS) capacitor c=3.09327e-17
C46 (\6\:CKbb VSS) capacitor c=2.80429e-17
C47 (\2\:mout VSS) capacitor c=5.65691e-17
C48 (\4\:CKbb VSS) capacitor c=3.93458e-17
C49 (\2\:CKbb VSS) capacitor c=4.65187e-17
C50 (\10\:qbint VSS) capacitor c=2.85985e-17
C51 (\2\:n30 VSS) capacitor c=3.13746e-17
C52 (\2\:CK VSS) capacitor c=2.68412e-17
C53 (\1\:VDD VSS) capacitor c=4.00532e-17
C54 (\3\:Db VSS) capacitor c=1.47946e-16
C55 (\11\:VDD VSS) capacitor c=1.33533e-17
C56 (\9\:CKbb VSS) capacitor c=7.0858e-17
C57 (\5\:Db VSS) capacitor c=1.51586e-16
C58 (\9\:n20 VSS) capacitor c=3.47986e-17
C59 (\13\:VDD VSS) capacitor c=2.34833e-17
C60 (\8\:mout VSS) capacitor c=3.58655e-17
C61 (\4\:n30 VSS) capacitor c=4.31874e-17
C62 (\15\:VDD VSS) capacitor c=2.35684e-17
C63 (\16\:qbint VSS) capacitor c=5.78675e-17
C64 (\13\:CKb VSS) capacitor c=1.31587e-16
C65 (\17\:VDD VSS) capacitor c=4.89789e-17
C66 (\1\:Q VSS) capacitor c=9.23834e-17
C67 (\5\:qint VSS) capacitor c=3.04608e-17
C68 (\19\:VDD VSS) capacitor c=6.02243e-17
C69 (\1\:QN VSS) capacitor c=4.73797e-17
C70 (\4\:VDD VSS) capacitor c=4.88153e-17
C71 (\11\:CKbb VSS) capacitor c=1.22709e-16
C72 (\7\:Db VSS) capacitor c=9.26947e-17
C73 (\7\:n20 VSS) capacitor c=4.93892e-17
C74 (\6\:mout VSS) capacitor c=3.35262e-17
C75 (\8\:n30 VSS) capacitor c=6.13738e-17
C76 (\14\:qbint VSS) capacitor c=7.45623e-17
C77 (\15\:CKb VSS) capacitor c=6.07813e-17
C78 (\9\:qint VSS) capacitor c=2.80976e-17
C79 (\3\:QN VSS) capacitor c=2.74866e-17
C80 (\2\:qint VSS) capacitor c=7.2067e-18
C81 (\2\:qbint VSS) capacitor c=3.38217e-17
C82 (\3\:qbint VSS) capacitor c=2.98769e-17
C83 (\9\:qbint VSS) capacitor c=2.56071e-17
C84 (\2\:n20 VSS) capacitor c=2.31125e-17
C85 (\5\:CKb VSS) capacitor c=4.67104e-17
C86 (\6\:CKb VSS) capacitor c=6.64929e-17
C87 (\7\:qint VSS) capacitor c=2.91461e-17
C88 (\8\:qint VSS) capacitor c=2.3113e-17
C89 (\4\:CK VSS) capacitor c=6.30162e-17
C90 (\12\:qbint VSS) capacitor c=5.17169e-17
C91 (\13\:qbint VSS) capacitor c=4.28026e-17
C92 (\18\:qbint VSS) capacitor c=1.43045e-16
C93 (\6\:n30 VSS) capacitor c=7.26532e-17
C94 (\7\:n30 VSS) capacitor c=5.50838e-17
C95 (\4\:mout VSS) capacitor c=4.40878e-17
C96 (\5\:mout VSS) capacitor c=5.29428e-17
C97 (\11\:CKb VSS) capacitor c=7.7016e-17
C98 (\12\:CKb VSS) capacitor c=1.52694e-16
C99 (\5\:n20 VSS) capacitor c=4.74676e-17
C100 (\6\:n20 VSS) capacitor c=4.80148e-17
C101 (\13\:CKbb VSS) capacitor c=6.61791e-17
C102 (\14\:CKbb VSS) capacitor c=8.68269e-17
C103 (\15\:CKbb VSS) capacitor c=1.17317e-16
C104 (\16\:CKbb VSS) capacitor c=4.54685e-17
C105 (\17\:CKbb VSS) capacitor c=7.22787e-17
C106 (\18\:CKbb VSS) capacitor c=1.78482e-17
C107 (\4\:RN VSS) capacitor c=5.60889e-17
C108 (\4\:D VSS) capacitor c=5.9523e-17
C109 (\3\:VDD VSS) capacitor c=3.32994e-17
C110 (\6\:VDD VSS) capacitor c=3.43781e-17
C111 (\7\:VDD VSS) capacitor c=4.30838e-17
C112 (\9\:VDD VSS) capacitor c=1.12859e-17
C113 (\10\:VDD VSS) capacitor c=1.58475e-17
Rk34 (D \4\:D) resistor r=0.1975 c=0
Rk2 (\4\:QN QN) resistor r=0.0928 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk33 (\4\:RN RN) resistor r=0.09118 c=0
Rk6 (\2\:Q Q) resistor r=0.5016 c=0
Rk7 (Q \4\:Q) resistor r=0.002638 c=0
Rk38 (\2\:VDD \3\:VDD) resistor r=0.604 c=0
Rk39 (\3\:VDD \5\:VDD) resistor r=0.2679 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.2754 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.4957 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.4308 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.03238 c=0
Rk45 (\10\:VDD VDD) resistor r=0.2 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.3178 c=0
Rk46 (\3\:VDD \12\:VDD) resistor r=0.07334 c=0
Rk47 (\6\:VDD \14\:VDD) resistor r=0.102 c=0
Rk48 (\7\:VDD \16\:VDD) resistor r=0.102 c=0
Rk49 (\9\:VDD \18\:VDD) resistor r=0.2702 c=0
Rk50 (\10\:VDD \20\:VDD) resistor r=0.4324 c=0
Rk51 (\2\:VSS \4\:VSS) resistor r=0.6612 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.2595 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.5098 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.4308 c=0
Rk55 (\5\:VSS \9\:VSS) resistor r=0.04326 c=0
Rk56 (\6\:VSS \11\:VSS) resistor r=0.3572 c=0
Rk58 (\12\:VSS VSS) resistor r=0.215 c=0
Rk57 (\7\:VSS \12\:VSS) resistor r=0.3362 c=0
Rk59 (\7\:VSS \14\:VSS) resistor r=0.3423 c=0
Rk60 (\12\:VSS \16\:VSS) resistor r=0.07334 c=0
Rk8 (\4\:CK CK) resistor r=0.2087 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.09348 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.119 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1294 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.23 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1863 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.3293 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.8158 c=0
Rk19 (\11\:CKb \12\:CKb) resistor r=0.5297 c=0
Rk20 (\12\:CKb \14\:CKb) resistor r=0.9863 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.272 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.3034 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2335 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.3782 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.196 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1123 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.2572 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.4919 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.3643 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.2125 c=0
Rk28 (\14\:CKbb \15\:CKbb) resistor r=0.7312 c=0
Rk29 (\15\:CKbb \16\:CKbb) resistor r=0.1581 c=0
Rk30 (\13\:CKbb \17\:CKbb) resistor r=0.3487 c=0
Rk31 (\14\:CKbb \18\:CKbb) resistor r=0.02532 c=0
Rk32 (\15\:CKbb \19\:CKbb) resistor r=0.03037 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.2126 c=0
Rk23 (\6\:n20 \8\:n20) resistor r=0.2377 c=0
Rk24 (\6\:n20 \10\:n20) resistor r=0.1554 c=0
Rk35 (\2\:Db \4\:Db) resistor r=0.4946 c=0
Rk36 (\4\:Db \6\:Db) resistor r=0.8953 c=0
Rk37 (\6\:Db \8\:Db) resistor r=0.4925 c=0
Rl36 (\1\:D \2\:D) resistor r=72.4273 c=0
Rl37 (\2\:D \3\:D) resistor r=38.2566 c=0
Rl34 (\1\:RN \2\:RN) resistor r=77.6148 c=0
Rl35 (\2\:RN \3\:RN) resistor r=39.1533 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl3 (\2\:qint \4\:qint) resistor r=34.3295 c=0
Rl2 (\2\:qint \3\:qint) resistor r=49.7141 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=72.0924 c=0
Rl4 (qbint \2\:qbint) resistor r=37.477 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.1042 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=53.0797 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=35.772 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=147.248 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=111.253 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=36.2526 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=11.4953 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=210.67 c=0
Rl33 (\7\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl31 (\5\:CKb \8\:CKb) resistor r=99.3167 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=38.9332 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=161.082 c=0
Rl32 (\6\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=181.633 c=0
Rl12 (n30 \2\:n30) resistor r=29.5379 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=100.692 c=0
Rl24 (mout \2\:mout) resistor r=103.079 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=53.079 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=58.3841 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=37.2302 c=0
Rl17 (CKbb \2\:CKbb) resistor r=50.6918 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=51.6372 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=95.868 c=0
Rl21 (n20 \2\:n20) resistor r=10.7022 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz12 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz13 (\4\:VDD \8\:VDD) resistor r=6.25 c=0
Rz14 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz15 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz16 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry19 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\5\:Db \6\:Db) resistor r=62 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (CKb \12\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \18\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx9 (n20 \5\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\15\:CKb \3\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\14\:qbint \3\:n30 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.85e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn50 (n35 \11\:qbint \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.812e-14 ps=7.3e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.585e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn51 (\8\:n30 \3\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.625e-14 ps=5.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.415e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\8\:n30 \3\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.625e-14 ps=7.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.12e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (\6\:mout \3\:n20 \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=3.118e-14 ps=1.55e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=8.6e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn35 (n25 \3\:mout \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=8.7e-15 ps=1.55e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=5.95e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn36 (\7\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=4.9e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn25 (\7\:n20 \9\:CKb \7\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=2.85e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn21 (\11\:CKbb \4\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (n0 \3\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.1e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=3.263e-14 ps=5.7e-07 pd=7.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=2.25e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp20 (\13\:CKb \1\:CK \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=4.085e-14 ps=1.26e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.9e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\16\:qbint n30 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.725e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (n36 \8\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.332e-14 ps=1.62e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.46e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\4\:n30 CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.26e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\4\:n30 \2\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.44e-14 ps=9.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.055e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\8\:mout \4\:n20 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.23e-14 ad=5.912e-14 ps=1.62e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=7.35e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (n26 mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.72e-14 ps=1.62e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=4.7e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\9\:n20 \7\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.44e-14 ps=5.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=3.45e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp25 (\9\:n20 \7\:CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp21 (\9\:CKbb \8\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.995e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=15.6591 \
        scb=0.0151507 scc=0.000885469 m=(1)
mp0 (\3\:Db \1\:RN \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.995e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=3.95e-07 sd=160n sca=17.4637 \
        scb=0.0170276 scc=0.000892958 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=24.9308 \
        scb=0.0292329 scc=0.0015565 m=(1)
ends DFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:57 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFTRX2
// View name: extracted

simulator lang=spectre

subckt DFFTRX2 CK D Q QN RN VDD VSS
mp1 (\4\:Db \4\:D \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.45e-07 sd=160n sca=27.2529 \
        scb=0.0321202 scc=0.00197428 m=(1)
mp0 (\4\:Db \4\:RN \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.548e-14 ps=1.45e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.35e-07 sd=160n sca=19.1286 \
        scb=0.0193134 scc=0.00106338 m=(1)
mp21 (\18\:CKbb \7\:CKb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.4e-07 sd=160n sca=17.1675 \
        scb=0.0165438 scc=0.00103968 m=(1)
mp25 (\9\:n20 CKbb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.775e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\9\:n20 \2\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.57e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (n26 mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=1.505e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.455e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout n20 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=8.17e-14 ps=1.58e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.19e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\7\:n30 \9\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.17e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=7.65e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\7\:n30 \7\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.44e-14 ps=6.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=5.6e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (n36 \4\:qbint \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=2.365e-14 ps=1.58e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=4.05e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp20 (\12\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=3.01e-14 ps=1.23e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\11\:qint \15\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.4e-07 sd=160n sca=52.4731 \
        scb=0.0379902 scc=0.00614793 m=(1)
C1 (CK VSS) capacitor c=5.08817e-17
C2 (RN VSS) capacitor c=3.45203e-17
C3 (Q VSS) capacitor c=3.14692e-17
C4 (VDD VSS) capacitor c=2.94531e-16
C5 (D VSS) capacitor c=1.6775e-17
C6 (QN VSS) capacitor c=3.84084e-17
C7 (n0 VSS) capacitor c=1.48018e-18
C8 (Db VSS) capacitor c=9.14919e-17
C9 (CKbb VSS) capacitor c=4.10531e-17
C10 (CKb VSS) capacitor c=3.03946e-17
C11 (n20 VSS) capacitor c=4.65521e-17
C12 (mout VSS) capacitor c=5.68065e-17
C13 (n30 VSS) capacitor c=6.3141e-17
C14 (qbint VSS) capacitor c=3.50083e-17
C15 (qint VSS) capacitor c=1.69919e-16
C16 (n36 VSS) capacitor c=2.01546e-18
C17 (\15\:qbint VSS) capacitor c=4.12943e-17
C18 (\5\:qbint VSS) capacitor c=4.36117e-16
C19 (\1\:CK VSS) capacitor c=2.80175e-17
C20 (\4\:qbint VSS) capacitor c=4.66423e-17
C21 (\7\:CKbb VSS) capacitor c=5.30541e-17
C22 (\9\:CKb VSS) capacitor c=6.42446e-17
C23 (\2\:CKb VSS) capacitor c=8.68408e-17
C24 (\7\:CKb VSS) capacitor c=5.55487e-17
C25 (\4\:RN VSS) capacitor c=4.01967e-17
C26 (\4\:D VSS) capacitor c=4.10443e-17
C27 (\14\:qbint VSS) capacitor c=2.81165e-17
C28 (\3\:CK VSS) capacitor c=3.24046e-17
C29 (\4\:n30 VSS) capacitor c=3.27395e-17
C30 (\3\:qbint VSS) capacitor c=7.98245e-17
C31 (\8\:CKb VSS) capacitor c=8.95288e-17
C32 (\5\:CKbb VSS) capacitor c=3.32537e-17
C33 (\4\:n20 VSS) capacitor c=3.1632e-17
C34 (\3\:mout VSS) capacitor c=7.04852e-17
C35 (\3\:CKbb VSS) capacitor c=8.11894e-17
C36 (\6\:CKb VSS) capacitor c=2.29223e-17
C37 (\5\:CKb VSS) capacitor c=3.73998e-17
C38 (\3\:RN VSS) capacitor c=7.63621e-17
C39 (\1\:D VSS) capacitor c=4.54873e-17
C40 (\13\:qbint VSS) capacitor c=2.09333e-17
C41 (\2\:CK VSS) capacitor c=3.09372e-17
C42 (\3\:n30 VSS) capacitor c=5.1587e-17
C43 (\8\:CKbb VSS) capacitor c=5.39668e-17
C44 (\10\:CKb VSS) capacitor c=2.20887e-17
C45 (\6\:CKbb VSS) capacitor c=3.98074e-17
C46 (\3\:n20 VSS) capacitor c=1.81243e-17
C47 (\2\:mout VSS) capacitor c=5.21299e-17
C48 (\4\:CKbb VSS) capacitor c=2.54393e-17
C49 (\2\:CKbb VSS) capacitor c=4.53343e-17
C50 (\1\:RN VSS) capacitor c=2.42197e-17
C51 (\3\:D VSS) capacitor c=1.04274e-17
C52 (\11\:qint VSS) capacitor c=1.75327e-17
C53 (\1\:VDD VSS) capacitor c=2.50028e-16
C54 (\3\:QN VSS) capacitor c=9.11046e-17
C55 (\1\:Q VSS) capacitor c=9.68928e-17
C56 (\12\:CKb VSS) capacitor c=1.48663e-16
C57 (\25\:qbint VSS) capacitor c=3.64392e-17
C58 (\12\:VDD VSS) capacitor c=2.47436e-17
C59 (\7\:n30 VSS) capacitor c=6.26635e-17
C60 (\8\:mout VSS) capacitor c=2.19314e-17
C61 (\15\:VDD VSS) capacitor c=1.86895e-17
C62 (\9\:n20 VSS) capacitor c=3.84288e-17
C63 (\8\:Db VSS) capacitor c=3.01991e-17
C64 (\18\:CKbb VSS) capacitor c=8.32556e-17
C65 (\19\:VDD VSS) capacitor c=1.83735e-17
C66 (\4\:Db VSS) capacitor c=1.43877e-16
C67 (\21\:VDD VSS) capacitor c=3.64184e-17
C68 (\4\:VDD VSS) capacitor c=5.51992e-17
C69 (\7\:qint VSS) capacitor c=2.47461e-17
C70 (\1\:QN VSS) capacitor c=3.93036e-17
C71 (\3\:Q VSS) capacitor c=3.62512e-17
C72 (\15\:CKb VSS) capacitor c=9.51152e-17
C73 (\19\:qbint VSS) capacitor c=1.02857e-16
C74 (\9\:n30 VSS) capacitor c=6.08835e-17
C75 (\4\:mout VSS) capacitor c=7.18634e-17
C76 (\7\:n20 VSS) capacitor c=3.947e-17
C77 (\13\:CKbb VSS) capacitor c=8.26269e-17
C78 (\6\:Db VSS) capacitor c=8.73216e-17
C79 (\2\:D VSS) capacitor c=3.23404e-17
C80 (\2\:RN VSS) capacitor c=3.26192e-17
C81 (\3\:CKb VSS) capacitor c=5.88131e-17
C82 (\4\:CKb VSS) capacitor c=4.68437e-17
C83 (\2\:n20 VSS) capacitor c=2.43801e-17
C84 (\2\:qbint VSS) capacitor c=2.79136e-17
C85 (\5\:D VSS) capacitor c=8.61399e-17
C86 (\5\:RN VSS) capacitor c=9.02639e-17
C87 (\3\:Db VSS) capacitor c=9.51859e-17
C88 (\5\:n20 VSS) capacitor c=4.98784e-17
C89 (\6\:n20 VSS) capacitor c=5.26593e-17
C90 (\6\:mout VSS) capacitor c=5.21324e-17
C91 (\7\:mout VSS) capacitor c=3.92429e-17
C92 (\9\:CKbb VSS) capacitor c=4.56254e-17
C93 (\10\:CKbb VSS) capacitor c=1.22835e-16
C94 (\11\:CKbb VSS) capacitor c=9.14299e-17
C95 (\12\:CKbb VSS) capacitor c=6.5047e-17
C96 (\15\:CKbb VSS) capacitor c=2.39355e-17
C97 (\16\:CKbb VSS) capacitor c=1.37667e-17
C98 (\17\:CKbb VSS) capacitor c=6.9775e-17
C99 (\5\:n30 VSS) capacitor c=3.32229e-17
C100 (\6\:n30 VSS) capacitor c=5.03e-17
C101 (\11\:CKb VSS) capacitor c=1.49128e-16
C102 (\14\:CKb VSS) capacitor c=6.83414e-17
C103 (\4\:CK VSS) capacitor c=7.05065e-17
C104 (\16\:qbint VSS) capacitor c=6.14544e-17
C105 (\21\:qbint VSS) capacitor c=4.80561e-17
C106 (\22\:qbint VSS) capacitor c=3.42477e-17
C107 (\9\:qint VSS) capacitor c=2.52973e-17
C108 (\10\:qint VSS) capacitor c=3.04564e-17
C109 (\11\:VDD VSS) capacitor c=4.6989e-17
C110 (\14\:VDD VSS) capacitor c=3.36558e-17
C111 (\18\:VDD VSS) capacitor c=1.87504e-17
Rk27 (CK \4\:CK) resistor r=0.07932 c=0
Rk2 (RN \5\:RN) resistor r=0.07501 c=0
Rk28 (\2\:Q Q) resistor r=0.3362 c=0
Rk29 (Q \4\:Q) resistor r=0.03326 c=0
Rk61 (\1\:VDD \11\:VDD) resistor r=0.4718 c=0
Rk62 (\11\:VDD \13\:VDD) resistor r=0.1025 c=0
Rk63 (\11\:VDD \14\:VDD) resistor r=0.5102 c=0
Rk64 (\14\:VDD \16\:VDD) resistor r=0.0433 c=0
Rk65 (\14\:VDD \17\:VDD) resistor r=0.2195 c=0
Rk68 (\18\:VDD VDD) resistor r=0.2358 c=0
Rk66 (\17\:VDD \18\:VDD) resistor r=0.3157 c=0
Rk67 (\18\:VDD \20\:VDD) resistor r=0.1439 c=0
Rk69 (VDD \22\:VDD) resistor r=0.3494 c=0
Rk1 (D \5\:D) resistor r=0.01969 c=0
Rk30 (\2\:QN QN) resistor r=0.02733 c=0
Rk31 (QN \4\:QN) resistor r=0.256 c=0
Rk46 (\1\:VSS \7\:VSS) resistor r=0.4174 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.5212 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.2054 c=0
Rk50 (\10\:VSS VSS) resistor r=0.2027 c=0
Rk49 (\9\:VSS \10\:VSS) resistor r=0.3483 c=0
Rk53 (\7\:VSS \16\:VSS) resistor r=0.3459 c=0
Rk54 (\8\:VSS \18\:VSS) resistor r=0.1025 c=0
Rk55 (\10\:VSS \20\:VSS) resistor r=0.2599 c=0
Rk3 (\2\:Db \3\:Db) resistor r=0.4146 c=0
Rk4 (\3\:Db \5\:Db) resistor r=0.5495 c=0
Rk5 (\5\:Db \7\:Db) resistor r=0.5506 c=0
Rk6 (\3\:Db \9\:Db) resistor r=0.07429 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.2231 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.8883 c=0
Rk15 (\11\:CKbb \12\:CKbb) resistor r=0.2322 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.2623 c=0
Rk17 (\10\:CKbb \15\:CKbb) resistor r=0.02784 c=0
Rk18 (\11\:CKbb \16\:CKbb) resistor r=0.02283 c=0
Rk19 (\12\:CKbb \17\:CKbb) resistor r=0.359 c=0
Rk20 (\14\:CKbb \19\:CKbb) resistor r=0.5014 c=0
Rk24 (\11\:CKb \13\:CKb) resistor r=0.9665 c=0
Rk25 (\11\:CKb \14\:CKb) resistor r=0.5498 c=0
Rk26 (\13\:CKb \16\:CKb) resistor r=0.4824 c=0
Rk7 (\5\:n20 \6\:n20) resistor r=0.2851 c=0
Rk8 (\6\:n20 \8\:n20) resistor r=0.1277 c=0
Rk9 (\6\:n20 \10\:n20) resistor r=0.2533 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.2946 c=0
Rk11 (\6\:mout \7\:mout) resistor r=0.2417 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.1176 c=0
Rk21 (\5\:n30 \6\:n30) resistor r=0.132 c=0
Rk22 (\6\:n30 \8\:n30) resistor r=0.3714 c=0
Rk23 (\6\:n30 \10\:n30) resistor r=0.2777 c=0
Rk32 (\16\:qbint \5\:qbint) resistor r=0.4971 c=0
Rk34 (\5\:qbint \20\:qbint) resistor r=0.5528 c=0
Rk35 (\20\:qbint \21\:qbint) resistor r=0.4085 c=0
Rk36 (\21\:qbint \22\:qbint) resistor r=0.1162 c=0
Rk39 (\21\:qbint \26\:qbint) resistor r=0.1458 c=0
Rk40 (\8\:qint \9\:qint) resistor r=0.1713 c=0
Rk41 (\9\:qint \10\:qint) resistor r=0.1954 c=0
Rk42 (\9\:qint \12\:qint) resistor r=0.1063 c=0
Rl30 (\1\:CK \2\:CK) resistor r=26.9231 c=0
Rl31 (\2\:CK \3\:CK) resistor r=41.7582 c=0
Rl6 (\2\:RN \4\:RN) resistor r=34.3295 c=0
Rl5 (\2\:RN \3\:RN) resistor r=157.99 c=0
Rl4 (\1\:RN \2\:RN) resistor r=0.5213 c=0
Rl3 (\2\:D \4\:D) resistor r=130.231 c=0
Rl1 (\1\:D \2\:D) resistor r=57.2019 c=0
Rl2 (\2\:D \3\:D) resistor r=4.5402 c=0
Rl21 (\7\:CKbb \8\:CKbb) resistor r=46.3695 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=48.7687 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=55.0021 c=0
Rl7 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl22 (\8\:CKb \9\:CKb) resistor r=218.796 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl8 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl9 (\2\:CKb \3\:CKb) resistor r=234.159 c=0
Rl12 (\3\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl13 (\4\:CKb \7\:CKb) resistor r=99.3618 c=0
Rl11 (\4\:CKb \5\:CKb) resistor r=102.754 c=0
Rl10 (\3\:CKb \4\:CKb) resistor r=139.705 c=0
Rl17 (n20 \2\:n20) resistor r=106.572 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=1.2301 c=0
Rl15 (mout \2\:mout) resistor r=24.2328 c=0
Rl16 (\2\:mout \3\:mout) resistor r=101.156 c=0
Rl27 (n30 \2\:n30) resistor r=123.385 c=0
Rl29 (\2\:n30 \4\:n30) resistor r=23.7402 c=0
Rl28 (\2\:n30 \3\:n30) resistor r=4.3511 c=0
Rl44 (\14\:qbint \15\:qbint) resistor r=97.6426 c=0
Rl43 (\13\:qbint \14\:qbint) resistor r=31.9846 c=0
Rl26 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl25 (\2\:qbint \3\:qbint) resistor r=106.581 c=0
Rl24 (\2\:qbint qbint) resistor r=10.9374 c=0
Rz8 (\4\:Q \3\:Q) resistor r=75 c=0
Rz18 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz19 (\17\:VDD \4\:VDD) resistor r=6.25 c=0
Rz9 (\2\:QN \1\:QN) resistor r=75 c=0
Rz15 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (Db \2\:Db) resistor r=75 c=0
Rz2 (\6\:Db \7\:Db) resistor r=75 c=0
Rz5 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz4 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz10 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz11 (\8\:qint \7\:qint) resistor r=75 c=0
Ry8 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry18 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry19 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry9 (\4\:QN \3\:QN) resistor r=20.6667 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry13 (\9\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:Db \5\:Db) resistor r=62 c=0
Ry2 (\8\:Db \9\:Db) resistor r=62 c=0
Ry5 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry7 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry3 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\26\:qbint \25\:qbint) resistor r=62 c=0
Ry11 (\12\:qint \11\:qint) resistor r=62 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\1\:RN \5\:RN) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx10 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx11 (CKb \14\:CKb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx13 (\16\:qbint \13\:qbint) resistor r=45 c=0
Rx14 (\22\:qbint qbint) resistor r=45 c=0
Rx17 (\10\:qint qint) resistor r=45 c=0
mn1 (\6\:Db \1\:D n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn0 (n0 \3\:RN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn21 (\13\:CKbb \5\:CKb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn25 (\7\:n20 \6\:CKb Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.93e-14 ps=5.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=4.93e-14 ps=4.2e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.495e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n25 \3\:mout \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=9.43e-15 ps=1.6e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.385e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\4\:mout \4\:n20 \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.12e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\9\:n30 \5\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\9\:n30 \8\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.988e-14 ps=4.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=4.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=8.7e-15 ps=7.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=3.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\15\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.48e-14 ps=1.7e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4e-07 sb=1.395e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\7\:qint \14\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint \4\:n30 \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=2.87e-14 ps=7.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37073e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\3\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.635e-14 ad=4.16e-14 ps=1.65e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84712e-07 sb=9.76058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.273e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.54712e-07 sb=5.06058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\25\:qbint n30 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=4.34e-14 ps=1.58e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28315e-06 sb=1.4e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp57_1__rcx (\3\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.388e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.98846e-07 sb=4.74551e-07 sd=160n sca=31.0979 \
        scb=0.0204275 scc=0.00336106 m=(2)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.764e-14 ad=6.24e-14 ps=1.165e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.88846e-07 sb=8.84551e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
ends DFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:59 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFTRX4
// View name: extracted

simulator lang=spectre

subckt DFFTRX4 CK D Q QN RN VDD VSS
mp0 (\4\:Db \3\:RN \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=3.44e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=26.9085 scb=0.0317837 \
        scc=0.0019009 m=(1)
mp1 (\4\:Db \1\:D \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.94e-14 ad=3.44e-14 ps=1.15e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=18.5149 scb=0.0187285 \
        scc=0.000914624 m=(1)
mp20 (\14\:CKb \1\:CK \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.665e-14 ad=2.89e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34419e-07 sb=3.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\16\:CKbb \8\:CKb \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.29419e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\8\:n20 CKbb \9\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp35 (n26 mout \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.848e-14 ps=8.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.848e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp50 (n36 \4\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
C1 (Q VSS) capacitor c=2.15642e-17
C2 (CK VSS) capacitor c=6.74796e-17
C3 (D VSS) capacitor c=4.88228e-17
C4 (QN VSS) capacitor c=1.56535e-17
C5 (VDD VSS) capacitor c=2.94996e-16
C6 (RN VSS) capacitor c=3.71365e-17
C7 (Db VSS) capacitor c=7.10618e-17
C8 (CKb VSS) capacitor c=7.82222e-17
C9 (CKbb VSS) capacitor c=3.42558e-17
C10 (n20 VSS) capacitor c=5.17181e-17
C11 (mout VSS) capacitor c=6.22572e-17
C12 (n30 VSS) capacitor c=2.18905e-16
C13 (qbint VSS) capacitor c=2.97807e-17
C14 (qint VSS) capacitor c=2.78532e-16
C15 (n36 VSS) capacitor c=5.26647e-18
C16 (\22\:qbint VSS) capacitor c=4.66957e-17
C17 (\5\:qbint VSS) capacitor c=2.69592e-16
C18 (\4\:qbint VSS) capacitor c=3.89633e-17
C19 (\7\:CKbb VSS) capacitor c=5.08373e-17
C20 (\2\:CKb VSS) capacitor c=1.06161e-16
C21 (\3\:CKb VSS) capacitor c=1.20118e-16
C22 (\8\:CKb VSS) capacitor c=4.69292e-17
C23 (\1\:CK VSS) capacitor c=4.2722e-17
C24 (\1\:D VSS) capacitor c=3.41526e-17
C25 (\3\:RN VSS) capacitor c=3.4837e-17
C26 (\20\:qbint VSS) capacitor c=3.58522e-17
C27 (\3\:qbint VSS) capacitor c=6.35178e-17
C28 (\5\:CKbb VSS) capacitor c=3.60264e-17
C29 (\3\:n20 VSS) capacitor c=3.25762e-17
C30 (\3\:mout VSS) capacitor c=6.98256e-17
C31 (\3\:CKbb VSS) capacitor c=8.37436e-17
C32 (\7\:CKb VSS) capacitor c=2.92454e-17
C33 (\9\:CKb VSS) capacitor c=2.80519e-17
C34 (\3\:CK VSS) capacitor c=3.60296e-17
C35 (\3\:D VSS) capacitor c=4.72586e-17
C36 (\1\:RN VSS) capacitor c=4.39296e-17
C37 (\21\:qbint VSS) capacitor c=4.03719e-17
C38 (\8\:CKbb VSS) capacitor c=4.00883e-17
C39 (\6\:CKbb VSS) capacitor c=3.47592e-17
C40 (\2\:n20 VSS) capacitor c=3.65527e-17
C41 (\2\:mout VSS) capacitor c=5.69572e-17
C42 (\4\:CKbb VSS) capacitor c=2.86235e-17
C43 (\2\:CKbb VSS) capacitor c=4.75607e-17
C44 (\6\:CKb VSS) capacitor c=5.2159e-17
C45 (\2\:CK VSS) capacitor c=4.57504e-17
C46 (\2\:D VSS) capacitor c=4.21417e-17
C47 (\2\:RN VSS) capacitor c=4.28307e-17
C48 (\19\:qint VSS) capacitor c=3.50141e-17
C49 (\1\:VDD VSS) capacitor c=4.5124e-16
C50 (\1\:Q VSS) capacitor c=1.52507e-16
C51 (\30\:qbint VSS) capacitor c=5.97187e-17
C52 (\10\:n30 VSS) capacitor c=5.857e-17
C53 (\4\:mout VSS) capacitor c=2.34004e-17
C54 (\21\:VDD VSS) capacitor c=3.6455e-17
C55 (\8\:n20 VSS) capacitor c=3.02932e-17
C56 (\9\:Db VSS) capacitor c=2.53587e-17
C57 (\16\:CKbb VSS) capacitor c=7.72455e-17
C58 (\24\:VDD VSS) capacitor c=1.93894e-17
C59 (\14\:CKb VSS) capacitor c=1.19706e-16
C60 (\28\:VDD VSS) capacitor c=2.07766e-17
C61 (\4\:Db VSS) capacitor c=3.82025e-17
C62 (\31\:VDD VSS) capacitor c=6.79915e-18
C63 (\3\:VDD VSS) capacitor c=6.08129e-17
C64 (\15\:qint VSS) capacitor c=4.45701e-17
C65 (\1\:QN VSS) capacitor c=1.1926e-16
C66 (\24\:qbint VSS) capacitor c=2.20326e-16
C67 (\8\:n30 VSS) capacitor c=6.50926e-17
C68 (\8\:mout VSS) capacitor c=5.06245e-17
C69 (\6\:n20 VSS) capacitor c=3.83399e-17
C70 (\7\:Db VSS) capacitor c=9.88909e-17
C71 (\11\:CKbb VSS) capacitor c=8.87963e-17
C72 (\12\:CKb VSS) capacitor c=1.92135e-17
C73 (\4\:CKb VSS) capacitor c=8.03502e-17
C74 (\2\:qbint VSS) capacitor c=3.37934e-17
C75 (\4\:RN VSS) capacitor c=5.57303e-17
C76 (\4\:D VSS) capacitor c=8.61483e-17
C77 (\4\:CK VSS) capacitor c=6.91582e-17
C78 (\10\:CKb VSS) capacitor c=8.30512e-17
C79 (\11\:CKb VSS) capacitor c=1.01375e-16
C80 (\3\:Db VSS) capacitor c=1.57419e-16
C81 (\6\:Db VSS) capacitor c=1.26681e-16
C82 (\4\:n20 VSS) capacitor c=5.79274e-17
C83 (\5\:n20 VSS) capacitor c=5.5722e-17
C84 (\6\:mout VSS) capacitor c=5.44229e-17
C85 (\7\:mout VSS) capacitor c=4.50696e-17
C86 (\9\:CKbb VSS) capacitor c=1.11445e-16
C87 (\10\:CKbb VSS) capacitor c=6.20574e-17
C88 (\13\:CKbb VSS) capacitor c=1.2723e-16
C89 (\14\:CKbb VSS) capacitor c=6.38531e-17
C90 (\15\:CKbb VSS) capacitor c=7.19645e-17
C91 (\6\:n30 VSS) capacitor c=5.19904e-17
C92 (\7\:n30 VSS) capacitor c=8.55732e-17
C93 (\4\:Q VSS) capacitor c=1.2294e-16
C94 (\5\:QN VSS) capacitor c=1.65636e-16
C95 (\23\:qbint VSS) capacitor c=2.44076e-16
C96 (\26\:qbint VSS) capacitor c=2.8374e-17
C97 (\27\:qbint VSS) capacitor c=2.28967e-17
C98 (\28\:qbint VSS) capacitor c=4.7337e-17
C99 (\29\:qbint VSS) capacitor c=2.63193e-17
C100 (\17\:qint VSS) capacitor c=3.51979e-17
C101 (\18\:qint VSS) capacitor c=3.79257e-17
C102 (\20\:VDD VSS) capacitor c=3.3376e-17
C103 (\23\:VDD VSS) capacitor c=2.17427e-17
C104 (\27\:VDD VSS) capacitor c=1.42764e-17
C105 (\30\:VDD VSS) capacitor c=6.15764e-18
Rk28 (\1\:Q Q) resistor r=0.04985 c=0
Rk29 (Q \4\:Q) resistor r=0.2115 c=0
Rk54 (\1\:VSS \11\:VSS) resistor r=0.4548 c=0
Rk55 (\11\:VSS \12\:VSS) resistor r=0.5751 c=0
Rk56 (\12\:VSS \13\:VSS) resistor r=0.1276 c=0
Rk58 (\14\:VSS VSS) resistor r=0.02211 c=0
Rk57 (\13\:VSS \14\:VSS) resistor r=0.5286 c=0
Rk64 (\11\:VSS \26\:VSS) resistor r=0.04327 c=0
Rk65 (\12\:VSS \28\:VSS) resistor r=0.1835 c=0
Rk66 (\14\:VSS \30\:VSS) resistor r=0.3326 c=0
Rk3 (\4\:CK CK) resistor r=0.03634 c=0
Rk2 (D \4\:D) resistor r=0.02649 c=0
Rk34 (\1\:QN QN) resistor r=0.2166 c=0
Rk35 (QN \5\:QN) resistor r=0.04792 c=0
Rk78 (\1\:VDD \20\:VDD) resistor r=0.5136 c=0
Rk79 (\20\:VDD \22\:VDD) resistor r=0.3625 c=0
Rk80 (\20\:VDD \23\:VDD) resistor r=0.5084 c=0
Rk81 (\23\:VDD \25\:VDD) resistor r=0.203 c=0
Rk82 (\23\:VDD \26\:VDD) resistor r=0.1802 c=0
Rk83 (\26\:VDD \27\:VDD) resistor r=0.3206 c=0
Rk84 (\27\:VDD \29\:VDD) resistor r=0.203 c=0
Rk87 (\30\:VDD VDD) resistor r=0.02963 c=0
Rk85 (\27\:VDD \30\:VDD) resistor r=0.2001 c=0
Rk86 (\30\:VDD \32\:VDD) resistor r=0.07346 c=0
Rk1 (\4\:RN RN) resistor r=0.01719 c=0
Rk7 (\2\:Db \3\:Db) resistor r=0.5579 c=0
Rk8 (\3\:Db \5\:Db) resistor r=0.2605 c=0
Rk9 (\3\:Db \6\:Db) resistor r=0.8671 c=0
Rk10 (\6\:Db \8\:Db) resistor r=0.4629 c=0
Rk11 (\6\:Db \10\:Db) resistor r=0.0619 c=0
Rk4 (\10\:CKb \11\:CKb) resistor r=0.4907 c=0
Rk5 (\11\:CKb \13\:CKb) resistor r=0.1204 c=0
Rk6 (\11\:CKb \15\:CKb) resistor r=0.642 c=0
Rk18 (\9\:CKbb \10\:CKbb) resistor r=0.1842 c=0
Rk19 (\10\:CKbb \12\:CKbb) resistor r=0.2568 c=0
Rk20 (\9\:CKbb \13\:CKbb) resistor r=0.7568 c=0
Rk21 (\13\:CKbb \14\:CKbb) resistor r=0.3027 c=0
Rk22 (\10\:CKbb \15\:CKbb) resistor r=0.3655 c=0
Rk23 (\12\:CKbb \17\:CKbb) resistor r=0.4721 c=0
Rk12 (\4\:n20 \5\:n20) resistor r=0.2794 c=0
Rk13 (\5\:n20 \7\:n20) resistor r=0.1269 c=0
Rk14 (\5\:n20 \9\:n20) resistor r=0.2555 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.1403 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.2406 c=0
Rk17 (\6\:mout \9\:mout) resistor r=0.2577 c=0
Rk24 (\6\:n30 \7\:n30) resistor r=0.258 c=0
Rk25 (\7\:n30 \9\:n30) resistor r=0.3134 c=0
Rk26 (\7\:n30 \11\:n30) resistor r=0.419 c=0
Rk38 (\23\:qbint \25\:qbint) resistor r=1.8737 c=0
Rk39 (\25\:qbint \26\:qbint) resistor r=0.433 c=0
Rk40 (\26\:qbint \27\:qbint) resistor r=0.1039 c=0
Rk41 (\27\:qbint \28\:qbint) resistor r=0.178 c=0
Rk42 (\26\:qbint \29\:qbint) resistor r=0.06882 c=0
Rk43 (\27\:qbint \31\:qbint) resistor r=0.197 c=0
Rk44 (\16\:qint \17\:qint) resistor r=0.3535 c=0
Rk45 (\17\:qint \18\:qint) resistor r=0.2067 c=0
Rk46 (\17\:qint \20\:qint) resistor r=0.1262 c=0
Rl5 (\1\:CK \2\:CK) resistor r=71.1538 c=0
Rl6 (\2\:CK \3\:CK) resistor r=101.374 c=0
Rl3 (\1\:D \2\:D) resistor r=57.6923 c=0
Rl4 (\2\:D \3\:D) resistor r=78.2967 c=0
Rl2 (\2\:RN \3\:RN) resistor r=88.2566 c=0
Rl1 (\1\:RN \2\:RN) resistor r=48.161 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=408.747 c=0
Rl14 (CKb \2\:CKb) resistor r=187.593 c=0
Rl21 (\6\:CKb \9\:CKb) resistor r=80.2255 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=168.774 c=0
Rl19 (\4\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl20 (\5\:CKb \8\:CKb) resistor r=83.7744 c=0
Rl18 (\5\:CKb \6\:CKb) resistor r=14.7598 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=201.998 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl13 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl8 (\3\:CKbb \4\:CKbb) resistor r=58.3841 c=0
Rl7 (CKbb \2\:CKbb) resistor r=53.079 c=0
Rl11 (n20 \2\:n20) resistor r=100.692 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl9 (mout \2\:mout) resistor r=37.6944 c=0
Rl10 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl58 (\21\:qbint \22\:qbint) resistor r=62.6944 c=0
Rl57 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl25 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rl23 (\2\:qbint qbint) resistor r=6.99 c=0
Rz20 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz21 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz22 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz24 (\1\:VDD \3\:VDD) resistor r=3.75 c=0
Rz25 (\26\:VDD \3\:VDD) resistor r=6.25 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz1 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz4 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz12 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz13 (\16\:qint \15\:qint) resistor r=75 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=3.1 c=0
Ry16 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry23 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry24 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry25 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry26 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry2 (\4\:Db \5\:Db) resistor r=62 c=0
Ry3 (\9\:Db \10\:Db) resistor r=62 c=0
Ry1 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry6 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry4 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry12 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry13 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:RN \4\:RN) resistor r=45 c=0
Rx4 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx7 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx5 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx6 (\2\:mout \7\:mout) resistor r=45 c=0
Rx11 (\6\:n30 n30) resistor r=45 c=0
Rx12 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx13 (\28\:qbint qbint) resistor r=45 c=0
Rx14 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx15 (\18\:qint qint) resistor r=45 c=0
mn0 (n0 \1\:RN \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn20 (\12\:CKb \3\:CK \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=5.728e-14 ps=6.8e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=3.85e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn21 (\11\:CKbb \9\:CKb \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=2.103e-14 ps=6.8e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn25 (\6\:n20 \7\:CKb \7\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.345e-14 ad=3.625e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.552e-14 ps=7.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.552e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (n35 \3\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.087e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.592e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(2)
mn56 (\15\:qint \20\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.095e-14 ad=4.745e-14 ps=1.3325e-06 pd=8.85e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=10.79 scb=0.0100512 scc=0.000418069 m=(4)
mn55_1__rcx (\4\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mp45 (\30\:qbint n30 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27395e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp56 (\19\:qint \22\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57 (\5\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
ends DFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:00 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFTRXL
// View name: extracted

simulator lang=spectre

subckt DFFTRXL CK D Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=48.9651 \
        scb=0.0318882 scc=0.00591085 m=(1)
mp56 (\5\:qint \7\:qbint \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\3\:Q \5\:qbint \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=3.117e-14 ps=1.6e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.35e-07 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp20 (\13\:CKb \3\:CK \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.4e-07 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp45 (\16\:qbint \3\:n30 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.755e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp50 (n36 \8\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.118e-14 ps=1.52e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.49e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp51 (\8\:n30 \2\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.3e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp40 (\8\:n30 \2\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.095e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp30 (\6\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=7.203e-14 ps=1.52e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.15e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp35 (n26 mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.29e-14 ps=1.52e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=4.5e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp36 (\9\:n20 \7\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=3.45e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp25 (\9\:n20 \7\:CKbb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp21 (\9\:CKbb \8\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.838e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=46.8621 \
        scb=0.0289219 scc=0.00588474 m=(1)
mp0 (\3\:Db \4\:RN \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.838e-14 ad=3.44e-14 ps=1.48e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.05e-07 sd=160n sca=48.9651 \
        scb=0.0318882 scc=0.00591085 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1e-07 sd=160n sca=57.0065 scb=0.0445545 \
        scc=0.00681945 m=(1)
C1 (D VSS) capacitor c=5.53782e-17
C2 (QN VSS) capacitor c=2.29681e-17
C3 (RN VSS) capacitor c=6.45708e-17
C4 (Q VSS) capacitor c=5.11104e-17
C5 (VDD VSS) capacitor c=2.80173e-16
C6 (CK VSS) capacitor c=5.43771e-17
C7 (qint VSS) capacitor c=1.99284e-17
C8 (qbint VSS) capacitor c=1.8263e-17
C9 (CKb VSS) capacitor c=8.19209e-17
C10 (n30 VSS) capacitor c=3.84709e-17
C11 (n35 VSS) capacitor c=5.08221e-18
C12 (mout VSS) capacitor c=8.47423e-17
C13 (CKbb VSS) capacitor c=5.1998e-17
C14 (n20 VSS) capacitor c=4.78685e-17
C15 (Db VSS) capacitor c=6.18428e-17
C16 (n0 VSS) capacitor c=7.73859e-19
C17 (n36 VSS) capacitor c=1.63392e-18
C18 (\1\:D VSS) capacitor c=2.99561e-17
C19 (\4\:RN VSS) capacitor c=4.25943e-17
C20 (\8\:CKb VSS) capacitor c=4.33039e-17
C21 (\7\:CKbb VSS) capacitor c=4.14188e-17
C22 (\7\:CKb VSS) capacitor c=7.78361e-17
C23 (\3\:n20 VSS) capacitor c=3.55012e-17
C24 (\2\:CKb VSS) capacitor c=4.44446e-17
C25 (\2\:CKbb VSS) capacitor c=4.32976e-17
C26 (\8\:qbint VSS) capacitor c=5.4143e-17
C27 (\3\:n30 VSS) capacitor c=3.12859e-17
C28 (\3\:CK VSS) capacitor c=3.11117e-17
C29 (\5\:qbint VSS) capacitor c=3.87673e-17
C30 (\7\:qbint VSS) capacitor c=3.58748e-17
C31 (\4\:qint VSS) capacitor c=3.81262e-17
C32 (\3\:D VSS) capacitor c=2.99285e-17
C33 (\1\:RN VSS) capacitor c=4.11022e-17
C34 (\4\:CKb VSS) capacitor c=2.65518e-17
C35 (\9\:CKb VSS) capacitor c=2.96691e-17
C36 (\5\:CKbb VSS) capacitor c=9.19415e-17
C37 (\3\:mout VSS) capacitor c=5.5672e-17
C38 (\3\:CKbb VSS) capacitor c=3.66645e-17
C39 (\11\:qbint VSS) capacitor c=2.88151e-17
C40 (\1\:CK VSS) capacitor c=4.11448e-17
C41 (\4\:qbint VSS) capacitor c=2.62604e-17
C42 (\3\:qint VSS) capacitor c=3.10033e-17
C43 (\2\:D VSS) capacitor c=2.89161e-17
C44 (\3\:RN VSS) capacitor c=4.14978e-17
C45 (\8\:CKbb VSS) capacitor c=4.84314e-17
C46 (\10\:CKb VSS) capacitor c=3.18292e-17
C47 (\6\:CKbb VSS) capacitor c=3.06885e-17
C48 (\2\:mout VSS) capacitor c=6.72024e-17
C49 (\4\:n20 VSS) capacitor c=5.52088e-17
C50 (\4\:CKbb VSS) capacitor c=3.5878e-17
C51 (\3\:CKb VSS) capacitor c=2.19988e-17
C52 (\10\:qbint VSS) capacitor c=2.5963e-17
C53 (\2\:n30 VSS) capacitor c=3.92941e-17
C54 (\2\:CK VSS) capacitor c=3.13585e-17
C55 (\1\:VDD VSS) capacitor c=1.30911e-17
C56 (\3\:Db VSS) capacitor c=9.06594e-17
C57 (\11\:VDD VSS) capacitor c=2.13178e-17
C58 (\9\:CKbb VSS) capacitor c=5.96949e-17
C59 (\8\:Db VSS) capacitor c=2.24651e-17
C60 (\9\:n20 VSS) capacitor c=3.57644e-17
C61 (\13\:VDD VSS) capacitor c=2.39587e-17
C62 (\6\:mout VSS) capacitor c=3.6927e-17
C63 (\8\:n30 VSS) capacitor c=3.96585e-17
C64 (\15\:VDD VSS) capacitor c=2.48041e-17
C65 (\16\:qbint VSS) capacitor c=4.55158e-17
C66 (\13\:CKb VSS) capacitor c=1.45715e-16
C67 (\17\:VDD VSS) capacitor c=1.28233e-17
C68 (\3\:Q VSS) capacitor c=4.97251e-17
C69 (\5\:qint VSS) capacitor c=3.26496e-17
C70 (\19\:VDD VSS) capacitor c=1.18029e-17
C71 (\1\:QN VSS) capacitor c=1.5866e-17
C72 (\4\:VDD VSS) capacitor c=5.07556e-17
C73 (\11\:CKbb VSS) capacitor c=7.18765e-17
C74 (\6\:Db VSS) capacitor c=7.47025e-17
C75 (\7\:n20 VSS) capacitor c=5.08648e-17
C76 (\8\:mout VSS) capacitor c=3.69588e-17
C77 (\4\:n30 VSS) capacitor c=7.62256e-17
C78 (\14\:qbint VSS) capacitor c=8.55675e-17
C79 (\11\:CKb VSS) capacitor c=7.51951e-17
C80 (\1\:Q VSS) capacitor c=5.20201e-17
C81 (\9\:qint VSS) capacitor c=3.12612e-17
C82 (\3\:QN VSS) capacitor c=3.52256e-17
C83 (\2\:qint VSS) capacitor c=1.25668e-17
C84 (\2\:qbint VSS) capacitor c=3.84479e-17
C85 (\3\:qbint VSS) capacitor c=3.72934e-17
C86 (\9\:qbint VSS) capacitor c=2.9314e-17
C87 (\5\:CKb VSS) capacitor c=4.1852e-17
C88 (\6\:CKb VSS) capacitor c=7.22505e-17
C89 (\7\:qint VSS) capacitor c=3.28649e-17
C90 (\8\:qint VSS) capacitor c=2.85862e-17
C91 (\4\:CK VSS) capacitor c=8.07667e-17
C92 (\12\:qbint VSS) capacitor c=6.18426e-17
C93 (\13\:qbint VSS) capacitor c=4.36404e-17
C94 (\18\:qbint VSS) capacitor c=1.12769e-16
C95 (\6\:n30 VSS) capacitor c=8.39204e-17
C96 (\7\:n30 VSS) capacitor c=5.19029e-17
C97 (\4\:mout VSS) capacitor c=3.856e-17
C98 (\5\:mout VSS) capacitor c=5.4457e-17
C99 (\15\:CKb VSS) capacitor c=1.56639e-16
C100 (\16\:CKb VSS) capacitor c=7.74459e-17
C101 (\5\:n20 VSS) capacitor c=4.59979e-17
C102 (\6\:n20 VSS) capacitor c=5.10753e-17
C103 (\13\:CKbb VSS) capacitor c=6.67456e-17
C104 (\14\:CKbb VSS) capacitor c=9.17856e-17
C105 (\15\:CKbb VSS) capacitor c=9.50477e-17
C106 (\16\:CKbb VSS) capacitor c=6.77652e-17
C107 (\17\:CKbb VSS) capacitor c=6.27164e-17
C108 (\5\:RN VSS) capacitor c=5.79494e-17
C109 (\4\:D VSS) capacitor c=7.65171e-17
C110 (\5\:Db VSS) capacitor c=7.44926e-17
C111 (\3\:VDD VSS) capacitor c=1.82742e-17
C112 (\6\:VDD VSS) capacitor c=4.12718e-17
C113 (\7\:VDD VSS) capacitor c=4.04552e-17
C114 (\9\:VDD VSS) capacitor c=7.59777e-18
C115 (\10\:VDD VSS) capacitor c=9.77877e-18
Rk32 (\4\:D D) resistor r=0.1747 c=0
Rk2 (\4\:QN QN) resistor r=0.0927 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2238 c=0
Rk31 (RN \5\:RN) resistor r=0.187 c=0
Rk6 (\2\:Q Q) resistor r=0.16 c=0
Rk7 (Q \4\:Q) resistor r=0.152 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.3948 c=0
Rk38 (\3\:VDD \5\:VDD) resistor r=0.2951 c=0
Rk39 (\5\:VDD \6\:VDD) resistor r=0.2676 c=0
Rk40 (\6\:VDD \7\:VDD) resistor r=0.5201 c=0
Rk41 (\7\:VDD \8\:VDD) resistor r=0.3627 c=0
Rk42 (\8\:VDD \9\:VDD) resistor r=0.04985 c=0
Rk44 (\10\:VDD VDD) resistor r=0.2323 c=0
Rk43 (\9\:VDD \10\:VDD) resistor r=0.2674 c=0
Rk45 (\3\:VDD \12\:VDD) resistor r=0.222 c=0
Rk46 (\6\:VDD \14\:VDD) resistor r=0.1017 c=0
Rk47 (\7\:VDD \16\:VDD) resistor r=0.1017 c=0
Rk48 (\9\:VDD \18\:VDD) resistor r=0.07311 c=0
Rk49 (\10\:VDD \20\:VDD) resistor r=0.222 c=0
Rk50 (\2\:VSS \4\:VSS) resistor r=0.3847 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.2616 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.4966 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.3902 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.04485 c=0
Rk56 (\9\:VSS VSS) resistor r=0.2323 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.2724 c=0
Rk57 (\5\:VSS \11\:VSS) resistor r=0.04318 c=0
Rk58 (\6\:VSS \13\:VSS) resistor r=0.3694 c=0
Rk59 (\8\:VSS \15\:VSS) resistor r=0.07311 c=0
Rk60 (\9\:VSS \17\:VSS) resistor r=0.07311 c=0
Rk8 (\4\:CK CK) resistor r=0.2418 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1173 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1188 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1053 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.2452 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.2569 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.287 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.8078 c=0
Rk19 (\12\:CKb \14\:CKb) resistor r=0.476 c=0
Rk20 (\14\:CKb \15\:CKb) resistor r=0.952 c=0
Rk21 (\15\:CKb \16\:CKb) resistor r=0.5262 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.4647 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2175 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.2739 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1639 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2791 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.08273 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.2997 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.3913 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \15\:CKbb) resistor r=0.682 c=0
Rk29 (\13\:CKbb \16\:CKbb) resistor r=0.3477 c=0
Rk30 (\15\:CKbb \17\:CKbb) resistor r=0.2586 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.2083 c=0
Rk23 (\6\:n20 \8\:n20) resistor r=0.237 c=0
Rk24 (\6\:n20 \10\:n20) resistor r=0.176 c=0
Rk33 (\2\:Db \4\:Db) resistor r=0.4546 c=0
Rk34 (\4\:Db \5\:Db) resistor r=0.4775 c=0
Rk35 (\5\:Db \7\:Db) resistor r=0.3903 c=0
Rk36 (\5\:Db \9\:Db) resistor r=0.08888 c=0
Rl37 (\1\:D \2\:D) resistor r=33.7834 c=0
Rl38 (\2\:D \3\:D) resistor r=24.7951 c=0
Rl36 (\2\:RN \4\:RN) resistor r=43.2462 c=0
Rl34 (\1\:RN \2\:RN) resistor r=47.0924 c=0
Rl35 (\2\:RN \3\:RN) resistor r=2.9709 c=0
Rl11 (\2\:CK \3\:CK) resistor r=26.3736 c=0
Rl10 (\1\:CK \2\:CK) resistor r=100 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=0.5213 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=104.301 c=0
Rl4 (qbint \2\:qbint) resistor r=38.9161 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=3.9233 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=146.04 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=111.253 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=47.791 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl18 (CKb \2\:CKb) resistor r=199.566 c=0
Rl33 (\7\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl31 (\5\:CKb \8\:CKb) resistor r=51.3446 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=47.0285 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=172.62 c=0
Rl32 (\6\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=201.946 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.9451 c=0
Rl12 (n30 \2\:n30) resistor r=113.462 c=0
Rl24 (mout \2\:mout) resistor r=111.139 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=64.6174 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=37.2302 c=0
Rl17 (CKbb \2\:CKbb) resistor r=64.5404 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=67.6161 c=0
Rl21 (n20 \2\:n20) resistor r=85.2786 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=4.3511 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz12 (\4\:VDD \5\:VDD) resistor r=6.8182 c=0
Rz13 (\4\:VDD \8\:VDD) resistor r=6.25 c=0
Rz14 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz15 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz16 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz17 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry19 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\8\:Db \9\:Db) resistor r=62 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\3\:RN \5\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx13 (CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \5\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q qbint \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.132e-14 ad=2.03e-14 ps=1.73e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\11\:CKb \1\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.132e-14 ad=2.32e-14 ps=1.73e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\14\:qbint n30 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.825e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn50 (n35 \11\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.19e-14 ps=6.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.615e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn51 (\4\:n30 CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.755e-14 ps=7.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.35e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn40 (\4\:n30 \3\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=2.755e-14 ps=8.5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.115e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn30 (\8\:mout n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=4.06e-14 ps=1.59e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=7.9e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn35 (n25 \3\:mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=8.7e-15 ps=1.59e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=5.95e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn36 (\7\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=4.9e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn25 (\7\:n20 \9\:CKb \6\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=2.85e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn21 (\11\:CKbb \4\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (n0 \1\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.232e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.233e-14 \
        ad=3.263e-14 ps=4.6e-07 pd=7.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=2.25e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
ends DFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:01 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFX1
// View name: extracted

simulator lang=spectre

subckt DFFX1 CK D Q QN VDD VSS
mp57 (\1\:QN \4\:qint \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.49744e-07 sd=160n sca=35.2977 \
        scb=0.0266107 scc=0.00346222 m=(1)
mp55 (\1\:Q qbint \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.555e-14 ad=5.46e-14 ps=1.92e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.87436e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
C1 (D VSS) capacitor c=8.25216e-17
C2 (QN VSS) capacitor c=2.1175e-17
C3 (Q VSS) capacitor c=4.07219e-17
C4 (VDD VSS) capacitor c=2.47524e-16
C5 (CK VSS) capacitor c=4.06489e-17
C6 (qint VSS) capacitor c=2.13586e-17
C7 (qbint VSS) capacitor c=4.56704e-17
C8 (CKb VSS) capacitor c=2.26755e-17
C9 (n30 VSS) capacitor c=4.02362e-17
C10 (n35 VSS) capacitor c=2.55819e-18
C11 (mout VSS) capacitor c=5.06335e-17
C12 (CKbb VSS) capacitor c=5.1112e-17
C13 (n20 VSS) capacitor c=3.2118e-17
C14 (n25 VSS) capacitor c=1.73661e-18
C15 (n21 VSS) capacitor c=7.01524e-19
C16 (n36 VSS) capacitor c=1.1262e-18
C17 (n26 VSS) capacitor c=8.70796e-19
C18 (n22 VSS) capacitor c=7.32139e-19
C19 (\10\:CKb VSS) capacitor c=4.66928e-17
C20 (\1\:D VSS) capacitor c=3.15347e-17
C21 (\5\:CKbb VSS) capacitor c=6.9781e-17
C22 (\5\:CKb VSS) capacitor c=5.14322e-17
C23 (\4\:mout VSS) capacitor c=7.89007e-17
C24 (\4\:n20 VSS) capacitor c=3.56696e-17
C25 (\2\:CKbb VSS) capacitor c=4.83774e-17
C26 (\8\:qbint VSS) capacitor c=6.78558e-17
C27 (\3\:n30 VSS) capacitor c=4.02986e-17
C28 (\1\:CK VSS) capacitor c=3.19565e-17
C29 (\7\:qbint VSS) capacitor c=3.31148e-17
C30 (\4\:qint VSS) capacitor c=4.52163e-17
C31 (\8\:CKb VSS) capacitor c=2.88626e-17
C32 (\3\:D VSS) capacitor c=8.07237e-17
C33 (\6\:CKb VSS) capacitor c=7.19358e-17
C34 (\6\:CKbb VSS) capacitor c=6.43098e-17
C35 (\3\:n20 VSS) capacitor c=4.9931e-17
C36 (\3\:CKbb VSS) capacitor c=4.02968e-17
C37 (\3\:CKb VSS) capacitor c=6.0241e-17
C38 (\11\:qbint VSS) capacitor c=3.56819e-17
C39 (\3\:CK VSS) capacitor c=3.50065e-17
C40 (\5\:qbint VSS) capacitor c=3.11695e-17
C41 (\4\:qbint VSS) capacitor c=2.72438e-17
C42 (\3\:qint VSS) capacitor c=3.64658e-17
C43 (\9\:CKb VSS) capacitor c=3.88397e-17
C44 (\2\:D VSS) capacitor c=6.04176e-17
C45 (\7\:CKb VSS) capacitor c=5.25326e-17
C46 (\7\:CKbb VSS) capacitor c=3.00387e-17
C47 (\4\:CKb VSS) capacitor c=5.00172e-17
C48 (\3\:mout VSS) capacitor c=3.41489e-17
C49 (\4\:CKbb VSS) capacitor c=3.94816e-17
C50 (\2\:CKb VSS) capacitor c=6.85356e-17
C51 (\10\:qbint VSS) capacitor c=2.68585e-17
C52 (\2\:n30 VSS) capacitor c=4.42892e-17
C53 (\2\:CK VSS) capacitor c=2.83132e-17
C54 (\13\:CKbb VSS) capacitor c=4.46506e-17
C55 (\1\:VDD VSS) capacitor c=3.62135e-17
C56 (\9\:n20 VSS) capacitor c=6.3773e-17
C57 (\8\:VDD VSS) capacitor c=1.41398e-17
C58 (\9\:mout VSS) capacitor c=6.09022e-17
C59 (\8\:n30 VSS) capacitor c=6.12715e-17
C60 (\10\:VDD VSS) capacitor c=1.49885e-17
C61 (\16\:qbint VSS) capacitor c=6.60424e-17
C62 (\15\:CKb VSS) capacitor c=1.46037e-16
C63 (\12\:VDD VSS) capacitor c=1.2322e-17
C64 (\1\:Q VSS) capacitor c=6.97323e-17
C65 (\5\:qint VSS) capacitor c=2.37998e-17
C66 (\15\:VDD VSS) capacitor c=1.96133e-17
C67 (\1\:QN VSS) capacitor c=3.58613e-17
C68 (\3\:VDD VSS) capacitor c=6.41271e-17
C69 (\8\:CKbb VSS) capacitor c=1.28346e-16
C70 (\5\:n20 VSS) capacitor c=8.67881e-17
C71 (\7\:mout VSS) capacitor c=4.48265e-17
C72 (\4\:n30 VSS) capacitor c=5.74075e-17
C73 (\13\:qbint VSS) capacitor c=7.39829e-17
C74 (\17\:CKb VSS) capacitor c=8.40801e-17
C75 (\3\:Q VSS) capacitor c=2.50746e-17
C76 (\9\:qint VSS) capacitor c=2.21292e-17
C77 (\3\:QN VSS) capacitor c=2.63069e-17
C78 (\2\:qint VSS) capacitor c=7.12383e-18
C79 (\2\:qbint VSS) capacitor c=4.03e-17
C80 (\3\:qbint VSS) capacitor c=3.27443e-17
C81 (\9\:qbint VSS) capacitor c=3.12381e-17
C82 (\2\:n20 VSS) capacitor c=3.31176e-17
C83 (\2\:mout VSS) capacitor c=4.12411e-17
C84 (\7\:qint VSS) capacitor c=2.28364e-17
C85 (\8\:qint VSS) capacitor c=1.98953e-17
C86 (\4\:CK VSS) capacitor c=7.3454e-17
C87 (\12\:qbint VSS) capacitor c=1.33302e-16
C88 (\15\:qbint VSS) capacitor c=6.08538e-17
C89 (\18\:qbint VSS) capacitor c=5.79106e-17
C90 (\6\:n30 VSS) capacitor c=7.1627e-17
C91 (\7\:n30 VSS) capacitor c=4.9543e-17
C92 (\5\:mout VSS) capacitor c=3.03714e-17
C93 (\6\:mout VSS) capacitor c=5.23718e-17
C94 (\7\:n20 VSS) capacitor c=5.73044e-17
C95 (\8\:n20 VSS) capacitor c=4.07e-17
C96 (\4\:D VSS) capacitor c=2.34028e-17
C97 (\11\:CKb VSS) capacitor c=6.47786e-17
C98 (\12\:CKb VSS) capacitor c=7.28769e-17
C99 (\13\:CKb VSS) capacitor c=1.02218e-16
C100 (\14\:CKb VSS) capacitor c=1.74037e-16
C101 (\19\:CKb VSS) capacitor c=4.05011e-17
C102 (\20\:CKb VSS) capacitor c=5.03118e-17
C103 (\10\:CKbb VSS) capacitor c=1.50485e-16
C104 (\11\:CKbb VSS) capacitor c=1.03566e-16
C105 (\12\:CKbb VSS) capacitor c=5.96848e-17
C106 (\15\:CKbb VSS) capacitor c=2.40635e-17
C107 (\5\:VDD VSS) capacitor c=2.96932e-17
C108 (\6\:VDD VSS) capacitor c=3.31046e-17
C109 (\14\:VDD VSS) capacitor c=1.18323e-17
Rk22 (\4\:D D) resistor r=0.03661 c=0
Rk2 (\4\:QN QN) resistor r=0.07346 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3051 c=0
Rk6 (\2\:Q Q) resistor r=0.3648 c=0
Rk7 (Q \4\:Q) resistor r=0.04326 c=0
Rk35 (\2\:VDD \4\:VDD) resistor r=0.4886 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.2344 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.4889 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.3247 c=0
Rk39 (\5\:VDD \9\:VDD) resistor r=0.04327 c=0
Rk40 (\6\:VDD \11\:VDD) resistor r=0.04327 c=0
Rk41 (\7\:VDD \13\:VDD) resistor r=0.1196 c=0
Rk44 (\14\:VDD VDD) resistor r=0.195 c=0
Rk42 (\7\:VDD \14\:VDD) resistor r=0.3563 c=0
Rk43 (\14\:VDD \16\:VDD) resistor r=0.223 c=0
Rk8 (CK \4\:CK) resistor r=0.1611 c=0
Rk45 (\2\:VSS \4\:VSS) resistor r=0.4471 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.1928 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.5209 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.3381 c=0
Rk49 (\7\:VSS \8\:VSS) resistor r=0.05243 c=0
Rk51 (\9\:VSS VSS) resistor r=0.195 c=0
Rk50 (\8\:VSS \9\:VSS) resistor r=0.3029 c=0
Rk52 (\5\:VSS \11\:VSS) resistor r=0.1021 c=0
Rk53 (\6\:VSS \13\:VSS) resistor r=0.3552 c=0
Rk54 (\8\:VSS \15\:VSS) resistor r=0.292 c=0
Rk55 (\9\:VSS \17\:VSS) resistor r=0.07346 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1175 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1191 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1055 c=0
Rk9 (\12\:qbint \14\:qbint) resistor r=0.7584 c=0
Rk10 (\14\:qbint \15\:qbint) resistor r=0.2002 c=0
Rk11 (\15\:qbint \17\:qbint) resistor r=0.3184 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.2298 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2903 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=0.1037 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=0.9093 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=0.8361 c=0
Rk27 (\16\:CKb \18\:CKb) resistor r=0.3728 c=0
Rk28 (\13\:CKb \19\:CKb) resistor r=0.09725 c=0
Rk29 (\14\:CKb \20\:CKb) resistor r=0.2089 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.3928 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2191 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.2438 c=0
Rk16 (\5\:mout \6\:mout) resistor r=0.1078 c=0
Rk17 (\6\:mout \8\:mout) resistor r=0.1663 c=0
Rk18 (\6\:mout \10\:mout) resistor r=0.3304 c=0
Rk30 (\9\:CKbb \10\:CKbb) resistor r=0.6479 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.817 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=0.2641 c=0
Rk33 (\9\:CKbb \14\:CKbb) resistor r=0.4353 c=0
Rk34 (\11\:CKbb \15\:CKbb) resistor r=0.03523 c=0
Rk19 (\6\:n20 \7\:n20) resistor r=0.4354 c=0
Rk20 (\7\:n20 \8\:n20) resistor r=0.1231 c=0
Rk21 (\7\:n20 \10\:n20) resistor r=0.2779 c=0
Rl31 (\1\:D \2\:D) resistor r=42.2849 c=0
Rl32 (\2\:D \3\:D) resistor r=126.284 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl4 (qbint \2\:qbint) resistor r=74.7185 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=40.1031 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=6.4781 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=153.345 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=120.868 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=47.791 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=110.713 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=33.7903 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=52.0674 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=193.029 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=50.7948 c=0
Rl12 (n30 \2\:n30) resistor r=101.923 c=0
Rl26 (\2\:mout \4\:mout) resistor r=114.125 c=0
Rl24 (mout \2\:mout) resistor r=73.3853 c=0
Rl25 (\2\:mout \3\:mout) resistor r=15.3298 c=0
Rl28 (\5\:CKbb \6\:CKbb) resistor r=197.643 c=0
Rl29 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=41.0764 c=0
Rl17 (CKbb \2\:CKbb) resistor r=61.5157 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=51.6372 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=117.022 c=0
Rl21 (n20 \2\:n20) resistor r=11.5001 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz10 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz11 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\7\:mout \8\:mout) resistor r=75 c=0
Rz9 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry16 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\9\:mout \10\:mout) resistor r=62 c=0
Ry9 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry7 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\6\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \18\:qbint) resistor r=45 c=0
Rx9 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx13 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx14 (CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (n20 \8\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q \5\:qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.64e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\17\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=2.682e-14 ps=9.8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint n30 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn50 (n35 \11\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=1.667e-14 ps=6.2e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.965e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn51 (\4\:n30 \3\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=4.132e-14 ps=5.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.805e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn40 (\4\:n30 \3\:CKbb \7\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=4.132e-14 ps=6.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.475e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn30 (\7\:mout \3\:n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.718e-14 ad=2.61e-14 ps=1.77e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.25e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn35 (n25 mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.718e-14 ad=1.595e-14 ps=1.77e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=8.7e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn36 (\5\:n20 \6\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=7.15e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.1e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=8.7e-15 ps=1e-06 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.91e-06 sb=4.05e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn21 (\8\:CKbb \8\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=2.03e-14 ps=1e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mp56 (\5\:qint \7\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp20 (\15\:CKb \1\:CK \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.555e-14 ad=3.977e-14 ps=1.92e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.85e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\16\:qbint \3\:n30 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (n36 \8\:qbint \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.827e-14 ps=1.52e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp51 (\8\:n30 \2\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=4.515e-14 ps=6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.935e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=4.515e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.68e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp30 (\9\:mout \4\:n20 \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=6.127e-14 ps=1.52e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.35e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp35 (n26 \4\:mout \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.397e-14 ps=1.52e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.085e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp36 (\9\:n20 \5\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.397e-14 ad=4.622e-14 ps=5.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=9.75e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.622e-14 ad=4.622e-14 ps=8.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=7.15e-07 sd=160n sca=12.3306 \
        scb=0.010847 scc=0.000332116 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.622e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.55e-07 sd=160n sca=13.4144 scb=0.0116069 \
        scc=0.000333202 m=(1)
mp21 (\13\:CKbb \10\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.5e-07 sd=160n sca=15.8535 scb=0.0153154 \
        scc=0.000377744 m=(1)
ends DFFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:02 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFX2
// View name: extracted

simulator lang=spectre

subckt DFFX2 CK D Q QN VDD VSS
mp21 (\13\:CKbb CKb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.3372 scb=0.0320686 \
        scc=0.00199675 m=(1)
mp25 (n22 \1\:D \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=1.29e-14 ps=1.32e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.94e-06 sd=160n sca=16.3177 \
        scb=0.0157291 scc=0.00060458 m=(1)
mp26 (\7\:n20 CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.835e-06 sd=160n sca=15.2202 \
        scb=0.0141545 scc=0.000592469 m=(1)
mp36 (\7\:n20 \4\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.63e-06 sd=160n sca=14.1441 \
        scb=0.0132095 scc=0.000590428 m=(1)
mp35 (n26 \3\:mout \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.05e-14 ad=2.902e-14 ps=1.59e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.45e-06 sd=160n sca=13.6837 \
        scb=0.0130542 scc=0.000590384 m=(1)
mp30 (\8\:mout n20 \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.05e-14 ad=8.062e-14 ps=1.59e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=1.185e-06 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp40 (\4\:n30 \7\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=4.515e-14 ps=1.18e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58e-06 sb=7.65e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp51 (\4\:n30 \7\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=5.1e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp50 (n36 \4\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94e-06 sb=4.05e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp20 (\9\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.9e-14 ad=3.655e-14 ps=1.38e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.485e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\7\:qint \12\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1.4e-07 sd=160n sca=47.1852 \
        scb=0.0292558 scc=0.00588561 m=(1)
C1 (CK VSS) capacitor c=4.54277e-17
C2 (D VSS) capacitor c=4.67477e-17
C3 (Q VSS) capacitor c=3.71826e-17
C4 (VDD VSS) capacitor c=2.6362e-16
C5 (QN VSS) capacitor c=3.34674e-17
C6 (CKb VSS) capacitor c=4.89776e-17
C7 (CKbb VSS) capacitor c=6.86649e-17
C8 (n20 VSS) capacitor c=4.45398e-17
C9 (mout VSS) capacitor c=7.38836e-17
C10 (n30 VSS) capacitor c=5.61324e-17
C11 (qbint VSS) capacitor c=2.84337e-17
C12 (qint VSS) capacitor c=1.58936e-16
C13 (n26 VSS) capacitor c=3.60107e-19
C14 (n36 VSS) capacitor c=1.11793e-18
C15 (\12\:qbint VSS) capacitor c=5.82287e-17
C16 (\5\:qbint VSS) capacitor c=4.46585e-16
C17 (\1\:CK VSS) capacitor c=2.39054e-17
C18 (\4\:qbint VSS) capacitor c=5.91845e-17
C19 (\7\:CKbb VSS) capacitor c=5.64563e-17
C20 (\7\:CKb VSS) capacitor c=4.68617e-17
C21 (\3\:mout VSS) capacitor c=4.77953e-17
C22 (\4\:CKb VSS) capacitor c=6.5606e-17
C23 (\1\:D VSS) capacitor c=5.41182e-17
C24 (\13\:qbint VSS) capacitor c=2.47188e-17
C25 (\3\:CK VSS) capacitor c=3.04619e-17
C26 (\3\:n30 VSS) capacitor c=3.15079e-17
C27 (\3\:qbint VSS) capacitor c=4.1629e-17
C28 (\6\:CKb VSS) capacitor c=7.55252e-17
C29 (\5\:CKbb VSS) capacitor c=3.50853e-17
C30 (\4\:n20 VSS) capacitor c=3.43246e-17
C31 (\3\:CKbb VSS) capacitor c=6.1774e-17
C32 (\3\:CKb VSS) capacitor c=1.13811e-16
C33 (\3\:D VSS) capacitor c=7.18738e-17
C34 (\2\:CKb VSS) capacitor c=6.08575e-17
C35 (\14\:qbint VSS) capacitor c=1.9913e-17
C36 (\2\:CK VSS) capacitor c=2.32997e-17
C37 (\2\:n30 VSS) capacitor c=3.12842e-17
C38 (\8\:CKbb VSS) capacitor c=5.95526e-17
C39 (\8\:CKb VSS) capacitor c=2.11285e-17
C40 (\6\:CKbb VSS) capacitor c=3.73295e-17
C41 (\3\:n20 VSS) capacitor c=2.69575e-17
C42 (\2\:mout VSS) capacitor c=4.96781e-17
C43 (\4\:CKbb VSS) capacitor c=2.77645e-17
C44 (\5\:CKb VSS) capacitor c=2.97319e-17
C45 (\2\:CKbb VSS) capacitor c=5.67094e-17
C46 (\2\:D VSS) capacitor c=5.32839e-17
C47 (\7\:qint VSS) capacitor c=1.53191e-17
C48 (\1\:VDD VSS) capacitor c=2.19065e-16
C49 (\1\:QN VSS) capacitor c=7.02553e-17
C50 (\3\:Q VSS) capacitor c=9.85202e-17
C51 (\9\:CKb VSS) capacitor c=1.29649e-16
C52 (\24\:qbint VSS) capacitor c=2.57335e-17
C53 (\15\:VDD VSS) capacitor c=2.48513e-17
C54 (\4\:n30 VSS) capacitor c=5.7071e-17
C55 (\8\:mout VSS) capacitor c=2.56755e-17
C56 (\17\:VDD VSS) capacitor c=2.47627e-17
C57 (\7\:n20 VSS) capacitor c=5.05353e-17
C58 (\19\:VDD VSS) capacitor c=2.7511e-17
C59 (\13\:CKbb VSS) capacitor c=3.13432e-17
C60 (\3\:VDD VSS) capacitor c=5.47434e-17
C61 (\11\:qint VSS) capacitor c=3.30773e-17
C62 (\4\:QN VSS) capacitor c=3.24977e-17
C63 (\1\:Q VSS) capacitor c=4.27058e-17
C64 (\13\:CKb VSS) capacitor c=7.07412e-17
C65 (\18\:qbint VSS) capacitor c=8.88957e-17
C66 (\7\:n30 VSS) capacitor c=5.815e-17
C67 (\4\:mout VSS) capacitor c=5.83417e-17
C68 (\9\:n20 VSS) capacitor c=3.08619e-17
C69 (\18\:CKbb VSS) capacitor c=1.72153e-17
C70 (\2\:n20 VSS) capacitor c=2.5097e-17
C71 (\2\:qbint VSS) capacitor c=2.95806e-17
C72 (\4\:D VSS) capacitor c=5.70554e-17
C73 (\5\:n20 VSS) capacitor c=4.5273e-17
C74 (\6\:n20 VSS) capacitor c=5.53271e-17
C75 (\6\:mout VSS) capacitor c=5.03318e-17
C76 (\7\:mout VSS) capacitor c=4.66426e-17
C77 (\9\:CKbb VSS) capacitor c=1.75361e-17
C78 (\10\:CKbb VSS) capacitor c=1.05541e-16
C79 (\11\:CKbb VSS) capacitor c=6.01192e-17
C80 (\12\:CKbb VSS) capacitor c=4.35398e-17
C81 (\15\:CKbb VSS) capacitor c=1.16592e-16
C82 (\16\:CKbb VSS) capacitor c=5.47997e-17
C83 (\17\:CKbb VSS) capacitor c=3.03904e-17
C84 (\6\:n30 VSS) capacitor c=6.23998e-17
C85 (\9\:n30 VSS) capacitor c=6.34561e-17
C86 (\11\:CKb VSS) capacitor c=1.5422e-16
C87 (\12\:CKb VSS) capacitor c=7.40395e-17
C88 (\4\:CK VSS) capacitor c=6.61869e-17
C89 (\3\:QN VSS) capacitor c=2.81532e-17
C90 (\20\:qbint VSS) capacitor c=1.49268e-16
C91 (\22\:qbint VSS) capacitor c=5.82474e-17
C92 (\23\:qbint VSS) capacitor c=4.20114e-17
C93 (\9\:qint VSS) capacitor c=4.86701e-17
C94 (\10\:qint VSS) capacitor c=4.23797e-17
C95 (\7\:VDD VSS) capacitor c=4.4048e-17
C96 (\9\:VDD VSS) capacitor c=2.03654e-17
C97 (\10\:VDD VSS) capacitor c=1.53442e-17
Rk22 (CK \4\:CK) resistor r=0.07473 c=0
Rk1 (\4\:D D) resistor r=0.1894 c=0
Rk23 (Q \2\:Q) resistor r=0.04484 c=0
Rk24 (Q \4\:Q) resistor r=0.2571 c=0
Rk53 (\1\:VDD \7\:VDD) resistor r=0.5001 c=0
Rk54 (\7\:VDD \8\:VDD) resistor r=0.4527 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.06987 c=0
Rk57 (\10\:VDD VDD) resistor r=0.1172 c=0
Rk56 (\9\:VDD \10\:VDD) resistor r=0.3625 c=0
Rk60 (\7\:VDD \16\:VDD) resistor r=0.1017 c=0
Rk61 (\9\:VDD \18\:VDD) resistor r=0.1017 c=0
Rk62 (\10\:VDD \20\:VDD) resistor r=0.1624 c=0
Rk26 (\3\:QN QN) resistor r=0.08956 c=0
Rk25 (\2\:QN \3\:QN) resistor r=0.307 c=0
Rk27 (\3\:QN \5\:QN) resistor r=0.07512 c=0
Rk41 (\1\:VSS \6\:VSS) resistor r=0.4541 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.4828 c=0
Rk44 (\8\:VSS VSS) resistor r=0.1047 c=0
Rk43 (\7\:VSS \8\:VSS) resistor r=0.4463 c=0
Rk47 (\6\:VSS \14\:VSS) resistor r=0.3319 c=0
Rk48 (\7\:VSS \16\:VSS) resistor r=0.07132 c=0
Rk49 (\8\:VSS \18\:VSS) resistor r=0.3635 c=0
Rk19 (\10\:CKb \11\:CKb) resistor r=0.9655 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.5379 c=0
Rk21 (\10\:CKb \14\:CKb) resistor r=0.3446 c=0
Rk8 (\9\:CKbb \10\:CKbb) resistor r=0.0378 c=0
Rk9 (\10\:CKbb \11\:CKbb) resistor r=0.4739 c=0
Rk10 (\11\:CKbb \12\:CKbb) resistor r=0.3013 c=0
Rk11 (\12\:CKbb \14\:CKbb) resistor r=0.2545 c=0
Rk12 (\10\:CKbb \15\:CKbb) resistor r=0.7637 c=0
Rk13 (\15\:CKbb \16\:CKbb) resistor r=0.239 c=0
Rk14 (\11\:CKbb \17\:CKbb) resistor r=0.09366 c=0
Rk15 (\12\:CKbb \19\:CKbb) resistor r=0.121 c=0
Rk2 (\5\:n20 \6\:n20) resistor r=0.2396 c=0
Rk3 (\6\:n20 \8\:n20) resistor r=0.3054 c=0
Rk4 (\6\:n20 \10\:n20) resistor r=0.1335 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.2787 c=0
Rk6 (\6\:mout \7\:mout) resistor r=0.2396 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.112 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.3462 c=0
Rk17 (\6\:n30 \8\:n30) resistor r=0.2937 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.2642 c=0
Rk30 (\5\:qbint \19\:qbint) resistor r=0.6139 c=0
Rk31 (\5\:qbint \20\:qbint) resistor r=0.9605 c=0
Rk33 (\19\:qbint \22\:qbint) resistor r=0.4051 c=0
Rk34 (\22\:qbint \23\:qbint) resistor r=0.2148 c=0
Rk35 (\22\:qbint \25\:qbint) resistor r=0.08579 c=0
Rk36 (\8\:qint \9\:qint) resistor r=0.09136 c=0
Rk37 (\9\:qint \10\:qint) resistor r=0.1964 c=0
Rk38 (\9\:qint \12\:qint) resistor r=0.2833 c=0
Rl23 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl24 (\2\:CK \3\:CK) resistor r=41.0764 c=0
Rl1 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl2 (\2\:D \3\:D) resistor r=99.2328 c=0
Rl15 (\6\:CKb \7\:CKb) resistor r=184.181 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=208.814 c=0
Rl4 (CKb \2\:CKb) resistor r=150.37 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=278.412 c=0
Rl16 (\7\:CKb \8\:CKb) resistor r=24.2328 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=53.0848 c=0
Rl14 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl8 (\3\:CKbb \4\:CKbb) resistor r=68.4636 c=0
Rl3 (CKbb \2\:CKbb) resistor r=49.2328 c=0
Rl11 (n20 \2\:n20) resistor r=104.649 c=0
Rl13 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=1.8551 c=0
Rl10 (\2\:mout \3\:mout) resistor r=25.8439 c=0
Rl9 (mout \2\:mout) resistor r=101.923 c=0
Rl21 (n30 \2\:n30) resistor r=87.2302 c=0
Rl22 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl35 (\13\:qbint \12\:qbint) resistor r=134.181 c=0
Rl36 (\14\:qbint \13\:qbint) resistor r=29.5379 c=0
Rl20 (\2\:qbint \4\:qbint) resistor r=43.9449 c=0
Rl19 (\2\:qbint \3\:qbint) resistor r=99.7141 c=0
Rl18 (\2\:qbint qbint) resistor r=11.5001 c=0
Rz6 (\2\:Q \1\:Q) resistor r=75 c=0
Rz16 (\1\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\5\:QN \4\:QN) resistor r=75 c=0
Rz13 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz3 (\18\:CKbb \19\:CKbb) resistor r=75 c=0
Rz1 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz4 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz8 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz9 (\12\:qint \11\:qint) resistor r=75 c=0
Ry6 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry15 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry16 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry7 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry11 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry5 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry3 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\8\:mout \9\:mout) resistor r=62 c=0
Ry4 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry8 (\25\:qbint \24\:qbint) resistor r=62 c=0
Ry9 (\8\:qint \7\:qint) resistor r=62 c=0
Rx11 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\8\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\5\:CKb \12\:CKb) resistor r=45 c=0
Rx4 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx2 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx3 (\2\:mout \7\:mout) resistor r=45 c=0
Rx8 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx13 (\20\:qbint \14\:qbint) resistor r=45 c=0
Rx15 (\23\:qbint qbint) resistor r=45 c=0
Rx16 (\10\:qint qint) resistor r=45 c=0
mn21 (\18\:CKbb \2\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.118e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \3\:D \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=8.7e-15 ps=7.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.94e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\9\:n20 \3\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.835e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\9\:n20 \3\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=4.132e-14 ps=4.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.505e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n25 mout \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.16e-14 ps=1.6e-06 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.38e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\4\:mout \4\:n20 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.915e-14 ps=1.6e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.185e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\7\:n30 \5\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.755e-14 ps=8.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=8.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\7\:n30 \6\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.755e-14 ps=6.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=2.682e-14 ps=8.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.935e-06 sb=4.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\13\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.89e-14 ad=2.465e-14 ps=1.88e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.715e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn56 (\11\:qint \13\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.263e-14 ps=1.09e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=2.25e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn45 (\18\:qbint \3\:n30 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=2.87e-14 ps=8.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45561e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\1\:Q \5\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.575e-14 ad=4.68e-14 ps=1.8e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.31442e-07 sb=1.21519e-06 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mn57 (\4\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.875e-14 ad=5.46e-14 ps=1.405e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91442e-07 sb=6.55192e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mp45 (\24\:qbint n30 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=4.34e-14 ps=1.64e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43355e-06 sb=1.4e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp55 (\3\:Q \5\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=7.02e-14 ps=1.37e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46731e-07 sb=1.03455e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57_1__rcx (\1\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.922e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.06731e-07 sb=4.74551e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
ends DFFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:03 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFX4
// View name: extracted

simulator lang=spectre

subckt DFFX4 CK D Q QN VDD VSS
mp20 (\21\:CKb \1\:CK \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=35.6444 \
        scb=0.0398802 scc=0.00365724 m=(1)
mp21 (\13\:CKbb CKb \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.8469 scb=0.00772406 \
        scc=8.06202e-05 m=(1)
mp25 (n22 \1\:D \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.472e-14 ps=7.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.2589 \
        scb=0.00748244 scc=8.05157e-05 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.73e-14 ps=6.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp36 (\5\:n20 \6\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.73e-14 ps=6.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp35 (n26 mout \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.472e-14 ps=1.32e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp30 (\7\:mout n20 \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=6.558e-14 ps=1.32e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\12\:n30 \8\:CKb \7\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.945e-14 ps=1.04e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\12\:n30 \4\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.945e-14 ps=5.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp50 (n36 qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=1.29e-14 ps=1e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
C1 (D VSS) capacitor c=3.48266e-17
C2 (Q VSS) capacitor c=3.6664e-17
C3 (QN VSS) capacitor c=1.78845e-17
C4 (CK VSS) capacitor c=9.58303e-17
C5 (VDD VSS) capacitor c=3.17892e-16
C6 (CKb VSS) capacitor c=5.69226e-17
C7 (CKbb VSS) capacitor c=8.16834e-17
C8 (n20 VSS) capacitor c=3.42846e-17
C9 (n25 VSS) capacitor c=1.45671e-19
C10 (mout VSS) capacitor c=8.23341e-17
C11 (n30 VSS) capacitor c=2.11642e-16
C12 (qbint VSS) capacitor c=6.77096e-17
C13 (qint VSS) capacitor c=2.87511e-16
C14 (n22 VSS) capacitor c=2.69352e-19
C15 (n26 VSS) capacitor c=2.60756e-18
C16 (n36 VSS) capacitor c=4.50931e-21
C17 (\22\:qbint VSS) capacitor c=5.0465e-17
C18 (\5\:qbint VSS) capacitor c=2.69978e-16
C19 (\4\:CKbb VSS) capacitor c=4.81861e-17
C20 (\8\:CKb VSS) capacitor c=2.94243e-17
C21 (\6\:CKb VSS) capacitor c=5.02936e-17
C22 (\3\:CKbb VSS) capacitor c=3.50587e-17
C23 (\1\:D VSS) capacitor c=7.18806e-17
C24 (\1\:CK VSS) capacitor c=2.89244e-17
C25 (\20\:qbint VSS) capacitor c=3.21089e-17
C26 (\3\:qbint VSS) capacitor c=7.29841e-17
C27 (\10\:CKb VSS) capacitor c=7.32451e-17
C28 (\6\:CKbb VSS) capacitor c=6.02006e-17
C29 (\3\:n20 VSS) capacitor c=5.3617e-17
C30 (\3\:mout VSS) capacitor c=5.14167e-17
C31 (\5\:CKb VSS) capacitor c=5.21019e-17
C32 (\3\:D VSS) capacitor c=4.63968e-17
C33 (\2\:CKb VSS) capacitor c=4.82382e-17
C34 (\3\:CK VSS) capacitor c=2.30212e-17
C35 (\21\:qbint VSS) capacitor c=4.26311e-17
C36 (\4\:qbint VSS) capacitor c=2.20754e-17
C37 (\5\:CKbb VSS) capacitor c=7.22504e-17
C38 (\11\:CKb VSS) capacitor c=2.95592e-17
C39 (\9\:CKb VSS) capacitor c=3.63327e-17
C40 (\2\:n20 VSS) capacitor c=5.52422e-17
C41 (\2\:mout VSS) capacitor c=6.75528e-17
C42 (\7\:CKb VSS) capacitor c=3.90864e-17
C43 (\4\:CKb VSS) capacitor c=2.15682e-17
C44 (\2\:CKbb VSS) capacitor c=6.27814e-17
C45 (\2\:D VSS) capacitor c=5.05125e-17
C46 (\3\:CKb VSS) capacitor c=2.22178e-17
C47 (\2\:CK VSS) capacitor c=2.64482e-17
C48 (\19\:qint VSS) capacitor c=3.93485e-17
C49 (\1\:Q VSS) capacitor c=1.78415e-16
C50 (\31\:qbint VSS) capacitor c=5.94928e-17
C51 (\12\:n30 VSS) capacitor c=8.01197e-17
C52 (\7\:mout VSS) capacitor c=8.03439e-17
C53 (\28\:VDD VSS) capacitor c=2.68694e-17
C54 (\5\:n20 VSS) capacitor c=1.17514e-16
C55 (\30\:VDD VSS) capacitor c=3.55176e-17
C56 (\13\:CKbb VSS) capacitor c=1.77288e-17
C57 (\21\:CKb VSS) capacitor c=6.02436e-17
C58 (\13\:VDD VSS) capacitor c=3.00898e-17
C59 (\1\:VDD VSS) capacitor c=5.64578e-17
C60 (\15\:qint VSS) capacitor c=4.89053e-17
C61 (\1\:QN VSS) capacitor c=7.34137e-17
C62 (\28\:qbint VSS) capacitor c=1.98498e-17
C63 (\10\:n30 VSS) capacitor c=3.17678e-17
C64 (\4\:mout VSS) capacitor c=3.66209e-17
C65 (\7\:n20 VSS) capacitor c=7.94743e-17
C66 (\10\:CKbb VSS) capacitor c=9.72892e-17
C67 (\17\:CKb VSS) capacitor c=9.56238e-17
C68 (\2\:qbint VSS) capacitor c=5.55739e-17
C69 (\4\:D VSS) capacitor c=5.19669e-17
C70 (\4\:n20 VSS) capacitor c=6.64545e-17
C71 (\6\:mout VSS) capacitor c=6.83922e-17
C72 (\9\:mout VSS) capacitor c=4.19983e-17
C73 (\12\:CKb VSS) capacitor c=9.45312e-17
C74 (\13\:CKb VSS) capacitor c=9.45085e-17
C75 (\14\:CKb VSS) capacitor c=8.74542e-17
C76 (\15\:CKb VSS) capacitor c=5.43095e-17
C77 (\16\:CKb VSS) capacitor c=7.63246e-17
C78 (\19\:CKb VSS) capacitor c=4.28577e-17
C79 (\20\:CKb VSS) capacitor c=9.43854e-17
C80 (\7\:CKbb VSS) capacitor c=1.91504e-16
C81 (\8\:CKbb VSS) capacitor c=1.86366e-16
C82 (\9\:CKbb VSS) capacitor c=5.34074e-17
C83 (\12\:CKbb VSS) capacitor c=2.4517e-17
C84 (\8\:n30 VSS) capacitor c=5.14137e-17
C85 (\9\:n30 VSS) capacitor c=5.69607e-17
C86 (\4\:Q VSS) capacitor c=9.97708e-17
C87 (\5\:QN VSS) capacitor c=1.7638e-16
C88 (\23\:qbint VSS) capacitor c=2.33815e-16
C89 (\24\:qbint VSS) capacitor c=2.09971e-16
C90 (\26\:qbint VSS) capacitor c=3.93037e-17
C91 (\27\:qbint VSS) capacitor c=4.12581e-17
C92 (\30\:qbint VSS) capacitor c=3.97896e-17
C93 (\17\:qint VSS) capacitor c=4.33346e-17
C94 (\18\:qint VSS) capacitor c=3.05313e-17
C95 (\3\:VDD VSS) capacitor c=5.3063e-16
C96 (\10\:VDD VSS) capacitor c=3.94915e-17
C97 (\12\:VDD VSS) capacitor c=2.00191e-17
Rk2 (D \4\:D) resistor r=0.06305 c=0
Rk25 (\1\:Q Q) resistor r=0.2391 c=0
Rk26 (Q \4\:Q) resistor r=0.1104 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.07253 c=0
Rk52 (\3\:VSS \10\:VSS) resistor r=0.4711 c=0
Rk53 (\10\:VSS \11\:VSS) resistor r=0.1754 c=0
Rk55 (\12\:VSS VSS) resistor r=0.4337 c=0
Rk54 (\11\:VSS \12\:VSS) resistor r=0.1177 c=0
Rk56 (VSS \14\:VSS) resistor r=0.2596 c=0
Rk63 (\10\:VSS \28\:VSS) resistor r=0.07393 c=0
Rk64 (\12\:VSS \30\:VSS) resistor r=0.07393 c=0
Rk31 (\1\:QN QN) resistor r=0.1689 c=0
Rk32 (QN \5\:QN) resistor r=0.1167 c=0
Rk1 (CK \4\:CK) resistor r=0.02238 c=0
Rk65 (\2\:VDD \3\:VDD) resistor r=0.1854 c=0
Rk72 (\3\:VDD \10\:VDD) resistor r=0.4977 c=0
Rk73 (\10\:VDD \11\:VDD) resistor r=0.2271 c=0
Rk75 (\12\:VDD VDD) resistor r=0.3685 c=0
Rk74 (\11\:VDD \12\:VDD) resistor r=0.1829 c=0
Rk76 (VDD \14\:VDD) resistor r=0.3799 c=0
Rk84 (\10\:VDD \29\:VDD) resistor r=0.04331 c=0
Rk85 (\12\:VDD \31\:VDD) resistor r=0.2276 c=0
Rk8 (\12\:CKb \13\:CKb) resistor r=0.548 c=0
Rk9 (\13\:CKb \14\:CKb) resistor r=0.4552 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.1638 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.3716 c=0
Rk12 (\16\:CKb \18\:CKb) resistor r=0.3725 c=0
Rk13 (\13\:CKb \19\:CKb) resistor r=0.2036 c=0
Rk14 (\14\:CKb \20\:CKb) resistor r=0.5096 c=0
Rk15 (\18\:CKb \22\:CKb) resistor r=0.4523 c=0
Rk16 (\7\:CKbb \8\:CKbb) resistor r=1.4506 c=0
Rk17 (\8\:CKbb \9\:CKbb) resistor r=0.2802 c=0
Rk18 (\9\:CKbb \11\:CKbb) resistor r=0.3846 c=0
Rk19 (\8\:CKbb \12\:CKbb) resistor r=0.06427 c=0
Rk20 (\9\:CKbb \14\:CKbb) resistor r=0.05841 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.4128 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.4737 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.1682 c=0
Rk6 (\6\:mout \8\:mout) resistor r=0.432 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.1869 c=0
Rk21 (\8\:n30 \9\:n30) resistor r=0.275 c=0
Rk22 (\9\:n30 \11\:n30) resistor r=0.0958 c=0
Rk23 (\9\:n30 \13\:n30) resistor r=0.3467 c=0
Rk35 (\23\:qbint \24\:qbint) resistor r=1.8995 c=0
Rk36 (\24\:qbint \25\:qbint) resistor r=0.2576 c=0
Rk37 (\25\:qbint \26\:qbint) resistor r=0.04668 c=0
Rk38 (\26\:qbint \27\:qbint) resistor r=0.1992 c=0
Rk39 (\24\:qbint \29\:qbint) resistor r=0.08669 c=0
Rk40 (\25\:qbint \30\:qbint) resistor r=0.1728 c=0
Rk41 (\26\:qbint \32\:qbint) resistor r=0.2428 c=0
Rk42 (\16\:qint \17\:qint) resistor r=0.3721 c=0
Rk43 (\17\:qint \18\:qint) resistor r=0.225 c=0
Rk44 (\17\:qint \20\:qint) resistor r=0.1493 c=0
Rl5 (\1\:D \2\:D) resistor r=148.769 c=0
Rl6 (\2\:D \3\:D) resistor r=29.5379 c=0
Rl1 (\1\:CK \2\:CK) resistor r=118.464 c=0
Rl2 (\2\:CK \3\:CK) resistor r=37.6944 c=0
Rl3 (CKb \2\:CKb) resistor r=203.846 c=0
Rl16 (\10\:CKb \11\:CKb) resistor r=81.461 c=0
Rl15 (\8\:CKb \9\:CKb) resistor r=57.6695 c=0
Rl10 (\6\:CKb \7\:CKb) resistor r=42.9995 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=74.2923 c=0
Rl4 (\2\:CKb \3\:CKb) resistor r=94.9225 c=0
Rl17 (\4\:CKbb \5\:CKbb) resistor r=35.6627 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=199.169 c=0
Rl9 (\2\:CKbb \3\:CKbb) resistor r=29.5379 c=0
Rl8 (CKbb \2\:CKbb) resistor r=209.873 c=0
Rl13 (n20 \2\:n20) resistor r=53.4003 c=0
Rl14 (\2\:n20 \3\:n20) resistor r=141.541 c=0
Rl11 (mout \2\:mout) resistor r=141.541 c=0
Rl12 (\2\:mout \3\:mout) resistor r=66.8618 c=0
Rl56 (\21\:qbint \22\:qbint) resistor r=74.2328 c=0
Rl55 (\21\:qbint \20\:qbint) resistor r=83.2317 c=0
Rl19 (\2\:qbint qbint) resistor r=82.1542 c=0
Rl20 (\2\:qbint \3\:qbint) resistor r=116.817 c=0
Rl21 (\2\:qbint \4\:qbint) resistor r=4.5402 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz19 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz20 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz21 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz22 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz5 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz10 (\29\:qbint \28\:qbint) resistor r=75 c=0
Rz11 (\16\:qint \15\:qint) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry23 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry24 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry3 (\21\:CKb \22\:CKb) resistor r=62 c=0
Ry4 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\7\:mout \8\:mout) resistor r=62 c=0
Ry5 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry10 (\32\:qbint \31\:qbint) resistor r=31 c=0
Ry11 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx5 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx7 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx8 (\11\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\8\:n30 n30) resistor r=45 c=0
Rx13 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx14 (\27\:qbint \4\:qbint) resistor r=45 c=0
Rx15 (\30\:qbint \5\:qbint) resistor r=45 c=0
Rx16 (\18\:qint qint) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn21 (\10\:CKbb \2\:CKb \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.415e-14 ad=2.9e-14 ps=1.8e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \3\:D \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=1.667e-14 ps=1.8e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\7\:n20 \5\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.32e-14 ps=5.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\7\:n20 CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (n25 \3\:mout \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.918e-14 ad=1.015e-14 ps=1.67e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\4\:mout \3\:n20 \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.918e-14 ad=5.147e-14 ps=1.67e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\10\:n30 \6\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\10\:n30 \10\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45_1__rcx (\28\:qbint n30 \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.388e-14 ad=3.28e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4439e-06 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn56 (\15\:qint \20\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.54e-14 ad=3.64e-14 ps=1.1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn55_1__rcx (\4\:Q \5\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.491e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.055e-14 ad=4.355e-14 ps=1.475e-06 pd=8.55e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mp45 (\31\:qbint n30 \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2e-06 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(2)
mp56 (\19\:qint \22\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=15.1531 \
        scb=0.0133339 scc=0.000649799 m=(1)
mp57 (\5\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp55_1__rcx (\1\:Q \5\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.78e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
ends DFFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:04 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFXL
// View name: extracted

simulator lang=spectre

subckt DFFXL CK D Q QN VDD VSS
mp57 (\4\:QN qint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
mp56 (\4\:qint \6\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=46.9517 \
        scb=0.029008 scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.01e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\18\:CKb \1\:CK \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.01e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\15\:qbint n30 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp50 (n36 \7\:qbint \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.44e-14 ps=1.32e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\9\:n30 CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.88e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\9\:n30 CKb \7\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=4.515e-14 ps=1.03e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.625e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp30 (\7\:mout n20 \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=6.45e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.28e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp35 (n26 \4\:mout \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.58e-14 ps=1.32e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.015e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp36 (\4\:n20 \5\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=8.5e-07 sd=160n sca=10.3113 \
        scb=0.00749421 scc=8.05171e-05 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=6.45e-07 sd=160n sca=10.9525 \
        scb=0.00779426 scc=8.06839e-05 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.053e-14 ps=7.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=13.4702 scb=0.0111763 \
        scc=0.0001097 m=(1)
mp21 (\8\:CKbb \8\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=21.8638 scb=0.0242315 \
        scc=0.00109598 m=(1)
C1 (D VSS) capacitor c=1.34698e-16
C2 (QN VSS) capacitor c=2.03706e-17
C3 (Q VSS) capacitor c=2.71174e-17
C4 (VDD VSS) capacitor c=2.93624e-16
C5 (CK VSS) capacitor c=4.52271e-17
C6 (qint VSS) capacitor c=2.9782e-17
C7 (qbint VSS) capacitor c=2.28165e-17
C8 (CKb VSS) capacitor c=2.1751e-17
C9 (n30 VSS) capacitor c=4.76274e-17
C10 (n35 VSS) capacitor c=6.99755e-18
C11 (mout VSS) capacitor c=4.25177e-17
C12 (CKbb VSS) capacitor c=3.95676e-17
C13 (n20 VSS) capacitor c=4.87301e-17
C14 (n25 VSS) capacitor c=1.70374e-18
C15 (n21 VSS) capacitor c=1.28589e-18
C16 (n36 VSS) capacitor c=2.02629e-18
C17 (n26 VSS) capacitor c=1.81666e-18
C18 (n22 VSS) capacitor c=2.87857e-18
C19 (\8\:CKb VSS) capacitor c=4.755e-17
C20 (\1\:D VSS) capacitor c=4.06208e-17
C21 (\5\:CKbb VSS) capacitor c=7.90554e-17
C22 (\5\:CKb VSS) capacitor c=4.18102e-17
C23 (\4\:mout VSS) capacitor c=7.89853e-17
C24 (\7\:qbint VSS) capacitor c=8.0823e-17
C25 (\1\:CK VSS) capacitor c=2.7879e-17
C26 (\6\:qbint VSS) capacitor c=2.50634e-17
C27 (\11\:CKb VSS) capacitor c=3.838e-17
C28 (\3\:D VSS) capacitor c=9.05842e-17
C29 (\6\:CKb VSS) capacitor c=6.6981e-17
C30 (\6\:CKbb VSS) capacitor c=7.99667e-17
C31 (\3\:n20 VSS) capacitor c=5.03173e-17
C32 (\3\:CKbb VSS) capacitor c=3.90482e-17
C33 (\3\:CKb VSS) capacitor c=6.99326e-17
C34 (\10\:qbint VSS) capacitor c=2.60709e-17
C35 (\3\:n30 VSS) capacitor c=4.25598e-17
C36 (\3\:CK VSS) capacitor c=2.2785e-17
C37 (\5\:qbint VSS) capacitor c=1.68913e-17
C38 (\4\:qbint VSS) capacitor c=2.36864e-17
C39 (\3\:qint VSS) capacitor c=2.78761e-17
C40 (\10\:CKb VSS) capacitor c=3.03183e-17
C41 (\2\:D VSS) capacitor c=7.67685e-17
C42 (\7\:CKb VSS) capacitor c=5.66111e-17
C43 (\7\:CKbb VSS) capacitor c=3.13385e-17
C44 (\4\:CKb VSS) capacitor c=4.83799e-17
C45 (\3\:mout VSS) capacitor c=2.97858e-17
C46 (\2\:n20 VSS) capacitor c=5.2618e-17
C47 (\2\:CKb VSS) capacitor c=8.66721e-17
C48 (\4\:CKbb VSS) capacitor c=3.50379e-17
C49 (\2\:CKbb VSS) capacitor c=5.5001e-17
C50 (\9\:qbint VSS) capacitor c=3.05954e-17
C51 (\4\:n30 VSS) capacitor c=2.83454e-17
C52 (\2\:CK VSS) capacitor c=2.02014e-17
C53 (\2\:qbint VSS) capacitor c=3.1155e-17
C54 (\2\:qint VSS) capacitor c=2.43969e-17
C55 (\8\:CKbb VSS) capacitor c=6.4966e-17
C56 (\1\:VDD VSS) capacitor c=5.25136e-17
C57 (\4\:n20 VSS) capacitor c=7.69281e-17
C58 (\8\:VDD VSS) capacitor c=2.46184e-17
C59 (\7\:mout VSS) capacitor c=7.29146e-17
C60 (\9\:n30 VSS) capacitor c=7.64854e-17
C61 (\10\:VDD VSS) capacitor c=2.36568e-17
C62 (\15\:qbint VSS) capacitor c=6.22773e-17
C63 (\18\:CKb VSS) capacitor c=1.58646e-16
C64 (\12\:VDD VSS) capacitor c=5.34649e-17
C65 (\1\:Q VSS) capacitor c=2.32957e-17
C66 (\4\:qint VSS) capacitor c=3.54716e-17
C67 (\15\:VDD VSS) capacitor c=4.34684e-17
C68 (\4\:QN VSS) capacitor c=3.673e-17
C69 (\3\:VDD VSS) capacitor c=9.05041e-17
C70 (\14\:CKbb VSS) capacitor c=1.41139e-17
C71 (\7\:n20 VSS) capacitor c=8.10363e-17
C72 (\9\:mout VSS) capacitor c=4.87788e-17
C73 (\5\:n30 VSS) capacitor c=7.52993e-17
C74 (\13\:qbint VSS) capacitor c=7.35002e-17
C75 (\20\:CKb VSS) capacitor c=7.49915e-17
C76 (\4\:Q VSS) capacitor c=8.672e-17
C77 (\8\:qint VSS) capacitor c=4.08796e-17
C78 (\1\:QN VSS) capacitor c=1.86453e-17
C79 (\3\:qbint VSS) capacitor c=2.91971e-17
C80 (\2\:n30 VSS) capacitor c=3.75823e-17
C81 (\8\:qbint VSS) capacitor c=4.56179e-17
C82 (\2\:mout VSS) capacitor c=4.69331e-17
C83 (\9\:CKb VSS) capacitor c=4.23203e-17
C84 (\3\:QN VSS) capacitor c=2.31195e-17
C85 (\6\:qint VSS) capacitor c=3.40345e-17
C86 (\7\:qint VSS) capacitor c=3.18161e-17
C87 (\3\:Q VSS) capacitor c=4.76271e-17
C88 (\4\:CK VSS) capacitor c=5.87935e-17
C89 (\11\:qbint VSS) capacitor c=4.03024e-17
C90 (\12\:qbint VSS) capacitor c=6.89486e-17
C91 (\17\:qbint VSS) capacitor c=1.22229e-16
C92 (\7\:n30 VSS) capacitor c=1.08692e-16
C93 (\8\:n30 VSS) capacitor c=3.39539e-17
C94 (\5\:mout VSS) capacitor c=4.70408e-17
C95 (\6\:mout VSS) capacitor c=6.8136e-17
C96 (\6\:n20 VSS) capacitor c=8.02564e-17
C97 (\9\:n20 VSS) capacitor c=4.85413e-17
C98 (\12\:CKb VSS) capacitor c=4.70783e-17
C99 (\13\:CKb VSS) capacitor c=6.34091e-17
C100 (\14\:CKb VSS) capacitor c=1.36381e-16
C101 (\15\:CKb VSS) capacitor c=3.95055e-17
C102 (\16\:CKb VSS) capacitor c=2.50409e-16
C103 (\17\:CKb VSS) capacitor c=5.19319e-17
C104 (\10\:CKbb VSS) capacitor c=1.23117e-16
C105 (\11\:CKbb VSS) capacitor c=2.18529e-16
C106 (\12\:CKbb VSS) capacitor c=1.64606e-16
C107 (\13\:CKbb VSS) capacitor c=5.97739e-17
C108 (\5\:VDD VSS) capacitor c=3.30199e-17
C109 (\6\:VDD VSS) capacitor c=5.82865e-17
C110 (\14\:VDD VSS) capacitor c=1.13019e-17
Rk24 (\4\:D D) resistor r=0.01595 c=0
Rk2 (\3\:QN QN) resistor r=0.04422 c=0
Rk1 (\2\:QN \3\:QN) resistor r=0.04806 c=0
Rk3 (\3\:QN \5\:QN) resistor r=0.2045 c=0
Rk8 (\3\:Q Q) resistor r=0.1133 c=0
Rk7 (\2\:Q \3\:Q) resistor r=0.04292 c=0
Rk9 (\3\:Q \5\:Q) resistor r=0.3038 c=0
Rk37 (\2\:VDD \4\:VDD) resistor r=0.5647 c=0
Rk38 (\4\:VDD \5\:VDD) resistor r=0.1042 c=0
Rk39 (\5\:VDD \6\:VDD) resistor r=0.5347 c=0
Rk40 (\6\:VDD \7\:VDD) resistor r=0.4611 c=0
Rk41 (\5\:VDD \9\:VDD) resistor r=0.04334 c=0
Rk42 (\6\:VDD \11\:VDD) resistor r=0.04334 c=0
Rk43 (\7\:VDD \13\:VDD) resistor r=0.4896 c=0
Rk46 (\14\:VDD VDD) resistor r=0.2128 c=0
Rk44 (\7\:VDD \14\:VDD) resistor r=0.3385 c=0
Rk45 (\14\:VDD \16\:VDD) resistor r=0.4203 c=0
Rk10 (CK \4\:CK) resistor r=0.1371 c=0
Rk47 (\2\:VSS \4\:VSS) resistor r=0.55 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.03995 c=0
Rk49 (\5\:VSS \6\:VSS) resistor r=0.6244 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.4389 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.03242 c=0
Rk53 (\9\:VSS VSS) resistor r=0.2128 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=0.3057 c=0
Rk54 (\5\:VSS \11\:VSS) resistor r=0.1257 c=0
Rk55 (\6\:VSS \13\:VSS) resistor r=0.2317 c=0
Rk56 (\8\:VSS \15\:VSS) resistor r=0.07428 c=0
Rk57 (\9\:VSS \17\:VSS) resistor r=0.3721 c=0
Rk4 (\5\:qint \6\:qint) resistor r=0.09998 c=0
Rk5 (\6\:qint \7\:qint) resistor r=0.1347 c=0
Rk6 (\6\:qint \9\:qint) resistor r=0.124 c=0
Rk11 (\11\:qbint \12\:qbint) resistor r=0.1344 c=0
Rk12 (\12\:qbint \14\:qbint) resistor r=0.2037 c=0
Rk13 (\12\:qbint \16\:qbint) resistor r=0.4439 c=0
Rk14 (\14\:qbint \17\:qbint) resistor r=0.773 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.2246 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2437 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.1623 c=0
Rk28 (\14\:CKb \16\:CKb) resistor r=1.1478 c=0
Rk29 (\16\:CKb \17\:CKb) resistor r=0.2328 c=0
Rk30 (\16\:CKb \19\:CKb) resistor r=1.2308 c=0
Rk31 (\19\:CKb \21\:CKb) resistor r=0.5628 c=0
Rk15 (\6\:n30 \7\:n30) resistor r=0.5455 c=0
Rk16 (\7\:n30 \8\:n30) resistor r=0.1057 c=0
Rk17 (\7\:n30 \10\:n30) resistor r=0.5067 c=0
Rk18 (\5\:mout \6\:mout) resistor r=0.1675 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.4479 c=0
Rk20 (\6\:mout \10\:mout) resistor r=0.1703 c=0
Rk32 (\9\:CKbb \10\:CKbb) resistor r=0.5433 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.7331 c=0
Rk34 (\11\:CKbb \12\:CKbb) resistor r=1.1779 c=0
Rk35 (\12\:CKbb \13\:CKbb) resistor r=0.4168 c=0
Rk36 (\10\:CKbb \15\:CKbb) resistor r=0.06511 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.4732 c=0
Rk22 (\6\:n20 \8\:n20) resistor r=0.4662 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.188 c=0
Rl29 (\1\:D \2\:D) resistor r=103.365 c=0
Rl30 (\2\:D \3\:D) resistor r=158.414 c=0
Rl8 (\1\:CK \2\:CK) resistor r=39.6174 c=0
Rl9 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl1 (qint \2\:qint) resistor r=28.079 c=0
Rl2 (\2\:qint \3\:qint) resistor r=35.7713 c=0
Rl3 (qbint \2\:qbint) resistor r=33.4251 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=33.8489 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=55.0028 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=160.453 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=226.203 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=47.791 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=9.1017 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl25 (\4\:CKb \5\:CKb) resistor r=64.5404 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=291.427 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=177.726 c=0
Rl33 (\9\:CKb \11\:CKb) resistor r=95.0334 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=2.4801 c=0
Rl10 (n30 \2\:n30) resistor r=131.606 c=0
Rl11 (\2\:n30 \3\:n30) resistor r=141.815 c=0
Rl12 (\2\:n30 \4\:n30) resistor r=7.6417 c=0
Rl24 (\2\:mout \4\:mout) resistor r=219.894 c=0
Rl22 (mout \2\:mout) resistor r=67.6161 c=0
Rl23 (\2\:mout \3\:mout) resistor r=15.3298 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=303.412 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl17 (\3\:CKbb \4\:CKbb) resistor r=62.6944 c=0
Rl16 (CKbb \2\:CKbb) resistor r=74.2328 c=0
Rl20 (n20 \2\:n20) resistor r=133.79 c=0
Rl21 (\2\:n20 \3\:n20) resistor r=116.483 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz10 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz11 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz7 (\7\:n20 \8\:n20) resistor r=75 c=0
Ry1 (\4\:QN \5\:QN) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry16 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry8 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry5 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry6 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx9 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx13 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \9\:n20) resistor r=45 c=0
mn57 (\1\:QN \3\:qint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\8\:qint \4\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\4\:Q \5\:qbint \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=2.03e-14 ps=1.78e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\20\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=3.698e-14 ps=1.78e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint \3\:n30 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.973e-14 ad=2.03e-14 ps=7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn50 (n35 \10\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=3.407e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.32e-14 ps=7.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.83e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn40 (\5\:n30 \3\:CKbb \9\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.64e-14 ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.625e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn30 (\9\:mout \3\:n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.44e-14 ad=4.64e-14 ps=1.23e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.26e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn35 (n25 mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.44e-14 ad=1.813e-14 ps=1.23e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=8.95e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn36 (\7\:n20 \6\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.813e-14 ad=2.32e-14 ps=5.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=7.25e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn26 (\7\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=5.2e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.61e-14 ad=1.015e-14 ps=8e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn21 (\14\:CKbb \11\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.61e-14 ad=2.03e-14 ps=8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
ends DFFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:05 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFHQX1
// View name: extracted

simulator lang=spectre

subckt EDFFHQX1 CK D E Q VDD VSS
mp20 (\12\:CKb \3\:CK \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.8664 \
        scb=0.0202043 scc=0.000597023 m=(1)
mp21 (\15\:CKbb \6\:CKb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.8049 \
        scb=0.0100559 scc=8.95671e-05 m=(1)
mp0 (\6\:Eb \5\:E \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.76395e-07 sb=1.4e-07 sd=160n sca=24.8073 \
        scb=0.0246729 scc=0.00213017 m=(1)
C1 (E VSS) capacitor c=3.69119e-17
C2 (Q VSS) capacitor c=2.81592e-17
C3 (D VSS) capacitor c=8.69786e-17
C4 (VDD VSS) capacitor c=3.14292e-16
C5 (CK VSS) capacitor c=1.16323e-16
C6 (CKb VSS) capacitor c=9.66399e-17
C7 (CKbb VSS) capacitor c=3.5695e-17
C8 (n20 VSS) capacitor c=5.41751e-17
C9 (Db VSS) capacitor c=1.11957e-16
C10 (net340 VSS) capacitor c=1.32881e-18
C11 (mout VSS) capacitor c=3.17058e-17
C12 (n30 VSS) capacitor c=6.78488e-17
C13 (net380 VSS) capacitor c=1.32746e-18
C14 (qbint VSS) capacitor c=3.84482e-17
C15 (Eb VSS) capacitor c=4.17502e-17
C16 (net333 VSS) capacitor c=4.74274e-19
C17 (net309 VSS) capacitor c=3.73929e-18
C18 (net317 VSS) capacitor c=6.19106e-18
C19 (net328 VSS) capacitor c=4.71904e-18
C20 (\5\:E VSS) capacitor c=4.8429e-17
C21 (\1\:D VSS) capacitor c=5.61257e-17
C22 (\1\:E VSS) capacitor c=5.38862e-17
C23 (\8\:qbint VSS) capacitor c=4.69843e-17
C24 (\7\:CKbb VSS) capacitor c=5.34177e-17
C25 (\2\:CKb VSS) capacitor c=1.09157e-16
C26 (\4\:mout VSS) capacitor c=4.75671e-17
C27 (\3\:CKb VSS) capacitor c=1.36672e-16
C28 (\6\:CKb VSS) capacitor c=5.86145e-17
C29 (\3\:CK VSS) capacitor c=3.554e-17
C30 (\7\:E VSS) capacitor c=3.09505e-17
C31 (\3\:D VSS) capacitor c=8.40174e-17
C32 (\3\:E VSS) capacitor c=6.65466e-17
C33 (\3\:Eb VSS) capacitor c=6.27889e-17
C34 (\4\:n30 VSS) capacitor c=2.23392e-17
C35 (\7\:qbint VSS) capacitor c=2.58382e-17
C36 (\5\:qbint VSS) capacitor c=4.65493e-17
C37 (\5\:CKbb VSS) capacitor c=3.17461e-17
C38 (\3\:n20 VSS) capacitor c=3.3877e-17
C39 (\3\:mout VSS) capacitor c=5.19861e-17
C40 (\3\:CKbb VSS) capacitor c=3.89703e-17
C41 (\7\:CKb VSS) capacitor c=2.3158e-17
C42 (\9\:CKb VSS) capacitor c=2.37109e-17
C43 (\1\:CK VSS) capacitor c=5.51986e-17
C44 (\6\:E VSS) capacitor c=3.26734e-17
C45 (\2\:D VSS) capacitor c=5.69982e-17
C46 (\2\:Eb VSS) capacitor c=5.86158e-17
C47 (\4\:E VSS) capacitor c=4.84224e-17
C48 (\2\:E VSS) capacitor c=3.29734e-17
C49 (\3\:n30 VSS) capacitor c=1.26163e-17
C50 (\6\:qbint VSS) capacitor c=3.20811e-17
C51 (\8\:CKbb VSS) capacitor c=5.20547e-17
C52 (\6\:CKbb VSS) capacitor c=2.84089e-17
C53 (\2\:n20 VSS) capacitor c=3.19936e-17
C54 (\4\:CKbb VSS) capacitor c=3.73524e-17
C55 (\2\:CKbb VSS) capacitor c=4.02879e-17
C56 (\8\:CKb VSS) capacitor c=1.88147e-17
C57 (\2\:CK VSS) capacitor c=5.47942e-17
C58 (\6\:Eb VSS) capacitor c=1.11447e-16
C59 (\10\:VDD VSS) capacitor c=3.0312e-17
C60 (\3\:Db VSS) capacitor c=3.21195e-16
C61 (\9\:qbint VSS) capacitor c=4.94456e-17
C62 (\12\:VDD VSS) capacitor c=3.72406e-17
C63 (\3\:Q VSS) capacitor c=4.24557e-17
C64 (\14\:VDD VSS) capacitor c=3.65603e-17
C65 (\9\:n30 VSS) capacitor c=8.27008e-17
C66 (\5\:mout VSS) capacitor c=4.31984e-17
C67 (\16\:VDD VSS) capacitor c=4.66436e-17
C68 (\4\:n20 VSS) capacitor c=3.40446e-17
C69 (\5\:Db VSS) capacitor c=3.02619e-16
C70 (\15\:CKbb VSS) capacitor c=6.99055e-17
C71 (\18\:VDD VSS) capacitor c=3.23209e-17
C72 (\12\:CKb VSS) capacitor c=7.27967e-17
C73 (\1\:VDD VSS) capacitor c=5.58182e-17
C74 (\4\:Eb VSS) capacitor c=8.31816e-17
C75 (\13\:qbint VSS) capacitor c=5.69645e-17
C76 (\1\:Q VSS) capacitor c=6.11352e-17
C77 (\7\:n30 VSS) capacitor c=5.79044e-17
C78 (\9\:mout VSS) capacitor c=5.89385e-17
C79 (\7\:n20 VSS) capacitor c=6.82836e-17
C80 (\7\:Db VSS) capacitor c=9.42314e-17
C81 (\13\:CKbb VSS) capacitor c=1.08664e-16
C82 (\14\:CKb VSS) capacitor c=1.99224e-17
C83 (\2\:mout VSS) capacitor c=2.83213e-17
C84 (\4\:CKb VSS) capacitor c=5.38255e-17
C85 (\5\:CKb VSS) capacitor c=4.30245e-17
C86 (\2\:qbint VSS) capacitor c=1.31329e-17
C87 (\3\:qbint VSS) capacitor c=6.70585e-18
C88 (\4\:qbint VSS) capacitor c=4.07691e-17
C89 (\2\:n30 VSS) capacitor c=3.4538e-17
C90 (\10\:CKb VSS) capacitor c=3.47116e-17
C91 (\11\:CKb VSS) capacitor c=7.9079e-17
C92 (\6\:n20 VSS) capacitor c=8.46973e-17
C93 (\9\:n20 VSS) capacitor c=8.89553e-17
C94 (\7\:mout VSS) capacitor c=4.78583e-17
C95 (\8\:mout VSS) capacitor c=6.24794e-17
C96 (\9\:CKbb VSS) capacitor c=6.28715e-17
C97 (\10\:CKbb VSS) capacitor c=1.27819e-16
C98 (\11\:CKbb VSS) capacitor c=1.10191e-16
C99 (\12\:CKbb VSS) capacitor c=7.52883e-17
C100 (\17\:CKbb VSS) capacitor c=5.34588e-17
C101 (\18\:CKbb VSS) capacitor c=6.74442e-17
C102 (\5\:n30 VSS) capacitor c=1.30373e-16
C103 (\6\:n30 VSS) capacitor c=1.38064e-16
C104 (\11\:qbint VSS) capacitor c=5.92846e-17
C105 (\12\:qbint VSS) capacitor c=4.91603e-17
C106 (\8\:E VSS) capacitor c=1.47695e-16
C107 (\9\:E VSS) capacitor c=1.15849e-16
C108 (\10\:E VSS) capacitor c=3.25895e-17
C109 (\11\:E VSS) capacitor c=3.99042e-17
C110 (\4\:D VSS) capacitor c=5.21404e-17
C111 (\8\:Eb VSS) capacitor c=7.76016e-17
C112 (\3\:VDD VSS) capacitor c=1.76492e-17
C113 (\5\:VDD VSS) capacitor c=1.12802e-17
C114 (\6\:VDD VSS) capacitor c=3.67754e-17
C115 (\7\:VDD VSS) capacitor c=4.13102e-17
C116 (\9\:VDD VSS) capacitor c=1.97058e-17
Rk29 (\8\:E \9\:E) resistor r=0.9065 c=0
Rk30 (\9\:E \10\:E) resistor r=0.08499 c=0
Rk32 (\11\:E E) resistor r=0.053 c=0
Rk31 (\9\:E \11\:E) resistor r=0.2237 c=0
Rk18 (\2\:Q Q) resistor r=0.1572 c=0
Rk19 (Q \4\:Q) resistor r=0.1049 c=0
Rk33 (D \4\:D) resistor r=0.03958 c=0
Rk36 (\2\:VSS \3\:VSS) resistor r=0.2054 c=0
Rk37 (\3\:VSS \4\:VSS) resistor r=0.446 c=0
Rk38 (\4\:VSS \5\:VSS) resistor r=0.06499 c=0
Rk39 (\5\:VSS \6\:VSS) resistor r=0.3606 c=0
Rk40 (\6\:VSS \7\:VSS) resistor r=0.5211 c=0
Rk41 (\7\:VSS \8\:VSS) resistor r=0.2555 c=0
Rk43 (\9\:VSS VSS) resistor r=0.1525 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.3984 c=0
Rk44 (\3\:VSS \11\:VSS) resistor r=0.3077 c=0
Rk45 (\5\:VSS \13\:VSS) resistor r=0.271 c=0
Rk46 (\6\:VSS \15\:VSS) resistor r=0.2827 c=0
Rk47 (\7\:VSS \17\:VSS) resistor r=0.1224 c=0
Rk48 (\9\:VSS \19\:VSS) resistor r=0.2529 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.2204 c=0
Rk50 (\3\:VDD \4\:VDD) resistor r=0.431 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.03741 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.3355 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.5737 c=0
Rk54 (\7\:VDD \8\:VDD) resistor r=0.2555 c=0
Rk56 (\9\:VDD VDD) resistor r=0.1324 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.4185 c=0
Rk57 (\3\:VDD \11\:VDD) resistor r=0.2503 c=0
Rk58 (\5\:VDD \13\:VDD) resistor r=0.1957 c=0
Rk59 (\6\:VDD \15\:VDD) resistor r=0.1957 c=0
Rk60 (\7\:VDD \17\:VDD) resistor r=0.2919 c=0
Rk61 (\9\:VDD \19\:VDD) resistor r=0.1966 c=0
Rk1 (\4\:CK CK) resistor r=0.002999 c=0
Rk2 (\10\:CKb \11\:CKb) resistor r=0.2077 c=0
Rk3 (\11\:CKb \13\:CKb) resistor r=0.6388 c=0
Rk4 (\11\:CKb \15\:CKb) resistor r=0.1003 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.2447 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.8878 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2837 c=0
Rk14 (\12\:CKbb \14\:CKbb) resistor r=0.2845 c=0
Rk15 (\14\:CKbb \16\:CKbb) resistor r=0.6667 c=0
Rk16 (\11\:CKbb \17\:CKbb) resistor r=0.2247 c=0
Rk17 (\12\:CKbb \18\:CKbb) resistor r=0.3613 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.2631 c=0
Rk7 (\6\:n20 \9\:n20) resistor r=0.5876 c=0
Rk26 (\2\:Db \4\:Db) resistor r=0.5934 c=0
Rk27 (\4\:Db \6\:Db) resistor r=2.4551 c=0
Rk28 (\6\:Db \8\:Db) resistor r=0.5402 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.1196 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.228 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2628 c=0
Rk20 (\5\:n30 \6\:n30) resistor r=0.9078 c=0
Rk21 (\6\:n30 \8\:n30) resistor r=0.2329 c=0
Rk22 (\6\:n30 \10\:n30) resistor r=0.4348 c=0
Rk23 (\10\:qbint \11\:qbint) resistor r=0.2292 c=0
Rk24 (\11\:qbint \12\:qbint) resistor r=0.2451 c=0
Rk25 (\11\:qbint \14\:qbint) resistor r=0.2442 c=0
Rk34 (\5\:Eb \7\:Eb) resistor r=0.6874 c=0
Rk35 (\7\:Eb \8\:Eb) resistor r=0.484 c=0
Rl36 (\5\:E \6\:E) resistor r=95.3288 c=0
Rl37 (\6\:E \7\:E) resistor r=35.7134 c=0
Rl31 (\3\:E \4\:E) resistor r=28.079 c=0
Rl30 (\1\:E \2\:E) resistor r=46.5349 c=0
Rl34 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl35 (\2\:D \3\:D) resistor r=101.156 c=0
Rl2 (\2\:CK \3\:CK) resistor r=58.7903 c=0
Rl1 (\1\:CK \2\:CK) resistor r=195.329 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=524.566 c=0
Rl11 (CKb \2\:CKb) resistor r=203.045 c=0
Rl18 (\8\:CKb \9\:CKb) resistor r=26.098 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=245.697 c=0
Rl16 (\4\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=206.36 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=12.0714 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=172.352 c=0
Rl19 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=48.7687 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=46.417 c=0
Rl8 (n20 \2\:n20) resistor r=98.7687 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=99.7141 c=0
Rl5 (mout \2\:mout) resistor r=16.2873 c=0
Rl27 (n30 \2\:n30) resistor r=171.462 c=0
Rl29 (\2\:n30 \4\:n30) resistor r=23.7402 c=0
Rl28 (\2\:n30 \3\:n30) resistor r=5.1011 c=0
Rl20 (qbint \2\:qbint) resistor r=72.3105 c=0
Rl24 (\2\:qbint \6\:qbint) resistor r=104.219 c=0
Rl25 (\3\:qbint \7\:qbint) resistor r=35.772 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=17.6978 c=0
Rl26 (\4\:qbint \8\:qbint) resistor r=93.4643 c=0
Rl23 (\4\:qbint \5\:qbint) resistor r=68.03 c=0
Rl22 (\3\:qbint \4\:qbint) resistor r=87.8245 c=0
Rl32 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl33 (\2\:Eb \3\:Eb) resistor r=135.217 c=0
Rz5 (\1\:Q \2\:Q) resistor r=75 c=0
Rz11 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz12 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz1 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz7 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry5 (\3\:Q \4\:Q) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry14 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry15 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry1 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry9 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry7 (\9\:qbint \10\:qbint) resistor r=62 c=0
Ry10 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx11 (\2\:E \8\:E) resistor r=45 c=0
Rx12 (\4\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\8\:CKb \10\:CKb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \17\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx10 (\6\:qbint \12\:qbint) resistor r=45 c=0
Rx15 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\14\:CKb \1\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn21 (\13\:CKbb \9\:CKb \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn0 (\4\:Eb \7\:E \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\7\:n20 \7\:CKb \7\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=8.098e-14 ps=6.9e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.075e-14 ad=8.098e-14 ps=7.1e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.755e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn35 (net340 \3\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=3.075e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.56e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn30 (\9\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.945e-14 ad=6.252e-14 ps=1.38e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.265e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn40 (\9\:mout \5\:CKbb \7\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=6.252e-14 ps=9.6e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=9.15e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (\7\:n30 CKb net380 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.638e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=5.95e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn50 (net380 \5\:qbint \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.598e-14 ad=1.23e-14 ps=1.11e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=4.9e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn45 (\13\:qbint \4\:n30 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=9.16e-14 ps=6.9e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.07951e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn55 (\1\:Q \7\:qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.598e-14 ad=3.9e-14 ps=1.11e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.5e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mn1 (\13\:qbint \3\:Eb Db VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=9.16e-14 ps=8.6e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.98173e-07 sb=5.73365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.42e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.13173e-07 sb=3.58365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (net333 \3\:D \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18173e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.96e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.775e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp35 (net309 \4\:mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.75e-14 ad=5.58e-14 ps=1.12e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.55e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp30 (\5\:mout n20 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.75e-14 ad=1.364e-13 ps=1.12e-06 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.255e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp40 (\5\:mout \2\:CKb \9\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.364e-13 ps=9.4e-07 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=7.7e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp51 (\9\:n30 \7\:CKbb net317 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=4.96e-14 ps=8.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=5.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp50 (net317 \8\:qbint \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.78e-14 ad=3.565e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=4.05e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp45 (\9\:qbint n30 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.17e-14 ad=7.01e-14 ps=1.11e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.12339e-07 sd=160n sca=12.4967 \
        scb=0.0111079 scc=0.00042389 m=(1)
mp55 (\3\:Q qbint \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.78e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60872e-06 sb=1.4e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp1 (\9\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.01e-14 ps=1.2e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.50641e-07 sb=7.04551e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.05641e-07 sb=4.49551e-07 sd=160n sca=16.5949 \
        scb=0.0146729 scc=0.00118863 m=(1)
mp2 (net328 \1\:D \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85641e-07 sb=2.69551e-07 sd=160n sca=17.3384 \
        scb=0.0151709 scc=0.00118918 m=(1)
ends EDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:06 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFHQX2
// View name: extracted

simulator lang=spectre

subckt EDFFHQX2 CK D E Q VDD VSS
mp20 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.7e-07 sd=160n sca=22.5547 \
        scb=0.0255076 scc=0.00117617 m=(1)
mp21 (\17\:CKbb \9\:CKb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.65e-07 sd=160n sca=14.1611 \
        scb=0.0124524 scc=0.000189889 m=(1)
mp0 (\5\:Eb \5\:E \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.382e-14 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.5754 scb=0.0148797 \
        scc=0.00022139 m=(1)
C1 (D VSS) capacitor c=4.05762e-17
C2 (Q VSS) capacitor c=3.7229e-17
C3 (VDD VSS) capacitor c=3.17498e-16
C4 (CK VSS) capacitor c=6.79091e-17
C5 (CKb VSS) capacitor c=8.76854e-17
C6 (CKbb VSS) capacitor c=3.9113e-17
C7 (n20 VSS) capacitor c=4.95587e-17
C8 (Db VSS) capacitor c=1.20877e-16
C9 (net340 VSS) capacitor c=2.80762e-18
C10 (mout VSS) capacitor c=2.00233e-17
C11 (n30 VSS) capacitor c=5.67102e-17
C12 (qbint VSS) capacitor c=1.56257e-16
C13 (Eb VSS) capacitor c=3.3715e-17
C14 (net333 VSS) capacitor c=5.79558e-18
C15 (net309 VSS) capacitor c=6.01613e-18
C16 (net317 VSS) capacitor c=3.54272e-18
C17 (net328 VSS) capacitor c=6.49179e-18
C18 (\5\:E VSS) capacitor c=4.63097e-17
C19 (\1\:D VSS) capacitor c=4.79034e-17
C20 (\1\:E VSS) capacitor c=3.73997e-17
C21 (\10\:qbint VSS) capacitor c=7.49162e-17
C22 (\7\:CKbb VSS) capacitor c=7.28648e-17
C23 (\2\:CKb VSS) capacitor c=1.06947e-16
C24 (\4\:mout VSS) capacitor c=4.19488e-17
C25 (\3\:CKb VSS) capacitor c=1.27634e-16
C26 (\9\:CKb VSS) capacitor c=4.97408e-17
C27 (\1\:CK VSS) capacitor c=3.9225e-17
C28 (\7\:E VSS) capacitor c=2.41103e-17
C29 (\3\:D VSS) capacitor c=3.57486e-17
C30 (\3\:E VSS) capacitor c=3.81175e-17
C31 (\3\:Eb VSS) capacitor c=5.87434e-17
C32 (\4\:n30 VSS) capacitor c=2.11916e-17
C33 (\6\:qbint VSS) capacitor c=3.59628e-17
C34 (\5\:CKbb VSS) capacitor c=3.4742e-17
C35 (\3\:n20 VSS) capacitor c=2.99949e-17
C36 (\3\:mout VSS) capacitor c=4.251e-17
C37 (\3\:CKbb VSS) capacitor c=3.30789e-17
C38 (\8\:CKb VSS) capacitor c=2.36059e-17
C39 (\10\:CKb VSS) capacitor c=2.35879e-17
C40 (\3\:CK VSS) capacitor c=4.41441e-17
C41 (\6\:E VSS) capacitor c=3.71369e-17
C42 (\2\:D VSS) capacitor c=3.82707e-17
C43 (\4\:Eb VSS) capacitor c=3.70732e-17
C44 (\4\:E VSS) capacitor c=4.43183e-17
C45 (\2\:E VSS) capacitor c=2.77698e-17
C46 (\3\:n30 VSS) capacitor c=1.71042e-17
C47 (\8\:CKbb VSS) capacitor c=5.3993e-17
C48 (\6\:CKbb VSS) capacitor c=2.72081e-17
C49 (\2\:n20 VSS) capacitor c=3.54066e-17
C50 (\4\:CKbb VSS) capacitor c=3.69538e-17
C51 (\2\:CKbb VSS) capacitor c=3.42036e-17
C52 (\7\:CKb VSS) capacitor c=2.63544e-17
C53 (\2\:CK VSS) capacitor c=5.1214e-17
C54 (\5\:Eb VSS) capacitor c=1.10773e-17
C55 (\10\:VDD VSS) capacitor c=3.15658e-17
C56 (\3\:Db VSS) capacitor c=3.19136e-16
C57 (\15\:qbint VSS) capacitor c=3.88463e-17
C58 (\4\:Q VSS) capacitor c=4.24196e-17
C59 (\8\:n30 VSS) capacitor c=8.27486e-17
C60 (\5\:mout VSS) capacitor c=3.69116e-17
C61 (\16\:VDD VSS) capacitor c=4.96851e-17
C62 (\8\:n20 VSS) capacitor c=3.85387e-17
C63 (\5\:Db VSS) capacitor c=3.1207e-16
C64 (\17\:CKbb VSS) capacitor c=7.52596e-17
C65 (\18\:VDD VSS) capacitor c=3.14251e-17
C66 (\15\:CKb VSS) capacitor c=5.29883e-17
C67 (\1\:VDD VSS) capacitor c=8.25934e-17
C68 (\9\:Eb VSS) capacitor c=7.18241e-17
C69 (\11\:qbint VSS) capacitor c=5.80138e-17
C70 (\2\:Q VSS) capacitor c=5.74682e-17
C71 (\5\:n30 VSS) capacitor c=5.42944e-17
C72 (\9\:mout VSS) capacitor c=7.46943e-17
C73 (\6\:n20 VSS) capacitor c=7.2703e-17
C74 (\7\:Db VSS) capacitor c=9.79656e-17
C75 (\12\:CKbb VSS) capacitor c=1.05015e-16
C76 (\13\:CKb VSS) capacitor c=1.97698e-17
C77 (\2\:mout VSS) capacitor c=2.40319e-17
C78 (\4\:CKb VSS) capacitor c=5.16949e-17
C79 (\5\:CKb VSS) capacitor c=4.29576e-17
C80 (\5\:qbint VSS) capacitor c=3.91815e-17
C81 (\2\:n30 VSS) capacitor c=1.96525e-17
C82 (\2\:Eb VSS) capacitor c=3.95473e-17
C83 (\4\:CK VSS) capacitor c=4.53895e-17
C84 (\11\:CKb VSS) capacitor c=4.24419e-17
C85 (\12\:CKb VSS) capacitor c=4.48908e-17
C86 (\4\:n20 VSS) capacitor c=1.12663e-16
C87 (\5\:n20 VSS) capacitor c=7.59666e-17
C88 (\7\:mout VSS) capacitor c=5.11317e-17
C89 (\8\:mout VSS) capacitor c=6.05343e-17
C90 (\9\:CKbb VSS) capacitor c=1.63173e-16
C91 (\10\:CKbb VSS) capacitor c=1.63743e-16
C92 (\11\:CKbb VSS) capacitor c=8.0273e-17
C93 (\14\:CKbb VSS) capacitor c=5.7876e-17
C94 (\15\:CKbb VSS) capacitor c=4.71125e-17
C95 (\16\:CKbb VSS) capacitor c=7.15596e-17
C96 (\1\:Q VSS) capacitor c=3.95511e-17
C97 (\7\:n30 VSS) capacitor c=1.5151e-16
C98 (\10\:n30 VSS) capacitor c=1.42261e-16
C99 (\13\:qbint VSS) capacitor c=6.71872e-17
C100 (\14\:qbint VSS) capacitor c=5.46798e-17
C101 (\4\:D VSS) capacitor c=6.9574e-17
C102 (\8\:E VSS) capacitor c=7.78848e-17
C103 (\9\:E VSS) capacitor c=1.31526e-16
C104 (\10\:E VSS) capacitor c=1.60514e-16
C105 (\11\:E VSS) capacitor c=4.42285e-17
C106 (\7\:Eb VSS) capacitor c=8.21577e-17
C107 (\8\:Eb VSS) capacitor c=8.37465e-17
C108 (\3\:VDD VSS) capacitor c=2.03081e-17
C109 (\5\:VDD VSS) capacitor c=1.21378e-16
C110 (\7\:VDD VSS) capacitor c=4.22023e-17
C111 (\9\:VDD VSS) capacitor c=1.59313e-17
Rk31 (E \8\:E) resistor r=0.005081 c=0
Rk32 (\8\:E \9\:E) resistor r=0.4616 c=0
Rk33 (\9\:E \10\:E) resistor r=0.9528 c=0
Rk34 (\9\:E \11\:E) resistor r=0.1737 c=0
Rk30 (D \4\:D) resistor r=0.02448 c=0
Rk18 (Q \1\:Q) resistor r=0.07016 c=0
Rk19 (\1\:Q \3\:Q) resistor r=0.1659 c=0
Rk20 (\1\:Q \5\:Q) resistor r=0.1485 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.2179 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.4837 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.07251 c=0
Rk55 (\5\:VSS \7\:VSS) resistor r=0.5511 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.2279 c=0
Rk58 (\9\:VSS VSS) resistor r=0.09733 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=0.4536 c=0
Rk59 (\3\:VSS \11\:VSS) resistor r=0.2736 c=0
Rk62 (\7\:VSS \17\:VSS) resistor r=0.2815 c=0
Rk63 (\9\:VSS \19\:VSS) resistor r=0.2627 c=0
Rk38 (\2\:VDD \3\:VDD) resistor r=0.2179 c=0
Rk39 (\3\:VDD \4\:VDD) resistor r=0.4837 c=0
Rk40 (\4\:VDD \5\:VDD) resistor r=0.1402 c=0
Rk42 (\5\:VDD \7\:VDD) resistor r=0.5687 c=0
Rk43 (\7\:VDD \8\:VDD) resistor r=0.258 c=0
Rk45 (\9\:VDD VDD) resistor r=0.1124 c=0
Rk44 (\8\:VDD \9\:VDD) resistor r=0.4385 c=0
Rk46 (\3\:VDD \11\:VDD) resistor r=0.2203 c=0
Rk49 (\7\:VDD \17\:VDD) resistor r=0.269 c=0
Rk50 (\9\:VDD \19\:VDD) resistor r=0.2603 c=0
Rk1 (CK \4\:CK) resistor r=0.1473 c=0
Rk2 (\11\:CKb \12\:CKb) resistor r=0.1752 c=0
Rk3 (\12\:CKb \14\:CKb) resistor r=0.1178 c=0
Rk4 (\12\:CKb \16\:CKb) resistor r=0.4258 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=1.2493 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.2837 c=0
Rk13 (\11\:CKbb \13\:CKbb) resistor r=0.313 c=0
Rk14 (\9\:CKbb \14\:CKbb) resistor r=0.2758 c=0
Rk15 (\10\:CKbb \15\:CKbb) resistor r=0.2391 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.3905 c=0
Rk17 (\13\:CKbb \18\:CKbb) resistor r=0.5662 c=0
Rk5 (\4\:n20 \5\:n20) resistor r=0.5759 c=0
Rk6 (\5\:n20 \7\:n20) resistor r=0.2867 c=0
Rk7 (\5\:n20 \9\:n20) resistor r=0.1411 c=0
Rk27 (\2\:Db \4\:Db) resistor r=0.6178 c=0
Rk28 (\4\:Db \6\:Db) resistor r=2.4126 c=0
Rk29 (\6\:Db \8\:Db) resistor r=0.6073 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.1174 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.271 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2989 c=0
Rk21 (\6\:n30 \7\:n30) resistor r=0.2625 c=0
Rk22 (\7\:n30 \9\:n30) resistor r=0.4468 c=0
Rk23 (\7\:n30 \10\:n30) resistor r=0.9313 c=0
Rk24 (\12\:qbint \13\:qbint) resistor r=0.2788 c=0
Rk25 (\13\:qbint \14\:qbint) resistor r=0.2678 c=0
Rk26 (\13\:qbint \16\:qbint) resistor r=0.1276 c=0
Rk35 (\6\:Eb \7\:Eb) resistor r=0.04776 c=0
Rk36 (\7\:Eb \8\:Eb) resistor r=0.6174 c=0
Rk37 (\7\:Eb \10\:Eb) resistor r=0.6151 c=0
Rl40 (\5\:E \6\:E) resistor r=193 c=0
Rl41 (\6\:E \7\:E) resistor r=39.1533 c=0
Rl34 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl33 (\1\:E \2\:E) resistor r=24.2328 c=0
Rl38 (\1\:D \2\:D) resistor r=74.2328 c=0
Rl39 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:CK \2\:CK) resistor r=110.713 c=0
Rl2 (\2\:CK \3\:CK) resistor r=95.3288 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=555.335 c=0
Rl11 (CKb \2\:CKb) resistor r=212.66 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=259.159 c=0
Rl17 (\4\:CKb \8\:CKb) resistor r=30.4507 c=0
Rl18 (\5\:CKb \9\:CKb) resistor r=172.31 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=153.047 c=0
Rl19 (\6\:CKb \10\:CKb) resistor r=34.3295 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=2.0166 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=22.0246 c=0
Rl20 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=46.417 c=0
Rl8 (n20 \2\:n20) resistor r=85.7713 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=53.079 c=0
Rl7 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl6 (\2\:mout \3\:mout) resistor r=124.714 c=0
Rl5 (mout \2\:mout) resistor r=5.1171 c=0
Rl30 (n30 \2\:n30) resistor r=103.56 c=0
Rl32 (\2\:n30 \4\:n30) resistor r=34.3295 c=0
Rl31 (\2\:n30 \3\:n30) resistor r=1.2666 c=0
Rl24 (\5\:qbint qbint) resistor r=134.566 c=0
Rl29 (\5\:qbint \10\:qbint) resistor r=114.618 c=0
Rl25 (\5\:qbint \6\:qbint) resistor r=49.2335 c=0
Rl35 (Eb \2\:Eb) resistor r=23.7402 c=0
Rl36 (\2\:Eb \3\:Eb) resistor r=126.865 c=0
Rl37 (\2\:Eb \4\:Eb) resistor r=33.6809 c=0
Rz5 (\3\:Q \2\:Q) resistor r=75 c=0
Rz14 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz11 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz12 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz13 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz2 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz7 (\12\:qbint \11\:qbint) resistor r=75 c=0
Rz10 (\9\:Eb \10\:Eb) resistor r=75 c=0
Ry5 (\5\:Q \4\:Q) resistor r=62 c=0
Ry16 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry1 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry8 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry9 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\16\:qbint \15\:qbint) resistor r=62 c=0
Ry10 (\5\:Eb \6\:Eb) resistor r=62 c=0
Rx12 (\6\:E \8\:E) resistor r=45 c=0
Rx13 (\2\:E \10\:E) resistor r=45 c=0
Rx14 (\4\:E \11\:E) resistor r=45 c=0
Rx11 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:CKb \11\:CKb) resistor r=45 c=0
Rx5 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \10\:n30) resistor r=45 c=0
Rx10 (\14\:qbint qbint) resistor r=45 c=0
Rx15 (\4\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\13\:CKb \3\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.6e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn21 (\12\:CKbb \10\:CKb \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\9\:Eb \7\:E \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=2.03e-14 ps=1.23e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn25 (\6\:n20 \8\:CKb \7\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=9.225e-14 ps=6.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn36 (\6\:n20 \3\:CKbb net340 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.997e-14 ad=9.225e-14 ps=8e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn35 (net340 \3\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.227e-14 ad=3.997e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn30 (\9\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.227e-14 ad=6.867e-14 ps=9.2e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn40 (\9\:mout \5\:CKbb \5\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=6.867e-14 ps=8.3e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn51 (\5\:n30 CKb net380 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.845e-14 ad=4.305e-14 ps=5.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn50 (net380 \6\:qbint \5\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.845e-14 ps=1.13e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.945e-06 sb=1.97366e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn45 (\11\:qbint \4\:n30 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.67e-14 ad=9.62e-14 ps=1.11e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71548e-06 sb=1.25038e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (\11\:qbint \3\:Eb Db VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=9.62e-14 ps=8.4e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.80327e-06 sb=8.35385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.84663e-06 sb=6.30385e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (net333 \3\:D \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=6.24e-14 ps=1.23e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.90692e-06 sb=3.45385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn55 (\2\:Q qbint \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.236e-14 ad=4.42e-14 ps=1.12e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.80538e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mp25 (\8\:n20 CKbb \5\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp36 (\8\:n20 \3\:CKb net309 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.68e-14 ad=4.96e-14 ps=1.18e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp35 (net309 \4\:mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=8.68e-14 ps=1.13e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp30 (\5\:mout n20 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=1.2865e-13 ps=1.13e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp40 (\5\:mout \2\:CKb \8\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.2865e-13 ps=9.4e-07 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp51 (\8\:n30 \7\:CKbb net317 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp50 (net317 \10\:qbint \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2085e-13 ad=1.86e-14 ps=1.57e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.94919e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp45 (\15\:qbint n30 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2465e-13 ad=9.945e-14 ps=1.53e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73641e-06 sb=1.24756e-06 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp1 (\15\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=9.945e-14 ps=1.14e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79795e-06 sb=9.47564e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=7.02e-14 ps=1.45e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8441e-06 sb=7.22564e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp2 (net328 \1\:D \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.382e-14 ad=1.3065e-13 ps=1.49e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92205e-06 sb=3.42564e-07 sd=160n sca=13.9445 \
        scb=0.0121677 scc=0.000600062 m=(1)
mp55_1__rcx (\4\:Q qbint \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.2275e-13 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62462e-06 sb=1.79256e-06 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(2)
ends EDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:07 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFHQX4
// View name: extracted

simulator lang=spectre

subckt EDFFHQX4 CK D E Q VDD VSS
mp20 (\12\:CKb \3\:CK \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.53e-14 ad=3.655e-14 ps=1.17e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.05e-07 sd=160n sca=19.0805 \
        scb=0.0206115 scc=0.000620106 m=(1)
mp21 (\18\:CKbb \8\:CKb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.53e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp0 (\6\:Eb \5\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.975e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=29.4705 \
        scb=0.0286682 scc=0.00289959 m=(1)
C1 (D VSS) capacitor c=1.21316e-16
C2 (Q VSS) capacitor c=2.86292e-17
C3 (VDD VSS) capacitor c=4.22129e-16
C4 (CK VSS) capacitor c=1.06123e-16
C5 (CKb VSS) capacitor c=9.86221e-17
C6 (CKbb VSS) capacitor c=3.82556e-17
C7 (n20 VSS) capacitor c=5.8824e-17
C8 (Db VSS) capacitor c=1.10863e-16
C9 (net340 VSS) capacitor c=4.79276e-19
C10 (mout VSS) capacitor c=2.89159e-17
C11 (n30 VSS) capacitor c=4.60875e-16
C12 (qbint VSS) capacitor c=2.97914e-16
C13 (Eb VSS) capacitor c=4.11629e-17
C14 (net333 VSS) capacitor c=8.93728e-19
C15 (net309 VSS) capacitor c=6.87608e-18
C16 (net317 VSS) capacitor c=3.19819e-18
C17 (net328 VSS) capacitor c=4.86067e-18
C18 (\5\:E VSS) capacitor c=4.15187e-17
C19 (\1\:D VSS) capacitor c=5.14161e-17
C20 (\1\:E VSS) capacitor c=4.07103e-17
C21 (\17\:qbint VSS) capacitor c=7.70168e-17
C22 (\7\:CKbb VSS) capacitor c=6.94734e-17
C23 (\2\:CKb VSS) capacitor c=1.12726e-16
C24 (\4\:mout VSS) capacitor c=4.64259e-17
C25 (\3\:CKb VSS) capacitor c=1.21694e-16
C26 (\8\:CKb VSS) capacitor c=5.42351e-17
C27 (\3\:CK VSS) capacitor c=3.74297e-17
C28 (\7\:E VSS) capacitor c=2.2921e-17
C29 (\3\:D VSS) capacitor c=8.13383e-17
C30 (\3\:E VSS) capacitor c=6.077e-17
C31 (\3\:Eb VSS) capacitor c=5.83278e-17
C32 (\9\:qbint VSS) capacitor c=4.36677e-17
C33 (\5\:CKbb VSS) capacitor c=3.33706e-17
C34 (\3\:n20 VSS) capacitor c=3.23908e-17
C35 (\3\:mout VSS) capacitor c=7.69729e-17
C36 (\3\:CKbb VSS) capacitor c=5.36096e-17
C37 (\6\:CKb VSS) capacitor c=2.32194e-17
C38 (\7\:CKb VSS) capacitor c=2.2523e-17
C39 (\1\:CK VSS) capacitor c=4.90633e-17
C40 (\6\:E VSS) capacitor c=2.53855e-17
C41 (\2\:D VSS) capacitor c=5.12879e-17
C42 (\2\:Eb VSS) capacitor c=6.26334e-17
C43 (\4\:E VSS) capacitor c=4.84008e-17
C44 (\2\:E VSS) capacitor c=2.4525e-17
C45 (\8\:CKbb VSS) capacitor c=5.35689e-17
C46 (\6\:CKbb VSS) capacitor c=2.92723e-17
C47 (\2\:n20 VSS) capacitor c=3.44271e-17
C48 (\4\:CKbb VSS) capacitor c=3.45265e-17
C49 (\2\:CKbb VSS) capacitor c=4.87089e-17
C50 (\5\:CKb VSS) capacitor c=5.15893e-17
C51 (\2\:CK VSS) capacitor c=4.52205e-17
C52 (\6\:Eb VSS) capacitor c=9.15126e-17
C53 (\1\:VDD VSS) capacitor c=3.71119e-17
C54 (\3\:Db VSS) capacitor c=4.09759e-16
C55 (\26\:qbint VSS) capacitor c=4.5873e-17
C56 (\28\:qbint VSS) capacitor c=2.33078e-17
C57 (\1\:Q VSS) capacitor c=1.31246e-16
C58 (\14\:n30 VSS) capacitor c=7.96274e-17
C59 (\5\:mout VSS) capacitor c=4.75581e-17
C60 (\19\:VDD VSS) capacitor c=5.42962e-17
C61 (\4\:n20 VSS) capacitor c=3.62775e-17
C62 (\5\:Db VSS) capacitor c=4.21322e-16
C63 (\18\:CKbb VSS) capacitor c=5.91265e-17
C64 (\23\:VDD VSS) capacitor c=9.14566e-18
C65 (\12\:CKb VSS) capacitor c=5.99425e-17
C66 (\3\:VDD VSS) capacitor c=8.82461e-17
C67 (\4\:Eb VSS) capacitor c=7.07305e-17
C68 (\18\:qbint VSS) capacitor c=3.60495e-17
C69 (\24\:qbint VSS) capacitor c=2.59535e-17
C70 (\11\:n30 VSS) capacitor c=6.02077e-17
C71 (\9\:mout VSS) capacitor c=6.17745e-17
C72 (\7\:n20 VSS) capacitor c=7.35577e-17
C73 (\7\:Db VSS) capacitor c=9.40353e-17
C74 (\14\:CKbb VSS) capacitor c=2.62545e-17
C75 (\9\:CKb VSS) capacitor c=1.77787e-17
C76 (\2\:mout VSS) capacitor c=2.86064e-17
C77 (\4\:CKb VSS) capacitor c=5.76628e-17
C78 (\8\:qbint VSS) capacitor c=4.39747e-17
C79 (\11\:CKb VSS) capacitor c=7.3962e-17
C80 (\14\:CKb VSS) capacitor c=3.7828e-17
C81 (\6\:n20 VSS) capacitor c=1.08133e-16
C82 (\9\:n20 VSS) capacitor c=9.79031e-17
C83 (\7\:mout VSS) capacitor c=5.16526e-17
C84 (\8\:mout VSS) capacitor c=6.25032e-17
C85 (\9\:CKbb VSS) capacitor c=6.71152e-17
C86 (\10\:CKbb VSS) capacitor c=1.35125e-16
C87 (\11\:CKbb VSS) capacitor c=1.04609e-16
C88 (\12\:CKbb VSS) capacitor c=7.31424e-17
C89 (\13\:CKbb VSS) capacitor c=1.07134e-16
C90 (\16\:CKbb VSS) capacitor c=6.104e-17
C91 (\17\:CKbb VSS) capacitor c=7.01146e-17
C92 (\5\:Q VSS) capacitor c=2.39857e-16
C93 (\10\:n30 VSS) capacitor c=2.19514e-16
C94 (\20\:qbint VSS) capacitor c=3.6119e-17
C95 (\21\:qbint VSS) capacitor c=5.94558e-17
C96 (\22\:qbint VSS) capacitor c=5.99001e-17
C97 (\23\:qbint VSS) capacitor c=7.10732e-17
C98 (\8\:E VSS) capacitor c=9.06115e-17
C99 (\9\:E VSS) capacitor c=1.27493e-16
C100 (\10\:E VSS) capacitor c=1.17197e-16
C101 (\11\:E VSS) capacitor c=3.28188e-17
C102 (\8\:Eb VSS) capacitor c=9.30341e-17
C103 (\5\:VDD VSS) capacitor c=2.01833e-16
C104 (\18\:VDD VSS) capacitor c=4.84287e-17
C105 (\22\:VDD VSS) capacitor c=2.24428e-17
Rk40 (E \8\:E) resistor r=0.02329 c=0
Rk41 (\8\:E \9\:E) resistor r=0.4346 c=0
Rk42 (\9\:E \10\:E) resistor r=0.8663 c=0
Rk43 (\9\:E \11\:E) resistor r=0.1053 c=0
Rk39 (\4\:D D) resistor r=0.003678 c=0
Rk20 (\1\:Q Q) resistor r=0.0613 c=0
Rk21 (Q \5\:Q) resistor r=0.1831 c=0
Rk46 (\2\:VDD \4\:VDD) resistor r=0.3344 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.5589 c=0
Rk56 (\5\:VDD \18\:VDD) resistor r=0.5762 c=0
Rk57 (\18\:VDD \20\:VDD) resistor r=0.2671 c=0
Rk58 (\18\:VDD \21\:VDD) resistor r=0.2906 c=0
Rk61 (\22\:VDD VDD) resistor r=0.1475 c=0
Rk59 (\21\:VDD \22\:VDD) resistor r=0.4034 c=0
Rk60 (\22\:VDD \24\:VDD) resistor r=0.07369 c=0
Rk62 (\2\:VSS \4\:VSS) resistor r=0.2737 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.436 c=0
Rk68 (\5\:VSS \10\:VSS) resistor r=0.506 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.2605 c=0
Rk71 (\12\:VSS VSS) resistor r=0.16 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.3909 c=0
Rk76 (\10\:VSS \22\:VSS) resistor r=0.1357 c=0
Rk77 (\12\:VSS \24\:VSS) resistor r=0.319 c=0
Rk1 (\4\:CK CK) resistor r=0.002999 c=0
Rk2 (\10\:CKb \11\:CKb) resistor r=0.097 c=0
Rk3 (\11\:CKb \13\:CKb) resistor r=0.5979 c=0
Rk4 (\11\:CKb \14\:CKb) resistor r=0.2103 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.3005 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.8339 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2837 c=0
Rk14 (\12\:CKbb \13\:CKbb) resistor r=0.2959 c=0
Rk15 (\13\:CKbb \15\:CKbb) resistor r=0.02467 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.2281 c=0
Rk17 (\12\:CKbb \17\:CKbb) resistor r=0.3608 c=0
Rk18 (\13\:CKbb \19\:CKbb) resistor r=0.6204 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.3034 c=0
Rk7 (\6\:n20 \9\:n20) resistor r=0.6257 c=0
Rk36 (\2\:Db \4\:Db) resistor r=0.5355 c=0
Rk37 (\4\:Db \6\:Db) resistor r=3.306 c=0
Rk38 (\6\:Db \8\:Db) resistor r=0.5391 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.127 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.228 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2916 c=0
Rk25 (n30 \10\:n30) resistor r=1.6488 c=0
Rk26 (\10\:n30 \12\:n30) resistor r=0.2699 c=0
Rk28 (\10\:n30 \15\:n30) resistor r=0.4527 c=0
Rk29 (\19\:qbint \20\:qbint) resistor r=0.1927 c=0
Rk30 (\20\:qbint \21\:qbint) resistor r=0.3329 c=0
Rk31 (\21\:qbint \22\:qbint) resistor r=0.2351 c=0
Rk32 (\22\:qbint \23\:qbint) resistor r=0.3953 c=0
Rk33 (\20\:qbint \25\:qbint) resistor r=0.08277 c=0
Rk34 (\21\:qbint \27\:qbint) resistor r=0.309 c=0
Rk35 (\22\:qbint \29\:qbint) resistor r=0.05443 c=0
Rk44 (\5\:Eb \7\:Eb) resistor r=0.5406 c=0
Rk45 (\7\:Eb \8\:Eb) resistor r=0.5895 c=0
Rl46 (\5\:E \6\:E) resistor r=110.307 c=0
Rl47 (\6\:E \7\:E) resistor r=29.5379 c=0
Rl41 (\3\:E \4\:E) resistor r=35.7713 c=0
Rl40 (\1\:E \2\:E) resistor r=30.2349 c=0
Rl44 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl45 (\2\:D \3\:D) resistor r=110.771 c=0
Rl2 (\2\:CK \3\:CK) resistor r=74.1758 c=0
Rl1 (\1\:CK \2\:CK) resistor r=167.308 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=528.412 c=0
Rl11 (CKb \2\:CKb) resistor r=185.67 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=201.384 c=0
Rl16 (\5\:CKb \7\:CKb) resistor r=31.8672 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=222.62 c=0
Rl15 (\4\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=167.982 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=53.3118 c=0
Rl8 (n20 \2\:n20) resistor r=98.7687 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=128.126 c=0
Rl5 (mout \2\:mout) resistor r=6.7128 c=0
Rl34 (\8\:qbint \17\:qbint) resistor r=109.439 c=0
Rl25 (\8\:qbint qbint) resistor r=124.455 c=0
Rl26 (\8\:qbint \9\:qbint) resistor r=46.5644 c=0
Rl42 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl43 (\2\:Eb \3\:Eb) resistor r=162.581 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz14 (\5\:VDD \3\:VDD) resistor r=6.25 c=0
Rz15 (\21\:VDD \3\:VDD) resistor r=6.25 c=0
Rz16 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz21 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz8 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz9 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz12 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry21 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry11 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry8 (\27\:qbint \26\:qbint) resistor r=62 c=0
Ry9 (\29\:qbint \28\:qbint) resistor r=62 c=0
Ry12 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx13 (\6\:E \8\:E) resistor r=45 c=0
Rx14 (\2\:E \10\:E) resistor r=45 c=0
Rx15 (\4\:E \11\:E) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx11 (\23\:qbint qbint) resistor r=45 c=0
Rx16 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\9\:CKb \1\:CK \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\14\:CKbb \7\:CKb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn0 (\4\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.685e-14 ad=3.263e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04793e-06 sb=2.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn25 (\7\:n20 \6\:CKb \7\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=8.713e-14 ps=6.9e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=8.713e-14 ps=5.3e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn35 (net340 \3\:mout \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.415e-14 ad=1.23e-14 ps=1.54e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn30 (\9\:mout \3\:n20 \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.415e-14 ad=5.638e-14 ps=1.54e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn40 (\9\:mout \5\:CKbb \11\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.023e-14 ad=5.638e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.96756e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn51 (\11\:n30 CKb net380 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.023e-14 ps=5.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=1.91805e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn50 (net380 \9\:qbint \5\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.23e-14 ps=1.13e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.785e-06 sb=1.87524e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn45_1__rcx (\24\:qbint n30 \5\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.646e-14 ad=3.28e-14 ps=1.26e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.90012e-06 sb=3.05e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn1 (\18\:qbint \3\:Eb Db VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=5.18e-14 ps=9.7e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.99231e-07 sb=7.82692e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=5.85e-14 ps=6.4e-07 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.69231e-07 sb=5.12692e-07 sd=160n sca=8.81533 scb=0.00706435 \
        scc=0.000179997 m=(1)
mn2 (net333 \3\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.685e-14 ad=1.56e-14 ps=1.22e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.74231e-07 sb=4.07692e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn55_1__rcx (\5\:Q qbint \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.261e-14 ad=7.93e-14 ps=1.045e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.5026e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp35 (net309 \4\:mout \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=9.3e-14 ps=1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp30 (\5\:mout n20 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.209e-13 ps=1e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp40 (\5\:mout \2\:CKb \14\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.209e-13 ps=9.4e-07 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp51 (\14\:n30 \7\:CKbb net317 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=1.87e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp50 (net317 \17\:qbint \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.471e-13 ad=1.86e-14 ps=1.77e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=1.765e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp45_1__rcx (\28\:qbint n30 \5\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.838e-14 ad=4.96e-14 ps=1.585e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.75e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(2)
mp1 (\26\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=5.46e-14 ps=1.2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.92756e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=5.37756e-07 sd=160n sca=18.4282 \
        scb=0.0159986 scc=0.00159615 m=(1)
mp2 (net328 \1\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.975e-14 ad=5.265e-14 ps=1.48e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.57756e-07 sd=160n sca=18.9201 \
        scb=0.0161836 scc=0.00159622 m=(1)
mp55 (\1\:Q qbint \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1359e-13 ad=6.24e-14 ps=1.57e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62462e-06 sb=1.23051e-06 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(4)
ends EDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:08 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFHQX8
// View name: extracted

simulator lang=spectre

subckt EDFFHQX8 CK D E Q VDD VSS
mp20 (\11\:CKb \3\:CK \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.0805 \
        scb=0.0206115 scc=0.000620106 m=(1)
mp21 (\15\:CKbb \8\:CKb \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.019 \
        scb=0.0104631 scc=0.000112651 m=(1)
mp0 (\6\:Eb \5\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=1.4e-07 sd=160n sca=25.493 \
        scb=0.0240811 scc=0.00243861 m=(1)
C1 (E VSS) capacitor c=5.12225e-17
C2 (Q VSS) capacitor c=1.21005e-17
C3 (D VSS) capacitor c=1.09778e-16
C4 (VDD VSS) capacitor c=3.51075e-16
C5 (CK VSS) capacitor c=8.44313e-17
C6 (CKb VSS) capacitor c=1.0045e-16
C7 (CKbb VSS) capacitor c=3.52697e-17
C8 (n20 VSS) capacitor c=5.04646e-17
C9 (Db VSS) capacitor c=1.11617e-16
C10 (net340 VSS) capacitor c=1.12663e-18
C11 (mout VSS) capacitor c=2.49985e-17
C12 (n30 VSS) capacitor c=2.18319e-16
C13 (qbint VSS) capacitor c=3.62313e-16
C14 (Eb VSS) capacitor c=4.23157e-17
C15 (net333 VSS) capacitor c=2.2582e-18
C16 (net309 VSS) capacitor c=3.62675e-18
C17 (net317 VSS) capacitor c=5.90399e-18
C18 (net328 VSS) capacitor c=4.72477e-18
C19 (\5\:E VSS) capacitor c=4.65216e-17
C20 (\3\:D VSS) capacitor c=5.49285e-17
C21 (\1\:E VSS) capacitor c=4.40492e-17
C22 (\29\:qbint VSS) capacitor c=4.42486e-17
C23 (\7\:CKbb VSS) capacitor c=5.76921e-17
C24 (\2\:CKb VSS) capacitor c=1.16743e-16
C25 (\4\:mout VSS) capacitor c=4.5096e-17
C26 (\3\:CKb VSS) capacitor c=1.34352e-16
C27 (\8\:CKb VSS) capacitor c=5.65424e-17
C28 (\3\:CK VSS) capacitor c=4.73391e-17
C29 (\7\:E VSS) capacitor c=3.28584e-17
C30 (\1\:D VSS) capacitor c=8.5406e-17
C31 (\3\:E VSS) capacitor c=6.52682e-17
C32 (\3\:Eb VSS) capacitor c=5.88807e-17
C33 (\15\:qbint VSS) capacitor c=6.25816e-17
C34 (\5\:CKbb VSS) capacitor c=3.10049e-17
C35 (\3\:n20 VSS) capacitor c=3.23819e-17
C36 (\3\:mout VSS) capacitor c=6.11827e-17
C37 (\3\:CKbb VSS) capacitor c=4.62681e-17
C38 (\6\:CKb VSS) capacitor c=2.44226e-17
C39 (\7\:CKb VSS) capacitor c=2.23479e-17
C40 (\1\:CK VSS) capacitor c=3.99285e-17
C41 (\6\:E VSS) capacitor c=3.50289e-17
C42 (\2\:D VSS) capacitor c=5.49783e-17
C43 (\4\:E VSS) capacitor c=4.56538e-17
C44 (\2\:Eb VSS) capacitor c=5.15256e-17
C45 (\2\:E VSS) capacitor c=3.15244e-17
C46 (\7\:n30 VSS) capacitor c=1.48916e-17
C47 (\8\:CKbb VSS) capacitor c=5.32254e-17
C48 (\6\:CKbb VSS) capacitor c=3.6641e-17
C49 (\2\:n20 VSS) capacitor c=3.02111e-17
C50 (\4\:CKbb VSS) capacitor c=3.74055e-17
C51 (\2\:CKbb VSS) capacitor c=4.55957e-17
C52 (\5\:CKb VSS) capacitor c=5.71465e-17
C53 (\2\:CK VSS) capacitor c=5.24937e-17
C54 (\6\:Eb VSS) capacitor c=1.18347e-16
C55 (\1\:VDD VSS) capacitor c=2.66852e-17
C56 (\3\:Db VSS) capacitor c=5.14783e-16
C57 (\30\:qbint VSS) capacitor c=1.13568e-16
C58 (\9\:Q VSS) capacitor c=2.62241e-16
C59 (\15\:n30 VSS) capacitor c=8.56554e-17
C60 (\5\:mout VSS) capacitor c=3.78249e-17
C61 (\24\:VDD VSS) capacitor c=5.47569e-17
C62 (\4\:n20 VSS) capacitor c=3.40688e-17
C63 (\5\:Db VSS) capacitor c=4.68006e-16
C64 (\15\:CKbb VSS) capacitor c=7.80976e-17
C65 (\28\:VDD VSS) capacitor c=3.5399e-17
C66 (\11\:CKb VSS) capacitor c=6.86501e-17
C67 (\3\:VDD VSS) capacitor c=7.75465e-17
C68 (\4\:Eb VSS) capacitor c=8.90281e-17
C69 (\35\:qbint VSS) capacitor c=9.2941e-17
C70 (\1\:Q VSS) capacitor c=2.70506e-16
C71 (\17\:n30 VSS) capacitor c=5.7878e-17
C72 (\9\:mout VSS) capacitor c=6.4818e-17
C73 (\7\:n20 VSS) capacitor c=7.74941e-17
C74 (\7\:Db VSS) capacitor c=9.08777e-17
C75 (\13\:CKbb VSS) capacitor c=1.10934e-16
C76 (\13\:CKb VSS) capacitor c=1.8644e-17
C77 (\2\:mout VSS) capacitor c=2.82037e-17
C78 (\4\:CKb VSS) capacitor c=5.68833e-17
C79 (\14\:qbint VSS) capacitor c=3.04518e-17
C80 (\4\:CK VSS) capacitor c=2.78583e-17
C81 (\9\:CKb VSS) capacitor c=3.97286e-17
C82 (\10\:CKb VSS) capacitor c=6.83956e-17
C83 (\6\:n20 VSS) capacitor c=9.55536e-17
C84 (\9\:n20 VSS) capacitor c=9.63186e-17
C85 (\7\:mout VSS) capacitor c=3.99299e-17
C86 (\8\:mout VSS) capacitor c=6.4372e-17
C87 (\9\:CKbb VSS) capacitor c=5.23388e-17
C88 (\10\:CKbb VSS) capacitor c=1.27722e-16
C89 (\11\:CKbb VSS) capacitor c=1.16042e-16
C90 (\12\:CKbb VSS) capacitor c=7.16989e-17
C91 (\17\:CKbb VSS) capacitor c=5.90301e-17
C92 (\18\:CKbb VSS) capacitor c=8.60953e-17
C93 (\13\:n30 VSS) capacitor c=2.27233e-16
C94 (\14\:n30 VSS) capacitor c=2.45172e-16
C95 (\34\:qbint VSS) capacitor c=8.26384e-17
C96 (\37\:qbint VSS) capacitor c=1.04026e-16
C97 (\8\:E VSS) capacitor c=2.97943e-17
C98 (\9\:E VSS) capacitor c=1.07285e-16
C99 (\10\:E VSS) capacitor c=1.20123e-16
C100 (\11\:E VSS) capacitor c=5.06495e-17
C101 (\4\:D VSS) capacitor c=4.36769e-17
C102 (\8\:Eb VSS) capacitor c=8.12321e-17
C103 (\5\:VDD VSS) capacitor c=1.02309e-16
C104 (\7\:VDD VSS) capacitor c=1.96469e-16
C105 (\23\:VDD VSS) capacitor c=3.93404e-17
C106 (\27\:VDD VSS) capacitor c=2.3371e-17
Rk39 (\8\:E \9\:E) resistor r=0.07408 c=0
Rk40 (\9\:E \10\:E) resistor r=0.8672 c=0
Rk42 (\11\:E E) resistor r=0.1102 c=0
Rk41 (\9\:E \11\:E) resistor r=0.1796 c=0
Rk24 (Q \9\:Q) resistor r=0.079 c=0
Rk23 (\1\:Q Q) resistor r=0.1749 c=0
Rk43 (D \4\:D) resistor r=0.09326 c=0
Rk66 (\2\:VDD \4\:VDD) resistor r=0.4589 c=0
Rk67 (\4\:VDD \5\:VDD) resistor r=0.258 c=0
Rk69 (\5\:VDD \7\:VDD) resistor r=0.3832 c=0
Rk79 (\7\:VDD \23\:VDD) resistor r=0.5762 c=0
Rk80 (\23\:VDD \25\:VDD) resistor r=0.3119 c=0
Rk81 (\23\:VDD \26\:VDD) resistor r=0.2355 c=0
Rk84 (\27\:VDD VDD) resistor r=0.1324 c=0
Rk82 (\26\:VDD \27\:VDD) resistor r=0.4185 c=0
Rk83 (\27\:VDD \29\:VDD) resistor r=0.1781 c=0
Rk46 (\2\:VSS \4\:VSS) resistor r=0.5247 c=0
Rk47 (\4\:VSS \5\:VSS) resistor r=0.2856 c=0
Rk49 (\5\:VSS \7\:VSS) resistor r=0.307 c=0
Rk54 (\7\:VSS \12\:VSS) resistor r=0.506 c=0
Rk55 (\12\:VSS \13\:VSS) resistor r=0.2655 c=0
Rk57 (\14\:VSS VSS) resistor r=0.1374 c=0
Rk56 (\13\:VSS \14\:VSS) resistor r=0.4135 c=0
Rk64 (\12\:VSS \28\:VSS) resistor r=0.1224 c=0
Rk65 (\14\:VSS \30\:VSS) resistor r=0.282 c=0
Rk3 (\4\:CK CK) resistor r=0.02099 c=0
Rk4 (\9\:CKb \10\:CKb) resistor r=0.2077 c=0
Rk5 (\10\:CKb \12\:CKb) resistor r=0.6501 c=0
Rk6 (\10\:CKb \14\:CKb) resistor r=0.1003 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.2151 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.9794 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.3432 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.3187 c=0
Rk17 (\14\:CKbb \16\:CKbb) resistor r=0.6636 c=0
Rk18 (\11\:CKbb \17\:CKbb) resistor r=0.1963 c=0
Rk19 (\12\:CKbb \18\:CKbb) resistor r=0.3724 c=0
Rk7 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk8 (\6\:n20 \8\:n20) resistor r=0.2775 c=0
Rk9 (\6\:n20 \9\:n20) resistor r=0.5876 c=0
Rk36 (\2\:Db \4\:Db) resistor r=0.5488 c=0
Rk37 (\4\:Db \6\:Db) resistor r=3.8624 c=0
Rk38 (\6\:Db \8\:Db) resistor r=0.577 c=0
Rk10 (\6\:mout \7\:mout) resistor r=0.1196 c=0
Rk11 (\7\:mout \8\:mout) resistor r=0.2225 c=0
Rk12 (\7\:mout \10\:mout) resistor r=0.2651 c=0
Rk28 (\13\:n30 \14\:n30) resistor r=1.8864 c=0
Rk29 (\14\:n30 \16\:n30) resistor r=0.4033 c=0
Rk30 (\14\:n30 \18\:n30) resistor r=0.2699 c=0
Rk32 (\30\:qbint \34\:qbint) resistor r=0.1424 c=0
Rk33 (\34\:qbint \35\:qbint) resistor r=0.234 c=0
Rk34 (\34\:qbint \37\:qbint) resistor r=0.7268 c=0
Rk44 (\5\:Eb \7\:Eb) resistor r=0.7303 c=0
Rk45 (\7\:Eb \8\:Eb) resistor r=0.466 c=0
Rl64 (\5\:E \6\:E) resistor r=94.9225 c=0
Rl65 (\6\:E \7\:E) resistor r=39.1533 c=0
Rl61 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl58 (\1\:E \2\:E) resistor r=37.2302 c=0
Rl63 (\2\:D \3\:D) resistor r=33.8972 c=0
Rl62 (\1\:D \2\:D) resistor r=86.3335 c=0
Rl2 (\2\:CK \3\:CK) resistor r=154.944 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.1749 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=532.258 c=0
Rl11 (CKb \2\:CKb) resistor r=195.353 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=228.021 c=0
Rl16 (\5\:CKb \7\:CKb) resistor r=27.116 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=245.697 c=0
Rl15 (\4\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=168.304 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=49.2328 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=50.6918 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=53.3118 c=0
Rl8 (n20 \2\:n20) resistor r=100 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.9451 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=99.7141 c=0
Rl5 (mout \2\:mout) resistor r=16.2873 c=0
Rl52 (n30 \7\:n30) resistor r=9.3321 c=0
Rl46 (\14\:qbint \29\:qbint) resistor r=62.6951 c=0
Rl31 (\14\:qbint qbint) resistor r=82.3745 c=0
Rl32 (\14\:qbint \15\:qbint) resistor r=100.722 c=0
Rl59 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl60 (\2\:Eb \3\:Eb) resistor r=122.197 c=0
Rz24 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz25 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz26 (\26\:VDD \3\:VDD) resistor r=6.25 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz22 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz23 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz1 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz9 (\18\:n30 \17\:n30) resistor r=75 c=0
Rz14 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry25 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry26 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry15 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry16 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry13 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:n30 \15\:n30) resistor r=62 c=0
Ry14 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx11 (\4\:E \8\:E) resistor r=45 c=0
Rx12 (\2\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\5\:CKb \9\:CKb) resistor r=45 c=0
Rx5 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\13\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\37\:qbint qbint) resistor r=45 c=0
Rx15 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\13\:CKb \1\:CK \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn21 (\13\:CKbb \7\:CKb \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn0 (\4\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\7\:n20 \6\:CKb \7\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=9.225e-14 ps=6.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.947e-14 ad=9.225e-14 ps=6e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn35 (net340 \3\:mout \27\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=1.948e-14 ps=1.32e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn30 (\9\:mout \3\:n20 \27\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.585e-14 ad=7.79e-14 ps=1.32e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn40 (\9\:mout \5\:CKbb \17\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.1e-14 ad=7.79e-14 ps=8.1e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn51 (\17\:n30 CKb net380 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.1e-14 ps=5.3e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.975e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn50 (net380 \15\:qbint \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.538e-14 ad=1.23e-14 ps=1.14e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.87e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn55_1__rcx (\1\:Q qbint \7\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=9.428e-14 ad=4.636e-14 ps=1.53429e-06 pd=9.0429e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.42034e-06 sb=1.55e-06 sd=160n \
        sca=16.4223 scb=0.0158966 scc=0.0014413 m=(7)
mn1 (\35\:qbint \3\:Eb Db VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=1.04e-13 ps=9e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=5.82212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.23e-06 sb=3.47212e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (net333 \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn45_1__rcx (\35\:qbint n30 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=6.24e-14 ps=8.2667e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43721e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(3)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.96e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp35 (net309 \4\:mout \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=5.58e-14 ps=1.23e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp30 (\5\:mout n20 \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=1.2555e-13 ps=1.23e-06 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp40 (\5\:mout \2\:CKb \15\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.2555e-13 ps=9.4e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.955e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp51 (\15\:n30 \7\:CKbb net317 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.96e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=1.75e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp50 (net317 \29\:qbint \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.62e-14 ad=3.1e-14 ps=1.27e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.605e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp55_1__rcx (\9\:Q qbint \7\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.191e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.40079e-06 sb=1.37e-06 sd=160n \
        sca=20.7359 scb=0.0165012 scc=0.00199728 m=(7)
mp1 (\30\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=7.14551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=8.19e-14 ps=1.07e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=4.59551e-07 sd=160n sca=17.3844 \
        scb=0.0153023 scc=0.00137893 m=(1)
mp2 (net328 \3\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=2.69551e-07 sd=160n sca=18.003 \
        scb=0.0156068 scc=0.00137911 m=(1)
mp45 (\30\:qbint n30 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.53e-14 ad=6.24e-14 ps=1.28667e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.38955e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(3)
ends EDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:09 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFTRX1
// View name: extracted

simulator lang=spectre

subckt EDFFTRX1 CK D E Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.4e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0705e-13 ad=5.15e-14 ps=1.72e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32051e-07 sb=3.32628e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
C1 (D VSS) capacitor c=7.52345e-17
C2 (Q VSS) capacitor c=7.63403e-17
C3 (CK VSS) capacitor c=7.18253e-17
C4 (VDD VSS) capacitor c=4.24913e-16
C5 (RN VSS) capacitor c=8.38429e-17
C6 (QN VSS) capacitor c=2.29663e-17
C7 (qint VSS) capacitor c=2.13499e-17
C8 (qbint VSS) capacitor c=2.49912e-17
C9 (CKb VSS) capacitor c=8.93696e-17
C10 (n30 VSS) capacitor c=3.7354e-17
C11 (net496 VSS) capacitor c=4.27757e-20
C12 (mout VSS) capacitor c=5.67367e-17
C13 (CKbb VSS) capacitor c=3.13331e-17
C14 (n20 VSS) capacitor c=4.7926e-17
C15 (net516 VSS) capacitor c=7.19536e-19
C16 (Dp VSS) capacitor c=6.79073e-17
C17 (RNb VSS) capacitor c=4.49575e-17
C18 (Eb VSS) capacitor c=5.00907e-17
C19 (n1 VSS) capacitor c=1.37941e-18
C20 (Db VSS) capacitor c=9.72919e-17
C21 (net427 VSS) capacitor c=7.07753e-19
C22 (n2 VSS) capacitor c=8.7571e-17
C23 (n3 VSS) capacitor c=8.27516e-17
C24 (\1\:D VSS) capacitor c=3.1754e-17
C25 (\4\:E VSS) capacitor c=3.59273e-17
C26 (\2\:Db VSS) capacitor c=5.86694e-17
C27 (\3\:E VSS) capacitor c=4.01286e-17
C28 (\11\:qbint VSS) capacitor c=5.76828e-17
C29 (\3\:RNb VSS) capacitor c=6.15343e-17
C30 (\1\:RN VSS) capacitor c=3.94806e-17
C31 (\11\:CKb VSS) capacitor c=4.84147e-17
C32 (\5\:CKb VSS) capacitor c=6.07996e-17
C33 (\3\:mout VSS) capacitor c=8.05873e-17
C34 (\3\:n20 VSS) capacitor c=3.29938e-17
C35 (\3\:CKb VSS) capacitor c=3.78819e-17
C36 (\5\:CKbb VSS) capacitor c=9.99566e-17
C37 (\7\:qbint VSS) capacitor c=5.98182e-17
C38 (\1\:CK VSS) capacitor c=2.12646e-17
C39 (\6\:qbint VSS) capacitor c=3.29188e-17
C40 (\4\:qint VSS) capacitor c=4.72851e-17
C41 (\3\:D VSS) capacitor c=2.65469e-17
C42 (\7\:E VSS) capacitor c=2.69442e-17
C43 (\1\:E VSS) capacitor c=6.72256e-17
C44 (\3\:Eb VSS) capacitor c=5.25672e-17
C45 (\10\:qbint VSS) capacitor c=1.06031e-16
C46 (\3\:RN VSS) capacitor c=3.77277e-17
C47 (\9\:CKb VSS) capacitor c=3.1975e-17
C48 (\2\:Dp VSS) capacitor c=5.52307e-17
C49 (\7\:CKb VSS) capacitor c=4.90764e-17
C50 (\3\:CKbb VSS) capacitor c=1.15364e-16
C51 (\4\:CKbb VSS) capacitor c=1.22224e-16
C52 (\9\:qbint VSS) capacitor c=8.15574e-17
C53 (\3\:n30 VSS) capacitor c=3.41982e-17
C54 (\3\:CK VSS) capacitor c=3.09939e-17
C55 (\5\:qbint VSS) capacitor c=4.23922e-17
C56 (\4\:qbint VSS) capacitor c=2.86154e-17
C57 (\3\:qint VSS) capacitor c=3.7656e-17
C58 (\2\:D VSS) capacitor c=2.31343e-17
C59 (\6\:E VSS) capacitor c=3.69366e-17
C60 (\3\:Db VSS) capacitor c=2.17658e-17
C61 (\2\:E VSS) capacitor c=7.13751e-17
C62 (\2\:Eb VSS) capacitor c=5.01584e-17
C63 (\12\:qbint VSS) capacitor c=3.05769e-17
C64 (\2\:RNb VSS) capacitor c=6.14036e-17
C65 (\2\:RN VSS) capacitor c=3.94708e-17
C66 (\10\:CKb VSS) capacitor c=3.87431e-17
C67 (\3\:Dp VSS) capacitor c=2.74192e-17
C68 (\8\:CKb VSS) capacitor c=5.48584e-17
C69 (\2\:CKbb VSS) capacitor c=7.71828e-17
C70 (\6\:CKb VSS) capacitor c=5.35666e-17
C71 (\2\:mout VSS) capacitor c=6.43947e-17
C72 (\4\:CKb VSS) capacitor c=4.41774e-17
C73 (\2\:CKb VSS) capacitor c=3.57599e-17
C74 (\8\:qbint VSS) capacitor c=2.8035e-17
C75 (\2\:n30 VSS) capacitor c=2.21742e-17
C76 (\2\:CK VSS) capacitor c=2.78028e-17
C77 (\2\:qbint VSS) capacitor c=3.57411e-17
C78 (\4\:Db VSS) capacitor c=1.20661e-16
C79 (\1\:VDD VSS) capacitor c=4.27815e-17
C80 (\4\:Eb VSS) capacitor c=4.04364e-17
C81 (\13\:Dp VSS) capacitor c=8.29391e-17
C82 (\3\:n3 VSS) capacitor c=8.49472e-17
C83 (\11\:Dp VSS) capacitor c=2.87487e-17
C84 (\3\:n2 VSS) capacitor c=7.23379e-17
C85 (\11\:VDD VSS) capacitor c=1.47061e-17
C86 (\6\:RNb VSS) capacitor c=4.63496e-17
C87 (\6\:CKbb VSS) capacitor c=3.31274e-17
C88 (\13\:VDD VSS) capacitor c=1.74449e-17
C89 (\5\:n20 VSS) capacitor c=1.84632e-17
C90 (\15\:VDD VSS) capacitor c=1.27987e-17
C91 (\8\:mout VSS) capacitor c=3.91829e-17
C92 (\8\:n30 VSS) capacitor c=4.21766e-17
C93 (\17\:VDD VSS) capacitor c=7.8639e-17
C94 (\16\:qbint VSS) capacitor c=9.21781e-17
C95 (\19\:CKb VSS) capacitor c=6.62446e-17
C96 (\19\:VDD VSS) capacitor c=3.12974e-17
C97 (\1\:Q VSS) capacitor c=5.3205e-17
C98 (\5\:qint VSS) capacitor c=2.54911e-17
C99 (\22\:VDD VSS) capacitor c=1.75742e-17
C100 (\1\:QN VSS) capacitor c=3.57749e-17
C101 (\3\:VDD VSS) capacitor c=9.89437e-17
C102 (\7\:Db VSS) capacitor c=3.3091e-17
C103 (\8\:Eb VSS) capacitor c=1.14929e-16
C104 (\4\:Dp VSS) capacitor c=1.05398e-16
C105 (\8\:Dp VSS) capacitor c=2.53495e-17
C106 (\8\:RNb VSS) capacitor c=4.7946e-17
C107 (\10\:CKbb VSS) capacitor c=4.15466e-17
C108 (\9\:n20 VSS) capacitor c=8.52921e-17
C109 (\6\:mout VSS) capacitor c=4.62858e-17
C110 (\6\:n30 VSS) capacitor c=5.75595e-17
C111 (\20\:qbint VSS) capacitor c=6.66264e-17
C112 (\17\:CKb VSS) capacitor c=1.44483e-16
C113 (\4\:Q VSS) capacitor c=2.13384e-17
C114 (\9\:qint VSS) capacitor c=2.74146e-17
C115 (\3\:QN VSS) capacitor c=2.71271e-17
C116 (\2\:qint VSS) capacitor c=7.89869e-18
C117 (\3\:qbint VSS) capacitor c=3.41223e-17
C118 (\2\:n20 VSS) capacitor c=3.95531e-17
C119 (\7\:qint VSS) capacitor c=2.81958e-17
C120 (\8\:qint VSS) capacitor c=1.972e-17
C121 (\4\:CK VSS) capacitor c=5.56118e-17
C122 (\5\:E VSS) capacitor c=2.29658e-17
C123 (\4\:n30 VSS) capacitor c=6.64004e-17
C124 (\5\:n30 VSS) capacitor c=6.40386e-17
C125 (\4\:mout VSS) capacitor c=5.65719e-17
C126 (\5\:mout VSS) capacitor c=5.91103e-17
C127 (\7\:n20 VSS) capacitor c=6.07806e-17
C128 (\8\:n20 VSS) capacitor c=7.04273e-17
C129 (\12\:CKb VSS) capacitor c=4.4046e-17
C130 (\13\:CKb VSS) capacitor c=1.09462e-16
C131 (\14\:CKb VSS) capacitor c=1.55131e-16
C132 (\15\:CKb VSS) capacitor c=1.02612e-16
C133 (\16\:CKb VSS) capacitor c=1.88572e-16
C134 (\21\:CKb VSS) capacitor c=4.84196e-17
C135 (\22\:CKb VSS) capacitor c=6.98299e-17
C136 (\8\:CKbb VSS) capacitor c=6.07125e-17
C137 (\9\:CKbb VSS) capacitor c=7.17699e-17
C138 (\4\:RN VSS) capacitor c=2.98768e-17
C139 (\4\:RNb VSS) capacitor c=5.97389e-17
C140 (\5\:RNb VSS) capacitor c=5.62332e-17
C141 (\13\:qbint VSS) capacitor c=2.00567e-16
C142 (\15\:qbint VSS) capacitor c=8.37726e-17
C143 (\18\:qbint VSS) capacitor c=1.63643e-16
C144 (\19\:qbint VSS) capacitor c=2.54358e-16
C145 (\6\:Dp VSS) capacitor c=2.86028e-16
C146 (\7\:Dp VSS) capacitor c=1.59147e-16
C147 (\10\:Dp VSS) capacitor c=1.26257e-16
C148 (\8\:E VSS) capacitor c=7.41641e-17
C149 (\9\:E VSS) capacitor c=7.56673e-17
C150 (\7\:Eb VSS) capacitor c=1.60652e-16
C151 (\4\:D VSS) capacitor c=3.79498e-17
C152 (\6\:Db VSS) capacitor c=9.98641e-17
C153 (\5\:VDD VSS) capacitor c=4.61343e-17
C154 (\6\:VDD VSS) capacitor c=2.42672e-17
C155 (\8\:VDD VSS) capacitor c=3.53237e-17
C156 (\9\:VDD VSS) capacitor c=3.9628e-17
C157 (\21\:VDD VSS) capacitor c=1.17535e-17
Rk53 (\4\:D D) resistor r=0.1309 c=0
Rk7 (\3\:Q Q) resistor r=0.02419 c=0
Rk6 (\2\:Q \3\:Q) resistor r=0.4387 c=0
Rk8 (\3\:Q \5\:Q) resistor r=0.179 c=0
Rk9 (CK \4\:CK) resistor r=0.1694 c=0
Rk48 (\8\:E E) resistor r=0.245 c=0
Rk49 (E \9\:E) resistor r=0.002376 c=0
Rk71 (\2\:VSS \4\:VSS) resistor r=0.7607 c=0
Rk72 (\4\:VSS \5\:VSS) resistor r=0.1352 c=0
Rk73 (\5\:VSS \6\:VSS) resistor r=0.1274 c=0
Rk74 (\6\:VSS \7\:VSS) resistor r=0.2277 c=0
Rk75 (\7\:VSS \8\:VSS) resistor r=0.4849 c=0
Rk76 (\8\:VSS \9\:VSS) resistor r=0.2244 c=0
Rk77 (\9\:VSS \10\:VSS) resistor r=0.2505 c=0
Rk78 (\10\:VSS \11\:VSS) resistor r=0.5109 c=0
Rk79 (\11\:VSS \12\:VSS) resistor r=0.441 c=0
Rk80 (\5\:VSS \14\:VSS) resistor r=0.202 c=0
Rk81 (\6\:VSS \16\:VSS) resistor r=0.202 c=0
Rk82 (\7\:VSS \18\:VSS) resistor r=0.2125 c=0
Rk83 (\8\:VSS \20\:VSS) resistor r=0.04328 c=0
Rk84 (\10\:VSS \22\:VSS) resistor r=0.2544 c=0
Rk85 (\11\:VSS \24\:VSS) resistor r=0.3404 c=0
Rk87 (\25\:VSS VSS) resistor r=0.2151 c=0
Rk86 (\12\:VSS \25\:VSS) resistor r=0.3361 c=0
Rk88 (\12\:VSS \27\:VSS) resistor r=0.401 c=0
Rk89 (\25\:VSS \29\:VSS) resistor r=0.07358 c=0
Rk56 (\2\:VDD \4\:VDD) resistor r=0.5762 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.5688 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.4633 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.1703 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.278 c=0
Rk61 (\8\:VDD \9\:VDD) resistor r=0.526 c=0
Rk62 (\9\:VDD \10\:VDD) resistor r=0.3983 c=0
Rk63 (\5\:VDD \12\:VDD) resistor r=0.07358 c=0
Rk64 (\6\:VDD \14\:VDD) resistor r=0.1022 c=0
Rk65 (\8\:VDD \16\:VDD) resistor r=0.07358 c=0
Rk66 (\9\:VDD \18\:VDD) resistor r=0.3694 c=0
Rk67 (\10\:VDD \20\:VDD) resistor r=0.175 c=0
Rk70 (\21\:VDD VDD) resistor r=0.2151 c=0
Rk68 (\10\:VDD \21\:VDD) resistor r=0.3361 c=0
Rk69 (\21\:VDD \23\:VDD) resistor r=0.2233 c=0
Rk30 (\4\:RN RN) resistor r=0.07165 c=0
Rk2 (\4\:QN QN) resistor r=0.09283 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3053 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1296 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1192 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.0936 c=0
Rk34 (\13\:qbint \14\:qbint) resistor r=1.9974 c=0
Rk35 (\14\:qbint \15\:qbint) resistor r=0.5272 c=0
Rk36 (\15\:qbint \17\:qbint) resistor r=0.05765 c=0
Rk37 (\17\:qbint \18\:qbint) resistor r=1.0114 c=0
Rk38 (\14\:qbint \19\:qbint) resistor r=0.04612 c=0
Rk39 (\15\:qbint \21\:qbint) resistor r=0.3747 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.2736 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.6521 c=0
Rk21 (\14\:CKb \15\:CKb) resistor r=0.6405 c=0
Rk22 (\15\:CKb \16\:CKb) resistor r=0.1789 c=0
Rk23 (\16\:CKb \18\:CKb) resistor r=1.201 c=0
Rk24 (\18\:CKb \20\:CKb) resistor r=0.3632 c=0
Rk25 (\14\:CKb \21\:CKb) resistor r=0.21 c=0
Rk26 (\15\:CKb \22\:CKb) resistor r=0.3497 c=0
Rk10 (\4\:n30 \5\:n30) resistor r=0.314 c=0
Rk11 (\5\:n30 \7\:n30) resistor r=0.2323 c=0
Rk12 (\5\:n30 \9\:n30) resistor r=0.1882 c=0
Rk13 (\4\:mout \5\:mout) resistor r=0.2539 c=0
Rk14 (\5\:mout \7\:mout) resistor r=0.1504 c=0
Rk15 (\5\:mout \9\:mout) resistor r=0.2658 c=0
Rk27 (\7\:CKbb \8\:CKbb) resistor r=0.1404 c=0
Rk28 (\8\:CKbb \9\:CKbb) resistor r=0.4133 c=0
Rk29 (\8\:CKbb \11\:CKbb) resistor r=0.2357 c=0
Rk16 (\6\:n20 \7\:n20) resistor r=0.05734 c=0
Rk17 (\7\:n20 \8\:n20) resistor r=0.415 c=0
Rk18 (\7\:n20 \10\:n20) resistor r=0.381 c=0
Rk42 (\5\:Dp \6\:Dp) resistor r=0.7338 c=0
Rk43 (\6\:Dp \7\:Dp) resistor r=1.3263 c=0
Rk44 (\6\:Dp \9\:Dp) resistor r=0.09158 c=0
Rk45 (\6\:Dp \10\:Dp) resistor r=0.7072 c=0
Rk46 (\10\:Dp \12\:Dp) resistor r=0.0496 c=0
Rk47 (\10\:Dp \14\:Dp) resistor r=0.3172 c=0
Rk31 (\4\:RNb \5\:RNb) resistor r=0.2715 c=0
Rk32 (\5\:RNb \7\:RNb) resistor r=0.2862 c=0
Rk33 (\5\:RNb \9\:RNb) resistor r=0.2124 c=0
Rk50 (\5\:Eb \6\:Eb) resistor r=0.2114 c=0
Rk51 (\6\:Eb \7\:Eb) resistor r=0.8562 c=0
Rk52 (\6\:Eb \9\:Eb) resistor r=0.0529 c=0
Rk54 (\5\:Db \6\:Db) resistor r=0.9098 c=0
Rk55 (\5\:Db \8\:Db) resistor r=0.2562 c=0
Rk40 (\2\:n2 \4\:n2) resistor r=0.3108 c=0
Rk41 (\2\:n3 \4\:n3) resistor r=0.4714 c=0
Rl47 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl48 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl9 (\1\:CK \2\:CK) resistor r=42.3077 c=0
Rl10 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl41 (\2\:E \3\:E) resistor r=63.4387 c=0
Rl40 (\1\:E \2\:E) resistor r=134.41 c=0
Rl44 (\4\:E \5\:E) resistor r=39.6181 c=0
Rl46 (\5\:E \7\:E) resistor r=49.2335 c=0
Rl45 (\5\:E \6\:E) resistor r=125.373 c=0
Rl32 (\1\:RN \2\:RN) resistor r=56.9251 c=0
Rl33 (\2\:RN \3\:RN) resistor r=137.694 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl36 (\10\:qbint \11\:qbint) resistor r=241.873 c=0
Rl14 (\7\:qbint \9\:qbint) resistor r=165.385 c=0
Rl37 (\11\:qbint \12\:qbint) resistor r=24.2328 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=35.7713 c=0
Rl4 (qbint \2\:qbint) resistor r=24.2328 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=53.079 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=47.3105 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=41.5412 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=167.299 c=0
Rl31 (\10\:CKb \11\:CKb) resistor r=103.079 c=0
Rl30 (\9\:CKb \10\:CKb) resistor r=57.2464 c=0
Rl27 (\7\:CKb \8\:CKb) resistor r=33.8482 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=62.6944 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=62.6944 c=0
Rl15 (CKb \2\:CKb) resistor r=43.4636 c=0
Rl11 (n30 \2\:n30) resistor r=24.2328 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=53.079 c=0
Rl21 (\2\:mout \3\:mout) resistor r=103.079 c=0
Rl20 (mout \2\:mout) resistor r=60.6695 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=201.054 c=0
Rl25 (\3\:CKbb \4\:CKbb) resistor r=459.181 c=0
Rl23 (CKbb \2\:CKbb) resistor r=41.5405 c=0
Rl24 (\2\:CKbb \3\:CKbb) resistor r=172.197 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=49.7185 c=0
Rl17 (n20 \2\:n20) resistor r=118.949 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=3.3229 c=0
Rl28 (Dp \2\:Dp) resistor r=165.385 c=0
Rl29 (\2\:Dp \3\:Dp) resistor r=24.2328 c=0
Rl35 (\2\:RNb \3\:RNb) resistor r=118.464 c=0
Rl34 (RNb \2\:RNb) resistor r=94.9523 c=0
Rl38 (Eb \2\:Eb) resistor r=115.18 c=0
Rl39 (\2\:Eb \3\:Eb) resistor r=74.168 c=0
Rl42 (Db \2\:Db) resistor r=226.489 c=0
Rl43 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz18 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz19 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz25 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz26 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=6.25 c=0
Rz16 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz10 (\20\:qbint \21\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz11 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz12 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz9 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz13 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry27 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry21 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry22 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry23 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry24 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry10 (\16\:qbint \17\:qbint) resistor r=31 c=0
Ry7 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry4 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\6\:CKbb \7\:CKbb) resistor r=62 c=0
Ry6 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry15 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry16 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry9 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry17 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry18 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (n2 \2\:n2) resistor r=62 c=0
Ry12 (\3\:n2 \4\:n2) resistor r=62 c=0
Ry13 (n3 \2\:n3) resistor r=62 c=0
Ry14 (\3\:n3 \4\:n3) resistor r=62 c=0
Rx21 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:E \8\:E) resistor r=45 c=0
Rx19 (\6\:E \9\:E) resistor r=45 c=0
Rx12 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx14 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx15 (\2\:qbint \18\:qbint) resistor r=45 c=0
Rx16 (\8\:qbint \19\:qbint) resistor r=45 c=0
Rx6 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\8\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx9 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \22\:CKb) resistor r=45 c=0
Rx3 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\3\:Dp \7\:Dp) resistor r=45 c=0
Rx13 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx20 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx22 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \28\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\4\:Q \5\:qbint \26\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=3.64e-14 ps=8.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39423e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn56 (\9\:qint \4\:qbint \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\17\:CKb \3\:CK \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=2.03e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn50 (net496 \9\:qbint \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.08e-14 ad=8.7e-15 ps=8.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=2e-06 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn51 (\6\:n30 CKb net496 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.995e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn40 (\6\:n30 \4\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.79e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\6\:mout n20 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.453e-14 ad=5.148e-14 ps=1.08e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.39e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (net516 mout \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.453e-14 ad=8.7e-15 ps=1.08e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=1.06e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn36 (\9\:n20 \3\:CKbb net516 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=9.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn26 (\9\:n20 \7\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=6.65e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn25 (n21 \2\:Dp \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.85e-14 ad=1.957e-14 ps=1.64e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.85e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn21 (\10\:CKbb \9\:CKb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.85e-14 ad=2.03e-14 ps=1.64e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (\8\:RNb \3\:RN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=8.1e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn3 (\8\:Dp RNb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.5e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn5 (\8\:Dp \10\:qbint n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn4 (n0 \3\:Eb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn6 (n1 \1\:E \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn7 (\4\:Dp Db n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.47547 scb=0.00467957 \
        scc=5.27432e-05 m=(1)
mn0 (\8\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\20\:qbint \3\:n30 \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.08e-14 ad=5.638e-14 ps=8.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4439e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp56 (\5\:qint \6\:qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=46.9517 \
        scb=0.029008 scc=0.00588492 m=(1)
mp20 (\19\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0705e-13 ad=4.3e-14 ps=1.72e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.82442e-07 sb=2e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (net411 \7\:qbint \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=1.72e-14 ps=1.1e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp51 (\8\:n30 \5\:CKbb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.44e-14 ps=5.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.895e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\8\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.69e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\8\:mout \3\:n20 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=6.773e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.33e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net427 \3\:mout \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=1.065e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\5\:n20 \5\:CKb net427 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=9.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp26 (\5\:n20 CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.558e-14 ps=7.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=6.1e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (n22 Dp \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.44e-14 ps=1.64e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp21 (\6\:CKbb \11\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (\6\:RNb \1\:RN \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=4.085e-14 ps=1.69e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.15e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp3 (\3\:n2 \3\:RNb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=3.44e-14 ps=1.69e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=5.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp5 (n3 \11\:qbint \3\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp4 (n3 Eb n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.65e-07 sb=1.4e-07 sd=160n sca=17.4145 scb=0.0172865 \
        scc=0.00131682 m=(1)
mp6 (\11\:Dp \3\:E \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp7 (\13\:Dp \2\:Db \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.225e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp0 (\4\:Eb \4\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=47.8367 \
        scb=0.030096 scc=0.00588989 m=(1)
mp1 (\4\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.44e-14 ps=1.62e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.6e-07 sd=160n sca=55.1271 \
        scb=0.0420653 scc=0.00650135 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41774e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
ends EDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:11 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFTRX2
// View name: extracted

simulator lang=spectre

subckt EDFFTRX2 CK D E Q QN RN VDD VSS
mp1 (\5\:Db \1\:D \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=47.4597 \
        scb=0.0295856 scc=0.00588691 m=(1)
mp0 (\7\:Eb \1\:E \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.1185 \
        scb=0.028424 scc=0.00588418 m=(1)
mp7 (\9\:Dp Db \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.655e-14 ps=1.04e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp6 (\12\:Dp \4\:E \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.01e-14 ps=1.04e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp4 (n3 Eb \3\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.1e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp5 (n3 \2\:qbint n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.05e-07 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp3 (n2 RNb \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.128e-14 ad=3.44e-14 ps=1.93e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp2 (\4\:RNb \1\:RN \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.128e-14 ad=3.87e-14 ps=1.93e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.8e-07 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp21 (\11\:CKbb CKb \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp25 (n22 Dp \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=6.773e-14 ps=1.7e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2e-06 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp26 (\7\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=6.558e-14 ps=1.06e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.97e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp36 (\7\:n20 \6\:CKb net427 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.62e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (net427 mout \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.515e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\8\:mout n20 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=5.697e-14 ps=1.7e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.25e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\7\:n30 \8\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=7.203e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=9.4e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp51 (\7\:n30 \4\:CKbb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=7.203e-14 ps=7.3e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.6e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp50 (net411 \4\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.48e-14 ad=3.225e-14 ps=1.22e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp20 (\19\:CKb \3\:CK \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.08e-13 ad=3.83e-14 ps=1.72e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7814e-07 sb=1.285e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp56 (\8\:qint \13\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.015e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32314e-06 sb=1.4e-07 sd=160n sca=23.0212 \
        scb=0.0246876 scc=0.0015445 m=(1)
C1 (D VSS) capacitor c=8.29098e-17
C2 (CK VSS) capacitor c=4.73364e-17
C3 (RN VSS) capacitor c=5.57101e-17
C4 (Q VSS) capacitor c=3.88117e-17
C5 (VDD VSS) capacitor c=5.60071e-16
C6 (E VSS) capacitor c=2.08757e-17
C7 (QN VSS) capacitor c=5.91592e-17
C8 (Db VSS) capacitor c=3.56612e-17
C9 (Eb VSS) capacitor c=6.10995e-17
C10 (n1 VSS) capacitor c=6.21654e-19
C11 (Dp VSS) capacitor c=6.3423e-17
C12 (qbint VSS) capacitor c=3.21704e-17
C13 (RNb VSS) capacitor c=5.32431e-17
C14 (CKb VSS) capacitor c=5.61675e-17
C15 (CKbb VSS) capacitor c=5.282e-17
C16 (n21 VSS) capacitor c=1.756e-18
C17 (n20 VSS) capacitor c=3.82986e-17
C18 (net516 VSS) capacitor c=3.35896e-18
C19 (mout VSS) capacitor c=7.69035e-17
C20 (n30 VSS) capacitor c=5.46344e-17
C21 (net496 VSS) capacitor c=5.58966e-19
C22 (qint VSS) capacitor c=2.00783e-16
C23 (n3 VSS) capacitor c=7.38829e-17
C24 (n2 VSS) capacitor c=6.5131e-17
C25 (n22 VSS) capacitor c=4.23483e-18
C26 (net427 VSS) capacitor c=1.65611e-18
C27 (net411 VSS) capacitor c=4.16996e-18
C28 (\13\:qbint VSS) capacitor c=4.01784e-17
C29 (\3\:CK VSS) capacitor c=2.98862e-17
C30 (\4\:qbint VSS) capacitor c=4.91284e-17
C31 (\4\:CKbb VSS) capacitor c=3.84331e-17
C32 (\8\:CKb VSS) capacitor c=3.62959e-17
C33 (\6\:CKb VSS) capacitor c=6.15235e-17
C34 (\3\:CKbb VSS) capacitor c=2.21641e-17
C35 (\1\:RN VSS) capacitor c=3.49156e-17
C36 (\2\:qbint VSS) capacitor c=6.4623e-17
C37 (\4\:E VSS) capacitor c=3.97491e-17
C38 (\1\:E VSS) capacitor c=3.59676e-17
C39 (\1\:D VSS) capacitor c=4.35622e-17
C40 (\14\:qbint VSS) capacitor c=5.09996e-17
C41 (\7\:qbint VSS) capacitor c=1.8793e-16
C42 (\1\:CK VSS) capacitor c=4.03265e-17
C43 (\4\:n30 VSS) capacitor c=4.22541e-17
C44 (\6\:qbint VSS) capacitor c=7.78634e-17
C45 (\10\:CKb VSS) capacitor c=6.45902e-17
C46 (\6\:CKbb VSS) capacitor c=4.0062e-17
C47 (\3\:n20 VSS) capacitor c=3.68774e-17
C48 (\3\:mout VSS) capacitor c=2.87014e-17
C49 (\4\:CKb VSS) capacitor c=4.38862e-17
C50 (\2\:Dp VSS) capacitor c=5.37731e-17
C51 (\3\:CKb VSS) capacitor c=2.95903e-17
C52 (\3\:RN VSS) capacitor c=4.32025e-17
C53 (\3\:RNb VSS) capacitor c=3.47572e-17
C54 (\3\:qbint VSS) capacitor c=9.23277e-17
C55 (\2\:Eb VSS) capacitor c=4.8393e-17
C56 (\6\:E VSS) capacitor c=4.54803e-17
C57 (\3\:Db VSS) capacitor c=6.5907e-17
C58 (\3\:E VSS) capacitor c=3.18422e-17
C59 (\3\:D VSS) capacitor c=3.11322e-17
C60 (\15\:qbint VSS) capacitor c=2.54334e-17
C61 (\2\:CK VSS) capacitor c=4.00973e-17
C62 (\3\:n30 VSS) capacitor c=1.92576e-17
C63 (\5\:qbint VSS) capacitor c=2.65295e-17
C64 (\5\:CKbb VSS) capacitor c=4.92498e-17
C65 (\11\:CKb VSS) capacitor c=3.08473e-17
C66 (\9\:CKb VSS) capacitor c=2.28724e-17
C67 (\2\:n20 VSS) capacitor c=3.58919e-17
C68 (\2\:mout VSS) capacitor c=4.97986e-17
C69 (\7\:CKb VSS) capacitor c=5.60391e-17
C70 (\2\:CKbb VSS) capacitor c=4.81203e-17
C71 (\5\:CKb VSS) capacitor c=4.09406e-17
C72 (\3\:Dp VSS) capacitor c=2.16669e-17
C73 (\2\:CKb VSS) capacitor c=4.38719e-17
C74 (\2\:RN VSS) capacitor c=3.98795e-17
C75 (\2\:RNb VSS) capacitor c=4.86111e-17
C76 (\3\:Eb VSS) capacitor c=2.7071e-17
C77 (\5\:E VSS) capacitor c=3.45453e-17
C78 (\2\:Db VSS) capacitor c=2.31669e-17
C79 (\2\:E VSS) capacitor c=3.42014e-17
C80 (\2\:D VSS) capacitor c=3.04938e-17
C81 (\8\:qint VSS) capacitor c=2.75392e-17
C82 (\3\:QN VSS) capacitor c=7.06298e-18
C83 (\2\:Q VSS) capacitor c=5.37516e-17
C84 (\19\:CKb VSS) capacitor c=1.01042e-16
C85 (\18\:qbint VSS) capacitor c=5.63259e-17
C86 (\20\:VDD VSS) capacitor c=8.10667e-17
C87 (\7\:n30 VSS) capacitor c=7.24717e-17
C88 (\8\:mout VSS) capacitor c=5.64147e-17
C89 (\22\:VDD VSS) capacitor c=2.53818e-17
C90 (\7\:n20 VSS) capacitor c=3.31182e-17
C91 (\24\:VDD VSS) capacitor c=1.60933e-17
C92 (\11\:CKbb VSS) capacitor c=1.50497e-17
C93 (\4\:RNb VSS) capacitor c=4.90021e-17
C94 (\26\:VDD VSS) capacitor c=1.69881e-17
C95 (\3\:n2 VSS) capacitor c=7.60482e-17
C96 (\12\:Dp VSS) capacitor c=3.88321e-17
C97 (\3\:n3 VSS) capacitor c=7.83223e-17
C98 (\9\:Dp VSS) capacitor c=5.83972e-17
C99 (\7\:Eb VSS) capacitor c=7.79021e-17
C100 (\28\:VDD VSS) capacitor c=1.77564e-17
C101 (\5\:Db VSS) capacitor c=1.54408e-16
C102 (\1\:VDD VSS) capacitor c=9.9312e-17
C103 (\12\:qint VSS) capacitor c=1.1249e-17
C104 (\1\:QN VSS) capacitor c=4.01044e-17
C105 (\4\:Q VSS) capacitor c=2.80771e-17
C106 (\23\:CKb VSS) capacitor c=2.92375e-17
C107 (\23\:qbint VSS) capacitor c=6.72231e-17
C108 (\9\:n30 VSS) capacitor c=2.53589e-17
C109 (\4\:mout VSS) capacitor c=4.60428e-17
C110 (\4\:n20 VSS) capacitor c=7.6865e-17
C111 (\7\:CKbb VSS) capacitor c=5.12178e-17
C112 (\8\:RNb VSS) capacitor c=3.82071e-17
C113 (\4\:Dp VSS) capacitor c=2.02129e-16
C114 (\7\:Dp VSS) capacitor c=8.4757e-17
C115 (\5\:Eb VSS) capacitor c=1.48582e-16
C116 (\7\:Db VSS) capacitor c=1.01082e-16
C117 (\4\:D VSS) capacitor c=2.94681e-17
C118 (\2\:n30 VSS) capacitor c=1.57177e-17
C119 (\4\:Db VSS) capacitor c=9.8757e-17
C120 (\7\:E VSS) capacitor c=1.20638e-16
C121 (\8\:E VSS) capacitor c=1.20678e-16
C122 (\9\:E VSS) capacitor c=3.4816e-17
C123 (\4\:Eb VSS) capacitor c=1.38198e-16
C124 (\4\:RN VSS) capacitor c=4.40057e-17
C125 (\6\:RNb VSS) capacitor c=5.65463e-17
C126 (\7\:RNb VSS) capacitor c=4.50558e-17
C127 (\6\:Dp VSS) capacitor c=1.1631e-16
C128 (\11\:Dp VSS) capacitor c=1.4153e-16
C129 (\6\:n20 VSS) capacitor c=6.87411e-17
C130 (\9\:n20 VSS) capacitor c=6.31519e-17
C131 (\6\:mout VSS) capacitor c=6.68623e-17
C132 (\7\:mout VSS) capacitor c=5.66977e-17
C133 (\9\:CKbb VSS) capacitor c=7.79547e-17
C134 (\10\:CKbb VSS) capacitor c=2.41764e-16
C135 (\13\:CKbb VSS) capacitor c=2.45166e-16
C136 (\5\:n30 VSS) capacitor c=6.63497e-17
C137 (\6\:n30 VSS) capacitor c=8.71947e-17
C138 (\12\:CKb VSS) capacitor c=2.73348e-17
C139 (\13\:CKb VSS) capacitor c=8.32462e-17
C140 (\14\:CKb VSS) capacitor c=1.24335e-16
C141 (\15\:CKb VSS) capacitor c=1.48424e-16
C142 (\16\:CKb VSS) capacitor c=9.44063e-17
C143 (\17\:CKb VSS) capacitor c=4.03116e-17
C144 (\18\:CKb VSS) capacitor c=8.88133e-17
C145 (\21\:CKb VSS) capacitor c=8.28745e-17
C146 (\22\:CKb VSS) capacitor c=4.15072e-17
C147 (\4\:CK VSS) capacitor c=8.15965e-17
C148 (\1\:Q VSS) capacitor c=4.36891e-17
C149 (\16\:qbint VSS) capacitor c=8.88892e-17
C150 (\17\:qbint VSS) capacitor c=1.27389e-16
C151 (\20\:qbint VSS) capacitor c=9.48609e-17
C152 (\21\:qbint VSS) capacitor c=3.81266e-16
C153 (\22\:qbint VSS) capacitor c=9.19214e-17
C154 (\25\:qbint VSS) capacitor c=2.42086e-16
C155 (\10\:qint VSS) capacitor c=2.17792e-17
C156 (\11\:qint VSS) capacitor c=2.24578e-17
C157 (\3\:VDD VSS) capacitor c=1.03072e-16
C158 (\7\:VDD VSS) capacitor c=3.31811e-17
C159 (\8\:VDD VSS) capacitor c=5.29291e-17
C160 (\10\:VDD VSS) capacitor c=2.00065e-17
C161 (\11\:VDD VSS) capacitor c=5.6708e-17
C162 (\13\:VDD VSS) capacitor c=1.79536e-17
Rk1 (\4\:D D) resistor r=0.1009 c=0
Rk43 (\4\:CK CK) resistor r=0.08837 c=0
Rk11 (RN \4\:RN) resistor r=0.141 c=0
Rk44 (Q \1\:Q) resistor r=0.07065 c=0
Rk45 (\1\:Q \3\:Q) resistor r=0.1486 c=0
Rk46 (\1\:Q \5\:Q) resistor r=0.1584 c=0
Rk79 (\2\:VSS \3\:VSS) resistor r=0.09007 c=0
Rk82 (\3\:VSS \6\:VSS) resistor r=0.233 c=0
Rk83 (\6\:VSS \7\:VSS) resistor r=0.1443 c=0
Rk84 (\7\:VSS \8\:VSS) resistor r=0.5904 c=0
Rk85 (\8\:VSS \9\:VSS) resistor r=0.4662 c=0
Rk86 (\9\:VSS \10\:VSS) resistor r=0.065 c=0
Rk87 (\10\:VSS \11\:VSS) resistor r=0.466 c=0
Rk88 (\11\:VSS \12\:VSS) resistor r=0.3657 c=0
Rk89 (\12\:VSS \13\:VSS) resistor r=0.1475 c=0
Rk90 (\13\:VSS \14\:VSS) resistor r=0.1578 c=0
Rk92 (\15\:VSS VSS) resistor r=0.2804 c=0
Rk91 (\14\:VSS \15\:VSS) resistor r=0.2706 c=0
Rk96 (\7\:VSS \23\:VSS) resistor r=0.0433 c=0
Rk97 (\8\:VSS \25\:VSS) resistor r=0.2424 c=0
Rk98 (\10\:VSS \27\:VSS) resistor r=0.1225 c=0
Rk99 (\11\:VSS \29\:VSS) resistor r=0.1632 c=0
Rk100 (\12\:VSS \31\:VSS) resistor r=0.193 c=0
Rk101 (\13\:VSS \33\:VSS) resistor r=0.1739 c=0
Rk102 (\15\:VSS \35\:VSS) resistor r=0.2811 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.05497 c=0
Rk62 (\3\:VDD \6\:VDD) resistor r=0.2255 c=0
Rk63 (\6\:VDD \7\:VDD) resistor r=0.1452 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.5754 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.4803 c=0
Rk66 (\9\:VDD \10\:VDD) resistor r=0.05998 c=0
Rk67 (\10\:VDD \11\:VDD) resistor r=0.4209 c=0
Rk68 (\11\:VDD \12\:VDD) resistor r=0.7219 c=0
Rk70 (\13\:VDD VDD) resistor r=0.2945 c=0
Rk69 (\12\:VDD \13\:VDD) resistor r=0.2546 c=0
Rk74 (\7\:VDD \21\:VDD) resistor r=0.3763 c=0
Rk75 (\8\:VDD \23\:VDD) resistor r=0.0433 c=0
Rk76 (\10\:VDD \25\:VDD) resistor r=0.07381 c=0
Rk77 (\11\:VDD \27\:VDD) resistor r=0.07381 c=0
Rk78 (\13\:VDD \29\:VDD) resistor r=0.0433 c=0
Rk5 (\8\:E E) resistor r=0.003075 c=0
Rk4 (\7\:E \8\:E) resistor r=0.8144 c=0
Rk6 (\8\:E \9\:E) resistor r=0.199 c=0
Rk47 (\2\:QN QN) resistor r=0.2696 c=0
Rk48 (QN \4\:QN) resistor r=0.005786 c=0
Rk2 (\4\:Db \6\:Db) resistor r=0.738 c=0
Rk3 (\6\:Db \8\:Db) resistor r=0.8318 c=0
Rk7 (\4\:Eb \6\:Eb) resistor r=1.0163 c=0
Rk8 (\6\:Eb \8\:Eb) resistor r=0.3423 c=0
Rk15 (\5\:Dp \6\:Dp) resistor r=0.5923 c=0
Rk16 (\6\:Dp \8\:Dp) resistor r=0.4251 c=0
Rk17 (\8\:Dp \10\:Dp) resistor r=0.2574 c=0
Rk18 (\5\:Dp \11\:Dp) resistor r=1.1713 c=0
Rk19 (\6\:Dp \13\:Dp) resistor r=0.198 c=0
Rk49 (\16\:qbint \17\:qbint) resistor r=0.7471 c=0
Rk50 (\17\:qbint \19\:qbint) resistor r=0.4259 c=0
Rk51 (\19\:qbint \20\:qbint) resistor r=0.2321 c=0
Rk52 (\20\:qbint \21\:qbint) resistor r=0.508 c=0
Rk53 (\17\:qbint \22\:qbint) resistor r=0.345 c=0
Rk54 (\20\:qbint \24\:qbint) resistor r=0.2945 c=0
Rk55 (\21\:qbint \25\:qbint) resistor r=2.2653 c=0
Rk12 (\5\:RNb \6\:RNb) resistor r=0.2592 c=0
Rk13 (\6\:RNb \7\:RNb) resistor r=0.2581 c=0
Rk14 (\6\:RNb \9\:RNb) resistor r=0.125 c=0
Rk33 (\12\:CKb \13\:CKb) resistor r=0.06796 c=0
Rk34 (\13\:CKb \14\:CKb) resistor r=0.2633 c=0
Rk35 (\14\:CKb \15\:CKb) resistor r=0.6951 c=0
Rk36 (\15\:CKb \16\:CKb) resistor r=0.7289 c=0
Rk37 (\16\:CKb \17\:CKb) resistor r=0.2224 c=0
Rk38 (\13\:CKb \18\:CKb) resistor r=0.5879 c=0
Rk39 (\18\:CKb \20\:CKb) resistor r=0.457 c=0
Rk40 (\14\:CKb \21\:CKb) resistor r=0.372 c=0
Rk41 (\15\:CKb \22\:CKb) resistor r=0.1884 c=0
Rk42 (\18\:CKb \24\:CKb) resistor r=0.04879 c=0
Rk26 (\8\:CKbb \9\:CKbb) resistor r=0.3813 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.4399 c=0
Rk28 (\9\:CKbb \12\:CKbb) resistor r=0.1224 c=0
Rk29 (\10\:CKbb \13\:CKbb) resistor r=1.6181 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.3743 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.04277 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3528 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.1766 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2948 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2219 c=0
Rk30 (\5\:n30 \6\:n30) resistor r=0.3819 c=0
Rk31 (\6\:n30 \8\:n30) resistor r=0.3835 c=0
Rk32 (\6\:n30 \10\:n30) resistor r=0.07121 c=0
Rk56 (\9\:qint \10\:qint) resistor r=0.1943 c=0
Rk57 (\10\:qint \11\:qint) resistor r=0.1513 c=0
Rk58 (\10\:qint \13\:qint) resistor r=0.1342 c=0
Rk9 (\2\:n3 \4\:n3) resistor r=0.5725 c=0
Rk10 (\2\:n2 \4\:n2) resistor r=0.3322 c=0
Rl1 (\1\:D \2\:D) resistor r=79.5379 c=0
Rl2 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl39 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl38 (\1\:CK \2\:CK) resistor r=115.385 c=0
Rl15 (\1\:RN \2\:RN) resistor r=26.9231 c=0
Rl16 (\2\:RN \3\:RN) resistor r=100.795 c=0
Rl7 (\4\:E \5\:E) resistor r=90.6605 c=0
Rl8 (\5\:E \6\:E) resistor r=39.6174 c=0
Rl3 (\1\:E \2\:E) resistor r=35.3066 c=0
Rl4 (\2\:E \3\:E) resistor r=84.4104 c=0
Rl6 (Db \3\:Db) resistor r=92.3077 c=0
Rl5 (Db \2\:Db) resistor r=50.6918 c=0
Rl9 (Eb \2\:Eb) resistor r=151.923 c=0
Rl10 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl19 (Dp \2\:Dp) resistor r=151.923 c=0
Rl20 (\2\:Dp \3\:Dp) resistor r=25.2509 c=0
Rl51 (\14\:qbint \13\:qbint) resistor r=130.769 c=0
Rl34 (\6\:qbint \4\:qbint) resistor r=151.923 c=0
Rl12 (\3\:qbint \2\:qbint) resistor r=172.643 c=0
Rl52 (\15\:qbint \13\:qbint) resistor r=37.6504 c=0
Rl33 (\5\:qbint \4\:qbint) resistor r=29.5379 c=0
Rl11 (qbint \2\:qbint) resistor r=102.252 c=0
Rl13 (RNb \2\:RNb) resistor r=82.4874 c=0
Rl14 (\2\:RNb \3\:RNb) resistor r=42.2849 c=0
Rl32 (\10\:CKb \11\:CKb) resistor r=89.6174 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=33.8482 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=66.5405 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=86.0515 c=0
Rl17 (CKb \2\:CKb) resistor r=89.6174 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=68.7849 c=0
Rl30 (\4\:CKbb \5\:CKbb) resistor r=49.2328 c=0
Rl31 (\5\:CKbb \6\:CKbb) resistor r=114.939 c=0
Rl23 (\2\:CKbb \3\:CKbb) resistor r=24.2328 c=0
Rl22 (CKbb \2\:CKbb) resistor r=157.246 c=0
Rl27 (n20 \2\:n20) resistor r=24.2328 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=99.2328 c=0
Rl25 (mout \2\:mout) resistor r=93.4057 c=0
Rl26 (\2\:mout \3\:mout) resistor r=26.098 c=0
Rl35 (n30 \2\:n30) resistor r=78.5603 c=0
Rl37 (\2\:n30 \4\:n30) resistor r=43.9449 c=0
Rl36 (\2\:n30 \3\:n30) resistor r=2.7666 c=0
Rz11 (\5\:Q \4\:Q) resistor r=75 c=0
Rz22 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz23 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz24 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz25 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz27 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz28 (\35\:VSS \34\:VSS) resistor r=75 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz16 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz18 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\2\:QN \1\:QN) resistor r=75 c=0
Rz1 (\7\:Db \8\:Db) resistor r=75 c=0
Rz2 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz4 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz5 (\7\:Dp \8\:Dp) resistor r=75 c=0
Rz13 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz3 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz10 (\23\:CKb \24\:CKb) resistor r=75 c=0
Rz8 (\7\:CKbb \8\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz7 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz14 (\13\:qint \12\:qint) resistor r=75 c=0
Ry15 (\3\:Q \2\:Q) resistor r=62 c=0
Ry27 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry28 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry29 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\14\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry23 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry24 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry25 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry26 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry16 (\4\:QN \3\:QN) resistor r=62 c=0
Ry1 (\5\:Db \6\:Db) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry8 (\9\:Dp \10\:Dp) resistor r=62 c=0
Ry9 (\12\:Dp \13\:Dp) resistor r=62 c=0
Ry17 (\19\:qbint \18\:qbint) resistor r=62 c=0
Ry7 (\4\:RNb \5\:RNb) resistor r=62 c=0
Ry14 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry12 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry10 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry11 (\8\:mout \9\:mout) resistor r=62 c=0
Ry13 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry18 (\9\:qint \8\:qint) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n2 \2\:n2) resistor r=62 c=0
Ry6 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx19 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:RN \4\:RN) resistor r=45 c=0
Rx3 (\5\:E \7\:E) resistor r=45 c=0
Rx4 (\2\:E \9\:E) resistor r=45 c=0
Rx2 (\2\:Db \4\:Db) resistor r=45 c=0
Rx5 (\3\:Eb \4\:Eb) resistor r=45 c=0
Rx8 (\3\:Dp \11\:Dp) resistor r=45 c=0
Rx20 (\16\:qbint \15\:qbint) resistor r=45 c=0
Rx21 (\21\:qbint \5\:qbint) resistor r=45 c=0
Rx22 (\22\:qbint \7\:qbint) resistor r=22.5 c=0
Rx23 (\25\:qbint qbint) resistor r=45 c=0
Rx7 (\2\:RNb \7\:RNb) resistor r=45 c=0
Rx14 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx17 (\9\:CKb \21\:CKb) resistor r=45 c=0
Rx18 (\7\:CKb \22\:CKb) resistor r=45 c=0
Rx11 (\2\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx13 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx24 (\11\:qint qint) resistor r=45 c=0
mn1 (\7\:Db \3\:D \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\5\:Eb \3\:E \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn7 (\7\:Dp \3\:Db n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (n1 \6\:E \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.885e-14 ad=8.7e-15 ps=1.2e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (n0 \2\:Eb \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.597e-14 ad=8.7e-15 ps=1.1e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (\4\:Dp \3\:qbint n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=6.95e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\4\:Dp \3\:RNb \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=4.9e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\8\:RNb \3\:RN \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=3.262e-14 ps=1.05e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=2.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn21 (\7\:CKbb \3\:CKb \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.37e-14 ad=4.132e-14 ps=1.41e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn25 (n21 \2\:Dp \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.37e-14 ad=4.06e-14 ps=1.41e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn26 (\4\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=2.32e-14 ps=8.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn36 (\4\:n20 CKbb net516 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.86e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net516 \3\:mout \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=3.48e-14 ps=9.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=1.575e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (\4\:mout \3\:n20 \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.69e-14 ad=7.54e-14 ps=9.8e-07 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=1.31e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn40 (\9\:n30 \6\:CKbb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.54e-14 ad=2.32e-14 ps=1.33e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.45e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn51 (\9\:n30 \10\:CKb net496 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.4e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn50 (net496 \6\:qbint \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=1.015e-14 ps=1.6e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.25e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn20 (\23\:CKb \1\:CK \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.687e-14 ad=2.03e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06793e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn56 (\12\:qint \14\:qbint \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05069e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\23\:qbint \4\:n30 \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17577e-06 sb=1.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\4\:Q \7\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.924e-14 ad=4.68e-14 ps=8.55e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.06058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.262e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.76058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\18\:qbint n30 \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=4.5e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=1.15385e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp55_1__rcx (\2\:Q \7\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.029e-13 ad=6.24e-14 ps=1.57e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.2609e-07 sb=9.04551e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(2)
mp57_1__rcx (\3\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.397e-14 ad=6.24e-14 ps=1.56e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9609e-07 sb=4.34551e-07 sd=160n sca=14.9766 \
        scb=0.0132237 scc=0.000814354 m=(2)
ends EDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:12 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFTRX4
// View name: extracted

simulator lang=spectre

subckt EDFFTRX4 CK D E Q QN RN VDD VSS
mp1 (\5\:Db \1\:D \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.001e-13 ad=3.01e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=22.8473 \
        scb=0.0215844 scc=0.00209118 m=(1)
mp0 (\7\:Eb \1\:E \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.001e-13 ad=3.01e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=21.5061 \
        scb=0.0204227 scc=0.00208845 m=(1)
mp7 (\13\:Dp \2\:Db \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp6 (\11\:Dp \4\:E \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp4 (n3 Eb \3\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.1e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp5 (n3 \2\:qbint n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.05e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp3 (n2 RNb \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.115e-14 ad=3.44e-14 ps=1.62e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp2 (\4\:RNb \1\:RN \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=2.77e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28837e-07 sb=2e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp25 (n22 Dp \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.87e-14 ps=1.7e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.23837e-07 sb=2e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=5.052e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.48837e-07 sb=1.84e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp36 (\6\:n20 \3\:CKb net427 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=5.052e-14 ps=6.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.28837e-07 sb=1.56e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (net427 mout \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=2.58e-14 ps=1.7e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.93837e-07 sb=1.395e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\4\:mout n20 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25884e-06 sb=1.13e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\8\:n30 \5\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=6.558e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.51384e-06 sb=8.75e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp51 (\8\:n30 CKbb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.558e-14 ps=7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86384e-06 sb=5.25e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp50 (net411 \5\:qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=2.903e-14 ps=1.72e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp21 (\10\:CKbb \9\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp20 (\12\:CKb \1\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
C1 (D VSS) capacitor c=5.97348e-17
C2 (Q VSS) capacitor c=1.32289e-17
C3 (CK VSS) capacitor c=8.0465e-17
C4 (RN VSS) capacitor c=5.6902e-17
C5 (QN VSS) capacitor c=1.94601e-17
C6 (VDD VSS) capacitor c=5.57681e-16
C7 (E VSS) capacitor c=2.58064e-17
C8 (Db VSS) capacitor c=6.74227e-17
C9 (Eb VSS) capacitor c=7.61084e-17
C10 (n1 VSS) capacitor c=7.13171e-19
C11 (Dp VSS) capacitor c=6.86934e-17
C12 (qbint VSS) capacitor c=3.64959e-17
C13 (RNb VSS) capacitor c=4.66417e-17
C14 (n20 VSS) capacitor c=4.60631e-17
C15 (CKb VSS) capacitor c=3.6454e-17
C16 (net516 VSS) capacitor c=1.19036e-18
C17 (CKbb VSS) capacitor c=3.81858e-17
C18 (mout VSS) capacitor c=4.15395e-17
C19 (n30 VSS) capacitor c=1.81162e-16
C20 (net496 VSS) capacitor c=4.27756e-20
C21 (qint VSS) capacitor c=2.97049e-16
C22 (n3 VSS) capacitor c=7.95066e-17
C23 (n2 VSS) capacitor c=6.49255e-17
C24 (n22 VSS) capacitor c=1.09542e-18
C25 (net427 VSS) capacitor c=5.75394e-19
C26 (net411 VSS) capacitor c=9.50992e-19
C27 (\20\:qbint VSS) capacitor c=4.43847e-17
C28 (\1\:CK VSS) capacitor c=5.07557e-17
C29 (\9\:CKb VSS) capacitor c=5.99285e-17
C30 (\5\:qbint VSS) capacitor c=6.21687e-17
C31 (\5\:CKb VSS) capacitor c=4.05778e-17
C32 (\3\:CKb VSS) capacitor c=4.72894e-17
C33 (\5\:CKbb VSS) capacitor c=7.3632e-17
C34 (\1\:RN VSS) capacitor c=4.73402e-17
C35 (\2\:qbint VSS) capacitor c=5.92619e-17
C36 (\4\:E VSS) capacitor c=4.09236e-17
C37 (\2\:Db VSS) capacitor c=4.43156e-17
C38 (\1\:E VSS) capacitor c=3.45877e-17
C39 (\1\:D VSS) capacitor c=3.47681e-17
C40 (\22\:qbint VSS) capacitor c=4.1752e-17
C41 (\7\:qbint VSS) capacitor c=2.70769e-16
C42 (\3\:CK VSS) capacitor c=2.89423e-17
C43 (\10\:CKb VSS) capacitor c=2.33195e-17
C44 (\6\:qbint VSS) capacitor c=8.1393e-17
C45 (\7\:CKb VSS) capacitor c=6.51551e-17
C46 (\3\:CKbb VSS) capacitor c=9.51407e-17
C47 (\3\:n20 VSS) capacitor c=3.78865e-17
C48 (\3\:mout VSS) capacitor c=5.3262e-17
C49 (\4\:CKbb VSS) capacitor c=1.15703e-16
C50 (\2\:CKb VSS) capacitor c=7.19075e-17
C51 (\2\:Dp VSS) capacitor c=4.94397e-17
C52 (\3\:RN VSS) capacitor c=4.92389e-17
C53 (\3\:RNb VSS) capacitor c=5.42397e-17
C54 (\3\:qbint VSS) capacitor c=8.95147e-17
C55 (\2\:Eb VSS) capacitor c=4.20091e-17
C56 (\6\:E VSS) capacitor c=5.92767e-17
C57 (\3\:E VSS) capacitor c=3.04403e-17
C58 (\3\:D VSS) capacitor c=3.36672e-17
C59 (\21\:qbint VSS) capacitor c=4.97795e-17
C60 (\2\:CK VSS) capacitor c=2.85558e-17
C61 (\11\:CKb VSS) capacitor c=2.10575e-17
C62 (\4\:qbint VSS) capacitor c=2.47457e-17
C63 (\2\:CKbb VSS) capacitor c=7.43667e-17
C64 (\8\:CKb VSS) capacitor c=3.3669e-17
C65 (\6\:CKb VSS) capacitor c=4.11753e-17
C66 (\2\:n20 VSS) capacitor c=3.41315e-17
C67 (\2\:mout VSS) capacitor c=4.37175e-17
C68 (\4\:CKb VSS) capacitor c=4.29438e-17
C69 (\3\:Dp VSS) capacitor c=2.9269e-17
C70 (\2\:RN VSS) capacitor c=4.20582e-17
C71 (\2\:RNb VSS) capacitor c=4.25848e-17
C72 (\3\:Eb VSS) capacitor c=2.78559e-17
C73 (\5\:E VSS) capacitor c=3.80477e-17
C74 (\3\:Db VSS) capacitor c=2.47022e-17
C75 (\2\:E VSS) capacitor c=3.24023e-17
C76 (\2\:D VSS) capacitor c=2.90769e-17
C77 (\16\:qint VSS) capacitor c=5.65457e-17
C78 (\1\:QN VSS) capacitor c=1.13627e-16
C79 (\26\:qbint VSS) capacitor c=3.99003e-17
C80 (\1\:VDD VSS) capacitor c=2.79989e-16
C81 (\12\:CKb VSS) capacitor c=1.46798e-16
C82 (\10\:CKbb VSS) capacitor c=3.77139e-17
C83 (\16\:VDD VSS) capacitor c=2.48171e-17
C84 (\8\:n30 VSS) capacitor c=2.24188e-16
C85 (\4\:mout VSS) capacitor c=2.46749e-17
C86 (\18\:VDD VSS) capacitor c=1.05414e-17
C87 (\6\:n20 VSS) capacitor c=1.26413e-16
C88 (\20\:VDD VSS) capacitor c=9.2039e-18
C89 (\4\:RNb VSS) capacitor c=7.72682e-17
C90 (\22\:VDD VSS) capacitor c=1.12254e-17
C91 (\3\:n2 VSS) capacitor c=7.56665e-17
C92 (\11\:Dp VSS) capacitor c=4.52421e-17
C93 (\3\:n3 VSS) capacitor c=7.75664e-17
C94 (\13\:Dp VSS) capacitor c=5.49462e-17
C95 (\7\:Eb VSS) capacitor c=6.19183e-17
C96 (\24\:VDD VSS) capacitor c=2.74349e-17
C97 (\5\:Db VSS) capacitor c=1.64554e-16
C98 (\6\:VDD VSS) capacitor c=1.02744e-16
C99 (\20\:qint VSS) capacitor c=8.65904e-18
C100 (\5\:QN VSS) capacitor c=7.57422e-17
C101 (\1\:Q VSS) capacitor c=7.09336e-17
C102 (\29\:qbint VSS) capacitor c=2.28699e-17
C103 (\14\:CKb VSS) capacitor c=1.20857e-16
C104 (\6\:CKbb VSS) capacitor c=5.8199e-17
C105 (\10\:n30 VSS) capacitor c=8.43931e-17
C106 (\8\:mout VSS) capacitor c=6.73439e-17
C107 (\4\:n20 VSS) capacitor c=7.17946e-17
C108 (\8\:RNb VSS) capacitor c=2.83938e-17
C109 (\5\:Dp VSS) capacitor c=1.16994e-16
C110 (\9\:Dp VSS) capacitor c=3.84513e-17
C111 (\5\:Eb VSS) capacitor c=1.51215e-16
C112 (\7\:Db VSS) capacitor c=8.17174e-17
C113 (\4\:D VSS) capacitor c=5.80391e-17
C114 (\4\:Db VSS) capacitor c=1.13705e-16
C115 (\7\:E VSS) capacitor c=5.78143e-17
C116 (\8\:E VSS) capacitor c=1.04617e-16
C117 (\9\:E VSS) capacitor c=1.09202e-16
C118 (\4\:Eb VSS) capacitor c=1.49283e-16
C119 (\6\:RNb VSS) capacitor c=3.72766e-17
C120 (\7\:RNb VSS) capacitor c=1.14678e-17
C121 (\4\:Dp VSS) capacitor c=6.76808e-17
C122 (\7\:Dp VSS) capacitor c=9.97974e-17
C123 (\8\:Dp VSS) capacitor c=6.57916e-17
C124 (\4\:RN VSS) capacitor c=4.79088e-17
C125 (\8\:n20 VSS) capacitor c=1.22036e-16
C126 (\6\:mout VSS) capacitor c=4.80014e-17
C127 (\7\:mout VSS) capacitor c=6.01673e-17
C128 (\8\:CKbb VSS) capacitor c=6.01609e-17
C129 (\9\:CKbb VSS) capacitor c=6.21538e-17
C130 (\16\:CKb VSS) capacitor c=1.40392e-16
C131 (\17\:CKb VSS) capacitor c=1.15438e-16
C132 (\18\:CKb VSS) capacitor c=3.36718e-17
C133 (\19\:CKb VSS) capacitor c=1.2207e-16
C134 (\20\:CKb VSS) capacitor c=1.05948e-16
C135 (\21\:CKb VSS) capacitor c=3.17257e-17
C136 (\22\:CKb VSS) capacitor c=8.00221e-17
C137 (\23\:CKb VSS) capacitor c=6.04718e-17
C138 (\4\:CK VSS) capacitor c=5.72979e-17
C139 (\7\:n30 VSS) capacitor c=2.52947e-16
C140 (\4\:Q VSS) capacitor c=1.19178e-16
C141 (\23\:qbint VSS) capacitor c=2.25575e-16
C142 (\24\:qbint VSS) capacitor c=3.17113e-16
C143 (\25\:qbint VSS) capacitor c=3.45088e-16
C144 (\28\:qbint VSS) capacitor c=4.03747e-17
C145 (\31\:qbint VSS) capacitor c=2.02481e-16
C146 (\32\:qbint VSS) capacitor c=2.39208e-17
C147 (\18\:qint VSS) capacitor c=4.05985e-17
C148 (\19\:qint VSS) capacitor c=4.45224e-17
C149 (\4\:VDD VSS) capacitor c=5.14149e-17
C150 (\5\:VDD VSS) capacitor c=2.63483e-17
C151 (\8\:VDD VSS) capacitor c=1.84005e-17
C152 (\9\:VDD VSS) capacitor c=3.69001e-17
C153 (\11\:VDD VSS) capacitor c=2.49049e-17
Rk1 (\4\:D D) resistor r=0.1053 c=0
Rk42 (\1\:Q Q) resistor r=0.1911 c=0
Rk43 (Q \4\:Q) resistor r=0.04541 c=0
Rk93 (\1\:VSS \11\:VSS) resistor r=0.5313 c=0
Rk94 (\11\:VSS \12\:VSS) resistor r=0.5112 c=0
Rk95 (\12\:VSS \13\:VSS) resistor r=0.05999 c=0
Rk96 (\13\:VSS \14\:VSS) resistor r=0.4227 c=0
Rk97 (\14\:VSS \15\:VSS) resistor r=0.2168 c=0
Rk98 (\15\:VSS \16\:VSS) resistor r=0.3306 c=0
Rk99 (\16\:VSS \17\:VSS) resistor r=0.07986 c=0
Rk100 (\17\:VSS \18\:VSS) resistor r=0.1503 c=0
Rk102 (\19\:VSS VSS) resistor r=0.2804 c=0
Rk101 (\18\:VSS \19\:VSS) resistor r=0.2706 c=0
Rk108 (\11\:VSS \31\:VSS) resistor r=0.3927 c=0
Rk109 (\12\:VSS \33\:VSS) resistor r=0.2571 c=0
Rk110 (\14\:VSS \35\:VSS) resistor r=0.04331 c=0
Rk111 (\15\:VSS \37\:VSS) resistor r=0.07393 c=0
Rk112 (\16\:VSS \39\:VSS) resistor r=0.2739 c=0
Rk113 (\17\:VSS \41\:VSS) resistor r=0.2734 c=0
Rk114 (\19\:VSS \43\:VSS) resistor r=0.3824 c=0
Rk38 (\4\:CK CK) resistor r=0.04731 c=0
Rk20 (\4\:RN RN) resistor r=0.03934 c=0
Rk48 (\1\:QN QN) resistor r=0.07077 c=0
Rk49 (QN \5\:QN) resistor r=0.2435 c=0
Rk62 (\1\:VDD \4\:VDD) resistor r=0.4491 c=0
Rk63 (\4\:VDD \5\:VDD) resistor r=0.5253 c=0
Rk64 (\5\:VDD \7\:VDD) resistor r=0.1177 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.3158 c=0
Rk66 (\8\:VDD \9\:VDD) resistor r=0.1977 c=0
Rk67 (\9\:VDD \10\:VDD) resistor r=0.6895 c=0
Rk69 (\11\:VDD VDD) resistor r=0.2945 c=0
Rk68 (\10\:VDD \11\:VDD) resistor r=0.2547 c=0
Rk73 (\4\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk74 (\5\:VDD \19\:VDD) resistor r=0.07393 c=0
Rk75 (\8\:VDD \21\:VDD) resistor r=0.07393 c=0
Rk76 (\9\:VDD \23\:VDD) resistor r=0.07393 c=0
Rk77 (\11\:VDD \25\:VDD) resistor r=0.04331 c=0
Rk5 (\8\:E E) resistor r=0.02565 c=0
Rk4 (\7\:E \8\:E) resistor r=0.2497 c=0
Rk6 (\8\:E \9\:E) resistor r=0.7111 c=0
Rk2 (\4\:Db \6\:Db) resistor r=0.7537 c=0
Rk3 (\6\:Db \8\:Db) resistor r=0.8054 c=0
Rk7 (\4\:Eb \6\:Eb) resistor r=1.037 c=0
Rk8 (\6\:Eb \8\:Eb) resistor r=0.342 c=0
Rk14 (\4\:Dp \6\:Dp) resistor r=0.6651 c=0
Rk15 (\6\:Dp \7\:Dp) resistor r=0.4335 c=0
Rk16 (\7\:Dp \8\:Dp) resistor r=0.4498 c=0
Rk17 (\8\:Dp \10\:Dp) resistor r=0.09733 c=0
Rk18 (\7\:Dp \12\:Dp) resistor r=0.2091 c=0
Rk19 (\8\:Dp \14\:Dp) resistor r=0.249 c=0
Rk51 (\23\:qbint \24\:qbint) resistor r=1.7888 c=0
Rk52 (\24\:qbint \25\:qbint) resistor r=1.0893 c=0
Rk53 (\24\:qbint \27\:qbint) resistor r=0.05684 c=0
Rk54 (\27\:qbint \28\:qbint) resistor r=0.3137 c=0
Rk55 (\28\:qbint \30\:qbint) resistor r=0.1511 c=0
Rk56 (\25\:qbint \31\:qbint) resistor r=1.7824 c=0
Rk57 (\28\:qbint \32\:qbint) resistor r=0.1983 c=0
Rk11 (\5\:RNb \6\:RNb) resistor r=0.3873 c=0
Rk12 (\6\:RNb \7\:RNb) resistor r=0.03421 c=0
Rk13 (\6\:RNb \9\:RNb) resistor r=0.1231 c=0
Rk21 (\5\:n20 \7\:n20) resistor r=0.4259 c=0
Rk22 (\7\:n20 \8\:n20) resistor r=0.6927 c=0
Rk29 (\13\:CKb \15\:CKb) resistor r=0.839 c=0
Rk30 (\15\:CKb \16\:CKb) resistor r=0.5402 c=0
Rk31 (\16\:CKb \17\:CKb) resistor r=0.7864 c=0
Rk32 (\17\:CKb \18\:CKb) resistor r=0.08968 c=0
Rk33 (\17\:CKb \19\:CKb) resistor r=0.1764 c=0
Rk34 (\19\:CKb \20\:CKb) resistor r=0.7273 c=0
Rk35 (\20\:CKb \21\:CKb) resistor r=0.1849 c=0
Rk36 (\19\:CKb \22\:CKb) resistor r=0.3637 c=0
Rk37 (\20\:CKb \23\:CKb) resistor r=0.2555 c=0
Rk26 (\7\:CKbb \8\:CKbb) resistor r=0.2466 c=0
Rk27 (\8\:CKbb \9\:CKbb) resistor r=0.3602 c=0
Rk28 (\8\:CKbb \11\:CKbb) resistor r=0.1695 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.07763 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2448 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2879 c=0
Rk39 (\7\:n30 \9\:n30) resistor r=1.5052 c=0
Rk40 (\9\:n30 \11\:n30) resistor r=0.3575 c=0
Rk58 (\17\:qint \18\:qint) resistor r=0.4787 c=0
Rk59 (\18\:qint \19\:qint) resistor r=0.2487 c=0
Rk60 (\18\:qint \21\:qint) resistor r=0.03792 c=0
Rk9 (\2\:n3 \4\:n3) resistor r=0.5224 c=0
Rk10 (\2\:n2 \4\:n2) resistor r=0.3324 c=0
Rl1 (\1\:D \2\:D) resistor r=31.461 c=0
Rl2 (\2\:D \3\:D) resistor r=64.1533 c=0
Rl35 (\1\:CK \2\:CK) resistor r=81.461 c=0
Rl36 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl15 (\1\:RN \2\:RN) resistor r=45.3867 c=0
Rl16 (\2\:RN \3\:RN) resistor r=102.463 c=0
Rl7 (\4\:E \5\:E) resistor r=103.4 c=0
Rl8 (\5\:E \6\:E) resistor r=91.1062 c=0
Rl3 (\1\:E \2\:E) resistor r=35.3066 c=0
Rl4 (\2\:E \3\:E) resistor r=61.3335 c=0
Rl5 (Db \2\:Db) resistor r=123.889 c=0
Rl6 (\2\:Db \3\:Db) resistor r=64.1533 c=0
Rl9 (Eb \2\:Eb) resistor r=145.72 c=0
Rl10 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl17 (Dp \2\:Dp) resistor r=132.539 c=0
Rl18 (\2\:Dp \3\:Dp) resistor r=29.5379 c=0
Rl32 (\6\:qbint \5\:qbint) resistor r=145.72 c=0
Rl12 (\3\:qbint \2\:qbint) resistor r=166.439 c=0
Rl68 (\21\:qbint \20\:qbint) resistor r=65.3618 c=0
Rl69 (\21\:qbint \22\:qbint) resistor r=63.2566 c=0
Rl31 (\4\:qbint \5\:qbint) resistor r=58.3841 c=0
Rl11 (qbint \2\:qbint) resistor r=31.0981 c=0
Rl13 (RNb \2\:RNb) resistor r=68.4636 c=0
Rl14 (\2\:RNb \3\:RNb) resistor r=97.631 c=0
Rl23 (n20 \2\:n20) resistor r=76.9231 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=29.9451 c=0
Rl33 (\9\:CKb \10\:CKb) resistor r=130.769 c=0
Rl34 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=94.9225 c=0
Rl25 (\5\:CKb \6\:CKb) resistor r=28.079 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=54.5567 c=0
Rl19 (CKb \2\:CKb) resistor r=64.0094 c=0
Rl30 (\4\:CKbb \5\:CKbb) resistor r=186.104 c=0
Rl29 (\3\:CKbb \4\:CKbb) resistor r=447.643 c=0
Rl27 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl28 (\2\:CKbb \3\:CKbb) resistor r=195.274 c=0
Rl21 (mout \2\:mout) resistor r=24.2328 c=0
Rl22 (\2\:mout \3\:mout) resistor r=93.0293 c=0
Rz27 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz28 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz29 (\35\:VSS \34\:VSS) resistor r=75 c=0
Rz30 (\37\:VSS \36\:VSS) resistor r=75 c=0
Rz31 (\39\:VSS \38\:VSS) resistor r=75 c=0
Rz32 (\41\:VSS \40\:VSS) resistor r=75 c=0
Rz33 (\43\:VSS \42\:VSS) resistor r=75 c=0
Rz20 (\1\:VDD \6\:VDD) resistor r=4.1667 c=0
Rz17 (\7\:VDD \6\:VDD) resistor r=6.25 c=0
Rz18 (\10\:VDD \6\:VDD) resistor r=6.25 c=0
Rz1 (\7\:Db \8\:Db) resistor r=75 c=0
Rz2 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz4 (\5\:Dp \6\:Dp) resistor r=75 c=0
Rz5 (\9\:Dp \10\:Dp) resistor r=75 c=0
Rz15 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz3 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz9 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz8 (\6\:CKbb \7\:CKbb) resistor r=75 c=0
Rz7 (\8\:mout \9\:mout) resistor r=75 c=0
Rz10 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz16 (\21\:qint \20\:qint) resistor r=75 c=0
Ry33 (\1\:VSS \3\:VSS) resistor r=3.4444 c=0
Ry34 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry35 (\18\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry23 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry24 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry25 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry26 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry27 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry1 (\5\:Db \6\:Db) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry8 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry9 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry19 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry7 (\4\:RNb \5\:RNb) resistor r=62 c=0
Ry10 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry13 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry12 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry11 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\9\:n30 \8\:n30) resistor r=62 c=0
Ry20 (\17\:qint \16\:qint) resistor r=20.6667 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n2 \2\:n2) resistor r=62 c=0
Ry6 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx17 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx3 (\2\:E \7\:E) resistor r=45 c=0
Rx4 (\5\:E \9\:E) resistor r=45 c=0
Rx2 (\3\:Db \4\:Db) resistor r=45 c=0
Rx5 (\3\:Eb \4\:Eb) resistor r=45 c=0
Rx7 (\3\:Dp \4\:Dp) resistor r=45 c=0
Rx19 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx20 (\25\:qbint \4\:qbint) resistor r=45 c=0
Rx21 (\31\:qbint qbint) resistor r=45 c=0
Rx22 (\32\:qbint \7\:qbint) resistor r=45 c=0
Rx6 (\2\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx12 (\11\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\8\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (CKb \21\:CKb) resistor r=45 c=0
Rx15 (\6\:CKb \22\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \23\:CKb) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx18 (\7\:n30 n30) resistor r=45 c=0
Rx23 (\19\:qint qint) resistor r=45 c=0
mn1 (\7\:Db \3\:D \42\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (\5\:Eb \3\:E \42\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn7 (\9\:Dp Db n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.61e-14 ps=4.1e-07 pd=6.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.8e-07 sb=2.75e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (n1 \6\:E \40\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (n0 \2\:Eb \38\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.137e-14 ad=8.7e-15 ps=1.19e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=4.1e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn5 (\5\:Dp \3\:qbint n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=3.05e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn3 (\5\:Dp \3\:RNb \36\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.415e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn2 (\8\:RNb \3\:RN \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0078e-13 ad=2.03e-14 ps=1.83e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \2\:Dp \34\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0078e-13 ad=8.7e-15 ps=1.83e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\4\:n20 \2\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.277e-14 ps=4.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\4\:n20 \4\:CKbb net516 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=4.277e-14 ps=5.4e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.71e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net516 \3\:mout \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.485e-14 ad=1.812e-14 ps=1.1e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.54e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.485e-14 ad=3.552e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=1.245e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\10\:n30 \3\:CKbb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=4.567e-14 ps=7.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=9.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\10\:n30 \7\:CKb net496 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.567e-14 ps=4.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.95e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (net496 \6\:qbint \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=8.7e-15 ps=7.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\6\:CKbb \10\:CKb \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=2.9e-14 ps=7.8e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\14\:CKb \3\:CK \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.812e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn45_1__rcx (\29\:qbint n30 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.444e-14 ad=3.895e-14 ps=8.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.16829e-07 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(2)
mn56 (\20\:qint \22\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95452e-06 sb=1.4e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn55_1__rcx (\1\:Q \7\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.389e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65769e-07 sb=1.785e-06 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn57_1__rcx (\5\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48577e-06 sb=9.65e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mp45 (\26\:qbint n30 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.948e-14 ad=4.96e-14 ps=1.61e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.62984e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(2)
mp56 (\16\:qint \20\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.18e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=44.1638 scb=0.0392167 \
        scc=0.00476734 m=(1)
mp55_1__rcx (\4\:Q \7\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.08e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.175e-07 sb=2e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57_1__rcx (\1\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.18e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5575e-06 sb=1.08e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
ends EDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:13 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFTRXL
// View name: extracted

simulator lang=spectre

subckt EDFFTRXL CK D E Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=49.7297 \
        scb=0.0332192 scc=0.00593869 m=(1)
mp56 (\5\:qint \7\:qbint \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\3\:Q \5\:qbint \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.117e-14 ps=1.51e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\17\:qbint n30 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.87e-14 ps=8.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp50 (net411 \9\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.3e-14 ad=1.29e-14 ps=8.3e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.975e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 \5\:CKbb net411 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.87e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \3\:CKb \7\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.87e-14 ps=1.04e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.645e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\7\:mout n20 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=6.558e-14 ps=1.64e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=1.295e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net427 \4\:mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.03e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\6\:n20 \5\:CKb net427 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.342e-14 ps=5.5e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=9.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp26 (\6\:n20 CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=6.342e-14 ps=7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=5.85e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (n22 \3\:Dp \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=2.902e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=4.05e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\6\:CKbb \9\:CKb \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (\6\:RNb \1\:RN \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.638e-14 ad=4.085e-14 ps=1.87e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.1e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp3 (\3\:n2 \3\:RNb \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.638e-14 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.5e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp5 (n3 \12\:qbint \3\:n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=3.45e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp4 (n3 Eb n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.6e-07 sb=1.4e-07 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp6 (\11\:Dp \3\:E \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp7 (\13\:Dp Db \3\:n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.225e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.5e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp0 (\4\:Eb \4\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=47.1147 \
        scb=0.0291776 scc=0.00588536 m=(1)
mp1 (\4\:Db \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=51.1829 \
        scb=0.0357894 scc=0.00602791 m=(1)
C1 (D VSS) capacitor c=5.99379e-17
C2 (QN VSS) capacitor c=2.11747e-17
C3 (CK VSS) capacitor c=4.9175e-17
C4 (E VSS) capacitor c=2.25194e-17
C5 (VDD VSS) capacitor c=4.2366e-16
C6 (RN VSS) capacitor c=5.94607e-17
C7 (Q VSS) capacitor c=3.41818e-17
C8 (qint VSS) capacitor c=1.99277e-17
C9 (qbint VSS) capacitor c=2.59914e-17
C10 (CKb VSS) capacitor c=7.86065e-17
C11 (n30 VSS) capacitor c=4.11133e-17
C12 (mout VSS) capacitor c=5.34747e-17
C13 (CKbb VSS) capacitor c=3.18728e-17
C14 (n20 VSS) capacitor c=3.08015e-17
C15 (net516 VSS) capacitor c=5.49529e-19
C16 (Dp VSS) capacitor c=3.37706e-17
C17 (RNb VSS) capacitor c=3.56371e-17
C18 (n0 VSS) capacitor c=1.31823e-18
C19 (Eb VSS) capacitor c=4.94482e-17
C20 (n1 VSS) capacitor c=1.36217e-18
C21 (Db VSS) capacitor c=6.09555e-17
C22 (net411 VSS) capacitor c=2.30706e-18
C23 (net427 VSS) capacitor c=9.1065e-19
C24 (n2 VSS) capacitor c=8.75512e-17
C25 (n3 VSS) capacitor c=8.31943e-17
C26 (\1\:D VSS) capacitor c=2.88716e-17
C27 (\4\:E VSS) capacitor c=3.82554e-17
C28 (\3\:E VSS) capacitor c=4.02709e-17
C29 (\12\:qbint VSS) capacitor c=5.57319e-17
C30 (\3\:RNb VSS) capacitor c=5.55509e-17
C31 (\1\:RN VSS) capacitor c=3.47521e-17
C32 (\9\:CKb VSS) capacitor c=4.86142e-17
C33 (\3\:Dp VSS) capacitor c=7.85875e-17
C34 (\5\:CKb VSS) capacitor c=6.32232e-17
C35 (\4\:mout VSS) capacitor c=7.4386e-17
C36 (\3\:CKb VSS) capacitor c=3.91677e-17
C37 (\5\:CKbb VSS) capacitor c=9.8771e-17
C38 (\9\:qbint VSS) capacitor c=6.28842e-17
C39 (\1\:CK VSS) capacitor c=4.21284e-17
C40 (\5\:qbint VSS) capacitor c=2.39768e-17
C41 (\7\:qbint VSS) capacitor c=3.59089e-17
C42 (\4\:qint VSS) capacitor c=3.79462e-17
C43 (\4\:D VSS) capacitor c=2.7304e-17
C44 (\7\:E VSS) capacitor c=2.64686e-17
C45 (\2\:Db VSS) capacitor c=8.36855e-17
C46 (\1\:E VSS) capacitor c=6.86908e-17
C47 (\3\:Eb VSS) capacitor c=4.78378e-17
C48 (\11\:qbint VSS) capacitor c=1.06129e-16
C49 (\3\:RN VSS) capacitor c=3.66225e-17
C50 (\11\:CKb VSS) capacitor c=3.42002e-17
C51 (\2\:Dp VSS) capacitor c=5.55903e-17
C52 (\7\:CKb VSS) capacitor c=5.25719e-17
C53 (\3\:CKbb VSS) capacitor c=1.12448e-16
C54 (\3\:n20 VSS) capacitor c=4.47093e-17
C55 (\4\:CKbb VSS) capacitor c=1.07223e-16
C56 (\8\:qbint VSS) capacitor c=8.02733e-17
C57 (\3\:n30 VSS) capacitor c=3.49951e-17
C58 (\4\:CK VSS) capacitor c=2.89943e-17
C59 (\4\:qbint VSS) capacitor c=2.68202e-17
C60 (\3\:qint VSS) capacitor c=3.10119e-17
C61 (\3\:D VSS) capacitor c=2.70618e-17
C62 (\6\:E VSS) capacitor c=2.96512e-17
C63 (\3\:Db VSS) capacitor c=2.08189e-17
C64 (\2\:E VSS) capacitor c=7.03827e-17
C65 (\2\:Eb VSS) capacitor c=4.53359e-17
C66 (\13\:qbint VSS) capacitor c=3.11218e-17
C67 (\2\:RNb VSS) capacitor c=6.13286e-17
C68 (\2\:RN VSS) capacitor c=3.68349e-17
C69 (\10\:CKb VSS) capacitor c=3.49195e-17
C70 (\8\:CKb VSS) capacitor c=5.20647e-17
C71 (\2\:CKbb VSS) capacitor c=7.33439e-17
C72 (\6\:CKb VSS) capacitor c=4.77335e-17
C73 (\3\:mout VSS) capacitor c=1.84463e-17
C74 (\2\:n20 VSS) capacitor c=3.48598e-17
C75 (\4\:CKb VSS) capacitor c=3.74112e-17
C76 (\2\:CKb VSS) capacitor c=3.33242e-17
C77 (\10\:qbint VSS) capacitor c=3.2609e-17
C78 (\2\:n30 VSS) capacitor c=3.11272e-17
C79 (\3\:CK VSS) capacitor c=3.27109e-17
C80 (\6\:qbint VSS) capacitor c=1.75412e-17
C81 (\4\:Db VSS) capacitor c=1.12604e-16
C82 (\1\:VDD VSS) capacitor c=3.67483e-17
C83 (\4\:Eb VSS) capacitor c=5.45156e-17
C84 (\13\:Dp VSS) capacitor c=8.10531e-17
C85 (\3\:n3 VSS) capacitor c=7.91054e-17
C86 (\11\:Dp VSS) capacitor c=2.87588e-17
C87 (\3\:n2 VSS) capacitor c=7.56859e-17
C88 (\7\:VDD VSS) capacitor c=1.4978e-17
C89 (\6\:RNb VSS) capacitor c=4.45852e-17
C90 (\6\:CKbb VSS) capacitor c=3.36334e-17
C91 (\9\:VDD VSS) capacitor c=1.71702e-17
C92 (\6\:n20 VSS) capacitor c=8.67237e-17
C93 (\12\:VDD VSS) capacitor c=1.71406e-17
C94 (\7\:mout VSS) capacitor c=4.97728e-17
C95 (\4\:n30 VSS) capacitor c=5.23474e-17
C96 (\15\:VDD VSS) capacitor c=7.21225e-17
C97 (\17\:qbint VSS) capacitor c=4.36425e-17
C98 (\22\:CKb VSS) capacitor c=6.29044e-17
C99 (\18\:VDD VSS) capacitor c=1.95968e-17
C100 (\3\:Q VSS) capacitor c=5.17014e-17
C101 (\5\:qint VSS) capacitor c=2.28015e-17
C102 (\21\:VDD VSS) capacitor c=5.29173e-18
C103 (\1\:QN VSS) capacitor c=1.57713e-17
C104 (\3\:VDD VSS) capacitor c=1.02175e-16
C105 (\7\:Db VSS) capacitor c=3.15762e-17
C106 (\6\:Eb VSS) capacitor c=1.2372e-16
C107 (\4\:Dp VSS) capacitor c=1.14397e-16
C108 (\6\:Dp VSS) capacitor c=9.39935e-17
C109 (\8\:RNb VSS) capacitor c=4.85908e-17
C110 (\10\:CKbb VSS) capacitor c=4.61633e-17
C111 (\4\:n20 VSS) capacitor c=8.41906e-17
C112 (\9\:mout VSS) capacitor c=4.40442e-17
C113 (\8\:n30 VSS) capacitor c=3.60315e-17
C114 (\21\:qbint VSS) capacitor c=5.03417e-17
C115 (\17\:CKb VSS) capacitor c=1.0264e-16
C116 (\1\:Q VSS) capacitor c=3.24295e-17
C117 (\9\:qint VSS) capacitor c=2.54322e-17
C118 (\3\:QN VSS) capacitor c=3.37505e-17
C119 (\2\:qint VSS) capacitor c=1.25457e-17
C120 (\2\:qbint VSS) capacitor c=3.05967e-17
C121 (\3\:qbint VSS) capacitor c=3.71043e-17
C122 (\2\:mout VSS) capacitor c=4.0254e-17
C123 (\7\:qint VSS) capacitor c=2.72793e-17
C124 (\8\:qint VSS) capacitor c=2.85445e-17
C125 (\5\:CK VSS) capacitor c=8.61213e-17
C126 (\5\:E VSS) capacitor c=2.12177e-17
C127 (\6\:n30 VSS) capacitor c=5.14445e-17
C128 (\7\:n30 VSS) capacitor c=5.3896e-17
C129 (\5\:mout VSS) capacitor c=6.20765e-17
C130 (\6\:mout VSS) capacitor c=5.59206e-17
C131 (\8\:n20 VSS) capacitor c=8.23113e-17
C132 (\12\:CKb VSS) capacitor c=4.55626e-17
C133 (\13\:CKb VSS) capacitor c=1.0637e-16
C134 (\14\:CKb VSS) capacitor c=1.51247e-16
C135 (\15\:CKb VSS) capacitor c=9.92545e-17
C136 (\16\:CKb VSS) capacitor c=7.02737e-17
C137 (\19\:CKb VSS) capacitor c=5.11489e-17
C138 (\20\:CKb VSS) capacitor c=8.14007e-17
C139 (\21\:CKb VSS) capacitor c=2.118e-17
C140 (\8\:CKbb VSS) capacitor c=5.56928e-17
C141 (\9\:CKbb VSS) capacitor c=7.06839e-17
C142 (\4\:RN VSS) capacitor c=5.93641e-17
C143 (\4\:RNb VSS) capacitor c=6.85199e-17
C144 (\5\:RNb VSS) capacitor c=5.8536e-17
C145 (\14\:qbint VSS) capacitor c=2.00829e-16
C146 (\16\:qbint VSS) capacitor c=7.46564e-17
C147 (\19\:qbint VSS) capacitor c=6.55387e-17
C148 (\20\:qbint VSS) capacitor c=2.72491e-16
C149 (\8\:Dp VSS) capacitor c=2.14683e-16
C150 (\9\:Dp VSS) capacitor c=1.41053e-16
C151 (\10\:Dp VSS) capacitor c=1.16776e-16
C152 (\8\:E VSS) capacitor c=6.14714e-17
C153 (\9\:E VSS) capacitor c=7.63942e-17
C154 (\8\:Eb VSS) capacitor c=1.56915e-16
C155 (\5\:D VSS) capacitor c=7.3523e-17
C156 (\6\:Db VSS) capacitor c=9.33773e-17
C157 (\5\:VDD VSS) capacitor c=4.68845e-17
C158 (\11\:VDD VSS) capacitor c=4.16062e-17
C159 (\14\:VDD VSS) capacitor c=2.84274e-17
C160 (\20\:VDD VSS) capacitor c=1.0232e-17
Rk51 (D \5\:D) resistor r=0.08319 c=0
Rk2 (\4\:QN QN) resistor r=0.07348 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2244 c=0
Rk8 (\5\:CK CK) resistor r=0.05475 c=0
Rk47 (E \8\:E) resistor r=0.02903 c=0
Rk48 (\8\:E \9\:E) resistor r=0.2684 c=0
Rk54 (\2\:VDD \4\:VDD) resistor r=0.4336 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.6791 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.4234 c=0
Rk57 (\5\:VDD \8\:VDD) resistor r=0.07358 c=0
Rk58 (\6\:VDD \10\:VDD) resistor r=0.1484 c=0
Rk59 (\6\:VDD \11\:VDD) resistor r=0.4616 c=0
Rk60 (\11\:VDD \13\:VDD) resistor r=0.1022 c=0
Rk61 (\11\:VDD \14\:VDD) resistor r=0.5059 c=0
Rk62 (\14\:VDD \16\:VDD) resistor r=0.3882 c=0
Rk63 (\14\:VDD \17\:VDD) resistor r=0.2354 c=0
Rk64 (\17\:VDD \19\:VDD) resistor r=0.2628 c=0
Rk67 (\20\:VDD VDD) resistor r=0.2126 c=0
Rk65 (\17\:VDD \20\:VDD) resistor r=0.3388 c=0
Rk66 (\20\:VDD \22\:VDD) resistor r=0.2233 c=0
Rk29 (RN \4\:RN) resistor r=0.1689 c=0
Rk6 (Q \2\:Q) resistor r=0.05094 c=0
Rk7 (Q \4\:Q) resistor r=0.1768 c=0
Rk68 (\2\:VSS \4\:VSS) resistor r=0.6181 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.2204 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.1375 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.2427 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.5023 c=0
Rk73 (\5\:VSS \10\:VSS) resistor r=0.1854 c=0
Rk74 (\6\:VSS \12\:VSS) resistor r=0.1854 c=0
Rk75 (\7\:VSS \14\:VSS) resistor r=0.2524 c=0
Rk76 (\8\:VSS \15\:VSS) resistor r=0.4284 c=0
Rk77 (\15\:VSS \16\:VSS) resistor r=0.4683 c=0
Rk78 (\16\:VSS \17\:VSS) resistor r=0.3056 c=0
Rk79 (\17\:VSS \18\:VSS) resistor r=0.0374 c=0
Rk81 (\19\:VSS VSS) resistor r=0.2126 c=0
Rk80 (\18\:VSS \19\:VSS) resistor r=0.3004 c=0
Rk82 (\8\:VSS \21\:VSS) resistor r=0.07144 c=0
Rk83 (\15\:VSS \23\:VSS) resistor r=0.2805 c=0
Rk84 (\16\:VSS \25\:VSS) resistor r=0.07358 c=0
Rk85 (\18\:VSS \27\:VSS) resistor r=0.07358 c=0
Rk86 (\19\:VSS \29\:VSS) resistor r=0.07358 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1176 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1192 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1056 c=0
Rk33 (\14\:qbint \15\:qbint) resistor r=1.9541 c=0
Rk34 (\15\:qbint \16\:qbint) resistor r=0.5433 c=0
Rk35 (\16\:qbint \18\:qbint) resistor r=0.07984 c=0
Rk36 (\18\:qbint \19\:qbint) resistor r=0.421 c=0
Rk37 (\15\:qbint \20\:qbint) resistor r=0.04368 c=0
Rk38 (\16\:qbint \22\:qbint) resistor r=0.2761 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2329 c=0
Rk18 (\13\:CKb \14\:CKb) resistor r=0.6727 c=0
Rk19 (\14\:CKb \15\:CKb) resistor r=0.6357 c=0
Rk20 (\15\:CKb \16\:CKb) resistor r=0.2131 c=0
Rk21 (\16\:CKb \18\:CKb) resistor r=0.6107 c=0
Rk22 (\14\:CKb \19\:CKb) resistor r=0.2285 c=0
Rk23 (\15\:CKb \20\:CKb) resistor r=0.3593 c=0
Rk24 (\16\:CKb \21\:CKb) resistor r=0.04287 c=0
Rk25 (\18\:CKb \23\:CKb) resistor r=0.3113 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.2465 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.2913 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.1274 c=0
Rk12 (\5\:mout \6\:mout) resistor r=0.2623 c=0
Rk13 (\6\:mout \8\:mout) resistor r=0.2355 c=0
Rk14 (\6\:mout \10\:mout) resistor r=0.1379 c=0
Rk26 (\7\:CKbb \8\:CKbb) resistor r=0.1171 c=0
Rk27 (\8\:CKbb \9\:CKbb) resistor r=0.3948 c=0
Rk28 (\8\:CKbb \11\:CKbb) resistor r=0.2213 c=0
Rk15 (\5\:n20 \7\:n20) resistor r=0.3957 c=0
Rk16 (\7\:n20 \8\:n20) resistor r=0.4817 c=0
Rk41 (\5\:Dp \7\:Dp) resistor r=0.7688 c=0
Rk42 (\7\:Dp \8\:Dp) resistor r=0.07676 c=0
Rk43 (\8\:Dp \9\:Dp) resistor r=1.2187 c=0
Rk44 (\8\:Dp \10\:Dp) resistor r=0.6473 c=0
Rk45 (\10\:Dp \12\:Dp) resistor r=0.0496 c=0
Rk46 (\10\:Dp \14\:Dp) resistor r=0.3172 c=0
Rk30 (\4\:RNb \5\:RNb) resistor r=0.3251 c=0
Rk31 (\5\:RNb \7\:RNb) resistor r=0.2296 c=0
Rk32 (\5\:RNb \9\:RNb) resistor r=0.2124 c=0
Rk49 (\5\:Eb \7\:Eb) resistor r=0.2817 c=0
Rk50 (\7\:Eb \8\:Eb) resistor r=0.8339 c=0
Rk52 (\5\:Db \6\:Db) resistor r=0.871 c=0
Rk53 (\5\:Db \8\:Db) resistor r=0.2562 c=0
Rk39 (\2\:n2 \4\:n2) resistor r=0.3108 c=0
Rk40 (\2\:n3 \4\:n3) resistor r=0.4708 c=0
Rl49 (\1\:D \2\:D) resistor r=42.0262 c=0
Rl51 (\2\:D \4\:D) resistor r=53.5647 c=0
Rl50 (\2\:D \3\:D) resistor r=3.1741 c=0
Rl10 (\1\:CK \2\:CK) resistor r=49.7141 c=0
Rl12 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl11 (\2\:CK \3\:CK) resistor r=0.5166 c=0
Rl43 (\2\:E \3\:E) resistor r=63.4387 c=0
Rl42 (\1\:E \2\:E) resistor r=134.41 c=0
Rl46 (\4\:E \5\:E) resistor r=49.2335 c=0
Rl48 (\5\:E \7\:E) resistor r=39.6181 c=0
Rl47 (\5\:E \6\:E) resistor r=92.681 c=0
Rl34 (\1\:RN \2\:RN) resistor r=24.2328 c=0
Rl35 (\2\:RN \3\:RN) resistor r=137.694 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=0.5213 c=0
Rl38 (\11\:qbint \12\:qbint) resistor r=211.104 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=145.073 c=0
Rl39 (\12\:qbint \13\:qbint) resistor r=30.0021 c=0
Rl16 (\9\:qbint \10\:qbint) resistor r=24.2328 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=60.772 c=0
Rl4 (qbint \2\:qbint) resistor r=28.0797 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=141.671 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=89.6174 c=0
Rl33 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=24.2328 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=37.2302 c=0
Rl18 (\3\:CKb \4\:CKb) resistor r=39.6174 c=0
Rl17 (CKb \2\:CKb) resistor r=71.8456 c=0
Rl13 (n30 \2\:n30) resistor r=87.2302 c=0
Rl14 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl23 (\2\:mout \4\:mout) resistor r=82.5332 c=0
Rl21 (mout \2\:mout) resistor r=38.6163 c=0
Rl22 (\2\:mout \3\:mout) resistor r=4.287 c=0
Rl28 (\4\:CKbb \5\:CKbb) resistor r=174.131 c=0
Rl27 (\3\:CKbb \4\:CKbb) resistor r=459.181 c=0
Rl25 (CKbb \2\:CKbb) resistor r=28.079 c=0
Rl26 (\2\:CKbb \3\:CKbb) resistor r=166.427 c=0
Rl19 (n20 \2\:n20) resistor r=24.2328 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=89.6174 c=0
Rl31 (\2\:Dp \3\:Dp) resistor r=145.72 c=0
Rl30 (Dp \2\:Dp) resistor r=24.2328 c=0
Rl37 (\2\:RNb \3\:RNb) resistor r=85.7713 c=0
Rl36 (RNb \2\:RNb) resistor r=93.9465 c=0
Rl40 (Eb \2\:Eb) resistor r=119.922 c=0
Rl41 (\2\:Eb \3\:Eb) resistor r=44.9225 c=0
Rl44 (Db \2\:Db) resistor r=223.077 c=0
Rl45 (Db \3\:Db) resistor r=24.2328 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz16 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \17\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz18 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz19 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz20 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz21 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz24 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz25 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz26 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz10 (\21\:qbint \22\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz5 (\9\:mout \10\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz12 (\6\:Dp \7\:Dp) resistor r=75 c=0
Rz9 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz13 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry21 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry22 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry23 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry10 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry7 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry4 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry5 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\6\:CKbb \7\:CKbb) resistor r=62 c=0
Ry6 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry15 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry16 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry9 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry17 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry18 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (n2 \2\:n2) resistor r=62 c=0
Ry12 (\3\:n2 \4\:n2) resistor r=62 c=0
Ry13 (n3 \2\:n3) resistor r=62 c=0
Ry14 (\3\:n3 \4\:n3) resistor r=62 c=0
Rx21 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\3\:CK \5\:CK) resistor r=45 c=0
Rx18 (\6\:E \8\:E) resistor r=45 c=0
Rx19 (\2\:E \9\:E) resistor r=45 c=0
Rx12 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx14 (\13\:qbint \14\:qbint) resistor r=45 c=0
Rx15 (\6\:qbint \19\:qbint) resistor r=45 c=0
Rx16 (\10\:qbint \20\:qbint) resistor r=45 c=0
Rx6 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\8\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\6\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\4\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \21\:CKb) resistor r=45 c=0
Rx3 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx4 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx17 (Dp \9\:Dp) resistor r=45 c=0
Rx13 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx20 (\2\:Eb \8\:Eb) resistor r=45 c=0
Rx22 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q qbint \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\17\:CKb \4\:CK \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\21\:qbint \3\:n30 \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=2.9e-14 ps=1.65e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (net496 \8\:qbint \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=8.7e-15 ps=1.65e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\8\:n30 CKb net496 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.9e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\8\:n30 \4\:CKbb \9\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.147e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.695e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\9\:mout \3\:n20 \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.632e-14 ad=5.147e-14 ps=1.11e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.295e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net516 mout \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.632e-14 ad=8.7e-15 ps=1.11e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=9.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\4\:n20 \3\:CKbb net516 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=8.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn26 (\4\:n20 \7\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=4.132e-14 ps=5.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (n21 \2\:Dp \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=1.957e-14 ps=1.63e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\10\:CKbb \11\:CKb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.407e-14 ad=2.03e-14 ps=1.63e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\8\:RNb \3\:RN \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=8.4e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn3 (\6\:Dp RNb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.8e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn5 (\6\:Dp \11\:qbint n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.75e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn4 (n0 \3\:Eb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=8.7e-15 ps=8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn6 (n1 \1\:E \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn7 (\4\:Dp \2\:Db n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn0 (\6\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \4\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends EDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:14 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFX1
// View name: extracted

simulator lang=spectre

subckt EDFFX1 CK D E Q QN VDD VSS
mp20 (\10\:Ckb \1\:CK \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.15e-07 sd=160n sca=18.4817 \
        scb=0.0199259 scc=0.00053385 m=(1)
mp21 (\18\:CKbb \9\:Ckb \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.3e-14 ad=3.655e-14 ps=8.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.7e-07 sd=160n sca=13.2059 \
        scb=0.0110334 scc=0.000224619 m=(1)
mp25 (\9\:n20 CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88733e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp36 (\9\:n20 \3\:Ckb net342 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.79674e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp35 (net342 mout \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=1.505e-14 ps=1.13e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.74593e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp30 (\4\:mout n20 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=5.912e-14 ps=1.13e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.62884e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp40 (\8\:n30 \2\:Ckb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.73e-14 ps=9.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.48744e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp51 (\8\:n30 \7\:CKbb net362 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.73e-14 ps=6.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.3536e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp50 (net362 \4\:qbint \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.585e-14 ad=2.687e-14 ps=1.6e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.1836e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp1 (\16\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.632e-14 ad=5.415e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28407e-06 sb=1.3e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp3 (\3\:Db Eb n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.333e-14 \
        ad=7.632e-14 ps=7.4e-07 pd=1.14e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.47198e-06 sb=9e-07 sd=160n sca=10.718 scb=0.00841932 \
        scc=0.00013813 m=(1)
mp2 (n1 \1\:D \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=3.333e-14 ps=1.29e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56035e-06 sb=7e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp0 (\8\:Eb \5\:E \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=4.838e-14 ps=1.29e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77023e-06 sb=2.25e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp56 (\9\:qint \5\:qbint \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=2.63e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.22326e-07 sd=160n sca=46.2776 \
        scb=0.0284965 scc=0.00588421 m=(1)
C1 (D VSS) capacitor c=8.40011e-17
C2 (VDD VSS) capacitor c=3.33878e-16
C3 (CK VSS) capacitor c=6.52601e-17
C4 (E VSS) capacitor c=9.54546e-17
C5 (Q VSS) capacitor c=2.85804e-17
C6 (Ckb VSS) capacitor c=8.53126e-17
C7 (CKbb VSS) capacitor c=3.39822e-17
C8 (n20 VSS) capacitor c=5.80581e-17
C9 (Db VSS) capacitor c=1.16219e-16
C10 (mout VSS) capacitor c=6.14457e-17
C11 (n30 VSS) capacitor c=7.78665e-17
C12 (qbint VSS) capacitor c=3.10353e-17
C13 (Eb VSS) capacitor c=3.93968e-17
C14 (qint VSS) capacitor c=3.96525e-17
C15 (net342 VSS) capacitor c=1.45033e-18
C16 (net362 VSS) capacitor c=1.61612e-18
C17 (\5\:qbint VSS) capacitor c=2.26564e-17
C18 (\8\:qbint VSS) capacitor c=3.01909e-17
C19 (\5\:E VSS) capacitor c=2.14147e-17
C20 (\1\:D VSS) capacitor c=4.00153e-17
C21 (\1\:E VSS) capacitor c=4.12108e-17
C22 (\4\:qbint VSS) capacitor c=4.56902e-17
C23 (\7\:CKbb VSS) capacitor c=5.28052e-17
C24 (\2\:Ckb VSS) capacitor c=1.30479e-16
C25 (\3\:Ckb VSS) capacitor c=1.25892e-16
C26 (\9\:Ckb VSS) capacitor c=4.06667e-17
C27 (\1\:CK VSS) capacitor c=3.45373e-17
C28 (\4\:qint VSS) capacitor c=2.9831e-17
C29 (\9\:qbint VSS) capacitor c=1.80605e-17
C30 (\10\:qbint VSS) capacitor c=2.20695e-17
C31 (\7\:E VSS) capacitor c=4.45729e-17
C32 (\3\:D VSS) capacitor c=4.26495e-17
C33 (\3\:E VSS) capacitor c=4.98427e-17
C34 (\3\:Eb VSS) capacitor c=6.60266e-17
C35 (\4\:n30 VSS) capacitor c=3.14602e-17
C36 (\3\:qbint VSS) capacitor c=6.4611e-17
C37 (\5\:CKbb VSS) capacitor c=3.36549e-17
C38 (\4\:n20 VSS) capacitor c=3.15199e-17
C39 (\3\:mout VSS) capacitor c=6.94062e-17
C40 (\3\:CKbb VSS) capacitor c=8.17604e-17
C41 (\8\:Ckb VSS) capacitor c=2.93879e-17
C42 (\7\:Ckb VSS) capacitor c=2.46352e-17
C43 (\3\:CK VSS) capacitor c=3.89345e-17
C44 (\3\:qint VSS) capacitor c=1.46096e-17
C45 (\7\:qbint VSS) capacitor c=1.53631e-17
C46 (\6\:E VSS) capacitor c=2.78233e-17
C47 (\2\:D VSS) capacitor c=4.76773e-17
C48 (\2\:Eb VSS) capacitor c=7.95762e-17
C49 (\4\:E VSS) capacitor c=5.06111e-17
C50 (\2\:E VSS) capacitor c=2.09307e-17
C51 (\3\:n30 VSS) capacitor c=1.86493e-17
C52 (\8\:CKbb VSS) capacitor c=3.94217e-17
C53 (\6\:CKbb VSS) capacitor c=4.24286e-17
C54 (\3\:n20 VSS) capacitor c=1.63675e-17
C55 (\2\:mout VSS) capacitor c=4.96563e-17
C56 (\4\:CKbb VSS) capacitor c=2.57274e-17
C57 (\2\:CKbb VSS) capacitor c=4.77483e-17
C58 (\6\:Ckb VSS) capacitor c=1.78633e-17
C59 (\2\:CK VSS) capacitor c=4.27421e-17
C60 (\1\:QN VSS) capacitor c=4.07915e-17
C61 (\11\:VDD VSS) capacitor c=2.54141e-17
C62 (\9\:qint VSS) capacitor c=2.6284e-17
C63 (\13\:VDD VSS) capacitor c=7.37376e-17
C64 (\1\:Q VSS) capacitor c=7.63151e-17
C65 (\8\:Eb VSS) capacitor c=7.12624e-17
C66 (\15\:VDD VSS) capacitor c=3.47924e-17
C67 (\3\:Db VSS) capacitor c=2.44599e-16
C68 (\16\:qbint VSS) capacitor c=4.50607e-17
C69 (\17\:VDD VSS) capacitor c=2.37579e-17
C70 (\8\:n30 VSS) capacitor c=7.38632e-17
C71 (\4\:mout VSS) capacitor c=3.2421e-17
C72 (\19\:VDD VSS) capacitor c=4.80485e-17
C73 (\9\:n20 VSS) capacitor c=4.19835e-17
C74 (\5\:Db VSS) capacitor c=2.55209e-16
C75 (\18\:CKbb VSS) capacitor c=8.4515e-17
C76 (\21\:VDD VSS) capacitor c=3.26099e-17
C77 (\10\:Ckb VSS) capacitor c=4.55267e-17
C78 (\1\:VDD VSS) capacitor c=7.27798e-17
C79 (\3\:QN VSS) capacitor c=2.71516e-17
C80 (\7\:qint VSS) capacitor c=2.17196e-17
C81 (\3\:Q VSS) capacitor c=4.9349e-17
C82 (\4\:Eb VSS) capacitor c=4.39085e-17
C83 (\12\:qbint VSS) capacitor c=2.25099e-16
C84 (\5\:n30 VSS) capacitor c=5.56679e-17
C85 (\8\:mout VSS) capacitor c=7.34156e-17
C86 (\7\:n20 VSS) capacitor c=3.82446e-17
C87 (\7\:Db VSS) capacitor c=9.57513e-17
C88 (\13\:CKbb VSS) capacitor c=9.15059e-17
C89 (\13\:Ckb VSS) capacitor c=1.85299e-17
C90 (\2\:n20 VSS) capacitor c=2.36768e-17
C91 (\4\:Ckb VSS) capacitor c=7.31788e-17
C92 (\5\:Ckb VSS) capacitor c=3.51512e-17
C93 (\2\:qbint VSS) capacitor c=2.74292e-17
C94 (\2\:n30 VSS) capacitor c=2.14216e-17
C95 (\6\:qbint VSS) capacitor c=1.12921e-17
C96 (\2\:qint VSS) capacitor c=5.72301e-18
C97 (\12\:Ckb VSS) capacitor c=4.69547e-17
C98 (\15\:Ckb VSS) capacitor c=5.08168e-17
C99 (\4\:CK VSS) capacitor c=4.65406e-17
C100 (\5\:n20 VSS) capacitor c=4.96788e-17
C101 (\6\:n20 VSS) capacitor c=5.4232e-17
C102 (\6\:mout VSS) capacitor c=6.21278e-17
C103 (\7\:mout VSS) capacitor c=5.70407e-17
C104 (\9\:CKbb VSS) capacitor c=2.53859e-17
C105 (\10\:CKbb VSS) capacitor c=1.25505e-16
C106 (\12\:CKbb VSS) capacitor c=6.5403e-17
C107 (\15\:CKbb VSS) capacitor c=4.9673e-17
C108 (\16\:CKbb VSS) capacitor c=1.01595e-16
C109 (\17\:CKbb VSS) capacitor c=7.37441e-17
C110 (\7\:n30 VSS) capacitor c=5.79298e-17
C111 (\10\:n30 VSS) capacitor c=4.12398e-17
C112 (\4\:D VSS) capacitor c=5.11124e-17
C113 (\8\:E VSS) capacitor c=6.39419e-17
C114 (\9\:E VSS) capacitor c=1.07044e-16
C115 (\10\:E VSS) capacitor c=6.85673e-17
C116 (\6\:Eb VSS) capacitor c=1.01877e-16
C117 (\7\:Eb VSS) capacitor c=1.09241e-16
C118 (\11\:qbint VSS) capacitor c=1.85883e-16
C119 (\14\:qbint VSS) capacitor c=5.74703e-17
C120 (\15\:qbint VSS) capacitor c=3.95398e-17
C121 (\5\:qint VSS) capacitor c=1.32297e-17
C122 (\6\:qint VSS) capacitor c=1.56262e-17
C123 (\3\:VDD VSS) capacitor c=3.59859e-18
C124 (\4\:VDD VSS) capacitor c=1.82786e-17
C125 (\5\:VDD VSS) capacitor c=1.73197e-17
C126 (\7\:VDD VSS) capacitor c=5.08102e-17
C127 (\8\:VDD VSS) capacitor c=2.95524e-17
C128 (\10\:VDD VSS) capacitor c=1.67997e-17
Rk25 (\4\:D D) resistor r=0.02915 c=0
Rk42 (\2\:QN QN) resistor r=0.3009 c=0
Rk43 (QN \4\:QN) resistor r=0.05391 c=0
Rk59 (\2\:VSS \3\:VSS) resistor r=0.06245 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.1224 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.5709 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.04491 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.4759 c=0
Rk64 (\7\:VSS \8\:VSS) resistor r=0.5108 c=0
Rk65 (\8\:VSS \9\:VSS) resistor r=0.2153 c=0
Rk67 (\10\:VSS VSS) resistor r=0.1474 c=0
Rk66 (\9\:VSS \10\:VSS) resistor r=0.4032 c=0
Rk68 (\3\:VSS \12\:VSS) resistor r=0.07415 c=0
Rk69 (\4\:VSS \14\:VSS) resistor r=0.07415 c=0
Rk70 (\5\:VSS \16\:VSS) resistor r=0.1219 c=0
Rk71 (\7\:VSS \18\:VSS) resistor r=0.3279 c=0
Rk72 (\8\:VSS \20\:VSS) resistor r=0.102 c=0
Rk73 (\10\:VSS \22\:VSS) resistor r=0.2812 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.05493 c=0
Rk45 (\3\:VDD \4\:VDD) resistor r=0.1976 c=0
Rk46 (\4\:VDD \5\:VDD) resistor r=0.5033 c=0
Rk47 (\5\:VDD \6\:VDD) resistor r=0.04491 c=0
Rk48 (\6\:VDD \7\:VDD) resistor r=0.506 c=0
Rk49 (\7\:VDD \8\:VDD) resistor r=0.5108 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.1852 c=0
Rk52 (\10\:VDD VDD) resistor r=0.1474 c=0
Rk51 (\9\:VDD \10\:VDD) resistor r=0.4032 c=0
Rk53 (\3\:VDD \12\:VDD) resistor r=0.3034 c=0
Rk54 (\4\:VDD \14\:VDD) resistor r=0.3955 c=0
Rk55 (\5\:VDD \16\:VDD) resistor r=0.2525 c=0
Rk56 (\7\:VDD \18\:VDD) resistor r=0.102 c=0
Rk57 (\8\:VDD \20\:VDD) resistor r=0.2247 c=0
Rk58 (\10\:VDD \22\:VDD) resistor r=0.2724 c=0
Rk4 (\4\:CK CK) resistor r=0.1913 c=0
Rk28 (\9\:E E) resistor r=0.591 c=0
Rk26 (\8\:E \9\:E) resistor r=0.298 c=0
Rk27 (\9\:E \10\:E) resistor r=0.4474 c=0
Rk29 (E \11\:E) resistor r=0.005986 c=0
Rk33 (Q \2\:Q) resistor r=0.1437 c=0
Rk34 (Q \4\:Q) resistor r=0.1526 c=0
Rk1 (\11\:Ckb \12\:Ckb) resistor r=0.3871 c=0
Rk2 (\12\:Ckb \14\:Ckb) resistor r=0.1224 c=0
Rk3 (\12\:Ckb \15\:Ckb) resistor r=0.2161 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.02782 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.881 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2309 c=0
Rk14 (\12\:CKbb \14\:CKbb) resistor r=0.2964 c=0
Rk15 (\10\:CKbb \15\:CKbb) resistor r=0.2216 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.0153 c=0
Rk17 (\12\:CKbb \17\:CKbb) resistor r=0.3653 c=0
Rk18 (\14\:CKbb \19\:CKbb) resistor r=0.5279 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.2834 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.1271 c=0
Rk7 (\6\:n20 \10\:n20) resistor r=0.2466 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6236 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.6561 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5727 c=0
Rk8 (\5\:mout \6\:mout) resistor r=0.1508 c=0
Rk9 (\6\:mout \7\:mout) resistor r=0.2802 c=0
Rk10 (\6\:mout \9\:mout) resistor r=0.3002 c=0
Rk19 (\6\:n30 \7\:n30) resistor r=0.2364 c=0
Rk20 (\7\:n30 \9\:n30) resistor r=0.4212 c=0
Rk21 (\7\:n30 \10\:n30) resistor r=0.1677 c=0
Rk35 (\11\:qbint \13\:qbint) resistor r=1.6067 c=0
Rk36 (\13\:qbint \14\:qbint) resistor r=0.3925 c=0
Rk37 (\14\:qbint \15\:qbint) resistor r=0.1573 c=0
Rk38 (\14\:qbint \17\:qbint) resistor r=0.09343 c=0
Rk30 (\5\:Eb \6\:Eb) resistor r=0.2046 c=0
Rk31 (\6\:Eb \7\:Eb) resistor r=0.6985 c=0
Rk32 (\6\:Eb \9\:Eb) resistor r=0.4704 c=0
Rk39 (\5\:qint \6\:qint) resistor r=0.05315 c=0
Rk40 (\6\:qint \8\:qint) resistor r=0.09647 c=0
Rk41 (\6\:qint \10\:qint) resistor r=0.1264 c=0
Rl30 (\1\:D \2\:D) resistor r=106.461 c=0
Rl31 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl1 (\1\:CK \2\:CK) resistor r=95.3867 c=0
Rl2 (\2\:CK \3\:CK) resistor r=99.2328 c=0
Rl32 (\5\:E \6\:E) resistor r=29.5379 c=0
Rl33 (\6\:E \7\:E) resistor r=154.538 c=0
Rl27 (\3\:E \4\:E) resistor r=89.8977 c=0
Rl26 (\1\:E \2\:E) resistor r=33.8482 c=0
Rl13 (\2\:Ckb \3\:Ckb) resistor r=389.516 c=0
Rl12 (Ckb \2\:Ckb) resistor r=237.593 c=0
Rl17 (\6\:Ckb \7\:Ckb) resistor r=35.7134 c=0
Rl14 (\3\:Ckb \4\:Ckb) resistor r=174.543 c=0
Rl18 (\4\:Ckb \8\:Ckb) resistor r=30.4507 c=0
Rl19 (\5\:Ckb \9\:Ckb) resistor r=135.772 c=0
Rl16 (\5\:Ckb \6\:Ckb) resistor r=15.7162 c=0
Rl15 (\4\:Ckb \5\:Ckb) resistor r=214.3 c=0
Rl11 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=39.1533 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=58.8482 c=0
Rl3 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl7 (n20 \2\:n20) resistor r=102.726 c=0
Rl9 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl8 (\2\:n20 \3\:n20) resistor r=1.2301 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\2\:mout \3\:mout) resistor r=97.3098 c=0
Rl23 (n30 \2\:n30) resistor r=107.406 c=0
Rl25 (\2\:n30 \4\:n30) resistor r=34.3295 c=0
Rl24 (\2\:n30 \3\:n30) resistor r=1.2666 c=0
Rl36 (\7\:qbint \8\:qbint) resistor r=56.5101 c=0
Rl38 (\7\:qbint \10\:qbint) resistor r=24.5191 c=0
Rl22 (\2\:qbint \4\:qbint) resistor r=34.3295 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=107.406 c=0
Rl20 (qbint \2\:qbint) resistor r=11.5001 c=0
Rl34 (\5\:qbint \6\:qbint) resistor r=53.0797 c=0
Rl37 (\6\:qbint \9\:qbint) resistor r=35.772 c=0
Rl35 (\6\:qbint \7\:qbint) resistor r=35.7515 c=0
Rl28 (Eb \2\:Eb) resistor r=106.925 c=0
Rl29 (\2\:Eb \3\:Eb) resistor r=201.477 c=0
Rl39 (qint \2\:qint) resistor r=60.772 c=0
Rl41 (\2\:qint \4\:qint) resistor r=28.0797 c=0
Rl40 (\2\:qint \3\:qint) resistor r=34.9887 c=0
Rz12 (\3\:QN \4\:QN) resistor r=75 c=0
Rz16 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz19 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz21 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz14 (\1\:VDD \6\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VDD \9\:VDD) resistor r=6.25 c=0
Rz9 (\3\:Q \4\:Q) resistor r=75 c=0
Rz1 (\13\:Ckb \14\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz10 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz8 (\4\:Eb \5\:Eb) resistor r=75 c=0
Rz11 (\7\:qint \8\:qint) resistor r=75 c=0
Ry12 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry19 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry20 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry21 (\1\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry9 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry1 (\10\:Ckb \11\:Ckb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry10 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry11 (\9\:qint \10\:qint) resistor r=62 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx11 (\4\:E \8\:E) resistor r=45 c=0
Rx12 (\2\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx1 (\6\:Ckb \15\:Ckb) resistor r=45 c=0
Rx5 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \10\:n30) resistor r=45 c=0
Rx15 (\7\:qbint \11\:qbint) resistor r=45 c=0
Rx16 (qbint \15\:qbint) resistor r=45 c=0
Rx14 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx17 (\3\:qint \5\:qint) resistor r=45 c=0
mn20 (\13\:Ckb \3\:CK \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.15e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn21 (\13\:CKbb \7\:Ckb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.1e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn25 (\7\:Db \8\:Ckb \7\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=4.132e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.89034e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKbb net411 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=2.827e-14 ps=4.2e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.79103e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net411 \3\:mout \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=9.43e-15 ps=1.6e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.74552e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \4\:n20 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout \5\:CKbb \5\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.50345e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 Ckb net415 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=3.988e-14 ps=4.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.27138e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net415 \3\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=1.015e-14 ps=8.5e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.15638e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\12\:qbint \3\:Eb Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=4.877e-14 ps=8.7e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37103e-06 sb=1.11e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn3 (Db \3\:E n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.667e-14 \
        ad=4.205e-14 ps=5.2e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.50966e-06 sb=7.75e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (n0 \3\:D \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.775e-14 ad=1.668e-14 ps=1.74e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57586e-06 sb=6.15e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn0 (\4\:Eb \7\:E \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.775e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77241e-06 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn56 (\7\:qint \9\:qbint \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.545e-14 ad=2.03e-14 ps=1.73e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\12\:qbint \4\:n30 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.877e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39902e-06 sb=1.05488e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\3\:Q \10\:qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.545e-14 ad=4.16e-14 ps=1.73e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn57 (\3\:QN \4\:qint \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.04e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.585e-14 ad=5.415e-14 ps=1.6e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.26234e-06 sb=1.1075e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp55 (\1\:Q \8\:qbint \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.59808e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp57 (\1\:QN qint \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.56e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16923e-07 sb=1.6e-07 sd=160n sca=34.4399 \
        scb=0.0250891 scc=0.0034155 m=(1)
ends EDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:15 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFX2
// View name: extracted

simulator lang=spectre

subckt EDFFX2 CK D E Q QN VDD VSS
mp20 (\17\:Ckb \4\:CK \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=28.9181 \
        scb=0.0340412 scc=0.0022918 m=(1)
mp21 (\15\:CKbb \8\:Ckb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=18.8843 \
        scb=0.0193686 scc=0.00092718 m=(1)
mp25 (\7\:n20 CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.80349e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\7\:n20 \2\:Ckb net342 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.398e-14 ad=3.44e-14 ps=5.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.67953e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp35 (net342 mout \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=1.397e-14 ps=1.9e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.59721e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout n20 \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=6.127e-14 ps=1.9e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.33221e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\5\:n30 \11\:Ckb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=1.00221e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (\5\:n30 \7\:CKbb net362 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.97209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (net362 qbint \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=1.29e-14 ps=1.33e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=6.92209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp1 (\23\:qbint \1\:E \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=7.908e-14 ps=8e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02721e-06 sb=5.05e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp3 (\3\:Db \4\:Eb n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.978e-14 ps=5.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20186e-06 sb=2.75e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp2 (n1 \3\:D \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.715e-14 ad=1.29e-14 ps=1.28e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26535e-06 sb=1.7e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp0 (\9\:Eb \5\:E \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.053e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.29e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp56 (\11\:qint \13\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=27.7871 \
        scb=0.0280637 scc=0.00253496 m=(1)
C1 (D VSS) capacitor c=4.89768e-17
C2 (Q VSS) capacitor c=6.17462e-17
C3 (QN VSS) capacitor c=5.14574e-17
C4 (VDD VSS) capacitor c=2.99125e-16
C5 (CK VSS) capacitor c=7.75737e-17
C6 (Ckb VSS) capacitor c=3.28592e-17
C7 (CKbb VSS) capacitor c=4.44424e-17
C8 (n20 VSS) capacitor c=3.85206e-17
C9 (Db VSS) capacitor c=9.175e-17
C10 (mout VSS) capacitor c=7.5892e-17
C11 (n30 VSS) capacitor c=5.86032e-17
C12 (net415 VSS) capacitor c=1.90771e-18
C13 (qbint VSS) capacitor c=7.37011e-17
C14 (Eb VSS) capacitor c=5.58861e-17
C15 (n0 VSS) capacitor c=4.08733e-19
C16 (qint VSS) capacitor c=1.90388e-16
C17 (net342 VSS) capacitor c=7.55565e-19
C18 (net362 VSS) capacitor c=2.84036e-18
C19 (n1 VSS) capacitor c=1.5203e-18
C20 (\13\:qbint VSS) capacitor c=4.51214e-17
C21 (\4\:qbint VSS) capacitor c=5.55499e-16
C22 (\5\:E VSS) capacitor c=3.44728e-17
C23 (\3\:D VSS) capacitor c=9.26526e-17
C24 (\4\:Eb VSS) capacitor c=6.41809e-17
C25 (\1\:E VSS) capacitor c=4.2393e-17
C26 (\7\:CKbb VSS) capacitor c=7.12339e-17
C27 (\11\:Ckb VSS) capacitor c=5.27579e-17
C28 (\2\:Ckb VSS) capacitor c=8.57231e-17
C29 (\8\:Ckb VSS) capacitor c=5.26263e-17
C30 (\4\:CK VSS) capacitor c=3.54446e-17
C31 (\12\:qbint VSS) capacitor c=4.23158e-17
C32 (\7\:E VSS) capacitor c=3.91324e-17
C33 (\1\:D VSS) capacitor c=6.54145e-17
C34 (\3\:E VSS) capacitor c=5.66781e-17
C35 (\3\:Eb VSS) capacitor c=5.51961e-17
C36 (\3\:n30 VSS) capacitor c=4.58235e-17
C37 (\3\:qbint VSS) capacitor c=2.75634e-17
C38 (\10\:Ckb VSS) capacitor c=5.67935e-17
C39 (\6\:CKbb VSS) capacitor c=4.5756e-17
C40 (\4\:n20 VSS) capacitor c=4.58757e-17
C41 (\3\:mout VSS) capacitor c=5.33598e-17
C42 (\3\:CKbb VSS) capacitor c=8.50587e-17
C43 (\7\:Ckb VSS) capacitor c=3.3259e-17
C44 (\9\:Ckb VSS) capacitor c=2.58329e-17
C45 (\3\:CK VSS) capacitor c=5.94262e-17
C46 (\11\:qbint VSS) capacitor c=2.18643e-17
C47 (\6\:E VSS) capacitor c=2.99968e-17
C48 (\2\:D VSS) capacitor c=4.96697e-17
C49 (\4\:E VSS) capacitor c=5.3414e-17
C50 (\2\:E VSS) capacitor c=2.54306e-17
C51 (\2\:n30 VSS) capacitor c=2.74391e-17
C52 (\2\:qbint VSS) capacitor c=3.84825e-17
C53 (\8\:CKbb VSS) capacitor c=4.05387e-17
C54 (\12\:Ckb VSS) capacitor c=2.42566e-17
C55 (\5\:CKbb VSS) capacitor c=2.67756e-17
C56 (\3\:n20 VSS) capacitor c=1.97591e-17
C57 (\2\:mout VSS) capacitor c=4.64126e-17
C58 (\4\:CKbb VSS) capacitor c=2.81851e-17
C59 (\2\:CKbb VSS) capacitor c=4.4584e-17
C60 (\6\:Ckb VSS) capacitor c=2.61461e-17
C61 (\1\:CK VSS) capacitor c=2.46484e-17
C62 (\11\:qint VSS) capacitor c=2.53749e-17
C63 (\1\:QN VSS) capacitor c=8.98535e-17
C64 (\1\:Q VSS) capacitor c=9.26727e-17
C65 (\9\:Eb VSS) capacitor c=8.55625e-17
C66 (\19\:VDD VSS) capacitor c=3.18068e-17
C67 (\3\:Db VSS) capacitor c=2.63889e-16
C68 (\23\:qbint VSS) capacitor c=7.21698e-17
C69 (\21\:VDD VSS) capacitor c=4.65098e-17
C70 (\5\:n30 VSS) capacitor c=1.157e-16
C71 (\8\:mout VSS) capacitor c=6.3053e-17
C72 (\23\:VDD VSS) capacitor c=1.69799e-17
C73 (\7\:n20 VSS) capacitor c=3.85281e-17
C74 (\5\:Db VSS) capacitor c=2.53121e-16
C75 (\15\:CKbb VSS) capacitor c=8.04575e-17
C76 (\25\:VDD VSS) capacitor c=3.53807e-17
C77 (\17\:Ckb VSS) capacitor c=5.63668e-17
C78 (\1\:VDD VSS) capacitor c=5.06617e-17
C79 (\7\:qint VSS) capacitor c=2.56789e-17
C80 (\3\:QN VSS) capacitor c=3.35444e-17
C81 (\3\:Q VSS) capacitor c=3.75786e-17
C82 (\5\:Eb VSS) capacitor c=2.63208e-17
C83 (\17\:qbint VSS) capacitor c=1.42311e-16
C84 (\7\:n30 VSS) capacitor c=8.2179e-17
C85 (\6\:mout VSS) capacitor c=3.01222e-17
C86 (\9\:n20 VSS) capacitor c=5.75936e-17
C87 (\7\:Db VSS) capacitor c=7.87079e-17
C88 (\13\:CKbb VSS) capacitor c=1.0077e-16
C89 (\15\:Ckb VSS) capacitor c=1.97294e-17
C90 (\2\:CK VSS) capacitor c=3.01694e-17
C91 (\3\:Ckb VSS) capacitor c=6.08583e-17
C92 (\4\:Ckb VSS) capacitor c=4.30907e-17
C93 (\5\:Ckb VSS) capacitor c=1.01166e-17
C94 (\2\:n20 VSS) capacitor c=1.88959e-17
C95 (\2\:Eb VSS) capacitor c=5.46051e-17
C96 (\5\:CK VSS) capacitor c=4.4729e-17
C97 (\13\:Ckb VSS) capacitor c=4.40522e-17
C98 (\14\:Ckb VSS) capacitor c=3.84277e-17
C99 (\5\:n20 VSS) capacitor c=5.72654e-17
C100 (\6\:n20 VSS) capacitor c=4.68412e-17
C101 (\4\:mout VSS) capacitor c=4.95846e-17
C102 (\5\:mout VSS) capacitor c=4.22804e-17
C103 (\19\:Ckb VSS) capacitor c=8.37903e-17
C104 (\20\:Ckb VSS) capacitor c=8.49002e-17
C105 (\9\:CKbb VSS) capacitor c=2.61102e-17
C106 (\10\:CKbb VSS) capacitor c=1.17317e-16
C107 (\11\:CKbb VSS) capacitor c=6.15255e-17
C108 (\12\:CKbb VSS) capacitor c=5.58201e-17
C109 (\17\:CKbb VSS) capacitor c=8.33248e-17
C110 (\18\:CKbb VSS) capacitor c=7.18095e-17
C111 (\4\:n30 VSS) capacitor c=7.64809e-17
C112 (\4\:D VSS) capacitor c=6.68671e-17
C113 (\7\:Eb VSS) capacitor c=1.13463e-16
C114 (\8\:Eb VSS) capacitor c=1.00715e-16
C115 (\8\:E VSS) capacitor c=7.24044e-17
C116 (\9\:E VSS) capacitor c=1.25452e-16
C117 (\10\:E VSS) capacitor c=4.64372e-17
C118 (\11\:E VSS) capacitor c=1.4226e-16
C119 (\14\:qbint VSS) capacitor c=6.44851e-17
C120 (\19\:qbint VSS) capacitor c=4.18994e-17
C121 (\20\:qbint VSS) capacitor c=5.2874e-17
C122 (\9\:qint VSS) capacitor c=2.54003e-17
C123 (\10\:qint VSS) capacitor c=3.26566e-17
C124 (\3\:VDD VSS) capacitor c=2.61916e-16
C125 (\7\:VDD VSS) capacitor c=2.86871e-17
C126 (\8\:VDD VSS) capacitor c=3.40592e-17
C127 (\9\:VDD VSS) capacitor c=1.90485e-17
C128 (\11\:VDD VSS) capacitor c=1.29938e-17
Rk24 (D \4\:D) resistor r=0.09311 c=0
Rk32 (\2\:Q Q) resistor r=0.3614 c=0
Rk33 (Q \4\:Q) resistor r=0.06696 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.05404 c=0
Rk50 (\3\:VSS \6\:VSS) resistor r=0.2146 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.1218 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.4853 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.4702 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.1218 c=0
Rk56 (\11\:VSS VSS) resistor r=0.08734 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.4638 c=0
Rk60 (\7\:VSS \19\:VSS) resistor r=0.04332 c=0
Rk61 (\8\:VSS \21\:VSS) resistor r=0.2651 c=0
Rk62 (\9\:VSS \23\:VSS) resistor r=0.04332 c=0
Rk63 (\11\:VSS \25\:VSS) resistor r=0.1803 c=0
Rk34 (\2\:QN QN) resistor r=0.3684 c=0
Rk35 (QN \4\:QN) resistor r=0.07892 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.09261 c=0
Rk67 (\3\:VDD \6\:VDD) resistor r=0.2306 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.198 c=0
Rk69 (\7\:VDD \8\:VDD) resistor r=0.4411 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.4401 c=0
Rk71 (\9\:VDD \10\:VDD) resistor r=0.1218 c=0
Rk73 (\11\:VDD VDD) resistor r=0.1024 c=0
Rk72 (\10\:VDD \11\:VDD) resistor r=0.4488 c=0
Rk78 (\7\:VDD \20\:VDD) resistor r=0.1563 c=0
Rk79 (\8\:VDD \22\:VDD) resistor r=0.2634 c=0
Rk80 (\9\:VDD \24\:VDD) resistor r=0.04332 c=0
Rk81 (\11\:VDD \26\:VDD) resistor r=0.3317 c=0
Rk1 (\5\:CK CK) resistor r=0.009896 c=0
Rk30 (\9\:E E) resistor r=0.9201 c=0
Rk28 (\8\:E \9\:E) resistor r=0.4126 c=0
Rk29 (\9\:E \10\:E) resistor r=0.2656 c=0
Rk31 (E \11\:E) resistor r=0.01024 c=0
Rk2 (\13\:Ckb \14\:Ckb) resistor r=0.1577 c=0
Rk3 (\14\:Ckb \16\:Ckb) resistor r=0.1183 c=0
Rk4 (\14\:Ckb \18\:Ckb) resistor r=0.4309 c=0
Rk11 (\19\:Ckb \20\:Ckb) resistor r=0.4206 c=0
Rk12 (\9\:CKbb \10\:CKbb) resistor r=0.03538 c=0
Rk13 (\10\:CKbb \11\:CKbb) resistor r=0.5838 c=0
Rk14 (\11\:CKbb \12\:CKbb) resistor r=0.09782 c=0
Rk15 (\12\:CKbb \14\:CKbb) resistor r=0.2801 c=0
Rk16 (\14\:CKbb \16\:CKbb) resistor r=0.588 c=0
Rk17 (\10\:CKbb \17\:CKbb) resistor r=0.5166 c=0
Rk18 (\12\:CKbb \18\:CKbb) resistor r=0.3366 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.2661 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.07753 c=0
Rk7 (\6\:n20 \10\:n20) resistor r=0.2567 c=0
Rk21 (\2\:Db \4\:Db) resistor r=0.5172 c=0
Rk22 (\4\:Db \6\:Db) resistor r=1.5614 c=0
Rk23 (\6\:Db \8\:Db) resistor r=0.4526 c=0
Rk8 (\4\:mout \5\:mout) resistor r=0.2397 c=0
Rk9 (\5\:mout \7\:mout) resistor r=0.07152 c=0
Rk10 (\5\:mout \9\:mout) resistor r=0.2656 c=0
Rk19 (\4\:n30 \6\:n30) resistor r=0.4558 c=0
Rk20 (\6\:n30 \8\:n30) resistor r=0.4297 c=0
Rk36 (\14\:qbint \4\:qbint) resistor r=0.5168 c=0
Rk38 (\4\:qbint \18\:qbint) resistor r=1.1352 c=0
Rk39 (\18\:qbint \19\:qbint) resistor r=0.1491 c=0
Rk40 (\19\:qbint \20\:qbint) resistor r=0.2199 c=0
Rk43 (\19\:qbint \24\:qbint) resistor r=0.2879 c=0
Rk25 (\6\:Eb \7\:Eb) resistor r=0.07551 c=0
Rk26 (\7\:Eb \8\:Eb) resistor r=0.5 c=0
Rk27 (\7\:Eb \10\:Eb) resistor r=0.4461 c=0
Rk44 (\8\:qint \9\:qint) resistor r=0.1706 c=0
Rk45 (\9\:qint \10\:qint) resistor r=0.1518 c=0
Rk46 (\9\:qint \12\:qint) resistor r=0.2338 c=0
Rl33 (\2\:D \3\:D) resistor r=218.029 c=0
Rl32 (\1\:D \2\:D) resistor r=101.477 c=0
Rl3 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl2 (\2\:CK \3\:CK) resistor r=167.022 c=0
Rl1 (\1\:CK \2\:CK) resistor r=1.2713 c=0
Rl34 (\5\:E \6\:E) resistor r=37.2302 c=0
Rl35 (\6\:E \7\:E) resistor r=79.5379 c=0
Rl28 (\3\:E \4\:E) resistor r=47.8762 c=0
Rl27 (\1\:E \2\:E) resistor r=66.5405 c=0
Rl20 (\10\:Ckb \11\:Ckb) resistor r=143.429 c=0
Rl21 (\11\:Ckb \12\:Ckb) resistor r=50.6918 c=0
Rl5 (Ckb \2\:Ckb) resistor r=47.2519 c=0
Rl6 (\2\:Ckb \3\:Ckb) resistor r=184.159 c=0
Rl10 (\3\:Ckb \7\:Ckb) resistor r=30.4507 c=0
Rl11 (\4\:Ckb \8\:Ckb) resistor r=145.387 c=0
Rl7 (\3\:Ckb \4\:Ckb) resistor r=181.607 c=0
Rl12 (\5\:Ckb \9\:Ckb) resistor r=34.3295 c=0
Rl9 (\5\:Ckb \6\:Ckb) resistor r=2.0166 c=0
Rl8 (\4\:Ckb \5\:Ckb) resistor r=54.7169 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=72.2327 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=48.7697 c=0
Rl4 (CKbb \2\:CKbb) resistor r=31.9251 c=0
Rl16 (n20 \2\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=87.3411 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=3.1183 c=0
Rl14 (mout \2\:mout) resistor r=79.5379 c=0
Rl15 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (n30 \2\:n30) resistor r=26.098 c=0
Rl26 (\2\:n30 \3\:n30) resistor r=53.0211 c=0
Rl47 (\12\:qbint \13\:qbint) resistor r=153.412 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=36.2715 c=0
Rl23 (\2\:qbint qbint) resistor r=81.9251 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=24.2328 c=0
Rl31 (\2\:Eb \4\:Eb) resistor r=70.8353 c=0
Rl30 (\2\:Eb \3\:Eb) resistor r=136.516 c=0
Rl29 (Eb \2\:Eb) resistor r=76.8484 c=0
Rz9 (\4\:Q \3\:Q) resistor r=75 c=0
Rz16 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz17 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz18 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz19 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz10 (\4\:QN \3\:QN) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz21 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\15\:Ckb \16\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz5 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz11 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz8 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz12 (\8\:qint \7\:qint) resistor r=75 c=0
Ry9 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry14 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry10 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry20 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry23 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\17\:Ckb \18\:Ckb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry5 (\5\:n30 \6\:n30) resistor r=62 c=0
Ry11 (\24\:qbint \23\:qbint) resistor r=62 c=0
Ry8 (\9\:Eb \10\:Eb) resistor r=62 c=0
Ry12 (\12\:qint \11\:qint) resistor r=62 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx14 (\4\:E \8\:E) resistor r=45 c=0
Rx15 (\2\:E \10\:E) resistor r=45 c=0
Rx16 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\6\:Ckb \13\:Ckb) resistor r=45 c=0
Rx5 (\12\:Ckb \19\:Ckb) resistor r=45 c=0
Rx6 (Ckb \20\:Ckb) resistor r=45 c=0
Rx7 (\5\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx17 (\14\:qbint \11\:qbint) resistor r=45 c=0
Rx18 (\20\:qbint \2\:qbint) resistor r=45 c=0
Rx13 (Eb \8\:Eb) resistor r=45 c=0
Rx21 (\10\:qint qint) resistor r=45 c=0
mn20 (\15\:Ckb \3\:CK \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn21 (\13\:CKbb \9\:Ckb \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.102e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn25 (\7\:Db \7\:Ckb \9\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=3.117e-14 ps=8.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=1.96414e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\9\:n20 \3\:CKbb net411 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.77e-14 ps=4.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.92207e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (net411 \3\:mout \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.90759e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\6\:mout \4\:n20 \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=2.32e-14 ps=1.38e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.71155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\6\:mout \6\:CKbb \7\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=1.50655e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn51 (\7\:n30 \10\:Ckb net415 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.30155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (net415 \3\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.632e-14 ad=2.682e-14 ps=9.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=1.07155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (\17\:qbint \3\:Eb Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=6.493e-14 ps=6.4e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79103e-06 sb=5.2e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn3 (Db \3\:E n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.233e-14 \
        ad=2.537e-14 ps=4.6e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.82138e-06 sb=3e-07 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn2 (n0 \1\:D \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.605e-14 ad=1.233e-14 ps=1.32e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83931e-06 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn0 (\5\:Eb \7\:E \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.205e-14 ad=2.03e-14 ps=1.47e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.365e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn56 (\7\:qint \12\:qbint \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.205e-14 ad=2.03e-14 ps=1.47e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.365e-06 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn45 (\17\:qbint \3\:n30 \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.633e-14 ad=6.493e-14 ps=9.7e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.05654e-06 sb=5.64808e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn55 (\3\:Q \4\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.493e-14 ad=4.68e-14 ps=1.47e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=9.96058e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn57 (\3\:QN qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.493e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.91058e-07 sb=5.06058e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mp45 (\23\:qbint n30 \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=7.908e-14 ps=1.33e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.74872e-07 sb=5.05962e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp55 (\1\:Q \4\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.002e-14 ad=7.02e-14 ps=1.175e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.38462e-07 sb=9.19551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(2)
mp57_1__rcx (\1\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.68e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.83462e-07 sb=4.74551e-07 sd=160n sca=17.6585 \
        scb=0.0154026 scc=0.00137896 m=(2)
ends EDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:16 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFX4
// View name: extracted

simulator lang=spectre

subckt EDFFX4 CK D E Q QN VDD VSS
mp20 (\13\:Ckb \3\:CK \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=18.237 scb=0.0193375 \
        scc=0.000503065 m=(1)
mp21 (\16\:CKbb \8\:Ckb \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp25 (\8\:n20 CKbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp36 (\8\:n20 \3\:Ckb net342 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp35 (net342 mout \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.505e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp30 (\4\:mout n20 \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=6.342e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp40 (\13\:n30 \2\:Ckb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.342e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.685e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\13\:n30 \7\:CKbb net362 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.48e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (net362 qbint \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=2.902e-14 ps=1.58e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=1.3e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp2 (n1 \1\:D \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=1.29e-14 ps=1.58e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.65e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp3 (\8\:Db \2\:Eb n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.912e-14 ps=5.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.6e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp1 (\21\:qbint \1\:E \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.01e-14 ps=9.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp0 (\5\:Eb \5\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.9534 scb=0.0134231 \
        scc=0.000640578 m=(1)
C1 (D VSS) capacitor c=6.32249e-17
C2 (QN VSS) capacitor c=1.82049e-17
C3 (VDD VSS) capacitor c=4.70427e-16
C4 (CK VSS) capacitor c=7.76951e-17
C5 (E VSS) capacitor c=5.49517e-17
C6 (Q VSS) capacitor c=2.86998e-17
C7 (Ckb VSS) capacitor c=7.83124e-17
C8 (CKbb VSS) capacitor c=3.19772e-17
C9 (n20 VSS) capacitor c=4.38459e-17
C10 (Db VSS) capacitor c=1.00364e-16
C11 (mout VSS) capacitor c=7.38679e-17
C12 (n30 VSS) capacitor c=9.46936e-17
C13 (net415 VSS) capacitor c=1.86478e-18
C14 (qbint VSS) capacitor c=6.46943e-17
C15 (n0 VSS) capacitor c=1.42475e-18
