Rk10 (B \9\:B) resistor r=0.08217 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2616 c=0
Rk4 (\6\:n0 \7\:n0) resistor r=0.9732 c=0
Rk5 (\7\:n0 \9\:n0) resistor r=0.8284 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.3091 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.2829 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.4309 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.03827 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5822 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.5296 c=0
Rl4 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl5 (\2\:A \3\:A) resistor r=110.307 c=0
Rl13 (\6\:B \7\:B) resistor r=76.2049 c=0
Rl12 (\5\:B \6\:B) resistor r=126.718 c=0
Rl9 (\3\:B \4\:B) resistor r=130.002 c=0
Rl6 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl3 (\2\:n0 \4\:n0) resistor r=43.1104 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=87.3411 c=0
Rl1 (n0 \2\:n0) resistor r=1.2334 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=140.679 c=0
Rl10 (n1 \2\:n1) resistor r=72.7035 c=0
Rl7 (n2 \2\:n2) resistor r=241.883 c=0
Rl8 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry3 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry4 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (n0 \7\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.29519e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (\6\:n1 \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.915e-14 ps=9.2e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.7e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn4 (\5\:n0 n2 \6\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=6.55e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn3 (\5\:n0 \3\:B net139 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=4.5e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn2 (net139 n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=3.45e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn1 (\8\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=1.4e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mp0 (\8\:n1 \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.5e-07 sd=160n sca=15.6438 \
        scb=0.0148425 scc=0.000445561 m=(1)
mp4 (\8\:n0 \1\:B \8\:n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=7.45e-07 sd=160n sca=13.754 \
        scb=0.0122361 scc=0.000425664 m=(1)
mp3 (\8\:n0 \2\:n2 net130 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=5.25e-07 sd=160n sca=13.561 \
        scb=0.0120014 scc=0.000425312 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.45e-07 sd=160n sca=14.4668 \
        scb=0.0130588 scc=0.000428492 m=(1)
mp1 (\4\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=17.9454 \
        scb=0.0188744 scc=0.000556907 m=(1)
ends CLKXOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:07 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKXOR2X2
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X2 A B VDD VSS Y
mp5 (\3\:Y n0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.826e-14 ad=6.24e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.73526e-07 sd=160n sca=22.1173 \
        scb=0.0235828 scc=0.00128647 m=(2)
C1 (VDD VSS) capacitor c=1.2638e-16
C2 (Y VSS) capacitor c=6.24434e-17
C3 (B VSS) capacitor c=5.6512e-17
C4 (n0 VSS) capacitor c=1.38487e-16
C5 (n1 VSS) capacitor c=4.8225e-17
C6 (n2 VSS) capacitor c=2.98851e-17
C7 (net130 VSS) capacitor c=1.88405e-18
C8 (\7\:B VSS) capacitor c=3.89021e-17
C9 (\3\:n1 VSS) capacitor c=8.96263e-17
C10 (\2\:n2 VSS) capacitor c=7.86672e-17
C11 (\1\:B VSS) capacitor c=4.17204e-17
C12 (\1\:A VSS) capacitor c=3.59161e-17
C13 (\5\:B VSS) capacitor c=4.14188e-17
C14 (\3\:B VSS) capacitor c=7.01522e-17
C15 (\3\:n2 VSS) capacitor c=6.84166e-17
C16 (\3\:A VSS) capacitor c=4.08917e-17
C17 (\6\:B VSS) capacitor c=5.33881e-17
C18 (\2\:n1 VSS) capacitor c=7.83729e-17
C19 (\4\:B VSS) capacitor c=7.0855e-17
C20 (\2\:B VSS) capacitor c=4.42822e-17
C21 (\2\:A VSS) capacitor c=3.59421e-17
C22 (\8\:n2 VSS) capacitor c=1.08958e-17
C23 (\1\:VDD VSS) capacitor c=6.78052e-17
C24 (\10\:n0 VSS) capacitor c=1.13681e-16
C25 (\6\:n1 VSS) capacitor c=5.97862e-17
C26 (\3\:Y VSS) capacitor c=8.59937e-17
C27 (\4\:n2 VSS) capacitor c=5.56415e-17
C28 (\7\:n0 VSS) capacitor c=1.03976e-16
C29 (\8\:n1 VSS) capacitor c=3.78307e-17
C30 (\1\:Y VSS) capacitor c=4.49962e-17
C31 (\4\:A VSS) capacitor c=1.29454e-16
C32 (\9\:n0 VSS) capacitor c=2.55434e-16
C33 (\4\:n1 VSS) capacitor c=8.93173e-17
C34 (\5\:n1 VSS) capacitor c=9.09055e-17
C35 (\8\:B VSS) capacitor c=2.95104e-17
C36 (\9\:B VSS) capacitor c=3.35495e-17
C37 (\10\:B VSS) capacitor c=4.60576e-17
C38 (\6\:n2 VSS) capacitor c=1.11673e-16
C39 (\7\:n2 VSS) capacitor c=8.18396e-17
C40 (\4\:VDD VSS) capacitor c=3.70778e-17
C41 (\5\:VDD VSS) capacitor c=9.01807e-17
Rk3 (A \4\:A) resistor r=0.03171 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.5922 c=0
Rk24 (\5\:VDD VDD) resistor r=0.02463 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.1794 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.6099 c=0
Rk18 (\5\:VSS VSS) resistor r=0.02463 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1954 c=0
Rk1 (\2\:Y Y) resistor r=0.1481 c=0
Rk2 (Y \4\:Y) resistor r=0.4376 c=0
Rk9 (\8\:B B) resistor r=0.1668 c=0
Rk10 (B \9\:B) resistor r=0.06849 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2021 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.9513 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.9572 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4557 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.3155 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.1277 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.524 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.6001 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04786 c=0
Rl6 (\1\:A \2\:A) resistor r=60.7134 c=0
Rl7 (\2\:A \3\:A) resistor r=99.1749 c=0
Rl15 (\6\:B \7\:B) resistor r=78.8233 c=0
Rl14 (\5\:B \6\:B) resistor r=86.3335 c=0
Rl11 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl8 (\1\:B \2\:B) resistor r=71.8456 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=149.361 c=0
Rl12 (n1 \2\:n1) resistor r=31.791 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=208.747 c=0
Rl9 (n2 \2\:n2) resistor r=24.2328 c=0
Rz5 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry6 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry2 (\11\:n0 \10\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (n2 \7\:n2) resistor r=45 c=0
mn5 (\1\:Y n0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.483e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.95577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\8\:n1 \3\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=5.728e-14 ps=9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.095e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\7\:n0 \3\:n2 \8\:n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.32e-14 ps=1.08e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\7\:n0 \3\:B net139 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net139 n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0243e-13 ad=5.805e-14 ps=1.74e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.015e-06 sd=160n sca=13.1802 \
        scb=0.0118482 scc=0.000425234 m=(1)
mp4 (\10\:n0 \1\:B \6\:n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.87e-14 ps=9.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=7e-07 sd=160n sca=12.8224 scb=0.011715 \
        scc=0.000425192 m=(1)
mp3 (\10\:n0 \2\:n2 net130 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.87e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=4.75e-07 sd=160n sca=13.569 \
        scb=0.0120992 scc=0.00042546 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=3.45e-07 sd=160n sca=14.4226 \
        scb=0.0130013 scc=0.000428203 m=(1)
mp1 (\8\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=17.794 \
        scb=0.0186079 scc=0.000545865 m=(1)
ends CLKXOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:08 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKXOR2X4
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X4 A B VDD VSS Y
mp5_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.523e-14 ad=6.24e-14 ps=1.1575e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.44314e-06 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(4)
C1 (A VSS) capacitor c=3.4467e-17
C2 (Y VSS) capacitor c=1.53566e-17
C3 (VDD VSS) capacitor c=2.93296e-16
C4 (B VSS) capacitor c=4.5567e-17
C5 (n0 VSS) capacitor c=2.27319e-16
C6 (n1 VSS) capacitor c=6.27824e-17
C7 (n2 VSS) capacitor c=3.33588e-17
C8 (net130 VSS) capacitor c=2.2278e-18
C9 (\4\:B VSS) capacitor c=5.02451e-17
C10 (\3\:n2 VSS) capacitor c=5.85491e-17
C11 (\3\:B VSS) capacitor c=5.2598e-17
C12 (\1\:A VSS) capacitor c=3.38744e-17
C13 (\6\:B VSS) capacitor c=4.19603e-17
C14 (\3\:n1 VSS) capacitor c=7.25642e-17
C15 (\1\:B VSS) capacitor c=4.82325e-17
C16 (\3\:A VSS) capacitor c=3.21752e-17
C17 (\5\:B VSS) capacitor c=4.98438e-17
C18 (\2\:n1 VSS) capacitor c=6.119e-17
C19 (\2\:B VSS) capacitor c=7.573e-17
C20 (\4\:n2 VSS) capacitor c=4.80005e-17
C21 (\2\:n2 VSS) capacitor c=3.41896e-17
C22 (\2\:A VSS) capacitor c=3.51815e-17
C23 (\10\:n2 VSS) capacitor c=6.26681e-17
C24 (\9\:VDD VSS) capacitor c=3.13605e-17
C25 (\13\:n0 VSS) capacitor c=1.10456e-16
C26 (\5\:n1 VSS) capacitor c=1.15294e-16
C27 (\1\:Y VSS) capacitor c=1.85138e-16
C28 (\1\:VDD VSS) capacitor c=3.04629e-17
C29 (\5\:n2 VSS) capacitor c=1.92849e-17
C30 (\17\:n0 VSS) capacitor c=1.51017e-16
C31 (\7\:n1 VSS) capacitor c=9.62209e-17
C32 (\4\:Y VSS) capacitor c=1.17334e-16
C33 (\4\:A VSS) capacitor c=8.57474e-17
C34 (\15\:n0 VSS) capacitor c=2.60312e-16
C35 (\16\:n0 VSS) capacitor c=2.6121e-17
C36 (\4\:n1 VSS) capacitor c=9.53837e-17
C37 (\7\:B VSS) capacitor c=5.83852e-17
C38 (\8\:B VSS) capacitor c=6.29361e-17
C39 (\7\:n2 VSS) capacitor c=1.04063e-16
C40 (\8\:n2 VSS) capacitor c=8.05844e-17
C41 (\9\:n2 VSS) capacitor c=3.94231e-17
C42 (\12\:n2 VSS) capacitor c=6.98176e-17
C43 (\3\:VDD VSS) capacitor c=2.24642e-17
Rk6 (A \4\:A) resistor r=0.04241 c=0
Rk2 (\1\:Y Y) resistor r=0.04859 c=0
Rk3 (Y \4\:Y) resistor r=0.2441 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.1478 c=0
Rk21 (\4\:VDD VDD) resistor r=0.1403 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.504 c=0
Rk25 (\3\:VDD \10\:VDD) resistor r=0.3116 c=0
Rk28 (\2\:VSS \3\:VSS) resistor r=0.1478 c=0
Rk30 (\4\:VSS VSS) resistor r=0.1403 c=0
Rk29 (\3\:VSS \4\:VSS) resistor r=0.504 c=0
Rk34 (\3\:VSS \10\:VSS) resistor r=0.1804 c=0
Rk12 (B \7\:B) resistor r=0.1082 c=0
Rk13 (\7\:B \8\:B) resistor r=0.2003 c=0
Rk7 (\14\:n0 \15\:n0) resistor r=1.0715 c=0
Rk8 (\15\:n0 \16\:n0) resistor r=0.1125 c=0
Rk9 (\15\:n0 \18\:n0) resistor r=1.1451 c=0
Rk10 (\4\:n1 \6\:n1) resistor r=0.5836 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.4358 c=0
Rk14 (\6\:n2 \7\:n2) resistor r=0.09749 c=0
Rk15 (\7\:n2 \8\:n2) resistor r=0.572 c=0
Rk16 (\8\:n2 \9\:n2) resistor r=0.08682 c=0
Rk17 (\7\:n2 \11\:n2) resistor r=0.5084 c=0
Rk18 (\8\:n2 \12\:n2) resistor r=0.2933 c=0
Rl12 (\1\:A \2\:A) resistor r=87.2302 c=0
Rl13 (\2\:A \3\:A) resistor r=89.1533 c=0
Rl20 (\4\:B \5\:B) resistor r=131.867 c=0
Rl21 (\5\:B \6\:B) resistor r=97.2519 c=0
Rl17 (\2\:B \3\:B) resistor r=158.232 c=0
Rl16 (\1\:B \2\:B) resistor r=64.6174 c=0
Rl18 (n1 \2\:n1) resistor r=29.5379 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=146.846 c=0
Rl15 (\3\:n2 \4\:n2) resistor r=39.6174 c=0
Rl14 (n2 \2\:n2) resistor r=66.8207 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz7 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz9 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=75 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry7 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=62 c=0
Ry4 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry5 (\10\:n2 \11\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\16\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn5_1__rcx (\4\:Y n0 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.075e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43163e-06 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=9.445e-14 ps=9.6e-07 pd=1.63e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.26362e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn1 (\5\:n2 \6\:B \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44966e-06 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn4 (\17\:n0 n2 \7\:n1 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=3.28e-14 ps=1.63e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21402e-06 sb=6.38293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn3 (\17\:n0 \1\:B net139 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=3.28e-14 ps=6.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41902e-06 sb=4.33293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (net139 \3\:n1 \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.358e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55073e-06 sb=2.73293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mp0 (\5\:n1 \1\:A VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=1.4818e-13 ps=1.37e-06 pd=1.91e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.25674e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp1 (\10\:n2 \4\:B \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39686e-06 sb=1.4e-07 sd=160n sca=20.5353 \
        scb=0.0230763 scc=0.000857203 m=(1)
mp4 (\13\:n0 \3\:B \5\:n1 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4818e-13 ad=4.96e-14 ps=1.91e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21661e-06 sb=5.99919e-07 sd=160n sca=19.4676 \
        scb=0.0175759 scc=0.00172296 m=(1)
mp3 (\13\:n0 \3\:n2 net130 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=4.96e-14 ps=7.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42161e-06 sb=3.94919e-07 sd=160n sca=20.3464 \
        scb=0.0181967 scc=0.00172377 m=(1)
mp2 (net130 n1 \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=2.48e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51887e-06 sb=2.69919e-07 sd=160n sca=21.4199 \
        scb=0.0195761 scc=0.00173118 m=(1)
ends CLKXOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:09 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKXOR2X8
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X8 A B VDD VSS Y
mp5 (\1\:Y n0 \5\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.234e-14 ad=6.993e-14 ps=1.22857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.67124e-06 sd=160n \
        sca=27.6714 scb=0.0224014 scc=0.0024948 m=(7)
C1 (A VSS) capacitor c=8.62461e-17
C2 (Y VSS) capacitor c=1.27986e-17
C3 (VDD VSS) capacitor c=1.33895e-16
C4 (B VSS) capacitor c=2.68339e-17
C5 (n0 VSS) capacitor c=3.51526e-16
C6 (n1 VSS) capacitor c=5.52509e-17
C7 (n2 VSS) capacitor c=3.55288e-17
C8 (net130 VSS) capacitor c=3.87181e-18
C9 (\7\:B VSS) capacitor c=3.64623e-17
C10 (\3\:n1 VSS) capacitor c=5.01174e-17
C11 (\3\:n2 VSS) capacitor c=4.82385e-17
C12 (\3\:B VSS) capacitor c=5.29833e-17
C13 (\1\:A VSS) capacitor c=3.51555e-17
C14 (\5\:B VSS) capacitor c=4.7269e-17
C15 (\1\:B VSS) capacitor c=3.68186e-17
C16 (\3\:A VSS) capacitor c=3.69264e-17
C17 (\6\:B VSS) capacitor c=4.16317e-17
C18 (\2\:n1 VSS) capacitor c=5.65301e-17
C19 (\4\:B VSS) capacitor c=3.73344e-17
C20 (\4\:n2 VSS) capacitor c=5.51167e-17
C21 (\2\:n2 VSS) capacitor c=3.31717e-17
C22 (\2\:A VSS) capacitor c=3.27587e-17
C23 (\10\:n2 VSS) capacitor c=5.73612e-17
C24 (\1\:VDD VSS) capacitor c=2.3783e-17
C25 (\23\:n0 VSS) capacitor c=1.06983e-16
C26 (\5\:n1 VSS) capacitor c=1.27129e-16
C27 (\1\:Y VSS) capacitor c=3.51488e-16
C28 (\3\:VDD VSS) capacitor c=4.64783e-17
C29 (\5\:n2 VSS) capacitor c=2.00365e-17
C30 (\27\:n0 VSS) capacitor c=1.10249e-16
C31 (\7\:n1 VSS) capacitor c=6.89019e-17
C32 (\6\:Y VSS) capacitor c=1.75728e-16
C33 (\2\:B VSS) capacitor c=6.0945e-17
C34 (\4\:A VSS) capacitor c=2.94883e-17
C35 (\25\:n0 VSS) capacitor c=2.38915e-16
C36 (\26\:n0 VSS) capacitor c=6.25357e-17
C37 (\4\:n1 VSS) capacitor c=8.39733e-17
C38 (\8\:B VSS) capacitor c=6.4356e-17
C39 (\9\:B VSS) capacitor c=5.18787e-17
C40 (\7\:n2 VSS) capacitor c=9.523e-17
C41 (\8\:n2 VSS) capacitor c=7.45095e-17
C42 (\9\:n2 VSS) capacitor c=3.58345e-17
C43 (\12\:n2 VSS) capacitor c=3.13117e-17
C44 (\5\:VDD VSS) capacitor c=3.14833e-16
Rk12 (A \4\:A) resistor r=0.01779 c=0
Rk25 (\2\:VSS \4\:VSS) resistor r=0.2367 c=0
Rk31 (\5\:VSS VSS) resistor r=0.195 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.6063 c=0
Rk4 (\1\:Y Y) resistor r=0.1964 c=0
Rk5 (Y \6\:Y) resistor r=0.1046 c=0
Rk36 (\2\:VDD \4\:VDD) resistor r=0.3769 c=0
Rk46 (\5\:VDD VDD) resistor r=0.1975 c=0
Rk37 (\4\:VDD \5\:VDD) resistor r=0.6038 c=0
Rk19 (\9\:B B) resistor r=0.0179 c=0
Rk18 (\8\:B \9\:B) resistor r=0.2816 c=0
Rk13 (\24\:n0 \25\:n0) resistor r=0.9828 c=0
Rk14 (\25\:n0 \26\:n0) resistor r=0.3588 c=0
Rk15 (\25\:n0 \28\:n0) resistor r=0.9432 c=0
Rk16 (\4\:n1 \6\:n1) resistor r=0.5904 c=0
Rk17 (\6\:n1 \8\:n1) resistor r=0.4262 c=0
Rk20 (\6\:n2 \7\:n2) resistor r=0.1114 c=0
Rk21 (\7\:n2 \8\:n2) resistor r=0.6139 c=0
Rk22 (\8\:n2 \9\:n2) resistor r=0.136 c=0
Rk23 (\7\:n2 \11\:n2) resistor r=0.4872 c=0
Rk24 (\8\:n2 \12\:n2) resistor r=0.1309 c=0
Rl22 (\1\:A \2\:A) resistor r=89.1533 c=0
Rl23 (\2\:A \3\:A) resistor r=83.3841 c=0
Rl32 (\6\:B \7\:B) resistor r=37.9121 c=0
Rl31 (\5\:B \6\:B) resistor r=159.615 c=0
Rl27 (\2\:B \3\:B) resistor r=138.77 c=0
Rl26 (\1\:B \2\:B) resistor r=64.1248 c=0
Rl28 (\2\:B \4\:B) resistor r=28.0958 c=0
Rl30 (\2\:n1 \3\:n1) resistor r=26.3736 c=0
Rl29 (n1 \2\:n1) resistor r=148.077 c=0
Rl25 (\3\:n2 \4\:n2) resistor r=39.9593 c=0
Rl24 (n2 \2\:n2) resistor r=75.6918 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=15 c=0
Rz14 (\5\:VDD \3\:VDD) resistor r=6.25 c=0
Rz5 (\28\:n0 \27\:n0) resistor r=75 c=0
Rz6 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz7 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry8 (\4\:VSS \3\:VSS) resistor r=12.4 c=0
Ry9 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry10 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry5 (\24\:n0 \23\:n0) resistor r=62 c=0
Ry6 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry7 (\10\:n2 \11\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:B \8\:B) resistor r=45 c=0
Rx5 (\6\:B \9\:B) resistor r=45 c=0
Rx2 (\26\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn5_1__rcx (\6\:Y n0 \5\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.745e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.66136e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mn0 (\7\:n1 \3\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.895e-14 ad=6.908e-14 ps=1.05e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=1.31466e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn1 (\5\:n2 \5\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.355e-14 ad=2.61e-14 ps=7.9e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53862e-06 sb=1.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn4 (\27\:n0 n2 \7\:n1 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.908e-14 ad=3.28e-14 ps=1.28e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4439e-06 sb=8.72805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mn3 (\27\:n0 \1\:B net139 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.15e-14 ad=3.28e-14 ps=1.01e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5039e-06 sb=6.67805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mn2 (net139 n1 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.355e-14 ad=6.15e-14 ps=7.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60488e-06 sb=3.22805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mp0 (\5\:n1 \1\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.918e-14 ad=1.256e-13 ps=1.34e-06 pd=1.7e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=1.33e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp1 (\10\:n2 \7\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=32.0046 scb=0.0317061 \
        scc=0.00322039 m=(1)
mp4 (\23\:n0 \3\:B \5\:n1 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.256e-13 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41774e-06 sb=6.72984e-07 sd=160n sca=21.4696 \
        scb=0.0188478 scc=0.00214554 m=(1)
mp3 (\23\:n0 \3\:n2 net130 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.72e-14 ad=4.96e-14 ps=8.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48056e-06 sb=4.67984e-07 sd=160n sca=22.0887 \
        scb=0.019123 scc=0.00214568 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.72e-14 ps=1e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53113e-06 sb=3.02984e-07 sd=160n sca=23.1022 \
        scb=0.0201418 scc=0.00214855 m=(1)
ends CLKXOR2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:10 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY1X1
// View name: extracted

simulator lang=spectre

subckt DLY1X1 A VDD VSS Y
mp0 (\8\:n0 \1\:A \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.85e-07 sd=160n sca=34.7345 \
        scb=0.0347529 scc=0.00361149 m=(1)
mp1 (n5 n0 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.8e-07 sd=160n sca=29.5145 \
        scb=0.0258721 scc=0.00324978 m=(1)
mp2 (\8\:n1 \2\:VSS n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.193e-14 ad=3.01e-14 ps=8.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=27.7866 \
        scb=0.0238669 scc=0.00324002 m=(1)
mp3 (\8\:n2 n1 \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
C1 (Y VSS) capacitor c=2.54847e-17
C2 (VDD VSS) capacitor c=7.50327e-17
C3 (A VSS) capacitor c=8.4435e-17
C4 (n0 VSS) capacitor c=5.79695e-17
C5 (n1 VSS) capacitor c=3.82999e-17
C6 (n2 VSS) capacitor c=4.69384e-17
C7 (n5 VSS) capacitor c=2.62229e-18
C8 (\1\:A VSS) capacitor c=2.95229e-17
C9 (\4\:n2 VSS) capacitor c=3.5342e-17
C10 (\3\:n1 VSS) capacitor c=3.21896e-17
C11 (\1\:VDD VSS) capacitor c=4.48904e-17
C12 (\3\:n0 VSS) capacitor c=3.24146e-17
C13 (\3\:A VSS) capacitor c=5.11216e-17
C14 (\3\:n2 VSS) capacitor c=1.726e-17
C15 (\2\:n1 VSS) capacitor c=2.6359e-17
C16 (\2\:VDD VSS) capacitor c=3.96155e-17
C17 (\2\:n0 VSS) capacitor c=5.23914e-17
C18 (\2\:A VSS) capacitor c=3.81271e-17
C19 (\3\:Y VSS) capacitor c=6.38368e-17
C20 (\3\:VDD VSS) capacitor c=5.6126e-17
C21 (\8\:n2 VSS) capacitor c=5.30698e-17
C22 (\8\:n1 VSS) capacitor c=5.0167e-17
C23 (\10\:VDD VSS) capacitor c=2.03738e-17
C24 (\8\:n0 VSS) capacitor c=4.11999e-17
C25 (\1\:Y VSS) capacitor c=1.56035e-17
C26 (\5\:n2 VSS) capacitor c=5.03688e-17
C27 (\6\:n1 VSS) capacitor c=7.46699e-17
C28 (\6\:n0 VSS) capacitor c=2.13963e-17
C29 (\2\:n2 VSS) capacitor c=1.3386e-17
C30 (\4\:n0 VSS) capacitor c=4.56463e-17
C31 (\5\:n0 VSS) capacitor c=3.54597e-17
C32 (\4\:A VSS) capacitor c=3.16811e-17
C33 (\4\:n1 VSS) capacitor c=5.05632e-17
C34 (\5\:n1 VSS) capacitor c=9.20113e-17
C35 (\7\:n2 VSS) capacitor c=8.90722e-17
C36 (\6\:VDD VSS) capacitor c=1.66107e-17
C37 (\7\:VDD VSS) capacitor c=6.78298e-18
C38 (\8\:VDD VSS) capacitor c=6.94673e-18
C39 (\9\:VDD VSS) capacitor c=1.21734e-16
Rk18 (\4\:VSS \6\:VSS) resistor r=0.5668 c=0
Rk19 (\6\:VSS \7\:VSS) resistor r=0.1151 c=0
Rk21 (\8\:VSS VSS) resistor r=0.1424 c=0
Rk20 (\7\:VSS \8\:VSS) resistor r=0.1425 c=0
Rk22 (\7\:VSS \9\:VSS) resistor r=0.7178 c=0
Rk23 (\8\:VSS \11\:VSS) resistor r=0.1777 c=0
Rk10 (Y \2\:Y) resistor r=0.05091 c=0
Rk11 (Y \4\:Y) resistor r=0.2575 c=0
Rk12 (\4\:VDD \6\:VDD) resistor r=0.6316 c=0
Rk13 (\6\:VDD \7\:VDD) resistor r=0.1151 c=0
Rk15 (\8\:VDD VDD) resistor r=0.1424 c=0
Rk14 (\7\:VDD \8\:VDD) resistor r=0.1425 c=0
Rk16 (\7\:VDD \9\:VDD) resistor r=0.7156 c=0
Rk17 (\8\:VDD \11\:VDD) resistor r=0.3858 c=0
Rk4 (\4\:A A) resistor r=0.08652 c=0
Rk1 (\4\:n0 \5\:n0) resistor r=0.1949 c=0
Rk2 (\5\:n0 \7\:n0) resistor r=0.1249 c=0
Rk3 (\5\:n0 \9\:n0) resistor r=0.3618 c=0
Rk5 (\4\:n1 \5\:n1) resistor r=0.1846 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4884 c=0
Rk7 (\5\:n1 \9\:n1) resistor r=0.2867 c=0
Rk8 (\6\:n2 \7\:n2) resistor r=0.2686 c=0
Rk9 (\7\:n2 \9\:n2) resistor r=0.3492 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=66.8207 c=0
Rl5 (\1\:VDD \2\:VDD) resistor r=93.4636 c=0
Rl1 (\1\:A \2\:A) resistor r=29.5379 c=0
Rl2 (\2\:A \3\:A) resistor r=162.23 c=0
Rl3 (n0 \2\:n0) resistor r=162.23 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=29.5379 c=0
Rl7 (n1 \2\:n1) resistor r=29.5379 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=44.9225 c=0
Rl9 (n2 \2\:n2) resistor r=57.4064 c=0
Rl11 (\2\:n2 \4\:n2) resistor r=34.3295 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=1.2666 c=0
Rz6 (\3\:VSS \4\:VSS) resistor r=75 c=0
Rz7 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz3 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry4 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry6 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx6 (\1\:VSS \9\:VSS) resistor r=45 c=0
Rx5 (\2\:VDD \9\:VDD) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\3\:n2 \7\:n2) resistor r=45 c=0
mn0 (\6\:n0 \3\:A \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.85e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (n4 \3\:n0 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.885e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.8e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\6\:n1 \1\:VDD n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.973e-14 ps=5.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.05e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\5\:n2 \3\:n1 \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn4 (\1\:Y \4\:n2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp4 (\3\:Y n2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
ends DLY1X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:11 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY1X4
// View name: extracted

simulator lang=spectre

subckt DLY1X4 A VDD VSS Y
mp0 (\8\:n0 \1\:A \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.75e-07 sd=160n sca=17.5351 \
        scb=0.0182864 scc=0.000415857 m=(1)
mp1 (n5 n0 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.613e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.7e-07 sd=160n sca=12.8452 \
        scb=0.0102734 scc=0.000135926 m=(1)
mp2 (\8\:n1 \2\:VSS n5 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=3.225e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.5e-07 sd=160n sca=11.8288 \
        scb=0.00897951 scc=0.000129234 m=(1)
C1 (Y VSS) capacitor c=1.83969e-17
C2 (VDD VSS) capacitor c=1.2561e-16
C3 (n0 VSS) capacitor c=8.2893e-17
C4 (n1 VSS) capacitor c=4.19574e-17
C5 (n2 VSS) capacitor c=2.13084e-16
C6 (n5 VSS) capacitor c=9.53257e-19
C7 (\1\:A VSS) capacitor c=4.02234e-17
C8 (\3\:n1 VSS) capacitor c=3.25602e-17
C9 (\1\:VDD VSS) capacitor c=6.26701e-17
C10 (\3\:n0 VSS) capacitor c=4.76703e-17
C11 (\3\:A VSS) capacitor c=4.27172e-17
C12 (\6\:n2 VSS) capacitor c=2.34909e-17
C13 (\2\:n1 VSS) capacitor c=3.67508e-17
C14 (\2\:VDD VSS) capacitor c=3.85699e-17
C15 (\2\:n0 VSS) capacitor c=8.16794e-17
C16 (\2\:A VSS) capacitor c=5.73924e-17
C17 (\3\:VDD VSS) capacitor c=1.90626e-16
C18 (\1\:Y VSS) capacitor c=1.59439e-16
C19 (\14\:n2 VSS) capacitor c=9.49126e-17
C20 (\8\:n1 VSS) capacitor c=8.30015e-17
C21 (\16\:VDD VSS) capacitor c=2.44576e-17
C22 (\8\:n0 VSS) capacitor c=6.85268e-17
C23 (\4\:Y VSS) capacitor c=7.41649e-17
C24 (\17\:n2 VSS) capacitor c=5.09456e-17
C25 (\6\:n1 VSS) capacitor c=6.72835e-17
C26 (\6\:n0 VSS) capacitor c=2.65707e-17
C27 (\4\:A VSS) capacitor c=1.15531e-16
C28 (\4\:n0 VSS) capacitor c=4.8958e-17
C29 (\5\:n0 VSS) capacitor c=5.16442e-17
C30 (\4\:n1 VSS) capacitor c=4.55304e-17
C31 (\5\:n1 VSS) capacitor c=8.49019e-17
C32 (\16\:n2 VSS) capacitor c=9.13895e-17
C33 (\8\:VDD VSS) capacitor c=1.34242e-17
C34 (\9\:VDD VSS) capacitor c=2.4391e-17
C35 (\10\:VDD VSS) capacitor c=4.87552e-18
C36 (\15\:VDD VSS) capacitor c=9.62493e-17
Rk11 (\1\:Y Y) resistor r=0.04849 c=0
Rk12 (Y \4\:Y) resistor r=0.1952 c=0
Rk27 (\3\:VSS \8\:VSS) resistor r=0.08007 c=0
Rk28 (\8\:VSS \9\:VSS) resistor r=0.2632 c=0
Rk30 (\10\:VSS VSS) resistor r=0.1225 c=0
Rk29 (\9\:VSS \10\:VSS) resistor r=0.115 c=0
Rk33 (\9\:VSS \15\:VSS) resistor r=0.8216 c=0
Rk34 (\10\:VSS \17\:VSS) resistor r=0.3084 c=0
Rk17 (\3\:VDD \8\:VDD) resistor r=0.08007 c=0
Rk18 (\8\:VDD \9\:VDD) resistor r=0.2632 c=0
Rk20 (\10\:VDD VDD) resistor r=0.15 c=0
Rk19 (\9\:VDD \10\:VDD) resistor r=0.0874 c=0
Rk23 (\9\:VDD \15\:VDD) resistor r=0.6293 c=0
Rk24 (\10\:VDD \17\:VDD) resistor r=0.2826 c=0
Rk1 (A \4\:A) resistor r=0.004953 c=0
Rk2 (\4\:n0 \5\:n0) resistor r=0.1912 c=0
Rk3 (\5\:n0 \7\:n0) resistor r=0.1365 c=0
Rk4 (\5\:n0 \9\:n0) resistor r=0.5147 c=0
Rk5 (\4\:n1 \5\:n1) resistor r=0.1467 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.3376 c=0
Rk7 (\5\:n1 \9\:n1) resistor r=0.4299 c=0
Rk8 (\15\:n2 \16\:n2) resistor r=0.4506 c=0
Rk9 (\16\:n2 \18\:n2) resistor r=0.2492 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=57.6695 c=0
Rl5 (\2\:VDD \1\:VDD) resistor r=97.2519 c=0
Rl1 (\1\:A \2\:A) resistor r=109.615 c=0
Rl2 (\2\:A \3\:A) resistor r=101.099 c=0
Rl3 (n0 \2\:n0) resistor r=196.982 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=47.2144 c=0
Rl7 (n1 \2\:n1) resistor r=26.098 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=41.4826 c=0
Rl13 (n2 \6\:n2) resistor r=4.8851 c=0
Rz10 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz3 (\18\:n2 \17\:n2) resistor r=75 c=0
Ry9 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\15\:n2 \14\:n2) resistor r=20.6667 c=0
Rx6 (\15\:VSS \1\:VSS) resistor r=45 c=0
Rx5 (\15\:VDD \2\:VDD) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\16\:n2 \6\:n2) resistor r=45 c=0
mn0 (\6\:n0 \3\:A \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.3e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn1 (n4 \3\:n0 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.25e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn2 (\6\:n1 \1\:VDD n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn3 (\17\:n2 \3\:n1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn4_1__rcx (\4\:Y n2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mp3 (\14\:n2 n1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp4_1__rcx (\1\:Y n2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=30.7862 \
        scb=0.0202776 scc=0.00336099 m=(4)
ends DLY1X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:12 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY2X1
// View name: extracted

simulator lang=spectre

subckt DLY2X1 A VDD VSS Y
mp8 (\1\:Y n4 \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=5.46e-14 ps=1.39e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.21154e-07 sd=160n sca=17.8302 \
        scb=0.0172414 scc=0.000800052 m=(1)
C1 (A VSS) capacitor c=2.87902e-17
C2 (Y VSS) capacitor c=8.76507e-17
C3 (VDD VSS) capacitor c=2.65726e-16
C4 (n4 VSS) capacitor c=3.90571e-17
C5 (n0 VSS) capacitor c=3.66846e-17
C6 (n1 VSS) capacitor c=9.03799e-17
C7 (n8 VSS) capacitor c=5.89322e-18
C8 (n2 VSS) capacitor c=1.04752e-16
C9 (n3 VSS) capacitor c=3.73211e-17
C10 (n10 VSS) capacitor c=1.37631e-18
C11 (n7 VSS) capacitor c=1.80608e-18
C12 (n11 VSS) capacitor c=1.58096e-18
C13 (\4\:A VSS) capacitor c=3.93202e-17
C14 (\5\:VDD VSS) capacitor c=4.7687e-17
C15 (\2\:n2 VSS) capacitor c=7.12218e-17
C16 (\3\:n3 VSS) capacitor c=5.19474e-17
C17 (\3\:VDD VSS) capacitor c=3.94583e-17
C18 (\2\:n1 VSS) capacitor c=3.17395e-17
C19 (\3\:A VSS) capacitor c=3.33348e-17
C20 (\1\:VDD VSS) capacitor c=4.07375e-17
C21 (\3\:n0 VSS) capacitor c=6.71445e-17
C22 (\3\:n4 VSS) capacitor c=4.6108e-17
C23 (\6\:VDD VSS) capacitor c=5.55117e-17
C24 (\3\:n2 VSS) capacitor c=3.14839e-17
C25 (\2\:n3 VSS) capacitor c=4.84732e-17
C26 (\4\:VDD VSS) capacitor c=3.61772e-17
C27 (\3\:n1 VSS) capacitor c=2.3324e-17
C28 (\1\:A VSS) capacitor c=1.76253e-17
C29 (\2\:n0 VSS) capacitor c=6.62739e-17
C30 (\2\:VDD VSS) capacitor c=3.94981e-17
C31 (\2\:n4 VSS) capacitor c=3.11748e-17
C32 (\5\:n3 VSS) capacitor c=1.10003e-16
C33 (\9\:VDD VSS) capacitor c=7.34986e-17
C34 (\8\:n4 VSS) capacitor c=4.29504e-17
C35 (\7\:n2 VSS) capacitor c=7.92613e-17
C36 (\18\:VDD VSS) capacitor c=2.92552e-17
C37 (\4\:n0 VSS) capacitor c=1.46559e-16
C38 (\7\:n1 VSS) capacitor c=8.83755e-17
C39 (\20\:VDD VSS) capacitor c=1.71656e-16
C40 (\1\:Y VSS) capacitor c=7.74668e-17
C41 (\13\:VDD VSS) capacitor c=5.70206e-17
C42 (\7\:n3 VSS) capacitor c=9.31947e-17
C43 (\4\:n4 VSS) capacitor c=1.36542e-16
C44 (\5\:n2 VSS) capacitor c=2.06166e-16
C45 (\7\:n0 VSS) capacitor c=6.67486e-17
C46 (\5\:n1 VSS) capacitor c=1.12442e-16
C47 (\3\:Y VSS) capacitor c=4.34196e-17
C48 (\2\:A VSS) capacitor c=1.54246e-17
C49 (\6\:n0 VSS) capacitor c=1.09002e-16
C50 (\5\:A VSS) capacitor c=7.52736e-17
C51 (\4\:n1 VSS) capacitor c=5.47307e-17
C52 (\6\:n4 VSS) capacitor c=2.61111e-16
C53 (\7\:n4 VSS) capacitor c=2.60871e-16
C54 (\4\:n2 VSS) capacitor c=1.79596e-16
C55 (\4\:n3 VSS) capacitor c=7.98834e-17
C56 (\7\:VDD VSS) capacitor c=7.92181e-17
C57 (\8\:VDD VSS) capacitor c=9.44665e-17
C58 (\11\:VDD VSS) capacitor c=2.88154e-17
C59 (\12\:VDD VSS) capacitor c=3.36399e-17
C60 (\15\:VDD VSS) capacitor c=2.10194e-17
C61 (\16\:VDD VSS) capacitor c=2.42531e-17
C62 (\22\:VDD VSS) capacitor c=1.27592e-16
Rk5 (A \5\:A) resistor r=0.06206 c=0
Rk1 (\2\:Y Y) resistor r=0.5484 c=0
Rk2 (Y \4\:Y) resistor r=0.2699 c=0
Rk28 (\7\:VDD \8\:VDD) resistor r=0.408 c=0
Rk29 (\8\:VDD \10\:VDD) resistor r=0.5772 c=0
Rk30 (\10\:VDD \11\:VDD) resistor r=0.2181 c=0
Rk31 (\11\:VDD \12\:VDD) resistor r=0.5844 c=0
Rk32 (\12\:VDD \14\:VDD) resistor r=0.1579 c=0
Rk34 (\15\:VDD VDD) resistor r=0.1909 c=0
Rk33 (\14\:VDD \15\:VDD) resistor r=0.3593 c=0
Rk35 (\8\:VDD \16\:VDD) resistor r=0.07969 c=0
Rk36 (\11\:VDD \17\:VDD) resistor r=0.1102 c=0
Rk37 (\12\:VDD \19\:VDD) resistor r=0.1033 c=0
Rk38 (\15\:VDD \21\:VDD) resistor r=0.1731 c=0
Rk39 (\21\:VDD \22\:VDD) resistor r=1.0471 c=0
Rk15 (\7\:VSS \9\:VSS) resistor r=0.9743 c=0
Rk16 (\9\:VSS \10\:VSS) resistor r=0.09769 c=0
Rk17 (\10\:VSS \11\:VSS) resistor r=0.4012 c=0
Rk18 (\11\:VSS \12\:VSS) resistor r=0.2145 c=0
Rk19 (\12\:VSS \13\:VSS) resistor r=0.1369 c=0
Rk20 (\13\:VSS \14\:VSS) resistor r=0.1253 c=0
Rk22 (\15\:VSS VSS) resistor r=0.2029 c=0
Rk21 (\14\:VSS \15\:VSS) resistor r=0.223 c=0
Rk23 (\10\:VSS \17\:VSS) resistor r=0.3595 c=0
Rk24 (\11\:VSS \18\:VSS) resistor r=0.6569 c=0
Rk25 (\12\:VSS \20\:VSS) resistor r=0.04336 c=0
Rk26 (\14\:VSS \21\:VSS) resistor r=0.552 c=0
Rk27 (\15\:VSS \23\:VSS) resistor r=0.2641 c=0
Rk8 (\5\:n4 \6\:n4) resistor r=0.6869 c=0
Rk9 (\6\:n4 \7\:n4) resistor r=1.7436 c=0
Rk10 (\6\:n4 \9\:n4) resistor r=0.1881 c=0
Rk3 (\5\:n0 \6\:n0) resistor r=0.7599 c=0
Rk4 (\5\:n0 \8\:n0) resistor r=0.3786 c=0
Rk6 (\4\:n1 \6\:n1) resistor r=0.4229 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.5321 c=0
Rk11 (\4\:n2 \6\:n2) resistor r=1.2506 c=0
Rk12 (\6\:n2 \8\:n2) resistor r=0.4933 c=0
Rk13 (\4\:n3 \6\:n3) resistor r=0.4346 c=0
Rk14 (\6\:n3 \8\:n3) resistor r=0.7515 c=0
Rl9 (\2\:A \4\:A) resistor r=79.6488 c=0
Rl8 (\2\:A \3\:A) resistor r=37.3411 c=0
Rl7 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl18 (\5\:VDD \6\:VDD) resistor r=98.7985 c=0
Rl13 (\3\:VDD \4\:VDD) resistor r=178.359 c=0
Rl5 (\1\:VDD \2\:VDD) resistor r=36.8016 c=0
Rl19 (\5\:VSS \6\:VSS) resistor r=53.1926 c=0
Rl12 (\3\:VSS \4\:VSS) resistor r=24.2328 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=66.5405 c=0
Rl1 (n4 \2\:n4) resistor r=67.9995 c=0
Rl2 (\2\:n4 \3\:n4) resistor r=56.461 c=0
Rl3 (n0 \2\:n0) resistor r=24.7951 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=176.9 c=0
Rl10 (n1 \2\:n1) resistor r=126.923 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl16 (n2 \2\:n2) resistor r=238.027 c=0
Rl17 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl14 (n3 \2\:n3) resistor r=49.2328 c=0
Rl15 (\2\:n3 \3\:n3) resistor r=149.233 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz10 (\13\:VDD \14\:VDD) resistor r=6.25 c=0
Rz11 (\13\:VDD \17\:VDD) resistor r=15 c=0
Rz7 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz8 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz9 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz4 (\4\:n4 \5\:n4) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz5 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz6 (\7\:n3 \8\:n3) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry11 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry7 (\8\:VSS \9\:VSS) resistor r=12.4 c=0
Ry8 (\8\:VSS \13\:VSS) resistor r=5.1667 c=0
Ry4 (\8\:n4 \9\:n4) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry5 (\7\:n2 \8\:n2) resistor r=62 c=0
Ry6 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx10 (\6\:VDD \7\:VDD) resistor r=45 c=0
Rx11 (\4\:VDD \16\:VDD) resistor r=45 c=0
Rx12 (\2\:VDD \22\:VDD) resistor r=45 c=0
Rx7 (\5\:VSS \7\:VSS) resistor r=45 c=0
Rx8 (\4\:VSS \18\:VSS) resistor r=45 c=0
Rx9 (\2\:VSS \21\:VSS) resistor r=45 c=0
Rx4 (\2\:n4 \7\:n4) resistor r=45 c=0
Rx1 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx5 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx6 (\2\:n3 \4\:n3) resistor r=45 c=0
mn8 (\3\:Y \3\:n4 \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=3.64e-14 ps=8.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.59712e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn1 (n6 \3\:n0 \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.683e-14 ps=8.6e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=5.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (\5\:n1 \1\:VDD n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\7\:n0 \3\:A \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (n8 \2\:n1 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=3.48e-14 ps=1.74e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\5\:n2 \3\:VDD n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn7 (\4\:n4 \3\:n3 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.408e-14 ad=3.335e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.3e-07 sb=7.05e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn5 (n10 \2\:n2 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.408e-14 ad=1.958e-14 ps=7.6e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=4.25e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn6 (\7\:n3 \5\:VDD n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp1 (n7 n0 \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=2.473e-14 ps=1.39e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=3e-07 sd=160n sca=17.9735 scb=0.0174913 \
        scc=0.0013169 m=(1)
mp2 (\7\:n1 \1\:VSS n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.4e-07 sd=160n sca=17.5155 \
        scb=0.0173077 scc=0.00131683 m=(1)
mp0 (\4\:n0 \4\:A \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.83e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp3 (n9 n1 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.83e-14 ad=1.29e-14 ps=1.72e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.45e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp4 (\7\:n2 \3\:VSS n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp7 (\8\:n4 n3 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=10.4732 \
        scb=0.00744141 scc=7.36981e-05 m=(1)
mp5 (n11 n2 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.3694 \
        scb=0.00808912 scc=7.45876e-05 m=(1)
mp6 (\5\:n3 \6\:VSS n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2441 \
        scb=0.00918936 scc=7.99464e-05 m=(1)
ends DLY2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:13 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY2X4
// View name: extracted

simulator lang=spectre

subckt DLY2X4 A VDD VSS Y
mp7 (\17\:n4 \3\:n3 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1468e-13 ad=5.46e-14 ps=1.63e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5391e-07 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp8_1__rcx (Y \2\:n4 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.737e-14 ad=6.24e-14 ps=1.1625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03615e-06 sd=160n sca=26.8544 \
        scb=0.027116 scc=0.00215592 m=(4)
C1 (A VSS) capacitor c=3.7144e-17
C2 (Y VSS) capacitor c=3.37994e-16
C3 (VDD VSS) capacitor c=2.32462e-16
C4 (n4 VSS) capacitor c=2.47718e-17
C5 (n0 VSS) capacitor c=3.85295e-17
C6 (n1 VSS) capacitor c=9.3671e-17
C7 (n8 VSS) capacitor c=1.61637e-18
C8 (n2 VSS) capacitor c=9.81961e-17
C9 (n3 VSS) capacitor c=6.61936e-17
C10 (n10 VSS) capacitor c=1.37378e-18
C11 (n7 VSS) capacitor c=1.68372e-18
C12 (n11 VSS) capacitor c=2.16144e-18
C13 (\3\:n3 VSS) capacitor c=5.04179e-17
C14 (\4\:A VSS) capacitor c=3.44081e-17
C15 (\5\:VDD VSS) capacitor c=5.05084e-17
C16 (\2\:n2 VSS) capacitor c=5.89292e-17
C17 (\3\:VDD VSS) capacitor c=4.20133e-17
C18 (\2\:n1 VSS) capacitor c=2.82919e-17
C19 (\3\:A VSS) capacitor c=3.90647e-17
C20 (\1\:VDD VSS) capacitor c=4.33399e-17
C21 (\3\:n0 VSS) capacitor c=5.70457e-17
C22 (\6\:VDD VSS) capacitor c=5.17765e-17
C23 (\3\:n2 VSS) capacitor c=3.05258e-17
C24 (\2\:n3 VSS) capacitor c=4.59913e-17
C25 (\4\:VDD VSS) capacitor c=4.70251e-17
C26 (\3\:n1 VSS) capacitor c=2.33607e-17
C27 (\1\:A VSS) capacitor c=1.77485e-17
C28 (\2\:VDD VSS) capacitor c=4.39752e-17
C29 (\2\:n0 VSS) capacitor c=6.20524e-17
C30 (\6\:n3 VSS) capacitor c=9.99517e-17
C31 (\9\:VDD VSS) capacitor c=6.42302e-17
C32 (\17\:n4 VSS) capacitor c=2.42338e-16
C33 (\7\:n2 VSS) capacitor c=9.55111e-17
C34 (\19\:VDD VSS) capacitor c=1.49001e-17
C35 (\4\:n0 VSS) capacitor c=7.10694e-20
C36 (\7\:n1 VSS) capacitor c=1.02794e-16
C37 (\13\:VDD VSS) capacitor c=6.22852e-17
C38 (\4\:n3 VSS) capacitor c=9.1523e-17
C39 (\15\:n4 VSS) capacitor c=1.20641e-16
C40 (\5\:n2 VSS) capacitor c=1.90643e-16
C41 (\6\:n0 VSS) capacitor c=6.58865e-17
C42 (\5\:n1 VSS) capacitor c=1.1278e-16
C43 (\2\:n4 VSS) capacitor c=2.41035e-16
C44 (\2\:A VSS) capacitor c=1.4932e-17
C45 (\5\:n0 VSS) capacitor c=1.5526e-16
C46 (\8\:n0 VSS) capacitor c=1.07495e-16
C47 (\5\:A VSS) capacitor c=7.06058e-17
C48 (\4\:n1 VSS) capacitor c=5.94099e-17
C49 (\19\:n4 VSS) capacitor c=2.42652e-16
C50 (\4\:n2 VSS) capacitor c=1.58156e-16
C51 (\8\:n3 VSS) capacitor c=7.16951e-17
C52 (\7\:VDD VSS) capacitor c=6.25076e-17
C53 (\8\:VDD VSS) capacitor c=9.4829e-17
C54 (\11\:VDD VSS) capacitor c=2.05347e-17
C55 (\12\:VDD VSS) capacitor c=3.78437e-17
C56 (\15\:VDD VSS) capacitor c=3.28854e-16
C57 (\23\:VDD VSS) capacitor c=9.57524e-17
Rk9 (A \5\:A) resistor r=0.1424 c=0
Rk35 (\7\:VDD \8\:VDD) resistor r=0.4079 c=0
Rk36 (\8\:VDD \10\:VDD) resistor r=0.4547 c=0
Rk37 (\10\:VDD \11\:VDD) resistor r=0.1878 c=0
Rk38 (\11\:VDD \12\:VDD) resistor r=0.4511 c=0
Rk39 (\12\:VDD \14\:VDD) resistor r=0.4714 c=0
Rk43 (\15\:VDD VDD) resistor r=0.0447 c=0
Rk40 (\14\:VDD \15\:VDD) resistor r=0.1177 c=0
Rk44 (\11\:VDD \18\:VDD) resistor r=0.08007 c=0
Rk45 (\12\:VDD \20\:VDD) resistor r=0.07405 c=0
Rk47 (\15\:VDD \23\:VDD) resistor r=0.8613 c=0
Rk18 (\7\:VSS \8\:VSS) resistor r=1.0017 c=0
Rk19 (\8\:VSS \10\:VSS) resistor r=0.08007 c=0
Rk20 (\10\:VSS \11\:VSS) resistor r=0.351 c=0
Rk21 (\11\:VSS \12\:VSS) resistor r=0.2144 c=0
Rk22 (\12\:VSS \13\:VSS) resistor r=0.262 c=0
Rk23 (\13\:VSS \14\:VSS) resistor r=0.1729 c=0
Rk27 (\15\:VSS VSS) resistor r=0.0447 c=0
Rk24 (\14\:VSS \15\:VSS) resistor r=0.04495 c=0
Rk28 (\8\:VSS \19\:VSS) resistor r=0.2972 c=0
Rk29 (\11\:VSS \20\:VSS) resistor r=0.6852 c=0
Rk30 (\12\:VSS \22\:VSS) resistor r=0.04332 c=0
Rk31 (\13\:VSS \23\:VSS) resistor r=0.5703 c=0
Rk12 (\16\:n4 \18\:n4) resistor r=0.6454 c=0
Rk13 (\18\:n4 \19\:n4) resistor r=1.6567 c=0
Rk7 (\5\:n0 \7\:n0) resistor r=0.3857 c=0
Rk8 (\5\:n0 \8\:n0) resistor r=0.753 c=0
Rk10 (\4\:n1 \6\:n1) resistor r=0.4203 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.5313 c=0
Rk14 (\4\:n2 \6\:n2) resistor r=1.1301 c=0
Rk15 (\6\:n2 \8\:n2) resistor r=0.5162 c=0
Rk16 (\5\:n3 \7\:n3) resistor r=0.7346 c=0
Rk17 (\7\:n3 \8\:n3) resistor r=0.423 c=0
Rl20 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl19 (\2\:A \3\:A) resistor r=87.3411 c=0
Rl18 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl30 (\6\:VDD \5\:VDD) resistor r=117.762 c=0
Rl24 (\4\:VDD \3\:VDD) resistor r=189.898 c=0
Rl16 (\2\:VDD \1\:VDD) resistor r=36.8016 c=0
Rl27 (\6\:VSS \5\:VSS) resistor r=24.2328 c=0
Rl23 (\4\:VSS \3\:VSS) resistor r=29.5379 c=0
Rl17 (\1\:VSS \2\:VSS) resistor r=61.8673 c=0
Rl1 (\2\:n4 n4) resistor r=4.1279 c=0
Rl14 (n0 \2\:n0) resistor r=24.7951 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=119.208 c=0
Rl21 (n1 \2\:n1) resistor r=134.615 c=0
Rl22 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl28 (n2 \2\:n2) resistor r=236.104 c=0
Rl29 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl26 (\2\:n3 \3\:n3) resistor r=113.016 c=0
Rl25 (n3 \2\:n3) resistor r=117.559 c=0
Rz13 (\14\:VDD \13\:VDD) resistor r=6.25 c=0
Rz14 (\18\:VDD \13\:VDD) resistor r=9.375 c=0
Rz8 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz9 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz5 (\16\:n4 \15\:n4) resistor r=75 c=0
Rz3 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz6 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz7 (\4\:n3 \5\:n3) resistor r=75 c=0
Ry10 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry11 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry8 (\10\:VSS \9\:VSS) resistor r=7.75 c=0
Ry9 (\14\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry5 (\18\:n4 \17\:n4) resistor r=20.6667 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry4 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry6 (\7\:n2 \8\:n2) resistor r=62 c=0
Ry7 (\6\:n3 \7\:n3) resistor r=62 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx10 (\7\:VDD \6\:VDD) resistor r=45 c=0
Rx11 (\8\:VDD \4\:VDD) resistor r=45 c=0
Rx12 (\23\:VDD \2\:VDD) resistor r=45 c=0
Rx7 (\7\:VSS \6\:VSS) resistor r=45 c=0
Rx8 (\20\:VSS \4\:VSS) resistor r=45 c=0
Rx9 (\23\:VSS \1\:VSS) resistor r=45 c=0
Rx4 (\19\:n4 n4) resistor r=45 c=0
Rx1 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx5 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx6 (\2\:n3 \8\:n3) resistor r=45 c=0
mn7 (\15\:n4 n3 \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.717e-14 ad=4.68e-14 ps=1.15e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.82019e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn8 (Y \2\:n4 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.857e-14 ad=5.46e-14 ps=8.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.16913e-06 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(4)
mn1 (n6 \3\:n0 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.682e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=5.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (\5\:n1 \1\:VDD n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\6\:n0 \3\:A \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (n8 \2\:n1 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=3.48e-14 ps=1.74e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\5\:n2 \3\:VDD n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn5 (n10 \2\:n2 \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.717e-14 ad=1.957e-14 ps=1.15e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=4.25e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (\4\:n3 \5\:VDD n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.552e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=2.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp1 (n7 n0 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=2.472e-14 ps=1.39e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=3e-07 sd=160n sca=27.1298 scb=0.023603 \
        scc=0.0032399 m=(1)
mp2 (\7\:n1 \2\:VSS n7 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp0 (\4\:n0 \4\:A \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp3 (n9 n1 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.45e-07 sd=160n sca=16.925 \
        scb=0.0168124 scc=0.00121732 m=(1)
mp4 (\7\:n2 \3\:VSS n9 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp5 (n11 n2 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1468e-13 ad=1.29e-14 ps=1.63e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2.45e-07 sd=160n sca=13.1834 \
        scb=0.0111853 scc=0.000283211 m=(1)
mp6 (\6\:n3 \5\:VSS n11 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.4e-07 sd=160n sca=14.1736 \
        scb=0.0125294 scc=0.000291648 m=(1)
ends DLY2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:14 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY3X1
// View name: extracted

simulator lang=spectre

subckt DLY3X1 A VDD VSS Y
mp2 (\9\:n1 \1\:VSS n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.55e-07 sd=160n sca=22.1455 \
        scb=0.0211116 scc=0.00193954 m=(1)
mp1 (n8 \2\:n0 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.5e-07 sd=160n sca=21.4207 \
        scb=0.0203168 scc=0.00193696 m=(1)
mp3 (n10 n1 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.913e-14 ps=7.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.45e-07 sd=160n sca=20.6521 \
        scb=0.0198557 scc=0.00193653 m=(1)
mp4 (\4\:n2 \3\:VSS n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.837e-14 ps=9.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.25e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp0 (\6\:n0 \1\:A \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp5 (n12 \3\:n2 \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.687e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.1e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp6 (\7\:n3 \6\:VSS n12 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=3.01e-14 ps=6.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.4e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp7 (n14 n3 \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.505e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp8 (\7\:n4 \7\:VSS n14 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.01e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp11 (\6\:n6 \3\:n5 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=7.847e-14 ps=7.5e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.5e-07 sd=160n sca=16.5775 \
        scb=0.0160907 scc=0.00103906 m=(1)
mp9 (n16 n4 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2.45e-07 sd=160n sca=17.7492 \
        scb=0.0172065 scc=0.001042 m=(1)
mp10 (\6\:n5 \10\:VSS n16 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.4e-07 sd=160n sca=18.9703 \
        scb=0.0190477 scc=0.00105936 m=(1)
C1 (A VSS) capacitor c=5.10683e-17
C2 (Y VSS) capacitor c=4.08498e-17
C3 (VDD VSS) capacitor c=2.65672e-16
C4 (n1 VSS) capacitor c=3.78854e-17
C5 (n0 VSS) capacitor c=3.6423e-17
C6 (n2 VSS) capacitor c=3.57868e-17
C7 (n11 VSS) capacitor c=1.53359e-18
C8 (n3 VSS) capacitor c=9.49489e-17
C9 (n6 VSS) capacitor c=2.41281e-17
C10 (n13 VSS) capacitor c=4.75455e-18
C11 (n4 VSS) capacitor c=1.03916e-16
C12 (n5 VSS) capacitor c=4.64577e-17
C13 (n15 VSS) capacitor c=1.41579e-18
C14 (n8 VSS) capacitor c=1.53039e-18
C15 (n10 VSS) capacitor c=3.20763e-18
C16 (n12 VSS) capacitor c=2.28512e-18
C17 (n14 VSS) capacitor c=6.09855e-19
C18 (n16 VSS) capacitor c=1.92136e-18
C19 (\3\:n5 VSS) capacitor c=2.82837e-17
C20 (\4\:n6 VSS) capacitor c=4.34896e-17
C21 (\3\:n2 VSS) capacitor c=8.06902e-17
C22 (\1\:A VSS) capacitor c=2.96724e-17
C23 (\2\:n0 VSS) capacitor c=1.33484e-16
C24 (\9\:VDD VSS) capacitor c=5.3239e-17
C25 (\2\:n4 VSS) capacitor c=6.8641e-17
C26 (\7\:VDD VSS) capacitor c=4.07475e-17
C27 (\2\:n3 VSS) capacitor c=2.68294e-17
C28 (\3\:n6 VSS) capacitor c=3.90888e-17
C29 (\5\:VDD VSS) capacitor c=3.96916e-17
C30 (\2\:n2 VSS) capacitor c=4.82767e-17
C31 (\3\:A VSS) capacitor c=4.24412e-17
C32 (\3\:VDD VSS) capacitor c=3.78169e-17
C33 (\4\:n1 VSS) capacitor c=6.13063e-17
C34 (\3\:n0 VSS) capacitor c=1.00287e-16
C35 (\1\:VDD VSS) capacitor c=5.77291e-17
C36 (\10\:VDD VSS) capacitor c=4.81686e-17
C37 (\3\:n4 VSS) capacitor c=3.35552e-17
C38 (\2\:n5 VSS) capacitor c=6.17805e-17
C39 (\8\:VDD VSS) capacitor c=4.68181e-17
C40 (\3\:n3 VSS) capacitor c=2.18895e-17
C41 (\6\:VDD VSS) capacitor c=4.77615e-17
C42 (\2\:A VSS) capacitor c=4.08205e-17
C43 (\4\:VDD VSS) capacitor c=3.99826e-17
C44 (\3\:n1 VSS) capacitor c=2.47185e-17
C45 (\2\:VDD VSS) capacitor c=5.18378e-17
C46 (\6\:n5 VSS) capacitor c=1.0033e-16
C47 (\19\:VDD VSS) capacitor c=2.48577e-17
C48 (\6\:n6 VSS) capacitor c=1.26955e-16
C49 (\7\:n4 VSS) capacitor c=8.8876e-17
C50 (\17\:VDD VSS) capacitor c=3.45881e-17
C51 (\1\:Y VSS) capacitor c=6.68074e-17
C52 (\7\:n3 VSS) capacitor c=8.86815e-17
C53 (\24\:VDD VSS) capacitor c=3.98717e-17
C54 (\6\:n0 VSS) capacitor c=1.25103e-16
C55 (\4\:n2 VSS) capacitor c=8.85893e-17
C56 (\29\:VDD VSS) capacitor c=1.96823e-17
C57 (\9\:n1 VSS) capacitor c=7.71345e-18
C58 (\14\:VDD VSS) capacitor c=4.40064e-17
C59 (\4\:n5 VSS) capacitor c=1.01829e-16
C60 (\8\:n6 VSS) capacitor c=1.15184e-16
C61 (\5\:n4 VSS) capacitor c=2.24042e-16
C62 (\3\:Y VSS) capacitor c=5.69624e-17
C63 (\5\:n3 VSS) capacitor c=1.97677e-16
C64 (\4\:n0 VSS) capacitor c=1.17651e-16
C65 (\6\:n2 VSS) capacitor c=1.94056e-16
C66 (\7\:n1 VSS) capacitor c=8.37319e-17
C67 (\2\:n1 VSS) capacitor c=4.16985e-17
C68 (\2\:n6 VSS) capacitor c=1.16723e-17
C69 (\5\:n1 VSS) capacitor c=5.32974e-17
C70 (\6\:n1 VSS) capacitor c=7.78861e-17
C71 (\8\:n0 VSS) capacitor c=6.02326e-17
C72 (\4\:A VSS) capacitor c=7.89124e-17
C73 (\8\:n2 VSS) capacitor c=1.33409e-16
C74 (\4\:n3 VSS) capacitor c=1.2612e-16
C75 (\5\:n6 VSS) capacitor c=9.56592e-17
C76 (\4\:n4 VSS) capacitor c=1.90517e-16
C77 (\8\:n5 VSS) capacitor c=7.17243e-17
C78 (\11\:VDD VSS) capacitor c=7.16931e-17
C79 (\12\:VDD VSS) capacitor c=1.34386e-16
C80 (\13\:VDD VSS) capacitor c=2.80969e-17
C81 (\16\:VDD VSS) capacitor c=2.29364e-17
C82 (\21\:VDD VSS) capacitor c=2.38704e-17
C83 (\22\:VDD VSS) capacitor c=9.4655e-17
C84 (\23\:VDD VSS) capacitor c=1.57212e-17
C85 (\27\:VDD VSS) capacitor c=1.48544e-17
C86 (\28\:VDD VSS) capacitor c=5.55726e-17
C87 (\31\:VDD VSS) capacitor c=7.99634e-17
C88 (\32\:VDD VSS) capacitor c=5.47297e-17
Rk19 (\11\:VSS \12\:VSS) resistor r=0.9514 c=0
Rk20 (\12\:VSS \14\:VSS) resistor r=0.2607 c=0
Rk21 (\14\:VSS \15\:VSS) resistor r=0.08762 c=0
Rk22 (\15\:VSS \16\:VSS) resistor r=0.1903 c=0
Rk23 (\16\:VSS \17\:VSS) resistor r=0.381 c=0
Rk24 (\17\:VSS \18\:VSS) resistor r=0.2179 c=0
Rk25 (\18\:VSS \19\:VSS) resistor r=0.326 c=0
Rk26 (\12\:VSS \21\:VSS) resistor r=0.2735 c=0
Rk27 (\15\:VSS \22\:VSS) resistor r=0.6302 c=0
Rk28 (\16\:VSS \24\:VSS) resistor r=0.3005 c=0
Rk29 (\17\:VSS \25\:VSS) resistor r=0.6585 c=0
Rk30 (\18\:VSS \27\:VSS) resistor r=0.3079 c=0
Rk31 (\19\:VSS \28\:VSS) resistor r=0.2212 c=0
Rk33 (\29\:VSS VSS) resistor r=0.1125 c=0
Rk32 (\28\:VSS \29\:VSS) resistor r=0.2179 c=0
Rk34 (\19\:VSS \30\:VSS) resistor r=0.6296 c=0
Rk35 (\28\:VSS \32\:VSS) resistor r=0.185 c=0
Rk36 (\29\:VSS \33\:VSS) resistor r=0.7146 c=0
Rk6 (A \4\:A) resistor r=0.0194 c=0
Rk9 (\2\:Y Y) resistor r=0.2502 c=0
Rk10 (Y \4\:Y) resistor r=0.2028 c=0
Rk37 (\11\:VDD \12\:VDD) resistor r=0.3658 c=0
Rk38 (\12\:VDD \13\:VDD) resistor r=0.6978 c=0
Rk39 (\13\:VDD \15\:VDD) resistor r=0.1529 c=0
Rk40 (\15\:VDD \16\:VDD) resistor r=0.2532 c=0
Rk41 (\16\:VDD \18\:VDD) resistor r=0.2988 c=0
Rk42 (\13\:VDD \20\:VDD) resistor r=0.499 c=0
Rk43 (\16\:VDD \21\:VDD) resistor r=0.5165 c=0
Rk44 (\21\:VDD \22\:VDD) resistor r=0.6347 c=0
Rk45 (\21\:VDD \23\:VDD) resistor r=0.1075 c=0
Rk46 (\23\:VDD \25\:VDD) resistor r=0.3538 c=0
Rk47 (\23\:VDD \26\:VDD) resistor r=0.326 c=0
Rk51 (\27\:VDD VDD) resistor r=0.3584 c=0
Rk48 (\26\:VDD \27\:VDD) resistor r=0.193 c=0
Rk49 (\27\:VDD \28\:VDD) resistor r=0.3312 c=0
Rk50 (\28\:VDD \30\:VDD) resistor r=0.05479 c=0
Rk52 (\28\:VDD \31\:VDD) resistor r=0.4901 c=0
Rk53 (\31\:VDD \32\:VDD) resistor r=0.3549 c=0
Rk1 (\5\:n1 \6\:n1) resistor r=0.3194 c=0
Rk2 (\6\:n1 \8\:n1) resistor r=0.6819 c=0
Rk3 (\6\:n1 \10\:n1) resistor r=0.02809 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.6105 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.5443 c=0
Rk7 (\5\:n2 \7\:n2) resistor r=0.5746 c=0
Rk8 (\7\:n2 \8\:n2) resistor r=0.9837 c=0
Rk11 (\4\:n3 \6\:n3) resistor r=0.9337 c=0
Rk12 (\6\:n3 \8\:n3) resistor r=0.7382 c=0
Rk13 (\5\:n6 \7\:n6) resistor r=0.7079 c=0
Rk14 (\7\:n6 \9\:n6) resistor r=0.6169 c=0
Rk15 (\4\:n4 \6\:n4) resistor r=1.3173 c=0
Rk16 (\6\:n4 \8\:n4) resistor r=0.5008 c=0
Rk17 (\5\:n5 \7\:n5) resistor r=0.7564 c=0
Rk18 (\7\:n5 \8\:n5) resistor r=0.4045 c=0
Rl28 (\9\:VSS \10\:VSS) resistor r=39.7311 c=0
Rl21 (\7\:VSS \8\:VSS) resistor r=31.9251 c=0
Rl15 (\5\:VSS \6\:VSS) resistor r=89.8977 c=0
Rl9 (\3\:VSS \4\:VSS) resistor r=71.8456 c=0
Rl1 (\1\:VSS \2\:VSS) resistor r=49.2328 c=0
Rl10 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl11 (\2\:A \3\:A) resistor r=156.925 c=0
Rl27 (\9\:VDD \10\:VDD) resistor r=91.2131 c=0
Rl22 (\7\:VDD \8\:VDD) resistor r=196.875 c=0
Rl14 (\5\:VDD \6\:VDD) resistor r=103.359 c=0
Rl8 (\3\:VDD \4\:VDD) resistor r=87.6944 c=0
Rl2 (\1\:VDD \2\:VDD) resistor r=87.6944 c=0
Rl3 (n1 \2\:n1) resistor r=34.3295 c=0
Rl5 (\2\:n1 \4\:n1) resistor r=184.329 c=0
Rl4 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=226.923 c=0
Rl6 (n0 \2\:n0) resistor r=189.898 c=0
Rl13 (\2\:n2 \3\:n2) resistor r=209.615 c=0
Rl12 (n2 \2\:n2) resistor r=36.2715 c=0
Rl19 (n3 \2\:n3) resistor r=134.615 c=0
Rl20 (\2\:n3 \3\:n3) resistor r=24.2328 c=0
Rl18 (\2\:n6 \4\:n6) resistor r=22.3936 c=0
Rl17 (\2\:n6 \3\:n6) resistor r=65.8358 c=0
Rl16 (n6 \2\:n6) resistor r=12.8731 c=0
Rl25 (n4 \2\:n4) resistor r=214.045 c=0
Rl26 (\2\:n4 \3\:n4) resistor r=35.7713 c=0
Rl24 (\2\:n5 \3\:n5) resistor r=51.2624 c=0
Rl23 (n5 \2\:n5) resistor r=152.174 c=0
Rz9 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz10 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz11 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz12 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\14\:VDD \15\:VDD) resistor r=6.25 c=0
Rz14 (\14\:VDD \26\:VDD) resistor r=6.25 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n2 \7\:n2) resistor r=75 c=0
Rz5 (\5\:n3 \6\:n3) resistor r=75 c=0
Rz6 (\8\:n6 \9\:n6) resistor r=75 c=0
Rz7 (\5\:n4 \6\:n4) resistor r=75 c=0
Rz8 (\4\:n5 \5\:n5) resistor r=75 c=0
Ry9 (\13\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry10 (\13\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry11 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry12 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry13 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry14 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\4\:n2 \5\:n2) resistor r=62 c=0
Ry5 (\7\:n3 \8\:n3) resistor r=62 c=0
Ry6 (\6\:n6 \7\:n6) resistor r=62 c=0
Ry7 (\7\:n4 \8\:n4) resistor r=62 c=0
Ry8 (\6\:n5 \7\:n5) resistor r=62 c=0
Rx9 (\9\:VSS \11\:VSS) resistor r=45 c=0
Rx10 (\8\:VSS \22\:VSS) resistor r=45 c=0
Rx11 (\5\:VSS \25\:VSS) resistor r=45 c=0
Rx12 (\4\:VSS \30\:VSS) resistor r=45 c=0
Rx13 (\2\:VSS \33\:VSS) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx14 (\10\:VDD \11\:VDD) resistor r=45 c=0
Rx15 (\8\:VDD \12\:VDD) resistor r=45 c=0
Rx16 (\6\:VDD \22\:VDD) resistor r=45 c=0
Rx17 (\4\:VDD \31\:VDD) resistor r=45 c=0
Rx18 (\2\:VDD \32\:VDD) resistor r=45 c=0
Rx1 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx2 (n0 \8\:n0) resistor r=45 c=0
Rx4 (n2 \8\:n2) resistor r=45 c=0
Rx5 (\3\:n3 \4\:n3) resistor r=45 c=0
Rx6 (n6 \5\:n6) resistor r=45 c=0
Rx7 (\3\:n4 \4\:n4) resistor r=45 c=0
Rx8 (\2\:n5 \8\:n5) resistor r=45 c=0
mn2 (\7\:n1 \1\:VDD n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.163e-14 ps=4.1e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=8.15e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (n7 \3\:n0 \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=7.1e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n9 \4\:n1 \31\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.175e-14 ps=6.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=5.05e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\6\:n2 \3\:VDD n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.495e-14 ps=5.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=3.1e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (\4\:n0 \3\:A \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.698e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.35e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn5 (n11 \2\:n2 \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn6 (\5\:n3 \5\:VDD n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=3e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn7 (n13 \2\:n3 \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.725e-14 ad=3.48e-14 ps=1.01e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.25e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn8 (\5\:n4 \7\:VDD n13 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\8\:n6 n5 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.567e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=6.2e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn9 (n15 \2\:n4 \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.812e-14 ps=6.1e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.15e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn10 (\4\:n5 \9\:VDD n15 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.552e-14 ps=5.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.45e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn12 (\3\:Y \3\:n6 \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.725e-14 ad=7.28e-14 ps=1.01e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=4.43846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp12 (\1\:Y \4\:n6 \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.32949e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
ends DLY3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:15 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY3X4
// View name: extracted

simulator lang=spectre

subckt DLY3X4 A VDD VSS Y
mp2 (\9\:n1 \1\:VSS n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.01e-14 ps=7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.8e-07 sd=160n sca=23.8898 \
        scb=0.0257238 scc=0.00168255 m=(1)
mp1 (n8 \2\:n0 \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=7e-07 sd=160n sca=20.5436 scb=0.0200303 \
        scc=0.00154452 m=(1)
mp3 (n10 \4\:n1 \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.665e-14 ps=7.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=4.95e-07 sd=160n sca=19.1751 \
        scb=0.0185424 scc=0.00153893 m=(1)
mp4 (\8\:n2 \3\:VSS n10 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=3.01e-14 ps=1.05e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp0 (\6\:n0 \4\:A \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.32326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp5 (n12 n2 \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.59e-14 ps=7.5e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.27326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp6 (\8\:n3 \5\:VSS n12 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.63e-14 ps=9.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.22326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp7 (n14 n3 \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.167e-14 ad=1.29e-14 ps=1.47e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10686e-06 sb=2.45e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp8 (\7\:n4 \8\:VSS n14 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21186e-06 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp9 (n16 n4 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0415e-13 ad=1.29e-14 ps=1.56e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=17.1405 \
        scb=0.0165101 scc=0.000961221 m=(1)
mp10 (\7\:n5 \10\:VSS n16 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=18.2098 \
        scb=0.0180238 scc=0.000972287 m=(1)
C1 (Y VSS) capacitor c=3.25246e-16
C2 (A VSS) capacitor c=4.46454e-17
C3 (VDD VSS) capacitor c=2.68081e-16
C4 (n1 VSS) capacitor c=9.15724e-17
C5 (n0 VSS) capacitor c=3.87798e-17
C6 (n9 VSS) capacitor c=7.26019e-19
C7 (n2 VSS) capacitor c=6.02824e-17
C8 (n11 VSS) capacitor c=1.08923e-18
C9 (n3 VSS) capacitor c=7.61519e-17
C10 (n6 VSS) capacitor c=2.37615e-16
C11 (n13 VSS) capacitor c=4.89877e-18
C12 (n4 VSS) capacitor c=9.96547e-17
C13 (n5 VSS) capacitor c=4.88244e-17
C14 (n15 VSS) capacitor c=1.91808e-19
C15 (n8 VSS) capacitor c=3.4105e-18
C16 (n10 VSS) capacitor c=1.46957e-18
C17 (n12 VSS) capacitor c=2.47056e-18
C18 (\3\:n5 VSS) capacitor c=5.16677e-17
C19 (\4\:A VSS) capacitor c=3.84771e-17
C20 (\4\:n1 VSS) capacitor c=4.01437e-17
C21 (\2\:n0 VSS) capacitor c=1.16124e-16
C22 (\9\:VDD VSS) capacitor c=4.55286e-17
C23 (\2\:n4 VSS) capacitor c=5.44927e-17
C24 (\7\:VDD VSS) capacitor c=4.78561e-17
C25 (\2\:n3 VSS) capacitor c=2.27426e-17
C26 (\5\:VDD VSS) capacitor c=5.85805e-17
C27 (\2\:n2 VSS) capacitor c=5.59928e-17
C28 (\3\:A VSS) capacitor c=3.38833e-17
C29 (\3\:VDD VSS) capacitor c=5.85448e-17
C30 (\3\:n0 VSS) capacitor c=1.00136e-16
C31 (\1\:VDD VSS) capacitor c=5.80815e-17
C32 (\10\:VDD VSS) capacitor c=4.91631e-17
C33 (\3\:n4 VSS) capacitor c=3.2509e-17
C34 (\4\:n5 VSS) capacitor c=3.29996e-17
C35 (\8\:VDD VSS) capacitor c=4.89942e-17
C36 (\3\:n3 VSS) capacitor c=2.03316e-17
C37 (\9\:n6 VSS) capacitor c=1.6592e-17
C38 (\6\:VDD VSS) capacitor c=4.64086e-17
C39 (\3\:n2 VSS) capacitor c=2.9458e-17
C40 (\1\:A VSS) capacitor c=2.36839e-17
C41 (\4\:VDD VSS) capacitor c=4.27378e-17
C42 (\3\:n1 VSS) capacitor c=2.75374e-17
C43 (\2\:VDD VSS) capacitor c=4.38253e-17
C44 (\7\:n5 VSS) capacitor c=9.82696e-17
C45 (\22\:VDD VSS) capacitor c=4.41016e-17
C46 (\16\:n6 VSS) capacitor c=1.5094e-16
C47 (\7\:n4 VSS) capacitor c=1.02001e-16
C48 (\8\:n3 VSS) capacitor c=5.90933e-17
C49 (\33\:VDD VSS) capacitor c=4.20954e-17
C50 (\6\:n0 VSS) capacitor c=1.07742e-16
C51 (\8\:n2 VSS) capacitor c=8.35695e-17
C52 (\35\:VDD VSS) capacitor c=7.75224e-17
C53 (\9\:n1 VSS) capacitor c=1.82376e-17
C54 (\11\:VDD VSS) capacitor c=7.18785e-17
C55 (\5\:n5 VSS) capacitor c=8.76659e-17
C56 (\18\:n6 VSS) capacitor c=1.03643e-16
C57 (\5\:n4 VSS) capacitor c=2.0265e-16
C58 (\6\:n3 VSS) capacitor c=2.93234e-17
C59 (\4\:n0 VSS) capacitor c=7.2857e-17
C60 (\6\:n2 VSS) capacitor c=4.30493e-17
C61 (\7\:n1 VSS) capacitor c=6.3303e-17
C62 (\2\:n1 VSS) capacitor c=4.66308e-17
C63 (\2\:A VSS) capacitor c=1.84648e-17
C64 (\2\:n5 VSS) capacitor c=2.80062e-17
C65 (\5\:n1 VSS) capacitor c=7.28546e-17
C66 (\6\:n1 VSS) capacitor c=6.38784e-17
C67 (\8\:n0 VSS) capacitor c=7.04176e-17
C68 (\5\:A VSS) capacitor c=6.84446e-17
C69 (\4\:n2 VSS) capacitor c=5.56967e-17
C70 (\5\:n2 VSS) capacitor c=8.86311e-17
C71 (\4\:n3 VSS) capacitor c=2.11623e-16
C72 (\5\:n3 VSS) capacitor c=1.93297e-16
C73 (\15\:n6 VSS) capacitor c=1.25744e-16
C74 (\4\:n4 VSS) capacitor c=1.45032e-16
C75 (\9\:n5 VSS) capacitor c=6.14717e-17
C76 (\13\:VDD VSS) capacitor c=1.57295e-17
C77 (\15\:VDD VSS) capacitor c=2.169e-16
C78 (\18\:VDD VSS) capacitor c=6.74666e-18
C79 (\19\:VDD VSS) capacitor c=1.13333e-17
C80 (\21\:VDD VSS) capacitor c=1.78814e-17
C81 (\24\:VDD VSS) capacitor c=8.65947e-17
C82 (\25\:VDD VSS) capacitor c=1.88106e-17
C83 (\32\:VDD VSS) capacitor c=4.80291e-17
C84 (\37\:VDD VSS) capacitor c=7.70258e-17
C85 (\38\:VDD VSS) capacitor c=7.03383e-17
C86 (\39\:VDD VSS) capacitor c=7.89878e-17
Rk25 (\12\:VSS \13\:VSS) resistor r=0.06753 c=0
Rk26 (\13\:VSS \14\:VSS) resistor r=0.1902 c=0
Rk27 (\14\:VSS \15\:VSS) resistor r=0.3934 c=0
Rk28 (\15\:VSS \16\:VSS) resistor r=0.04997 c=0
Rk29 (\16\:VSS \17\:VSS) resistor r=0.1403 c=0
Rk32 (\17\:VSS \20\:VSS) resistor r=0.0874 c=0
Rk33 (\20\:VSS \21\:VSS) resistor r=0.1793 c=0
Rk34 (\21\:VSS \22\:VSS) resistor r=0.207 c=0
Rk35 (\22\:VSS \23\:VSS) resistor r=0.1603 c=0
Rk36 (\23\:VSS \24\:VSS) resistor r=0.07987 c=0
Rk38 (\25\:VSS VSS) resistor r=0.09236 c=0
Rk37 (\24\:VSS \25\:VSS) resistor r=0.2178 c=0
Rk39 (\13\:VSS \26\:VSS) resistor r=0.6834 c=0
Rk40 (\14\:VSS \28\:VSS) resistor r=0.237 c=0
Rk41 (\15\:VSS \29\:VSS) resistor r=0.6114 c=0
Rk45 (\20\:VSS \36\:VSS) resistor r=0.5823 c=0
Rk46 (\21\:VSS \38\:VSS) resistor r=0.04332 c=0
Rk47 (\23\:VSS \39\:VSS) resistor r=0.7478 c=0
Rk48 (\24\:VSS \41\:VSS) resistor r=0.2622 c=0
Rk49 (\25\:VSS \42\:VSS) resistor r=0.5645 c=0
Rk6 (\5\:A A) resistor r=0.07297 c=0
Rk50 (\12\:VDD \13\:VDD) resistor r=0.356 c=0
Rk51 (\13\:VDD \14\:VDD) resistor r=0.3459 c=0
Rk52 (\14\:VDD \15\:VDD) resistor r=0.208 c=0
Rk55 (\15\:VDD \18\:VDD) resistor r=0.2479 c=0
Rk56 (\18\:VDD \19\:VDD) resistor r=0.1075 c=0
Rk57 (\19\:VDD \20\:VDD) resistor r=0.2281 c=0
Rk59 (\21\:VDD VDD) resistor r=0.288 c=0
Rk58 (\20\:VDD \21\:VDD) resistor r=0.2632 c=0
Rk60 (\13\:VDD \23\:VDD) resistor r=0.2927 c=0
Rk61 (\23\:VDD \24\:VDD) resistor r=0.3931 c=0
Rk62 (\24\:VDD \25\:VDD) resistor r=0.06622 c=0
Rk66 (\18\:VDD \32\:VDD) resistor r=0.5025 c=0
Rk67 (\19\:VDD \34\:VDD) resistor r=0.3918 c=0
Rk68 (\21\:VDD \36\:VDD) resistor r=0.3521 c=0
Rk69 (\36\:VDD \37\:VDD) resistor r=0.4008 c=0
Rk70 (\37\:VDD \38\:VDD) resistor r=0.3206 c=0
Rk71 (\24\:VDD \39\:VDD) resistor r=0.3785 c=0
Rk1 (\5\:n1 \6\:n1) resistor r=0.3436 c=0
Rk2 (\6\:n1 \8\:n1) resistor r=0.4134 c=0
Rk3 (\6\:n1 \10\:n1) resistor r=0.02292 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.3899 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.6089 c=0
Rk7 (\4\:n2 \5\:n2) resistor r=0.4021 c=0
Rk8 (\5\:n2 \7\:n2) resistor r=0.1355 c=0
Rk9 (\5\:n2 \9\:n2) resistor r=0.517 c=0
Rk16 (\4\:n3 \5\:n3) resistor r=1.5123 c=0
Rk17 (\5\:n3 \7\:n3) resistor r=0.06035 c=0
Rk18 (\5\:n3 \9\:n3) resistor r=0.3849 c=0
Rk19 (\15\:n6 \17\:n6) resistor r=0.9667 c=0
Rk20 (\17\:n6 \19\:n6) resistor r=0.4137 c=0
Rk21 (\4\:n4 \6\:n4) resistor r=1.0255 c=0
Rk22 (\6\:n4 \8\:n4) resistor r=0.5622 c=0
Rk23 (\6\:n5 \8\:n5) resistor r=0.689 c=0
Rk24 (\8\:n5 \9\:n5) resistor r=0.3794 c=0
Rl40 (\9\:VSS \10\:VSS) resistor r=90.3618 c=0
Rl32 (\7\:VSS \8\:VSS) resistor r=57.6695 c=0
Rl16 (\6\:VSS \5\:VSS) resistor r=71.8456 c=0
Rl9 (\4\:VSS \3\:VSS) resistor r=24.2328 c=0
Rl1 (\2\:VSS \1\:VSS) resistor r=66.0234 c=0
Rl12 (\2\:A \4\:A) resistor r=97.7911 c=0
Rl11 (\2\:A \3\:A) resistor r=34.3295 c=0
Rl10 (\1\:A \2\:A) resistor r=1.2713 c=0
Rl39 (\10\:VDD \9\:VDD) resistor r=95.1508 c=0
Rl33 (\8\:VDD \7\:VDD) resistor r=189.898 c=0
Rl15 (\6\:VDD \5\:VDD) resistor r=87.6944 c=0
Rl8 (\4\:VDD \3\:VDD) resistor r=87.6944 c=0
Rl2 (\2\:VDD \1\:VDD) resistor r=47.3097 c=0
Rl5 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl3 (n1 \2\:n1) resistor r=180.049 c=0
Rl4 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=222.643 c=0
Rl6 (n0 \2\:n0) resistor r=189.898 c=0
Rl13 (n2 \2\:n2) resistor r=140.385 c=0
Rl14 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl30 (n3 \2\:n3) resistor r=153.846 c=0
Rl31 (\2\:n3 \3\:n3) resistor r=24.2328 c=0
Rl24 (n6 \9\:n6) resistor r=10.3526 c=0
Rl37 (n4 \2\:n4) resistor r=216.534 c=0
Rl38 (\2\:n4 \3\:n4) resistor r=24.2328 c=0
Rl35 (\2\:n5 \3\:n5) resistor r=90.3625 c=0
Rl34 (n5 \2\:n5) resistor r=90.0661 c=0
Rl36 (\2\:n5 \4\:n5) resistor r=34.5407 c=0
Rz10 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz14 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz15 (\41\:VSS \40\:VSS) resistor r=75 c=0
Rz16 (\12\:VDD \11\:VDD) resistor r=37.5 c=0
Rz17 (\14\:VDD \11\:VDD) resistor r=6.25 c=0
Rz18 (\20\:VDD \11\:VDD) resistor r=6.25 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n2 \7\:n2) resistor r=75 c=0
Rz6 (\6\:n3 \7\:n3) resistor r=75 c=0
Rz7 (\19\:n6 \18\:n6) resistor r=75 c=0
Rz8 (\5\:n4 \6\:n4) resistor r=75 c=0
Rz9 (\5\:n5 \6\:n5) resistor r=75 c=0
Ry10 (\12\:VSS \11\:VSS) resistor r=31 c=0
Ry11 (\16\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry12 (\22\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry13 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry17 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry18 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\8\:n2 \9\:n2) resistor r=62 c=0
Ry6 (\8\:n3 \9\:n3) resistor r=62 c=0
Ry7 (\17\:n6 \16\:n6) resistor r=20.6667 c=0
Ry8 (\7\:n4 \8\:n4) resistor r=62 c=0
Ry9 (\7\:n5 \8\:n5) resistor r=62 c=0
Rx9 (\26\:VSS \9\:VSS) resistor r=45 c=0
Rx10 (\29\:VSS \7\:VSS) resistor r=45 c=0
Rx11 (\36\:VSS \6\:VSS) resistor r=45 c=0
Rx12 (\39\:VSS \4\:VSS) resistor r=45 c=0
Rx13 (\42\:VSS \2\:VSS) resistor r=45 c=0
Rx3 (\1\:A \5\:A) resistor r=45 c=0
Rx14 (\25\:VDD \8\:VDD) resistor r=45 c=0
Rx15 (\32\:VDD \6\:VDD) resistor r=45 c=0
Rx16 (\37\:VDD \4\:VDD) resistor r=45 c=0
Rx17 (\38\:VDD \2\:VDD) resistor r=45 c=0
Rx18 (\39\:VDD \10\:VDD) resistor r=45 c=0
Rx1 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx2 (n0 \8\:n0) resistor r=45 c=0
Rx4 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx5 (\3\:n3 \4\:n3) resistor r=45 c=0
Rx6 (\15\:n6 \9\:n6) resistor r=45 c=0
Rx7 (\3\:n4 \4\:n4) resistor r=45 c=0
Rx8 (\4\:n5 \9\:n5) resistor r=45 c=0
mn2 (\7\:n1 \1\:VDD n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.163e-14 ps=4.1e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=5.65e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn1 (n7 \3\:n0 \40\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=4.6e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn3 (n9 n1 \40\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2.55e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn4 (\6\:n2 \3\:VDD n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.175e-14 ps=4.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.5e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn0 (\4\:n0 \3\:A \37\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=2.465e-14 ps=1.62e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=6.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn5 (n11 \2\:n2 \37\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=1.957e-14 ps=1.62e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=4.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (\6\:n3 \5\:VDD n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.407e-14 ps=5.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn7 (n13 \2\:n3 \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=3.48e-14 ps=1.23e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=4.25e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn8 (\5\:n4 \7\:VDD n13 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn9 (n15 \2\:n4 \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=1.957e-14 ps=1e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=4.55e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn10 (\5\:n5 \9\:VDD n15 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.988e-14 ps=5.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2.75e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn11 (\18\:n6 n5 \27\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=8.19e-14 ps=1e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=4.56923e-07 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn12_1__rcx (Y n6 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.069e-14 ad=4.16e-14 ps=1.3975e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22115e-07 sb=1.17933e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mp11 (\16\:n6 \3\:n5 \22\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0415e-13 ad=5.46e-14 ps=1.56e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.26923e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp12 (Y n6 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.507e-14 ad=6.24e-14 ps=1.1825e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.00994e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
ends DLY3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:16 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY4X1
// View name: extracted

simulator lang=spectre

subckt DLY4X1 A VDD VSS Y
mp16 (\1\:Y net333 \37\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.1619 scb=0.02637 \
        scc=0.00345369 m=(1)
C1 (Y VSS) capacitor c=8.02748e-17
C2 (VDD VSS) capacitor c=3.72072e-16
C3 (A VSS) capacitor c=8.31345e-17
C4 (net333 VSS) capacitor c=3.06847e-17
C5 (net345 VSS) capacitor c=3.30526e-17
C6 (net353 VSS) capacitor c=5.83625e-17
C7 (net349 VSS) capacitor c=1.40987e-18
C8 (net361 VSS) capacitor c=8.89061e-17
C9 (net357 VSS) capacitor c=5.62055e-18
C10 (net369 VSS) capacitor c=5.8407e-17
C11 (net365 VSS) capacitor c=1.66931e-18
C12 (net377 VSS) capacitor c=4.73742e-17
C13 (net385 VSS) capacitor c=2.36088e-17
C14 (net393 VSS) capacitor c=1.01375e-16
C15 (net389 VSS) capacitor c=2.06898e-18
C16 (net397 VSS) capacitor c=2.17505e-17
C17 (net276 VSS) capacitor c=1.29981e-18
C18 (net284 VSS) capacitor c=1.6656e-18
C19 (net300 VSS) capacitor c=1.91562e-18
C20 (net292 VSS) capacitor c=2.19821e-18
C21 (net308 VSS) capacitor c=2.65208e-18
C22 (\1\:A VSS) capacitor c=4.67574e-17
C23 (\4\:net397 VSS) capacitor c=1.02064e-16
C24 (\4\:net385 VSS) capacitor c=4.00803e-17
C25 (\2\:net377 VSS) capacitor c=5.99341e-17
C26 (\3\:net345 VSS) capacitor c=3.77021e-17
C27 (\4\:A VSS) capacitor c=4.35633e-17
C28 (\3\:net397 VSS) capacitor c=3.11883e-17
C29 (\9\:VDD VSS) capacitor c=6.42667e-17
C30 (\11\:VDD VSS) capacitor c=3.29842e-17
C31 (\2\:net393 VSS) capacitor c=5.63493e-17
C32 (\3\:net385 VSS) capacitor c=5.42511e-17
C33 (\7\:VDD VSS) capacitor c=4.05976e-17
C34 (\6\:VDD VSS) capacitor c=4.32933e-17
C35 (\3\:net377 VSS) capacitor c=3.93628e-17
C36 (\5\:net369 VSS) capacitor c=3.03169e-17
C37 (\3\:VDD VSS) capacitor c=2.6464e-17
C38 (\5\:VDD VSS) capacitor c=5.31173e-17
C39 (\2\:net361 VSS) capacitor c=5.60912e-17
C40 (\1\:VDD VSS) capacitor c=4.34589e-17
C41 (\2\:net353 VSS) capacitor c=6.60038e-17
C42 (\4\:net333 VSS) capacitor c=2.00246e-17
C43 (\3\:A VSS) capacitor c=2.35955e-17
C44 (\10\:VDD VSS) capacitor c=6.62883e-17
C45 (\3\:net393 VSS) capacitor c=3.30589e-17
C46 (\8\:VDD VSS) capacitor c=2.61349e-17
C47 (\2\:net369 VSS) capacitor c=7.35389e-17
C48 (\4\:net377 VSS) capacitor c=2.89249e-17
C49 (\4\:net361 VSS) capacitor c=3.36236e-17
C50 (\4\:net369 VSS) capacitor c=2.57675e-17
C51 (\4\:VDD VSS) capacitor c=2.54206e-17
C52 (\3\:net361 VSS) capacitor c=4.65265e-17
C53 (\2\:VDD VSS) capacitor c=3.64656e-17
C54 (\3\:net353 VSS) capacitor c=3.09958e-17
C55 (\3\:net333 VSS) capacitor c=1.16476e-17
C56 (\5\:net397 VSS) capacitor c=6.62465e-17
C57 (\12\:VDD VSS) capacitor c=3.61126e-17
C58 (\7\:net393 VSS) capacitor c=8.90922e-17
C59 (\9\:net385 VSS) capacitor c=1.91745e-17
C60 (\25\:VDD VSS) capacitor c=4.02617e-18
C61 (\5\:net377 VSS) capacitor c=3.62745e-17
C62 (\8\:net361 VSS) capacitor c=1.70081e-16
C63 (\29\:VDD VSS) capacitor c=2.13808e-17
C64 (\6\:net369 VSS) capacitor c=6.27666e-17
C65 (\6\:net353 VSS) capacitor c=1.51193e-16
C66 (\32\:VDD VSS) capacitor c=3.28241e-17
C67 (\7\:net345 VSS) capacitor c=1.17004e-16
C68 (\34\:VDD VSS) capacitor c=6.769e-17
C69 (\5\:net333 VSS) capacitor c=8.41404e-17
C70 (\1\:Y VSS) capacitor c=8.11802e-17
C71 (\37\:VDD VSS) capacitor c=5.53031e-17
C72 (\14\:VDD VSS) capacitor c=7.35889e-17
C73 (\9\:net397 VSS) capacitor c=2.13821e-17
C74 (\5\:net393 VSS) capacitor c=1.32365e-16
C75 (\5\:net385 VSS) capacitor c=5.34215e-17
C76 (\9\:net377 VSS) capacitor c=9.6725e-17
C77 (\9\:net369 VSS) capacitor c=1.07311e-16
C78 (\6\:net361 VSS) capacitor c=5.602e-17
C79 (\4\:net353 VSS) capacitor c=1.17562e-16
C80 (\5\:net345 VSS) capacitor c=7.47479e-17
C81 (\7\:net333 VSS) capacitor c=1.14392e-16
C82 (\3\:Y VSS) capacitor c=1.60814e-18
C83 (\2\:net333 VSS) capacitor c=7.75759e-18
C84 (\2\:net345 VSS) capacitor c=4.5042e-17
C85 (\3\:net369 VSS) capacitor c=3.94187e-17
C86 (\2\:net385 VSS) capacitor c=2.93278e-17
C87 (\2\:net397 VSS) capacitor c=6.40122e-17
C88 (\2\:A VSS) capacitor c=4.29779e-17
C89 (\9\:net333 VSS) capacitor c=1.00889e-16
C90 (\9\:net345 VSS) capacitor c=5.15051e-17
C91 (\8\:net353 VSS) capacitor c=8.98314e-17
C92 (\5\:net361 VSS) capacitor c=4.28286e-17
C93 (\8\:net369 VSS) capacitor c=7.02396e-17
C94 (\10\:net361 VSS) capacitor c=1.87764e-16
C95 (\11\:net369 VSS) capacitor c=1.05279e-16
C96 (\7\:net377 VSS) capacitor c=1.12977e-16
C97 (\8\:net377 VSS) capacitor c=1.61079e-16
C98 (\11\:net377 VSS) capacitor c=8.51345e-17
C99 (\7\:net385 VSS) capacitor c=6.16779e-17
C100 (\8\:net385 VSS) capacitor c=4.08141e-17
C101 (\4\:net393 VSS) capacitor c=3.91548e-17
C102 (\5\:A VSS) capacitor c=3.62602e-17
C103 (\7\:net397 VSS) capacitor c=5.69429e-17
C104 (\8\:net397 VSS) capacitor c=4.10932e-17
C105 (\16\:VDD VSS) capacitor c=1.30162e-17
C106 (\17\:VDD VSS) capacitor c=2.61568e-17
C107 (\19\:VDD VSS) capacitor c=2.42007e-17
C108 (\20\:VDD VSS) capacitor c=4.88428e-17
C109 (\21\:VDD VSS) capacitor c=2.33782e-17
C110 (\23\:VDD VSS) capacitor c=3.09241e-18
C111 (\24\:VDD VSS) capacitor c=8.25723e-18
C112 (\27\:VDD VSS) capacitor c=1.02359e-16
C113 (\28\:VDD VSS) capacitor c=5.64162e-17
C114 (\31\:VDD VSS) capacitor c=1.18618e-16
C115 (\36\:VDD VSS) capacitor c=1.49798e-16
Rk1 (\2\:Y Y) resistor r=0.2605 c=0
Rk2 (Y \4\:Y) resistor r=0.04165 c=0
Rk26 (\13\:VDD \15\:VDD) resistor r=0.3045 c=0
Rk27 (\15\:VDD \16\:VDD) resistor r=0.3934 c=0
Rk28 (\16\:VDD \17\:VDD) resistor r=0.135 c=0
Rk29 (\17\:VDD \18\:VDD) resistor r=0.3232 c=0
Rk30 (\18\:VDD \19\:VDD) resistor r=0.242 c=0
Rk31 (\19\:VDD \20\:VDD) resistor r=0.3396 c=0
Rk32 (\20\:VDD \21\:VDD) resistor r=0.2979 c=0
Rk33 (\21\:VDD \22\:VDD) resistor r=0.3207 c=0
Rk34 (\22\:VDD \23\:VDD) resistor r=0.1165 c=0
Rk36 (\24\:VDD VDD) resistor r=0.07978 c=0
Rk35 (\23\:VDD \24\:VDD) resistor r=0.347 c=0
Rk37 (\16\:VDD \26\:VDD) resistor r=0.07369 c=0
Rk38 (\17\:VDD \27\:VDD) resistor r=0.6651 c=0
Rk39 (\27\:VDD \28\:VDD) resistor r=0.35 c=0
Rk40 (\19\:VDD \30\:VDD) resistor r=0.04329 c=0
Rk41 (\20\:VDD \31\:VDD) resistor r=0.6893 c=0
Rk42 (\21\:VDD \33\:VDD) resistor r=0.1923 c=0
Rk43 (\23\:VDD \35\:VDD) resistor r=0.01898 c=0
Rk44 (\35\:VDD \36\:VDD) resistor r=0.9087 c=0
Rk45 (\24\:VDD \38\:VDD) resistor r=0.4047 c=0
Rk22 (A \5\:A) resistor r=0.06297 c=0
Rk46 (\15\:VSS \17\:VSS) resistor r=0.3217 c=0
Rk47 (\17\:VSS \18\:VSS) resistor r=0.0349 c=0
Rk48 (\18\:VSS \19\:VSS) resistor r=0.4032 c=0
Rk49 (\19\:VSS \20\:VSS) resistor r=0.2002 c=0
Rk50 (\20\:VSS \21\:VSS) resistor r=0.2129 c=0
Rk51 (\21\:VSS \22\:VSS) resistor r=0.05746 c=0
Rk52 (\22\:VSS \23\:VSS) resistor r=0.2478 c=0
Rk53 (\23\:VSS \24\:VSS) resistor r=0.1977 c=0
Rk54 (\24\:VSS \25\:VSS) resistor r=0.2754 c=0
Rk55 (\25\:VSS \26\:VSS) resistor r=0.1174 c=0
Rk56 (\26\:VSS \27\:VSS) resistor r=0.145 c=0
Rk57 (\27\:VSS \28\:VSS) resistor r=0.1603 c=0
Rk58 (\28\:VSS \29\:VSS) resistor r=0.05746 c=0
Rk60 (\30\:VSS VSS) resistor r=0.02212 c=0
Rk59 (\29\:VSS \30\:VSS) resistor r=0.4709 c=0
Rk61 (\18\:VSS \31\:VSS) resistor r=0.6246 c=0
Rk62 (\19\:VSS \33\:VSS) resistor r=0.07369 c=0
Rk63 (\20\:VSS \34\:VSS) resistor r=0.6059 c=0
Rk64 (\22\:VSS \35\:VSS) resistor r=0.5592 c=0
Rk65 (\23\:VSS \37\:VSS) resistor r=0.07369 c=0
Rk66 (\24\:VSS \38\:VSS) resistor r=0.7625 c=0
Rk67 (\25\:VSS \39\:VSS) resistor r=0.7207 c=0
Rk68 (\26\:VSS \41\:VSS) resistor r=0.0765 c=0
Rk69 (\27\:VSS \42\:VSS) resistor r=0.5916 c=0
Rk70 (\29\:VSS \44\:VSS) resistor r=0.3632 c=0
Rk71 (\30\:VSS \46\:VSS) resistor r=0.2929 c=0
Rk3 (\6\:net333 \8\:net333) resistor r=0.4891 c=0
Rk4 (\8\:net333 \9\:net333) resistor r=0.7554 c=0
Rk5 (\6\:net345 \8\:net345) resistor r=0.5219 c=0
Rk6 (\8\:net345 \9\:net345) resistor r=0.4005 c=0
Rk7 (\5\:net353 \7\:net353) resistor r=0.6367 c=0
Rk8 (\7\:net353 \8\:net353) resistor r=0.7078 c=0
Rk9 (\5\:net361 \7\:net361) resistor r=0.201 c=0
Rk11 (\9\:net361 \10\:net361) resistor r=1.2577 c=0
Rk10 (\7\:net369 \8\:net369) resistor r=0.2279 c=0
Rk12 (\10\:net369 \11\:net369) resistor r=0.6342 c=0
Rk13 (\6\:net377 \7\:net377) resistor r=0.1774 c=0
Rk14 (\7\:net377 \8\:net377) resistor r=0.6423 c=0
Rk15 (\7\:net377 \10\:net377) resistor r=0.4634 c=0
Rk16 (\8\:net377 \11\:net377) resistor r=0.5841 c=0
Rk17 (\6\:net385 \7\:net385) resistor r=0.3448 c=0
Rk18 (\7\:net385 \8\:net385) resistor r=0.2667 c=0
Rk19 (\7\:net385 \10\:net385) resistor r=0.08441 c=0
Rk20 (\4\:net393 \6\:net393) resistor r=0.3134 c=0
Rk21 (\6\:net393 \8\:net393) resistor r=0.6552 c=0
Rk23 (\6\:net397 \7\:net397) resistor r=0.5416 c=0
Rk24 (\7\:net397 \8\:net397) resistor r=0.1621 c=0
Rk25 (\7\:net397 \10\:net397) resistor r=0.1266 c=0
Rl26 (\6\:VDD \7\:VDD) resistor r=301.489 c=0
Rl33 (\9\:VDD \10\:VDD) resistor r=246.131 c=0
Rl34 (\10\:VDD \11\:VDD) resistor r=31.9741 c=0
Rl27 (\7\:VDD \8\:VDD) resistor r=24.2328 c=0
Rl12 (\3\:VDD \4\:VDD) resistor r=55.2823 c=0
Rl13 (\4\:VDD \5\:VDD) resistor r=132.205 c=0
Rl9 (\1\:VDD \2\:VDD) resistor r=26.1559 c=0
Rl40 (\1\:A \2\:A) resistor r=166.187 c=0
Rl42 (\2\:A \4\:A) resistor r=110.418 c=0
Rl41 (\2\:A \3\:A) resistor r=1.2301 c=0
Rl35 (\11\:VSS \12\:VSS) resistor r=106.925 c=0
Rl36 (\12\:VSS \13\:VSS) resistor r=217.847 c=0
Rl25 (\9\:VSS \10\:VSS) resistor r=78.3592 c=0
Rl24 (\7\:VSS \8\:VSS) resistor r=110.771 c=0
Rl17 (\5\:VSS \6\:VSS) resistor r=124.513 c=0
Rl11 (\3\:VSS \4\:VSS) resistor r=24.2328 c=0
Rl10 (\1\:VSS \2\:VSS) resistor r=80.7464 c=0
Rl1 (net333 \2\:net333) resistor r=49.7141 c=0
Rl3 (\2\:net333 \4\:net333) resistor r=34.3295 c=0
Rl2 (\2\:net333 \3\:net333) resistor r=5.9102 c=0
Rl5 (\2\:net345 \3\:net345) resistor r=58.4173 c=0
Rl4 (net345 \2\:net345) resistor r=90.0759 c=0
Rl6 (\2\:net345 \4\:net345) resistor r=11.0837 c=0
Rl7 (net353 \2\:net353) resistor r=140.385 c=0
Rl8 (net353 \3\:net353) resistor r=24.2328 c=0
Rl14 (net361 \2\:net361) resistor r=209.615 c=0
Rl15 (\2\:net361 \3\:net361) resistor r=172.59 c=0
Rl16 (\3\:net361 \4\:net361) resistor r=182.153 c=0
Rl20 (net369 \2\:net369) resistor r=50.6918 c=0
Rl23 (\3\:net369 \5\:net369) resistor r=86.22 c=0
Rl21 (\2\:net369 \3\:net369) resistor r=142.627 c=0
Rl22 (\3\:net369 \4\:net369) resistor r=44.1561 c=0
Rl19 (\3\:net377 \4\:net377) resistor r=91.5405 c=0
Rl18 (net377 \2\:net377) resistor r=57.6695 c=0
Rl30 (\2\:net385 \4\:net385) resistor r=34.3295 c=0
Rl29 (\2\:net385 \3\:net385) resistor r=109.329 c=0
Rl28 (net385 \2\:net385) resistor r=0.5213 c=0
Rl31 (net393 \2\:net393) resistor r=151.923 c=0
Rl32 (\2\:net393 \3\:net393) resistor r=26.1559 c=0
Rl39 (\2\:net397 \4\:net397) resistor r=239.264 c=0
Rl38 (\2\:net397 \3\:net397) resistor r=37.3411 c=0
Rl37 (net397 \2\:net397) resistor r=1.2334 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz11 (\14\:VDD \15\:VDD) resistor r=15 c=0
Rz12 (\14\:VDD \18\:VDD) resistor r=6.25 c=0
Rz13 (\14\:VDD \22\:VDD) resistor r=6.25 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz16 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz17 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz18 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz19 (\45\:VSS \46\:VSS) resistor r=75 c=0
Rz2 (\7\:net333 \8\:net333) resistor r=75 c=0
Rz3 (\5\:net345 \6\:net345) resistor r=75 c=0
Rz4 (\4\:net353 \5\:net353) resistor r=75 c=0
Rz5 (\6\:net361 \7\:net361) resistor r=75 c=0
Rz6 (\9\:net369 \10\:net369) resistor r=75 c=0
Rz7 (\9\:net377 \10\:net377) resistor r=75 c=0
Rz8 (\5\:net385 \6\:net385) resistor r=75 c=0
Rz9 (\5\:net393 \6\:net393) resistor r=75 c=0
Rz10 (\9\:net397 \10\:net397) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry13 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry14 (\32\:VDD \33\:VDD) resistor r=62 c=0
Ry15 (\34\:VDD \35\:VDD) resistor r=62 c=0
Ry16 (\37\:VDD \38\:VDD) resistor r=20.6667 c=0
Ry17 (\16\:VSS \17\:VSS) resistor r=12.4 c=0
Ry18 (\16\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry19 (\16\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net333 \6\:net333) resistor r=62 c=0
Ry3 (\7\:net345 \8\:net345) resistor r=62 c=0
Ry4 (\6\:net353 \7\:net353) resistor r=62 c=0
Ry6 (\8\:net361 \9\:net361) resistor r=62 c=0
Ry5 (\6\:net369 \7\:net369) resistor r=62 c=0
Ry7 (\5\:net377 \6\:net377) resistor r=62 c=0
Ry8 (\9\:net385 \10\:net385) resistor r=62 c=0
Ry9 (\7\:net393 \8\:net393) resistor r=62 c=0
Ry10 (\5\:net397 \6\:net397) resistor r=62 c=0
Rx14 (\8\:VDD \27\:VDD) resistor r=45 c=0
Rx15 (\10\:VDD \28\:VDD) resistor r=45 c=0
Rx16 (\4\:VDD \31\:VDD) resistor r=45 c=0
Rx17 (\2\:VDD \36\:VDD) resistor r=45 c=0
Rx12 (\3\:A \5\:A) resistor r=45 c=0
Rx18 (\12\:VSS \31\:VSS) resistor r=45 c=0
Rx19 (\10\:VSS \34\:VSS) resistor r=45 c=0
Rx20 (\8\:VSS \35\:VSS) resistor r=45 c=0
Rx21 (\6\:VSS \38\:VSS) resistor r=45 c=0
Rx22 (\4\:VSS \39\:VSS) resistor r=45 c=0
Rx23 (\1\:VSS \42\:VSS) resistor r=45 c=0
Rx1 (\3\:net333 \9\:net333) resistor r=45 c=0
Rx2 (\4\:net345 \9\:net345) resistor r=45 c=0
Rx3 (\3\:net353 \8\:net353) resistor r=45 c=0
Rx4 (\3\:net361 \5\:net361) resistor r=45 c=0
Rx6 (\4\:net361 \10\:net361) resistor r=45 c=0
Rx5 (\4\:net369 \8\:net369) resistor r=45 c=0
Rx7 (\2\:net369 \11\:net369) resistor r=45 c=0
Rx8 (net377 \8\:net377) resistor r=45 c=0
Rx9 (\4\:net377 \11\:net377) resistor r=45 c=0
Rx10 (net385 \8\:net385) resistor r=45 c=0
Rx11 (\3\:net393 \4\:net393) resistor r=45 c=0
Rx13 (net397 \8\:net397) resistor r=45 c=0
mn16 (\3\:Y \4\:net333 \45\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=3.64e-14 ps=1.03e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn15 (\7\:net333 net345 \43\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn13 (net341 \2\:net353 \43\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=1.958e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.3e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn14 (\5\:net345 \1\:VDD net341 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.958e-14 ad=5.075e-14 ps=5.6e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=3.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn11 (net349 \2\:net361 \40\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.215e-14 ad=1.668e-14 ps=1.4e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn12 (\4\:net353 \5\:VDD net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn10 (\6\:net361 \3\:VDD net357 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.438e-14 ad=2.03e-14 ps=1.04e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn9 (net357 \5\:net369 \36\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=5.438e-14 ps=1.7e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.55e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn7 (net365 \3\:net377 \36\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=3.988e-14 ps=1.7e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=4.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn8 (\9\:net369 \6\:VDD net365 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn6 (\9\:net377 \7\:VDD net373 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.075e-14 ps=6.1e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=7.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn5 (net373 \3\:net385 \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.18e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=5.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (net381 \2\:net393 \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.18e-14 ad=1.958e-14 ps=1.54e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=3.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\5\:net385 \11\:VDD net381 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.958e-14 ad=2.175e-14 ps=5.6e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=1.5e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\5\:net393 \9\:VDD net389 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.103e-14 ad=2.03e-14 ps=5.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.35e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn1 (net389 \3\:net397 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=3.45e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn0 (\9\:net397 \4\:A \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mp15 (\5\:net333 \3\:net345 \34\:VDD VDD) g45p1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=1.008e-13 ad=5.268e-14 ps=1.73e-06 pd=9.2e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.45e-07 sb=5.85e-07 sd=160n \
        sca=17.5376 scb=0.0173132 scc=0.00131683 m=(1)
mp13 (net276 net353 \34\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.008e-13 ad=2.473e-14 ps=1.73e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=3e-07 sd=160n sca=17.4145 scb=0.0172865 \
        scc=0.00131682 m=(1)
mp14 (\7\:net345 \2\:VSS net276 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp11 (net284 net361 \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.555e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp12 (\6\:net353 \3\:VSS net284 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp8 (\6\:net369 \5\:VSS net300 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp7 (net300 \2\:net377 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.127e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.75e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp9 (net292 net369 \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.127e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp10 (\8\:net361 \7\:VSS net292 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp6 (\5\:net377 \9\:VSS net308 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.01e-14 ps=7.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.65e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp5 (net308 \4\:net385 \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.115e-14 ad=3.87e-14 ps=1.69e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp3 (net316 net393 \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.115e-14 ad=1.29e-14 ps=1.69e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=2.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp4 (\9\:net385 \13\:VSS net316 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp2 (\7\:net393 \11\:VSS net324 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.9849 \
        scb=0.00884842 scc=8.12635e-05 m=(1)
mp1 (net324 \4\:net397 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=13.2748 \
        scb=0.010838 scc=0.000102032 m=(1)
mp0 (\5\:net397 \1\:A \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=20.984 scb=0.0231223 \
        scc=0.000938814 m=(1)
ends DLY4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:17 2013 )
// Library name: gsclib045_hvt
// Cell name: DLY4X4
// View name: extracted

simulator lang=spectre

subckt DLY4X4 A VDD VSS Y
mp15 (\18\:net333 \3\:net345 \28\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=9.18e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37481e-06 sd=160n \
        sca=40.9076 scb=0.0353918 scc=0.00415366 m=(1)
mp16_1__rcx (Y net333 \28\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.078e-14 ad=6.728e-14 ps=1.3375e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.10981e-06 sd=160n sca=32.7095 \
        scb=0.022203 scc=0.00336849 m=(4)
C1 (Y VSS) capacitor c=1.81016e-16
C2 (VDD VSS) capacitor c=3.04755e-16
C3 (A VSS) capacitor c=5.34184e-17
C4 (net345 VSS) capacitor c=3.72745e-17
C5 (net333 VSS) capacitor c=2.7651e-16
C6 (net341 VSS) capacitor c=1.63061e-18
C7 (net353 VSS) capacitor c=3.39164e-17
C8 (net349 VSS) capacitor c=7.21012e-19
C9 (net361 VSS) capacitor c=1.04931e-16
C10 (net357 VSS) capacitor c=1.7865e-18
C11 (net369 VSS) capacitor c=6.15605e-17
C12 (net365 VSS) capacitor c=1.51928e-18
C13 (net377 VSS) capacitor c=5.49135e-17
C14 (net385 VSS) capacitor c=3.03357e-17
C15 (net393 VSS) capacitor c=7.64964e-17
C16 (net389 VSS) capacitor c=1.51142e-18
C17 (net397 VSS) capacitor c=2.9114e-17
C18 (net276 VSS) capacitor c=1.81242e-18
C19 (net284 VSS) capacitor c=1.38779e-18
C20 (net300 VSS) capacitor c=2.11386e-18
C21 (net292 VSS) capacitor c=2.32516e-18
C22 (net308 VSS) capacitor c=2.74416e-18
C23 (\1\:A VSS) capacitor c=2.52785e-17
C24 (\3\:net397 VSS) capacitor c=7.07962e-17
C25 (\2\:net377 VSS) capacitor c=6.57527e-17
C26 (\2\:net353 VSS) capacitor c=5.42966e-17
C27 (\3\:net345 VSS) capacitor c=4.37248e-17
C28 (\3\:A VSS) capacitor c=4.04423e-17
C29 (\12\:VDD VSS) capacitor c=5.30134e-17
C30 (\15\:VDD VSS) capacitor c=3.27191e-17
C31 (\2\:net393 VSS) capacitor c=5.04401e-17
C32 (\3\:net385 VSS) capacitor c=5.59653e-17
C33 (\10\:VDD VSS) capacitor c=4.97458e-17
C34 (\9\:VDD VSS) capacitor c=4.8575e-17
C35 (\3\:net377 VSS) capacitor c=3.56305e-17
C36 (\5\:net369 VSS) capacitor c=3.04624e-17
C37 (\3\:VDD VSS) capacitor c=3.21384e-17
C38 (\8\:VDD VSS) capacitor c=5.56835e-17
C39 (\2\:net361 VSS) capacitor c=1.25085e-16
C40 (\1\:VDD VSS) capacitor c=5.4745e-17
C41 (\3\:net353 VSS) capacitor c=5.96793e-17
C42 (\2\:A VSS) capacitor c=3.99632e-17
C43 (\2\:net397 VSS) capacitor c=4.61732e-17
C44 (\14\:VDD VSS) capacitor c=6.52169e-17
C45 (\3\:net393 VSS) capacitor c=3.55979e-17
C46 (\2\:net385 VSS) capacitor c=4.29577e-17
C47 (\11\:VDD VSS) capacitor c=3.21943e-17
C48 (\2\:net369 VSS) capacitor c=6.86754e-17
C49 (\4\:net377 VSS) capacitor c=3.28363e-17
C50 (\4\:net369 VSS) capacitor c=2.85708e-17
C51 (\4\:net361 VSS) capacitor c=3.60267e-17
C52 (\7\:VDD VSS) capacitor c=1.71357e-17
C53 (\3\:net361 VSS) capacitor c=4.25941e-17
C54 (\6\:VDD VSS) capacitor c=4.66952e-17
C55 (\2\:VDD VSS) capacitor c=3.86708e-17
C56 (\2\:net345 VSS) capacitor c=4.60749e-17
C57 (\4\:net397 VSS) capacitor c=3.96184e-17
C58 (\18\:VDD VSS) capacitor c=2.90824e-17
C59 (\7\:net393 VSS) capacitor c=7.12303e-17
C60 (\8\:net385 VSS) capacitor c=1.90252e-17
C61 (\32\:VDD VSS) capacitor c=2.47037e-17
C62 (\5\:net377 VSS) capacitor c=2.73352e-17
C63 (\8\:net361 VSS) capacitor c=1.84447e-16
C64 (\36\:VDD VSS) capacitor c=1.96523e-17
C65 (\6\:net369 VSS) capacitor c=4.63575e-17
C66 (\6\:net353 VSS) capacitor c=1.47005e-16
C67 (\39\:VDD VSS) capacitor c=2.22696e-17
C68 (\6\:net345 VSS) capacitor c=1.76782e-16
C69 (\18\:net333 VSS) capacitor c=5.05922e-17
C70 (\20\:VDD VSS) capacitor c=4.55396e-17
C71 (\8\:net397 VSS) capacitor c=1.96095e-17
C72 (\5\:net393 VSS) capacitor c=1.06309e-16
C73 (\4\:net385 VSS) capacitor c=5.44833e-17
C74 (\9\:net377 VSS) capacitor c=9.68706e-17
C75 (\9\:net369 VSS) capacitor c=1.02783e-16
C76 (\5\:net361 VSS) capacitor c=5.38217e-17
C77 (\4\:net353 VSS) capacitor c=1.20713e-16
C78 (\4\:net345 VSS) capacitor c=7.00664e-17
C79 (\16\:net333 VSS) capacitor c=5.27077e-17
C80 (\4\:VDD VSS) capacitor c=3.0151e-17
C81 (\5\:VDD VSS) capacitor c=2.29242e-17
C82 (\3\:net369 VSS) capacitor c=4.27329e-17
C83 (\15\:net333 VSS) capacitor c=6.53176e-17
C84 (\8\:net345 VSS) capacitor c=1.55252e-16
C85 (\16\:VDD VSS) capacitor c=4.313e-17
C86 (\17\:VDD VSS) capacitor c=6.34297e-17
C87 (\8\:net353 VSS) capacitor c=5.93104e-17
C88 (\7\:net361 VSS) capacitor c=5.7521e-17
C89 (\8\:net369 VSS) capacitor c=7.17707e-17
C90 (\10\:net361 VSS) capacitor c=1.97815e-16
C91 (\11\:net369 VSS) capacitor c=1.10956e-16
C92 (\7\:net377 VSS) capacitor c=9.78579e-17
C93 (\8\:net377 VSS) capacitor c=1.80301e-16
C94 (\11\:net377 VSS) capacitor c=1.178e-16
C95 (\6\:net385 VSS) capacitor c=6.63185e-17
C96 (\7\:net385 VSS) capacitor c=6.09835e-17
C97 (\4\:net393 VSS) capacitor c=5.58303e-17
C98 (\4\:A VSS) capacitor c=4.5774e-17
C99 (\6\:net397 VSS) capacitor c=3.79822e-17
C100 (\7\:net397 VSS) capacitor c=4.22273e-17
C101 (\22\:VDD VSS) capacitor c=1.20061e-17
C102 (\23\:VDD VSS) capacitor c=2.01876e-17
C103 (\25\:VDD VSS) capacitor c=1.38554e-17
C104 (\26\:VDD VSS) capacitor c=2.08279e-17
C105 (\27\:VDD VSS) capacitor c=2.63506e-17
C106 (\28\:VDD VSS) capacitor c=1.24668e-16
C107 (\34\:VDD VSS) capacitor c=1.16019e-16
C108 (\35\:VDD VSS) capacitor c=6.6541e-17
C109 (\38\:VDD VSS) capacitor c=5.06307e-17
Rk11 (\16\:VDD \17\:VDD) resistor r=0.2376 c=0
Rk31 (\19\:VDD \21\:VDD) resistor r=0.2572 c=0
Rk32 (\21\:VDD \22\:VDD) resistor r=0.3682 c=0
Rk33 (\22\:VDD \23\:VDD) resistor r=0.1124 c=0
Rk34 (\23\:VDD \24\:VDD) resistor r=0.471 c=0
Rk35 (\24\:VDD \25\:VDD) resistor r=0.04491 c=0
Rk36 (\25\:VDD \26\:VDD) resistor r=0.3956 c=0
Rk37 (\26\:VDD \27\:VDD) resistor r=0.4081 c=0
Rk42 (\28\:VDD VDD) resistor r=0.1198 c=0
Rk38 (\27\:VDD \28\:VDD) resistor r=0.2853 c=0
Rk43 (\22\:VDD \33\:VDD) resistor r=0.4415 c=0
Rk44 (\23\:VDD \34\:VDD) resistor r=0.7453 c=0
Rk45 (\34\:VDD \35\:VDD) resistor r=0.3716 c=0
Rk46 (\25\:VDD \37\:VDD) resistor r=0.1021 c=0
Rk47 (\26\:VDD \38\:VDD) resistor r=0.3891 c=0
Rk48 (\27\:VDD \40\:VDD) resistor r=0.1652 c=0
Rk27 (\4\:A A) resistor r=0.1301 c=0
Rk52 (\15\:VSS \16\:VSS) resistor r=0.4094 c=0
Rk53 (\16\:VSS \18\:VSS) resistor r=0.04491 c=0
Rk54 (\18\:VSS \19\:VSS) resistor r=0.3532 c=0
Rk55 (\19\:VSS \20\:VSS) resistor r=0.2126 c=0
Rk56 (\20\:VSS \21\:VSS) resistor r=0.2602 c=0
Rk57 (\21\:VSS \22\:VSS) resistor r=0.1251 c=0
Rk58 (\22\:VSS \23\:VSS) resistor r=0.06998 c=0
Rk59 (\23\:VSS \24\:VSS) resistor r=0.2803 c=0
Rk60 (\24\:VSS \25\:VSS) resistor r=0.2803 c=0
Rk61 (\25\:VSS \26\:VSS) resistor r=0.07981 c=0
Rk62 (\26\:VSS \27\:VSS) resistor r=0.3179 c=0
Rk67 (\28\:VSS VSS) resistor r=0.1925 c=0
Rk63 (\27\:VSS \28\:VSS) resistor r=0.1199 c=0
Rk68 (\16\:VSS \32\:VSS) resistor r=0.5497 c=0
Rk69 (\19\:VSS \34\:VSS) resistor r=0.07346 c=0
Rk70 (\20\:VSS \35\:VSS) resistor r=0.5399 c=0
Rk71 (\21\:VSS \36\:VSS) resistor r=0.5358 c=0
Rk72 (\23\:VSS \38\:VSS) resistor r=0.2852 c=0
Rk73 (\24\:VSS \39\:VSS) resistor r=0.606 c=0
Rk74 (\25\:VSS \40\:VSS) resistor r=0.7999 c=0
Rk75 (\26\:VSS \42\:VSS) resistor r=0.2972 c=0
Rk76 (\27\:VSS \43\:VSS) resistor r=0.5033 c=0
Rk9 (\5\:net345 \7\:net345) resistor r=0.3646 c=0
Rk10 (\7\:net345 \8\:net345) resistor r=1.2909 c=0
Rk1 (\15\:net333 \17\:net333) resistor r=0.2722 c=0
Rk2 (\17\:net333 \19\:net333) resistor r=0.4353 c=0
Rk12 (\5\:net353 \7\:net353) resistor r=0.7607 c=0
Rk13 (\7\:net353 \8\:net353) resistor r=0.5269 c=0
Rk14 (\6\:net361 \7\:net361) resistor r=0.2137 c=0
Rk16 (\9\:net361 \10\:net361) resistor r=1.3148 c=0
Rk15 (\7\:net369 \8\:net369) resistor r=0.1917 c=0
Rk17 (\10\:net369 \11\:net369) resistor r=0.6325 c=0
Rk18 (\6\:net377 \7\:net377) resistor r=0.1104 c=0
Rk19 (\7\:net377 \8\:net377) resistor r=0.642 c=0
Rk20 (\7\:net377 \10\:net377) resistor r=0.4381 c=0
Rk21 (\8\:net377 \11\:net377) resistor r=0.5967 c=0
Rk22 (\5\:net385 \6\:net385) resistor r=0.3443 c=0
Rk23 (\6\:net385 \7\:net385) resistor r=0.3303 c=0
Rk24 (\6\:net385 \9\:net385) resistor r=0.06751 c=0
Rk25 (\4\:net393 \6\:net393) resistor r=0.4226 c=0
Rk26 (\6\:net393 \8\:net393) resistor r=0.4284 c=0
Rk28 (\5\:net397 \6\:net397) resistor r=0.3134 c=0
Rk29 (\6\:net397 \7\:net397) resistor r=0.2071 c=0
Rk30 (\6\:net397 \9\:net397) resistor r=0.1 c=0
Rl38 (\9\:VDD \10\:VDD) resistor r=295.719 c=0
Rl39 (\11\:VDD \10\:VDD) resistor r=29.5379 c=0
Rl19 (\2\:VDD \1\:VDD) resistor r=128.359 c=0
Rl21 (\4\:VDD \3\:VDD) resistor r=126.901 c=0
Rl24 (\4\:VDD \7\:VDD) resistor r=127.296 c=0
Rl25 (\5\:VDD \8\:VDD) resistor r=72.7584 c=0
Rl23 (\5\:VDD \6\:VDD) resistor r=53.7715 c=0
Rl22 (\5\:VDD \4\:VDD) resistor r=113.852 c=0
Rl44 (\13\:VDD \12\:VDD) resistor r=180.432 c=0
Rl46 (\13\:VDD \15\:VDD) resistor r=26.0821 c=0
Rl45 (\13\:VDD \14\:VDD) resistor r=14.7598 c=0
Rl51 (\1\:A \2\:A) resistor r=33.9954 c=0
Rl52 (\2\:A \3\:A) resistor r=97.6085 c=0
Rl47 (\12\:VSS \11\:VSS) resistor r=41.5405 c=0
Rl48 (\12\:VSS \13\:VSS) resistor r=221.693 c=0
Rl37 (\10\:VSS \9\:VSS) resistor r=62.9746 c=0
Rl36 (\8\:VSS \7\:VSS) resistor r=110.771 c=0
Rl29 (\6\:VSS \5\:VSS) resistor r=147.59 c=0
Rl20 (\4\:VSS \3\:VSS) resistor r=66.5405 c=0
Rl18 (\2\:VSS \1\:VSS) resistor r=59.8789 c=0
Rl2 (\2\:net345 \3\:net345) resistor r=65.3618 c=0
Rl1 (net345 \2\:net345) resistor r=51.4546 c=0
Rl17 (\2\:net353 \3\:net353) resistor r=155.769 c=0
Rl16 (net353 \2\:net353) resistor r=30.3481 c=0
Rl26 (net361 \2\:net361) resistor r=324.566 c=0
Rl27 (\2\:net361 \3\:net361) resistor r=168.744 c=0
Rl28 (\3\:net361 \4\:net361) resistor r=172.537 c=0
Rl31 (net369 \2\:net369) resistor r=50.6918 c=0
Rl34 (\3\:net369 \5\:net369) resistor r=98.7402 c=0
Rl32 (\2\:net369 \3\:net369) resistor r=155.239 c=0
Rl33 (\3\:net369 \4\:net369) resistor r=10.5426 c=0
Rl35 (\3\:net377 \4\:net377) resistor r=56.9251 c=0
Rl30 (net377 \2\:net377) resistor r=42.1309 c=0
Rl40 (net385 \2\:net385) resistor r=24.2328 c=0
Rl41 (\2\:net385 \3\:net385) resistor r=89.6174 c=0
Rl42 (net393 \2\:net393) resistor r=142.308 c=0
Rl43 (\2\:net393 \3\:net393) resistor r=26.1559 c=0
Rl50 (\2\:net397 \3\:net397) resistor r=99.1367 c=0
Rl49 (net397 \2\:net397) resistor r=29.5379 c=0
Rz12 (\21\:VDD \20\:VDD) resistor r=10.7143 c=0
Rz13 (\24\:VDD \20\:VDD) resistor r=6.25 c=0
Rz14 (\28\:VDD \20\:VDD) resistor r=6.25 c=0
Rz15 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz17 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz18 (\42\:VSS \41\:VSS) resistor r=75 c=0
Rz4 (\4\:net345 \5\:net345) resistor r=75 c=0
Rz1 (\17\:net333 \16\:net333) resistor r=75 c=0
Rz5 (\4\:net353 \5\:net353) resistor r=75 c=0
Rz6 (\5\:net361 \6\:net361) resistor r=75 c=0
Rz7 (\9\:net369 \10\:net369) resistor r=75 c=0
Rz8 (\9\:net377 \10\:net377) resistor r=75 c=0
Rz9 (\4\:net385 \5\:net385) resistor r=75 c=0
Rz10 (\5\:net393 \6\:net393) resistor r=75 c=0
Rz11 (\8\:net397 \9\:net397) resistor r=75 c=0
Ry12 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry13 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry14 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry15 (\40\:VDD \39\:VDD) resistor r=62 c=0
Ry19 (\18\:VSS \17\:VSS) resistor r=8.8571 c=0
Ry20 (\22\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry21 (\28\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry4 (\6\:net345 \7\:net345) resistor r=62 c=0
Ry1 (\19\:net333 \18\:net333) resistor r=20.6667 c=0
Ry5 (\6\:net353 \7\:net353) resistor r=62 c=0
Ry7 (\8\:net361 \9\:net361) resistor r=62 c=0
Ry6 (\6\:net369 \7\:net369) resistor r=62 c=0
Ry8 (\5\:net377 \6\:net377) resistor r=62 c=0
Ry9 (\8\:net385 \9\:net385) resistor r=62 c=0
Ry10 (\7\:net393 \8\:net393) resistor r=62 c=0
Ry11 (\4\:net397 \5\:net397) resistor r=62 c=0
Rx3 (\16\:VDD \6\:VDD) resistor r=45 c=0
Rx4 (\17\:VDD \2\:VDD) resistor r=45 c=0
Rx16 (\34\:VDD \11\:VDD) resistor r=45 c=0
Rx17 (\35\:VDD \14\:VDD) resistor r=45 c=0
Rx18 (\38\:VDD \7\:VDD) resistor r=45 c=0
Rx14 (\2\:A \4\:A) resistor r=45 c=0
Rx19 (\32\:VSS \12\:VSS) resistor r=45 c=0
Rx20 (\35\:VSS \10\:VSS) resistor r=45 c=0
Rx21 (\36\:VSS \8\:VSS) resistor r=45 c=0
Rx22 (\39\:VSS \6\:VSS) resistor r=45 c=0
Rx23 (\40\:VSS \4\:VSS) resistor r=45 c=0
Rx24 (\43\:VSS \2\:VSS) resistor r=45 c=0
Rx2 (\2\:net345 \8\:net345) resistor r=45 c=0
Rx1 (\15\:net333 net333) resistor r=45 c=0
Rx5 (net353 \8\:net353) resistor r=45 c=0
Rx6 (\3\:net361 \7\:net361) resistor r=45 c=0
Rx8 (\4\:net361 \10\:net361) resistor r=45 c=0
Rx7 (\4\:net369 \8\:net369) resistor r=45 c=0
Rx9 (\2\:net369 \11\:net369) resistor r=45 c=0
Rx10 (net377 \8\:net377) resistor r=45 c=0
Rx11 (\4\:net377 \11\:net377) resistor r=45 c=0
Rx12 (\2\:net385 \7\:net385) resistor r=45 c=0
Rx13 (\3\:net393 \4\:net393) resistor r=45 c=0
Rx15 (\2\:net397 \7\:net397) resistor r=45 c=0
mn15 (\16\:net333 net345 \28\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18212e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn16_1__rcx (Y net333 \28\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.223e-14 ad=4.16e-14 ps=8.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.77115e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(4)
mn13 (net341 \3\:net353 \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.413e-14 ad=1.668e-14 ps=9.7e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=3e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn14 (\4\:net345 \1\:VDD net341 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn11 (net349 \2\:net361 \41\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.85e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (\4\:net353 \8\:VDD net349 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.61e-14 ps=4.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.8e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\5\:net361 \3\:VDD net357 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn9 (net357 \5\:net369 \37\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.365e-14 ad=5.003e-14 ps=1.18e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=8.15e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn7 (net365 \3\:net377 \37\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.365e-14 ad=2.538e-14 ps=1.18e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=3.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn8 (\9\:net369 \9\:VDD net365 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn6 (\9\:net377 \10\:VDD net373 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=4.785e-14 ps=5.2e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=7.65e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (net373 \3\:net385 \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.175e-14 ad=1.668e-14 ps=1.39e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=6.05e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (net381 \2\:net393 \33\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.175e-14 ad=2.103e-14 ps=1.39e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.3e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (\4\:net385 \15\:VDD net381 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.103e-14 ad=2.03e-14 ps=5.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\5\:net393 \12\:VDD net389 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (net389 net397 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\8\:net397 \3\:A \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp13 (net276 \2\:net353 \28\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.772e-14 ad=3.225e-14 ps=1.39e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=3.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp14 (\6\:net345 \1\:VSS net276 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.225e-14 ad=3.01e-14 ps=7.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp11 (net284 net361 \39\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.555e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp12 (\6\:net353 \3\:VSS net284 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp8 (\6\:net369 \5\:VSS net300 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (net300 \2\:net377 \36\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0208e-13 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.75e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp9 (net292 net369 \36\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0208e-13 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp10 (\8\:net361 \7\:VSS net292 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\5\:net377 \9\:VSS net308 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.225e-14 ps=7.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=7.2e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp5 (net308 net385 \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.332e-14 ps=8.9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=5.2e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp3 (net316 net393 \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=1.29e-14 ps=8.9e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp4 (\8\:net385 \13\:VSS net316 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp2 (\7\:net393 \11\:VSS net324 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=31.4533 \
        scb=0.0258077 scc=0.00372922 m=(1)
mp1 (net324 \3\:net397 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=32.5509 \
        scb=0.0273823 scc=0.00374133 m=(1)
mp0 (\4\:net397 \1\:A \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=43.5704 \
        scb=0.0437218 scc=0.0051335 m=(1)
ends DLY4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:18 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFHQX1
// View name: extracted

simulator lang=spectre

subckt DFFHQX1 CK D Q VDD VSS
mp55 (\1\:Q \4\:qbint \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.30833e-07 sd=160n sca=29.0978 \
        scb=0.0329394 scc=0.00242907 m=(1)
C1 (D VSS) capacitor c=3.7961e-17
C2 (VDD VSS) capacitor c=1.64072e-16
C3 (CK VSS) capacitor c=4.4925e-17
C4 (qbint VSS) capacitor c=1.86259e-17
C5 (CKb VSS) capacitor c=2.98286e-17
C6 (n30 VSS) capacitor c=3.77891e-17
C7 (net172 VSS) capacitor c=3.17549e-18
C8 (mout VSS) capacitor c=9.78313e-17
C9 (CKbb VSS) capacitor c=5.08845e-17
C10 (n20 VSS) capacitor c=4.51875e-17
C11 (net192 VSS) capacitor c=2.98175e-18
C12 (n21 VSS) capacitor c=2.12137e-18
C13 (net123 VSS) capacitor c=5.0544e-18
C14 (net147 VSS) capacitor c=1.69422e-18
C15 (n22 VSS) capacitor c=5.79395e-18
C16 (\10\:CKb VSS) capacitor c=4.48165e-17
C17 (\1\:D VSS) capacitor c=4.69792e-17
C18 (\5\:CKbb VSS) capacitor c=6.74269e-17
C19 (\4\:CKb VSS) capacitor c=7.03671e-17
C20 (\5\:qbint VSS) capacitor c=6.0215e-17
C21 (\3\:n30 VSS) capacitor c=4.83577e-17
C22 (\3\:CK VSS) capacitor c=4.28144e-17
C23 (\4\:qbint VSS) capacitor c=5.71555e-17
C24 (\8\:CKb VSS) capacitor c=2.99928e-17
C25 (\3\:D VSS) capacitor c=6.9591e-17
C26 (\6\:CKb VSS) capacitor c=5.44589e-17
C27 (\7\:CKbb VSS) capacitor c=2.89605e-17
C28 (\3\:mout VSS) capacitor c=3.72983e-17
C29 (\3\:n20 VSS) capacitor c=5.06705e-17
C30 (\3\:CKbb VSS) capacitor c=2.7304e-17
C31 (\3\:CKb VSS) capacitor c=7.25483e-17
C32 (\8\:qbint VSS) capacitor c=5.45103e-17
C33 (\1\:CK VSS) capacitor c=4.66786e-17
C34 (\3\:qbint VSS) capacitor c=2.9607e-17
C35 (\9\:CKb VSS) capacitor c=3.93797e-17
C36 (\2\:D VSS) capacitor c=5.52908e-17
C37 (\7\:CKb VSS) capacitor c=3.92214e-17
C38 (\5\:CKb VSS) capacitor c=3.35071e-17
C39 (\6\:CKbb VSS) capacitor c=6.26256e-17
C40 (\2\:mout VSS) capacitor c=5.1133e-17
C41 (\2\:n20 VSS) capacitor c=4.07649e-17
C42 (\4\:CKbb VSS) capacitor c=4.051e-17
C43 (\2\:CKb VSS) capacitor c=6.68163e-17
C44 (\2\:CKbb VSS) capacitor c=4.54923e-17
C45 (\7\:qbint VSS) capacitor c=2.3006e-17
C46 (\2\:n30 VSS) capacitor c=4.61573e-17
C47 (\2\:CK VSS) capacitor c=3.89516e-17
C48 (\8\:CKbb VSS) capacitor c=4.37419e-17
C49 (\8\:VDD VSS) capacitor c=4.44749e-17
C50 (\8\:n20 VSS) capacitor c=3.55338e-17
C51 (\10\:VDD VSS) capacitor c=3.76214e-17
C52 (\4\:mout VSS) capacitor c=8.14413e-17
C53 (\8\:n30 VSS) capacitor c=5.03701e-17
C54 (\12\:VDD VSS) capacitor c=4.99527e-17
C55 (\14\:qbint VSS) capacitor c=9.48835e-17
C56 (\20\:CKb VSS) capacitor c=3.25051e-17
C57 (\14\:VDD VSS) capacitor c=4.19291e-17
C58 (\1\:Q VSS) capacitor c=5.65157e-17
C59 (\1\:VDD VSS) capacitor c=2.88068e-17
C60 (\10\:CKbb VSS) capacitor c=1.23095e-16
C61 (\4\:n20 VSS) capacitor c=7.83189e-17
C62 (\7\:mout VSS) capacitor c=4.6961e-17
C63 (\4\:n30 VSS) capacitor c=9.05638e-17
C64 (\11\:qbint VSS) capacitor c=7.46794e-17
C65 (\18\:CKb VSS) capacitor c=1.14745e-16
C66 (\3\:Q VSS) capacitor c=5.95164e-17
C67 (\2\:qbint VSS) capacitor c=1.68306e-17
C68 (\6\:qbint VSS) capacitor c=3.3125e-17
C69 (\4\:CK VSS) capacitor c=9.51527e-17
C70 (\9\:qbint VSS) capacitor c=7.45565e-17
C71 (\10\:qbint VSS) capacitor c=1.05587e-16
C72 (\13\:qbint VSS) capacitor c=1.15784e-16
C73 (\6\:n30 VSS) capacitor c=1.18506e-16
C74 (\7\:n30 VSS) capacitor c=8.64177e-17
C75 (\6\:mout VSS) capacitor c=7.35263e-17
C76 (\9\:mout VSS) capacitor c=5.94393e-17
C77 (\6\:n20 VSS) capacitor c=8.34618e-17
C78 (\7\:n20 VSS) capacitor c=5.60397e-17
C79 (\5\:D VSS) capacitor c=4.85543e-17
C80 (\11\:CKb VSS) capacitor c=7.12166e-17
C81 (\12\:CKb VSS) capacitor c=1.24047e-16
C82 (\13\:CKb VSS) capacitor c=9.77399e-17
C83 (\14\:CKb VSS) capacitor c=1.12186e-16
C84 (\15\:CKb VSS) capacitor c=6.85765e-17
C85 (\16\:CKb VSS) capacitor c=2.54133e-17
C86 (\17\:CKb VSS) capacitor c=1.48938e-16
C87 (\12\:CKbb VSS) capacitor c=1.97607e-16
C88 (\13\:CKbb VSS) capacitor c=1.2999e-16
C89 (\14\:CKbb VSS) capacitor c=4.32336e-17
C90 (\15\:CKbb VSS) capacitor c=6.74472e-17
C91 (\3\:VDD VSS) capacitor c=1.2693e-17
C92 (\4\:VDD VSS) capacitor c=2.9539e-17
C93 (\6\:VDD VSS) capacitor c=1.19104e-17
C94 (\7\:VDD VSS) capacitor c=1.85588e-17
Rk17 (\4\:D \5\:D) resistor r=0.01233 c=0
Rk18 (\6\:D D) resistor r=0.0125 c=0
Rk19 (\5\:D \6\:D) resistor r=0.02493 c=0
Rk33 (\2\:VSS \4\:VSS) resistor r=0.1443 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.4504 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.3538 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.1103 c=0
Rk38 (\8\:VSS VSS) resistor r=0.1025 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.3385 c=0
Rk39 (\5\:VSS \10\:VSS) resistor r=0.1319 c=0
Rk40 (\7\:VSS \12\:VSS) resistor r=0.2162 c=0
Rk41 (\8\:VSS \14\:VSS) resistor r=0.2903 c=0
Rk42 (\2\:VDD \3\:VDD) resistor r=0.05754 c=0
Rk43 (\3\:VDD \4\:VDD) resistor r=0.3914 c=0
Rk44 (\4\:VDD \5\:VDD) resistor r=0.3515 c=0
Rk45 (\5\:VDD \6\:VDD) resistor r=0.1219 c=0
Rk47 (\7\:VDD VDD) resistor r=0.1025 c=0
Rk46 (\6\:VDD \7\:VDD) resistor r=0.325 c=0
Rk48 (\3\:VDD \9\:VDD) resistor r=0.357 c=0
Rk49 (\4\:VDD \11\:VDD) resistor r=0.1323 c=0
Rk50 (\6\:VDD \13\:VDD) resistor r=0.1563 c=0
Rk51 (\7\:VDD \15\:VDD) resistor r=0.2566 c=0
Rk1 (\2\:Q Q) resistor r=0.3913 c=0
Rk2 (Q \4\:Q) resistor r=0.09099 c=0
Rk3 (\4\:CK CK) resistor r=0.101 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.401 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06291 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6085 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.417 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.2921 c=0
Rk21 (\12\:CKb \13\:CKb) resistor r=0.6435 c=0
Rk22 (\13\:CKb \14\:CKb) resistor r=0.4535 c=0
Rk23 (\14\:CKb \15\:CKb) resistor r=0.2689 c=0
Rk24 (\13\:CKb \16\:CKb) resistor r=0.08897 c=0
Rk25 (\14\:CKb \17\:CKb) resistor r=0.7035 c=0
Rk26 (\17\:CKb \19\:CKb) resistor r=0.4767 c=0
Rk27 (\17\:CKb \21\:CKb) resistor r=0.0696 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.5389 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.4421 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1644 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3339 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1232 c=0
Rk13 (\6\:mout \9\:mout) resistor r=0.2346 c=0
Rk28 (\9\:CKbb \11\:CKbb) resistor r=0.4434 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.7898 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.8589 c=0
Rk31 (\12\:CKbb \14\:CKbb) resistor r=0.1406 c=0
Rk32 (\13\:CKbb \15\:CKbb) resistor r=0.3031 c=0
Rk14 (\5\:n20 \6\:n20) resistor r=0.3828 c=0
Rk15 (\6\:n20 \7\:n20) resistor r=0.3082 c=0
Rk16 (\6\:n20 \9\:n20) resistor r=0.132 c=0
Rl23 (\1\:D \2\:D) resistor r=62.6944 c=0
Rl24 (\2\:D \3\:D) resistor r=89.6174 c=0
Rl5 (\2\:CK \3\:CK) resistor r=68.4066 c=0
Rl4 (\1\:CK \2\:CK) resistor r=107.692 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=90.0987 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=57.4064 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=115.099 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\9\:CKb \10\:CKb) resistor r=120.949 c=0
Rl25 (\8\:CKb \9\:CKb) resistor r=30.0511 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=47.3097 c=0
Rl19 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl12 (CKb \2\:CKb) resistor r=28.6412 c=0
Rl13 (\2\:CKb \3\:CKb) resistor r=193.774 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=78.022 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl17 (mout \2\:mout) resistor r=125.692 c=0
Rl18 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=156.3 c=0
Rl21 (\6\:CKbb \7\:CKbb) resistor r=26.4372 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=39.9512 c=0
Rl11 (CKbb \2\:CKbb) resistor r=48.7687 c=0
Rl15 (n20 \2\:n20) resistor r=49.1749 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=99.1749 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz13 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz5 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry9 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry10 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry11 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry6 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx8 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.90577e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20 (\18\:CKb \1\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\10\:CKbb \8\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn45 (\11\:qbint n30 \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.383e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96341e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn50 (net172 \8\:qbint \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.383e-14 ad=2.05e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.83122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\4\:n30 \3\:CKb net172 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=5.843e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.68622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=1.35622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\7\:mout \3\:n20 \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=3.28e-14 ps=1.28e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.15122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net192 \3\:mout \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=2.768e-14 ps=1.28e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=8.8122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\4\:n20 \7\:CKbb net192 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.408e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=7.0122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn26 (\4\:n20 \6\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.408e-14 ps=5.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=4.4122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=3.3622e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mp20 (\20\:CKb \3\:CK \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=2.63e-14 ps=1.12e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.22326e-07 sd=160n sca=13.9323 \
        scb=0.0120188 scc=0.000146665 m=(1)
mp21 (\8\:CKbb \10\:CKb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.63e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=27.2531 scb=0.0271167 \
        scc=0.00250214 m=(1)
mp45 (\14\:qbint \3\:n30 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=3.64e-14 ps=1.32e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17419e-07 sb=1.96935e-06 sd=160n sca=19.4821 \
        scb=0.0175815 scc=0.00172296 m=(1)
mp50 (net123 \5\:qbint \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=3.1e-14 ps=1.32e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.82419e-07 sb=1.81879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 CKbb net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.27419e-07 sb=1.67379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\4\:mout CKb \8\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=6.82e-14 ps=1.07e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.97419e-07 sb=1.40379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\4\:mout n20 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=6.82e-14 ps=1.78e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06242e-06 sb=1.13879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net147 mout \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=1.86e-14 ps=1.78e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33242e-06 sb=8.6879e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\8\:n20 \4\:CKb net147 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43742e-06 sb=7.6379e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp26 (\8\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64242e-06 sb=5.5879e-07 sd=160n sca=19.3989 \
        scb=0.017551 scc=0.00172296 m=(1)
mp25 (n22 \1\:D \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.63e-14 ad=5.89e-14 ps=1.02e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.87742e-06 sb=3.2379e-07 sd=160n sca=20.3782 \
        scb=0.0182292 scc=0.00172385 m=(1)
ends DFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:19 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFHQX2
// View name: extracted

simulator lang=spectre

subckt DFFHQX2 CK D Q VDD VSS
mp20 (\22\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=52.067 scb=0.0373106 \
        scc=0.00610613 m=(1)
mp21 (\13\:CKbb CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=3.01e-14 ps=1.08e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.8597 scb=0.00777428 \
        scc=8.41005e-05 m=(1)
C1 (D VSS) capacitor c=5.0243e-17
C2 (VDD VSS) capacitor c=2.51094e-16
C3 (Q VSS) capacitor c=6.3355e-17
C4 (CK VSS) capacitor c=2.98281e-17
C5 (CKb VSS) capacitor c=6.1857e-17
C6 (CKbb VSS) capacitor c=4.81325e-17
C7 (n21 VSS) capacitor c=7.79438e-19
C8 (n20 VSS) capacitor c=4.08417e-17
C9 (net192 VSS) capacitor c=4.92035e-18
C10 (mout VSS) capacitor c=8.49133e-17
C11 (n30 VSS) capacitor c=2.71079e-17
C12 (net172 VSS) capacitor c=1.57933e-18
C13 (qbint VSS) capacitor c=1.73988e-16
C14 (n22 VSS) capacitor c=8.34168e-18
C15 (net147 VSS) capacitor c=3.32808e-18
C16 (net123 VSS) capacitor c=2.18543e-18
C17 (\3\:n30 VSS) capacitor c=5.37738e-17
C18 (\11\:qbint VSS) capacitor c=6.41336e-17
C19 (\4\:CKbb VSS) capacitor c=7.82008e-17
C20 (\8\:CKb VSS) capacitor c=2.80116e-17
C21 (\6\:CKb VSS) capacitor c=5.61819e-17
C22 (\3\:CKbb VSS) capacitor c=2.36264e-17
C23 (\3\:D VSS) capacitor c=5.08634e-17
C24 (\1\:CK VSS) capacitor c=2.78503e-17
C25 (\7\:qbint VSS) capacitor c=6.1296e-17
C26 (\10\:CKb VSS) capacitor c=6.71639e-17
C27 (\6\:CKbb VSS) capacitor c=4.08737e-17
C28 (\3\:n20 VSS) capacitor c=3.46995e-17
C29 (\3\:mout VSS) capacitor c=2.96267e-17
C30 (\4\:CKb VSS) capacitor c=5.11172e-17
C31 (\1\:D VSS) capacitor c=5.18683e-17
C32 (\2\:CKb VSS) capacitor c=3.48916e-17
C33 (\4\:CK VSS) capacitor c=2.34424e-17
C34 (\2\:n30 VSS) capacitor c=4.69975e-17
C35 (\11\:CKb VSS) capacitor c=4.79121e-17
C36 (\5\:CKbb VSS) capacitor c=4.85954e-17
C37 (\9\:CKb VSS) capacitor c=2.77891e-17
C38 (\2\:n20 VSS) capacitor c=3.7802e-17
C39 (\2\:mout VSS) capacitor c=5.36433e-17
C40 (\7\:CKb VSS) capacitor c=3.72744e-17
C41 (\2\:CKbb VSS) capacitor c=4.4004e-17
C42 (\5\:CKb VSS) capacitor c=3.97846e-17
C43 (\2\:D VSS) capacitor c=6.04886e-17
C44 (\3\:CKb VSS) capacitor c=1.83853e-17
C45 (\3\:CK VSS) capacitor c=1.04457e-17
C46 (\16\:qbint VSS) capacitor c=3.48474e-17
C47 (\1\:VDD VSS) capacitor c=1.77282e-16
C48 (\3\:Q VSS) capacitor c=5.68561e-17
C49 (\4\:n30 VSS) capacitor c=1.14031e-16
C50 (\8\:mout VSS) capacitor c=6.99217e-17
C51 (\12\:VDD VSS) capacitor c=3.52177e-17
C52 (\5\:n20 VSS) capacitor c=1.28236e-16
C53 (\14\:VDD VSS) capacitor c=3.10353e-17
C54 (\13\:CKbb VSS) capacitor c=2.35908e-17
C55 (\22\:CKb VSS) capacitor c=5.96888e-17
C56 (\16\:VDD VSS) capacitor c=3.7524e-17
C57 (\3\:VDD VSS) capacitor c=4.20366e-17
C58 (\12\:qbint VSS) capacitor c=3.57488e-17
C59 (\1\:Q VSS) capacitor c=6.5198e-17
C60 (\7\:n30 VSS) capacitor c=3.92332e-17
C61 (\4\:mout VSS) capacitor c=5.46679e-17
C62 (\7\:n20 VSS) capacitor c=9.74757e-17
C63 (\10\:CKbb VSS) capacitor c=8.65465e-17
C64 (\17\:CKb VSS) capacitor c=6.37679e-17
C65 (\2\:CK VSS) capacitor c=9.27046e-18
C66 (\6\:qbint VSS) capacitor c=4.49316e-17
C67 (\5\:CK VSS) capacitor c=6.14497e-17
C68 (\4\:D VSS) capacitor c=7.67965e-17
C69 (\4\:n20 VSS) capacitor c=7.54808e-17
C70 (\6\:mout VSS) capacitor c=6.58002e-17
C71 (\7\:mout VSS) capacitor c=5.31975e-17
C72 (\7\:CKbb VSS) capacitor c=1.67893e-16
C73 (\8\:CKbb VSS) capacitor c=1.75079e-16
C74 (\9\:CKbb VSS) capacitor c=1.03541e-16
C75 (\12\:CKbb VSS) capacitor c=2.59358e-17
C76 (\12\:CKb VSS) capacitor c=5.34661e-17
C77 (\13\:CKb VSS) capacitor c=1.14949e-16
C78 (\14\:CKb VSS) capacitor c=2.13426e-16
C79 (\15\:CKb VSS) capacitor c=1.17547e-16
C80 (\16\:CKb VSS) capacitor c=9.29408e-17
C81 (\19\:CKb VSS) capacitor c=4.20462e-17
C82 (\20\:CKb VSS) capacitor c=4.98742e-17
C83 (\21\:CKb VSS) capacitor c=3.90768e-17
C84 (\6\:n30 VSS) capacitor c=1.4931e-16
C85 (\9\:n30 VSS) capacitor c=1.40903e-16
C86 (\14\:qbint VSS) capacitor c=3.82292e-17
C87 (\15\:qbint VSS) capacitor c=4.45202e-17
C88 (\6\:VDD VSS) capacitor c=5.35378e-17
C89 (\8\:VDD VSS) capacitor c=2.00047e-17
C90 (\9\:VDD VSS) capacitor c=1.10153e-17
Rk2 (D \4\:D) resistor r=0.05798 c=0
Rk43 (\1\:VDD \6\:VDD) resistor r=0.583 c=0
Rk44 (\6\:VDD \7\:VDD) resistor r=0.37 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.1804 c=0
Rk47 (\9\:VDD VDD) resistor r=0.05473 c=0
Rk46 (\8\:VDD \9\:VDD) resistor r=0.3156 c=0
Rk49 (\6\:VDD \13\:VDD) resistor r=0.04331 c=0
Rk50 (\8\:VDD \15\:VDD) resistor r=0.1842 c=0
Rk51 (\9\:VDD \17\:VDD) resistor r=0.4181 c=0
Rk22 (\2\:Q Q) resistor r=0.3653 c=0
Rk23 (Q \4\:Q) resistor r=0.1634 c=0
Rk32 (\1\:VSS \6\:VSS) resistor r=0.5714 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.3133 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.08758 c=0
Rk36 (\9\:VSS VSS) resistor r=0.07479 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.3883 c=0
Rk38 (\6\:VSS \13\:VSS) resistor r=0.3346 c=0
Rk39 (\8\:VSS \15\:VSS) resistor r=0.3342 c=0
Rk40 (\9\:VSS \17\:VSS) resistor r=0.07393 c=0
Rk1 (\5\:CK CK) resistor r=0.1128 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.2579 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.9845 c=0
Rk15 (\14\:CKb \15\:CKb) resistor r=0.688 c=0
Rk16 (\15\:CKb \16\:CKb) resistor r=0.4308 c=0
Rk17 (\16\:CKb \18\:CKb) resistor r=0.3377 c=0
Rk18 (\13\:CKb \19\:CKb) resistor r=0.1497 c=0
Rk19 (\14\:CKb \20\:CKb) resistor r=0.2518 c=0
Rk20 (\15\:CKb \21\:CKb) resistor r=0.1462 c=0
Rk21 (\18\:CKb \23\:CKb) resistor r=0.2859 c=0
Rk8 (\7\:CKbb \8\:CKbb) resistor r=1.2992 c=0
Rk9 (\8\:CKbb \9\:CKbb) resistor r=0.4755 c=0
Rk10 (\9\:CKbb \11\:CKbb) resistor r=0.4315 c=0
Rk11 (\8\:CKbb \12\:CKbb) resistor r=0.1348 c=0
Rk12 (\9\:CKbb \14\:CKbb) resistor r=0.05277 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.5132 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.549 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.1928 c=0
Rk6 (\6\:mout \7\:mout) resistor r=0.2403 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.2949 c=0
Rk24 (\5\:n30 \6\:n30) resistor r=0.5981 c=0
Rk25 (\6\:n30 \8\:n30) resistor r=0.2352 c=0
Rk26 (\6\:n30 \9\:n30) resistor r=0.9167 c=0
Rk27 (\13\:qbint \14\:qbint) resistor r=0.3349 c=0
Rk28 (\14\:qbint \15\:qbint) resistor r=0.1763 c=0
Rk29 (\14\:qbint \17\:qbint) resistor r=0.1769 c=0
Rl7 (\2\:D \3\:D) resistor r=110.307 c=0
Rl6 (\1\:D \2\:D) resistor r=66.7194 c=0
Rl1 (\1\:CK \2\:CK) resistor r=49.7141 c=0
Rl3 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl2 (\2\:CK \3\:CK) resistor r=1.2666 c=0
Rl4 (CKb \2\:CKb) resistor r=226.923 c=0
Rl19 (\10\:CKb \11\:CKb) resistor r=53.079 c=0
Rl16 (\8\:CKb \9\:CKb) resistor r=35.7713 c=0
Rl11 (\6\:CKb \7\:CKb) resistor r=48.7687 c=0
Rl8 (\4\:CKb \5\:CKb) resistor r=74.2328 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl17 (\4\:CKbb \5\:CKbb) resistor r=77.4625 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=126.156 c=0
Rl10 (\2\:CKbb \3\:CKbb) resistor r=24.7951 c=0
Rl9 (CKbb \2\:CKbb) resistor r=161.516 c=0
Rl14 (n20 \2\:n20) resistor r=37.2302 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=127.615 c=0
Rl12 (mout \2\:mout) resistor r=108.848 c=0
Rl13 (\2\:mout \3\:mout) resistor r=68.3618 c=0
Rl31 (\2\:n30 \3\:n30) resistor r=109.066 c=0
Rl30 (n30 \2\:n30) resistor r=34.2718 c=0
Rl29 (\6\:qbint \11\:qbint) resistor r=78.0797 c=0
Rl24 (\6\:qbint qbint) resistor r=112.377 c=0
Rl25 (\6\:qbint \7\:qbint) resistor r=108.849 c=0
Rz13 (\1\:VDD \3\:VDD) resistor r=9.375 c=0
Rz14 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz5 (\2\:Q \1\:Q) resistor r=75 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz4 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz7 (\13\:qbint \12\:qbint) resistor r=75 c=0
Ry12 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry5 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry8 (\1\:VSS \3\:VSS) resistor r=7.75 c=0
Ry9 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry4 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry3 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\4\:n30 \5\:n30) resistor r=31 c=0
Ry7 (\17\:qbint \16\:qbint) resistor r=31 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx9 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \20\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \21\:CKb) resistor r=45 c=0
Rx5 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx6 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx12 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx13 (\15\:qbint qbint) resistor r=45 c=0
mn20 (\17\:CKb \4\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\10\:CKbb \2\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.407e-14 ad=2.32e-14 ps=1.04e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \1\:D \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=1.435e-14 ps=1.04e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.0878e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn26 (\7\:n20 \4\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=4.51e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2378e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn36 (\7\:n20 CKbb net192 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=4.51e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8878e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net192 \3\:mout \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=4.715e-14 ps=9.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06378e-06 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (\4\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.638e-14 ad=9.533e-14 ps=9.6e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38378e-06 sb=1.835e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\4\:mout \6\:CKbb \7\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=9.533e-14 ps=7.3e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.89024e-06 sb=1.325e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (\7\:n30 \10\:CKb net172 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95024e-06 sb=1.12e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net172 \7\:qbint \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.23e-14 ps=1.13e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98098e-06 sb=1.015e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn45 (\12\:qbint n30 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.777e-14 ad=2.87e-14 ps=1.03e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn55 (\1\:Q qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=4.68e-14 ps=1.08e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=5.93077e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp25 (n22 \3\:D \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=8.06e-14 ps=1.08e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.18468e-07 sb=2e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.023e-13 ps=1.14e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.23468e-07 sb=2e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp36 (\5\:n20 \6\:CKb net147 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.17e-14 ad=1.023e-13 ps=7.6e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.98468e-07 sb=1.96387e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp35 (net147 mout \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=2.17e-14 ps=1.39e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11347e-06 sb=1.91935e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp30 (\8\:mout n20 \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=8.835e-14 ps=1.39e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37847e-06 sb=1.65435e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp40 (\8\:mout \8\:CKb \4\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=8.835e-14 ps=1.3e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.70847e-06 sb=1.32435e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp51 (\4\:n30 \4\:CKbb net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=1.054e-13 ps=7.4e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96169e-06 sb=9.39355e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp50 (net123 \11\:qbint \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.49e-14 ad=1.86e-14 ps=1.32e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99387e-06 sb=8.34355e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp45 (\16\:qbint \3\:n30 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.01e-14 ad=4.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63355e-06 sb=1.4e-07 sd=160n sca=16.7687 \
        scb=0.0168289 scc=0.000420091 m=(1)
mp55_1__rcx (\3\:Q qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.25e-14 ad=6.24e-14 ps=1.24e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61846e-06 sb=5.31795e-07 sd=160n sca=12.0426 \
        scb=0.00999671 scc=0.000274125 m=(2)
ends DFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:20 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFHQX4
// View name: extracted

simulator lang=spectre

subckt DFFHQX4 CK D Q VDD VSS
mp20 (\20\:CKb \1\:CK \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.86465e-06 sd=160n sca=34.311 \
        scb=0.0304179 scc=0.00380485 m=(1)
mp21 (\10\:CKbb \10\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=27.6463 scb=0.0278146 \
        scc=0.00252566 m=(1)
C1 (D VSS) capacitor c=1.59088e-16
C2 (VDD VSS) capacitor c=2.09252e-16
C3 (Q VSS) capacitor c=2.84729e-16
C4 (CK VSS) capacitor c=3.60999e-17
C5 (CKb VSS) capacitor c=5.3076e-17
C6 (qbint VSS) capacitor c=2.58593e-16
C7 (n30 VSS) capacitor c=1.49337e-16
C8 (net172 VSS) capacitor c=2.72667e-18
C9 (mout VSS) capacitor c=2.90736e-17
C10 (CKbb VSS) capacitor c=7.43427e-17
C11 (n20 VSS) capacitor c=1.83254e-17
C12 (net192 VSS) capacitor c=9.46485e-18
C13 (n21 VSS) capacitor c=3.62743e-19
C14 (net147 VSS) capacitor c=6.38904e-18
C15 (n22 VSS) capacitor c=9.53459e-18
C16 (\10\:CKb VSS) capacitor c=4.61192e-17
C17 (\3\:D VSS) capacitor c=4.71066e-17
C18 (\5\:CKbb VSS) capacitor c=2.70538e-17
C19 (\4\:CKb VSS) capacitor c=3.99203e-17
C20 (\3\:mout VSS) capacitor c=7.01676e-17
C21 (\4\:n20 VSS) capacitor c=3.39065e-17
C22 (\17\:qbint VSS) capacitor c=7.41938e-17
C23 (\1\:CK VSS) capacitor c=3.45292e-17
C24 (\8\:CKb VSS) capacitor c=3.19584e-17
C25 (\1\:D VSS) capacitor c=7.61671e-17
C26 (\6\:CKb VSS) capacitor c=6.38932e-17
C27 (\7\:CKbb VSS) capacitor c=3.81929e-17
C28 (\3\:n20 VSS) capacitor c=4.44106e-17
C29 (\3\:CKbb VSS) capacitor c=3.06028e-17
C30 (\3\:CKb VSS) capacitor c=2.6542e-17
C31 (\15\:qbint VSS) capacitor c=3.58141e-17
C32 (\3\:CK VSS) capacitor c=3.21745e-17
C33 (\9\:CKb VSS) capacitor c=3.64711e-17
C34 (\2\:D VSS) capacitor c=5.93184e-17
C35 (\7\:CKb VSS) capacitor c=3.81505e-17
C36 (\6\:CKbb VSS) capacitor c=3.20061e-17
C37 (\5\:CKb VSS) capacitor c=3.32746e-17
C38 (\2\:mout VSS) capacitor c=4.87552e-17
C39 (\4\:CKbb VSS) capacitor c=2.64591e-17
C40 (\2\:CKb VSS) capacitor c=4.77192e-17
C41 (\2\:CKbb VSS) capacitor c=3.42562e-17
C42 (\16\:qbint VSS) capacitor c=5.16097e-17
C43 (\2\:CK VSS) capacitor c=3.24127e-17
C44 (\10\:CKbb VSS) capacitor c=9.8812e-17
C45 (\1\:VDD VSS) capacitor c=4.82389e-17
C46 (\7\:n20 VSS) capacitor c=1.27036e-16
C47 (\11\:VDD VSS) capacitor c=2.98713e-17
C48 (\8\:mout VSS) capacitor c=6.88843e-17
C49 (\12\:n30 VSS) capacitor c=4.81107e-17
C50 (\24\:qbint VSS) capacitor c=4.05573e-17
C51 (\20\:CKb VSS) capacitor c=5.79738e-17
C52 (\3\:VDD VSS) capacitor c=3.68055e-17
C53 (\8\:CKbb VSS) capacitor c=6.03052e-17
C54 (\5\:n20 VSS) capacitor c=9.77487e-17
C55 (\6\:mout VSS) capacitor c=3.89402e-17
C56 (\8\:n30 VSS) capacitor c=6.75093e-17
C57 (\22\:qbint VSS) capacitor c=4.23993e-17
C58 (\15\:CKb VSS) capacitor c=2.81251e-16
C59 (\2\:n20 VSS) capacitor c=2.31269e-17
C60 (\4\:CK VSS) capacitor c=8.00905e-17
C61 (\18\:qbint VSS) capacitor c=7.21695e-17
C62 (\19\:qbint VSS) capacitor c=8.32843e-17
C63 (\21\:qbint VSS) capacitor c=7.18645e-17
C64 (\10\:n30 VSS) capacitor c=7.62803e-17
C65 (\11\:n30 VSS) capacitor c=6.78805e-17
C66 (\4\:mout VSS) capacitor c=6.18606e-17
C67 (\5\:mout VSS) capacitor c=5.00975e-17
C68 (\9\:n20 VSS) capacitor c=8.30953e-17
C69 (\11\:CKb VSS) capacitor c=4.63845e-17
C70 (\12\:CKb VSS) capacitor c=9.82456e-17
C71 (\13\:CKb VSS) capacitor c=2.26647e-16
C72 (\14\:CKb VSS) capacitor c=3.88014e-16
C73 (\17\:CKb VSS) capacitor c=2.63929e-17
C74 (\18\:CKb VSS) capacitor c=5.68758e-17
C75 (\19\:CKb VSS) capacitor c=3.58004e-17
C76 (\12\:CKbb VSS) capacitor c=1.39262e-16
C77 (\13\:CKbb VSS) capacitor c=1.43331e-16
C78 (\14\:CKbb VSS) capacitor c=5.34057e-17
C79 (\15\:CKbb VSS) capacitor c=3.54503e-17
C80 (\16\:CKbb VSS) capacitor c=5.46467e-17
C81 (\5\:VDD VSS) capacitor c=2.73367e-17
C82 (\6\:VDD VSS) capacitor c=3.4929e-16
Rk51 (\2\:VDD \4\:VDD) resistor r=0.643 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.1578 c=0
Rk58 (\6\:VDD VDD) resistor r=0.2027 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.6089 c=0
Rk59 (\5\:VDD \12\:VDD) resistor r=0.2039 c=0
Rk38 (\2\:VSS \4\:VSS) resistor r=0.7147 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=0.09509 c=0
Rk45 (\6\:VSS VSS) resistor r=0.134 c=0
Rk40 (\5\:VSS \6\:VSS) resistor r=0.5989 c=0
Rk46 (\5\:VSS \12\:VSS) resistor r=0.2243 c=0
Rk3 (\4\:CK CK) resistor r=0.03301 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2254 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=0.7773 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=1.0373 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=2.2675 c=0
Rk27 (\12\:CKb \17\:CKb) resistor r=0.06418 c=0
Rk28 (\13\:CKb \18\:CKb) resistor r=0.2445 c=0
Rk29 (\14\:CKb \19\:CKb) resistor r=0.1092 c=0
Rk30 (\16\:CKb \21\:CKb) resistor r=0.4379 c=0
Rk10 (\18\:qbint \19\:qbint) resistor r=0.3362 c=0
Rk11 (\19\:qbint \20\:qbint) resistor r=0.04851 c=0
Rk12 (\20\:qbint \21\:qbint) resistor r=0.3881 c=0
Rk13 (\19\:qbint \23\:qbint) resistor r=0.1149 c=0
Rk14 (\20\:qbint \25\:qbint) resistor r=0.2614 c=0
Rk15 (\9\:n30 \10\:n30) resistor r=0.3553 c=0
Rk16 (\10\:n30 \11\:n30) resistor r=0.37 c=0
Rk17 (\10\:n30 \13\:n30) resistor r=0.1513 c=0
Rk18 (\4\:mout \5\:mout) resistor r=0.2631 c=0
Rk19 (\5\:mout \7\:mout) resistor r=0.1203 c=0
Rk20 (\5\:mout \9\:mout) resistor r=0.2341 c=0
Rk32 (\9\:CKbb \11\:CKbb) resistor r=0.5732 c=0
Rk33 (\11\:CKbb \12\:CKbb) resistor r=0.4067 c=0
Rk34 (\12\:CKbb \13\:CKbb) resistor r=0.9967 c=0
Rk35 (\13\:CKbb \14\:CKbb) resistor r=0.4026 c=0
Rk36 (\12\:CKbb \15\:CKbb) resistor r=0.1203 c=0
Rk37 (\13\:CKbb \16\:CKbb) resistor r=0.2797 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.5638 c=0
Rk22 (\8\:n20 \9\:n20) resistor r=0.486 c=0
Rl38 (\2\:D \3\:D) resistor r=67.227 c=0
Rl37 (\1\:D \2\:D) resistor r=88.3096 c=0
Rl1 (\1\:CK \2\:CK) resistor r=43.3029 c=0
Rl2 (\2\:CK \3\:CK) resistor r=36.3335 c=0
Rl40 (\9\:CKb \10\:CKb) resistor r=93.4636 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=26.1559 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=30.0021 c=0
Rl25 (CKb \2\:CKb) resistor r=122.631 c=0
Rl26 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl23 (\16\:qbint \17\:qbint) resistor r=89.9037 c=0
Rl22 (\16\:qbint \15\:qbint) resistor r=42.0992 c=0
Rl32 (\2\:mout \3\:mout) resistor r=88.2566 c=0
Rl31 (mout \2\:mout) resistor r=43.5097 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl35 (\6\:CKbb \7\:CKbb) resistor r=95.3867 c=0
Rl27 (\3\:CKbb \4\:CKbb) resistor r=70.3867 c=0
Rl24 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl30 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl29 (\2\:n20 \3\:n20) resistor r=105.483 c=0
Rl28 (n20 \2\:n20) resistor r=2.7713 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz16 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\23\:qbint \22\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry11 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry10 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry7 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\25\:qbint \24\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=31 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Rx11 (\2\:D D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx7 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (\7\:CKb \17\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \18\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx6 (n20 \9\:n20) resistor r=45 c=0
mn20 (\15\:CKb \3\:CK \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=2.755e-14 ps=1.65e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.46207e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\8\:CKbb \8\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn55_1__rcx (Q qbint \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.779e-14 ad=4.55e-14 ps=1.5875e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.72885e-07 sb=1.63231e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn50 (net172 \15\:qbint \6\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.973e-14 ad=2.768e-14 ps=1.14e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82183e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn51 (\8\:n30 \3\:CKb net172 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=6.867e-14 ps=6.8e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.89146e-06 sb=1.96049e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn40 (\6\:mout \3\:CKbb \8\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=4.715e-14 ps=1.08e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9378e-06 sb=1.65829e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn30 (\6\:mout \3\:n20 \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.238e-14 ad=4.715e-14 ps=1.17e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97134e-06 sb=1.38329e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn35 (net192 mout \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=7.073e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.02329e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn36 (\5\:n20 \7\:CKbb net192 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=4.305e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.33293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.78293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn25 (n21 \1\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.73293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn45 (\22\:qbint n30 \6\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.42e-14 ad=4.51e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27817e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(2)
mp55_1__rcx (Q qbint \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.08e-14 ad=7.02e-14 ps=1.2325e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.75128e-06 sd=160n sca=31.7909 \
        scb=0.0210107 scc=0.00336206 m=(4)
mp50 (net123 \17\:qbint \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.86e-14 ps=1.15e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=2e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\12\:n30 CKbb net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96573e-06 sb=1.97395e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:mout CKb \12\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.612e-13 ps=9.4e-07 pd=1.66e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.90766e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\8\:mout \4\:n20 \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.612e-13 ps=1.38e-06 pd=1.66e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.34266e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net147 \3\:mout \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.185e-14 ps=1.38e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.07766e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\7\:n20 \4\:CKb net147 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=8.06e-14 ps=8.9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.97661e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp26 (\7\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=8.06e-14 ps=1.04e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.92661e-07 sd=160n sca=19.2885 \
        scb=0.0175179 scc=0.00172295 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=6.51e-14 ps=1.1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.37661e-07 sd=160n sca=20.2256 \
        scb=0.0180795 scc=0.00172352 m=(1)
mp45_1__rcx (\24\:qbint n30 \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.076e-13 ad=6.82e-14 ps=1.36e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37524e-06 sb=2e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(2)
ends DFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:21 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFHQX8
// View name: extracted

simulator lang=spectre

subckt DFFHQX8 CK D Q VDD VSS
mp55_1__rcx (Q qbint \7\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.91719e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (VDD VSS) capacitor c=2.52616e-16
C2 (CK VSS) capacitor c=4.3404e-17
C3 (D VSS) capacitor c=5.81481e-17
C4 (Q VSS) capacitor c=5.10493e-16
C5 (qbint VSS) capacitor c=3.67397e-16
C6 (n30 VSS) capacitor c=2.27475e-16
C7 (CKb VSS) capacitor c=7.23343e-17
C8 (CKbb VSS) capacitor c=4.49646e-17
C9 (net172 VSS) capacitor c=2.18678e-18
C10 (mout VSS) capacitor c=9.83896e-17
C11 (n20 VSS) capacitor c=2.05258e-17
C12 (net192 VSS) capacitor c=3.2229e-18
C13 (net123 VSS) capacitor c=1.92235e-18
C14 (net147 VSS) capacitor c=1.1106e-18
C15 (n22 VSS) capacitor c=8.95344e-18
C16 (\3\:CK VSS) capacitor c=3.31274e-17
C17 (\3\:D VSS) capacitor c=4.68007e-17
C18 (\5\:CKbb VSS) capacitor c=7.37724e-17
C19 (\8\:CKb VSS) capacitor c=7.07877e-17
C20 (\4\:n20 VSS) capacitor c=3.55238e-17
C21 (\7\:CKb VSS) capacitor c=2.51359e-17
C22 (\26\:qbint VSS) capacitor c=6.45216e-17
C23 (\2\:CKb VSS) capacitor c=4.35789e-17
C24 (\1\:CK VSS) capacitor c=2.87435e-17
C25 (\1\:D VSS) capacitor c=6.94164e-17
C26 (\10\:CKb VSS) capacitor c=6.14882e-17
C27 (\7\:CKbb VSS) capacitor c=3.08556e-17
C28 (\3\:mout VSS) capacitor c=4.15689e-17
C29 (\3\:n20 VSS) capacitor c=4.58835e-17
C30 (\3\:CKbb VSS) capacitor c=3.0622e-17
C31 (\6\:CKb VSS) capacitor c=6.43996e-17
C32 (\23\:qbint VSS) capacitor c=4.79933e-17
C33 (\2\:CK VSS) capacitor c=3.15804e-17
C34 (\2\:D VSS) capacitor c=5.05945e-17
C35 (\11\:CKb VSS) capacitor c=3.89668e-17
C36 (\6\:CKbb VSS) capacitor c=5.45428e-17
C37 (\9\:CKb VSS) capacitor c=3.19886e-17
C38 (\2\:mout VSS) capacitor c=5.4393e-17
C39 (\4\:CKb VSS) capacitor c=2.68599e-17
C40 (\4\:CKbb VSS) capacitor c=4.10243e-17
C41 (\2\:CKbb VSS) capacitor c=3.37937e-17
C42 (\25\:qbint VSS) capacitor c=2.49776e-17
C43 (\3\:CKb VSS) capacitor c=2.61802e-17
C44 (\11\:qbint VSS) capacitor c=2.32764e-17
C45 (\19\:CKb VSS) capacitor c=5.89885e-17
C46 (\13\:VDD VSS) capacitor c=6.03084e-17
C47 (\9\:n20 VSS) capacitor c=6.387e-17
C48 (\15\:VDD VSS) capacitor c=3.9656e-17
C49 (\8\:mout VSS) capacitor c=7.4377e-17
C50 (\12\:n30 VSS) capacitor c=1.83537e-16
C51 (\17\:VDD VSS) capacitor c=2.14788e-17
C52 (\15\:CKbb VSS) capacitor c=8.77164e-17
C53 (\1\:VDD VSS) capacitor c=5.37548e-17
C54 (\12\:CKb VSS) capacitor c=7.05931e-17
C55 (\5\:n20 VSS) capacitor c=6.79016e-17
C56 (\6\:mout VSS) capacitor c=5.5373e-17
C57 (\14\:n30 VSS) capacitor c=1.04977e-16
C58 (\13\:CKbb VSS) capacitor c=6.18718e-17
C59 (\24\:qbint VSS) capacitor c=3.88591e-17
C60 (\5\:CKb VSS) capacitor c=4.42755e-17
C61 (\2\:n20 VSS) capacitor c=2.55133e-17
C62 (\27\:qbint VSS) capacitor c=7.93643e-17
C63 (\28\:qbint VSS) capacitor c=2.58886e-16
C64 (\31\:qbint VSS) capacitor c=4.13885e-17
C65 (\11\:n30 VSS) capacitor c=1.32357e-16
C66 (\4\:mout VSS) capacitor c=5.57945e-17
C67 (\5\:mout VSS) capacitor c=7.83921e-17
C68 (\8\:CKbb VSS) capacitor c=1.24819e-16
C69 (\9\:CKbb VSS) capacitor c=1.49716e-16
C70 (\10\:CKbb VSS) capacitor c=1.057e-16
C71 (\11\:CKbb VSS) capacitor c=6.73784e-17
C72 (\12\:CKbb VSS) capacitor c=6.2011e-17
C73 (\7\:n20 VSS) capacitor c=7.01305e-17
C74 (\8\:n20 VSS) capacitor c=4.41306e-17
C75 (\4\:D VSS) capacitor c=6.67967e-17
C76 (\5\:CK VSS) capacitor c=2.58803e-17
C77 (\14\:CKb VSS) capacitor c=1.16206e-16
C78 (\15\:CKb VSS) capacitor c=1.24374e-16
C79 (\16\:CKb VSS) capacitor c=1.11907e-16
C80 (\17\:CKb VSS) capacitor c=1.27456e-16
C81 (\18\:CKb VSS) capacitor c=1.15985e-16
C82 (\21\:CKb VSS) capacitor c=5.24819e-17
C83 (\3\:VDD VSS) capacitor c=2.01052e-17
C84 (\4\:VDD VSS) capacitor c=1.95174e-17
C85 (\6\:VDD VSS) capacitor c=3.82766e-17
C86 (\7\:VDD VSS) capacitor c=4.61755e-16
Rk44 (\2\:VSS \3\:VSS) resistor r=0.1828 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.4384 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.1302 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.4411 c=0
Rk54 (\7\:VSS VSS) resistor r=0.1074 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.3832 c=0
Rk55 (\3\:VSS \14\:VSS) resistor r=0.2139 c=0
Rk56 (\4\:VSS \16\:VSS) resistor r=0.1889 c=0
Rk57 (\6\:VSS \18\:VSS) resistor r=0.2148 c=0
Rk63 (\2\:VDD \3\:VDD) resistor r=0.2505 c=0
Rk64 (\3\:VDD \4\:VDD) resistor r=0.3707 c=0
Rk65 (\4\:VDD \5\:VDD) resistor r=0.1302 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=0.4627 c=0
Rk73 (\7\:VDD VDD) resistor r=0.1074 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.3597 c=0
Rk74 (\3\:VDD \14\:VDD) resistor r=0.3079 c=0
Rk75 (\4\:VDD \16\:VDD) resistor r=0.1859 c=0
Rk76 (\6\:VDD \18\:VDD) resistor r=0.0433 c=0
Rk34 (\4\:CK \5\:CK) resistor r=0.003538 c=0
Rk35 (\6\:CK CK) resistor r=0.003656 c=0
Rk36 (\5\:CK \6\:CK) resistor r=0.04834 c=0
Rk33 (D \4\:D) resistor r=0.1009 c=0
Rk11 (\27\:qbint \28\:qbint) resistor r=0.4437 c=0
Rk14 (\28\:qbint \31\:qbint) resistor r=0.1477 c=0
Rk19 (\11\:n30 \13\:n30) resistor r=1.0951 c=0
Rk20 (\13\:n30 \15\:n30) resistor r=0.4999 c=0
Rk37 (\13\:CKb \14\:CKb) resistor r=0.6524 c=0
Rk38 (\14\:CKb \15\:CKb) resistor r=0.2949 c=0
Rk39 (\15\:CKb \16\:CKb) resistor r=0.4758 c=0
Rk40 (\16\:CKb \17\:CKb) resistor r=0.5591 c=0
Rk41 (\17\:CKb \18\:CKb) resistor r=0.7952 c=0
Rk42 (\15\:CKb \20\:CKb) resistor r=0.4751 c=0
Rk43 (\17\:CKb \21\:CKb) resistor r=0.3051 c=0
Rk24 (\8\:CKbb \9\:CKbb) resistor r=0.8612 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.4501 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.2699 c=0
Rk27 (\9\:CKbb \12\:CKbb) resistor r=0.2854 c=0
Rk28 (\10\:CKbb \14\:CKbb) resistor r=0.3471 c=0
Rk29 (\11\:CKbb \16\:CKbb) resistor r=0.4396 c=0
Rk21 (\4\:mout \5\:mout) resistor r=0.2777 c=0
Rk22 (\5\:mout \7\:mout) resistor r=0.1804 c=0
Rk23 (\5\:mout \9\:mout) resistor r=0.2844 c=0
Rk30 (\6\:n20 \7\:n20) resistor r=0.4097 c=0
Rk31 (\7\:n20 \8\:n20) resistor r=0.2942 c=0
Rk32 (\7\:n20 \10\:n20) resistor r=0.1572 c=0
Rl53 (\2\:CK \3\:CK) resistor r=83.7912 c=0
Rl52 (\1\:CK \2\:CK) resistor r=101.923 c=0
Rl51 (\2\:D \3\:D) resistor r=65.3618 c=0
Rl50 (\1\:D \2\:D) resistor r=117.103 c=0
Rl10 (qbint \11\:qbint) resistor r=4.8851 c=0
Rl35 (\24\:qbint \26\:qbint) resistor r=101.385 c=0
Rl33 (\24\:qbint \23\:qbint) resistor r=62.9711 c=0
Rl34 (\24\:qbint \25\:qbint) resistor r=4.5402 c=0
Rl31 (CKb \2\:CKb) resistor r=197.643 c=0
Rl49 (\10\:CKb \11\:CKb) resistor r=52.6149 c=0
Rl46 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl32 (\2\:CKb \3\:CKb) resistor r=50.6918 c=0
Rl40 (\5\:CKb \7\:CKb) resistor r=47.4388 c=0
Rl39 (\5\:CKb \6\:CKb) resistor r=181.166 c=0
Rl38 (\4\:CKb \5\:CKb) resistor r=89.2399 c=0
Rl47 (\5\:CKbb \6\:CKbb) resistor r=156.882 c=0
Rl48 (\6\:CKbb \7\:CKbb) resistor r=30.0511 c=0
Rl37 (\3\:CKbb \4\:CKbb) resistor r=52.6149 c=0
Rl36 (CKbb \2\:CKbb) resistor r=35.3072 c=0
Rl44 (mout \2\:mout) resistor r=116.483 c=0
Rl45 (\2\:mout \3\:mout) resistor r=37.6365 c=0
Rl43 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=139.264 c=0
Rl41 (n20 \2\:n20) resistor r=3.1216 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz21 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\15\:n30 \14\:n30) resistor r=75 c=0
Rz11 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz9 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz8 (\6\:mout \7\:mout) resistor r=75 c=0
Rz10 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\13\:n30 \12\:n30) resistor r=31 c=0
Ry11 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry9 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\9\:n20 \10\:n20) resistor r=31 c=0
Rx10 (\2\:CK \4\:CK) resistor r=45 c=0
Rx9 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\27\:qbint \25\:qbint) resistor r=45 c=0
Rx2 (\31\:qbint \11\:qbint) resistor r=45 c=0
Rx3 (\11\:n30 n30) resistor r=45 c=0
Rx11 (\11\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\9\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \21\:CKb) resistor r=45 c=0
Rx5 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx6 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (n20 \8\:n20) resistor r=45 c=0
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90729e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45 (\28\:qbint n30 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.277e-14 ad=3.987e-14 ps=8.6333e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
mn21 (\13\:CKbb CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn20 (\12\:CKb \1\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=2.03e-14 ps=1.25e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn50 (net172 \23\:qbint \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=2.665e-14 ps=7.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.96488e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\14\:n30 \6\:CKb net172 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=5.433e-14 ps=6.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8122e-07 sb=1.91366e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\6\:mout \3\:CKbb \14\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.432e-14 ad=7.688e-14 ps=9.4e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9122e-07 sb=1.7522e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\6\:mout \3\:n20 \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.93e-14 ad=7.688e-14 ps=9.2e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21122e-06 sb=1.3322e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net192 \3\:mout \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.87e-14 ps=9.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47622e-06 sb=1.0672e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\5\:n20 \7\:CKbb net192 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=5.638e-14 ps=6.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66122e-06 sb=8.82195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn26 (\5\:n20 \10\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.638e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94585e-06 sb=5.62195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (n21 \1\:D \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=1.23e-14 ps=1.25e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97659e-06 sb=4.57195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mp45_1__rcx (\28\:qbint n30 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.583e-14 ad=5.98e-14 ps=1.31667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.1e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp21 (\15\:CKbb \2\:CKb \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0425e-13 ad=3.01e-14 ps=1.74e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp20 (\19\:CKb \3\:CK \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1435e-13 ad=3.01e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=25.2301 scb=0.0262115 \
        scc=0.00203777 m=(1)
mp50 (net123 \26\:qbint \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.0425e-13 ad=3.565e-14 ps=1.74e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=1.9571e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (\12\:n30 CKbb net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=5.89e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92984e-07 sb=1.90806e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp40 (\8\:mout \7\:CKb \12\:n30 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.581e-13 ps=1e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.27984e-07 sb=1.82218e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp30 (\8\:mout \4\:n20 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=1.581e-13 ps=1.39e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28298e-06 sb=1.26718e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp35 (net147 mout \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=1.86e-14 ps=1.39e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54798e-06 sb=1.00218e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp36 (\9\:n20 \8\:CKb net147 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.27e-14 ps=7.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65298e-06 sb=8.97177e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=5.27e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86798e-06 sb=6.82177e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp25 (n22 \3\:D \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1435e-13 ad=4.34e-14 ps=1.56e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96629e-06 sb=4.97177e-07 sd=160n sca=17.5841 \
        scb=0.016252 scc=0.00137566 m=(1)
ends DFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:22 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFNSRX1
// View name: extracted

simulator lang=spectre

subckt DFFNSRX1 CKN D Q QN RN SN VDD VSS
mp57 (\1\:QN qint \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.35064e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
mp55 (\3\:Q qbint \24\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.54359e-07 sd=160n sca=18.7372 \
        scb=0.0160946 scc=0.00159617 m=(1)
C1 (RN VSS) capacitor c=3.33204e-17
C2 (CKN VSS) capacitor c=8.42887e-17
C3 (QN VSS) capacitor c=4.04962e-17
C4 (D VSS) capacitor c=1.16797e-16
C5 (Q VSS) capacitor c=8.77591e-17
C6 (VDD VSS) capacitor c=3.58782e-16
C7 (SN VSS) capacitor c=2.41033e-16
C8 (qint VSS) capacitor c=4.60795e-17
C9 (qbint VSS) capacitor c=5.22954e-17
C10 (RNb VSS) capacitor c=5.98e-17
C11 (n35 VSS) capacitor c=3.53398e-17
C12 (n42 VSS) capacitor c=6.0511e-17
C13 (n40 VSS) capacitor c=6.96351e-17
C14 (CKNbb VSS) capacitor c=3.70705e-17
C15 (mout VSS) capacitor c=5.73141e-17
C16 (CKNb VSS) capacitor c=7.6384e-17
C17 (n25 VSS) capacitor c=1.01605e-16
C18 (n20 VSS) capacitor c=4.47875e-17
C19 (n30 VSS) capacitor c=2.36337e-18
C20 (n21 VSS) capacitor c=1.26516e-20
C21 (n41 VSS) capacitor c=8.81546e-17
C22 (n43 VSS) capacitor c=9.19802e-19
C23 (n26 VSS) capacitor c=4.56963e-18
C24 (n31 VSS) capacitor c=1.09643e-18
C25 (n22 VSS) capacitor c=2.59562e-18
C26 (\1\:CKN VSS) capacitor c=2.86123e-17
C27 (\7\:CKNb VSS) capacitor c=6.36738e-17
C28 (\3\:D VSS) capacitor c=6.04575e-17
C29 (\4\:CKNb VSS) capacitor c=7.84979e-17
C30 (\7\:CKNbb VSS) capacitor c=4.85804e-17
C31 (\4\:SN VSS) capacitor c=5.54097e-17
C32 (\4\:RNb VSS) capacitor c=5.65225e-17
C33 (\3\:CKNbb VSS) capacitor c=3.64962e-17
C34 (\2\:RNb VSS) capacitor c=6.94632e-17
C35 (\8\:qbint VSS) capacitor c=7.71487e-17
C36 (\1\:SN VSS) capacitor c=3.68297e-17
C37 (\1\:RN VSS) capacitor c=4.65793e-17
C38 (\7\:qbint VSS) capacitor c=3.37686e-17
C39 (\3\:CKN VSS) capacitor c=2.40292e-17
C40 (\8\:CKNb VSS) capacitor c=4.55466e-17
C41 (\1\:D VSS) capacitor c=4.4871e-17
C42 (\8\:CKNbb VSS) capacitor c=5.6864e-17
C43 (\5\:CKNb VSS) capacitor c=6.55901e-17
C44 (\4\:mout VSS) capacitor c=4.74131e-17
C45 (\6\:SN VSS) capacitor c=6.45235e-17
C46 (\3\:n20 VSS) capacitor c=3.29172e-17
C47 (\5\:RNb VSS) capacitor c=4.83039e-17
C48 (\2\:CKNb VSS) capacitor c=7.46597e-17
C49 (\9\:qbint VSS) capacitor c=5.04638e-17
C50 (\3\:SN VSS) capacitor c=4.41521e-17
C51 (\3\:n35 VSS) capacitor c=3.82014e-17
C52 (\3\:RN VSS) capacitor c=5.01044e-17
C53 (\6\:qbint VSS) capacitor c=3.62744e-17
C54 (\4\:qbint VSS) capacitor c=2.54035e-17
C55 (\3\:qint VSS) capacitor c=3.73312e-17
C56 (\2\:CKN VSS) capacitor c=2.07436e-17
C57 (\9\:CKNb VSS) capacitor c=1.86016e-17
C58 (\2\:D VSS) capacitor c=6.49778e-17
C59 (\9\:CKNbb VSS) capacitor c=5.36174e-17
C60 (\6\:CKNb VSS) capacitor c=2.20703e-17
C61 (\6\:CKNbb VSS) capacitor c=5.1891e-17
C62 (\3\:mout VSS) capacitor c=2.06599e-17
C63 (\5\:SN VSS) capacitor c=2.89651e-17
C64 (\2\:n20 VSS) capacitor c=3.93026e-17
C65 (\6\:RNb VSS) capacitor c=2.68447e-17
C66 (\5\:CKNbb VSS) capacitor c=3.68641e-17
C67 (\3\:CKNb VSS) capacitor c=2.58548e-17
C68 (\4\:CKNbb VSS) capacitor c=3.64561e-17
C69 (\2\:CKNbb VSS) capacitor c=2.79e-17
C70 (\3\:RNb VSS) capacitor c=2.81498e-17
C71 (\10\:qbint VSS) capacitor c=2.44619e-17
C72 (\2\:SN VSS) capacitor c=3.36773e-17
C73 (\2\:n35 VSS) capacitor c=2.87359e-17
C74 (\2\:RN VSS) capacitor c=4.32981e-17
C75 (\5\:qbint VSS) capacitor c=3.92281e-17
C76 (\2\:qint VSS) capacitor c=2.64055e-17
C77 (\1\:VDD VSS) capacitor c=3.78214e-17
C78 (\10\:CKNb VSS) capacitor c=1.1221e-16
C79 (\12\:CKNbb VSS) capacitor c=2.01052e-17
C80 (\14\:VDD VSS) capacitor c=4.73406e-17
C81 (\8\:n20 VSS) capacitor c=7.36337e-17
C82 (\16\:VDD VSS) capacitor c=1.22765e-17
C83 (\11\:mout VSS) capacitor c=4.33913e-17
C84 (\18\:VDD VSS) capacitor c=3.10725e-17
C85 (\9\:mout VSS) capacitor c=7.4448e-17
C86 (\4\:n35 VSS) capacitor c=4.04372e-17
C87 (\20\:VDD VSS) capacitor c=2.91996e-17
C88 (\3\:n41 VSS) capacitor c=9.59159e-17
C89 (\22\:VDD VSS) capacitor c=1.5608e-17
C90 (\11\:qbint VSS) capacitor c=7.04702e-17
C91 (\9\:RNb VSS) capacitor c=1.30682e-16
C92 (\24\:VDD VSS) capacitor c=3.91137e-17
C93 (\3\:Q VSS) capacitor c=3.96148e-17
C94 (\4\:qint VSS) capacitor c=3.77758e-17
C95 (\26\:VDD VSS) capacitor c=6.20029e-17
C96 (\1\:QN VSS) capacitor c=6.98021e-17
C97 (\3\:VDD VSS) capacitor c=5.24404e-17
C98 (\12\:CKNb VSS) capacitor c=1.18652e-16
C99 (\17\:CKNbb VSS) capacitor c=7.34029e-17
C100 (\4\:n20 VSS) capacitor c=4.33334e-17
C101 (\13\:mout VSS) capacitor c=3.88754e-17
C102 (\3\:n25 VSS) capacitor c=9.0551e-17
C103 (\15\:mout VSS) capacitor c=4.23582e-17
C104 (\8\:n35 VSS) capacitor c=6.34182e-17
C105 (\3\:n40 VSS) capacitor c=8.50744e-17
C106 (\3\:n42 VSS) capacitor c=9.55e-17
C107 (\13\:qbint VSS) capacitor c=5.83639e-17
C108 (\11\:RNb VSS) capacitor c=1.02454e-16
C109 (\1\:Q VSS) capacitor c=8.21704e-17
C110 (\8\:qint VSS) capacitor c=4.18492e-17
C111 (\3\:qbint VSS) capacitor c=2.98071e-17
C112 (\2\:mout VSS) capacitor c=3.34135e-17
C113 (\6\:qint VSS) capacitor c=3.35634e-17
C114 (\7\:qint VSS) capacitor c=3.82394e-17
C115 (\4\:RN VSS) capacitor c=7.39411e-17
C116 (\15\:qbint VSS) capacitor c=1.15914e-16
C117 (\16\:qbint VSS) capacitor c=1.29522e-16
C118 (\17\:qbint VSS) capacitor c=8.23543e-17
C119 (\6\:n35 VSS) capacitor c=1.68817e-16
C120 (\7\:n35 VSS) capacitor c=1.85724e-16
C121 (\10\:CKNbb VSS) capacitor c=7.21042e-17
C122 (\11\:CKNbb VSS) capacitor c=1.25044e-16
C123 (\7\:RNb VSS) capacitor c=1.58533e-16
C124 (\8\:RNb VSS) capacitor c=2.08842e-16
C125 (\7\:SN VSS) capacitor c=2.90016e-16
C126 (\8\:SN VSS) capacitor c=3.89425e-17
C127 (\5\:mout VSS) capacitor c=4.4258e-17
C128 (\6\:mout VSS) capacitor c=5.00409e-17
C129 (\7\:mout VSS) capacitor c=5.5912e-17
C130 (\8\:mout VSS) capacitor c=6.98796e-17
C131 (\6\:n20 VSS) capacitor c=9.59323e-17
C132 (\7\:n20 VSS) capacitor c=7.06673e-17
C133 (\14\:CKNbb VSS) capacitor c=6.57435e-17
C134 (\15\:CKNbb VSS) capacitor c=1.46828e-16
C135 (\16\:CKNbb VSS) capacitor c=2.53577e-16
C136 (\19\:CKNbb VSS) capacitor c=3.08784e-17
C137 (\20\:CKNbb VSS) capacitor c=3.91699e-17
C138 (\14\:CKNb VSS) capacitor c=7.53557e-17
C139 (\15\:CKNb VSS) capacitor c=1.41752e-16
C140 (\16\:CKNb VSS) capacitor c=1.34193e-16
C141 (\5\:VDD VSS) capacitor c=2.85016e-17
C142 (\6\:VDD VSS) capacitor c=1.93013e-17
C143 (\8\:VDD VSS) capacitor c=3.58515e-17
C144 (\9\:VDD VSS) capacitor c=3.30826e-17
C145 (\10\:VDD VSS) capacitor c=1.83091e-17
C146 (\12\:VDD VSS) capacitor c=1.90476e-17
C147 (\13\:VDD VSS) capacitor c=1.04661e-17
Rk8 (RN \4\:RN) resistor r=0.03453 c=0
Rk1 (\2\:QN QN) resistor r=0.3779 c=0
Rk2 (QN \4\:QN) resistor r=0.002835 c=0
Rk36 (D \4\:D) resistor r=0.007525 c=0
Rk6 (Q \2\:Q) resistor r=0.4289 c=0
Rk7 (Q \4\:Q) resistor r=0.07434 c=0
Rk48 (\2\:VDD \4\:VDD) resistor r=0.3974 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.281 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.3963 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.07513 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.2775 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.4355 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.2924 c=0
Rk55 (\10\:VDD \11\:VDD) resistor r=0.1947 c=0
Rk56 (\11\:VDD \12\:VDD) resistor r=0.1429 c=0
Rk58 (\13\:VDD VDD) resistor r=0.1025 c=0
Rk57 (\12\:VDD \13\:VDD) resistor r=0.3059 c=0
Rk59 (\5\:VDD \15\:VDD) resistor r=0.2878 c=0
Rk60 (\6\:VDD \17\:VDD) resistor r=0.07476 c=0
Rk61 (\8\:VDD \19\:VDD) resistor r=0.04338 c=0
Rk62 (\9\:VDD \21\:VDD) resistor r=0.1036 c=0
Rk63 (\10\:VDD \23\:VDD) resistor r=0.04338 c=0
Rk64 (\12\:VDD \25\:VDD) resistor r=0.2746 c=0
Rk65 (\13\:VDD \27\:VDD) resistor r=0.44 c=0
Rk24 (\7\:SN SN) resistor r=1.9301 c=0
Rk25 (SN \8\:SN) resistor r=0.04356 c=0
Rk66 (\2\:VSS \4\:VSS) resistor r=0.4075 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.281 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.3954 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.07418 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=1.0082 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.1947 c=0
Rk72 (\9\:VSS \10\:VSS) resistor r=0.1429 c=0
Rk74 (\11\:VSS VSS) resistor r=0.1025 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.3059 c=0
Rk75 (\5\:VSS \13\:VSS) resistor r=0.07476 c=0
Rk76 (\6\:VSS \15\:VSS) resistor r=0.04338 c=0
Rk77 (\8\:VSS \17\:VSS) resistor r=0.04338 c=0
Rk78 (\10\:VSS \19\:VSS) resistor r=0.3419 c=0
Rk79 (\11\:VSS \21\:VSS) resistor r=0.3844 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1153 c=0
Rk4 (\6\:qint \7\:qint) resistor r=0.1291 c=0
Rk5 (\6\:qint \9\:qint) resistor r=0.1093 c=0
Rk9 (\12\:qbint \14\:qbint) resistor r=0.3691 c=0
Rk10 (\14\:qbint \15\:qbint) resistor r=0.1151 c=0
Rk11 (\15\:qbint \16\:qbint) resistor r=0.7243 c=0
Rk12 (\15\:qbint \17\:qbint) resistor r=0.3637 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=0.9657 c=0
Rk21 (\8\:RNb \10\:RNb) resistor r=0.7251 c=0
Rk22 (\10\:RNb \12\:RNb) resistor r=0.5107 c=0
Rk16 (\5\:n35 \6\:n35) resistor r=0.1257 c=0
Rk17 (\6\:n35 \7\:n35) resistor r=1.1889 c=0
Rk18 (\6\:n35 \9\:n35) resistor r=0.2867 c=0
Rk13 (\2\:n42 \4\:n42) resistor r=0.4286 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=0.5071 c=0
Rk19 (\10\:CKNbb \11\:CKNbb) resistor r=0.5711 c=0
Rk37 (\13\:CKNbb \14\:CKNbb) resistor r=0.07809 c=0
Rk38 (\14\:CKNbb \15\:CKNbb) resistor r=0.254 c=0
Rk39 (\15\:CKNbb \16\:CKNbb) resistor r=1.4769 c=0
Rk40 (\14\:CKNbb \18\:CKNbb) resistor r=0.3983 c=0
Rk41 (\15\:CKNbb \19\:CKNbb) resistor r=0.1667 c=0
Rk42 (\19\:CKNbb \20\:CKNbb) resistor r=0.1701 c=0
Rk26 (\5\:mout \6\:mout) resistor r=0.2543 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.2923 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.2401 c=0
Rk29 (\8\:mout \10\:mout) resistor r=0.2616 c=0
Rk30 (\6\:mout \12\:mout) resistor r=0.0876 c=0
Rk31 (\7\:mout \14\:mout) resistor r=0.1206 c=0
Rk32 (\8\:mout \16\:mout) resistor r=0.133 c=0
Rk43 (\11\:CKNb \13\:CKNb) resistor r=0.5735 c=0
Rk44 (\13\:CKNb \14\:CKNb) resistor r=0.3472 c=0
Rk45 (\14\:CKNb \15\:CKNb) resistor r=0.3974 c=0
Rk46 (\15\:CKNb \16\:CKNb) resistor r=0.9578 c=0
Rk23 (\2\:n25 \4\:n25) resistor r=0.5661 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.2999 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3682 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.4464 c=0
Rk15 (\2\:n41 \4\:n41) resistor r=0.502 c=0
Rl9 (\1\:RN \2\:RN) resistor r=96.8456 c=0
Rl10 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl41 (\1\:CKN \2\:CKN) resistor r=87.2302 c=0
Rl42 (\2\:CKN \3\:CKN) resistor r=39.1533 c=0
Rl38 (\2\:D \3\:D) resistor r=125.722 c=0
Rl37 (\1\:D \2\:D) resistor r=43.7849 c=0
Rl29 (\4\:SN \6\:SN) resistor r=140.385 c=0
Rl28 (\4\:SN \5\:SN) resistor r=73.7687 c=0
Rl13 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl14 (\2\:SN \3\:SN) resistor r=69.9225 c=0
Rl1 (qint \2\:qint) resistor r=37.6944 c=0
Rl2 (\2\:qint \3\:qint) resistor r=26.1559 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=125.584 c=0
Rl16 (\9\:qbint \10\:qbint) resistor r=56.9251 c=0
Rl7 (\5\:qbint \6\:qbint) resistor r=24.848 c=0
Rl3 (qbint \2\:qbint) resistor r=81.4873 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=11.259 c=0
Rl8 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=133.209 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=140.385 c=0
Rl17 (RNb \2\:RNb) resistor r=132.258 c=0
Rl25 (\4\:RNb \6\:RNb) resistor r=72.3097 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=94.48 c=0
Rl11 (n35 \2\:n35) resistor r=39.1533 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=71.8456 c=0
Rl36 (\8\:CKNbb \9\:CKNbb) resistor r=79.5379 c=0
Rl33 (\6\:CKNbb \7\:CKNbb) resistor r=61.4557 c=0
Rl22 (\3\:CKNbb \4\:CKNbb) resistor r=24.2328 c=0
Rl23 (\4\:CKNbb \5\:CKNbb) resistor r=67.7945 c=0
Rl19 (CKNbb \2\:CKNbb) resistor r=24.2328 c=0
Rl30 (mout \2\:mout) resistor r=78.5603 c=0
Rl32 (\2\:mout \4\:mout) resistor r=97.7911 c=0
Rl31 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl39 (\7\:CKNb \8\:CKNb) resistor r=187.381 c=0
Rl34 (\4\:CKNb \5\:CKNb) resistor r=202.895 c=0
Rl20 (CKNb \2\:CKNb) resistor r=170.285 c=0
Rl40 (\8\:CKNb \9\:CKNb) resistor r=46.8456 c=0
Rl35 (\5\:CKNb \6\:CKNb) resistor r=46.8456 c=0
Rl21 (\2\:CKNb \3\:CKNb) resistor r=126.436 c=0
Rl26 (n20 \2\:n20) resistor r=85.7713 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz18 (\3\:VDD \4\:VDD) resistor r=25 c=0
Rz19 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz20 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz23 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz24 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz25 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz26 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz16 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz14 (\15\:mout \16\:mout) resistor r=75 c=0
Rz17 (\12\:CKNb \13\:CKNb) resistor r=75 c=0
Rz11 (n25 \2\:n25) resistor r=75 c=0
Rz12 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz15 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry22 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry23 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\11\:mout \12\:mout) resistor r=62 c=0
Ry13 (\10\:CKNb \11\:CKNb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CKN CKN) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx3 (\5\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \17\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\4\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \19\:CKNbb) resistor r=45 c=0
Rx17 (\6\:CKNbb \20\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx18 (\9\:CKNb \14\:CKNb) resistor r=45 c=0
Rx19 (\6\:CKNb \15\:CKNb) resistor r=45 c=0
Rx20 (\3\:CKNb \16\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \7\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.36635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\1\:Q \6\:qbint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.56154e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn56 (\8\:qint \4\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn22 (\11\:RNb \3\:RN \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.537e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn45 (\13\:qbint \3\:n35 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.39e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.2e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (\3\:n42 \3\:SN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=2.392e-14 ps=1.43e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn52 (\3\:n40 \9\:qbint \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\3\:n40 RNb n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn53 (n40 CKNbb \8\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn40 (\8\:n35 \2\:CKNb \15\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\3\:n25 \5\:RNb \13\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.625e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn32 (\13\:mout \3\:n20 n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn30 (n25 \6\:SN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.195e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn35 (n30 \4\:mout \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.61e-14 ps=1.54e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=9.3e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn36 (\4\:n20 \5\:CKNb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.32e-14 ps=6.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=7.05e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn26 (\4\:n20 \8\:CKNbb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=5e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn25 (n21 \1\:D \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.305e-14 ps=1.54e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=3.65e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn21 (\17\:CKNbb \8\:CKNb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.33e-14 ad=2.03e-14 ps=1.54e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn20 (\12\:CKNb \3\:CKN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mp56 (\4\:qint \7\:qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=49.4198 \
        scb=0.0326741 scc=0.00592591 m=(1)
mp22 (\9\:RNb \1\:RN \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.762e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp45 (\11\:qbint n35 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.99186e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp50 (\3\:n41 \1\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=4.3e-14 ps=1.9e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.62442e-07 sb=5.2e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.07442e-07 sb=2.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n43 \2\:RNb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.835e-14 ad=1.29e-14 ps=1.8e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12442e-07 sb=1.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (n41 CKNb \4\:n35 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp40 (\4\:n35 \3\:CKNbb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp31 (n26 \4\:RNb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=3.87e-14 ps=1.63e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=1.02535e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp32 (\11\:mout n20 n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=8.00349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\11\:mout \4\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.965e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=5.95349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp35 (n31 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.965e-14 ad=1.827e-14 ps=1.71e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.72326e-07 sb=9e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp36 (\8\:n20 \7\:CKNbb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.02326e-07 sb=7.7e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp26 (\8\:n20 \4\:CKNb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.07326e-07 sb=5.65e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp25 (n22 \3\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02733e-06 sb=3.45e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp21 (\12\:CKNbb \7\:CKNb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23233e-06 sb=1.4e-07 sd=160n sca=12.0329 \
        scb=0.00996522 scc=0.000239356 m=(1)
mp20 (\10\:CKNb \1\:CKN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5355 \
        scb=0.0237969 scc=0.00114597 m=(1)
ends DFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:23 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFNSRX2
// View name: extracted

simulator lang=spectre

subckt DFFNSRX2 CKN D Q QN RN SN VDD VSS
mp20 (\21\:CKNb \3\:CKN \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.623e-14 ad=3.762e-14 ps=8.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=7.91512e-07 sd=160n sca=17.7347 \
        scb=0.018547 scc=0.000439635 m=(1)
mp25 (n22 \1\:D \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=1.29e-14 ps=8.6e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=5.31512e-07 sd=160n sca=12.132 \
        scb=0.00915419 scc=0.000101757 m=(1)
mp26 (\5\:n20 CKNb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.56e-14 ps=5.5e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=4.26512e-07 sd=160n sca=11.3905 \
        scb=0.00832609 scc=9.89279e-05 m=(1)
mp36 (\5\:n20 CKNbb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=5.56e-14 ps=8.1e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.4093e-07 sb=3.35e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp35 (n31 mout \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=4.085e-14 ps=1.9e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7593e-07 sb=1e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\8\:CKNbb \5\:CKNb \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.64e-14 ad=2.63e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (n26 RNb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=1.29e-14 ps=2.03e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26744e-07 sb=1.335e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\8\:mout \2\:n20 n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=9.352e-14 ps=5.5e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.31744e-07 sb=1.23e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout \5\:SN \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0787e-13 ad=9.352e-14 ps=2.33e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.11744e-07 sb=7.5e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \1\:RN \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0787e-13 ad=8.385e-14 ps=2.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07174e-06 sb=3.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\8\:n35 \5\:CKNbb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.16e-14 ad=3.762e-14 ps=9.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4e-07 sb=3.6e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp53 (\3\:n41 \12\:CKNb \8\:n35 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp50 (n41 \1\:SN \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.82e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95349e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp52 (n41 \2\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.82e-14 ps=5.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36744e-07 sb=2.45e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp51 (n43 \6\:RNb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41744e-07 sb=1.4e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp56 (\8\:qint \10\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.265e-14 ad=3.01e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39791e-06 sb=1.4e-07 sd=160n sca=38.5216 \
        scb=0.0409143 scc=0.00421269 m=(1)
C1 (RN VSS) capacitor c=5.53921e-17
C2 (SN VSS) capacitor c=6.58946e-17
C3 (Q VSS) capacitor c=8.03058e-17
C4 (D VSS) capacitor c=1.30294e-16
C5 (VDD VSS) capacitor c=5.06068e-16
C6 (CKNb VSS) capacitor c=5.84931e-17
C7 (n21 VSS) capacitor c=1.43231e-18
C8 (n20 VSS) capacitor c=7.29424e-17
C9 (CKNbb VSS) capacitor c=3.85365e-17
C10 (n30 VSS) capacitor c=3.43925e-19
C11 (mout VSS) capacitor c=8.14009e-17
C12 (RNb VSS) capacitor c=9.15604e-17
C13 (n25 VSS) capacitor c=8.04936e-17
C14 (n35 VSS) capacitor c=4.64585e-17
C15 (n40 VSS) capacitor c=1.4395e-16
C16 (n42 VSS) capacitor c=7.18668e-17
C17 (qbint VSS) capacitor c=3.90678e-17
C18 (qint VSS) capacitor c=1.70267e-16
C19 (n31 VSS) capacitor c=5.58581e-18
C20 (n26 VSS) capacitor c=8.08912e-19
C21 (n41 VSS) capacitor c=9.89377e-17
C22 (n43 VSS) capacitor c=6.39224e-19
C23 (\10\:qbint VSS) capacitor c=3.21071e-17
C24 (\4\:qbint VSS) capacitor c=4.27602e-16
C25 (\3\:n35 VSS) capacitor c=3.95971e-17
C26 (\6\:RNb VSS) capacitor c=7.55507e-17
C27 (\2\:qbint VSS) capacitor c=1.06539e-16
C28 (\1\:SN VSS) capacitor c=7.33641e-17
C29 (\12\:CKNb VSS) capacitor c=5.16436e-17
C30 (\5\:CKNbb VSS) capacitor c=6.91466e-17
C31 (\1\:RN VSS) capacitor c=3.22101e-17
C32 (\5\:SN VSS) capacitor c=3.55731e-17
C33 (\2\:n20 VSS) capacitor c=7.47943e-17
C34 (\5\:CKNb VSS) capacitor c=4.41467e-17
C35 (\1\:D VSS) capacitor c=6.09618e-17
C36 (\3\:CKN VSS) capacitor c=3.97429e-17
C37 (\12\:qbint VSS) capacitor c=3.85797e-17
C38 (\4\:RNb VSS) capacitor c=3.62288e-17
C39 (\3\:qbint VSS) capacitor c=7.18306e-17
C40 (\2\:SN VSS) capacitor c=1.39318e-16
C41 (\4\:CKNbb VSS) capacitor c=6.41462e-17
C42 (\10\:CKNb VSS) capacitor c=4.83774e-17
C43 (\3\:RN VSS) capacitor c=4.22415e-17
C44 (\3\:SN VSS) capacitor c=1.23752e-16
C45 (\2\:RNb VSS) capacitor c=6.33633e-17
C46 (\8\:CKNb VSS) capacitor c=3.42316e-17
C47 (\2\:mout VSS) capacitor c=6.76619e-17
C48 (\3\:CKNb VSS) capacitor c=3.95232e-17
C49 (\3\:CKNbb VSS) capacitor c=6.36444e-17
C50 (\3\:D VSS) capacitor c=5.67103e-17
C51 (\1\:CKN VSS) capacitor c=3.82514e-17
C52 (\11\:qbint VSS) capacitor c=4.52827e-17
C53 (\2\:n35 VSS) capacitor c=3.03916e-17
C54 (\5\:RNb VSS) capacitor c=5.74835e-17
C55 (\13\:CKNb VSS) capacitor c=2.45863e-17
C56 (\6\:CKNbb VSS) capacitor c=2.82333e-17
C57 (\11\:CKNb VSS) capacitor c=3.78582e-17
C58 (\2\:RN VSS) capacitor c=2.48899e-17
C59 (\4\:SN VSS) capacitor c=2.70435e-17
C60 (\3\:RNb VSS) capacitor c=5.08577e-17
C61 (\3\:n20 VSS) capacitor c=3.5697e-17
C62 (\9\:CKNb VSS) capacitor c=3.42444e-17
C63 (\7\:CKNb VSS) capacitor c=3.56247e-17
C64 (\3\:mout VSS) capacitor c=2.36312e-17
C65 (\2\:CKNbb VSS) capacitor c=7.13222e-17
C66 (\4\:CKNb VSS) capacitor c=4.3236e-17
C67 (\2\:CKNb VSS) capacitor c=4.78174e-17
C68 (\2\:D VSS) capacitor c=6.5676e-17
C69 (\2\:CKN VSS) capacitor c=4.88122e-17
C70 (\8\:qint VSS) capacitor c=3.91601e-17
C71 (\1\:VDD VSS) capacitor c=1.29353e-16
C72 (\3\:QN VSS) capacitor c=7.84875e-17
C73 (\1\:Q VSS) capacitor c=8.43872e-18
C74 (\16\:qbint VSS) capacitor c=5.81988e-17
C75 (\19\:VDD VSS) capacitor c=6.03378e-17
C76 (\21\:VDD VSS) capacitor c=3.34396e-17
C77 (\3\:n41 VSS) capacitor c=7.58517e-17
C78 (\8\:n35 VSS) capacitor c=3.51489e-17
C79 (\4\:mout VSS) capacitor c=2.47702e-18
C80 (\11\:RNb VSS) capacitor c=9.69723e-17
C81 (\23\:VDD VSS) capacitor c=2.9639e-17
C82 (\8\:mout VSS) capacitor c=1.73059e-16
C83 (\25\:VDD VSS) capacitor c=1.62697e-17
C84 (\8\:CKNbb VSS) capacitor c=1.94646e-16
C85 (\27\:VDD VSS) capacitor c=1.97035e-17
C86 (\5\:n20 VSS) capacitor c=1.32534e-16
C87 (\29\:VDD VSS) capacitor c=1.97139e-17
C88 (\21\:CKNb VSS) capacitor c=6.0785e-17
C89 (\4\:VDD VSS) capacitor c=1.07637e-16
C90 (\12\:qint VSS) capacitor c=1.75358e-17
C91 (\1\:QN VSS) capacitor c=5.05913e-17
C92 (\3\:Q VSS) capacitor c=5.80888e-17
C93 (\20\:qbint VSS) capacitor c=4.19853e-17
C94 (\3\:n40 VSS) capacitor c=1.32942e-16
C95 (\3\:n42 VSS) capacitor c=1.02841e-16
C96 (\6\:n35 VSS) capacitor c=5.35916e-17
C97 (\6\:mout VSS) capacitor c=6.21026e-17
C98 (\8\:RNb VSS) capacitor c=2.20997e-16
C99 (\3\:n25 VSS) capacitor c=7.4982e-17
C100 (\11\:mout VSS) capacitor c=3.27292e-17
C101 (\11\:CKNbb VSS) capacitor c=4.4282e-17
C102 (\7\:n20 VSS) capacitor c=1.18488e-16
C103 (\18\:CKNb VSS) capacitor c=2.96637e-17
C104 (\4\:CKN VSS) capacitor c=1.27279e-16
C105 (\14\:CKNb VSS) capacitor c=4.0607e-17
C106 (\15\:CKNb VSS) capacitor c=1.14499e-16
C107 (\16\:CKNb VSS) capacitor c=1.56146e-16
C108 (\17\:CKNb VSS) capacitor c=7.00771e-17
C109 (\20\:CKNb VSS) capacitor c=7.14673e-17
C110 (\4\:n20 VSS) capacitor c=9.18974e-17
C111 (\6\:SN VSS) capacitor c=3.9775e-17
C112 (\4\:RN VSS) capacitor c=5.38759e-17
C113 (\5\:mout VSS) capacitor c=1.67888e-16
C114 (\10\:mout VSS) capacitor c=1.48497e-16
C115 (\13\:mout VSS) capacitor c=1.08118e-16
C116 (\7\:CKNbb VSS) capacitor c=2.61332e-16
C117 (\10\:CKNbb VSS) capacitor c=4.76074e-17
C118 (\13\:CKNbb VSS) capacitor c=5.6063e-17
C119 (\23\:CKNb VSS) capacitor c=8.53244e-17
C120 (\24\:CKNb VSS) capacitor c=3.08787e-16
C121 (\25\:CKNb VSS) capacitor c=2.20318e-16
C122 (\26\:CKNb VSS) capacitor c=3.29617e-17
C123 (\7\:RNb VSS) capacitor c=2.89355e-16
C124 (\10\:RNb VSS) capacitor c=9.63975e-17
C125 (\4\:n35 VSS) capacitor c=1.41738e-16
C126 (\5\:n35 VSS) capacitor c=2.0602e-16
C127 (\13\:qbint VSS) capacitor c=9.87196e-17
C128 (\22\:qbint VSS) capacitor c=4.26502e-17
C129 (\10\:qint VSS) capacitor c=3.93407e-17
C130 (\11\:qint VSS) capacitor c=6.22541e-17
C131 (\7\:VDD VSS) capacitor c=3.41021e-17
C132 (\8\:VDD VSS) capacitor c=1.60875e-17
C133 (\10\:VDD VSS) capacitor c=4.83403e-17
C134 (\11\:VDD VSS) capacitor c=2.88598e-17
C135 (\12\:VDD VSS) capacitor c=7.82666e-18
C136 (\14\:VDD VSS) capacitor c=2.45043e-17
Rk13 (RN \4\:RN) resistor r=0.03585 c=0
Rk1 (\4\:CKN CKN) resistor r=0.002711 c=0
Rk12 (SN \6\:SN) resistor r=0.1632 c=0
Rk35 (Q \2\:Q) resistor r=0.003006 c=0
Rk36 (\2\:Q \4\:Q) resistor r=0.2645 c=0
Rk2 (\4\:D D) resistor r=0.0029 c=0
Rk38 (\4\:QN QN) resistor r=0.005081 c=0
Rk37 (\2\:QN \4\:QN) resistor r=0.2978 c=0
Rk72 (\1\:VSS \7\:VSS) resistor r=0.6594 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.3711 c=0
Rk74 (\8\:VSS \9\:VSS) resistor r=0.4137 c=0
Rk75 (\9\:VSS \10\:VSS) resistor r=0.6785 c=0
Rk76 (\10\:VSS \11\:VSS) resistor r=0.1092 c=0
Rk78 (\12\:VSS VSS) resistor r=0.1727 c=0
Rk77 (\11\:VSS \12\:VSS) resistor r=0.3786 c=0
Rk81 (\7\:VSS \18\:VSS) resistor r=0.2722 c=0
Rk82 (\9\:VSS \20\:VSS) resistor r=0.1737 c=0
Rk83 (\10\:VSS \22\:VSS) resistor r=0.04333 c=0
Rk84 (\12\:VSS \24\:VSS) resistor r=0.2952 c=0
Rk52 (\1\:VDD \7\:VDD) resistor r=0.3759 c=0
Rk53 (\7\:VDD \8\:VDD) resistor r=0.1827 c=0
Rk54 (\8\:VDD \9\:VDD) resistor r=0.4288 c=0
Rk55 (\9\:VDD \10\:VDD) resistor r=0.5006 c=0
Rk56 (\10\:VDD \11\:VDD) resistor r=0.4226 c=0
Rk57 (\11\:VDD \12\:VDD) resistor r=0.1928 c=0
Rk58 (\12\:VDD \13\:VDD) resistor r=0.0851 c=0
Rk60 (\14\:VDD VDD) resistor r=0.1451 c=0
Rk59 (\13\:VDD \14\:VDD) resistor r=0.4062 c=0
Rk63 (\7\:VDD \20\:VDD) resistor r=0.4015 c=0
Rk64 (\8\:VDD \22\:VDD) resistor r=0.2585 c=0
Rk65 (\10\:VDD \24\:VDD) resistor r=0.04333 c=0
Rk66 (\11\:VDD \26\:VDD) resistor r=0.07416 c=0
Rk67 (\12\:VDD \28\:VDD) resistor r=0.07416 c=0
Rk68 (\14\:VDD \30\:VDD) resistor r=0.1747 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.2532 c=0
Rk4 (\15\:CKNb \16\:CKNb) resistor r=0.8373 c=0
Rk5 (\16\:CKNb \17\:CKNb) resistor r=0.3708 c=0
Rk6 (\17\:CKNb \19\:CKNb) resistor r=0.1911 c=0
Rk7 (\16\:CKNb \20\:CKNb) resistor r=0.3358 c=0
Rk8 (\17\:CKNb \22\:CKNb) resistor r=0.5023 c=0
Rk23 (\23\:CKNb \24\:CKNb) resistor r=0.3797 c=0
Rk24 (\24\:CKNb \25\:CKNb) resistor r=1.8534 c=0
Rk25 (\24\:CKNb \26\:CKNb) resistor r=0.2116 c=0
Rk9 (\4\:n20 \6\:n20) resistor r=0.7465 c=0
Rk10 (\6\:n20 \8\:n20) resistor r=0.5912 c=0
Rk19 (\7\:CKNbb \9\:CKNbb) resistor r=1.8706 c=0
Rk20 (\9\:CKNbb \10\:CKNbb) resistor r=0.06271 c=0
Rk21 (\10\:CKNbb \12\:CKNbb) resistor r=0.2429 c=0
Rk22 (\10\:CKNbb \13\:CKNbb) resistor r=0.3536 c=0
Rk14 (\5\:mout \7\:mout) resistor r=0.3793 c=0
Rk15 (\5\:mout \9\:mout) resistor r=0.852 c=0
Rk16 (\9\:mout \10\:mout) resistor r=0.5887 c=0
Rk17 (\10\:mout \12\:mout) resistor r=0.09812 c=0
Rk18 (\10\:mout \13\:mout) resistor r=0.8499 c=0
Rk28 (\7\:RNb \9\:RNb) resistor r=1.8196 c=0
Rk29 (\9\:RNb \10\:RNb) resistor r=0.6065 c=0
Rk30 (\9\:RNb \12\:RNb) resistor r=0.5393 c=0
Rk11 (\2\:n25 \4\:n25) resistor r=0.4979 c=0
Rk32 (\4\:n35 \5\:n35) resistor r=1.189 c=0
Rk33 (\5\:n35 \7\:n35) resistor r=0.2576 c=0
Rk34 (\5\:n35 \9\:n35) resistor r=0.118 c=0
Rk27 (\2\:n40 \4\:n40) resistor r=0.8739 c=0
Rk31 (\2\:n42 \4\:n42) resistor r=0.3869 c=0
Rk39 (\13\:qbint \4\:qbint) resistor r=0.7617 c=0
Rk41 (\4\:qbint \17\:qbint) resistor r=0.2921 c=0
Rk44 (\4\:qbint \21\:qbint) resistor r=0.3257 c=0
Rk45 (\17\:qbint \22\:qbint) resistor r=0.343 c=0
Rk46 (\9\:qint \10\:qint) resistor r=0.2699 c=0
Rk47 (\10\:qint \11\:qint) resistor r=0.28 c=0
Rk48 (\10\:qint \13\:qint) resistor r=0.1152 c=0
Rk26 (\2\:n41 \4\:n41) resistor r=0.4249 c=0
Rl19 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl20 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl2 (\2\:CKN \3\:CKN) resistor r=147.253 c=0
Rl1 (\1\:CKN \2\:CKN) resistor r=105.769 c=0
Rl25 (\1\:SN \2\:SN) resistor r=242.308 c=0
Rl26 (\2\:SN \3\:SN) resistor r=899.566 c=0
Rl28 (\4\:SN \5\:SN) resistor r=87.6944 c=0
Rl27 (\3\:SN \4\:SN) resistor r=37.6944 c=0
Rl3 (\1\:D \2\:D) resistor r=73.7687 c=0
Rl4 (\2\:D \3\:D) resistor r=177.615 c=0
Rl22 (\12\:CKNb \13\:CKNb) resistor r=47.3097 c=0
Rl21 (\10\:CKNb \11\:CKNb) resistor r=31.9251 c=0
Rl8 (\3\:CKNb \4\:CKNb) resistor r=74.2328 c=0
Rl5 (CKNb \2\:CKNb) resistor r=66.5405 c=0
Rl11 (\5\:CKNb \6\:CKNb) resistor r=43.0526 c=0
Rl13 (\6\:CKNb \8\:CKNb) resistor r=39.2065 c=0
Rl14 (\6\:CKNb \9\:CKNb) resistor r=118.861 c=0
Rl12 (\6\:CKNb \7\:CKNb) resistor r=4.4327 c=0
Rl15 (n20 \2\:n20) resistor r=174.566 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=96.8466 c=0
Rl23 (\4\:CKNbb \5\:CKNbb) resistor r=183.747 c=0
Rl24 (\5\:CKNbb \6\:CKNbb) resistor r=68.4636 c=0
Rl6 (CKNbb \2\:CKNbb) resistor r=70.3867 c=0
Rl7 (\2\:CKNbb \3\:CKNbb) resistor r=232.246 c=0
Rl9 (mout \2\:mout) resistor r=240.385 c=0
Rl10 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl17 (RNb \2\:RNb) resistor r=153.846 c=0
Rl30 (\5\:RNb \6\:RNb) resistor r=93.4636 c=0
Rl29 (\4\:RNb \5\:RNb) resistor r=99.8423 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=228.823 c=0
Rl34 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl33 (n35 \2\:n35) resistor r=104.806 c=0
Rl32 (\3\:qbint \2\:qbint) resistor r=205.769 c=0
Rl45 (\11\:qbint \10\:qbint) resistor r=33.9954 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=95.9489 c=0
Rl31 (qbint \2\:qbint) resistor r=151.436 c=0
Rz14 (\4\:Q \3\:Q) resistor r=75 c=0
Rz15 (\2\:QN \1\:QN) resistor r=75 c=0
Rz24 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz25 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz26 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz18 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz19 (\9\:VDD \4\:VDD) resistor r=6.25 c=0
Rz20 (\13\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz7 (\11\:CKNbb \12\:CKNbb) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:mout \12\:mout) resistor r=75 c=0
Rz10 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz3 (n25 \2\:n25) resistor r=75 c=0
Rz4 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz8 (n40 \2\:n40) resistor r=75 c=0
Rz9 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (n42 \2\:n42) resistor r=75 c=0
Rz12 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz16 (\21\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\13\:qint \12\:qint) resistor r=75 c=0
Ry10 (\2\:Q \1\:Q) resistor r=62 c=0
Ry11 (\4\:QN \3\:QN) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry24 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry25 (\11\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry22 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry1 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry2 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry13 (\9\:qint \8\:qint) resistor r=62 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx7 (\4\:SN \6\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\7\:CKNb \14\:CKNb) resistor r=45 c=0
Rx4 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx5 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx12 (\11\:CKNb \23\:CKNb) resistor r=45 c=0
Rx13 (\9\:CKNb \25\:CKNb) resistor r=45 c=0
Rx14 (\13\:CKNb \26\:CKNb) resistor r=45 c=0
Rx6 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx11 (\2\:CKNbb \13\:CKNbb) resistor r=45 c=0
Rx9 (\3\:mout \13\:mout) resistor r=45 c=0
Rx15 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx16 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\2\:n35 \4\:n35) resistor r=45 c=0
Rx18 (\13\:qbint \11\:qbint) resistor r=45 c=0
Rx21 (\22\:qbint qbint) resistor r=45 c=0
Rx22 (\11\:qint qint) resistor r=45 c=0
mn20 (\18\:CKNb \1\:CKN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04362e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn25 (n21 \3\:D \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.38621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn26 (\7\:n20 \3\:CKNbb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=6.38621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn36 (\7\:n20 \3\:CKNb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=3.045e-14 ps=6.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=3.83621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn35 (n30 \2\:mout \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.79e-14 ad=2.755e-14 ps=1.7e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.48621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn21 (\11\:CKNbb \8\:CKNb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.79e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.33793e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (n25 \2\:RNb \11\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.085e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn32 (\11\:mout n20 \3\:n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.8e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn30 (\3\:n25 \3\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=4.857e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=5e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn22 (\8\:RNb \3\:RN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=2.03e-14 ps=1.18e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn40 (\6\:n35 \10\:CKNb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.407e-14 ad=2.61e-14 ps=7.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn53 (n40 \4\:CKNbb \6\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=3.697e-14 ps=6.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (\3\:n42 \2\:SN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.275e-14 ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.17586e-07 sb=5.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn52 (\3\:n40 \3\:qbint \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.22586e-07 sb=3.5e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn51 (\3\:n40 \4\:RNb n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.32586e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn56 (\12\:qint \12\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.122e-14 ad=2.03e-14 ps=9.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25207e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn45 (\20\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18232e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\3\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=5.98e-14 ps=9.05e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.93173e-07 sb=1.01173e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.986e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.38173e-07 sb=4.66731e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp45 (\16\:qbint \3\:n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.3095e-13 ad=4.34e-14 ps=2e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30629e-06 sd=160n sca=15.1875 \
        scb=0.0142433 scc=0.000935749 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.4243e-13 ad=8.97e-14 ps=2.035e-06 pd=1.24e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.67692e-07 sb=9.99936e-07 sd=160n \
        sca=28.7024 scb=0.0198217 scc=0.00315848 m=(2)
mp57_1__rcx (\3\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.1327e-13 ad=6.24e-14 ps=1.935e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.33077e-07 sb=4.34551e-07 sd=160n sca=20.2826 \
        scb=0.0171335 scc=0.00171662 m=(2)
ends DFFNSRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:24 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFNSRX4
// View name: extracted

simulator lang=spectre

subckt DFFNSRX4 CKN D Q QN RN SN VDD VSS
mp20 (\21\:CKNb \1\:CKN \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06058e-06 sd=160n sca=16.2774 \
        scb=0.0161284 scc=0.000285108 m=(1)
mp25 (n22 \1\:D \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.55581e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp26 (\5\:n20 CKNb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.50581e-07 sd=160n sca=11.5061 \
        scb=0.00843398 scc=9.91415e-05 m=(1)
mp36 (\5\:n20 CKNbb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=6.558e-14 ps=6.7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=4.00581e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp35 (n31 \3\:mout \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.075e-14 ad=2.58e-14 ps=1.48e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=2.35581e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\8\:CKNbb \8\:CKNb \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.075e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.51163e-07 sb=1.4e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp31 (n26 RNb \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.717e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.225e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\7\:mout n20 n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=9.997e-14 ps=7.5e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.02e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\7\:mout \6\:SN \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.9633e-13 ad=9.997e-14 ps=2.79e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.1e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \3\:RN \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.9633e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\11\:n35 \5\:CKNbb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.482e-14 ad=3.762e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.6e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp53 (\3\:n41 \12\:CKNb \11\:n35 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp51 (n43 \4\:RNb \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp52 (n41 qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp50 (n41 \1\:SN \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.605e-14 ad=3.44e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
C1 (RN VSS) capacitor c=5.16842e-17
C2 (Q VSS) capacitor c=1.51797e-16
C3 (CKN VSS) capacitor c=1.2956e-16
C4 (SN VSS) capacitor c=6.96501e-17
C5 (QN VSS) capacitor c=3.01073e-17
C6 (VDD VSS) capacitor c=5.46246e-16
C7 (D VSS) capacitor c=6.84392e-17
C8 (CKNb VSS) capacitor c=5.5887e-17
C9 (n21 VSS) capacitor c=1.49022e-18
C10 (n20 VSS) capacitor c=4.20656e-17
C11 (CKNbb VSS) capacitor c=4.53976e-17
C12 (n30 VSS) capacitor c=2.25577e-18
C13 (mout VSS) capacitor c=2.25551e-17
C14 (RNb VSS) capacitor c=6.04089e-17
C15 (n25 VSS) capacitor c=7.85399e-17
C16 (n35 VSS) capacitor c=2.10932e-16
C17 (n40 VSS) capacitor c=8.7776e-17
C18 (n42 VSS) capacitor c=7.69556e-17
C19 (qbint VSS) capacitor c=8.37618e-17
C20 (qint VSS) capacitor c=2.91601e-16
C21 (n31 VSS) capacitor c=3.2412e-18
C22 (n26 VSS) capacitor c=3.79228e-18
C23 (n41 VSS) capacitor c=1.00355e-16
C24 (n43 VSS) capacitor c=3.5553e-18
C25 (\21\:qbint VSS) capacitor c=6.12855e-17
C26 (\1\:SN VSS) capacitor c=7.54532e-17
C27 (\4\:RNb VSS) capacitor c=7.77089e-17
C28 (\12\:CKNb VSS) capacitor c=3.78097e-17
C29 (\5\:CKNbb VSS) capacitor c=6.30098e-17
C30 (\3\:RN VSS) capacitor c=3.59287e-17
C31 (\6\:SN VSS) capacitor c=3.61706e-17
C32 (\8\:CKNb VSS) capacitor c=5.59111e-17
C33 (\3\:mout VSS) capacitor c=1.04907e-16
C34 (\1\:D VSS) capacitor c=8.49636e-17
C35 (\1\:CKN VSS) capacitor c=3.83873e-17
C36 (\19\:qbint VSS) capacitor c=2.52012e-17
C37 (\4\:qbint VSS) capacitor c=2.77644e-16
C38 (\2\:SN VSS) capacitor c=1.86377e-16
C39 (\3\:qbint VSS) capacitor c=4.02893e-17
C40 (\6\:RNb VSS) capacitor c=4.53755e-17
C41 (\4\:CKNbb VSS) capacitor c=5.81069e-17
C42 (\10\:CKNb VSS) capacitor c=4.58493e-17
C43 (\1\:RN VSS) capacitor c=3.61899e-17
C44 (\3\:SN VSS) capacitor c=1.21446e-16
C45 (\3\:n20 VSS) capacitor c=5.10808e-17
C46 (\2\:RNb VSS) capacitor c=5.51316e-17
C47 (\9\:CKNb VSS) capacitor c=2.73252e-17
C48 (\2\:mout VSS) capacitor c=6.04065e-17
C49 (\3\:CKNb VSS) capacitor c=4.24264e-17
C50 (\3\:CKNbb VSS) capacitor c=6.66442e-17
C51 (\3\:D VSS) capacitor c=4.37858e-17
C52 (\3\:CKN VSS) capacitor c=4.92716e-17
C53 (\20\:qbint VSS) capacitor c=4.0771e-17
C54 (\2\:qbint VSS) capacitor c=7.35416e-17
C55 (\5\:RNb VSS) capacitor c=5.98745e-17
C56 (\13\:CKNb VSS) capacitor c=2.07004e-17
C57 (\6\:CKNbb VSS) capacitor c=2.5683e-17
C58 (\11\:CKNb VSS) capacitor c=3.5483e-17
C59 (\2\:RN VSS) capacitor c=2.82543e-17
C60 (\5\:SN VSS) capacitor c=2.1696e-17
C61 (\3\:RNb VSS) capacitor c=4.87986e-17
C62 (\2\:n20 VSS) capacitor c=3.14601e-17
C63 (\5\:CKNb VSS) capacitor c=2.87904e-17
C64 (\7\:CKNb VSS) capacitor c=3.37838e-17
C65 (\2\:CKNbb VSS) capacitor c=7.49454e-17
C66 (\4\:CKNb VSS) capacitor c=3.43548e-17
C67 (\2\:CKNb VSS) capacitor c=4.73601e-17
C68 (\2\:D VSS) capacitor c=6.78519e-17
C69 (\2\:CKN VSS) capacitor c=5.21289e-17
C70 (\20\:qint VSS) capacitor c=3.89112e-17
C71 (\27\:qbint VSS) capacitor c=7.57821e-17
C72 (\29\:VDD VSS) capacitor c=3.96874e-17
C73 (\3\:n41 VSS) capacitor c=8.43065e-17
C74 (\11\:n35 VSS) capacitor c=3.25335e-17
C75 (\9\:mout VSS) capacitor c=1.50977e-16
C76 (\11\:RNb VSS) capacitor c=6.04462e-17
C77 (\31\:VDD VSS) capacitor c=2.761e-17
C78 (\7\:mout VSS) capacitor c=2.04805e-16
C79 (\33\:VDD VSS) capacitor c=2.20401e-17
C80 (\8\:CKNbb VSS) capacitor c=2.61857e-16
C81 (\35\:VDD VSS) capacitor c=1.88352e-17
C82 (\5\:n20 VSS) capacitor c=1.48896e-16
C83 (\37\:VDD VSS) capacitor c=2.36747e-17
C84 (\21\:CKNb VSS) capacitor c=8.20053e-17
C85 (\1\:VDD VSS) capacitor c=1.23479e-16
C86 (\16\:qint VSS) capacitor c=3.28546e-17
C87 (\1\:QN VSS) capacitor c=1.30638e-16
C88 (\1\:Q VSS) capacitor c=1.34825e-16
C89 (\29\:qbint VSS) capacitor c=2.04513e-17
C90 (\3\:n40 VSS) capacitor c=1.01679e-16
C91 (\3\:n42 VSS) capacitor c=8.26913e-17
C92 (\9\:n35 VSS) capacitor c=6.27579e-17
C93 (\4\:mout VSS) capacitor c=8.81656e-17
C94 (\8\:RNb VSS) capacitor c=2.0983e-16
C95 (\3\:n25 VSS) capacitor c=7.36849e-17
C96 (\12\:mout VSS) capacitor c=3.80576e-17
C97 (\12\:CKNbb VSS) capacitor c=5.71935e-17
C98 (\7\:n20 VSS) capacitor c=1.15363e-16
C99 (\18\:CKNb VSS) capacitor c=1.8583e-17
C100 (\6\:CKNb VSS) capacitor c=2.49861e-17
C101 (\4\:SN VSS) capacitor c=1.78197e-17
C102 (\4\:D VSS) capacitor c=5.4971e-17
C103 (\14\:CKNb VSS) capacitor c=6.55984e-17
C104 (\15\:CKNb VSS) capacitor c=1.22707e-16
C105 (\16\:CKNb VSS) capacitor c=1.39619e-16
C106 (\17\:CKNb VSS) capacitor c=8.63096e-17
C107 (\20\:CKNb VSS) capacitor c=7.42981e-17
C108 (\4\:n20 VSS) capacitor c=1.34978e-16
C109 (\7\:SN VSS) capacitor c=4.48006e-17
C110 (\4\:RN VSS) capacitor c=5.29915e-17
C111 (\11\:mout VSS) capacitor c=1.61848e-16
C112 (\14\:mout VSS) capacitor c=1.11139e-16
C113 (\7\:CKNbb VSS) capacitor c=2.46567e-16
C114 (\10\:CKNbb VSS) capacitor c=6.89268e-17
C115 (\11\:CKNbb VSS) capacitor c=4.63842e-17
C116 (\23\:CKNb VSS) capacitor c=4.42741e-17
C117 (\24\:CKNb VSS) capacitor c=2.9961e-16
C118 (\25\:CKNb VSS) capacitor c=2.45956e-16
C119 (\26\:CKNb VSS) capacitor c=8.30224e-17
C120 (\7\:RNb VSS) capacitor c=2.13241e-16
C121 (\10\:RNb VSS) capacitor c=7.66086e-17
C122 (\7\:n35 VSS) capacitor c=1.33253e-16
C123 (\8\:n35 VSS) capacitor c=1.70216e-16
C124 (\5\:QN VSS) capacitor c=1.84873e-16
C125 (\22\:qbint VSS) capacitor c=2.49521e-16
C126 (\23\:qbint VSS) capacitor c=2.11411e-16
C127 (\24\:qbint VSS) capacitor c=3.03454e-17
C128 (\25\:qbint VSS) capacitor c=5.37865e-17
C129 (\26\:qbint VSS) capacitor c=2.58963e-17
C130 (\31\:qbint VSS) capacitor c=1.22126e-17
C131 (\18\:qint VSS) capacitor c=6.29274e-17
C132 (\19\:qint VSS) capacitor c=4.07628e-17
C133 (\3\:VDD VSS) capacitor c=4.19932e-16
C134 (\10\:VDD VSS) capacitor c=1.91682e-17
C135 (\12\:VDD VSS) capacitor c=4.15346e-17
C136 (\13\:VDD VSS) capacitor c=2.70989e-17
C137 (\14\:VDD VSS) capacitor c=1.41088e-17
C138 (\16\:VDD VSS) capacitor c=2.5034e-17
Rk13 (\4\:RN RN) resistor r=0.1685 c=0
Rk37 (\1\:Q Q) resistor r=0.332 c=0
Rk1 (\4\:CKN CKN) resistor r=0.003008 c=0
Rk12 (\7\:SN SN) resistor r=0.2025 c=0
Rk44 (\5\:QN QN) resistor r=0.1661 c=0
Rk42 (\1\:QN \5\:QN) resistor r=0.2278 c=0
Rk77 (\2\:VDD \3\:VDD) resistor r=0.1754 c=0
Rk84 (\3\:VDD \10\:VDD) resistor r=0.2731 c=0
Rk85 (\10\:VDD \11\:VDD) resistor r=0.4289 c=0
Rk86 (\11\:VDD \12\:VDD) resistor r=0.5408 c=0
Rk87 (\12\:VDD \13\:VDD) resistor r=0.3164 c=0
Rk88 (\13\:VDD \14\:VDD) resistor r=0.3023 c=0
Rk89 (\14\:VDD \15\:VDD) resistor r=0.03995 c=0
Rk91 (\16\:VDD VDD) resistor r=0.1626 c=0
Rk90 (\15\:VDD \16\:VDD) resistor r=0.3887 c=0
Rk98 (\10\:VDD \30\:VDD) resistor r=0.2708 c=0
Rk99 (\12\:VDD \32\:VDD) resistor r=0.04334 c=0
Rk100 (\13\:VDD \34\:VDD) resistor r=0.04334 c=0
Rk101 (\14\:VDD \36\:VDD) resistor r=0.07428 c=0
Rk102 (\16\:VDD \38\:VDD) resistor r=0.1794 c=0
Rk2 (D \4\:D) resistor r=0.1354 c=0
Rk63 (\1\:VSS \10\:VSS) resistor r=0.6798 c=0
Rk64 (\10\:VSS \11\:VSS) resistor r=0.2783 c=0
Rk65 (\11\:VSS \12\:VSS) resistor r=0.8241 c=0
Rk66 (\12\:VSS \13\:VSS) resistor r=0.09922 c=0
Rk68 (\14\:VSS VSS) resistor r=0.1626 c=0
Rk67 (\13\:VSS \14\:VSS) resistor r=0.3887 c=0
Rk74 (\11\:VSS \26\:VSS) resistor r=0.2116 c=0
Rk75 (\12\:VSS \28\:VSS) resistor r=0.04334 c=0
Rk76 (\14\:VSS \30\:VSS) resistor r=0.2803 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.371 c=0
Rk4 (\15\:CKNb \16\:CKNb) resistor r=0.7671 c=0
Rk5 (\16\:CKNb \17\:CKNb) resistor r=0.3137 c=0
Rk6 (\17\:CKNb \19\:CKNb) resistor r=0.09782 c=0
Rk7 (\16\:CKNb \20\:CKNb) resistor r=0.353 c=0
Rk8 (\17\:CKNb \22\:CKNb) resistor r=0.6738 c=0
Rk24 (\23\:CKNb \24\:CKNb) resistor r=0.2922 c=0
Rk25 (\24\:CKNb \25\:CKNb) resistor r=1.7181 c=0
Rk26 (\24\:CKNb \26\:CKNb) resistor r=0.3701 c=0
Rk9 (\4\:n20 \6\:n20) resistor r=0.9248 c=0
Rk10 (\6\:n20 \8\:n20) resistor r=0.6003 c=0
Rk20 (\7\:CKNbb \9\:CKNbb) resistor r=1.8527 c=0
Rk21 (\9\:CKNbb \10\:CKNbb) resistor r=0.1772 c=0
Rk22 (\10\:CKNbb \11\:CKNbb) resistor r=0.3419 c=0
Rk23 (\10\:CKNbb \13\:CKNbb) resistor r=0.2709 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.41 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.6898 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.03277 c=0
Rk17 (\8\:mout \11\:mout) resistor r=0.6101 c=0
Rk18 (\11\:mout \13\:mout) resistor r=0.1176 c=0
Rk19 (\11\:mout \14\:mout) resistor r=0.8773 c=0
Rk27 (\7\:RNb \9\:RNb) resistor r=1.2367 c=0
Rk28 (\9\:RNb \10\:RNb) resistor r=0.7235 c=0
Rk29 (\9\:RNb \12\:RNb) resistor r=0.3666 c=0
Rk11 (\2\:n25 \4\:n25) resistor r=0.3827 c=0
Rk33 (\7\:n35 \8\:n35) resistor r=0.9363 c=0
Rk34 (\8\:n35 \10\:n35) resistor r=0.2846 c=0
Rk35 (\8\:n35 \12\:n35) resistor r=0.06538 c=0
Rk30 (\2\:n40 \4\:n40) resistor r=0.3591 c=0
Rk31 (\2\:n42 \4\:n42) resistor r=0.3827 c=0
Rk47 (\22\:qbint \23\:qbint) resistor r=2.0554 c=0
Rk48 (\23\:qbint \24\:qbint) resistor r=0.07673 c=0
Rk49 (\24\:qbint \25\:qbint) resistor r=0.3144 c=0
Rk50 (\23\:qbint \26\:qbint) resistor r=0.0917 c=0
Rk51 (\26\:qbint \28\:qbint) resistor r=0.3273 c=0
Rk52 (\24\:qbint \30\:qbint) resistor r=0.06407 c=0
Rk53 (\26\:qbint \31\:qbint) resistor r=0.1321 c=0
Rk54 (\17\:qint \18\:qint) resistor r=0.4765 c=0
Rk55 (\18\:qint \19\:qint) resistor r=0.2199 c=0
Rk56 (\18\:qint \21\:qint) resistor r=0.1649 c=0
Rk32 (\2\:n41 \4\:n41) resistor r=0.611 c=0
Rl20 (\2\:RN \3\:RN) resistor r=70.3867 c=0
Rl19 (\1\:RN \2\:RN) resistor r=44.3981 c=0
Rl1 (\1\:CKN \2\:CKN) resistor r=73.7687 c=0
Rl2 (\2\:CKN \3\:CKN) resistor r=185.307 c=0
Rl29 (\1\:SN \2\:SN) resistor r=222.643 c=0
Rl30 (\2\:SN \3\:SN) resistor r=943.796 c=0
Rl33 (\4\:SN \6\:SN) resistor r=65.0871 c=0
Rl31 (\3\:SN \4\:SN) resistor r=49.842 c=0
Rl32 (\4\:SN \5\:SN) resistor r=13.0342 c=0
Rl3 (\1\:D \2\:D) resistor r=158.384 c=0
Rl4 (\2\:D \3\:D) resistor r=100.692 c=0
Rl24 (\12\:CKNb \13\:CKNb) resistor r=29.982 c=0
Rl21 (\10\:CKNb \11\:CKNb) resistor r=49.5131 c=0
Rl14 (\7\:CKNb \9\:CKNb) resistor r=24.2328 c=0
Rl6 (\3\:CKNb \4\:CKNb) resistor r=35.7713 c=0
Rl5 (CKNb \2\:CKNb) resistor r=66.5405 c=0
Rl13 (\6\:CKNb \8\:CKNb) resistor r=40.6312 c=0
Rl11 (\5\:CKNb \6\:CKNb) resistor r=82.7008 c=0
Rl12 (\6\:CKNb \7\:CKNb) resistor r=52.3304 c=0
Rl16 (n20 \3\:n20) resistor r=132.692 c=0
Rl15 (n20 \2\:n20) resistor r=95.9055 c=0
Rl22 (\4\:CKNbb \5\:CKNbb) resistor r=168.362 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=67.9995 c=0
Rl7 (CKNbb \2\:CKNbb) resistor r=106.925 c=0
Rl8 (\2\:CKNbb \3\:CKNbb) resistor r=239.939 c=0
Rl10 (\2\:mout \3\:mout) resistor r=293.796 c=0
Rl9 (mout \2\:mout) resistor r=24.2328 c=0
Rl17 (RNb \2\:RNb) resistor r=132.692 c=0
Rl25 (\4\:RNb \5\:RNb) resistor r=155.746 c=0
Rl26 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=249.513 c=0
Rl68 (\20\:qbint \21\:qbint) resistor r=131.708 c=0
Rl67 (\20\:qbint \19\:qbint) resistor r=44.2438 c=0
Rl27 (\2\:qbint qbint) resistor r=158.134 c=0
Rl28 (\2\:qbint \3\:qbint) resistor r=42.9964 c=0
Rz29 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz30 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz31 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz32 (\15\:VDD \1\:VDD) resistor r=6.25 c=0
Rz26 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz27 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz28 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz1 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz7 (\12\:CKNbb \13\:CKNbb) resistor r=75 c=0
Rz5 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz3 (n25 \2\:n25) resistor r=75 c=0
Rz4 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\10\:n35 \9\:n35) resistor r=75 c=0
Rz9 (n40 \2\:n40) resistor r=75 c=0
Rz10 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (n42 \2\:n42) resistor r=75 c=0
Rz12 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz19 (\17\:qint \16\:qint) resistor r=75 c=0
Ry26 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry27 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry28 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry29 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry30 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=4.1333 c=0
Ry18 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry2 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry3 (\7\:mout \8\:mout) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry6 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\12\:n35 \11\:n35) resistor r=62 c=0
Ry14 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry15 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Ry7 (n41 \2\:n41) resistor r=62 c=0
Ry8 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx7 (\5\:SN \7\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\7\:CKNb \14\:CKNb) resistor r=45 c=0
Rx4 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx5 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx12 (\13\:CKNb \23\:CKNb) resistor r=45 c=0
Rx13 (\5\:CKNb \25\:CKNb) resistor r=45 c=0
Rx14 (\11\:CKNb \26\:CKNb) resistor r=45 c=0
Rx6 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx11 (\2\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (mout \14\:mout) resistor r=45 c=0
Rx15 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx16 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\7\:n35 n35) resistor r=45 c=0
Rx18 (\22\:qbint \20\:qbint) resistor r=45 c=0
Rx19 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx20 (\31\:qbint \4\:qbint) resistor r=45 c=0
Rx21 (\19\:qint qint) resistor r=45 c=0
mn20 (\18\:CKNb \3\:CKN \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04121e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn25 (n21 \3\:D \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.36207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn26 (\7\:n20 \3\:CKNbb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.61e-14 ps=6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=6.36207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn36 (\7\:n20 \3\:CKNb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=4.11207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn35 (n30 \2\:mout \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.735e-14 ad=3.19e-14 ps=1.7e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.46207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\12\:CKNbb \9\:CKNb \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.735e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98621e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (n25 \2\:RNb \12\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.255e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn32 (\12\:mout \3\:n20 \3\:n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.177e-14 ad=2.32e-14 ps=1.28e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.05e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn30 (\3\:n25 \3\:SN \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=7.177e-14 ps=1.2e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=5.1e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn22 (\8\:RNb \1\:RN \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn40 (\9\:n35 \10\:CKNb \4\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn53 (n40 \4\:CKNbb \9\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\3\:n40 \6\:RNb \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.392e-14 ps=6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn52 (\3\:n40 \3\:qbint n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn50 (n42 \2\:SN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn45_1__rcx (\29\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.734e-14 ad=3.28e-14 ps=8.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.77439e-07 sb=2e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(2)
mn56 (\16\:qint \19\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.568e-14 ad=4.16e-14 ps=1.385e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72673e-06 sb=1.165e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mn55_1__rcx (\1\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.722e-14 ad=5.59e-14 ps=1.33e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.27308e-07 sb=2e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mp45 (\27\:qbint n35 \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.802e-14 ad=4.96e-14 ps=1.07e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.91855e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp56 (\20\:qint \21\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95692e-06 sb=1.4e-07 sd=160n sca=22.2573 \
        scb=0.0184811 scc=0.00198102 m=(1)
mp57 (\5\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.727e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61417e-06 sb=9.85e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp55_1__rcx (Q \4\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.917e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.69167e-07 sb=1.83e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
ends DFFNSRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:25 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFNSRXL
// View name: extracted

simulator lang=spectre

subckt DFFNSRXL CKN D Q QN RN SN VDD VSS
mp57 (\1\:QN \4\:qint \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.323 \
        scb=0.0325052 scc=0.00592234 m=(1)
mp56 (\5\:qint \7\:qbint \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0147 \
        scb=0.0290717 scc=0.00588507 m=(1)
mp55 (\1\:Q qbint \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp22 (\10\:RNb \1\:RN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp45 (\16\:qbint n35 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (\3\:n41 \1\:SN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.44e-14 ps=1.64e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.65e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (n43 \2\:RNb \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0103e-13 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.55e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp53 (n41 CKNb \7\:n35 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.115e-14 ad=3.118e-14 ps=8.7e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.36628e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n35 \3\:CKNbb \15\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=4.115e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4093e-07 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp31 (n26 \5\:RNb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=1.612e-14 ps=2.1e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63953e-07 sb=1.05849e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp32 (\10\:mout n20 n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=5.16e-14 ps=5.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.83953e-07 sb=9.38488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp30 (\10\:mout \5\:SN \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.905e-14 ad=5.16e-14 ps=1.71e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.68953e-07 sb=6.53488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp35 (n31 \4\:mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.905e-14 ad=3.87e-14 ps=1.71e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.26977e-07 sb=9.95e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp36 (\7\:n20 \7\:CKNbb n31 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.51977e-07 sb=7.7e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp26 (\7\:n20 \4\:CKNb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.56977e-07 sb=5.65e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp25 (n22 \3\:D \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17698e-06 sb=3.45e-07 sd=160n sca=10.8251 \
        scb=0.00858217 scc=0.000148871 m=(1)
mp21 (\12\:CKNbb \7\:CKNb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38198e-06 sb=1.4e-07 sd=160n sca=11.384 \
        scb=0.00879424 scc=0.00014895 m=(1)
mp20 (\15\:CKNb \1\:CKN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
C1 (RN VSS) capacitor c=5.99665e-17
C2 (CKN VSS) capacitor c=4.37051e-17
C3 (QN VSS) capacitor c=2.25228e-17
C4 (D VSS) capacitor c=4.86306e-17
C5 (Q VSS) capacitor c=6.68525e-17
C6 (VDD VSS) capacitor c=4.49608e-16
C7 (SN VSS) capacitor c=2.1546e-17
C8 (qint VSS) capacitor c=2.07337e-17
C9 (qbint VSS) capacitor c=4.97082e-17
C10 (RNb VSS) capacitor c=5.26133e-17
C11 (n35 VSS) capacitor c=4.27349e-17
C12 (n42 VSS) capacitor c=7.71651e-17
C13 (n40 VSS) capacitor c=8.05037e-17
C14 (CKNbb VSS) capacitor c=4.61426e-17
C15 (mout VSS) capacitor c=4.68076e-17
C16 (CKNb VSS) capacitor c=6.68486e-17
C17 (n25 VSS) capacitor c=7.05526e-17
C18 (n20 VSS) capacitor c=6.26341e-17
C19 (n30 VSS) capacitor c=2.45524e-18
C20 (n41 VSS) capacitor c=1.17263e-16
C21 (n43 VSS) capacitor c=1.48145e-18
C22 (n26 VSS) capacitor c=2.97535e-18
C23 (n31 VSS) capacitor c=3.71866e-18
C24 (n22 VSS) capacitor c=2.41226e-18
C25 (\1\:CKN VSS) capacitor c=2.81976e-17
C26 (\7\:CKNb VSS) capacitor c=6.43835e-17
C27 (\3\:D VSS) capacitor c=5.61619e-17
C28 (\4\:CKNb VSS) capacitor c=7.85718e-17
C29 (\7\:CKNbb VSS) capacitor c=3.48266e-17
C30 (\4\:mout VSS) capacitor c=4.63042e-17
C31 (\5\:SN VSS) capacitor c=5.19637e-17
C32 (\5\:RNb VSS) capacitor c=8.14245e-17
C33 (\3\:CKNbb VSS) capacitor c=3.86926e-17
C34 (\2\:RNb VSS) capacitor c=8.85617e-17
C35 (\8\:qbint VSS) capacitor c=9.10944e-17
C36 (\1\:SN VSS) capacitor c=3.68772e-17
C37 (\1\:RN VSS) capacitor c=3.34711e-17
C38 (\7\:qbint VSS) capacitor c=2.47784e-17
C39 (\4\:qint VSS) capacitor c=3.10855e-17
C40 (\3\:CKN VSS) capacitor c=2.48678e-17
C41 (\8\:CKNb VSS) capacitor c=4.50236e-17
C42 (\1\:D VSS) capacitor c=4.65834e-17
C43 (\8\:CKNbb VSS) capacitor c=6.3296e-17
C44 (\5\:CKNb VSS) capacitor c=6.16625e-17
C45 (\4\:SN VSS) capacitor c=6.76747e-17
C46 (\3\:n20 VSS) capacitor c=3.4362e-17
C47 (\4\:RNb VSS) capacitor c=6.75026e-17
C48 (\2\:CKNb VSS) capacitor c=9.53616e-17
C49 (\9\:qbint VSS) capacitor c=4.01149e-17
C50 (\3\:SN VSS) capacitor c=5.61256e-17
C51 (\3\:n35 VSS) capacitor c=3.26003e-17
C52 (\3\:RN VSS) capacitor c=5.5993e-17
C53 (\5\:qbint VSS) capacitor c=2.2886e-17
C54 (\4\:qbint VSS) capacitor c=3.45565e-17
C55 (\3\:qint VSS) capacitor c=3.05607e-17
C56 (\2\:CKN VSS) capacitor c=1.94479e-17
C57 (\9\:CKNb VSS) capacitor c=1.85611e-17
C58 (\4\:D VSS) capacitor c=2.67087e-17
C59 (\9\:CKNbb VSS) capacitor c=5.99482e-17
C60 (\6\:CKNb VSS) capacitor c=2.27164e-17
C61 (\6\:CKNbb VSS) capacitor c=4.73977e-17
C62 (\3\:mout VSS) capacitor c=1.60356e-17
C63 (\6\:SN VSS) capacitor c=2.87457e-17
C64 (\3\:CKNb VSS) capacitor c=6.41676e-17
C65 (\2\:n20 VSS) capacitor c=4.4258e-17
C66 (\5\:CKNbb VSS) capacitor c=3.23559e-17
C67 (\6\:RNb VSS) capacitor c=2.14967e-17
C68 (\4\:CKNbb VSS) capacitor c=3.33024e-17
C69 (\2\:CKNbb VSS) capacitor c=2.65253e-17
C70 (\3\:RNb VSS) capacitor c=2.20985e-17
C71 (\10\:qbint VSS) capacitor c=2.91433e-17
C72 (\2\:SN VSS) capacitor c=4.40917e-17
C73 (\2\:n35 VSS) capacitor c=3.17506e-17
C74 (\2\:RN VSS) capacitor c=4.30052e-17
C75 (\1\:VDD VSS) capacitor c=3.10582e-17
C76 (\15\:CKNb VSS) capacitor c=4.99109e-17
C77 (\12\:CKNbb VSS) capacitor c=1.63472e-17
C78 (\8\:VDD VSS) capacitor c=3.59209e-17
C79 (\7\:n20 VSS) capacitor c=8.31495e-17
C80 (\10\:VDD VSS) capacitor c=1.4028e-17
C81 (\10\:mout VSS) capacitor c=2.80584e-17
C82 (\12\:VDD VSS) capacitor c=2.68294e-17
C83 (\15\:mout VSS) capacitor c=5.2606e-17
C84 (\7\:n35 VSS) capacitor c=2.72696e-17
C85 (\15\:VDD VSS) capacitor c=3.22602e-17
C86 (\3\:n41 VSS) capacitor c=1.11581e-16
C87 (\18\:VDD VSS) capacitor c=3.03752e-17
C88 (\16\:qbint VSS) capacitor c=7.89909e-17
C89 (\10\:RNb VSS) capacitor c=2.50573e-17
C90 (\22\:VDD VSS) capacitor c=2.85842e-17
C91 (\1\:Q VSS) capacitor c=4.54065e-17
C92 (\5\:qint VSS) capacitor c=3.50101e-17
C93 (\25\:VDD VSS) capacitor c=3.98683e-17
C94 (\1\:QN VSS) capacitor c=1.99466e-17
C95 (\3\:VDD VSS) capacitor c=9.56684e-17
C96 (\13\:CKNb VSS) capacitor c=6.48007e-17
C97 (\17\:CKNbb VSS) capacitor c=6.38439e-17
C98 (\4\:n20 VSS) capacitor c=4.85957e-17
C99 (\3\:n25 VSS) capacitor c=8.39093e-17
C100 (\8\:mout VSS) capacitor c=4.30823e-17
C101 (\13\:mout VSS) capacitor c=5.10942e-17
C102 (\4\:n35 VSS) capacitor c=5.47418e-17
C103 (\3\:n40 VSS) capacitor c=8.86744e-17
C104 (\3\:n42 VSS) capacitor c=1.04412e-16
C105 (\13\:qbint VSS) capacitor c=5.75734e-17
C106 (\12\:RNb VSS) capacitor c=1.07864e-16
C107 (\3\:Q VSS) capacitor c=4.92885e-17
C108 (\9\:qint VSS) capacitor c=2.6791e-17
C109 (\3\:QN VSS) capacitor c=3.47746e-17
C110 (\2\:qint VSS) capacitor c=1.26256e-17
C111 (\2\:qbint VSS) capacitor c=5.64516e-17
C112 (\3\:qbint VSS) capacitor c=3.24121e-17
C113 (\2\:mout VSS) capacitor c=3.37287e-17
C114 (\2\:D VSS) capacitor c=4.43413e-17
C115 (\7\:qint VSS) capacitor c=2.67327e-17
C116 (\8\:qint VSS) capacitor c=2.97275e-17
C117 (\4\:RN VSS) capacitor c=6.43938e-17
C118 (\11\:qbint VSS) capacitor c=6.15539e-17
C119 (\12\:qbint VSS) capacitor c=9.03676e-17
C120 (\15\:qbint VSS) capacitor c=1.13107e-16
C121 (\6\:n35 VSS) capacitor c=1.65334e-16
C122 (\9\:n35 VSS) capacitor c=1.50894e-16
C123 (\10\:CKNbb VSS) capacitor c=7.78899e-17
C124 (\11\:CKNbb VSS) capacitor c=1.17838e-16
C125 (\7\:RNb VSS) capacitor c=1.52178e-16
C126 (\8\:RNb VSS) capacitor c=2.30672e-16
C127 (\9\:RNb VSS) capacitor c=1.3176e-16
C128 (\7\:SN VSS) capacitor c=2.89356e-16
C129 (\8\:SN VSS) capacitor c=3.04298e-16
C130 (\9\:SN VSS) capacitor c=2.81025e-17
C131 (\5\:mout VSS) capacitor c=5.05568e-17
C132 (\6\:mout VSS) capacitor c=6.31384e-17
C133 (\7\:mout VSS) capacitor c=7.11582e-17
C134 (\12\:mout VSS) capacitor c=4.88517e-17
C135 (\6\:n20 VSS) capacitor c=1.1046e-16
C136 (\9\:n20 VSS) capacitor c=8.67149e-17
C137 (\5\:D VSS) capacitor c=5.50027e-17
C138 (\14\:CKNbb VSS) capacitor c=6.00384e-17
C139 (\15\:CKNbb VSS) capacitor c=1.63952e-16
C140 (\16\:CKNbb VSS) capacitor c=2.16761e-16
C141 (\19\:CKNbb VSS) capacitor c=1.28566e-17
C142 (\20\:CKNbb VSS) capacitor c=2.26352e-17
C143 (\21\:CKNbb VSS) capacitor c=3.55284e-17
C144 (\10\:CKNb VSS) capacitor c=7.50829e-17
C145 (\11\:CKNb VSS) capacitor c=8.12621e-17
C146 (\12\:CKNb VSS) capacitor c=5.86678e-17
C147 (\4\:CKN VSS) capacitor c=3.31036e-17
C148 (\5\:VDD VSS) capacitor c=2.28582e-17
C149 (\6\:VDD VSS) capacitor c=5.29355e-17
C150 (\14\:VDD VSS) capacitor c=4.52969e-17
C151 (\17\:VDD VSS) capacitor c=3.27455e-17
C152 (\21\:VDD VSS) capacitor c=1.50312e-17
C153 (\24\:VDD VSS) capacitor c=1.20246e-17
Rk8 (\4\:RN RN) resistor r=0.04551 c=0
Rk50 (\4\:CKN CKN) resistor r=0.07373 c=0
Rk2 (\4\:QN QN) resistor r=0.08804 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk51 (\2\:VSS \4\:VSS) resistor r=0.3499 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.09009 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.3924 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.4678 c=0
Rk55 (\7\:VSS \8\:VSS) resistor r=0.8515 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=0.35 c=0
Rk57 (\9\:VSS \10\:VSS) resistor r=0.03742 c=0
Rk59 (\11\:VSS VSS) resistor r=0.2228 c=0
Rk58 (\10\:VSS \11\:VSS) resistor r=0.2905 c=0
Rk60 (\5\:VSS \13\:VSS) resistor r=0.07393 c=0
Rk61 (\6\:VSS \15\:VSS) resistor r=0.04331 c=0
Rk62 (\8\:VSS \17\:VSS) resistor r=0.04331 c=0
Rk63 (\10\:VSS \19\:VSS) resistor r=0.379 c=0
Rk64 (\11\:VSS \21\:VSS) resistor r=0.07393 c=0
Rk38 (\5\:D D) resistor r=0.07439 c=0
Rk6 (\2\:Q Q) resistor r=0.3038 c=0
Rk7 (Q \4\:Q) resistor r=0.1889 c=0
Rk65 (\2\:VDD \4\:VDD) resistor r=0.6791 c=0
Rk66 (\4\:VDD \5\:VDD) resistor r=0.07504 c=0
Rk67 (\5\:VDD \6\:VDD) resistor r=0.4435 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.4337 c=0
Rk69 (\5\:VDD \9\:VDD) resistor r=0.2621 c=0
Rk70 (\6\:VDD \11\:VDD) resistor r=0.07393 c=0
Rk71 (\7\:VDD \13\:VDD) resistor r=0.07147 c=0
Rk72 (\7\:VDD \14\:VDD) resistor r=0.5215 c=0
Rk73 (\14\:VDD \16\:VDD) resistor r=0.04331 c=0
Rk74 (\14\:VDD \17\:VDD) resistor r=0.3287 c=0
Rk75 (\17\:VDD \19\:VDD) resistor r=0.04331 c=0
Rk76 (\17\:VDD \20\:VDD) resistor r=0.35 c=0
Rk77 (\20\:VDD \21\:VDD) resistor r=0.03241 c=0
Rk78 (\21\:VDD \23\:VDD) resistor r=0.2054 c=0
Rk81 (\24\:VDD VDD) resistor r=0.2077 c=0
Rk79 (\21\:VDD \24\:VDD) resistor r=0.3106 c=0
Rk80 (\24\:VDD \26\:VDD) resistor r=0.4181 c=0
Rk26 (\8\:SN SN) resistor r=0.003077 c=0
Rk25 (\7\:SN \8\:SN) resistor r=2.1683 c=0
Rk27 (\8\:SN \9\:SN) resistor r=0.08618 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1178 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1194 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1058 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.3368 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.101 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.6754 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.4463 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=0.9732 c=0
Rk21 (\8\:RNb \9\:RNb) resistor r=0.669 c=0
Rk22 (\9\:RNb \11\:RNb) resistor r=0.05532 c=0
Rk23 (\9\:RNb \13\:RNb) resistor r=0.5816 c=0
Rk16 (\5\:n35 \6\:n35) resistor r=0.276 c=0
Rk17 (\6\:n35 \8\:n35) resistor r=0.076 c=0
Rk18 (\6\:n35 \9\:n35) resistor r=1.0707 c=0
Rk13 (\2\:n42 \4\:n42) resistor r=0.6107 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=0.5088 c=0
Rk19 (\10\:CKNbb \11\:CKNbb) resistor r=0.51 c=0
Rk39 (\13\:CKNbb \14\:CKNbb) resistor r=0.07429 c=0
Rk40 (\14\:CKNbb \15\:CKNbb) resistor r=0.2756 c=0
Rk41 (\15\:CKNbb \16\:CKNbb) resistor r=1.4921 c=0
Rk42 (\14\:CKNbb \18\:CKNbb) resistor r=0.3929 c=0
Rk43 (\15\:CKNbb \19\:CKNbb) resistor r=0.1018 c=0
Rk44 (\19\:CKNbb \20\:CKNbb) resistor r=0.06586 c=0
Rk45 (\19\:CKNbb \21\:CKNbb) resistor r=0.142 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.2852 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.3496 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.1396 c=0
Rk31 (\6\:mout \11\:mout) resistor r=0.08669 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.2373 c=0
Rk33 (\12\:mout \14\:mout) resistor r=0.1472 c=0
Rk34 (\12\:mout \16\:mout) resistor r=0.278 c=0
Rk46 (\10\:CKNb \11\:CKNb) resistor r=0.5205 c=0
Rk47 (\11\:CKNb \12\:CKNb) resistor r=0.3998 c=0
Rk48 (\12\:CKNb \14\:CKNb) resistor r=0.1977 c=0
Rk49 (\14\:CKNb \16\:CKNb) resistor r=0.4074 c=0
Rk24 (\2\:n25 \4\:n25) resistor r=0.5039 c=0
Rk35 (\5\:n20 \6\:n20) resistor r=0.3371 c=0
Rk36 (\6\:n20 \8\:n20) resistor r=0.4144 c=0
Rk37 (\6\:n20 \9\:n20) resistor r=0.4839 c=0
Rk15 (\2\:n41 \4\:n41) resistor r=0.6358 c=0
Rl10 (\1\:RN \2\:RN) resistor r=58.3841 c=0
Rl11 (\2\:RN \3\:RN) resistor r=135.307 c=0
Rl43 (\1\:CKN \2\:CKN) resistor r=85.3072 c=0
Rl44 (\2\:CKN \3\:CKN) resistor r=29.5379 c=0
Rl39 (\2\:D \3\:D) resistor r=122.865 c=0
Rl38 (\1\:D \2\:D) resistor r=50.4153 c=0
Rl40 (\2\:D \4\:D) resistor r=5.1011 c=0
Rl29 (\4\:SN \5\:SN) resistor r=161.104 c=0
Rl30 (\5\:SN \6\:SN) resistor r=73.7687 c=0
Rl14 (\1\:SN \2\:SN) resistor r=36.7742 c=0
Rl15 (\2\:SN \3\:SN) resistor r=91.8219 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=2.0213 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=142.308 c=0
Rl17 (\9\:qbint \10\:qbint) resistor r=42.0567 c=0
Rl4 (qbint \2\:qbint) resistor r=173.531 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=38.9161 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.7659 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=35.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=53.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=143.992 c=0
Rl23 (\4\:RNb \5\:RNb) resistor r=157.258 c=0
Rl18 (RNb \2\:RNb) resistor r=222.643 c=0
Rl24 (\5\:RNb \6\:RNb) resistor r=124.513 c=0
Rl19 (\2\:RNb \3\:RNb) resistor r=62.2302 c=0
Rl12 (n35 \2\:n35) resistor r=87.2302 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl37 (\8\:CKNbb \9\:CKNbb) resistor r=79.5379 c=0
Rl34 (\6\:CKNbb \7\:CKNbb) resistor r=61.4557 c=0
Rl21 (\3\:CKNbb \4\:CKNbb) resistor r=24.2328 c=0
Rl22 (\4\:CKNbb \5\:CKNbb) resistor r=114.412 c=0
Rl20 (CKNbb \2\:CKNbb) resistor r=93.4636 c=0
Rl33 (\2\:mout \4\:mout) resistor r=78.5603 c=0
Rl31 (mout \2\:mout) resistor r=106.972 c=0
Rl32 (\2\:mout \3\:mout) resistor r=2.0166 c=0
Rl41 (\7\:CKNb \8\:CKNb) resistor r=187.381 c=0
Rl35 (\4\:CKNb \5\:CKNb) resistor r=202.895 c=0
Rl27 (CKNb \2\:CKNb) resistor r=151.054 c=0
Rl42 (\8\:CKNb \9\:CKNb) resistor r=29.5379 c=0
Rl36 (\5\:CKNb \6\:CKNb) resistor r=29.5379 c=0
Rl28 (\2\:CKNb \3\:CKNb) resistor r=451.436 c=0
Rl25 (n20 \2\:n20) resistor r=85.7713 c=0
Rl26 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz24 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz25 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz26 (\3\:VDD \20\:VDD) resistor r=6.25 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz16 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz13 (\8\:mout \9\:mout) resistor r=75 c=0
Rz14 (\13\:mout \14\:mout) resistor r=75 c=0
Rz17 (\13\:CKNb \14\:CKNb) resistor r=75 c=0
Rz11 (n25 \2\:n25) resistor r=75 c=0
Rz12 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz15 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry15 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry16 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry17 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry18 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry19 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry20 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry21 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry22 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry23 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry24 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\7\:n35 \8\:n35) resistor r=62 c=0
Ry12 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\10\:mout \11\:mout) resistor r=62 c=0
Ry10 (\15\:mout \16\:mout) resistor r=62 c=0
Ry13 (\15\:CKNb \16\:CKNb) resistor r=62 c=0
Ry11 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx14 (\4\:D \5\:D) resistor r=45 c=0
Rx10 (\6\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \9\:SN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \15\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \9\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\4\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \20\:CKNbb) resistor r=45 c=0
Rx17 (\6\:CKNbb \21\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx18 (\3\:CKNb \10\:CKNb) resistor r=45 c=0
Rx19 (\6\:CKNb \11\:CKNb) resistor r=45 c=0
Rx20 (\9\:CKNb \12\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn22 (\12\:RNb \3\:RN \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.553e-14 ps=6.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=2.45e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn45 (\13\:qbint \3\:n35 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=2.03e-14 ps=1.68e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (\3\:n42 \3\:SN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.755e-14 ps=1.68e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=7.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn52 (n40 \9\:qbint \3\:n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=4.568e-14 ps=6.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (n40 RNb n42 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=4.568e-14 ps=5.7e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn53 (\3\:n40 CKNbb \4\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\4\:n35 \2\:CKNb \13\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn31 (n25 \4\:RNb \8\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.815e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn32 (\8\:mout \3\:n20 \3\:n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.393e-14 ps=9.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.605e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\3\:n25 \4\:SN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=4.93e-14 ps=1.6e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n30 mout \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.973e-14 ps=1.6e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=9.55e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\4\:n20 \5\:CKNb n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=7.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn26 (\4\:n20 \8\:CKNbb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \1\:D \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.625e-14 ad=1.305e-14 ps=1.66e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\17\:CKNbb \8\:CKNb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\13\:CKNb \3\:CKN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.84e-14 ad=2.465e-14 ps=1.25e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1e-07 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
ends DFFNSRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:26 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFQX1
// View name: extracted

simulator lang=spectre

subckt DFFQX1 CK D Q VDD VSS
mp55 (\1\:Q \4\:qbint \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.70897e-07 sd=160n sca=21.8895 \
        scb=0.024842 scc=0.00105464 m=(1)
C1 (D VSS) capacitor c=1.31132e-16
C2 (VDD VSS) capacitor c=2.74421e-16
C3 (Q VSS) capacitor c=5.24339e-17
C4 (CK VSS) capacitor c=1.15329e-16
C5 (qbint VSS) capacitor c=1.95314e-17
C6 (CKb VSS) capacitor c=2.14077e-17
C7 (n30 VSS) capacitor c=3.62825e-17
C8 (n35 VSS) capacitor c=3.63289e-18
C9 (mout VSS) capacitor c=4.34151e-17
C10 (CKbb VSS) capacitor c=4.97474e-17
C11 (n20 VSS) capacitor c=3.19962e-17
C12 (n25 VSS) capacitor c=1.27446e-18
C13 (n21 VSS) capacitor c=1.25e-18
C14 (n36 VSS) capacitor c=1.26428e-18
C15 (n26 VSS) capacitor c=1.13617e-18
C16 (n22 VSS) capacitor c=3.43716e-18
C17 (\10\:CKb VSS) capacitor c=4.23821e-17
C18 (\3\:D VSS) capacitor c=3.13717e-17
C19 (\5\:CKbb VSS) capacitor c=6.77985e-17
C20 (\5\:CKb VSS) capacitor c=5.39144e-17
C21 (\4\:mout VSS) capacitor c=9.18303e-17
C22 (\4\:n20 VSS) capacitor c=3.9671e-17
C23 (\2\:CKbb VSS) capacitor c=4.69135e-17
C24 (\5\:qbint VSS) capacitor c=6.6422e-17
C25 (\3\:n30 VSS) capacitor c=3.68391e-17
C26 (\3\:CK VSS) capacitor c=4.07492e-17
C27 (\4\:qbint VSS) capacitor c=6.39105e-17
C28 (\8\:CKb VSS) capacitor c=3.14537e-17
C29 (\1\:D VSS) capacitor c=6.93126e-17
C30 (\6\:CKb VSS) capacitor c=5.83045e-17
C31 (\6\:CKbb VSS) capacitor c=5.22411e-17
C32 (\3\:n20 VSS) capacitor c=5.04355e-17
C33 (\3\:CKbb VSS) capacitor c=3.51611e-17
C34 (\3\:CKb VSS) capacitor c=6.7508e-17
C35 (\8\:qbint VSS) capacitor c=3.80203e-17
C36 (\1\:CK VSS) capacitor c=5.95756e-17
C37 (\3\:qbint VSS) capacitor c=3.62166e-17
C38 (\9\:CKb VSS) capacitor c=4.90183e-17
C39 (\2\:D VSS) capacitor c=5.8373e-17
C40 (\7\:CKb VSS) capacitor c=5.51139e-17
C41 (\7\:CKbb VSS) capacitor c=2.50927e-17
C42 (\4\:CKb VSS) capacitor c=5.56172e-17
C43 (\3\:mout VSS) capacitor c=3.3056e-17
C44 (\4\:CKbb VSS) capacitor c=4.54235e-17
C45 (\2\:CKb VSS) capacitor c=6.49404e-17
C46 (\7\:qbint VSS) capacitor c=3.32248e-17
C47 (\4\:n30 VSS) capacitor c=3.23236e-17
C48 (\2\:CK VSS) capacitor c=4.16642e-17
C49 (\8\:CKbb VSS) capacitor c=4.50264e-17
C50 (\1\:VDD VSS) capacitor c=3.55994e-17
C51 (\9\:n20 VSS) capacitor c=6.55276e-17
C52 (\9\:VDD VSS) capacitor c=2.19094e-17
C53 (\9\:mout VSS) capacitor c=6.36204e-17
C54 (\9\:n30 VSS) capacitor c=6.41875e-17
C55 (\11\:VDD VSS) capacitor c=2.40299e-17
C56 (\14\:qbint VSS) capacitor c=5.55534e-17
C57 (\15\:CKb VSS) capacitor c=1.67238e-16
C58 (\13\:VDD VSS) capacitor c=3.13618e-17
C59 (\1\:Q VSS) capacitor c=5.20251e-17
C60 (\3\:VDD VSS) capacitor c=7.5529e-17
C61 (\14\:CKbb VSS) capacitor c=1.52227e-17
C62 (\5\:n20 VSS) capacitor c=7.66509e-17
C63 (\7\:mout VSS) capacitor c=3.34202e-17
C64 (\5\:n30 VSS) capacitor c=5.87235e-17
C65 (\11\:qbint VSS) capacitor c=9.47533e-17
C66 (\19\:CKb VSS) capacitor c=1.11081e-16
C67 (\3\:Q VSS) capacitor c=1.80725e-17
C68 (\2\:qbint VSS) capacitor c=2.31753e-17
C69 (\2\:n30 VSS) capacitor c=3.05192e-17
C70 (\6\:qbint VSS) capacitor c=3.57103e-17
C71 (\2\:n20 VSS) capacitor c=3.66147e-17
C72 (\2\:mout VSS) capacitor c=4.67378e-17
C73 (\9\:qbint VSS) capacitor c=3.67416e-17
C74 (\10\:qbint VSS) capacitor c=5.04519e-17
C75 (\13\:qbint VSS) capacitor c=1.38074e-16
C76 (\7\:n30 VSS) capacitor c=6.1748e-17
C77 (\8\:n30 VSS) capacitor c=4.1286e-17
C78 (\5\:mout VSS) capacitor c=4.07122e-17
C79 (\6\:mout VSS) capacitor c=6.19696e-17
C80 (\7\:n20 VSS) capacitor c=7.83547e-17
C81 (\8\:n20 VSS) capacitor c=3.1902e-17
C82 (\11\:CKb VSS) capacitor c=7.27311e-17
C83 (\12\:CKb VSS) capacitor c=6.87735e-17
C84 (\13\:CKb VSS) capacitor c=1.18899e-16
C85 (\14\:CKb VSS) capacitor c=1.8522e-16
C86 (\17\:CKb VSS) capacitor c=3.28474e-17
C87 (\18\:CKb VSS) capacitor c=4.99865e-17
C88 (\10\:CKbb VSS) capacitor c=1.21008e-16
C89 (\11\:CKbb VSS) capacitor c=1.77094e-16
C90 (\12\:CKbb VSS) capacitor c=1.27976e-16
C91 (\13\:CKbb VSS) capacitor c=5.90153e-17
C92 (\5\:VDD VSS) capacitor c=4.58442e-17
C93 (\7\:VDD VSS) capacitor c=1.90514e-17
C94 (\8\:VDD VSS) capacitor c=2.25062e-17
Rk17 (D \4\:D) resistor r=0.006754 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.1299 c=0
Rk31 (\3\:VSS \5\:VSS) resistor r=0.5242 c=0
Rk32 (\5\:VSS \6\:VSS) resistor r=0.06253 c=0
Rk34 (\7\:VSS VSS) resistor r=0.125 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.3634 c=0
Rk35 (\3\:VSS \8\:VSS) resistor r=0.3285 c=0
Rk36 (\8\:VSS \10\:VSS) resistor r=0.4417 c=0
Rk37 (\6\:VSS \12\:VSS) resistor r=0.3706 c=0
Rk38 (\7\:VSS \14\:VSS) resistor r=0.2547 c=0
Rk39 (\2\:VDD \4\:VDD) resistor r=0.2755 c=0
Rk40 (\4\:VDD \5\:VDD) resistor r=0.4003 c=0
Rk41 (\5\:VDD \6\:VDD) resistor r=0.4505 c=0
Rk42 (\6\:VDD \7\:VDD) resistor r=0.05154 c=0
Rk44 (\8\:VDD VDD) resistor r=0.125 c=0
Rk43 (\7\:VDD \8\:VDD) resistor r=0.3725 c=0
Rk45 (\5\:VDD \10\:VDD) resistor r=0.04334 c=0
Rk46 (\7\:VDD \12\:VDD) resistor r=0.04334 c=0
Rk47 (\8\:VDD \14\:VDD) resistor r=0.2063 c=0
Rk1 (\2\:Q Q) resistor r=0.3432 c=0
Rk2 (Q \4\:Q) resistor r=0.06947 c=0
Rk3 (\4\:CK CK) resistor r=0.003008 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1472 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.2486 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.7919 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.2188 c=0
Rk18 (\11\:CKb \12\:CKb) resistor r=0.3178 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.179 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.9691 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.7408 c=0
Rk22 (\13\:CKb \17\:CKb) resistor r=0.1169 c=0
Rk23 (\14\:CKb \18\:CKb) resistor r=0.2253 c=0
Rk24 (\16\:CKb \20\:CKb) resistor r=0.6646 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.473 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.1426 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.235 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.1256 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1685 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3693 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.3743 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.7505 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=0.9062 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.2986 c=0
Rk29 (\10\:CKbb \15\:CKbb) resistor r=0.09559 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.5238 c=0
Rk15 (\7\:n20 \8\:n20) resistor r=0.09453 c=0
Rk16 (\7\:n20 \10\:n20) resistor r=0.3553 c=0
Rl27 (\2\:D \3\:D) resistor r=41.5405 c=0
Rl26 (\1\:D \2\:D) resistor r=137.694 c=0
Rl5 (\2\:CK \3\:CK) resistor r=54.9442 c=0
Rl4 (\1\:CK \2\:CK) resistor r=153.021 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=130.483 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=111.253 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=88.1757 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=9.8995 c=0
Rl29 (\9\:CKb \10\:CKb) resistor r=99.5316 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=82.9508 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=89.8977 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=53.733 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=213.278 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=51.0755 c=0
Rl6 (n30 \2\:n30) resistor r=151.076 c=0
Rl8 (\2\:n30 \4\:n30) resistor r=13.6663 c=0
Rl21 (\2\:mout \4\:mout) resistor r=151.605 c=0
Rl19 (mout \2\:mout) resistor r=82.6702 c=0
Rl20 (\2\:mout \3\:mout) resistor r=32.6176 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=207.692 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=78.079 c=0
Rl12 (CKbb \2\:CKbb) resistor r=68.7438 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=79.6488 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=118.11 c=0
Rl16 (n20 \2\:n20) resistor r=10.9374 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz13 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry8 (\4\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry9 (\4\:VSS \8\:VSS) resistor r=12.4 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry12 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx8 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx14 (CKbb \13\:CKbb) resistor r=45 c=0
Rx6 (n20 \8\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.18462e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mn20 (\19\:CKb \1\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn45 (\11\:qbint n30 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn50 (n35 \8\:qbint \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.698e-14 ps=5.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.895e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\5\:n30 \3\:CKbb \7\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.595e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\7\:mout \3\:n20 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.758e-14 ad=3.045e-14 ps=1.61e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.34e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n25 mout \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.758e-14 ad=2.465e-14 ps=1.61e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=9.6e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (\5\:n20 \6\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.045e-14 ps=6.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=7.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.045e-14 ps=4.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=4.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn25 (n21 \1\:D \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.85e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn21 (\14\:CKbb \8\:CKb \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mp20 (\15\:CKb \3\:CK \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=4.193e-14 ps=1.12e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.95e-07 sd=160n sca=12.8473 \
        scb=0.0101159 scc=8.80993e-05 m=(1)
mp45 (\14\:qbint \3\:n30 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.55e-14 ad=3.01e-14 ps=1.34e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.2815 scb=0.00760864 \
        scc=8.81378e-05 m=(1)
mp50 (n36 \5\:qbint \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.55e-14 ad=1.935e-14 ps=1.34e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp51 (\9\:n30 \2\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.515e-14 ps=6.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.975e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp40 (\9\:n30 CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.515e-14 ps=1.04e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.72e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp30 (\9\:mout \4\:n20 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.55e-14 ad=6.558e-14 ps=1.34e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.37e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp35 (n26 \4\:mout \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.55e-14 ad=1.29e-14 ps=1.34e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.105e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp36 (\9\:n20 \5\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.87e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=7.75e-07 sd=160n sca=10.5668 \
        scb=0.00768563 scc=8.81513e-05 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.913e-14 ps=7.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.55e-07 sd=160n sca=12.3276 \
        scb=0.00937389 scc=9.38578e-05 m=(1)
mp21 (\8\:CKbb \10\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.5e-07 sd=160n sca=16.5578 scb=0.0165885 \
        scc=0.000310105 m=(1)
ends DFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:27 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFQX2
// View name: extracted

simulator lang=spectre

subckt DFFQX2 CK D Q VDD VSS
mp20 (\22\:CKb \3\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
mp21 (\13\:CKbb CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.0642 scb=0.00864592 \
        scc=0.000148882 m=(1)
mp25 (n22 \3\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.472e-14 ps=7.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=6.773e-14 ps=6.6e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=2e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp36 (\5\:n20 \6\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.773e-14 ps=5.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.88884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp35 (n26 \4\:mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.245e-14 ad=1.29e-14 ps=1.44e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.78384e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp30 (\5\:mout n20 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.245e-14 ad=6.342e-14 ps=1.44e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.245e-06 sb=1.50884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp40 (\8\:n30 \8\:CKb \5\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.342e-14 ad=4.622e-14 ps=1.02e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.16884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp51 (\8\:n30 \4\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.622e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=9.08837e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp50 (n36 \10\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=2.687e-14 ps=1.22e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.38837e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
C1 (D VSS) capacitor c=3.79553e-17
C2 (Q VSS) capacitor c=4.50906e-17
C3 (VDD VSS) capacitor c=2.17429e-16
C4 (CK VSS) capacitor c=3.46156e-17
C5 (CKb VSS) capacitor c=5.71018e-17
C6 (CKbb VSS) capacitor c=6.95768e-17
C7 (n20 VSS) capacitor c=3.20066e-17
C8 (n25 VSS) capacitor c=1.40643e-18
C9 (mout VSS) capacitor c=2.02994e-17
C10 (n30 VSS) capacitor c=2.59989e-17
C11 (qbint VSS) capacitor c=1.55478e-16
C12 (n22 VSS) capacitor c=2.69733e-19
C13 (n26 VSS) capacitor c=1.67182e-18
C14 (n36 VSS) capacitor c=3.16269e-18
C15 (\3\:n30 VSS) capacitor c=5.83338e-17
C16 (\10\:qbint VSS) capacitor c=4.52251e-17
C17 (\4\:CKbb VSS) capacitor c=3.34139e-17
C18 (\8\:CKb VSS) capacitor c=3.29962e-17
C19 (\4\:mout VSS) capacitor c=7.7391e-17
C20 (\6\:CKb VSS) capacitor c=6.1751e-17
C21 (\3\:CKbb VSS) capacitor c=3.09697e-17
C22 (\3\:D VSS) capacitor c=7.23252e-17
C23 (\3\:CK VSS) capacitor c=2.47714e-17
C24 (\5\:qbint VSS) capacitor c=5.3671e-17
C25 (\10\:CKb VSS) capacitor c=9.1395e-17
C26 (\6\:CKbb VSS) capacitor c=5.21532e-17
C27 (\3\:n20 VSS) capacitor c=4.08263e-17
C28 (\3\:mout VSS) capacitor c=3.60742e-17
C29 (\4\:CKb VSS) capacitor c=5.84018e-17
C30 (\1\:D VSS) capacitor c=4.04106e-17
C31 (\2\:CKb VSS) capacitor c=4.33668e-17
C32 (\1\:CK VSS) capacitor c=2.45498e-17
C33 (\2\:n30 VSS) capacitor c=3.9248e-17
C34 (\5\:CKbb VSS) capacitor c=8.18108e-17
C35 (\11\:CKb VSS) capacitor c=3.35315e-17
C36 (\9\:CKb VSS) capacitor c=2.96759e-17
C37 (\2\:n20 VSS) capacitor c=4.34292e-17
C38 (\7\:CKb VSS) capacitor c=3.59375e-17
C39 (\5\:CKb VSS) capacitor c=2.70358e-17
C40 (\2\:CKbb VSS) capacitor c=7.47365e-17
C41 (\2\:D VSS) capacitor c=5.42191e-17
C42 (\3\:CKb VSS) capacitor c=2.10533e-17
C43 (\2\:CK VSS) capacitor c=2.32306e-17
C44 (\15\:qbint VSS) capacitor c=3.20955e-17
C45 (\1\:VDD VSS) capacitor c=1.44384e-16
C46 (\1\:Q VSS) capacitor c=5.36287e-17
C47 (\8\:n30 VSS) capacitor c=8.79883e-17
C48 (\5\:mout VSS) capacitor c=6.67015e-17
C49 (\12\:VDD VSS) capacitor c=3.28084e-17
C50 (\5\:n20 VSS) capacitor c=1.36616e-16
C51 (\14\:VDD VSS) capacitor c=3.68243e-17
C52 (\13\:CKbb VSS) capacitor c=1.62283e-17
C53 (\22\:CKb VSS) capacitor c=5.99311e-17
C54 (\16\:VDD VSS) capacitor c=2.49099e-17
C55 (\3\:VDD VSS) capacitor c=4.94851e-17
C56 (\11\:qbint VSS) capacitor c=3.72412e-17
C57 (\3\:Q VSS) capacitor c=5.76074e-17
C58 (\6\:n30 VSS) capacitor c=3.48847e-17
C59 (\9\:mout VSS) capacitor c=6.45407e-17
C60 (\7\:n20 VSS) capacitor c=7.49547e-17
C61 (\10\:CKbb VSS) capacitor c=8.28722e-17
C62 (\20\:CKb VSS) capacitor c=7.62102e-17
C63 (\2\:mout VSS) capacitor c=3.71953e-17
C64 (\4\:qbint VSS) capacitor c=4.85441e-17
C65 (\4\:CK VSS) capacitor c=5.73996e-17
C66 (\4\:D VSS) capacitor c=5.47495e-17
C67 (\4\:n20 VSS) capacitor c=7.94588e-17
C68 (\7\:mout VSS) capacitor c=7.25563e-17
C69 (\8\:mout VSS) capacitor c=5.259e-17
C70 (\12\:CKb VSS) capacitor c=9.10613e-17
C71 (\13\:CKb VSS) capacitor c=1.34543e-16
C72 (\14\:CKb VSS) capacitor c=1.41283e-16
C73 (\15\:CKb VSS) capacitor c=8.54915e-17
C74 (\16\:CKb VSS) capacitor c=7.38109e-17
C75 (\17\:CKb VSS) capacitor c=4.10219e-17
C76 (\18\:CKb VSS) capacitor c=5.22818e-17
C77 (\7\:CKbb VSS) capacitor c=1.91929e-16
C78 (\8\:CKbb VSS) capacitor c=2.01052e-16
C79 (\9\:CKbb VSS) capacitor c=5.71957e-17
C80 (\12\:CKbb VSS) capacitor c=2.44665e-17
C81 (\4\:n30 VSS) capacitor c=1.5403e-16
C82 (\5\:n30 VSS) capacitor c=1.46112e-16
C83 (\13\:qbint VSS) capacitor c=4.28456e-17
C84 (\14\:qbint VSS) capacitor c=5.32853e-17
C85 (\6\:VDD VSS) capacitor c=3.97174e-17
C86 (\8\:VDD VSS) capacitor c=1.38834e-17
C87 (\9\:VDD VSS) capacitor c=1.02255e-17
Rk32 (\1\:VSS \6\:VSS) resistor r=0.5061 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.2907 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.08506 c=0
Rk36 (\9\:VSS VSS) resistor r=0.06475 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.4008 c=0
Rk38 (\6\:VSS \13\:VSS) resistor r=0.3394 c=0
Rk39 (\8\:VSS \15\:VSS) resistor r=0.07381 c=0
Rk40 (\9\:VSS \17\:VSS) resistor r=0.274 c=0
Rk2 (\4\:D D) resistor r=0.07782 c=0
Rk22 (\2\:Q Q) resistor r=0.2095 c=0
Rk23 (Q \4\:Q) resistor r=0.181 c=0
Rk43 (\1\:VDD \6\:VDD) resistor r=0.5237 c=0
Rk44 (\6\:VDD \7\:VDD) resistor r=0.2907 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.1252 c=0
Rk47 (\9\:VDD VDD) resistor r=0.03967 c=0
Rk46 (\8\:VDD \9\:VDD) resistor r=0.3857 c=0
Rk49 (\6\:VDD \13\:VDD) resistor r=0.1025 c=0
Rk50 (\8\:VDD \15\:VDD) resistor r=0.2607 c=0
Rk51 (\9\:VDD \17\:VDD) resistor r=0.4175 c=0
Rk1 (\4\:CK CK) resistor r=0.1131 c=0
Rk8 (\12\:CKb \13\:CKb) resistor r=0.4726 c=0
Rk9 (\13\:CKb \14\:CKb) resistor r=0.7688 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.4674 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.338 c=0
Rk12 (\13\:CKb \17\:CKb) resistor r=0.1955 c=0
Rk13 (\14\:CKb \18\:CKb) resistor r=0.2742 c=0
Rk14 (\15\:CKb \19\:CKb) resistor r=0.01531 c=0
Rk15 (\16\:CKb \21\:CKb) resistor r=0.3292 c=0
Rk16 (\21\:CKb \23\:CKb) resistor r=0.3733 c=0
Rk17 (\7\:CKbb \8\:CKbb) resistor r=1.5026 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.2767 c=0
Rk19 (\9\:CKbb \11\:CKbb) resistor r=0.4206 c=0
Rk20 (\8\:CKbb \12\:CKbb) resistor r=0.06418 c=0
Rk21 (\9\:CKbb \14\:CKbb) resistor r=0.06451 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.5397 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.4964 c=0
Rk5 (\6\:mout \7\:mout) resistor r=0.3384 c=0
Rk6 (\7\:mout \8\:mout) resistor r=0.2362 c=0
Rk7 (\7\:mout \10\:mout) resistor r=0.2676 c=0
Rk24 (\4\:n30 \5\:n30) resistor r=1.035 c=0
Rk25 (\5\:n30 \7\:n30) resistor r=0.07036 c=0
Rk26 (\5\:n30 \9\:n30) resistor r=0.392 c=0
Rk27 (\12\:qbint \13\:qbint) resistor r=0.3325 c=0
Rk28 (\13\:qbint \14\:qbint) resistor r=0.187 c=0
Rk29 (\13\:qbint \16\:qbint) resistor r=0.1416 c=0
Rl6 (\2\:D \3\:D) resistor r=147.872 c=0
Rl5 (\1\:D \2\:D) resistor r=42.5711 c=0
Rl2 (\2\:CK \3\:CK) resistor r=70.6044 c=0
Rl1 (\1\:CK \2\:CK) resistor r=49.2678 c=0
Rl3 (CKb \2\:CKb) resistor r=217.308 c=0
Rl17 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl16 (\8\:CKb \9\:CKb) resistor r=66.0643 c=0
Rl10 (\6\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=48.7687 c=0
Rl4 (\2\:CKb \3\:CKb) resistor r=33.7903 c=0
Rl18 (\4\:CKbb \5\:CKbb) resistor r=35.7713 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=202.028 c=0
Rl9 (\2\:CKbb \3\:CKbb) resistor r=29.5379 c=0
Rl8 (CKbb \2\:CKbb) resistor r=246.411 c=0
Rl14 (n20 \2\:n20) resistor r=29.5379 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=162.23 c=0
Rl13 (\2\:mout \4\:mout) resistor r=111.253 c=0
Rl12 (\2\:mout \3\:mout) resistor r=97.7911 c=0
Rl11 (mout \2\:mout) resistor r=4.3192 c=0
Rl30 (\2\:n30 \3\:n30) resistor r=110.031 c=0
Rl29 (n30 \2\:n30) resistor r=30.2349 c=0
Rl25 (\7\:qbint qbint) resistor r=4.7234 c=0
Rl28 (\4\:qbint \10\:qbint) resistor r=109.297 c=0
Rl22 (\4\:qbint qbint) resistor r=102.948 c=0
Rl23 (\4\:qbint \5\:qbint) resistor r=115.362 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz5 (\4\:Q \3\:Q) resistor r=75 c=0
Rz13 (\1\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz14 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz3 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz4 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz7 (\12\:qbint \11\:qbint) resistor r=75 c=0
Ry8 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry9 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry5 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry12 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry3 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry4 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\16\:qbint \15\:qbint) resistor r=31 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx5 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\11\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\7\:CKb \18\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \19\:CKb) resistor r=45 c=0
Rx10 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx12 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx13 (\14\:qbint \7\:qbint) resistor r=45 c=0
mn20 (\20\:CKb \1\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\10\:CKbb \2\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.49e-14 ad=2.683e-14 ps=1.53e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn25 (n21 \1\:D \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=1.958e-14 ps=1.53e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn26 (\7\:n20 \4\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\7\:n20 CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.248e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.995e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (\9\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.335e-14 ad=5.075e-14 ps=7.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.72e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn40 (\6\:n30 \6\:CKbb \9\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.32e-14 ps=9.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=1.325e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\6\:n30 \10\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=1.12e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn50 (n35 \5\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.038e-14 ad=8.7e-15 ps=1.13e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=1.015e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn55 (\3\:Q qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.113e-14 ad=4.16e-14 ps=1.1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1775e-06 sb=5.88846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\11\:qbint n30 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.188e-14 ad=2.87e-14 ps=1.07e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62024e-06 sb=1.4e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mp55_1__rcx (\1\:Q qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.12e-14 ad=6.825e-14 ps=1.16e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=5.14744e-07 sd=160n sca=17.596 \
        scb=0.015375 scc=0.00137895 m=(2)
mp45 (\15\:qbint \3\:n30 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16734e-06 sb=1.4e-07 sd=160n sca=23.2035 \
        scb=0.0225719 scc=0.00178254 m=(1)
ends DFFQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:28 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFQX4
// View name: extracted

simulator lang=spectre

subckt DFFQX4 CK D Q VDD VSS
mp20 (\19\:CKb \1\:CK \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30209e-06 sd=160n sca=27.0129 \
        scb=0.0266904 scc=0.00248953 m=(1)
mp50 (n36 \18\:qbint \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=2.902e-14 ps=1.02e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41558e-06 sb=1.98e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp51 (\12\:n30 \2\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59558e-06 sb=1.8e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp40 (\12\:n30 CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.3e-14 ps=1.04e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83314e-06 sb=1.555e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp30 (\8\:mout n20 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=6.558e-14 ps=1.42e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.205e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp35 (n26 mout \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=2.472e-14 ps=1.42e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.4e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp36 (\7\:n20 \4\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.515e-14 ps=6.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.8e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp26 (\7\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.25e-07 sd=160n sca=10.9637 \
        scb=0.00861453 scc=0.000148875 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=11.5483 scb=0.0088999 \
        scc=0.00014904 m=(1)
mp21 (\16\:CKbb \10\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.0147 scb=0.0105811 \
        scc=0.000156391 m=(1)
C1 (D VSS) capacitor c=4.76678e-17
C2 (VDD VSS) capacitor c=2.75113e-16
C3 (Q VSS) capacitor c=3.03194e-16
C4 (CK VSS) capacitor c=4.75954e-17
C5 (CKb VSS) capacitor c=7.63843e-17
C6 (qbint VSS) capacitor c=3.20458e-16
C7 (n30 VSS) capacitor c=2.24451e-16
C8 (mout VSS) capacitor c=8.31331e-17
C9 (CKbb VSS) capacitor c=4.33082e-17
C10 (n20 VSS) capacitor c=3.31623e-17
C11 (n25 VSS) capacitor c=1.96538e-18
C12 (n21 VSS) capacitor c=2.31908e-18
C13 (n36 VSS) capacitor c=2.07421e-18
C14 (n26 VSS) capacitor c=3.20347e-18
C15 (n22 VSS) capacitor c=5.15807e-19
C16 (\10\:CKb VSS) capacitor c=5.10436e-17
C17 (\1\:D VSS) capacitor c=6.6795e-17
C18 (\5\:CKbb VSS) capacitor c=3.01848e-17
C19 (\4\:CKb VSS) capacitor c=4.51525e-17
C20 (\2\:CKbb VSS) capacitor c=3.84098e-17
C21 (\18\:qbint VSS) capacitor c=5.96333e-17
C22 (\1\:CK VSS) capacitor c=4.93443e-17
C23 (\8\:CKb VSS) capacitor c=2.26414e-17
C24 (\3\:D VSS) capacitor c=5.31715e-17
C25 (\6\:CKb VSS) capacitor c=5.59526e-17
C26 (\7\:CKbb VSS) capacitor c=7.82048e-17
C27 (\3\:mout VSS) capacitor c=3.78237e-17
C28 (\3\:n20 VSS) capacitor c=5.62278e-17
C29 (\3\:CKbb VSS) capacitor c=4.63462e-17
C30 (\2\:CKb VSS) capacitor c=6.98147e-17
C31 (\16\:qbint VSS) capacitor c=5.25016e-17
C32 (\3\:CK VSS) capacitor c=3.25493e-17
C33 (\9\:CKb VSS) capacitor c=4.5158e-17
C34 (\2\:D VSS) capacitor c=5.57532e-17
C35 (\7\:CKb VSS) capacitor c=4.91121e-17
C36 (\6\:CKbb VSS) capacitor c=7.03663e-17
C37 (\5\:CKb VSS) capacitor c=4.90905e-17
C38 (\2\:mout VSS) capacitor c=5.0236e-17
C39 (\4\:n20 VSS) capacitor c=3.0028e-17
C40 (\4\:CKbb VSS) capacitor c=5.17121e-17
C41 (\3\:CKb VSS) capacitor c=2.91095e-17
C42 (\17\:qbint VSS) capacitor c=6.15673e-17
C43 (\2\:CK VSS) capacitor c=3.66696e-17
C44 (\16\:CKbb VSS) capacitor c=2.22876e-17
C45 (\1\:VDD VSS) capacitor c=3.72484e-17
C46 (\7\:n20 VSS) capacitor c=1.06454e-16
C47 (\11\:VDD VSS) capacitor c=1.81076e-17
C48 (\8\:mout VSS) capacitor c=7.97445e-17
C49 (\12\:n30 VSS) capacitor c=4.19157e-17
C50 (\25\:qbint VSS) capacitor c=7.723e-17
C51 (\19\:CKb VSS) capacitor c=7.0124e-17
C52 (\3\:VDD VSS) capacitor c=5.30237e-17
C53 (\13\:CKbb VSS) capacitor c=4.87803e-17
C54 (\5\:n20 VSS) capacitor c=1.00626e-16
C55 (\6\:mout VSS) capacitor c=3.41494e-17
C56 (\8\:n30 VSS) capacitor c=6.84768e-17
C57 (\19\:qbint VSS) capacitor c=2.91187e-17
C58 (\17\:CKb VSS) capacitor c=2.10137e-16
C59 (\2\:n20 VSS) capacitor c=3.00244e-17
C60 (\4\:CK VSS) capacitor c=6.66497e-17
C61 (\21\:qbint VSS) capacitor c=1.8525e-17
C62 (\22\:qbint VSS) capacitor c=2.57867e-17
C63 (\23\:qbint VSS) capacitor c=2.62635e-17
C64 (\24\:qbint VSS) capacitor c=3.50693e-17
C65 (\10\:n30 VSS) capacitor c=7.35668e-17
C66 (\11\:n30 VSS) capacitor c=4.68514e-17
C67 (\4\:mout VSS) capacitor c=4.06773e-17
C68 (\5\:mout VSS) capacitor c=5.13369e-17
C69 (\9\:n20 VSS) capacitor c=5.861e-17
C70 (\4\:D VSS) capacitor c=6.92608e-17
C71 (\11\:CKb VSS) capacitor c=3.54224e-17
C72 (\12\:CKb VSS) capacitor c=5.93252e-17
C73 (\13\:CKb VSS) capacitor c=1.29206e-16
C74 (\14\:CKb VSS) capacitor c=2.20398e-16
C75 (\15\:CKb VSS) capacitor c=7.89197e-17
C76 (\16\:CKb VSS) capacitor c=7.95253e-17
C77 (\8\:CKbb VSS) capacitor c=2.11626e-17
C78 (\9\:CKbb VSS) capacitor c=1.52613e-16
C79 (\10\:CKbb VSS) capacitor c=1.37845e-16
C80 (\11\:CKbb VSS) capacitor c=3.94873e-17
C81 (\12\:CKbb VSS) capacitor c=6.43175e-17
C82 (\15\:CKbb VSS) capacitor c=3.65563e-17
C83 (\5\:VDD VSS) capacitor c=3.62981e-17
C84 (\6\:VDD VSS) capacitor c=3.08479e-16
Rk21 (D \4\:D) resistor r=0.165 c=0
Rk49 (\2\:VDD \4\:VDD) resistor r=0.4073 c=0
Rk50 (\4\:VDD \5\:VDD) resistor r=0.2671 c=0
Rk56 (\6\:VDD VDD) resistor r=0.1926 c=0
Rk51 (\5\:VDD \6\:VDD) resistor r=0.5251 c=0
Rk57 (\5\:VDD \12\:VDD) resistor r=0.04329 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.3813 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.2671 c=0
Rk43 (\6\:VSS VSS) resistor r=0.16 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.4675 c=0
Rk44 (\5\:VSS \12\:VSS) resistor r=0.04329 c=0
Rk1 (CK \4\:CK) resistor r=0.1079 c=0
Rk22 (\11\:CKb \12\:CKb) resistor r=0.1131 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.3928 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.6575 c=0
Rk25 (\12\:CKb \15\:CKb) resistor r=0.3152 c=0
Rk26 (\13\:CKb \16\:CKb) resistor r=0.4265 c=0
Rk27 (\14\:CKb \18\:CKb) resistor r=1.4894 c=0
Rk28 (\18\:CKb \20\:CKb) resistor r=0.5291 c=0
Rk8 (\20\:qbint \21\:qbint) resistor r=0.1331 c=0
Rk9 (\21\:qbint \22\:qbint) resistor r=0.1007 c=0
Rk10 (\22\:qbint \23\:qbint) resistor r=0.174 c=0
Rk11 (\21\:qbint \24\:qbint) resistor r=0.1535 c=0
Rk12 (\22\:qbint \26\:qbint) resistor r=0.308 c=0
Rk13 (\9\:n30 \10\:n30) resistor r=0.4949 c=0
Rk14 (\10\:n30 \11\:n30) resistor r=0.2049 c=0
Rk15 (\10\:n30 \13\:n30) resistor r=0.2732 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1764 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1545 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3156 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=0.05668 c=0
Rk30 (\9\:CKbb \10\:CKbb) resistor r=1.1163 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.1424 c=0
Rk32 (\9\:CKbb \12\:CKbb) resistor r=0.3008 c=0
Rk33 (\12\:CKbb \14\:CKbb) resistor r=0.3945 c=0
Rk34 (\10\:CKbb \15\:CKbb) resistor r=0.1848 c=0
Rk35 (\12\:CKbb \17\:CKbb) resistor r=0.0384 c=0
Rk19 (\6\:n20 \8\:n20) resistor r=0.5348 c=0
Rk20 (\8\:n20 \9\:n20) resistor r=0.3942 c=0
Rl38 (\1\:D \2\:D) resistor r=143 c=0
Rl39 (\2\:D \3\:D) resistor r=48.7687 c=0
Rl1 (\1\:CK \2\:CK) resistor r=112.07 c=0
Rl2 (\2\:CK \3\:CK) resistor r=25.2509 c=0
Rl26 (CKb \2\:CKb) resistor r=249.566 c=0
Rl41 (\9\:CKb \10\:CKb) resistor r=157.487 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=26.0911 c=0
Rl35 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=71.8456 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=26.1559 c=0
Rl24 (\17\:qbint \18\:qbint) resistor r=122.872 c=0
Rl23 (\17\:qbint \16\:qbint) resistor r=90.3618 c=0
Rl32 (mout \2\:mout) resistor r=152.615 c=0
Rl33 (\2\:mout \3\:mout) resistor r=39.1533 c=0
Rl36 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl37 (\6\:CKbb \7\:CKbb) resistor r=226.043 c=0
Rl28 (\3\:CKbb \4\:CKbb) resistor r=98.7687 c=0
Rl25 (CKbb \2\:CKbb) resistor r=57.6695 c=0
Rl29 (n20 \2\:n20) resistor r=55.0028 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=158.849 c=0
Rl31 (\2\:n20 \4\:n20) resistor r=29.6836 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz16 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry11 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry10 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry7 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry3 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\7\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \14\:CKb) resistor r=45 c=0
Rx10 (\9\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx2 (\23\:qbint qbint) resistor r=45 c=0
Rx3 (\24\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx13 (CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\4\:n20 \9\:n20) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.485e-14 ad=3.698e-14 ps=1.45e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (n35 \16\:qbint \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.102e-14 ps=1.57e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 \2\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=2.755e-14 ps=5.8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.83e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \3\:CKbb \6\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.755e-14 ps=6.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.595e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\6\:mout \3\:n20 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.39e-14 ad=2.9e-14 ps=1.43e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.35e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=2.102e-14 ps=1.43e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.085e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\5\:n20 \7\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=3.625e-14 ps=5.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.95e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=3.625e-14 ps=4.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=9.42e-15 ps=1e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn21 (\13\:CKbb \8\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.81e-14 ad=3.262e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn55_1__rcx (Q qbint \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.707e-14 ad=4.16e-14 ps=1.435e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.00769e-07 sb=1.58144e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn45 (\19\:qbint n30 \6\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.172e-14 ad=3.28e-14 ps=1.5e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29463e-06 sb=1.5039e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(2)
mp55_1__rcx (Q qbint \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.857e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=1.52327e-06 sd=160n sca=18.6696 \
        scb=0.0162362 scc=0.00138051 m=(4)
mp45_1__rcx (\25\:qbint n30 \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.505e-14 ad=4.96e-14 ps=1.06e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02669e-06 sb=1.48056e-06 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(2)
ends DFFQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:30 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFQXL
// View name: extracted

simulator lang=spectre

subckt DFFQXL CK D Q VDD VSS
mp55 (\3\:Q \4\:qbint \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.01e-14 ps=8.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=23.8733 \
        scb=0.0264891 scc=0.00148688 m=(1)
mp20 (\18\:CKb \1\:CK \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=4.085e-14 ps=8.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.9e-07 sd=160n sca=12.9231 scb=0.0102616 \
        scc=9.6055e-05 m=(1)
mp45 (\13\:qbint \3\:n30 \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3005 scb=0.00749164 \
        scc=8.05168e-05 m=(1)
mp50 (n36 \5\:qbint \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.15e-14 ps=1.32e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.955e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\9\:n30 \2\:CKbb n36 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.81e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\9\:n30 CKb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.87e-14 ps=1.03e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.585e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp30 (\9\:mout n20 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.538e-14 ad=6.45e-14 ps=1.33e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.24e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp35 (n26 \4\:mout \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.538e-14 ad=2.043e-14 ps=1.33e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.7e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp36 (\5\:n20 \5\:CKb n26 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.043e-14 ad=3.44e-14 ps=6.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=8.3e-07 sd=160n sca=10.3563 \
        scb=0.00750569 scc=8.05187e-05 m=(1)
mp26 (\5\:n20 \5\:CKbb n22 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.44e-14 ps=8.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.735e-06 sb=6.25e-07 sd=160n sca=11.0447 \
        scb=0.00786221 scc=8.0761e-05 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.623e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=3.65e-07 sd=160n sca=13.4702 \
        scb=0.0111763 scc=0.0001097 m=(1)
mp21 (\8\:CKbb \8\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=21.8638 scb=0.0242315 \
        scc=0.00109598 m=(1)
C1 (Q VSS) capacitor c=4.57167e-17
C2 (D VSS) capacitor c=7.02969e-17
C3 (VDD VSS) capacitor c=2.61571e-16
C4 (CK VSS) capacitor c=5.87867e-17
C5 (qbint VSS) capacitor c=1.74067e-17
C6 (CKb VSS) capacitor c=2.36739e-17
C7 (n30 VSS) capacitor c=4.36045e-17
C8 (n35 VSS) capacitor c=1.49475e-18
C9 (mout VSS) capacitor c=3.47679e-17
C10 (CKbb VSS) capacitor c=5.12176e-17
C11 (n20 VSS) capacitor c=5.51364e-17
C12 (n25 VSS) capacitor c=1.70374e-18
C13 (n21 VSS) capacitor c=1.29587e-18
C14 (n36 VSS) capacitor c=1.59823e-18
C15 (n26 VSS) capacitor c=2.23864e-18
C16 (n22 VSS) capacitor c=3.46284e-18
C17 (\8\:CKb VSS) capacitor c=4.92129e-17
C18 (\1\:D VSS) capacitor c=4.03321e-17
C19 (\5\:CKbb VSS) capacitor c=8.09065e-17
C20 (\5\:CKb VSS) capacitor c=4.67115e-17
C21 (\4\:mout VSS) capacitor c=8.68203e-17
C22 (\2\:CKbb VSS) capacitor c=4.63158e-17
C23 (\5\:qbint VSS) capacitor c=8.11339e-17
C24 (\3\:n30 VSS) capacitor c=4.7851e-17
C25 (\1\:CK VSS) capacitor c=3.47766e-17
C26 (\4\:qbint VSS) capacitor c=4.488e-17
C27 (\11\:CKb VSS) capacitor c=3.81159e-17
C28 (\3\:D VSS) capacitor c=8.99021e-17
C29 (\6\:CKb VSS) capacitor c=7.16399e-17
C30 (\6\:CKbb VSS) capacitor c=8.07412e-17
C31 (\3\:n20 VSS) capacitor c=5.25897e-17
C32 (\3\:CKbb VSS) capacitor c=2.46541e-17
C33 (\3\:CKb VSS) capacitor c=9.21043e-17
C34 (\8\:qbint VSS) capacitor c=4.60217e-17
C35 (\3\:CK VSS) capacitor c=4.58515e-17
C36 (\3\:qbint VSS) capacitor c=2.50931e-17
C37 (\10\:CKb VSS) capacitor c=3.05726e-17
C38 (\2\:D VSS) capacitor c=7.63021e-17
C39 (\7\:CKb VSS) capacitor c=5.66139e-17
C40 (\7\:CKbb VSS) capacitor c=3.02187e-17
C41 (\4\:CKb VSS) capacitor c=4.78657e-17
C42 (\3\:mout VSS) capacitor c=3.16856e-17
C43 (\4\:n20 VSS) capacitor c=3.15524e-17
C44 (\4\:CKbb VSS) capacitor c=5.32992e-17
C45 (\2\:CKb VSS) capacitor c=8.40136e-17
C46 (\7\:qbint VSS) capacitor c=2.74598e-17
C47 (\4\:n30 VSS) capacitor c=1.75928e-17
C48 (\2\:CK VSS) capacitor c=3.79036e-17
C49 (\8\:CKbb VSS) capacitor c=6.55304e-17
C50 (\1\:VDD VSS) capacitor c=3.19124e-17
C51 (\5\:n20 VSS) capacitor c=7.62894e-17
C52 (\9\:VDD VSS) capacitor c=2.35555e-17
C53 (\9\:mout VSS) capacitor c=7.32883e-17
C54 (\9\:n30 VSS) capacitor c=7.62039e-17
C55 (\11\:VDD VSS) capacitor c=2.3952e-17
C56 (\13\:qbint VSS) capacitor c=6.50326e-17
C57 (\18\:CKb VSS) capacitor c=1.47711e-16
C58 (\13\:VDD VSS) capacitor c=3.1556e-17
C59 (\3\:Q VSS) capacitor c=6.26179e-17
C60 (\3\:VDD VSS) capacitor c=7.65565e-17
C61 (\14\:CKbb VSS) capacitor c=1.40934e-17
C62 (\8\:n20 VSS) capacitor c=7.64957e-17
C63 (\7\:mout VSS) capacitor c=5.85906e-17
C64 (\5\:n30 VSS) capacitor c=6.42328e-17
C65 (\11\:qbint VSS) capacitor c=8.40884e-17
C66 (\20\:CKb VSS) capacitor c=8.77851e-17
C67 (\1\:Q VSS) capacitor c=2.04527e-17
C68 (\2\:qbint VSS) capacitor c=2.82575e-17
C69 (\2\:n30 VSS) capacitor c=3.98092e-17
C70 (\6\:qbint VSS) capacitor c=5.71319e-17
C71 (\2\:n20 VSS) capacitor c=4.40884e-17
C72 (\2\:mout VSS) capacitor c=5.56009e-17
C73 (\9\:CKb VSS) capacitor c=4.16644e-17
C74 (\4\:CK VSS) capacitor c=6.34944e-17
C75 (\9\:qbint VSS) capacitor c=4.49371e-17
C76 (\10\:qbint VSS) capacitor c=6.29702e-17
C77 (\15\:qbint VSS) capacitor c=1.20646e-16
C78 (\7\:n30 VSS) capacitor c=8.14991e-17
C79 (\8\:n30 VSS) capacitor c=3.94853e-17
C80 (\5\:mout VSS) capacitor c=3.52393e-17
C81 (\6\:mout VSS) capacitor c=6.26898e-17
C82 (\7\:n20 VSS) capacitor c=8.62377e-17
C83 (\10\:n20 VSS) capacitor c=3.6781e-17
C84 (\4\:D VSS) capacitor c=5.84151e-17
C85 (\12\:CKb VSS) capacitor c=4.6938e-17
C86 (\13\:CKb VSS) capacitor c=6.30568e-17
C87 (\14\:CKb VSS) capacitor c=1.33497e-16
C88 (\15\:CKb VSS) capacitor c=3.99857e-17
C89 (\16\:CKb VSS) capacitor c=2.10358e-16
C90 (\17\:CKb VSS) capacitor c=4.82051e-17
C91 (\10\:CKbb VSS) capacitor c=1.18761e-16
C92 (\11\:CKbb VSS) capacitor c=2.22878e-16
C93 (\12\:CKbb VSS) capacitor c=1.41745e-16
C94 (\13\:CKbb VSS) capacitor c=6.02782e-17
C95 (\16\:CKbb VSS) capacitor c=2.32758e-17
C96 (\5\:VDD VSS) capacitor c=4.46234e-17
C97 (\7\:VDD VSS) capacitor c=1.95569e-17
C98 (\8\:VDD VSS) capacitor c=1.8889e-17
Rk1 (Q \2\:Q) resistor r=0.06644 c=0
Rk2 (Q \4\:Q) resistor r=0.3533 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.2338 c=0
Rk41 (\3\:VSS \5\:VSS) resistor r=0.07524 c=0
Rk42 (\5\:VSS \6\:VSS) resistor r=0.4323 c=0
Rk43 (\6\:VSS \7\:VSS) resistor r=0.372 c=0
Rk45 (\8\:VSS VSS) resistor r=0.1026 c=0
Rk44 (\3\:VSS \8\:VSS) resistor r=0.3743 c=0
Rk46 (\6\:VSS \10\:VSS) resistor r=0.1268 c=0
Rk47 (\7\:VSS \12\:VSS) resistor r=0.2645 c=0
Rk48 (\8\:VSS \14\:VSS) resistor r=0.357 c=0
Rk17 (D \4\:D) resistor r=0.04824 c=0
Rk31 (\2\:VDD \4\:VDD) resistor r=0.2655 c=0
Rk32 (\4\:VDD \5\:VDD) resistor r=0.3861 c=0
Rk33 (\5\:VDD \6\:VDD) resistor r=0.4163 c=0
Rk34 (\6\:VDD \7\:VDD) resistor r=0.07429 c=0
Rk36 (\8\:VDD VDD) resistor r=0.1026 c=0
Rk35 (\7\:VDD \8\:VDD) resistor r=0.3733 c=0
Rk37 (\5\:VDD \10\:VDD) resistor r=0.04347 c=0
Rk38 (\7\:VDD \12\:VDD) resistor r=0.04347 c=0
Rk39 (\8\:VDD \14\:VDD) resistor r=0.2273 c=0
Rk3 (\4\:CK CK) resistor r=0.1139 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1556 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1738 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.4618 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.6677 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.2242 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2606 c=0
Rk20 (\14\:CKb \15\:CKb) resistor r=0.1471 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=1.0145 c=0
Rk22 (\16\:CKb \17\:CKb) resistor r=0.2321 c=0
Rk23 (\16\:CKb \19\:CKb) resistor r=0.9118 c=0
Rk24 (\19\:CKb \21\:CKb) resistor r=0.5318 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.4182 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.1518 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.4062 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.09664 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.2571 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.5103 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.5479 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.6888 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=1.2013 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.3686 c=0
Rk29 (\10\:CKbb \15\:CKbb) resistor r=0.06536 c=0
Rk30 (\12\:CKbb \16\:CKbb) resistor r=0.08203 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.4788 c=0
Rk15 (\7\:n20 \9\:n20) resistor r=0.4426 c=0
Rk16 (\7\:n20 \10\:n20) resistor r=0.1181 c=0
Rl26 (\1\:D \2\:D) resistor r=103.365 c=0
Rl27 (\2\:D \3\:D) resistor r=158.414 c=0
Rl4 (\1\:CK \2\:CK) resistor r=94.9225 c=0
Rl5 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=164.264 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=46.9565 c=0
Rl1 (qbint \2\:qbint) resistor r=2.4834 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=226.637 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=47.791 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=6.708 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=64.0519 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=314.183 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=177.726 c=0
Rl30 (\9\:CKb \11\:CKb) resistor r=95.0334 c=0
Rl29 (\9\:CKb \10\:CKb) resistor r=2.4801 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=151.431 c=0
Rl6 (n30 \2\:n30) resistor r=121.99 c=0
Rl8 (\2\:n30 \4\:n30) resistor r=3.8588 c=0
Rl21 (\2\:mout \4\:mout) resistor r=219.894 c=0
Rl19 (mout \2\:mout) resistor r=50.3084 c=0
Rl20 (\2\:mout \3\:mout) resistor r=16.1277 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=299.934 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=81.0266 c=0
Rl12 (CKbb \2\:CKbb) resistor r=65.2137 c=0
Rl16 (n20 \2\:n20) resistor r=162.695 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=116.541 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=31.6066 c=0
Rz1 (\1\:Q \2\:Q) resistor r=75 c=0
Rz10 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz11 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz12 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\3\:Q \4\:Q) resistor r=62 c=0
Ry12 (\4\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry13 (\4\:VSS \7\:VSS) resistor r=15.5 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry6 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\5\:n20 \6\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx8 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (CKbb \13\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx6 (\4\:n20 \10\:n20) resistor r=45 c=0
mn55 (\1\:Q \3\:qbint \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn20 (\20\:CKb \3\:CK \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.9e-14 ps=7.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn45 (\11\:qbint n30 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn50 (n35 \8\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=8.7e-15 ps=6.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.935e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.06e-14 ps=4.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.83e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn40 (\5\:n30 \3\:CKbb \7\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=4.06e-14 ps=7.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.505e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn30 (\7\:mout \3\:n20 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.86e-14 ad=3.48e-14 ps=1.15e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.22e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn35 (n25 mout \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.86e-14 ad=1.813e-14 ps=1.15e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=8.95e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn36 (\8\:n20 \6\:CKbb n25 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.813e-14 ad=2.32e-14 ps=5.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=7.25e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn26 (\8\:n20 \6\:CKb n21 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=5.2e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn25 (n21 \3\:D \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.61e-14 ad=1.015e-14 ps=8e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=4.05e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn21 (\14\:CKbb \11\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.61e-14 ad=2.03e-14 ps=8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
ends DFFQXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:31 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRHQX1
// View name: extracted

simulator lang=spectre

subckt DFFRHQX1 CK D Q RN VDD VSS
mp55 (\1\:Q qbint \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.61346e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
C1 (Q VSS) capacitor c=4.49951e-17
C2 (CK VSS) capacitor c=5.00619e-17
C3 (D VSS) capacitor c=4.62016e-17
C4 (VDD VSS) capacitor c=2.37202e-16
C5 (qbint VSS) capacitor c=5.37814e-17
C6 (CKb VSS) capacitor c=4.97774e-17
C7 (n35 VSS) capacitor c=1.23531e-18
C8 (n30 VSS) capacitor c=5.94898e-17
C9 (n40 VSS) capacitor c=1.30342e-18
C10 (mout VSS) capacitor c=5.38733e-17
C11 (CKbb VSS) capacitor c=2.51902e-17
C12 (n20 VSS) capacitor c=5.05968e-17
C13 (n21 VSS) capacitor c=1.23445e-18
C14 (n41 VSS) capacitor c=1.08267e-18
C15 (n26 VSS) capacitor c=1.20354e-16
C16 (n22 VSS) capacitor c=9.87314e-20
C17 (\8\:CKb VSS) capacitor c=2.85359e-17
C18 (\1\:D VSS) capacitor c=1.11298e-16
C19 (\6\:CKbb VSS) capacitor c=7.02065e-17
C20 (\5\:CKb VSS) capacitor c=3.64428e-17
C21 (\1\:RN VSS) capacitor c=1.42616e-16
C22 (\3\:CKb VSS) capacitor c=3.79559e-17
C23 (\3\:CKbb VSS) capacitor c=9.35877e-17
C24 (\4\:qbint VSS) capacitor c=9.03406e-17
C25 (\2\:RN VSS) capacitor c=1.05385e-16
C26 (\3\:n30 VSS) capacitor c=5.66571e-17
C27 (\1\:CK VSS) capacitor c=3.62963e-17
C28 (\10\:CKb VSS) capacitor c=4.6685e-17
C29 (\3\:D VSS) capacitor c=7.18923e-17
C30 (\7\:CKb VSS) capacitor c=6.96053e-17
C31 (\4\:CKbb VSS) capacitor c=4.19606e-17
C32 (\3\:mout VSS) capacitor c=5.42261e-17
C33 (\5\:RN VSS) capacitor c=7.13108e-17
C34 (\3\:n20 VSS) capacitor c=4.81596e-17
C35 (\6\:qbint VSS) capacitor c=5.81999e-17
C36 (\4\:RN VSS) capacitor c=8.08593e-17
C37 (\3\:CK VSS) capacitor c=4.73568e-17
C38 (\3\:qbint VSS) capacitor c=3.26871e-17
C39 (\9\:CKb VSS) capacitor c=5.12762e-17
C40 (\2\:D VSS) capacitor c=6.84267e-17
C41 (\7\:CKbb VSS) capacitor c=5.17329e-17
C42 (\6\:CKb VSS) capacitor c=4.57864e-17
C43 (\5\:CKbb VSS) capacitor c=3.74601e-17
C44 (\2\:mout VSS) capacitor c=6.19949e-17
C45 (\2\:n20 VSS) capacitor c=4.58148e-17
C46 (\4\:CKb VSS) capacitor c=3.11925e-17
C47 (\2\:CKbb VSS) capacitor c=7.497e-17
C48 (\2\:CKb VSS) capacitor c=5.63669e-17
C49 (\5\:qbint VSS) capacitor c=7.87274e-17
C50 (\3\:RN VSS) capacitor c=5.28322e-17
C51 (\2\:n30 VSS) capacitor c=4.22487e-17
C52 (\2\:CK VSS) capacitor c=4.75037e-17
C53 (\2\:qbint VSS) capacitor c=3.4983e-17
C54 (\12\:CKbb VSS) capacitor c=3.53364e-17
C55 (\1\:VDD VSS) capacitor c=6.65964e-17
C56 (\4\:n20 VSS) capacitor c=1.20274e-16
C57 (\8\:VDD VSS) capacitor c=5.8644e-17
C58 (\3\:n26 VSS) capacitor c=1.01938e-16
C59 (\10\:VDD VSS) capacitor c=6.818e-17
C60 (\8\:mout VSS) capacitor c=1.12123e-16
C61 (\4\:n30 VSS) capacitor c=1.04635e-16
C62 (\12\:VDD VSS) capacitor c=9.08538e-17
C63 (\11\:qbint VSS) capacitor c=8.24971e-17
C64 (\15\:VDD VSS) capacitor c=7.45089e-17
C65 (\20\:CKb VSS) capacitor c=3.6369e-17
C66 (\18\:VDD VSS) capacitor c=7.20196e-17
C67 (\1\:Q VSS) capacitor c=3.36843e-17
C68 (\3\:VDD VSS) capacitor c=8.78369e-17
C69 (\15\:CKbb VSS) capacitor c=1.61375e-17
C70 (\8\:n20 VSS) capacitor c=6.085e-17
C71 (\6\:mout VSS) capacitor c=6.02542e-17
C72 (\8\:n30 VSS) capacitor c=3.30566e-17
C73 (\13\:qbint VSS) capacitor c=3.84702e-17
C74 (\17\:CKb VSS) capacitor c=1.04714e-16
C75 (\3\:Q VSS) capacitor c=7.06496e-17
C76 (\4\:CK VSS) capacitor c=4.02521e-17
C77 (\7\:qbint VSS) capacitor c=7.02437e-17
C78 (\8\:qbint VSS) capacitor c=1.48628e-16
C79 (\9\:qbint VSS) capacitor c=1.8069e-16
C80 (\10\:qbint VSS) capacitor c=1.46097e-16
C81 (\6\:RN VSS) capacitor c=7.08568e-17
C82 (\8\:RN VSS) capacitor c=6.81434e-17
C83 (\6\:n30 VSS) capacitor c=1.41619e-16
C84 (\7\:n30 VSS) capacitor c=1.11477e-16
C85 (\4\:mout VSS) capacitor c=1.00263e-16
C86 (\5\:mout VSS) capacitor c=1.27625e-16
C87 (\6\:n20 VSS) capacitor c=1.68474e-16
C88 (\7\:n20 VSS) capacitor c=1.38912e-16
C89 (\4\:D VSS) capacitor c=7.25127e-17
C90 (\11\:CKb VSS) capacitor c=1.63799e-16
C91 (\12\:CKb VSS) capacitor c=3.41845e-16
C92 (\13\:CKb VSS) capacitor c=2.32392e-16
C93 (\14\:CKb VSS) capacitor c=8.59697e-17
C94 (\15\:CKb VSS) capacitor c=2.76465e-16
C95 (\16\:CKb VSS) capacitor c=2.38568e-16
C96 (\19\:CKb VSS) capacitor c=7.46464e-17
C97 (\8\:CKbb VSS) capacitor c=3.59147e-17
C98 (\9\:CKbb VSS) capacitor c=2.69096e-16
C99 (\10\:CKbb VSS) capacitor c=1.36757e-16
C100 (\11\:CKbb VSS) capacitor c=6.79526e-17
C101 (\14\:CKbb VSS) capacitor c=1.8255e-16
C102 (\17\:CKbb VSS) capacitor c=7.84808e-17
C103 (\5\:VDD VSS) capacitor c=1.49963e-17
C104 (\6\:VDD VSS) capacitor c=4.1732e-17
C105 (\14\:VDD VSS) capacitor c=1.74847e-17
C106 (\17\:VDD VSS) capacitor c=9.47365e-18
Rk1 (Q \2\:Q) resistor r=0.07294 c=0
Rk2 (Q \4\:Q) resistor r=0.4479 c=0
Rk3 (\4\:CK CK) resistor r=0.05341 c=0
Rk22 (D \4\:D) resistor r=0.1047 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.2514 c=0
Rk39 (\3\:VSS \5\:VSS) resistor r=0.4594 c=0
Rk40 (\3\:VSS \6\:VSS) resistor r=0.4541 c=0
Rk42 (\7\:VSS VSS) resistor r=0.1035 c=0
Rk41 (\6\:VSS \7\:VSS) resistor r=0.4537 c=0
Rk43 (\5\:VSS \9\:VSS) resistor r=0.2571 c=0
Rk44 (\5\:VSS \11\:VSS) resistor r=0.3398 c=0
Rk45 (\6\:VSS \13\:VSS) resistor r=0.2782 c=0
Rk46 (\7\:VSS \15\:VSS) resistor r=0.309 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.5077 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.2508 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.2075 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.4543 c=0
Rk51 (\5\:VDD \9\:VDD) resistor r=0.3115 c=0
Rk52 (\6\:VDD \11\:VDD) resistor r=0.3676 c=0
Rk53 (\7\:VDD \13\:VDD) resistor r=0.4487 c=0
Rk54 (\7\:VDD \14\:VDD) resistor r=0.228 c=0
Rk55 (\14\:VDD \16\:VDD) resistor r=0.3386 c=0
Rk58 (\17\:VDD VDD) resistor r=0.1035 c=0
Rk56 (\14\:VDD \17\:VDD) resistor r=0.2253 c=0
Rk57 (\17\:VDD \19\:VDD) resistor r=0.3605 c=0
Rk9 (\6\:RN \7\:RN) resistor r=0.00567 c=0
Rk10 (RN \8\:RN) resistor r=0.00567 c=0
Rk11 (\6\:RN \8\:RN) resistor r=0.06642 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.3386 c=0
Rk5 (\8\:qbint \9\:qbint) resistor r=0.5369 c=0
Rk6 (\9\:qbint \10\:qbint) resistor r=0.9141 c=0
Rk7 (\8\:qbint \12\:qbint) resistor r=0.3894 c=0
Rk8 (\9\:qbint \14\:qbint) resistor r=0.1112 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=1.1591 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=1.3824 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=0.3979 c=0
Rk26 (\13\:CKb \15\:CKb) resistor r=0.5539 c=0
Rk27 (\15\:CKb \16\:CKb) resistor r=1.3763 c=0
Rk28 (\16\:CKb \18\:CKb) resistor r=0.461 c=0
Rk29 (\15\:CKb \19\:CKb) resistor r=0.4123 c=0
Rk30 (\16\:CKb \21\:CKb) resistor r=0.1996 c=0
Rk12 (\5\:n30 \6\:n30) resistor r=0.6402 c=0
Rk13 (\6\:n30 \7\:n30) resistor r=0.6152 c=0
Rk14 (\6\:n30 \9\:n30) resistor r=0.08583 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.5031 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2002 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.4231 c=0
Rk31 (\8\:CKbb \9\:CKbb) resistor r=0.06918 c=0
Rk32 (\9\:CKbb \10\:CKbb) resistor r=1.0875 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.252 c=0
Rk34 (\11\:CKbb \13\:CKbb) resistor r=0.2478 c=0
Rk35 (\9\:CKbb \14\:CKbb) resistor r=1.1807 c=0
Rk36 (\10\:CKbb \16\:CKbb) resistor r=0.07674 c=0
Rk37 (\11\:CKbb \17\:CKbb) resistor r=0.3146 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.676 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.7869 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2139 c=0
Rk18 (\2\:n26 \4\:n26) resistor r=0.5797 c=0
Rl3 (\1\:CK \2\:CK) resistor r=96.8456 c=0
Rl4 (\2\:CK \3\:CK) resistor r=154.538 c=0
Rl25 (\1\:D \2\:D) resistor r=168.257 c=0
Rl26 (\2\:D \3\:D) resistor r=111.459 c=0
Rl15 (\1\:RN \2\:RN) resistor r=367.561 c=0
Rl18 (\1\:RN \5\:RN) resistor r=207.692 c=0
Rl16 (\2\:RN \3\:RN) resistor r=40.8576 c=0
Rl17 (\3\:RN \4\:RN) resistor r=138.31 c=0
Rl7 (\4\:qbint \5\:qbint) resistor r=127.926 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=53.079 c=0
Rl1 (qbint \2\:qbint) resistor r=106.867 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=26.098 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=187.694 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=42.3077 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=141.209 c=0
Rl12 (\3\:CKb \4\:CKb) resistor r=35.3072 c=0
Rl9 (CKb \2\:CKb) resistor r=51.098 c=0
Rl6 (\2\:n30 \3\:n30) resistor r=149.175 c=0
Rl5 (n30 \2\:n30) resistor r=60.6757 c=0
Rl19 (mout \2\:mout) resistor r=133.848 c=0
Rl20 (\2\:mout \3\:mout) resistor r=45.3867 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=71.8456 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=29.5379 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=174.543 c=0
Rl10 (CKbb \2\:CKbb) resistor r=55.3008 c=0
Rl13 (n20 \2\:n20) resistor r=56.4615 c=0
Rl14 (\2\:n20 \3\:n20) resistor r=124.527 c=0
Rz1 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz14 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz2 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz6 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry10 (\4\:VSS \5\:VSS) resistor r=10.3333 c=0
Ry11 (\4\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry14 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry15 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \16\:VDD) resistor r=31 c=0
Ry17 (\18\:VDD \19\:VDD) resistor r=20.6667 c=0
Ry2 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry5 (n26 \2\:n26) resistor r=31 c=0
Ry6 (\3\:n26 \4\:n26) resistor r=31 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:RN \7\:RN) resistor r=45 c=0
Rx2 (\5\:qbint \7\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \10\:qbint) resistor r=45 c=0
Rx9 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx15 (\7\:CKbb \17\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.85e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn20 (\17\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.393e-14 ps=9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.65e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn21 (\15\:CKbb \10\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn46 (\13\:qbint n30 n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=1.98037e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn45 (n35 \4\:RN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.28415e-07 sb=1.89073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (n40 \6\:qbint \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.38415e-07 sb=1.68073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\8\:n30 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.715e-14 ps=5.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43415e-07 sb=1.57573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\8\:n30 CKbb \6\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.715e-14 ps=8.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18415e-07 sb=1.30073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (\6\:mout \3\:n20 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=4.51e-14 ps=1.24e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08341e-06 sb=1.03573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (n27 \5\:RN \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=3.28e-14 ps=1.24e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31841e-06 sb=8.00732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52341e-06 sb=5.95732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62841e-06 sb=4.90732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn26 (\8\:n20 \7\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.88341e-06 sb=2.35732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (n21 \3\:D \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=1.23e-14 ps=8.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98549e-06 sb=1.30732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mp20 (\20\:CKb \1\:CK \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.69e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.25116e-07 sd=160n sca=13.8096 \
        scb=0.0118363 scc=0.000162518 m=(1)
mp21 (\12\:CKbb \8\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.415e-14 ad=2.63e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.22326e-07 sd=160n sca=27.6163 \
        scb=0.0324392 scc=0.00204694 m=(1)
mp46 (\11\:qbint \3\:n30 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=5.735e-14 ps=9.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50323e-07 sb=1.65597e-06 sd=160n sca=12.8747 \
        scb=0.0114137 scc=0.000458937 m=(1)
mp45 (\11\:qbint \2\:RN \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=5.735e-14 ps=1.01e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.80323e-07 sb=1.42597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp50 (n41 \4\:qbint \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=2.015e-14 ps=1.01e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.20323e-07 sb=1.18597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp51 (\4\:n30 \3\:CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.015e-14 ad=6.355e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30323e-07 sb=1.07597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=6.355e-14 ps=1.04e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.80323e-07 sb=8.25968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp30 (\8\:mout n20 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.51e-14 ps=1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23532e-06 sb=5.70968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp35 (\3\:n26 \1\:RN \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47032e-06 sb=3.35968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp36 (\3\:n26 mout \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67532e-06 sb=1.30968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp37 (\4\:n20 \5\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=4.96e-14 ps=9.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65968e-07 sb=6.00726e-07 sd=160n sca=13.271 \
        scb=0.0115865 scc=0.00045901 m=(1)
mp26 (\4\:n20 \6\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.70968e-07 sb=3.95726e-07 sd=160n sca=14.4949 \
        scb=0.0127984 scc=0.000462551 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=1.86e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75968e-07 sb=2.90726e-07 sd=160n sca=15.7848 \
        scb=0.014788 scc=0.000483319 m=(1)
ends DFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:31 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRHQX2
// View name: extracted

simulator lang=spectre

subckt DFFRHQX2 CK D Q RN VDD VSS
mp55_1__rcx (\3\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.379e-14 ad=6.24e-14 ps=1.085e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.42821e-07 sd=160n sca=38.817 \
        scb=0.037485 scc=0.00407535 m=(2)
C1 (Q VSS) capacitor c=2.67224e-17
C2 (CK VSS) capacitor c=6.04692e-17
C3 (D VSS) capacitor c=7.35457e-17
C4 (VDD VSS) capacitor c=4.02381e-16
C5 (RN VSS) capacitor c=4.90791e-17
C6 (qbint VSS) capacitor c=1.38277e-16
C7 (CKb VSS) capacitor c=4.63368e-17
C8 (n35 VSS) capacitor c=1.73071e-18
C9 (n30 VSS) capacitor c=3.7669e-17
C10 (n40 VSS) capacitor c=3.50006e-18
C11 (mout VSS) capacitor c=4.61242e-17
C12 (CKbb VSS) capacitor c=2.65043e-17
C13 (n20 VSS) capacitor c=4.21675e-17
C14 (n27 VSS) capacitor c=5.23137e-18
C15 (n25 VSS) capacitor c=4.78744e-18
C16 (n21 VSS) capacitor c=1.56139e-18
C17 (n41 VSS) capacitor c=3.90696e-18
C18 (n26 VSS) capacitor c=7.61497e-17
C19 (n22 VSS) capacitor c=1.67153e-18
C20 (\8\:CKb VSS) capacitor c=3.68791e-17
C21 (\1\:D VSS) capacitor c=9.61385e-17
C22 (\6\:CKbb VSS) capacitor c=6.13336e-17
C23 (\7\:CKb VSS) capacitor c=2.93969e-17
C24 (\2\:RN VSS) capacitor c=1.23797e-16
C25 (\3\:n20 VSS) capacitor c=5.33397e-17
C26 (\3\:CKb VSS) capacitor c=3.35718e-17
C27 (\3\:CKbb VSS) capacitor c=6.94947e-17
C28 (\8\:qbint VSS) capacitor c=7.83365e-17
C29 (\3\:RN VSS) capacitor c=8.44483e-17
C30 (\3\:n30 VSS) capacitor c=5.11385e-17
C31 (\3\:CK VSS) capacitor c=4.17663e-17
C32 (\9\:CKb VSS) capacitor c=3.29451e-17
C33 (\3\:D VSS) capacitor c=5.73365e-17
C34 (\5\:CKb VSS) capacitor c=6.54594e-17
C35 (\4\:CKbb VSS) capacitor c=3.88447e-17
C36 (\3\:mout VSS) capacitor c=3.39951e-17
C37 (\1\:RN VSS) capacitor c=7.39762e-17
C38 (\10\:qbint VSS) capacitor c=3.93995e-17
C39 (\5\:RN VSS) capacitor c=9.56038e-17
C40 (\1\:CK VSS) capacitor c=3.11582e-17
C41 (\10\:CKb VSS) capacitor c=2.76559e-17
C42 (\2\:D VSS) capacitor c=4.60671e-17
C43 (\7\:CKbb VSS) capacitor c=3.39369e-17
C44 (\6\:CKb VSS) capacitor c=3.48999e-17
C45 (\5\:CKbb VSS) capacitor c=3.24123e-17
C46 (\2\:mout VSS) capacitor c=3.51573e-17
C47 (\2\:n20 VSS) capacitor c=4.89389e-17
C48 (\4\:CKb VSS) capacitor c=3.47598e-17
C49 (\2\:CKbb VSS) capacitor c=5.05446e-17
C50 (\2\:CKb VSS) capacitor c=4.41405e-17
C51 (\9\:qbint VSS) capacitor c=6.76246e-17
C52 (\4\:RN VSS) capacitor c=4.29336e-17
C53 (\2\:n30 VSS) capacitor c=4.65619e-17
C54 (\2\:CK VSS) capacitor c=4.60174e-17
C55 (\6\:qbint VSS) capacitor c=1.67235e-17
C56 (\10\:CKbb VSS) capacitor c=2.80507e-17
C57 (\1\:VDD VSS) capacitor c=4.19045e-17
C58 (\4\:n20 VSS) capacitor c=7.72332e-17
C59 (\13\:VDD VSS) capacitor c=2.79846e-17
C60 (\3\:n26 VSS) capacitor c=6.50166e-17
C61 (\15\:VDD VSS) capacitor c=4.28146e-17
C62 (\8\:mout VSS) capacitor c=5.71849e-17
C63 (\8\:n30 VSS) capacitor c=9.83476e-17
C64 (\17\:VDD VSS) capacitor c=3.69546e-17
C65 (\16\:qbint VSS) capacitor c=6.86365e-17
C66 (\19\:VDD VSS) capacitor c=3.71577e-17
C67 (\16\:CKb VSS) capacitor c=4.28692e-17
C68 (\3\:Q VSS) capacitor c=9.60914e-17
C69 (\3\:VDD VSS) capacitor c=5.21416e-17
C70 (\8\:CKbb VSS) capacitor c=1.23946e-17
C71 (\8\:n20 VSS) capacitor c=5.57202e-17
C72 (\6\:mout VSS) capacitor c=4.28086e-17
C73 (\4\:n30 VSS) capacitor c=2.44898e-17
C74 (\13\:qbint VSS) capacitor c=1.45063e-16
C75 (\21\:CKb VSS) capacitor c=1.07249e-16
C76 (\1\:Q VSS) capacitor c=1.91387e-17
C77 (\4\:CK VSS) capacitor c=5.21964e-17
C78 (\11\:qbint VSS) capacitor c=4.49686e-17
C79 (\12\:qbint VSS) capacitor c=8.89612e-17
C80 (\15\:qbint VSS) capacitor c=1.43006e-16
C81 (\6\:RN VSS) capacitor c=6.07465e-17
C82 (\6\:n30 VSS) capacitor c=9.08657e-17
C83 (\7\:n30 VSS) capacitor c=1.03742e-16
C84 (\4\:mout VSS) capacitor c=1.11117e-16
C85 (\5\:mout VSS) capacitor c=8.9278e-17
C86 (\6\:n20 VSS) capacitor c=1.27996e-16
C87 (\7\:n20 VSS) capacitor c=1.05304e-16
C88 (\4\:D VSS) capacitor c=4.12362e-17
C89 (\12\:CKbb VSS) capacitor c=1.20044e-16
C90 (\13\:CKbb VSS) capacitor c=2.72705e-16
C91 (\14\:CKbb VSS) capacitor c=1.43734e-16
C92 (\15\:CKbb VSS) capacitor c=4.24751e-17
C93 (\16\:CKbb VSS) capacitor c=4.07531e-17
C94 (\11\:CKb VSS) capacitor c=5.75064e-17
C95 (\12\:CKb VSS) capacitor c=1.94629e-16
C96 (\13\:CKb VSS) capacitor c=1.59537e-16
C97 (\14\:CKb VSS) capacitor c=1.54872e-16
C98 (\15\:CKb VSS) capacitor c=1.43356e-16
C99 (\18\:CKb VSS) capacitor c=9.07164e-17
C100 (\19\:CKb VSS) capacitor c=5.94432e-17
C101 (\20\:CKb VSS) capacitor c=8.27081e-17
C102 (\5\:VDD VSS) capacitor c=1.58222e-17
C103 (\6\:VDD VSS) capacitor c=3.96628e-17
C104 (\7\:VDD VSS) capacitor c=4.02747e-17
C105 (\9\:VDD VSS) capacitor c=9.52135e-18
Rk1 (Q \2\:Q) resistor r=0.04515 c=0
Rk2 (Q \4\:Q) resistor r=0.2679 c=0
Rk3 (\4\:CK CK) resistor r=0.09453 c=0
Rk19 (\4\:D D) resistor r=0.06815 c=0
Rk35 (\2\:VDD \4\:VDD) resistor r=0.4765 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.09171 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.3224 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.4689 c=0
Rk39 (\7\:VDD \8\:VDD) resistor r=0.2683 c=0
Rk41 (\9\:VDD VDD) resistor r=0.2606 c=0
Rk40 (\8\:VDD \9\:VDD) resistor r=0.08262 c=0
Rk44 (\5\:VDD \14\:VDD) resistor r=0.04335 c=0
Rk45 (\6\:VDD \16\:VDD) resistor r=0.2096 c=0
Rk46 (\7\:VDD \18\:VDD) resistor r=0.1805 c=0
Rk47 (\9\:VDD \20\:VDD) resistor r=0.1875 c=0
Rk8 (\6\:RN RN) resistor r=0.1845 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.2155 c=0
Rk50 (\3\:VSS \5\:VSS) resistor r=0.2257 c=0
Rk51 (\5\:VSS \6\:VSS) resistor r=0.3135 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.632 c=0
Rk54 (\8\:VSS VSS) resistor r=0.3587 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.2081 c=0
Rk57 (\3\:VSS \13\:VSS) resistor r=0.1267 c=0
Rk58 (\6\:VSS \15\:VSS) resistor r=0.2275 c=0
Rk59 (\7\:VSS \17\:VSS) resistor r=0.2208 c=0
Rk4 (\11\:qbint \12\:qbint) resistor r=0.2714 c=0
Rk5 (\12\:qbint \14\:qbint) resistor r=0.5122 c=0
Rk6 (\14\:qbint \15\:qbint) resistor r=0.9016 c=0
Rk7 (\12\:qbint \17\:qbint) resistor r=0.2925 c=0
Rk26 (\11\:CKb \12\:CKb) resistor r=0.2599 c=0
Rk27 (\12\:CKb \13\:CKb) resistor r=1.1332 c=0
Rk28 (\13\:CKb \14\:CKb) resistor r=0.33 c=0
Rk29 (\14\:CKb \15\:CKb) resistor r=0.9125 c=0
Rk30 (\15\:CKb \17\:CKb) resistor r=0.1733 c=0
Rk31 (\12\:CKb \18\:CKb) resistor r=0.671 c=0
Rk32 (\13\:CKb \19\:CKb) resistor r=0.2443 c=0
Rk33 (\14\:CKb \20\:CKb) resistor r=0.4177 c=0
Rk34 (\15\:CKb \22\:CKb) resistor r=0.5405 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.06464 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.5524 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.4387 c=0
Rk12 (\4\:mout \5\:mout) resistor r=0.5666 c=0
Rk13 (\5\:mout \7\:mout) resistor r=0.1136 c=0
Rk14 (\5\:mout \9\:mout) resistor r=0.2503 c=0
Rk20 (\9\:CKbb \11\:CKbb) resistor r=0.3278 c=0
Rk21 (\11\:CKbb \12\:CKbb) resistor r=0.1211 c=0
Rk22 (\12\:CKbb \13\:CKbb) resistor r=1.2314 c=0
Rk23 (\13\:CKbb \14\:CKbb) resistor r=1.1897 c=0
Rk24 (\12\:CKbb \15\:CKbb) resistor r=0.2186 c=0
Rk25 (\13\:CKbb \16\:CKbb) resistor r=0.1211 c=0
Rk16 (\5\:n20 \6\:n20) resistor r=0.3851 c=0
Rk17 (\6\:n20 \7\:n20) resistor r=0.6748 c=0
Rk18 (\6\:n20 \9\:n20) resistor r=0.2067 c=0
Rk15 (\2\:n26 \4\:n26) resistor r=0.2574 c=0
Rl8 (\2\:CK \3\:CK) resistor r=110.989 c=0
Rl7 (\1\:CK \2\:CK) resistor r=78.8462 c=0
Rl29 (\1\:D \2\:D) resistor r=122.31 c=0
Rl30 (\2\:D \3\:D) resistor r=135.155 c=0
Rl20 (\2\:RN \3\:RN) resistor r=639.95 c=0
Rl19 (\1\:RN \2\:RN) resistor r=180.335 c=0
Rl21 (\3\:RN \4\:RN) resistor r=24.2328 c=0
Rl22 (\4\:RN \5\:RN) resistor r=198.905 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=139.125 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=51.098 c=0
Rl5 (qbint \6\:qbint) resistor r=4.3693 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=101.923 c=0
Rl32 (\8\:CKb \10\:CKb) resistor r=57.2054 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=143.832 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl13 (CKb \2\:CKb) resistor r=53.079 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=219.646 c=0
Rl9 (n30 \2\:n30) resistor r=24.2328 c=0
Rl23 (mout \2\:mout) resistor r=97.3098 c=0
Rl24 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl25 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=147.197 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=78.4003 c=0
Rl17 (n20 \2\:n20) resistor r=97.3098 c=0
Rz1 (\2\:Q \1\:Q) resistor r=75 c=0
Rz8 (\4\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz9 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz10 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz7 (\21\:CKb \22\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry10 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry17 (\5\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry18 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry2 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry9 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry5 (n26 \2\:n26) resistor r=62 c=0
Ry6 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\4\:RN \6\:RN) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\15\:qbint \6\:qbint) resistor r=45 c=0
Rx12 (\6\:CKb \11\:CKb) resistor r=45 c=0
Rx13 (\10\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx15 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\7\:CKbb \15\:CKbb) resistor r=45 c=0
Rx11 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55_1__rcx (\1\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.135e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.78269e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mn20 (\21\:CKb \1\:CK VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=4.422e-14 ps=1e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.3e-07 sb=3.05e-07 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn21 (\8\:CKbb \9\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.685e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn46 (\13\:qbint n30 n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.743e-14 ad=4.202e-14 ps=5.8e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.44024e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn45 (n35 \5\:RN \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.743e-14 ps=7.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.38634e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (n40 \10\:qbint \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.485e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.30134e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\4\:n30 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=4.82e-14 ps=7.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.2122e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\4\:n30 CKbb \6\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.61e-14 ad=4.82e-14 ps=1.25e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.61951e-07 sb=1.81e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn30 (\6\:mout n20 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=8.61e-14 ps=1.08e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12695e-06 sb=1.345e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn35 (n27 \1\:RN \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43195e-06 sb=1.04e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.588e-14 ps=7.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61646e-06 sb=8.35e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn37 (\8\:n20 \4\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=5.228e-14 ps=7.6e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70768e-06 sb=6.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn26 (\8\:n20 \5\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=5.228e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83207e-06 sb=3.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn25 (n21 \3\:D \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.185e-14 ad=2.05e-14 ps=1.2e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8922e-06 sb=1.7e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mp20 (\16\:CKb \3\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.297e-14 ad=3.01e-14 ps=1.11e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=13.3166 \
        scb=0.0115053 scc=0.000332937 m=(1)
mp21 (\10\:CKbb \8\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.99e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91279e-07 sb=1.4e-07 sd=160n sca=43.6839 \
        scb=0.0409846 scc=0.00506402 m=(1)
mp46 (\16\:qbint \3\:n30 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.905e-14 ad=6.51e-14 ps=1.13e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.17194e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp45 (\16\:qbint \3\:RN \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.685e-14 ad=6.51e-14 ps=1.53e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=9.62097e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp50 (n41 \8\:qbint \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.685e-14 ad=4.03e-14 ps=1.53e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.34194e-07 sb=1.515e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\8\:n30 \3\:CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=6.975e-14 ps=8.8e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.09194e-07 sb=1.34e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\8\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.44e-14 ad=6.975e-14 ps=1.1e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.79194e-07 sb=1.07e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\8\:mout \3\:n20 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=7.44e-14 ps=1.36e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16419e-06 sb=7.85e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (\3\:n26 \2\:RN \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=8.835e-14 ps=1.36e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.44919e-06 sb=5e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\3\:n26 mout \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.29e-14 ad=8.835e-14 ps=1.63e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.69565e-06 sb=1.7e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp37 (\4\:n20 \7\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.355e-14 ad=1.0385e-13 ps=1.03e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=6.03952e-07 sd=160n sca=11.0604 \
        scb=0.00885796 scc=0.000174054 m=(1)
mp26 (\4\:n20 \6\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=1.0385e-13 ps=7.4e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=2.23952e-07 sd=160n sca=12.8183 \
        scb=0.0103291 scc=0.000178019 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.99e-14 ad=1.86e-14 ps=1.85e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.18952e-07 sd=160n sca=14.1447 \
        scb=0.0123968 scc=0.000200733 m=(1)
ends DFFRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:32 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRHQX4
// View name: extracted

simulator lang=spectre

subckt DFFRHQX4 CK D Q RN VDD VSS
mp20 (\13\:CKb \3\:CK \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.335e-14 ad=3.01e-14 ps=1.36e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.81395e-07 sd=160n sca=16.1121 \
        scb=0.0158148 scc=0.000267169 m=(1)
mp21 (\15\:CKbb \4\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.18023e-07 sb=1.4e-07 sd=160n sca=19.509 \
        scb=0.0211666 scc=0.000797427 m=(1)
C1 (CK VSS) capacitor c=4.52823e-17
C2 (D VSS) capacitor c=1.25185e-16
C3 (Q VSS) capacitor c=2.18479e-16
C4 (VDD VSS) capacitor c=3.99573e-16
C5 (RN VSS) capacitor c=6.3568e-16
C6 (CKb VSS) capacitor c=6.06128e-17
C7 (qbint VSS) capacitor c=3.03649e-16
C8 (16 VSS) capacitor c=1.38261e-18
C9 (n30 VSS) capacitor c=1.08162e-16
C10 (17 VSS) capacitor c=2.73804e-18
C11 (n40 VSS) capacitor c=5.97173e-18
C12 (mout VSS) capacitor c=3.76356e-17
C13 (CKbb VSS) capacitor c=5.50556e-17
C14 (n20 VSS) capacitor c=2.29934e-17
C15 (n25 VSS) capacitor c=5.40073e-19
C16 (n41 VSS) capacitor c=9.26454e-18
C17 (n26 VSS) capacitor c=6.7518e-17
C18 (n22 VSS) capacitor c=2.11974e-18
C19 (\4\:CKb VSS) capacitor c=8.47619e-17
C20 (\1\:D VSS) capacitor c=9.79194e-17
C21 (\7\:CKbb VSS) capacitor c=6.8772e-17
C22 (\8\:CKb VSS) capacitor c=4.72494e-17
C23 (\9\:RN VSS) capacitor c=4.23735e-17
C24 (\4\:n20 VSS) capacitor c=4.97104e-17
C25 (\2\:CKb VSS) capacitor c=7.249e-17
C26 (\16\:qbint VSS) capacitor c=3.96401e-17
C27 (\3\:CK VSS) capacitor c=5.45427e-17
C28 (\7\:CKb VSS) capacitor c=6.20639e-17
C29 (\3\:D VSS) capacitor c=3.58372e-17
C30 (\9\:CKb VSS) capacitor c=4.96307e-17
C31 (\5\:CKbb VSS) capacitor c=3.82523e-17
C32 (\3\:mout VSS) capacitor c=3.57244e-17
C33 (\7\:RN VSS) capacitor c=3.58849e-17
C34 (\3\:n20 VSS) capacitor c=2.34241e-17
C35 (\3\:CKbb VSS) capacitor c=4.2501e-17
C36 (\18\:qbint VSS) capacitor c=4.52097e-17
C37 (\6\:RN VSS) capacitor c=3.06832e-17
C38 (\5\:n30 VSS) capacitor c=3.33057e-17
C39 (\4\:n30 VSS) capacitor c=3.73922e-17
C40 (\1\:RN VSS) capacitor c=3.83282e-17
C41 (\1\:CK VSS) capacitor c=3.22646e-17
C42 (\2\:D VSS) capacitor c=4.16305e-17
C43 (\8\:CKbb VSS) capacitor c=3.27252e-17
C44 (\6\:CKbb VSS) capacitor c=3.78954e-17
C45 (\6\:CKb VSS) capacitor c=2.6492e-17
C46 (\2\:mout VSS) capacitor c=3.43771e-17
C47 (\8\:RN VSS) capacitor c=3.88479e-17
C48 (\4\:CKbb VSS) capacitor c=3.15597e-17
C49 (\3\:CKb VSS) capacitor c=2.00924e-17
C50 (\2\:CKbb VSS) capacitor c=4.64243e-17
C51 (\17\:qbint VSS) capacitor c=4.95283e-17
C52 (\2\:CK VSS) capacitor c=4.11258e-17
C53 (\15\:CKbb VSS) capacitor c=2.05148e-17
C54 (\1\:VDD VSS) capacitor c=3.90029e-17
C55 (\5\:n20 VSS) capacitor c=1.01674e-16
C56 (\6\:VDD VSS) capacitor c=2.69566e-17
C57 (\3\:n26 VSS) capacitor c=8.91592e-17
C58 (\10\:VDD VSS) capacitor c=2.95189e-17
C59 (\5\:mout VSS) capacitor c=1.74742e-16
C60 (\11\:n30 VSS) capacitor c=8.50119e-17
C61 (\16\:VDD VSS) capacitor c=1.54157e-17
C62 (\13\:CKb VSS) capacitor c=2.16106e-17
C63 (\3\:VDD VSS) capacitor c=7.11312e-17
C64 (\9\:CKbb VSS) capacitor c=4.57923e-17
C65 (\9\:n20 VSS) capacitor c=1.22539e-17
C66 (\7\:mout VSS) capacitor c=8.0056e-17
C67 (\7\:n30 VSS) capacitor c=6.43068e-17
C68 (\27\:qbint VSS) capacitor c=8.21173e-17
C69 (\15\:CKb VSS) capacitor c=7.87631e-17
C70 (\2\:n20 VSS) capacitor c=2.08828e-17
C71 (\5\:CKb VSS) capacitor c=4.48338e-17
C72 (\4\:CK VSS) capacitor c=7.47775e-17
C73 (\19\:qbint VSS) capacitor c=6.13842e-17
C74 (\20\:qbint VSS) capacitor c=1.69316e-16
C75 (\24\:qbint VSS) capacitor c=4.94381e-17
C76 (\9\:n30 VSS) capacitor c=1.44501e-16
C77 (\10\:n30 VSS) capacitor c=1.07034e-16
C78 (\10\:RN VSS) capacitor c=2.44847e-16
C79 (\4\:mout VSS) capacitor c=1.17589e-16
C80 (\10\:CKb VSS) capacitor c=1.52402e-16
C81 (\11\:CKb VSS) capacitor c=3.76341e-16
C82 (\12\:CKb VSS) capacitor c=2.78782e-16
C83 (\7\:n20 VSS) capacitor c=9.47129e-17
C84 (\8\:n20 VSS) capacitor c=1.10394e-16
C85 (\11\:CKbb VSS) capacitor c=6.92546e-17
C86 (\12\:CKbb VSS) capacitor c=6.60106e-17
C87 (\13\:CKbb VSS) capacitor c=2.34528e-16
C88 (\14\:CKbb VSS) capacitor c=7.80773e-17
C89 (\17\:CKbb VSS) capacitor c=4.09386e-17
C90 (\18\:CKbb VSS) capacitor c=1.9132e-16
C91 (\19\:CKbb VSS) capacitor c=2.75251e-17
C92 (\20\:CKbb VSS) capacitor c=4.34635e-17
C93 (\5\:VDD VSS) capacitor c=3.90114e-17
C94 (\9\:VDD VSS) capacitor c=2.7761e-17
C95 (\12\:VDD VSS) capacitor c=2.22649e-16
Rk1 (CK \4\:CK) resistor r=0.0258 c=0
Rk30 (D \4\:D) resistor r=0.006018 c=0
Rk40 (\2\:VDD \4\:VDD) resistor r=0.3675 c=0
Rk41 (\4\:VDD \5\:VDD) resistor r=0.4887 c=0
Rk42 (\5\:VDD \7\:VDD) resistor r=0.04333 c=0
Rk43 (\5\:VDD \8\:VDD) resistor r=0.3124 c=0
Rk44 (\8\:VDD \9\:VDD) resistor r=0.04401 c=0
Rk45 (\9\:VDD \11\:VDD) resistor r=0.04333 c=0
Rk57 (\12\:VDD VDD) resistor r=0.1476 c=0
Rk46 (\9\:VDD \12\:VDD) resistor r=0.5957 c=0
Rk49 (\12\:VDD \17\:VDD) resistor r=0.07416 c=0
Rk16 (\10\:RN RN) resistor r=1.7073 c=0
Rk58 (\2\:VSS \4\:VSS) resistor r=0.3016 c=0
Rk59 (\4\:VSS \5\:VSS) resistor r=0.8034 c=0
Rk60 (\5\:VSS \6\:VSS) resistor r=0.05499 c=0
Rk61 (\6\:VSS \7\:VSS) resistor r=0.682 c=0
Rk66 (\8\:VSS VSS) resistor r=0.1902 c=0
Rk62 (\7\:VSS \8\:VSS) resistor r=0.401 c=0
Rk67 (\6\:VSS \13\:VSS) resistor r=0.2629 c=0
Rk68 (\7\:VSS \15\:VSS) resistor r=0.2224 c=0
Rk23 (\10\:CKb \11\:CKb) resistor r=1.0979 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=2.2583 c=0
Rk25 (\12\:CKb \14\:CKb) resistor r=0.02105 c=0
Rk26 (\12\:CKb \16\:CKb) resistor r=0.5817 c=0
Rk7 (\19\:qbint \20\:qbint) resistor r=0.2999 c=0
Rk10 (\20\:qbint \24\:qbint) resistor r=0.3086 c=0
Rk12 (\20\:qbint \28\:qbint) resistor r=0.4197 c=0
Rk13 (\8\:n30 \9\:n30) resistor r=0.3868 c=0
Rk14 (\9\:n30 \10\:n30) resistor r=0.6042 c=0
Rk15 (\9\:n30 \12\:n30) resistor r=0.5374 c=0
Rk20 (\4\:mout \6\:mout) resistor r=0.8324 c=0
Rk21 (\6\:mout \8\:mout) resistor r=0.3792 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.4033 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=0.3044 c=0
Rk33 (\12\:CKbb \13\:CKbb) resistor r=0.4052 c=0
Rk34 (\13\:CKbb \14\:CKbb) resistor r=0.3692 c=0
Rk35 (\11\:CKbb \16\:CKbb) resistor r=0.04182 c=0
Rk36 (\12\:CKbb \17\:CKbb) resistor r=0.1515 c=0
Rk37 (\13\:CKbb \18\:CKbb) resistor r=1.6215 c=0
Rk38 (\18\:CKbb \19\:CKbb) resistor r=0.1091 c=0
Rk39 (\18\:CKbb \20\:CKbb) resistor r=0.1758 c=0
Rk27 (\6\:n20 \7\:n20) resistor r=0.4954 c=0
Rk28 (\7\:n20 \8\:n20) resistor r=0.7269 c=0
Rk29 (\7\:n20 \10\:n20) resistor r=0.05483 c=0
Rk22 (\2\:n26 \4\:n26) resistor r=0.23 c=0
Rl2 (\2\:CK \3\:CK) resistor r=168.407 c=0
Rl1 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl41 (\1\:D \2\:D) resistor r=89.1533 c=0
Rl42 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl25 (RN \6\:RN) resistor r=26.3736 c=0
Rl17 (RN \1\:RN) resistor r=30.7692 c=0
Rl36 (\8\:RN \9\:RN) resistor r=45.3867 c=0
Rl35 (\8\:RN \7\:RN) resistor r=130.323 c=0
Rl45 (\4\:CKb \7\:CKb) resistor r=213.462 c=0
Rl47 (\8\:CKb \9\:CKb) resistor r=153.846 c=0
Rl29 (CKb \2\:CKb) resistor r=176.122 c=0
Rl30 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl43 (\4\:CKb \5\:CKb) resistor r=298.055 c=0
Rl46 (\5\:CKb \8\:CKb) resistor r=70.8353 c=0
Rl44 (\5\:CKb \6\:CKb) resistor r=85.2376 c=0
Rl26 (\17\:qbint \16\:qbint) resistor r=35.7713 c=0
Rl27 (\17\:qbint \18\:qbint) resistor r=147.31 c=0
Rl22 (n30 \5\:n30) resistor r=76.1559 c=0
Rl21 (n30 \4\:n30) resistor r=75.6397 c=0
Rl37 (mout \2\:mout) resistor r=28.079 c=0
Rl38 (\2\:mout \3\:mout) resistor r=93.4636 c=0
Rl40 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=75.6918 c=0
Rl31 (\3\:CKbb \4\:CKbb) resistor r=46.8456 c=0
Rl28 (CKbb \2\:CKbb) resistor r=85.7713 c=0
Rl34 (\2\:n20 \4\:n20) resistor r=110.772 c=0
Rl33 (\2\:n20 \3\:n20) resistor r=35.772 c=0
Rl32 (n20 \2\:n20) resistor r=32.3537 c=0
Rz9 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz10 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\12\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz6 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\28\:qbint \27\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz7 (\9\:n20 \10\:n20) resistor r=75 c=0
Ry12 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry13 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry14 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry21 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry9 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry10 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry7 (n26 \2\:n26) resistor r=62 c=0
Ry8 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx5 (\10\:RN \8\:RN) resistor r=45 c=0
Rx9 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx10 (\3\:CKb \11\:CKb) resistor r=45 c=0
Rx2 (\19\:qbint \17\:qbint) resistor r=45 c=0
Rx3 (\24\:qbint qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx14 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx15 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx16 (\2\:CKbb \20\:CKbb) resistor r=45 c=0
Rx11 (n20 \8\:n20) resistor r=45 c=0
mn20 (\15\:CKb \1\:CK \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=2.03e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.60172e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn21 (\9\:CKbb \7\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn55_1__rcx (Q qbint \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.384e-14 ad=4.485e-14 ps=8.875e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.39423e-07 sb=1.73346e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(4)
mn45_1__rcx (16 \1\:RN \8\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.675e-14 ad=1.947e-14 ps=1.02e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14476e-06 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn46_1__rcx (\27\:qbint \4\:n30 16 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.947e-14 ad=3.28e-14 ps=6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28476e-06 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn46 (\27\:qbint \5\:n30 17 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=3.28e-14 ps=6.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48976e-06 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn45 (17 \6\:RN \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.715e-14 ad=2.358e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64976e-06 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn50 (n40 \18\:qbint \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.715e-14 ad=6.355e-14 ps=1.2e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96354e-06 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn51 (\7\:n30 CKb n40 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.355e-14 ad=3.28e-14 ps=1.03e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.7727 scb=0.0101457 \
        scc=0.000373012 m=(1)
mn40 (\7\:n30 \3\:CKbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.175e-14 ad=3.28e-14 ps=1.11e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.7727 scb=0.0101457 \
        scc=0.000373012 m=(1)
mn30 (\7\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.815e-14 ad=7.175e-14 ps=1.27e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.93707e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn35 (n27 \7\:RN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.815e-14 ad=5.433e-14 ps=1.27e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.54341e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.433e-14 ad=5.228e-14 ps=9.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.23341e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn37 (\9\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=3.28e-14 ps=9.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.33415e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn26 (\9\:n20 \9\:CKb n21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.175e-14 ad=3.28e-14 ps=1.11e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.28415e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=7.175e-14 ps=7.3e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.33415e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mp55 (Q qbint \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.452e-14 ad=7.02e-14 ps=1.5175e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8109e-07 sb=1.46949e-06 sd=160n sca=27.3684 \
        scb=0.0203057 scc=0.00278102 m=(4)
mp50 (n41 \16\:qbint \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=7.13e-14 ps=9.4e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.51532e-07 sb=1.08387e-06 sd=160n sca=11.1346 \
        scb=0.00910425 scc=0.000198662 m=(1)
mp51 (\11\:n30 CKbb n41 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=5.6e-14 ps=1.08e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12968e-06 sb=8.08871e-07 sd=160n sca=11.1346 \
        scb=0.00910425 scc=0.000198662 m=(1)
mp40 (\11\:n30 \2\:CKb \5\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=5.6e-14 ps=1.48e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.01774e-07 sb=1.36e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp30 (\5\:mout \4\:n20 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4575e-13 ad=1.333e-13 ps=2.02e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1929e-06 sb=8.85e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp35 (\3\:n26 \9\:RN \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4575e-13 ad=1.147e-13 ps=2.02e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.41968e-06 sb=5.15e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp36 (\3\:n26 mout \6\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=1.147e-13 ps=1.71e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66968e-06 sb=1e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp37 (\5\:n20 \8\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=7.595e-14 ps=1.13e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=6.64919e-07 sd=160n sca=20.6412 \
        scb=0.0183899 scc=0.00199566 m=(1)
mp26 (\5\:n20 \7\:CKbb n22 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=7.595e-14 ps=7.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.74919e-07 sd=160n sca=21.654 \
        scb=0.0189695 scc=0.00199623 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=1.86e-14 ps=9.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.69919e-07 sd=160n sca=22.4306 \
        scb=0.019868 scc=0.00199963 m=(1)
mp46_1__rcx (\20\:qbint n30 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.515e-14 ad=6.21e-14 ps=1.87e-06 pd=1.275e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24605e-06 sb=9.55e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(2)
mp45 (\20\:qbint RN \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.437e-14 ad=6.21e-14 ps=1.405e-06 pd=1.275e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04105e-06 sb=1.08065e-06 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(2)
ends DFFRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:33 2013 )
// Library name: gsclib045_hvt
// Cell name: DFFRHQX8
// View name: extracted

simulator lang=spectre

subckt DFFRHQX8 CK D Q RN VDD VSS
mp55_1__rcx (Q qbint \8\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.435e-14 ad=7.056e-14 ps=1.22857e-06 pd=1.20714e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.90096e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (RN VSS) capacitor c=4.59962e-16
C2 (VDD VSS) capacitor c=3.47222e-16
C3 (CK VSS) capacitor c=4.50305e-17
C4 (D VSS) capacitor c=3.57527e-17
C5 (Q VSS) capacitor c=4.97564e-16
C6 (qbint VSS) capacitor c=3.64144e-16
C7 (16 VSS) capacitor c=1.21854e-18
C8 (n30 VSS) capacitor c=5.93366e-16
C9 (17 VSS) capacitor c=4.69791e-18
C10 (18 VSS) capacitor c=9.60058e-19
C11 (CKb VSS) capacitor c=4.12355e-17
C12 (CKbb VSS) capacitor c=6.83983e-17
C13 (mout VSS) capacitor c=4.97291e-17
C14 (n20 VSS) capacitor c=2.22271e-17
