C3 (AN VSS) capacitor c=3.52583e-17
C4 (n1 VSS) capacitor c=1.56892e-18
C5 (n0 VSS) capacitor c=5.74477e-17
C6 (\1\:AN VSS) capacitor c=4.34787e-17
C7 (\4\:B VSS) capacitor c=4.00496e-17
C8 (\3\:AN VSS) capacitor c=3.59296e-17
C9 (\3\:n0 VSS) capacitor c=6.42643e-17
C10 (\1\:B VSS) capacitor c=5.59285e-17
C11 (\2\:AN VSS) capacitor c=3.92783e-17
C12 (\2\:n0 VSS) capacitor c=4.46418e-17
C13 (\3\:B VSS) capacitor c=1.09983e-17
C14 (\4\:n0 VSS) capacitor c=6.84821e-17
C15 (\1\:VDD VSS) capacitor c=4.88365e-17
C16 (\1\:Y VSS) capacitor c=4.08603e-17
C17 (\5\:VDD VSS) capacitor c=7.96577e-18
C18 (\7\:n0 VSS) capacitor c=4.82194e-17
C19 (\4\:Y VSS) capacitor c=7.47529e-17
C20 (\2\:B VSS) capacitor c=2.68349e-17
C21 (\5\:B VSS) capacitor c=3.32724e-17
C22 (\6\:B VSS) capacitor c=1.91864e-17
C23 (\6\:n0 VSS) capacitor c=1.22933e-16
C24 (\4\:AN VSS) capacitor c=4.95055e-17
C25 (\4\:VDD VSS) capacitor c=1.85125e-17
Rk4 (\2\:Y Y) resistor r=0.1555 c=0
Rk5 (Y \5\:Y) resistor r=0.5005 c=0
Rk1 (B \5\:B) resistor r=0.002798 c=0
Rk3 (\5\:B \6\:B) resistor r=0.06107 c=0
Rk2 (\6\:B \7\:B) resistor r=0.002946 c=0
Rk14 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3415 c=0
Rk11 (\4\:VDD VDD) resistor r=0.1511 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3443 c=0
Rk12 (VDD \6\:VDD) resistor r=0.06044 c=0
Rk9 (\4\:AN AN) resistor r=0.03221 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.5506 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.2967 c=0
Rl3 (\2\:B \4\:B) resistor r=39.8465 c=0
Rl1 (\1\:B \2\:B) resistor r=57.2019 c=0
Rl2 (\2\:B \3\:B) resistor r=6.4152 c=0
Rl6 (\1\:AN \2\:AN) resistor r=78.079 c=0
Rl7 (\2\:AN \3\:AN) resistor r=70.3867 c=0
Rl4 (n0 \2\:n0) resistor r=49.5142 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=42.2135 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:B \7\:B) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
mn2 (\4\:Y \1\:B n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.08e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.18462e-07 sb=3.76058e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.23462e-07 sb=2.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41379e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.22326e-07 sd=160n sca=26.8107 \
        scb=0.0301615 scc=0.00168945 m=(1)
ends NAND2BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:18 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2BX2
// View name: extracted

simulator lang=spectre

subckt NAND2BX2 AN B VDD VSS Y
mp1 (\1\:Y \2\:n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.998e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.76346e-07 sd=160n sca=24.5042 \
        scb=0.0279724 scc=0.00152894 m=(2)
mp2 (\1\:Y \3\:B \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.71346e-07 sd=160n sca=14.919 \
        scb=0.0137126 scc=0.000270031 m=(2)
C1 (Y VSS) capacitor c=1.43786e-16
C2 (B VSS) capacitor c=6.07611e-17
C3 (VDD VSS) capacitor c=2.43031e-16
C4 (n0 VSS) capacitor c=5.82454e-17
C5 (\1\:AN VSS) capacitor c=3.77466e-17
C6 (\3\:AN VSS) capacitor c=4.28264e-17
C7 (\6\:n0 VSS) capacitor c=6.8651e-17
C8 (\1\:B VSS) capacitor c=7.56426e-17
C9 (\4\:B VSS) capacitor c=5.22912e-17
C10 (\2\:AN VSS) capacitor c=4.29526e-17
C11 (\3\:B VSS) capacitor c=1.20981e-16
C12 (\2\:n0 VSS) capacitor c=3.69608e-16
C13 (\12\:n0 VSS) capacitor c=5.95005e-17
C14 (\1\:Y VSS) capacitor c=3.08045e-16
C15 (\8\:VDD VSS) capacitor c=6.34416e-17
C16 (\7\:n0 VSS) capacitor c=3.76398e-17
C17 (\6\:Y VSS) capacitor c=9.20654e-17
C18 (\2\:B VSS) capacitor c=4.05061e-17
C19 (\7\:B VSS) capacitor c=8.32838e-17
C20 (\9\:n0 VSS) capacitor c=7.50018e-17
C21 (\4\:AN VSS) capacitor c=3.80332e-17
C22 (\6\:AN VSS) capacitor c=1.85818e-17
Rk3 (\1\:Y Y) resistor r=0.9015 c=0
Rk5 (Y \7\:Y) resistor r=0.5334 c=0
Rk1 (\7\:B B) resistor r=0.2271 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.3423 c=0
Rk20 (\5\:VSS VSS) resistor r=0.1024 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.198 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.2283 c=0
Rk17 (VDD \9\:VDD) resistor r=0.2371 c=0
Rk10 (\4\:AN \5\:AN) resistor r=0.004659 c=0
Rk11 (AN \6\:AN) resistor r=0.004659 c=0
Rk12 (\4\:AN \6\:AN) resistor r=0.01774 c=0
Rk7 (\9\:n0 \2\:n0) resistor r=0.0382 c=0
Rk6 (\8\:n0 \9\:n0) resistor r=0.339 c=0
Rk9 (\9\:n0 \13\:n0) resistor r=0.4918 c=0
Rl3 (\2\:B \1\:B) resistor r=113.956 c=0
Rl5 (\2\:B \4\:B) resistor r=57.6674 c=0
Rl4 (\2\:B \3\:B) resistor r=96.1289 c=0
Rl10 (\1\:AN \2\:AN) resistor r=68.4636 c=0
Rl11 (\2\:AN \3\:AN) resistor r=126.156 c=0
Rl9 (\2\:n0 \6\:n0) resistor r=60.3072 c=0
Rl1 (\2\:n0 n0) resistor r=56.8672 c=0
Rz1 (\7\:Y \6\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Ry6 (\9\:VDD \8\:VDD) resistor r=31 c=0
Ry3 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\7\:B \3\:B) resistor r=45 c=0
Rx4 (\2\:AN \5\:AN) resistor r=45 c=0
mn1_1__rcx (7 n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.86058e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_1__rcx (\6\:Y \4\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.81058e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\6\:Y \1\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=3.76058e-07 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mn1 (8 \6\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.71058e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp0 (\12\:n0 \1\:AN VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.69e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.25116e-07 sd=160n sca=17.3594 \
        scb=0.0179801 scc=0.000463826 m=(1)
ends NAND2BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:20 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2BX4
// View name: extracted

simulator lang=spectre

subckt NAND2BX4 AN B VDD VSS Y
mp0 (\14\:n0 \1\:AN VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.4e-07 sd=160n sca=16.1834 \
        scb=0.0159482 scc=0.0003331 m=(1)
mp1_1__rcx (\1\:Y \2\:n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.78e-06 sd=160n sca=25.0495 \
        scb=0.0285542 scc=0.00163822 m=(4)
mp2_1__rcx (\1\:Y \3\:B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.575e-06 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(4)
C1 (B VSS) capacitor c=5.4045e-17
C2 (Y VSS) capacitor c=2.25105e-16
C3 (AN VSS) capacitor c=3.23546e-17
C4 (VDD VSS) capacitor c=4.98864e-16
C5 (n0 VSS) capacitor c=5.9511e-17
C6 (\1\:AN VSS) capacitor c=4.84101e-17
C7 (\3\:AN VSS) capacitor c=4.98638e-17
C8 (\13\:n0 VSS) capacitor c=5.93722e-17
C9 (\7\:B VSS) capacitor c=7.48486e-17
C10 (\11\:B VSS) capacitor c=5.22968e-17
C11 (\4\:n0 VSS) capacitor c=5.3245e-17
C12 (\7\:n0 VSS) capacitor c=5.7331e-17
C13 (\1\:B VSS) capacitor c=7.35609e-17
C14 (\5\:B VSS) capacitor c=5.31517e-17
C15 (\2\:AN VSS) capacitor c=6.15612e-17
C16 (\3\:B VSS) capacitor c=4.62804e-16
C17 (\2\:n0 VSS) capacitor c=8.72858e-16
C18 (\14\:n0 VSS) capacitor c=8.15397e-17
C19 (\1\:Y VSS) capacitor c=6.56214e-16
C20 (\20\:n0 VSS) capacitor c=5.84815e-17
C21 (\15\:Y VSS) capacitor c=1.07766e-16
C22 (\9\:Y VSS) capacitor c=3.95146e-17
C23 (\2\:B VSS) capacitor c=4.34022e-17
C24 (\8\:B VSS) capacitor c=4.0721e-17
C25 (\8\:Y VSS) capacitor c=1.34454e-16
C26 (\5\:AN VSS) capacitor c=5.27492e-17
Rk2 (\3\:B B) resistor r=0.14 c=0
Rk30 (\2\:VSS \4\:VSS) resistor r=0.5225 c=0
Rk31 (\4\:VSS \5\:VSS) resistor r=0.03749 c=0
Rk33 (\6\:VSS VSS) resistor r=0.1528 c=0
Rk32 (\5\:VSS \6\:VSS) resistor r=0.3112 c=0
Rk34 (\5\:VSS \8\:VSS) resistor r=0.2304 c=0
Rk35 (\6\:VSS \10\:VSS) resistor r=0.2304 c=0
Rk4 (\1\:Y Y) resistor r=1.5894 c=0
Rk8 (Y \8\:Y) resistor r=0.4932 c=0
Rk9 (\8\:Y \10\:Y) resistor r=0.1197 c=0
Rk12 (\8\:Y \16\:Y) resistor r=0.674 c=0
Rk18 (\4\:AN \5\:AN) resistor r=0.003261 c=0
Rk19 (\6\:AN AN) resistor r=0.003261 c=0
Rk20 (\5\:AN \6\:AN) resistor r=0.0634 c=0
Rk13 (\15\:n0 \2\:n0) resistor r=0.6816 c=0
Rk17 (\2\:n0 \21\:n0) resistor r=0.3785 c=0
Rl3 (\2\:B \1\:B) resistor r=125.426 c=0
Rl6 (\2\:B \5\:B) resistor r=60.772 c=0
Rl4 (\2\:B \3\:B) resistor r=89.4132 c=0
Rl14 (\8\:B \7\:B) resistor r=125.426 c=0
Rl17 (\8\:B \11\:B) resistor r=60.772 c=0
Rl15 (\8\:B \3\:B) resistor r=90.7162 c=0
Rl21 (\1\:AN \2\:AN) resistor r=96.0237 c=0
Rl22 (\2\:AN \3\:AN) resistor r=106.613 c=0
Rl20 (\2\:n0 \13\:n0) resistor r=33.7912 c=0
Rl8 (\2\:n0 \4\:n0) resistor r=61.5385 c=0
Rl10 (\2\:n0 \7\:n0) resistor r=92.6161 c=0
Rl1 (\2\:n0 n0) resistor r=64.2323 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz1 (\10\:Y \9\:Y) resistor r=37.5 c=0
Rz2 (\16\:Y \15\:Y) resistor r=37.5 c=0
Rz3 (\21\:n0 \20\:n0) resistor r=37.5 c=0
Ry5 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx6 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (7 n0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_1__rcx (\9\:Y \5\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.275e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_2__rcx (\9\:Y \1\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.07e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn1_2__rcx (8 \7\:n0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=9.65e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn1_3__rcx (9 \4\:n0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=7.6e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_3__rcx (\15\:Y \11\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=6.55e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\15\:Y \7\:B 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.07e-06 sb=4.5e-07 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mn1 (10 \13\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=3.45e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn0 (\20\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=1.4e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
ends NAND2BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:21 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2BXL
// View name: extracted

simulator lang=spectre

subckt NAND2BXL AN B VDD VSS Y
mp2 (\1\:Y \3\:B \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-07 sb=5.5e-07 sd=160n sca=29.0688 \
        scb=0.0326842 scc=0.00215013 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=19.8763 \
        scb=0.0203148 scc=0.000456883 m=(1)
mp0 (\7\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.01e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=27.33 scb=0.0309842 \
        scc=0.00176829 m=(1)
C1 (B VSS) capacitor c=7.50266e-17
C2 (VDD VSS) capacitor c=8.24883e-17
C3 (AN VSS) capacitor c=3.51004e-17
C4 (Y VSS) capacitor c=2.31469e-17
C5 (n1 VSS) capacitor c=3.04313e-18
C6 (n0 VSS) capacitor c=3.8229e-17
C7 (\1\:AN VSS) capacitor c=3.46999e-17
C8 (\3\:B VSS) capacitor c=2.91447e-17
C9 (\3\:AN VSS) capacitor c=3.87821e-17
C10 (\3\:n0 VSS) capacitor c=5.00511e-17
C11 (\1\:B VSS) capacitor c=3.97758e-17
C12 (\2\:AN VSS) capacitor c=3.90813e-17
C13 (\2\:n0 VSS) capacitor c=4.93464e-17
C14 (\2\:B VSS) capacitor c=3.79133e-17
C15 (\7\:n0 VSS) capacitor c=4.33568e-17
C16 (\1\:VDD VSS) capacitor c=1.11991e-17
C17 (\1\:Y VSS) capacitor c=4.21675e-17
C18 (\5\:VDD VSS) capacitor c=2.13678e-17
C19 (\4\:n0 VSS) capacitor c=6.49359e-17
C20 (\4\:Y VSS) capacitor c=7.92514e-17
C21 (\3\:Y VSS) capacitor c=3.56768e-17
C22 (\4\:B VSS) capacitor c=6.35841e-17
C23 (\6\:n0 VSS) capacitor c=1.12392e-16
C24 (\4\:AN VSS) capacitor c=6.15053e-17
C25 (\4\:VDD VSS) capacitor c=2.00749e-17
Rk12 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.4176 c=0
Rk4 (B \4\:B) resistor r=0.2021 c=0
Rk9 (\4\:VDD VDD) resistor r=0.1507 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.1222 c=0
Rk10 (VDD \6\:VDD) resistor r=0.07764 c=0
Rk7 (AN \4\:AN) resistor r=0.04974 c=0
Rk3 (\3\:Y Y) resistor r=0.07463 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.1099 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.3398 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.3855 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.3127 c=0
Rl2 (\2\:B \3\:B) resistor r=41.4835 c=0
Rl1 (\1\:B \2\:B) resistor r=98.0769 c=0
Rl5 (\1\:AN \2\:AN) resistor r=33.8482 c=0
Rl6 (\2\:AN \3\:AN) resistor r=101.156 c=0
Rl3 (n0 \2\:n0) resistor r=24.2328 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=110.771 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
mn2 (\4\:Y \1\:B n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.175e-14 ps=5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=4.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.522e-14 ps=6.1e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=3.45e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\4\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends NAND2BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:22 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2X1
// View name: extracted

simulator lang=spectre

subckt NAND2X1 A B VDD VSS Y
mp0 (\3\:Y \1\:A \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.25e-07 sd=160n sca=36.5212 \
        scb=0.040075 scc=0.00317187 m=(1)
mp1 (\3\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=6.24e-14 ps=1.7e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.2e-07 sd=160n sca=37.5084 \
        scb=0.0409147 scc=0.00340882 m=(1)
C1 (Y VSS) capacitor c=5.32179e-17
C2 (VDD VSS) capacitor c=4.20012e-17
C3 (B VSS) capacitor c=2.45699e-17
C4 (\1\:B VSS) capacitor c=4.14367e-17
C5 (\1\:A VSS) capacitor c=3.48823e-17
C6 (\3\:B VSS) capacitor c=4.71311e-17
C7 (\4\:A VSS) capacitor c=6.04062e-17
C8 (\2\:B VSS) capacitor c=3.99212e-17
C9 (\3\:A VSS) capacitor c=1.32967e-17
C10 (\1\:VDD VSS) capacitor c=4.91555e-18
C11 (\3\:Y VSS) capacitor c=8.07507e-17
C12 (\5\:VDD VSS) capacitor c=3.92856e-17
C13 (\1\:Y VSS) capacitor c=5.93624e-17
C14 (\2\:A VSS) capacitor c=2.6342e-17
C15 (\5\:A VSS) capacitor c=5.82932e-17
C16 (\4\:B VSS) capacitor c=6.69072e-17
C17 (\4\:VDD VSS) capacitor c=1.08715e-17
Rk5 (\2\:Y Y) resistor r=0.2303 c=0
Rk6 (Y \4\:Y) resistor r=0.3412 c=0
Rk8 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.1406 c=0
Rk9 (VDD \6\:VDD) resistor r=0.3286 c=0
Rk4 (\4\:B B) resistor r=0.01 c=0
Rk2 (\4\:B \5\:B) resistor r=0.001047 c=0
Rk1 (\5\:A A) resistor r=0.01023 c=0
Rk11 (VSS \4\:VSS) resistor r=0.2793 c=0
Rl4 (\1\:B \2\:B) resistor r=90.782 c=0
Rl5 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl1 (\1\:A \2\:A) resistor r=37.3411 c=0
Rl3 (\2\:A \4\:A) resistor r=96.9565 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2301 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
mn0 (n0 \4\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\1\:Y \3\:B n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.81e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.55e-07 sb=1.85e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends NAND2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:23 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2X2
// View name: extracted

simulator lang=spectre

subckt NAND2X2 A B VDD VSS Y
mp0 (\1\:Y \2\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.405e-14 ad=6.24e-14 ps=1.39e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(2)
mp1 (\1\:Y \1\:B \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.3e-07 sd=160n sca=24.0497 \
        scb=0.0216272 scc=0.0017588 m=(2)
C1 (Y VSS) capacitor c=9.84517e-17
C2 (A VSS) capacitor c=2.31334e-17
C3 (VDD VSS) capacitor c=1.31787e-16
C4 (7 VSS) capacitor c=1.89232e-18
C5 (\1\:B VSS) capacitor c=1.41677e-16
C6 (\6\:A VSS) capacitor c=5.18992e-17
C7 (\6\:B VSS) capacitor c=4.77445e-17
C8 (\5\:B VSS) capacitor c=4.85657e-17
C9 (\1\:A VSS) capacitor c=5.38831e-17
C10 (\2\:A VSS) capacitor c=3.88605e-16
C11 (\1\:Y VSS) capacitor c=2.2955e-16
C12 (\7\:VDD VSS) capacitor c=8.58299e-17
C13 (\6\:Y VSS) capacitor c=9.32618e-17
C14 (\8\:B VSS) capacitor c=4.13948e-17
C15 (\10\:B VSS) capacitor c=4.95438e-17
Rk9 (\1\:Y Y) resistor r=0.2606 c=0
Rk10 (Y \7\:Y) resistor r=0.5711 c=0
Rk5 (\2\:A A) resistor r=0.08755 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.2984 c=0
Rk17 (\5\:VSS VSS) resistor r=0.03743 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1639 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.2768 c=0
Rk14 (VDD \8\:VDD) resistor r=0.2513 c=0
Rk1 (\8\:B \9\:B) resistor r=0.001284 c=0
Rk2 (B \10\:B) resistor r=0.001284 c=0
Rk3 (\8\:B \10\:B) resistor r=0.04073 c=0
Rl10 (\2\:A \6\:A) resistor r=46.9721 c=0
Rl1 (\2\:A \1\:A) resistor r=50 c=0
Rl7 (\1\:B \6\:B) resistor r=40.849 c=0
Rl6 (\1\:B \5\:B) resistor r=53.6577 c=0
Rz1 (\7\:Y \6\:Y) resistor r=37.5 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Ry5 (\8\:VDD \7\:VDD) resistor r=31 c=0
Rx1 (\9\:B \1\:B) resistor r=45 c=0
mn0_1__rcx (6 \1\:A \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\6\:Y \5\:B 6 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.8e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\6\:Y \6\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=2.75e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (7 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=1.56e-14 ps=1.33e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.7e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends NAND2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:25 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2X4
// View name: extracted

simulator lang=spectre

subckt NAND2X4 A B VDD VSS Y
mp0_1__rcx (\1\:Y A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=32.0426 \
        scb=0.0350053 scc=0.00300251 m=(4)
mp1_1__rcx (\1\:Y B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=22.0088 \
        scb=0.0203326 scc=0.00163789 m=(4)
C1 (A VSS) capacitor c=6.51018e-16
C2 (Y VSS) capacitor c=5.78314e-17
C3 (VDD VSS) capacitor c=4.1784e-16
C4 (B VSS) capacitor c=4.10351e-16
C5 (7 VSS) capacitor c=1.36339e-18
C6 (8 VSS) capacitor c=1.36339e-18
C7 (9 VSS) capacitor c=1.34363e-18
C8 (\12\:A VSS) capacitor c=4.94613e-17
C9 (\13\:B VSS) capacitor c=6.17997e-17
C10 (\11\:B VSS) capacitor c=5.41064e-17
C11 (\4\:A VSS) capacitor c=4.87216e-17
C12 (\6\:A VSS) capacitor c=6.07272e-17
C13 (\1\:B VSS) capacitor c=5.43502e-17
C14 (\4\:B VSS) capacitor c=5.89124e-17
C15 (\1\:A VSS) capacitor c=7.22735e-17
C16 (\1\:Y VSS) capacitor c=4.62782e-16
C17 (\10\:Y VSS) capacitor c=2.68071e-17
C18 (\19\:Y VSS) capacitor c=1.01043e-16
C19 (\2\:B VSS) capacitor c=3.3771e-17
C20 (\10\:B VSS) capacitor c=3.50701e-17
C21 (\9\:Y VSS) capacitor c=1.34134e-16
Rk29 (\2\:VSS \4\:VSS) resistor r=0.4766 c=0
Rk30 (\4\:VSS \5\:VSS) resistor r=0.0324 c=0
Rk32 (\6\:VSS VSS) resistor r=0.1074 c=0
Rk31 (\5\:VSS \6\:VSS) resistor r=0.3105 c=0
Rk33 (\5\:VSS \8\:VSS) resistor r=0.2273 c=0
Rk34 (\6\:VSS \10\:VSS) resistor r=0.264 c=0
Rk11 (\1\:Y Y) resistor r=0.1521 c=0
Rk12 (Y \9\:Y) resistor r=0.4921 c=0
Rk13 (\9\:Y \11\:Y) resistor r=0.0698 c=0
Rk19 (\9\:Y \20\:Y) resistor r=0.5733 c=0
Rl20 (A \12\:A) resistor r=28.6412 c=0
Rl8 (A \4\:A) resistor r=28.3837 c=0
Rl9 (A \6\:A) resistor r=78.5649 c=0
Rl1 (A \1\:A) resistor r=86.5156 c=0
Rl4 (\2\:B B) resistor r=6.458 c=0
Rl3 (\2\:B \1\:B) resistor r=92.7662 c=0
Rl5 (\2\:B \4\:B) resistor r=104.305 c=0
Rl15 (\10\:B B) resistor r=10.5426 c=0
Rl18 (\10\:B \13\:B) resistor r=116.792 c=0
Rl16 (\10\:B \11\:B) resistor r=67.3711 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz1 (\11\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\20\:Y \19\:Y) resistor r=37.5 c=0
mn0_1__rcx (6 \1\:A \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (\19\:Y \4\:B 6 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.1e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_2__rcx (\19\:Y \1\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.95e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_2__rcx (7 \6\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.9e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (8 \4\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=5.85e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_3__rcx (\10\:Y \11\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=4.8e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (\10\:Y \13\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.07e-06 sb=2.75e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0 (9 \12\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.7e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
ends NAND2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:26 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2X6
// View name: extracted

simulator lang=spectre

subckt NAND2X6 A B VDD VSS Y
mp0_1__rcx (\1\:Y \2\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=6.305e-14 ps=1.08667e-06 pd=1.10333e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=32.0426 scb=0.0350053 \
        scc=0.00300251 m=(6)
mp1_1__rcx (\1\:Y B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.305e-14 ps=1.1e-06 pd=1.10333e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=22.0088 scb=0.0203326 \
        scc=0.00163789 m=(6)
C1 (A VSS) capacitor c=1.09831e-17
C2 (Y VSS) capacitor c=8.65689e-17
C3 (VDD VSS) capacitor c=6.06685e-16
C4 (B VSS) capacitor c=8.13246e-16
C5 (6 VSS) capacitor c=5.30371e-18
C6 (7 VSS) capacitor c=2.54934e-18
C7 (8 VSS) capacitor c=8.5648e-18
C8 (9 VSS) capacitor c=1.82949e-18
C9 (10 VSS) capacitor c=1.79953e-18
C10 (\16\:B VSS) capacitor c=6.98908e-17
C11 (\11\:A VSS) capacitor c=5.43052e-17
C12 (\15\:A VSS) capacitor c=5.29641e-17
C13 (\8\:B VSS) capacitor c=6.35861e-17
C14 (\12\:B VSS) capacitor c=2.68954e-17
C15 (\4\:A VSS) capacitor c=2.42979e-17
C16 (\8\:A VSS) capacitor c=4.34053e-17
C17 (\1\:B VSS) capacitor c=4.74912e-17
C18 (\5\:B VSS) capacitor c=5.812e-17
C19 (\1\:A VSS) capacitor c=5.49718e-17
C20 (\2\:A VSS) capacitor c=9.57084e-16
C21 (\1\:Y VSS) capacitor c=6.75947e-16
C22 (\12\:Y VSS) capacitor c=1.7196e-17
C23 (\28\:Y VSS) capacitor c=2.32985e-17
C24 (\30\:Y VSS) capacitor c=1.16692e-16
C25 (\11\:Y VSS) capacitor c=1.1812e-16
C26 (\27\:Y VSS) capacitor c=1.17947e-16
Rk45 (\2\:VSS \3\:VSS) resistor r=0.4104 c=0
Rk46 (\3\:VSS \4\:VSS) resistor r=0.29 c=0
Rk47 (\4\:VSS \5\:VSS) resistor r=0.1469 c=0
Rk49 (\6\:VSS VSS) resistor r=0.04974 c=0
Rk48 (\5\:VSS \6\:VSS) resistor r=0.3525 c=0
Rk50 (\3\:VSS \8\:VSS) resistor r=0.1262 c=0
Rk51 (\5\:VSS \10\:VSS) resistor r=0.1262 c=0
Rk52 (\6\:VSS \12\:VSS) resistor r=0.2827 c=0
Rk8 (\2\:A A) resistor r=0.01242 c=0
Rk16 (\1\:Y Y) resistor r=0.1688 c=0
Rk17 (Y \11\:Y) resistor r=0.6436 c=0
Rk18 (\11\:Y \13\:Y) resistor r=0.04664 c=0
Rk28 (\11\:Y \27\:Y) resistor r=0.5467 c=0
Rk29 (\27\:Y \29\:Y) resistor r=0.04664 c=0
Rk30 (\27\:Y \31\:Y) resistor r=0.7599 c=0
Rl20 (\2\:A \11\:A) resistor r=34.6466 c=0
Rl23 (\2\:A \15\:A) resistor r=34.3295 c=0
Rl9 (\2\:A \4\:A) resistor r=34.0954 c=0
Rl12 (\2\:A \8\:A) resistor r=34.7148 c=0
Rl1 (\2\:A \1\:A) resistor r=26.9231 c=0
Rl27 (B \16\:B) resistor r=76.7373 c=0
Rl15 (B \8\:B) resistor r=91.0296 c=0
Rl18 (B \12\:B) resistor r=75.8974 c=0
Rl3 (B \1\:B) resistor r=80.7323 c=0
Rl6 (B \5\:B) resistor r=81.9857 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\13\:Y \12\:Y) resistor r=37.5 c=0
Rz2 (\29\:Y \28\:Y) resistor r=37.5 c=0
Rz3 (\31\:Y \30\:Y) resistor r=37.5 c=0
Ry20 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry21 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (6 \1\:A \11\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=1.86e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_1__rcx (\30\:Y \5\:B 6 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.89e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.75e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_2__rcx (\30\:Y \1\:B 7 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.635e-14 ad=5.89e-14 ps=7.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.515e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_2__rcx (7 \8\:A \9\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=2.635e-14 ps=1.3e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.385e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_3__rcx (8 \4\:A \9\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=7.905e-14 ps=1.3e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.12e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_3__rcx (\28\:Y \12\:B 8 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=4.96e-14 ps=1.13e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=8.2e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_4__rcx (\28\:Y \8\:B 9 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=6.15e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_4__rcx (9 \15\:A \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=1.86e-14 ps=1.3e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.1e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0 (10 \11\:A \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=1.86e-14 ps=1.3e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.45e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1 (\12\:Y \16\:B 10 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1.4e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
ends NAND2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:27 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2X8
// View name: extracted

simulator lang=spectre

subckt NAND2X8 A B VDD VSS Y
mp0_1__rcx (\4\:Y \2\:A VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.8642 scb=0.0316804 \
        scc=0.00218972 m=(7)
mp1_1__rcx (\4\:Y \1\:B VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.8304 scb=0.0170078 \
        scc=0.000825102 m=(7)
C1 (VDD VSS) capacitor c=6.73675e-16
C2 (B VSS) capacitor c=1.51192e-17
C3 (A VSS) capacitor c=2.51424e-17
C4 (Y VSS) capacitor c=4.77584e-17
C5 (7 VSS) capacitor c=1.5146e-18
C6 (8 VSS) capacitor c=4.03895e-18
C7 (9 VSS) capacitor c=3.26021e-18
C8 (10 VSS) capacitor c=3.28164e-18
C9 (11 VSS) capacitor c=2.52434e-18
C10 (12 VSS) capacitor c=1.5146e-18
C11 (\1\:B VSS) capacitor c=1.06918e-15
C12 (\24\:B VSS) capacitor c=6.86429e-17
C13 (\21\:A VSS) capacitor c=5.22717e-17
C14 (\22\:A VSS) capacitor c=3.90063e-17
C15 (\20\:B VSS) capacitor c=4.36467e-17
C16 (\19\:B VSS) capacitor c=3.73818e-17
C17 (\11\:A VSS) capacitor c=3.28359e-17
C18 (\15\:A VSS) capacitor c=3.29605e-17
C19 (\13\:B VSS) capacitor c=3.72543e-17
C20 (\12\:B VSS) capacitor c=3.33867e-17
C21 (\9\:A VSS) capacitor c=2.96419e-17
C22 (\8\:A VSS) capacitor c=7.36646e-17
C23 (\6\:B VSS) capacitor c=5.90065e-17
C24 (\5\:B VSS) capacitor c=6.0671e-17
C25 (\1\:A VSS) capacitor c=5.49782e-17
C26 (\2\:A VSS) capacitor c=1.12905e-15
C27 (\1\:Y VSS) capacitor c=1.97285e-17
C28 (\13\:Y VSS) capacitor c=1.89981e-16
C29 (\28\:Y VSS) capacitor c=1.98234e-16
C30 (\30\:Y VSS) capacitor c=1.3511e-16
C31 (\3\:Y VSS) capacitor c=8.55061e-17
C32 (\4\:Y VSS) capacitor c=8.01132e-16
Rk46 (\2\:VSS \3\:VSS) resistor r=0.1345 c=0
Rk47 (\3\:VSS \4\:VSS) resistor r=0.3947 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.2702 c=0
Rk49 (\5\:VSS \6\:VSS) resistor r=0.1622 c=0
Rk51 (\7\:VSS VSS) resistor r=0.0498 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.3378 c=0
Rk52 (\3\:VSS \9\:VSS) resistor r=0.1866 c=0
Rk53 (\4\:VSS \11\:VSS) resistor r=0.1866 c=0
Rk54 (\6\:VSS \13\:VSS) resistor r=0.1854 c=0
Rk55 (\7\:VSS \15\:VSS) resistor r=0.3013 c=0
Rk9 (\1\:B B) resistor r=0.005605 c=0
Rk4 (\2\:A A) resistor r=0.03147 c=0
Rk11 (\3\:Y Y) resistor r=0.3219 c=0
Rk10 (\2\:Y \3\:Y) resistor r=0.07404 c=0
Rk12 (Y \4\:Y) resistor r=0.1435 c=0
Rk19 (\3\:Y \12\:Y) resistor r=0.5996 c=0
Rk20 (\12\:Y \14\:Y) resistor r=0.07404 c=0
Rk27 (\12\:Y \27\:Y) resistor r=0.7166 c=0
Rk28 (\27\:Y \29\:Y) resistor r=0.07404 c=0
Rk29 (\27\:Y \31\:Y) resistor r=0.7924 c=0
Rl39 (\1\:B \24\:B) resistor r=82.1429 c=0
Rl31 (\1\:B \20\:B) resistor r=90.0987 c=0
Rl30 (\1\:B \19\:B) resistor r=90.0987 c=0
Rl19 (\1\:B \13\:B) resistor r=90.0987 c=0
Rl18 (\1\:B \12\:B) resistor r=90.0987 c=0
Rl7 (\1\:B \6\:B) resistor r=90.0987 c=0
Rl6 (\1\:B \5\:B) resistor r=90.0987 c=0
Rl35 (\2\:A \21\:A) resistor r=37.3411 c=0
Rl36 (\2\:A \22\:A) resistor r=36.6367 c=0
Rl21 (\2\:A \11\:A) resistor r=34.7464 c=0
Rl24 (\2\:A \15\:A) resistor r=32.6324 c=0
Rl13 (\2\:A \9\:A) resistor r=38.5087 c=0
Rl12 (\2\:A \8\:A) resistor r=44.3957 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=37.5 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz10 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz1 (\2\:Y \1\:Y) resistor r=37.5 c=0
Rz2 (\14\:Y \13\:Y) resistor r=37.5 c=0
Rz3 (\29\:Y \28\:Y) resistor r=37.5 c=0
Rz4 (\31\:Y \30\:Y) resistor r=37.5 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry17 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (6 \1\:A \14\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=1.77e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1_1__rcx (\30\:Y \5\:B 6 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1_2__rcx (\30\:Y \6\:B 7 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0_2__rcx (7 \8\:A \12\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=1.77e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0_3__rcx (8 \9\:A \12\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=4.72e-14 ps=1.24e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.885e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_3__rcx (\28\:Y \12\:B 8 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.68e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_4__rcx (\28\:Y \13\:B 9 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.72e-14 ps=8.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.475e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn0_4__rcx (9 \15\:A \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.835e-14 ps=1.16e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.3e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn0_5__rcx (10 \11\:A \10\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.835e-14 ps=1.16e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=1.035e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_5__rcx (\13\:Y \19\:B 10 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.72e-14 ps=8.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.885e-06 sb=8.6e-07 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_6__rcx (\13\:Y \20\:B 11 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=2.95e-14 ad=4.72e-14 ps=7.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.55e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0_6__rcx (11 \22\:A \8\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=2.95e-14 ps=1.16e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.1e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0 (12 \21\:A \8\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=1.77e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1 (\1\:Y \24\:B 12 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.13e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
ends NAND2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:28 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND2XL
// View name: extracted

simulator lang=spectre

subckt NAND2XL A B VDD VSS Y
mp0 (\3\:Y \3\:A \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=3.4e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
mp1 (\3\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.35e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
C1 (VDD VSS) capacitor c=4.89314e-17
C2 (B VSS) capacitor c=2.71429e-17
C3 (A VSS) capacitor c=2.70662e-17
C4 (\1\:B VSS) capacitor c=3.02361e-17
C5 (\3\:A VSS) capacitor c=3.68575e-17
C6 (\3\:B VSS) capacitor c=4.81071e-17
C7 (\1\:A VSS) capacitor c=3.69658e-17
C8 (\2\:B VSS) capacitor c=4.476e-17
C9 (\2\:A VSS) capacitor c=5.13563e-17
C10 (\1\:VDD VSS) capacitor c=2.03612e-17
C11 (\3\:Y VSS) capacitor c=6.07873e-17
C12 (\5\:VDD VSS) capacitor c=3.11105e-18
C13 (\1\:Y VSS) capacitor c=8.95008e-17
C14 (\4\:A VSS) capacitor c=3.46739e-17
C15 (\4\:B VSS) capacitor c=5.27137e-17
C16 (\4\:VDD VSS) capacitor c=1.18958e-17
Rk9 (\3\:VSS VSS) resistor r=0.01706 c=0
Rk10 (\3\:VSS \5\:VSS) resistor r=0.2976 c=0
Rk6 (\4\:VDD VDD) resistor r=0.1001 c=0
Rk5 (\2\:VDD \4\:VDD) resistor r=0.2592 c=0
Rk7 (VDD \6\:VDD) resistor r=0.1677 c=0
Rk2 (\4\:B B) resistor r=0.03695 c=0
Rk1 (\4\:A A) resistor r=0.05013 c=0
Rk3 (Y \2\:Y) resistor r=0.002476 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.5783 c=0
Rl3 (\1\:B \2\:B) resistor r=65.3846 c=0
Rl4 (\2\:B \3\:B) resistor r=83.7912 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (n0 \1\:A \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\1\:Y \3\:B n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 scb=0.0129007 \
        scc=0.000589158 m=(1)
ends NAND2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:29 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3BX1
// View name: extracted

simulator lang=spectre

subckt NAND3BX1 AN B C VDD VSS Y
mp3 (\6\:Y \3\:C \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.82308e-07 sd=160n sca=19.3275 \
        scb=0.0211052 scc=0.000636468 m=(1)
mp2 (\1\:Y \1\:B \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.77308e-07 sd=160n sca=14.532 \
        scb=0.0121946 scc=0.000242813 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.643e-14 ad=6.24e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.72308e-07 sd=160n sca=14.3198 \
        scb=0.0117685 scc=0.000238368 m=(1)
C1 (B VSS) capacitor c=5.06123e-17
C2 (VDD VSS) capacitor c=1.11069e-16
C3 (C VSS) capacitor c=3.96815e-17
C4 (AN VSS) capacitor c=4.34374e-17
C5 (Y VSS) capacitor c=1.02925e-16
C6 (n0 VSS) capacitor c=6.3207e-17
C7 (\1\:AN VSS) capacitor c=3.87081e-17
C8 (\1\:B VSS) capacitor c=5.58066e-17
C9 (\3\:C VSS) capacitor c=4.58767e-17
C10 (\3\:AN VSS) capacitor c=3.67102e-17
C11 (\3\:n0 VSS) capacitor c=5.19753e-17
C12 (\3\:B VSS) capacitor c=6.3295e-17
C13 (\1\:C VSS) capacitor c=4.79944e-17
C14 (\2\:AN VSS) capacitor c=4.52453e-17
C15 (\2\:n0 VSS) capacitor c=5.75085e-17
C16 (\2\:B VSS) capacitor c=5.39973e-17
C17 (\2\:C VSS) capacitor c=4.44899e-17
C18 (\4\:n0 VSS) capacitor c=5.34934e-17
C19 (\1\:VDD VSS) capacitor c=4.26698e-17
C20 (\1\:Y VSS) capacitor c=9.75933e-17
C21 (\6\:VDD VSS) capacitor c=6.76605e-17
C22 (\6\:Y VSS) capacitor c=2.99206e-17
C23 (\8\:n0 VSS) capacitor c=1.56914e-17
C24 (\4\:Y VSS) capacitor c=7.6031e-17
C25 (\4\:C VSS) capacitor c=8.69528e-17
C26 (\5\:B VSS) capacitor c=4.69598e-17
C27 (\4\:AN VSS) capacitor c=4.82935e-17
C28 (\6\:n0 VSS) capacitor c=6.21414e-17
C29 (\7\:n0 VSS) capacitor c=5.73776e-17
C30 (\4\:VDD VSS) capacitor c=2.46216e-17
C31 (\5\:VDD VSS) capacitor c=8.29943e-18
Rk18 (\4\:VSS VSS) resistor r=0.2503 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.3462 c=0
Rk4 (B \5\:B) resistor r=0.02394 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.3331 c=0
Rk15 (\5\:VDD VDD) resistor r=0.1399 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1101 c=0
Rk16 (\5\:VDD \7\:VDD) resistor r=0.2492 c=0
Rk1 (C \4\:C) resistor r=0.1137 c=0
Rk9 (AN \4\:AN) resistor r=0.09311 c=0
Rk6 (\3\:Y Y) resistor r=0.04558 c=0
Rk5 (\2\:Y \3\:Y) resistor r=0.4817 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4932 c=0
Rk8 (Y \7\:Y) resistor r=0.1337 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.4199 c=0
Rk11 (\6\:n0 \7\:n0) resistor r=0.2802 c=0
Rk12 (\6\:n0 \9\:n0) resistor r=0.08538 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl2 (\2\:C \3\:C) resistor r=79.9451 c=0
Rl1 (\1\:C \2\:C) resistor r=92.3077 c=0
Rl7 (\1\:AN \2\:AN) resistor r=84.6154 c=0
Rl8 (\2\:AN \3\:AN) resistor r=87.5194 c=0
Rl5 (n0 \2\:n0) resistor r=103.378 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=68.5619 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz1 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\4\:Y \1\:C n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=3.64e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=5.81058e-07 sd=160n sca=11.0409 scb=0.0104003 scc=0.000454168 \
        m=(1)
mn2 (n1 \3\:B n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=2.73e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.9e-07 sb=4.31058e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn1 (n2 \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.99e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.71058e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.643e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=20.3233 \
        scb=0.0227744 scc=0.000772584 m=(1)
ends NAND3BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:30 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3BX2
// View name: extracted

simulator lang=spectre

subckt NAND3BX2 AN B C VDD VSS Y
mp1 (\1\:Y \2\:n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.997e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32109e-06 sd=160n sca=25.2782 \
        scb=0.0260046 scc=0.0018836 m=(2)
mp2 (\1\:Y B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11609e-06 sd=160n sca=20.5883 \
        scb=0.0179916 scc=0.00160367 m=(2)
mp3 (\6\:Y \1\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=9.0109e-07 sd=160n sca=19.0783 \
        scb=0.0162806 scc=0.00159629 m=(2)
C1 (Y VSS) capacitor c=9.54707e-17
C2 (B VSS) capacitor c=4.09113e-16
C3 (C VSS) capacitor c=8.24074e-17
C4 (AN VSS) capacitor c=1.11758e-16
C5 (VDD VSS) capacitor c=7.69403e-17
C6 (8 VSS) capacitor c=4.52973e-18
C7 (n0 VSS) capacitor c=3.98999e-17
C8 (9 VSS) capacitor c=4.76826e-18
C9 (10 VSS) capacitor c=6.65953e-18
C10 (11 VSS) capacitor c=3.95926e-18
C11 (\1\:AN VSS) capacitor c=2.94046e-17
C12 (\1\:C VSS) capacitor c=1.02584e-16
C13 (\3\:AN VSS) capacitor c=4.08382e-17
C14 (\6\:n0 VSS) capacitor c=4.90268e-17
C15 (\6\:B VSS) capacitor c=4.61506e-17
C16 (\6\:C VSS) capacitor c=3.24691e-17
C17 (\4\:C VSS) capacitor c=3.12613e-17
C18 (\3\:B VSS) capacitor c=5.5144e-17
C19 (\2\:AN VSS) capacitor c=3.19666e-17
C20 (\2\:n0 VSS) capacitor c=4.65016e-16
C21 (\7\:n0 VSS) capacitor c=4.92792e-17
C22 (\1\:VDD VSS) capacitor c=2.1307e-16
C23 (\1\:Y VSS) capacitor c=1.98461e-16
C24 (\6\:Y VSS) capacitor c=3.39875e-17
C25 (\9\:n0 VSS) capacitor c=5.59332e-17
C26 (\9\:Y VSS) capacitor c=1.31396e-16
C27 (\3\:C VSS) capacitor c=2.56971e-17
C28 (\7\:C VSS) capacitor c=4.79224e-17
Rk8 (\1\:Y Y) resistor r=0.06436 c=0
Rk9 (\1\:Y \7\:Y) resistor r=0.05786 c=0
Rk11 (Y \10\:Y) resistor r=0.9641 c=0
Rk26 (\3\:VSS VSS) resistor r=0.0663 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.0433 c=0
Rk27 (\3\:VSS \5\:VSS) resistor r=0.3323 c=0
Rk28 (\5\:VSS \7\:VSS) resistor r=0.4632 c=0
Rk3 (\7\:C C) resistor r=0.006301 c=0
Rk12 (AN \4\:AN) resistor r=0.01842 c=0
Rk21 (\1\:VDD VDD) resistor r=0.04719 c=0
Rk14 (\10\:n0 \2\:n0) resistor r=0.2267 c=0
Rk13 (\8\:n0 \10\:n0) resistor r=0.4049 c=0
Rl11 (B \6\:B) resistor r=44.9225 c=0
Rl4 (B \3\:B) resistor r=33.3841 c=0
Rl6 (\3\:C \1\:C) resistor r=24.6542 c=0
Rl9 (\3\:C \6\:C) resistor r=82.1768 c=0
Rl7 (\3\:C \4\:C) resistor r=32.7557 c=0
Rl14 (\1\:AN \2\:AN) resistor r=30.7692 c=0
Rl15 (\2\:AN \3\:AN) resistor r=95.3297 c=0
Rl13 (\2\:n0 \6\:n0) resistor r=39.5604 c=0
Rl1 (\2\:n0 n0) resistor r=24.7951 c=0
Rz1 (\10\:Y \9\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\10\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\7\:Y \6\:Y) resistor r=31 c=0
Ry5 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\7\:C \1\:C) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (8 n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.34e-14 ps=1.31e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.18106e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (8 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=2.34e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.04606e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (\9\:Y \4\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=8.86058e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3 (\9\:Y \6\:C 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.59e-14 \
        ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.7e-07 sb=6.81058e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (10 \6\:B 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=5.59e-14 ps=7.3e-07 pd=9.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.3e-07 sb=4.21058e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (11 \6\:n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.73e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=2.71058e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0 (\9\:n0 \3\:AN \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp0 (\7\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.7e-07 sd=160n sca=35.6104 \
        scb=0.0382002 scc=0.00366805 m=(1)
ends NAND3BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:31 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3BX4
// View name: extracted

simulator lang=spectre

subckt NAND3BX4 AN B C VDD VSS Y
mp0 (\13\:n0 \1\:AN VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.9839 scb=0.0202117 \
        scc=0.000700179 m=(1)
mp1_1__rcx (\1\:Y \2\:n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.9235 scb=0.0274556 \
        scc=0.0014135 m=(4)
mp2_1__rcx (\1\:Y B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=15.882 scb=0.0147893 \
        scc=0.000504893 m=(4)
mp3_1__rcx (\1\:Y C VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=13.8083 scb=0.0118505 \
        scc=0.000478838 m=(4)
C1 (VDD VSS) capacitor c=5.95563e-16
C2 (B VSS) capacitor c=8.3758e-16
C3 (C VSS) capacitor c=5.23655e-16
C4 (AN VSS) capacitor c=5.85448e-17
C5 (Y VSS) capacitor c=8.66541e-17
C6 (8 VSS) capacitor c=3.11501e-18
C7 (n0 VSS) capacitor c=5.18851e-17
C8 (9 VSS) capacitor c=4.39052e-18
C9 (10 VSS) capacitor c=3.54276e-18
C10 (11 VSS) capacitor c=3.17329e-18
C11 (12 VSS) capacitor c=5.49334e-18
C12 (13 VSS) capacitor c=2.26498e-18
C13 (\1\:AN VSS) capacitor c=5.05493e-17
C14 (\3\:AN VSS) capacitor c=3.62061e-17
C15 (\12\:n0 VSS) capacitor c=6.2214e-17
C16 (\13\:B VSS) capacitor c=5.09485e-17
C17 (\11\:C VSS) capacitor c=2.96028e-17
C18 (\12\:C VSS) capacitor c=3.69331e-17
C19 (\9\:B VSS) capacitor c=6.00437e-17
C20 (\9\:n0 VSS) capacitor c=2.90521e-17
C21 (\7\:n0 VSS) capacitor c=5.18344e-17
C22 (\6\:B VSS) capacitor c=6.20128e-17
C23 (\6\:C VSS) capacitor c=2.56169e-17
C24 (\4\:C VSS) capacitor c=3.75292e-17
C25 (\3\:B VSS) capacitor c=4.80155e-17
C26 (\2\:AN VSS) capacitor c=3.61326e-17
C27 (\2\:n0 VSS) capacitor c=8.37592e-16
C28 (\13\:n0 VSS) capacitor c=4.67031e-17
C29 (\1\:Y VSS) capacitor c=6.23824e-16
C30 (\1\:VDD VSS) capacitor c=3.00575e-17
C31 (\17\:n0 VSS) capacitor c=4.49369e-17
C32 (\20\:Y VSS) capacitor c=1.11887e-16
C33 (\18\:Y VSS) capacitor c=1.23658e-16
C34 (\6\:n0 VSS) capacitor c=2.83297e-17
C35 (\4\:AN VSS) capacitor c=4.70389e-17
C36 (\15\:n0 VSS) capacitor c=5.99281e-17
Rk27 (\2\:VDD VDD) resistor r=0.0575 c=0
Rk42 (\2\:VSS \3\:VSS) resistor r=0.0851 c=0
Rk43 (\3\:VSS \4\:VSS) resistor r=0.6243 c=0
Rk44 (\4\:VSS \5\:VSS) resistor r=0.04245 c=0
Rk46 (\6\:VSS VSS) resistor r=0.01711 c=0
Rk45 (\5\:VSS \6\:VSS) resistor r=0.5342 c=0
Rk47 (\3\:VSS \8\:VSS) resistor r=0.2317 c=0
Rk48 (\4\:VSS \10\:VSS) resistor r=0.1029 c=0
Rk49 (\6\:VSS \12\:VSS) resistor r=0.1029 c=0
Rk20 (\4\:AN AN) resistor r=0.1099 c=0
Rk12 (\1\:Y Y) resistor r=0.6259 c=0
Rk18 (Y \19\:Y) resistor r=0.4531 c=0
Rk19 (\19\:Y \21\:Y) resistor r=0.8431 c=0
Rk22 (\15\:n0 \2\:n0) resistor r=0.2763 c=0
Rk21 (\14\:n0 \15\:n0) resistor r=0.1557 c=0
Rk23 (\15\:n0 \18\:n0) resistor r=0.4528 c=0
Rl26 (B \13\:B) resistor r=95.0334 c=0
Rl18 (B \9\:B) resistor r=75.6918 c=0
Rl11 (B \6\:B) resistor r=87.2302 c=0
Rl4 (B \3\:B) resistor r=29.5379 c=0
Rl22 (C \11\:C) resistor r=76.0994 c=0
Rl23 (C \12\:C) resistor r=26.3736 c=0
Rl9 (C \6\:C) resistor r=24.2328 c=0
Rl7 (C \4\:C) resistor r=105.323 c=0
Rl29 (\1\:AN \2\:AN) resistor r=100 c=0
Rl30 (\2\:AN \3\:AN) resistor r=53.022 c=0
Rl28 (\2\:n0 \12\:n0) resistor r=122.253 c=0
Rl1 (\2\:n0 n0) resistor r=97.872 c=0
Rl16 (\6\:n0 \9\:n0) resistor r=33.2809 c=0
Rl14 (\6\:n0 \7\:n0) resistor r=110.401 c=0
Rl13 (\6\:n0 \2\:n0) resistor r=44.0838 c=0
Rz5 (VDD \1\:VDD) resistor r=6.25 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\19\:Y \18\:Y) resistor r=75 c=0
Rz2 (\21\:Y \20\:Y) resistor r=75 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=75 c=0
Ry15 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry16 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry7 (\14\:n0 \13\:n0) resistor r=20.6667 c=0
Rx7 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (8 n0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=2.34e-14 ps=1.33e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (8 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.34e-14 ps=8.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_1__rcx (\18\:Y \4\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_2__rcx (\18\:Y \6\:C 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.93e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_2__rcx (10 \6\:B 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.51e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.75e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_2__rcx (11 \7\:n0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.99e-14 ps=1.43e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=1.59e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_3__rcx (12 \9\:n0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.42e-14 ps=1.43e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=1.325e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_3__rcx (12 \9\:B 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.42e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=1.11e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3_3__rcx (\20\:Y \12\:C 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.16e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=9.85e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (\20\:Y \11\:C 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=7.8e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (14 \13\:B 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=6.24e-14 ps=7.3e-07 pd=1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.95e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn1 (15 \12\:n0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.73e-14 ps=8.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (\17\:n0 \3\:AN \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends NAND3BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:33 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3BXL
// View name: extracted

simulator lang=spectre

subckt NAND3BXL AN B C VDD VSS Y
mp3 (\3\:Y \3\:C \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=2.63e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.17326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
mp2 (\1\:Y \1\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.17326e-07 sb=5.22326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.22326e-07 sb=3.17326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.17326e-07 sb=1.22326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
C1 (B VSS) capacitor c=3.84051e-17
C2 (VDD VSS) capacitor c=1.02517e-16
C3 (C VSS) capacitor c=2.24632e-17
C4 (Y VSS) capacitor c=1.46343e-17
C5 (n0 VSS) capacitor c=6.45795e-17
C6 (\1\:AN VSS) capacitor c=4.08798e-17
C7 (\1\:B VSS) capacitor c=5.18918e-17
C8 (\3\:C VSS) capacitor c=5.20075e-17
C9 (\3\:AN VSS) capacitor c=3.8988e-17
C10 (\3\:n0 VSS) capacitor c=3.00054e-17
C11 (\3\:B VSS) capacitor c=4.71228e-17
C12 (\1\:C VSS) capacitor c=2.79712e-17
C13 (\2\:AN VSS) capacitor c=4.63377e-17
C14 (\2\:n0 VSS) capacitor c=5.81203e-17
C15 (\2\:B VSS) capacitor c=5.26549e-17
C16 (\2\:C VSS) capacitor c=4.39862e-17
C17 (\4\:n0 VSS) capacitor c=5.02769e-17
C18 (\1\:VDD VSS) capacitor c=2.08135e-17
C19 (\1\:Y VSS) capacitor c=4.06212e-17
C20 (\6\:VDD VSS) capacitor c=1.24222e-17
C21 (\3\:Y VSS) capacitor c=4.21205e-17
C22 (\8\:n0 VSS) capacitor c=1.87338e-17
C23 (\5\:Y VSS) capacitor c=6.7085e-17
C24 (\4\:C VSS) capacitor c=4.85573e-17
C25 (\4\:B VSS) capacitor c=2.76454e-17
C26 (\4\:AN VSS) capacitor c=6.74071e-17
C27 (\6\:AN VSS) capacitor c=4.63384e-17
C28 (\6\:n0 VSS) capacitor c=4.89806e-17
C29 (\7\:n0 VSS) capacitor c=4.72246e-17
C30 (\4\:VDD VSS) capacitor c=6.05812e-18
C31 (\5\:VDD VSS) capacitor c=1.58817e-18
Rk2 (B \4\:B) resistor r=0.02441 c=0
Rk17 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.4089 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.1386 c=0
Rk14 (\5\:VDD VDD) resistor r=0.1176 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.08023 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.05128 c=0
Rk1 (C \4\:C) resistor r=0.02587 c=0
Rk6 (\4\:AN \5\:AN) resistor r=0.006173 c=0
Rk7 (AN \6\:AN) resistor r=0.00607 c=0
Rk8 (\4\:AN \6\:AN) resistor r=0.06409 c=0
Rk5 (\4\:Y Y) resistor r=0.05294 c=0
Rk3 (\2\:Y \4\:Y) resistor r=0.2876 c=0
Rk4 (\4\:Y \6\:Y) resistor r=0.4768 c=0
Rk9 (\5\:n0 \6\:n0) resistor r=0.3387 c=0
Rk10 (\6\:n0 \7\:n0) resistor r=0.1884 c=0
Rk11 (\6\:n0 \9\:n0) resistor r=0.1249 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl2 (\2\:C \3\:C) resistor r=129.319 c=0
Rl1 (\1\:C \2\:C) resistor r=38.3096 c=0
Rl7 (\1\:AN \2\:AN) resistor r=68.4057 c=0
Rl8 (\2\:AN \3\:AN) resistor r=95.3288 c=0
Rl5 (n0 \2\:n0) resistor r=137.637 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=26.098 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\5\:Y \6\:Y) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx4 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\5\:Y \1\:C n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (n1 \3\:B n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.102e-14 \
        ad=1.957e-14 ps=5.8e-07 pd=5.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.2e-07 sb=5.35e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn1 (n2 \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.102e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
ends NAND3BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:34 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3X1
// View name: extracted

simulator lang=spectre

subckt NAND3X1 A B C VDD VSS Y
mp0 (\4\:Y \1\:A \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=25.4535 \
        scb=0.0286798 scc=0.00163825 m=(1)
mp1 (\4\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=16.4103 \
        scb=0.0148066 scc=0.000275039 m=(1)
mp2 (\6\:Y \1\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=16.6925 \
        scb=0.0153965 scc=0.00029244 m=(1)
C1 (Y VSS) capacitor c=6.1411e-18
C2 (C VSS) capacitor c=2.03918e-17
C3 (VDD VSS) capacitor c=8.15229e-17
C4 (B VSS) capacitor c=1.9667e-17
C5 (n0 VSS) capacitor c=3.35995e-18
C6 (\1\:C VSS) capacitor c=5.16852e-17
C7 (\1\:B VSS) capacitor c=5.86769e-17
C8 (\1\:A VSS) capacitor c=3.66925e-17
C9 (\3\:C VSS) capacitor c=4.61067e-17
C10 (\3\:B VSS) capacitor c=6.45398e-17
C11 (\3\:A VSS) capacitor c=4.30211e-17
C12 (\2\:C VSS) capacitor c=4.10889e-17
C13 (\2\:B VSS) capacitor c=4.9341e-17
C14 (\2\:A VSS) capacitor c=3.87468e-17
C15 (\6\:Y VSS) capacitor c=3.96301e-17
C16 (\1\:VDD VSS) capacitor c=6.80171e-17
C17 (\4\:Y VSS) capacitor c=8.23247e-17
C18 (\5\:VDD VSS) capacitor c=4.69274e-17
C19 (\1\:Y VSS) capacitor c=8.29015e-17
C20 (\5\:A VSS) capacitor c=1.71198e-17
C21 (\6\:A VSS) capacitor c=3.06487e-17
C22 (\4\:B VSS) capacitor c=2.89706e-17
C23 (\4\:C VSS) capacitor c=6.53855e-17
C24 (\3\:Y VSS) capacitor c=5.25677e-17
C25 (\4\:VDD VSS) capacitor c=2.62736e-17
Rk1 (\4\:A \5\:A) resistor r=0.009432 c=0
Rk2 (A \6\:A) resistor r=0.009274 c=0
Rk3 (\4\:A \6\:A) resistor r=0.0314 c=0
Rk14 (VSS \4\:VSS) resistor r=0.3197 c=0
Rk8 (\3\:Y Y) resistor r=0.05218 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.4304 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.386 c=0
Rk9 (Y \7\:Y) resistor r=0.06453 c=0
Rk5 (C \4\:C) resistor r=0.02186 c=0
Rk11 (\4\:VDD VDD) resistor r=0.2001 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.2926 c=0
Rk12 (VDD \6\:VDD) resistor r=0.2441 c=0
Rk4 (B \4\:B) resistor r=0.02903 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl5 (\1\:C \2\:C) resistor r=127.402 c=0
Rl6 (\2\:C \3\:C) resistor r=26.3736 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=71.8456 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (n1 \3\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (n0 \3\:B n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=1.82e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=3.1e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (\1\:Y \3\:C n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=5.07e-14 ps=6.6e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=1.95e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
ends NAND3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:35 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3X2
// View name: extracted

simulator lang=spectre

subckt NAND3X2 A B C VDD VSS Y
mp2 (\9\:Y \3\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=20.6186 \
        scb=0.0170876 scc=0.00184289 m=(2)
mp0 (\1\:Y \2\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=26.6291 \
        scb=0.0267491 scc=0.00213017 m=(2)
mp1 (\1\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=21.9392 \
        scb=0.0187361 scc=0.00185024 m=(2)
C1 (VDD VSS) capacitor c=6.17693e-17
C2 (C VSS) capacitor c=5.70583e-17
C3 (A VSS) capacitor c=1.48687e-17
C4 (Y VSS) capacitor c=9.03707e-17
C5 (B VSS) capacitor c=3.04309e-17
C6 (7 VSS) capacitor c=3.65106e-18
C7 (8 VSS) capacitor c=6.67144e-18
C8 (9 VSS) capacitor c=4.80329e-18
C9 (10 VSS) capacitor c=4.5835e-18
C10 (\1\:B VSS) capacitor c=3.70937e-16
C11 (\6\:A VSS) capacitor c=4.59253e-17
C12 (\6\:B VSS) capacitor c=6.03643e-17
C13 (\1\:C VSS) capacitor c=4.92448e-17
C14 (\5\:C VSS) capacitor c=2.38554e-17
C15 (\3\:B VSS) capacitor c=4.73601e-17
C16 (\1\:A VSS) capacitor c=3.9275e-17
C17 (\3\:C VSS) capacitor c=9.31457e-17
C18 (\2\:A VSS) capacitor c=4.09357e-16
C19 (\1\:VDD VSS) capacitor c=2.15342e-16
C20 (\1\:Y VSS) capacitor c=2.07701e-16
C21 (\9\:Y VSS) capacitor c=3.46321e-17
C22 (\7\:Y VSS) capacitor c=1.3211e-16
C23 (\2\:C VSS) capacitor c=1.61194e-17
C24 (\7\:C VSS) capacitor c=6.48355e-17
Rk16 (\1\:VDD VDD) resistor r=0.0472 c=0
Rk1 (C \7\:C) resistor r=0.03835 c=0
Rk5 (\2\:A A) resistor r=0.01817 c=0
Rk20 (\2\:VSS \4\:VSS) resistor r=0.3341 c=0
Rk22 (\5\:VSS VSS) resistor r=0.06726 c=0
Rk21 (\4\:VSS \5\:VSS) resistor r=0.2832 c=0
Rk23 (\5\:VSS \7\:VSS) resistor r=0.2196 c=0
Rk9 (\1\:Y Y) resistor r=0.2013 c=0
Rk10 (Y \8\:Y) resistor r=0.9494 c=0
Rk11 (\1\:Y \10\:Y) resistor r=0.05797 c=0
Rk2 (B \1\:B) resistor r=0.08407 c=0
Rl5 (\2\:C \1\:C) resistor r=100.426 c=0
Rl8 (\2\:C \5\:C) resistor r=35.772 c=0
Rl6 (\2\:C \3\:C) resistor r=54.2356 c=0
Rl13 (\2\:A \6\:A) resistor r=24.7951 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rl11 (\1\:B \6\:B) resistor r=44.9225 c=0
Rl4 (\1\:B \3\:B) resistor r=33.3841 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Ry3 (\10\:Y \9\:Y) resistor r=31 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0_1__rcx (7 \1\:A \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.045e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=2.34e-14 ps=9.3e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=9.1e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\7\:Y \5\:C 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=6.6e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (\7\:Y \1\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.3e-07 sb=4.55e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (9 \6\:B 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.08e-14 \
        ad=2.99e-14 ps=6.8e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.9e-07 sb=2.95e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0 (10 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.08e-14 ps=1.31e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.7e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
ends NAND3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:36 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3X4
// View name: extracted

simulator lang=spectre

subckt NAND3X4 A B C VDD VSS Y
mp0_1__rcx (\1\:Y \2\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.8021 scb=0.0193662 \
        scc=0.00077923 m=(4)
mp1_1__rcx (\1\:Y B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=15.3235 scb=0.0135506 \
        scc=0.000650815 m=(4)
mp2_1__rcx (\1\:Y C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.985e-06 sd=160n sca=14.1261 \
        scb=0.0123878 scc=0.000647585 m=(4)
C1 (VDD VSS) capacitor c=1.44095e-16
C2 (C VSS) capacitor c=5.40319e-16
C3 (A VSS) capacitor c=2.47861e-17
C4 (Y VSS) capacitor c=9.61193e-17
C5 (B VSS) capacitor c=8.56987e-16
C6 (9 VSS) capacitor c=2.1232e-18
C7 (10 VSS) capacitor c=4.14367e-18
C8 (11 VSS) capacitor c=3.48423e-18
C9 (12 VSS) capacitor c=6.12528e-18
C10 (13 VSS) capacitor c=4.99533e-18
C11 (14 VSS) capacitor c=2.08455e-18
C12 (\12\:A VSS) capacitor c=6.64188e-17
C13 (\12\:B VSS) capacitor c=5.70988e-17
C14 (\14\:C VSS) capacitor c=3.36994e-17
C15 (\13\:C VSS) capacitor c=2.12773e-17
C16 (\9\:B VSS) capacitor c=5.72621e-17
C17 (\4\:A VSS) capacitor c=4.15997e-17
C18 (\6\:A VSS) capacitor c=5.08815e-17
C19 (\6\:B VSS) capacitor c=7.94352e-17
C20 (\1\:C VSS) capacitor c=4.42879e-17
C21 (\4\:C VSS) capacitor c=1.93258e-17
C22 (\3\:B VSS) capacitor c=5.69242e-17
C23 (\1\:A VSS) capacitor c=7.57093e-17
C24 (\2\:A VSS) capacitor c=7.79247e-16
C25 (\1\:VDD VSS) capacitor c=4.06461e-16
C26 (\1\:Y VSS) capacitor c=5.85282e-16
C27 (\10\:Y VSS) capacitor c=1.62405e-16
C28 (\12\:Y VSS) capacitor c=1.09172e-16
C29 (\5\:A VSS) capacitor c=3.05678e-17
Rk32 (\1\:VDD VDD) resistor r=0.06978 c=0
Rk10 (\2\:A A) resistor r=0.0486 c=0
Rk40 (\3\:VSS VSS) resistor r=0.1199 c=0
Rk39 (\2\:VSS \3\:VSS) resistor r=0.2313 c=0
Rk41 (\3\:VSS \5\:VSS) resistor r=0.4312 c=0
Rk42 (\5\:VSS \6\:VSS) resistor r=0.1127 c=0
Rk43 (\6\:VSS \8\:VSS) resistor r=0.1028 c=0
Rk44 (\6\:VSS \9\:VSS) resistor r=0.5896 c=0
Rk45 (\9\:VSS \11\:VSS) resistor r=0.09884 c=0
Rk17 (\1\:Y Y) resistor r=0.213 c=0
Rk18 (Y \11\:Y) resistor r=0.8581 c=0
Rk19 (\11\:Y \13\:Y) resistor r=0.8133 c=0
Rl25 (C \14\:C) resistor r=99.7716 c=0
Rl24 (C \13\:C) resistor r=62.5704 c=0
Rl5 (C \1\:C) resistor r=26.9231 c=0
Rl7 (C \4\:C) resistor r=69.2184 c=0
Rl29 (\2\:A \12\:A) resistor r=99.7951 c=0
Rl1 (\2\:A \1\:A) resistor r=111.211 c=0
Rl13 (\5\:A \4\:A) resistor r=61.5164 c=0
Rl14 (\5\:A \6\:A) resistor r=94.2087 c=0
Rl15 (\5\:A \2\:A) resistor r=69.7363 c=0
Rl27 (B \12\:B) resistor r=29.5379 c=0
Rl19 (B \9\:B) resistor r=87.6374 c=0
Rl12 (B \6\:B) resistor r=87.2302 c=0
Rl4 (B \3\:B) resistor r=44.9225 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\11\:Y \10\:Y) resistor r=75 c=0
Rz2 (\13\:Y \12\:Y) resistor r=75 c=0
Ry14 (\4\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry15 (\4\:VSS \9\:VSS) resistor r=31 c=0
mn0_1__rcx (7 \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (\12\:Y \4\:C 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.815e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_2__rcx (\12\:Y \1\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.61e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_2__rcx (9 \6\:B 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.505e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0_2__rcx (10 \6\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.99e-14 ps=1.43e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.345e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0_3__rcx (11 \4\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.47e-14 ps=1.43e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.08e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_3__rcx (11 \9\:B 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.47e-14 ps=9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=9.4e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_3__rcx (\10\:Y \13\:C 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=7.05e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (\10\:Y \14\:C 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=5e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (13 \12\:B 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.68e-14 ps=6.4e-07 pd=8.8e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.75e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn0 (14 \12\:A \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=1.56e-14 ps=1.33e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.7e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends NAND3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:37 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3X6
// View name: extracted

simulator lang=spectre

subckt NAND3X6 A B C VDD VSS Y
mp0 (\1\:Y \2\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=6.402e-14 ps=1.08667e-06 pd=1.10833e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.6153 scb=0.0196772 \
        scc=0.000647465 m=(6)
mp1_1__rcx (\1\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=6.402e-14 ps=1.14667e-06 pd=1.10833e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.5247 scb=0.0127136 \
        scc=0.000449121 m=(6)
mp2 (\1\:Y C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=6.24e-14 ps=1.14667e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=13.1869 scb=0.0112853 \
        scc=0.000444017 m=(6)
C1 (VDD VSS) capacitor c=2.44025e-16
C2 (C VSS) capacitor c=9.83672e-16
C3 (A VSS) capacitor c=1.90585e-17
C4 (Y VSS) capacitor c=1.1089e-16
C5 (B VSS) capacitor c=1.68057e-17
C6 (9 VSS) capacitor c=9.87819e-18
C7 (10 VSS) capacitor c=5.83404e-18
C8 (11 VSS) capacitor c=4.69902e-18
C9 (12 VSS) capacitor c=7.28392e-18
C10 (13 VSS) capacitor c=1.52758e-17
C11 (14 VSS) capacitor c=4.94436e-18
C12 (15 VSS) capacitor c=7.2369e-18
C13 (16 VSS) capacitor c=4.87818e-18
C14 (\1\:B VSS) capacitor c=1.34751e-15
C15 (\15\:C VSS) capacitor c=3.73555e-17
C16 (\16\:B VSS) capacitor c=4.85405e-17
C17 (\15\:A VSS) capacitor c=4.67943e-17
C18 (\14\:A VSS) capacitor c=4.73584e-17
C19 (\12\:B VSS) capacitor c=4.12857e-17
C20 (\11\:C VSS) capacitor c=1.9057e-17
C21 (\10\:C VSS) capacitor c=2.75644e-17
C22 (\9\:B VSS) capacitor c=6.65331e-17
C23 (\4\:A VSS) capacitor c=5.63922e-17
C24 (\8\:A VSS) capacitor c=4.93426e-17
C25 (\6\:B VSS) capacitor c=5.50209e-17
C26 (\5\:C VSS) capacitor c=2.6339e-17
C27 (\4\:C VSS) capacitor c=3.19262e-17
C28 (\3\:B VSS) capacitor c=8.1759e-17
C29 (\1\:A VSS) capacitor c=6.46163e-17
C30 (\2\:A VSS) capacitor c=1.32425e-15
C31 (\1\:Y VSS) capacitor c=7.89067e-16
C32 (\1\:VDD VSS) capacitor c=4.98895e-16
C33 (\10\:Y VSS) capacitor c=1.96728e-16
C34 (\22\:Y VSS) capacitor c=2.25743e-16
C35 (\24\:Y VSS) capacitor c=1.15136e-16
Rk29 (\1\:VDD VDD) resistor r=0.05726 c=0
Rk12 (\2\:A A) resistor r=0.02677 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.2607 c=0
Rk50 (\3\:VSS \4\:VSS) resistor r=0.6921 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.1002 c=0
Rk53 (\6\:VSS VSS) resistor r=0.1074 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.4439 c=0
Rk54 (\3\:VSS \8\:VSS) resistor r=0.1031 c=0
Rk55 (\4\:VSS \10\:VSS) resistor r=0.1031 c=0
Rk56 (\6\:VSS \12\:VSS) resistor r=0.2991 c=0
Rk19 (\1\:Y Y) resistor r=0.2692 c=0
Rk20 (Y \11\:Y) resistor r=0.8701 c=0
Rk26 (\11\:Y \23\:Y) resistor r=1.0357 c=0
Rk27 (\23\:Y \25\:Y) resistor r=0.9598 c=0
Rk4 (B \1\:B) resistor r=0.01685 c=0
Rl36 (C \15\:C) resistor r=24.2328 c=0
Rl23 (C \11\:C) resistor r=45.7894 c=0
Rl22 (C \10\:C) resistor r=35.2336 c=0
Rl8 (C \5\:C) resistor r=24.2328 c=0
Rl7 (C \4\:C) resistor r=52.7541 c=0
Rl30 (\2\:A \15\:A) resistor r=106.926 c=0
Rl29 (\2\:A \14\:A) resistor r=120.708 c=0
Rl12 (\2\:A \4\:A) resistor r=118.246 c=0
Rl15 (\2\:A \8\:A) resistor r=115.362 c=0
Rl1 (\2\:A \1\:A) resistor r=73.0541 c=0
Rl34 (\1\:B \16\:B) resistor r=53.5603 c=0
Rl26 (\1\:B \12\:B) resistor r=44.9225 c=0
Rl19 (\1\:B \9\:B) resistor r=87.6374 c=0
Rl11 (\1\:B \6\:B) resistor r=66.0764 c=0
Rl4 (\1\:B \3\:B) resistor r=83.7903 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\11\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\23\:Y \22\:Y) resistor r=37.5 c=0
Rz3 (\25\:Y \24\:Y) resistor r=37.5 c=0
Ry20 (\1\:VSS \2\:VSS) resistor r=6.8889 c=0
Ry21 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (7 \1\:A \11\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=1.86e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=1.86e-14 ps=8.9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn2_1__rcx (\24\:Y \4\:C 8 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn2_2__rcx (\24\:Y \5\:C 9 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=4.96e-14 ps=9.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1_2__rcx (9 \6\:B 10 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=5.735e-14 ps=8.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_2__rcx (10 \8\:A \9\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.565e-14 ps=1.54e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_3__rcx (11 \4\:A \9\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=2.79e-14 ps=1.54e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.91e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn1_3__rcx (11 \9\:B 12 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=2.79e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.775e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn2_3__rcx (\22\:Y \10\:C 12 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.615e-06 sb=1.58e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn2_4__rcx (\22\:Y \11\:C 13 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1315e-13 ad=4.96e-14 ps=1.35e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=1.375e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn1_4__rcx (13 \12\:B 14 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=1.1315e-13 ps=8.7e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.65e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_4__rcx (14 \14\:A \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.875e-14 ps=1.54e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.95e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0 (15 \15\:A \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=4.96e-14 ps=1.54e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.3e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1 (15 \16\:B 16 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=3.875e-14 \
        ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=3.25e-07 sd=160n sca=13.2036 scb=0.0127776 scc=0.000861941 \
        m=(1)
mn2 (\10\:Y \15\:C 16 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.805e-14 ps=8.7e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
ends NAND3X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:38 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3X8
// View name: extracted

simulator lang=spectre

subckt NAND3X8 A B C VDD VSS Y
mp0_1__rcx (\3\:Y A \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.565e-14 ps=1.20429e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.275 scb=0.0264752 \
        scc=0.0013153 m=(7)
mp1_1__rcx (\3\:Y B \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.374e-14 ad=7.565e-14 ps=1.22143e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2e-06 sd=160n sca=15.6896 scb=0.014147 \
        scc=0.000596665 m=(7)
mp2_1__rcx (\3\:Y C \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.374e-14 ad=6.993e-14 ps=1.22143e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.85e-07 sb=2e-06 sd=160n sca=14.0773 \
        scb=0.0121711 scc=0.000586094 m=(7)
C1 (A VSS) capacitor c=1.30975e-15
C2 (VDD VSS) capacitor c=2.36501e-16
C3 (C VSS) capacitor c=1.37262e-15
C4 (Y VSS) capacitor c=3.98845e-17
C5 (B VSS) capacitor c=1.59415e-15
C6 (9 VSS) capacitor c=5.22845e-18
C7 (10 VSS) capacitor c=2.74606e-18
C8 (11 VSS) capacitor c=1.00667e-17
C9 (12 VSS) capacitor c=5.54197e-18
C10 (13 VSS) capacitor c=1.22378e-17
C11 (14 VSS) capacitor c=8.85504e-18
C12 (15 VSS) capacitor c=2.77099e-18
C13 (16 VSS) capacitor c=1.07273e-17
C14 (17 VSS) capacitor c=7.95323e-18
C15 (18 VSS) capacitor c=7.30018e-18
C16 (19 VSS) capacitor c=7.8426e-18
C17 (20 VSS) capacitor c=3.43879e-18
C18 (\21\:C VSS) capacitor c=5.7337e-17
C19 (\22\:B VSS) capacitor c=6.31065e-17
C20 (\20\:A VSS) capacitor c=4.40016e-17
C21 (\19\:A VSS) capacitor c=4.05076e-17
C22 (\18\:B VSS) capacitor c=4.32792e-17
C23 (\17\:C VSS) capacitor c=2.60189e-17
C24 (\16\:C VSS) capacitor c=1.96871e-17
C25 (\15\:B VSS) capacitor c=5.92851e-17
C26 (\10\:A VSS) capacitor c=6.39994e-17
C27 (\13\:A VSS) capacitor c=3.682e-17
C28 (\12\:B VSS) capacitor c=3.57027e-17
C29 (\11\:C VSS) capacitor c=1.85724e-17
C30 (\10\:C VSS) capacitor c=3.25302e-17
C31 (\9\:B VSS) capacitor c=4.27846e-17
C32 (\7\:A VSS) capacitor c=3.51885e-17
C33 (\8\:A VSS) capacitor c=6.84297e-17
C34 (\6\:B VSS) capacitor c=7.09512e-17
C35 (\1\:C VSS) capacitor c=2.95968e-17
C36 (\4\:C VSS) capacitor c=1.94813e-17
C37 (\3\:B VSS) capacitor c=7.02686e-17
C38 (\1\:A VSS) capacitor c=6.17758e-17
C39 (\1\:VDD VSS) capacitor c=6.01602e-16
C40 (\1\:Y VSS) capacitor c=1.45017e-16
C41 (\6\:Y VSS) capacitor c=2.17488e-16
C42 (\8\:Y VSS) capacitor c=2.12693e-16
C43 (\10\:Y VSS) capacitor c=1.23838e-16
C44 (\3\:Y VSS) capacitor c=9.71256e-16
Rk36 (\1\:VDD VDD) resistor r=0.01963 c=0
Rk58 (\2\:VSS \4\:VSS) resistor r=0.2028 c=0
Rk59 (\4\:VSS \5\:VSS) resistor r=0.4481 c=0
Rk60 (\5\:VSS \6\:VSS) resistor r=0.6853 c=0
Rk61 (\6\:VSS \7\:VSS) resistor r=0.06661 c=0
Rk63 (\8\:VSS VSS) resistor r=0.08739 c=0
Rk62 (\7\:VSS \8\:VSS) resistor r=0.4641 c=0
Rk64 (\5\:VSS \10\:VSS) resistor r=0.04335 c=0
Rk65 (\6\:VSS \12\:VSS) resistor r=0.04335 c=0
Rk66 (\8\:VSS \14\:VSS) resistor r=0.2659 c=0
Rk19 (\2\:Y Y) resistor r=0.5124 c=0
Rk20 (Y \3\:Y) resistor r=0.0144 c=0
Rk22 (\2\:Y \7\:Y) resistor r=0.8662 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.9783 c=0
Rk24 (\9\:Y \11\:Y) resistor r=0.8532 c=0
Rl43 (A \20\:A) resistor r=85.772 c=0
Rl42 (A \19\:A) resistor r=83.8482 c=0
Rl26 (A \10\:A) resistor r=99.9779 c=0
Rl28 (A \13\:A) resistor r=83.8482 c=0
Rl14 (A \7\:A) resistor r=84.7767 c=0
Rl15 (A \8\:A) resistor r=118.346 c=0
Rl1 (A \1\:A) resistor r=74.5443 c=0
Rl49 (C \21\:C) resistor r=45.4267 c=0
Rl36 (C \17\:C) resistor r=47.3105 c=0
Rl35 (C \16\:C) resistor r=24.2328 c=0
Rl22 (C \11\:C) resistor r=22.4021 c=0
Rl21 (C \10\:C) resistor r=67.2856 c=0
Rl5 (C \1\:C) resistor r=34.2718 c=0
Rl7 (C \4\:C) resistor r=23.7402 c=0
Rl47 (B \22\:B) resistor r=34.3295 c=0
Rl39 (B \18\:B) resistor r=29.5379 c=0
Rl32 (B \15\:B) resistor r=26.098 c=0
Rl25 (B \12\:B) resistor r=29.5379 c=0
Rl18 (B \9\:B) resistor r=29.5379 c=0
Rl11 (B \6\:B) resistor r=35.3072 c=0
Rl4 (B \3\:B) resistor r=81.461 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\7\:Y \6\:Y) resistor r=75 c=0
Rz3 (\9\:Y \8\:Y) resistor r=75 c=0
Rz4 (\11\:Y \10\:Y) resistor r=75 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (7 \1\:A \13\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=1.77e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=6.047e-14 ad=1.77e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_1__rcx (\10\:Y \4\:C 8 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=6.047e-14 ad=4.72e-14 ps=1e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_2__rcx (\10\:Y \1\:C 9 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.393e-14 ad=4.72e-14 ps=8.2e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_2__rcx (9 \6\:B 10 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=3.393e-14 ps=7.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_2__rcx (10 \8\:A \11\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=1.77e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_3__rcx (11 \7\:A \11\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=5.9e-14 ps=1.6e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_3__rcx (11 \9\:B 12 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.54e-14 ad=5.9e-14 ps=8.3e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn2_3__rcx (\8\:Y \10\:C 12 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.54e-14 ad=4.72e-14 ps=8.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_4__rcx (\8\:Y \11\:C 13 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.08e-14 ad=4.72e-14 ps=1.07e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn1_4__rcx (13 \12\:B 14 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=7.08e-14 ps=9.1e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_4__rcx (14 \13\:A \9\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=4.72e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.92e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_5__rcx (15 \10\:A \9\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=1.77e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.655e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn1_5__rcx (15 \15\:B 16 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=1.77e-14 ps=9.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_5__rcx (\6\:Y \16\:C 16 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=4.72e-14 ps=9.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.305e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn2_6__rcx (\6\:Y \17\:C 17 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.1e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_6__rcx (17 \18\:B 18 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.983e-14 ad=4.72e-14 ps=8.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.95e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_6__rcx (18 \19\:A \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=3.983e-14 ps=1.6e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.15e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0 (19 \20\:A \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=4.72e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1 (19 \22\:B 20 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 as=1.77e-14 \
        ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=16.4223 scb=0.0158966 scc=0.0014413 m=(1)
mn2 (\1\:Y \21\:C 20 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.13e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
ends NAND3X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:40 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND3XL
// View name: extracted

simulator lang=spectre

subckt NAND3XL A B C VDD VSS Y
mp0 (\5\:Y \1\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=22.6868 \
        scb=0.0236005 scc=0.00131066 m=(1)
mp1 (\5\:Y \1\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=3.44e-14 ps=1.68e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.6e-07 sd=160n sca=21.6855 \
        scb=0.0215209 scc=0.00124628 m=(1)
mp2 (\3\:Y \1\:C \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=3.548e-14 ps=1.68e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.65e-07 sd=160n sca=27.8541 \
        scb=0.032188 scc=0.00201007 m=(1)
C1 (VDD VSS) capacitor c=7.20267e-17
C2 (C VSS) capacitor c=5.53315e-17
C3 (Y VSS) capacitor c=2.29956e-17
C4 (B VSS) capacitor c=5.50224e-17
C5 (n1 VSS) capacitor c=1.78429e-18
C6 (n0 VSS) capacitor c=3.97147e-20
C7 (\1\:C VSS) capacitor c=4.28746e-17
C8 (\1\:B VSS) capacitor c=5.24477e-17
C9 (\1\:A VSS) capacitor c=2.90209e-17
C10 (\3\:C VSS) capacitor c=3.56602e-17
C11 (\3\:B VSS) capacitor c=3.64108e-17
C12 (\4\:A VSS) capacitor c=3.15256e-17
C13 (\2\:C VSS) capacitor c=3.66179e-17
C14 (\2\:B VSS) capacitor c=4.79567e-17
C15 (\3\:A VSS) capacitor c=3.226e-17
C16 (\3\:Y VSS) capacitor c=2.09895e-17
C17 (\1\:VDD VSS) capacitor c=9.09256e-18
C18 (\5\:Y VSS) capacitor c=3.41262e-17
C19 (\6\:VDD VSS) capacitor c=3.29662e-17
C20 (\1\:Y VSS) capacitor c=4.77797e-17
C21 (\5\:A VSS) capacitor c=8.19562e-17
C22 (\4\:B VSS) capacitor c=6.3822e-17
C23 (\4\:C VSS) capacitor c=6.72844e-17
C24 (\4\:VDD VSS) capacitor c=1.85764e-17
C25 (\5\:VDD VSS) capacitor c=3.43016e-18
Rk1 (\5\:A A) resistor r=0.001027 c=0
Rk12 (\3\:VSS VSS) resistor r=0.0797 c=0
Rk13 (\3\:VSS \5\:VSS) resistor r=0.3674 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.1393 c=0
Rk9 (\5\:VDD VDD) resistor r=0.0797 c=0
Rk8 (\4\:VDD \5\:VDD) resistor r=0.12 c=0
Rk10 (\5\:VDD \7\:VDD) resistor r=0.3416 c=0
Rk3 (C \4\:C) resistor r=0.2064 c=0
Rk4 (\2\:Y Y) resistor r=0.2882 c=0
Rk5 (Y \4\:Y) resistor r=0.07178 c=0
Rk6 (\4\:Y \6\:Y) resistor r=0.2771 c=0
Rk2 (\4\:B B) resistor r=0.1702 c=0
Rl1 (\1\:A \2\:A) resistor r=56.5719 c=0
Rl3 (\2\:A \4\:A) resistor r=68.1104 c=0
Rl2 (\2\:A \3\:A) resistor r=0.6051 c=0
Rl6 (\1\:C \2\:C) resistor r=61.5385 c=0
Rl7 (\2\:C \3\:C) resistor r=49.4506 c=0
Rl4 (\1\:B \2\:B) resistor r=81.9251 c=0
Rl5 (\2\:B \3\:B) resistor r=24.2328 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (n1 \4\:A \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (n0 \3\:B n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=1.087e-14 ps=6.1e-07 pd=4.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=3.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\1\:Y \3\:C n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.625e-14 ps=4.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=2.5e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends NAND3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:41 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BBX1
// View name: extracted

simulator lang=spectre

subckt NAND4BBX1 AN BN C D VDD VSS Y
mp1 (\5\:n1 \1\:BN \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=28.2276 \
        scb=0.0332165 scc=0.00215993 m=(1)
mp0 (\5\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.483e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2.55e-07 sd=160n sca=18.0262 scb=0.0191386 \
        scc=0.000518763 m=(1)
C1 (BN VSS) capacitor c=5.00345e-17
C2 (AN VSS) capacitor c=1.20863e-16
C3 (Y VSS) capacitor c=1.05684e-16
C4 (D VSS) capacitor c=4.8945e-17
C5 (VDD VSS) capacitor c=1.43991e-16
C6 (n1 VSS) capacitor c=6.88539e-17
C7 (n2 VSS) capacitor c=3.19199e-18
C8 (n3 VSS) capacitor c=9.98735e-18
C9 (n4 VSS) capacitor c=5.52646e-18
C10 (n0 VSS) capacitor c=6.4245e-17
C11 (\1\:AN VSS) capacitor c=3.41387e-17
C12 (\1\:C VSS) capacitor c=5.66462e-17
C13 (\1\:D VSS) capacitor c=6.33676e-17
C14 (\1\:BN VSS) capacitor c=2.5295e-17
C15 (\3\:AN VSS) capacitor c=4.03219e-17
C16 (\3\:n0 VSS) capacitor c=4.5254e-17
C17 (\4\:n1 VSS) capacitor c=3.42257e-17
C18 (\3\:C VSS) capacitor c=7.34077e-17
C19 (\4\:D VSS) capacitor c=5.86972e-17
C20 (\4\:BN VSS) capacitor c=3.48965e-17
C21 (\2\:AN VSS) capacitor c=3.9465e-17
C22 (\4\:n0 VSS) capacitor c=1.95473e-17
C23 (\3\:n1 VSS) capacitor c=1.25759e-17
C24 (\2\:C VSS) capacitor c=6.53901e-17
C25 (\3\:D VSS) capacitor c=9.70229e-18
C26 (\3\:BN VSS) capacitor c=1.25388e-17
C27 (\5\:n0 VSS) capacitor c=6.56852e-17
C28 (\1\:VDD VSS) capacitor c=8.06285e-17
C29 (\6\:Y VSS) capacitor c=3.40827e-17
C30 (\9\:VDD VSS) capacitor c=3.66316e-17
C31 (\1\:Y VSS) capacitor c=7.10922e-17
C32 (\11\:VDD VSS) capacitor c=2.02429e-17
C33 (\5\:n1 VSS) capacitor c=6.99173e-17
C34 (\7\:VDD VSS) capacitor c=2.80923e-17
C35 (\9\:n0 VSS) capacitor c=1.2614e-17
C36 (\4\:Y VSS) capacitor c=1.34623e-16
C37 (\7\:n1 VSS) capacitor c=1.20701e-16
C38 (\2\:BN VSS) capacitor c=1.63575e-17
C39 (\2\:D VSS) capacitor c=4.50806e-17
C40 (\2\:n1 VSS) capacitor c=3.427e-17
C41 (\2\:n0 VSS) capacitor c=3.26822e-17
C42 (\5\:BN VSS) capacitor c=5.35795e-17
C43 (\5\:D VSS) capacitor c=5.80395e-17
C44 (\4\:C VSS) capacitor c=9.68436e-17
C45 (\9\:n1 VSS) capacitor c=1.14063e-16
C46 (\3\:Y VSS) capacitor c=3.23292e-17
C47 (\7\:n0 VSS) capacitor c=5.38041e-17
C48 (\8\:n0 VSS) capacitor c=3.48612e-17
C49 (\3\:VDD VSS) capacitor c=1.66545e-17
C50 (\5\:VDD VSS) capacitor c=1.31958e-17
C51 (\6\:VDD VSS) capacitor c=1.067e-17
Rk1 (\5\:BN BN) resistor r=0.1612 c=0
Rk7 (\3\:Y Y) resistor r=0.1153 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3422 c=0
Rk8 (Y \5\:Y) resistor r=0.9418 c=0
Rk9 (\3\:Y \7\:Y) resistor r=0.08594 c=0
Rk22 (\4\:VSS VSS) resistor r=0.4512 c=0
Rk21 (\2\:VSS \4\:VSS) resistor r=0.445 c=0
Rk23 (VSS \6\:VSS) resistor r=0.2845 c=0
Rk3 (\4\:C C) resistor r=0.002794 c=0
Rk2 (\5\:D D) resistor r=0.1916 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.4948 c=0
Rk15 (\3\:VDD \5\:VDD) resistor r=0.04242 c=0
Rk17 (\6\:VDD VDD) resistor r=0.2881 c=0
Rk16 (\5\:VDD \6\:VDD) resistor r=0.1627 c=0
Rk18 (VDD \8\:VDD) resistor r=0.3318 c=0
Rk19 (\3\:VDD \10\:VDD) resistor r=0.1825 c=0
Rk20 (\6\:VDD \12\:VDD) resistor r=0.1778 c=0
Rk4 (\6\:n1 \8\:n1) resistor r=0.4574 c=0
Rk5 (\8\:n1 \9\:n1) resistor r=0.6491 c=0
Rk11 (\6\:n0 \7\:n0) resistor r=0.4503 c=0
Rk12 (\7\:n0 \8\:n0) resistor r=0.1947 c=0
Rk13 (\7\:n0 \10\:n0) resistor r=0.09758 c=0
Rl1 (\1\:BN \2\:BN) resistor r=34.3295 c=0
Rl3 (\2\:BN \4\:BN) resistor r=155.483 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl15 (\1\:AN \2\:AN) resistor r=85.3072 c=0
Rl16 (\2\:AN \3\:AN) resistor r=102.615 c=0
Rl7 (\1\:C \2\:C) resistor r=82.4824 c=0
Rl8 (\2\:C \3\:C) resistor r=108.791 c=0
Rl4 (\1\:D \2\:D) resistor r=162.341 c=0
Rl6 (\2\:D \4\:D) resistor r=41.1873 c=0
Rl5 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl9 (n1 \2\:n1) resistor r=170.868 c=0
Rl11 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl12 (n0 \2\:n0) resistor r=151.912 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=49.759 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=11.4385 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=31 c=0
Ry3 (\6\:Y \7\:Y) resistor r=31 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry8 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\3\:BN \5\:BN) resistor r=45 c=0
Rx5 (\2\:AN AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\3\:n1 \9\:n1) resistor r=45 c=0
Rx6 (\4\:n0 \8\:n0) resistor r=45 c=0
mn1 (\7\:n1 \4\:BN \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\9\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=2.03e-14 ps=1.04e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn5 (\4\:Y \4\:D n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=9.05096e-07 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn4 (n2 \3\:C n3 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=6.76e-14 \
        ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.00096e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (n3 \4\:n1 n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=6.76e-14 ps=8e-07 pd=1.04e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=4.95096e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (n4 \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=3.10096e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp5 (\1\:Y \1\:D \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=9.84487e-07 sd=160n sca=11.8564 \
        scb=0.00969513 scc=0.0002319 m=(1)
mp4 (\1\:Y \1\:C \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17308e-07 sb=7.79487e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp3 (\6\:Y n1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.02e-14 ps=1.1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22308e-07 sb=5.74487e-07 sd=160n sca=11.7441 \
        scb=0.00964347 scc=0.000231878 m=(1)
mp2 (\6\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=7.02e-14 ps=1.22e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.47308e-07 sb=3.49487e-07 sd=160n sca=12.8177 \
        scb=0.0105047 scc=0.000233437 m=(1)
ends NAND4BBX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:42 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BBX2
// View name: extracted

simulator lang=spectre

subckt NAND4BBX2 AN BN C D VDD VSS Y
mp1 (\10\:n1 \1\:BN \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.45e-07 sd=160n sca=14.4249 \
        scb=0.0128702 scc=0.000158043 m=(1)
mp0 (\10\:n0 \3\:AN \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=11.7702 \
        scb=0.00871161 scc=9.98964e-05 m=(1)
C1 (BN VSS) capacitor c=4.17711e-17
C2 (D VSS) capacitor c=4.01485e-17
C3 (Y VSS) capacitor c=2.89299e-17
C4 (VDD VSS) capacitor c=1.81929e-16
C5 (C VSS) capacitor c=3.59717e-17
C6 (AN VSS) capacitor c=8.03082e-17
C7 (n1 VSS) capacitor c=1.81902e-16
C8 (n0 VSS) capacitor c=1.65652e-16
C9 (n4 VSS) capacitor c=2.3112e-16
C10 (n3 VSS) capacitor c=9.21477e-17
C11 (n2 VSS) capacitor c=1.67084e-16
C12 (\3\:AN VSS) capacitor c=3.76942e-17
C13 (\1\:BN VSS) capacitor c=3.87939e-17
C14 (\1\:D VSS) capacitor c=1.67468e-16
C15 (\1\:C VSS) capacitor c=1.9358e-16
C16 (\1\:AN VSS) capacitor c=4.53613e-17
C17 (\3\:BN VSS) capacitor c=3.7186e-17
C18 (\2\:AN VSS) capacitor c=4.01825e-17
C19 (\2\:BN VSS) capacitor c=3.88925e-17
C20 (\1\:VDD VSS) capacitor c=3.05634e-16
C21 (\9\:Y VSS) capacitor c=3.68824e-17
C22 (\11\:Y VSS) capacitor c=3.58333e-17
C23 (\13\:Y VSS) capacitor c=3.46816e-17
C24 (\7\:Y VSS) capacitor c=4.10936e-17
C25 (\10\:n0 VSS) capacitor c=6.91354e-17
C26 (\19\:VDD VSS) capacitor c=3.27379e-17
C27 (\10\:n1 VSS) capacitor c=5.66679e-17
C28 (\3\:VDD VSS) capacitor c=2.83014e-17
C29 (\1\:Y VSS) capacitor c=6.16294e-17
C30 (\3\:n3 VSS) capacitor c=7.75226e-17
C31 (\12\:n0 VSS) capacitor c=6.88148e-17
C32 (\12\:n1 VSS) capacitor c=1.61021e-17
C33 (\4\:BN VSS) capacitor c=7.5416e-17
C34 (\4\:AN VSS) capacitor c=4.21776e-17
C35 (\8\:n0 VSS) capacitor c=6.09432e-17
C36 (\9\:n0 VSS) capacitor c=7.92701e-17
C37 (\8\:n1 VSS) capacitor c=2.16198e-16
C38 (\9\:n1 VSS) capacitor c=2.49346e-16
C39 (\7\:C VSS) capacitor c=7.48321e-17
C40 (\7\:D VSS) capacitor c=7.61304e-17
C41 (\3\:Y VSS) capacitor c=8.37207e-17
C42 (\4\:Y VSS) capacitor c=6.72013e-17
C43 (\5\:Y VSS) capacitor c=2.56082e-17
C44 (\6\:Y VSS) capacitor c=2.73863e-17
C45 (\10\:VDD VSS) capacitor c=2.08831e-17
Rk1 (BN \4\:BN) resistor r=0.07076 c=0
Rk13 (\7\:D D) resistor r=0.02379 c=0
Rk14 (\2\:Y \3\:Y) resistor r=0.5148 c=0
Rk15 (\3\:Y \4\:Y) resistor r=0.3409 c=0
Rk16 (\4\:Y \5\:Y) resistor r=0.309 c=0
Rk22 (\6\:Y Y) resistor r=0.02589 c=0
Rk17 (\5\:Y \6\:Y) resistor r=0.1921 c=0
Rk18 (\6\:Y \8\:Y) resistor r=0.07409 c=0
Rk19 (\3\:Y \10\:Y) resistor r=0.06391 c=0
Rk20 (\4\:Y \12\:Y) resistor r=0.05797 c=0
Rk21 (\5\:Y \14\:Y) resistor r=0.05797 c=0
Rk30 (\1\:VDD \9\:VDD) resistor r=0.08758 c=0
Rk32 (\10\:VDD VDD) resistor r=0.1952 c=0
Rk31 (\9\:VDD \10\:VDD) resistor r=0.3559 c=0
Rk37 (\10\:VDD \20\:VDD) resistor r=0.2421 c=0
Rk12 (C \7\:C) resistor r=0.02484 c=0
Rk2 (AN \4\:AN) resistor r=0.1348 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.6619 c=0
Rk39 (\3\:VSS \4\:VSS) resistor r=0.1402 c=0
Rk41 (\5\:VSS VSS) resistor r=0.2077 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.3434 c=0
Rk42 (\3\:VSS \7\:VSS) resistor r=0.2367 c=0
Rk43 (\5\:VSS \9\:VSS) resistor r=0.327 c=0
Rk6 (\8\:n1 \9\:n1) resistor r=1.6447 c=0
Rk7 (\9\:n1 \11\:n1) resistor r=0.5767 c=0
Rk8 (\9\:n1 \13\:n1) resistor r=0.09278 c=0
Rk3 (\8\:n0 \9\:n0) resistor r=0.3117 c=0
Rk4 (\9\:n0 \11\:n0) resistor r=0.446 c=0
Rk5 (\9\:n0 \13\:n0) resistor r=0.2934 c=0
Rk11 (\2\:n3 \4\:n3) resistor r=0.4745 c=0
Rl1 (\1\:BN \2\:BN) resistor r=100.692 c=0
Rl2 (\2\:BN \3\:BN) resistor r=98.7687 c=0
Rl4 (\2\:AN \3\:AN) resistor r=101.099 c=0
Rl3 (\1\:AN \2\:AN) resistor r=100 c=0
Rz8 (\2\:Y \1\:Y) resistor r=75 c=0
Rz12 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz13 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz14 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz15 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\13\:n1 \12\:n1) resistor r=75 c=0
Rz1 (\13\:n0 \12\:n0) resistor r=75 c=0
Rz6 (\2\:n3 n3) resistor r=75 c=0
Rz7 (\4\:n3 \3\:n3) resistor r=75 c=0
Ry3 (\8\:Y \7\:Y) resistor r=20.6667 c=0
Ry4 (\10\:Y \9\:Y) resistor r=31 c=0
Ry5 (\12\:Y \11\:Y) resistor r=31 c=0
Ry6 (\14\:Y \13\:Y) resistor r=31 c=0
Ry12 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry14 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry1 (\11\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\7\:D \1\:D) resistor r=45 c=0
Rx5 (\7\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\8\:n1 n1) resistor r=45 c=0
Rx3 (\8\:n0 n0) resistor r=45 c=0
mn1 (\12\:n1 \3\:BN \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\12\:n0 \1\:AN \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2.25e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn4_1__rcx (n2 \1\:C n3 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn2 (n4 n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.095e-14 ps=8.4e-07 pd=8.35e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(2)
mn3 (\3\:n3 n1 n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(2)
mn5_1__rcx (\1\:Y \1\:D n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mp4_1__rcx (\11\:Y \1\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.95e-07 sd=160n sca=15.5579 \
        scb=0.0139499 scc=0.00102271 m=(2)
mp2 (\7\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.615e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(2)
mp5 (\9\:Y \1\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=7.8e-14 ps=1.08e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.85e-07 sd=160n sca=17.7593 scb=0.0161 \
        scc=0.00103173 m=(2)
mp3_1__rcx (\13\:Y n1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.205e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(2)
ends NAND4BBX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:43 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BBX4
// View name: extracted

simulator lang=spectre

subckt NAND4BBX4 AN BN C D VDD VSS Y
mp1 (\18\:n1 \1\:BN \30\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=16.9422 \
        scb=0.0172816 scc=0.000388705 m=(1)
mp0 (\16\:n0 \1\:AN \30\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=13.2347 \
        scb=0.0110279 scc=0.000235823 m=(1)
mp3_1__rcx (\9\:Y n1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp4_1__rcx (\7\:Y \1\:C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
mp5_1__rcx (\5\:Y \1\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=16.2957 scb=0.0145851 \
        scc=0.00118861 m=(4)
mp2_1__rcx (\11\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
C1 (BN VSS) capacitor c=1.00086e-16
C2 (D VSS) capacitor c=6.16931e-17
C3 (VDD VSS) capacitor c=2.23536e-16
C4 (C VSS) capacitor c=2.75115e-17
C5 (AN VSS) capacitor c=8.07034e-17
C6 (Y VSS) capacitor c=3.13929e-17
C7 (n1 VSS) capacitor c=2.78216e-16
C8 (n0 VSS) capacitor c=2.6421e-16
C9 (n4 VSS) capacitor c=3.85236e-16
C10 (n3 VSS) capacitor c=1.65896e-16
C11 (n2 VSS) capacitor c=3.10092e-16
C12 (\1\:AN VSS) capacitor c=4.32818e-17
C13 (\1\:BN VSS) capacitor c=4.65308e-17
C14 (\1\:D VSS) capacitor c=2.62412e-16
C15 (\1\:C VSS) capacitor c=2.86903e-16
C16 (\3\:AN VSS) capacitor c=3.71654e-17
C17 (\3\:BN VSS) capacitor c=3.07548e-17
C18 (\2\:AN VSS) capacitor c=3.26591e-17
C19 (\2\:BN VSS) capacitor c=3.89688e-17
C20 (\1\:VDD VSS) capacitor c=5.5423e-16
C21 (\16\:n0 VSS) capacitor c=6.3804e-17
C22 (\30\:VDD VSS) capacitor c=3.3055e-17
C23 (\18\:n1 VSS) capacitor c=8.45396e-17
C24 (\1\:Y VSS) capacitor c=1.31821e-16
C25 (\4\:n3 VSS) capacitor c=1.43308e-16
C26 (\18\:n0 VSS) capacitor c=5.99747e-17
C27 (\16\:n1 VSS) capacitor c=2.76938e-16
C28 (\4\:BN VSS) capacitor c=3.41251e-17
C29 (\4\:AN VSS) capacitor c=5.13105e-17
C30 (\14\:n0 VSS) capacitor c=5.85535e-17
C31 (\15\:n0 VSS) capacitor c=6.98837e-17
C32 (\15\:n1 VSS) capacitor c=1.99764e-16
C33 (\14\:C VSS) capacitor c=6.72503e-17
C34 (\16\:D VSS) capacitor c=5.12715e-17
C35 (\5\:Y VSS) capacitor c=1.7241e-16
C36 (\7\:Y VSS) capacitor c=1.66006e-16
C37 (\9\:Y VSS) capacitor c=1.38341e-16
C38 (\11\:Y VSS) capacitor c=1.27398e-16
C39 (\29\:VDD VSS) capacitor c=1.98192e-17
Rk1 (\4\:BN BN) resistor r=0.021 c=0
Rk17 (D \16\:D) resistor r=0.1098 c=0
Rk59 (\29\:VDD VDD) resistor r=0.1675 c=0
Rk57 (\1\:VDD \29\:VDD) resistor r=0.3281 c=0
Rk58 (\29\:VDD \31\:VDD) resistor r=0.181 c=0
Rk12 (C \14\:C) resistor r=0.02606 c=0
Rk2 (AN \4\:AN) resistor r=0.135 c=0
Rk60 (\2\:VSS \3\:VSS) resistor r=0.9275 c=0
Rk64 (\7\:VSS VSS) resistor r=0.1299 c=0
Rk63 (\3\:VSS \7\:VSS) resistor r=0.4216 c=0
Rk66 (\7\:VSS \11\:VSS) resistor r=0.2799 c=0
Rk19 (\1\:Y \5\:Y) resistor r=0.432 c=0
Rk21 (\5\:Y \7\:Y) resistor r=0.3033 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.3044 c=0
Rk35 (\11\:Y Y) resistor r=0.01692 c=0
Rk25 (\9\:Y \11\:Y) resistor r=0.2996 c=0
Rk6 (\15\:n1 \17\:n1) resistor r=1.7189 c=0
Rk7 (\17\:n1 \19\:n1) resistor r=0.651 c=0
Rk3 (\14\:n0 \15\:n0) resistor r=0.3252 c=0
Rk4 (\15\:n0 \17\:n0) resistor r=0.3093 c=0
Rk5 (\15\:n0 \19\:n0) resistor r=0.2262 c=0
Rk14 (n3 \4\:n3) resistor r=0.4388 c=0
Rl1 (\1\:BN \2\:BN) resistor r=92.3077 c=0
Rl2 (\2\:BN \3\:BN) resistor r=57.1429 c=0
Rl3 (\1\:AN \2\:AN) resistor r=91.0764 c=0
Rl4 (\2\:AN \3\:AN) resistor r=56.461 c=0
Rz23 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz2 (\17\:n1 \16\:n1) resistor r=75 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry20 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry21 (\2\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry22 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\19\:n1 \18\:n1) resistor r=62 c=0
Ry1 (\17\:n0 \16\:n0) resistor r=20.6667 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\16\:D \1\:D) resistor r=45 c=0
Rx5 (\14\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\15\:n1 n1) resistor r=45 c=0
Rx3 (\14\:n0 n0) resistor r=45 c=0
mn1 (\16\:n1 \3\:BN \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\18\:n0 \3\:AN \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn4_1__rcx (n2 \1\:C n3 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mn5 (\1\:Y \1\:D n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.03e-14 \
        ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.6e-07 sb=7.55e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(4)
mn2_1__rcx (n4 n0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.127e-14 ps=8.4e-07 pd=8.375e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn3_1__rcx (\4\:n3 n1 n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.127e-14 ad=4.16e-14 ps=8.375e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
ends NAND4BBX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:44 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BBXL
// View name: extracted

simulator lang=spectre

subckt NAND4BBXL AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.6444 \
        scb=0.0398802 scc=0.00365724 m=(1)
mp5 (\6\:Y \3\:D \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.115e-06 sd=160n sca=11.5997 \
        scb=0.00852753 scc=9.93622e-05 m=(1)
mp4 (\6\:Y \1\:C \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.1e-07 sd=160n sca=10.7035 \
        scb=0.00787982 scc=9.84727e-05 m=(1)
mp3 (\1\:Y n1 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.05e-07 sd=160n sca=10.8626 \
        scb=0.00795231 scc=9.85034e-05 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=4.35e-07 sd=160n sca=12.5842 \
        scb=0.00978897 scc=0.000105974 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.945e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.3e-07 sd=160n sca=17.2741 \
        scb=0.017802 scc=0.000385905 m=(1)
C1 (Y VSS) capacitor c=1.07936e-16
C2 (VDD VSS) capacitor c=1.5415e-16
C3 (C VSS) capacitor c=3.2821e-17
C4 (n1 VSS) capacitor c=7.03393e-17
C5 (n2 VSS) capacitor c=1.62358e-18
C6 (n3 VSS) capacitor c=3.97837e-18
C7 (n4 VSS) capacitor c=3.98504e-18
C8 (n0 VSS) capacitor c=6.44613e-17
C9 (\1\:AN VSS) capacitor c=4.74691e-17
C10 (\1\:C VSS) capacitor c=5.52043e-17
C11 (\3\:D VSS) capacitor c=3.88582e-17
C12 (\1\:BN VSS) capacitor c=3.25973e-17
C13 (\3\:AN VSS) capacitor c=4.83788e-17
C14 (\3\:n0 VSS) capacitor c=2.92781e-17
C15 (\4\:n1 VSS) capacitor c=2.8513e-17
C16 (\3\:C VSS) capacitor c=8.72685e-17
C17 (\1\:D VSS) capacitor c=7.94349e-17
C18 (\4\:BN VSS) capacitor c=3.2757e-17
C19 (\2\:AN VSS) capacitor c=5.6314e-17
C20 (\2\:n0 VSS) capacitor c=6.7194e-17
C21 (\3\:n1 VSS) capacitor c=2.80347e-17
C22 (\2\:C VSS) capacitor c=8.04354e-17
C23 (\2\:D VSS) capacitor c=7.52575e-17
C24 (\3\:BN VSS) capacitor c=1.11021e-17
C25 (\4\:n0 VSS) capacitor c=5.6998e-17
C26 (\1\:VDD VSS) capacitor c=4.4467e-17
C27 (\1\:Y VSS) capacitor c=1.5138e-17
C28 (\5\:VDD VSS) capacitor c=2.78974e-17
C29 (\6\:Y VSS) capacitor c=5.97423e-17
C30 (\8\:VDD VSS) capacitor c=1.87504e-17
C31 (\9\:n1 VSS) capacitor c=7.18964e-17
C32 (\10\:VDD VSS) capacitor c=3.06447e-17
C33 (\8\:n0 VSS) capacitor c=3.08909e-17
C34 (\4\:Y VSS) capacitor c=1.10934e-16
C35 (\7\:n1 VSS) capacitor c=2.81927e-17
C36 (\2\:BN VSS) capacitor c=1.76581e-17
C37 (\2\:n1 VSS) capacitor c=4.52918e-17
C38 (\5\:BN VSS) capacitor c=1.05485e-16
C39 (\4\:D VSS) capacitor c=5.51938e-17
C40 (\5\:D VSS) capacitor c=6.50216e-17
C41 (\4\:C VSS) capacitor c=7.49875e-17
C42 (\5\:n1 VSS) capacitor c=8.06688e-17
C43 (\6\:n1 VSS) capacitor c=8.00497e-17
C44 (\3\:Y VSS) capacitor c=3.50449e-17
C45 (\4\:AN VSS) capacitor c=1.05358e-16
C46 (\6\:n0 VSS) capacitor c=5.49869e-17
C47 (\7\:n0 VSS) capacitor c=4.28403e-17
C48 (\4\:VDD VSS) capacitor c=2.24455e-17
C49 (\7\:VDD VSS) capacitor c=1.37046e-17
Rk1 (BN \5\:BN) resistor r=0.005134 c=0
Rk3 (\5\:BN \6\:BN) resistor r=0.02321 c=0
Rk2 (\6\:BN \7\:BN) resistor r=0.005134 c=0
Rk15 (AN \4\:AN) resistor r=0.01812 c=0
Rk12 (\3\:Y Y) resistor r=0.1133 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.05606 c=0
Rk13 (Y \5\:Y) resistor r=0.8519 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.3009 c=0
Rk26 (\4\:VSS VSS) resistor r=0.4015 c=0
Rk25 (\2\:VSS \4\:VSS) resistor r=0.4774 c=0
Rk27 (VSS \6\:VSS) resistor r=0.2196 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.4267 c=0
Rk20 (\4\:VDD \6\:VDD) resistor r=0.2167 c=0
Rk23 (\7\:VDD VDD) resistor r=0.2081 c=0
Rk21 (\4\:VDD \7\:VDD) resistor r=0.1934 c=0
Rk22 (\7\:VDD \9\:VDD) resistor r=0.175 c=0
Rk24 (VDD \11\:VDD) resistor r=0.3814 c=0
Rk7 (C \4\:C) resistor r=0.01074 c=0
Rk4 (D \4\:D) resistor r=0.01414 c=0
Rk6 (\4\:D \5\:D) resistor r=0.0542 c=0
Rk5 (\5\:D \6\:D) resistor r=0.01424 c=0
Rk8 (\5\:n1 \6\:n1) resistor r=0.458 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.144 c=0
Rk10 (\6\:n1 \10\:n1) resistor r=0.3449 c=0
Rk16 (\5\:n0 \6\:n0) resistor r=0.5358 c=0
Rk17 (\6\:n0 \7\:n0) resistor r=0.2395 c=0
Rk18 (\6\:n0 \9\:n0) resistor r=0.2002 c=0
Rl1 (\1\:BN \2\:BN) resistor r=105.483 c=0
Rl3 (\2\:BN \4\:BN) resistor r=95.868 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl13 (\1\:AN \2\:AN) resistor r=148.769 c=0
Rl14 (\2\:AN \3\:AN) resistor r=139.153 c=0
Rl6 (\1\:C \2\:C) resistor r=127.615 c=0
Rl7 (\2\:C \3\:C) resistor r=160.307 c=0
Rl5 (\2\:D \3\:D) resistor r=57.8815 c=0
Rl4 (\1\:D \2\:D) resistor r=232.258 c=0
Rl8 (n1 \2\:n1) resistor r=266.187 c=0
Rl10 (\2\:n1 \4\:n1) resistor r=37.3411 c=0
Rl9 (\2\:n1 \3\:n1) resistor r=3.1183 c=0
Rl11 (n0 \2\:n0) resistor r=251.156 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=33.8482 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\6\:Y \7\:Y) resistor r=62 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry7 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry8 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:BN \7\:BN) resistor r=45 c=0
Rx5 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \6\:D) resistor r=45 c=0
Rx4 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n0 \7\:n0) resistor r=45 c=0
mn1 (\7\:n1 \4\:BN \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn5 (\4\:Y \1\:D n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.25e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn4 (n2 \3\:C n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.2e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn3 (n3 \4\:n1 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=3.263e-14 \
        ad=2.32e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.15e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn2 (n4 \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.263e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=3.45e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
ends NAND4BBXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:45 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BX1
// View name: extracted

simulator lang=spectre

subckt NAND4BX1 AN B C D VDD VSS Y
mp4 (\4\:Y \3\:D \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05577e-07 sd=160n sca=18.7456 \
        scb=0.0202985 scc=0.000573036 m=(1)
mp3 (\4\:Y \1\:C \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.00577e-07 sd=160n sca=13.8229 \
        scb=0.0117387 scc=0.000240879 m=(1)
mp2 (\1\:Y \1\:B \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=4.85577e-07 sd=160n sca=12.9393 \
        scb=0.0102305 scc=0.000232248 m=(1)
mp1 (\1\:Y net118 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.80577e-07 sd=160n sca=13.8723 \
        scb=0.0118284 scc=0.000241736 m=(1)
C1 (B VSS) capacitor c=1.19711e-16
C2 (VDD VSS) capacitor c=1.07729e-16
C3 (C VSS) capacitor c=1.27829e-16
C4 (D VSS) capacitor c=1.31225e-16
C5 (AN VSS) capacitor c=7.62135e-17
C6 (Y VSS) capacitor c=7.81456e-17
C7 (net130 VSS) capacitor c=1.12121e-18
C8 (net126 VSS) capacitor c=4.06786e-18
C9 (net118 VSS) capacitor c=6.3095e-17
C10 (\1\:AN VSS) capacitor c=3.97615e-17
C11 (\1\:B VSS) capacitor c=5.51567e-17
C12 (\1\:C VSS) capacitor c=5.30129e-17
C13 (\3\:D VSS) capacitor c=4.19441e-17
C14 (\3\:AN VSS) capacitor c=3.39936e-17
C15 (\3\:net118 VSS) capacitor c=5.36452e-17
C16 (\3\:B VSS) capacitor c=5.22137e-17
C17 (\3\:C VSS) capacitor c=4.80064e-17
C18 (\1\:D VSS) capacitor c=4.27323e-17
C19 (\2\:AN VSS) capacitor c=4.11575e-17
C20 (\2\:net118 VSS) capacitor c=4.95466e-17
C21 (\2\:B VSS) capacitor c=4.9958e-17
C22 (\2\:C VSS) capacitor c=4.848e-17
C23 (\2\:D VSS) capacitor c=3.84165e-17
C24 (\4\:net118 VSS) capacitor c=5.64567e-17
C25 (\1\:VDD VSS) capacitor c=3.69396e-17
C26 (\1\:Y VSS) capacitor c=6.15461e-17
C27 (\7\:VDD VSS) capacitor c=4.15604e-17
C28 (\4\:Y VSS) capacitor c=3.17151e-17
C29 (\9\:VDD VSS) capacitor c=3.07872e-17
C30 (\6\:net118 VSS) capacitor c=6.31019e-17
C31 (\6\:Y VSS) capacitor c=6.20536e-17
C32 (\3\:Y VSS) capacitor c=6.02955e-17
C33 (\4\:AN VSS) capacitor c=3.2921e-17
C34 (\8\:net118 VSS) capacitor c=5.95336e-17
C35 (\4\:VDD VSS) capacitor c=1.96084e-17
C36 (\5\:VDD VSS) capacitor c=1.07291e-17
C37 (\6\:VDD VSS) capacitor c=1.0534e-17
Rk20 (\4\:VSS VSS) resistor r=0.3005 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.3945 c=0
Rk3 (B \4\:B) resistor r=0.002506 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.337 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.05243 c=0
Rk16 (\6\:VDD VDD) resistor r=0.04216 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.2051 c=0
Rk17 (\5\:VDD \8\:VDD) resistor r=0.1831 c=0
Rk18 (\6\:VDD \10\:VDD) resistor r=0.1776 c=0
Rk2 (C \4\:C) resistor r=0.002814 c=0
Rk1 (\4\:D D) resistor r=0.002995 c=0
Rk10 (\4\:AN AN) resistor r=0.02096 c=0
Rk5 (\3\:Y Y) resistor r=0.3173 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.3736 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.05755 c=0
Rk7 (Y \7\:Y) resistor r=0.4874 c=0
Rk11 (\5\:net118 \7\:net118) resistor r=0.4299 c=0
Rk12 (\7\:net118 \8\:net118) resistor r=0.2576 c=0
Rl5 (\1\:B \2\:B) resistor r=79.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=67.9995 c=0
Rl3 (\1\:C \2\:C) resistor r=75.6918 c=0
Rl4 (\2\:C \3\:C) resistor r=71.8456 c=0
Rl2 (\2\:D \3\:D) resistor r=79.0354 c=0
Rl1 (\1\:D \2\:D) resistor r=69.2308 c=0
Rl9 (\1\:AN \2\:AN) resistor r=92.3077 c=0
Rl10 (\2\:AN \3\:AN) resistor r=57.1429 c=0
Rl7 (net118 \2\:net118) resistor r=103.378 c=0
Rl8 (\2\:net118 \3\:net118) resistor r=43.7671 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\6\:Y \7\:Y) resistor r=75 c=0
Rz2 (\6\:net118 \7\:net118) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\4\:Y \5\:Y) resistor r=31 c=0
Ry3 (\4\:net118 \5\:net118) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:net118 \8\:net118) resistor r=45 c=0
mn4 (\6\:Y \1\:D net130 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=3.64e-14 ps=7.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn3 (net130 \3\:C net126 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=2.86e-14 ps=8.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=6.16058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn2 (net126 \3\:B net122 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.42e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=4.01058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (net122 \3\:net118 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.21e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\6\:net118 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mp0 (\4\:net118 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.6e-07 sd=160n sca=21.4608 scb=0.0245314 \
        scc=0.000949294 m=(1)
ends NAND4BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:46 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BX2
// View name: extracted

simulator lang=spectre

subckt NAND4BX2 AN B C D VDD VSS Y
mp0 (\12\:net118 \1\:AN \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
C1 (B VSS) capacitor c=5.39623e-17
C2 (AN VSS) capacitor c=4.4054e-17
C3 (D VSS) capacitor c=5.64859e-17
C4 (VDD VSS) capacitor c=1.29316e-16
C5 (net118 VSS) capacitor c=8.03951e-17
C6 (net122 VSS) capacitor c=1.91762e-16
C7 (net126 VSS) capacitor c=1.19285e-16
C8 (net130 VSS) capacitor c=1.72087e-16
C9 (\1\:B VSS) capacitor c=1.01467e-16
C10 (\1\:AN VSS) capacitor c=2.57826e-17
C11 (\1\:D VSS) capacitor c=7.46926e-17
C12 (\1\:C VSS) capacitor c=8.97863e-17
C13 (\3\:AN VSS) capacitor c=1.88707e-17
C14 (\3\:D VSS) capacitor c=9.06939e-17
C15 (\3\:C VSS) capacitor c=1.05799e-16
C16 (\3\:net118 VSS) capacitor c=1.26799e-17
C17 (\2\:AN VSS) capacitor c=1.67243e-17
C18 (\1\:Y VSS) capacitor c=8.27687e-17
C19 (\8\:Y VSS) capacitor c=3.60059e-17
C20 (\10\:Y VSS) capacitor c=4.03898e-17
C21 (\6\:Y VSS) capacitor c=5.30136e-17
C22 (\12\:net118 VSS) capacitor c=1.07192e-17
C23 (\20\:VDD VSS) capacitor c=2.23487e-17
C24 (\1\:VDD VSS) capacitor c=1.63899e-17
C25 (\12\:Y VSS) capacitor c=1.91665e-16
C26 (\3\:net126 VSS) capacitor c=1.16215e-16
C27 (\10\:net118 VSS) capacitor c=4.88389e-17
C28 (\5\:net118 VSS) capacitor c=7.09194e-17
C29 (\3\:B VSS) capacitor c=8.60613e-17
C30 (\4\:AN VSS) capacitor c=3.97349e-17
C31 (\8\:net118 VSS) capacitor c=1.87691e-17
C32 (\9\:net118 VSS) capacitor c=2.70231e-17
C33 (\7\:B VSS) capacitor c=4.9822e-17
C34 (\7\:C VSS) capacitor c=6.40368e-17
C35 (\9\:C VSS) capacitor c=6.87063e-17
C36 (\3\:Y VSS) capacitor c=6.88987e-17
C37 (\4\:Y VSS) capacitor c=3.29131e-17
C38 (\5\:Y VSS) capacitor c=1.54036e-16
C39 (\7\:D VSS) capacitor c=3.77066e-17
C40 (\3\:VDD VSS) capacitor c=2.78302e-16
C41 (\9\:VDD VSS) capacitor c=8.79682e-18
Rk37 (\2\:VSS \3\:VSS) resistor r=0.6523 c=0
Rk38 (\3\:VSS \4\:VSS) resistor r=0.193 c=0
Rk40 (\5\:VSS VSS) resistor r=0.03718 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=0.3207 c=0
Rk41 (\4\:VSS \7\:VSS) resistor r=0.1952 c=0
Rk42 (\5\:VSS \9\:VSS) resistor r=0.07416 c=0
Rk9 (\7\:C \8\:C) resistor r=0.002116 c=0
Rk10 (C \9\:C) resistor r=0.002116 c=0
Rk11 (\7\:C \9\:C) resistor r=0.04922 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.3759 c=0
Rk17 (\4\:Y Y) resistor r=0.03368 c=0
Rk13 (\3\:Y \4\:Y) resistor r=0.338 c=0
Rk14 (\4\:Y \5\:Y) resistor r=0.09266 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.2859 c=0
Rk16 (\3\:Y \9\:Y) resistor r=0.05819 c=0
Rk18 (Y \11\:Y) resistor r=0.01112 c=0
Rk19 (\5\:Y \13\:Y) resistor r=1.2418 c=0
Rk7 (\7\:B B) resistor r=0.03181 c=0
Rk1 (AN \4\:AN) resistor r=0.09243 c=0
Rk22 (\7\:D D) resistor r=0.02957 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.07506 c=0
Rk30 (\9\:VDD VDD) resistor r=0.01711 c=0
Rk29 (\3\:VDD \9\:VDD) resistor r=0.2881 c=0
Rk36 (\9\:VDD \21\:VDD) resistor r=0.4193 c=0
Rk2 (\8\:net118 \9\:net118) resistor r=0.08653 c=0
Rk3 (\9\:net118 \11\:net118) resistor r=0.2283 c=0
Rk4 (\9\:net118 \13\:net118) resistor r=0.06384 c=0
Rk8 (\2\:net126 \4\:net126) resistor r=0.395 c=0
Rl15 (\3\:C \1\:C) resistor r=75.3894 c=0
Rl10 (\3\:B \1\:B) resistor r=81.1008 c=0
Rl1 (\1\:AN \2\:AN) resistor r=39.6174 c=0
Rl2 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rl20 (\3\:D \1\:D) resistor r=27.8457 c=0
Rl4 (net118 \3\:net118) resistor r=15.8314 c=0
Rl6 (\5\:net118 \3\:net118) resistor r=36.6223 c=0
Rz13 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz14 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\13\:Y \12\:Y) resistor r=75 c=0
Rz11 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz12 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\11\:net118 \10\:net118) resistor r=75 c=0
Rz5 (\2\:net126 net126) resistor r=75 c=0
Rz6 (\4\:net126 \3\:net126) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry13 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\2\:Y \1\:Y) resistor r=31 c=0
Ry3 (\7\:Y \6\:Y) resistor r=31 c=0
Ry4 (\9\:Y \8\:Y) resistor r=31 c=0
Ry5 (\11\:Y \10\:Y) resistor r=31 c=0
Ry11 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry1 (\13\:net118 \12\:net118) resistor r=62 c=0
Rx4 (\8\:C \3\:C) resistor r=45 c=0
Rx3 (\7\:B \1\:B) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\7\:D \3\:D) resistor r=45 c=0
Rx2 (\8\:net118 \3\:net118) resistor r=45 c=0
mn0 (\10\:net118 \3\:AN \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=2.755e-14 ps=1.5e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn4_1__rcx (\12\:Y \1\:D net130 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn3_1__rcx (net130 \1\:C net126 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.095e-14 ps=8.4e-07 pd=8.35e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=7.55e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn1_1__rcx (net122 \5\:net118 \6\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mn2_1__rcx (\3\:net126 \3\:B net122 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.9e-14 ad=4.55e-14 ps=8.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.6e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp4 (\1\:Y \3\:D \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34231e-06 sb=3.45e-07 sd=160n sca=15.7702 \
        scb=0.0139777 scc=0.000757166 m=(2)
mp1_1__rcx (\6\:Y net118 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.31e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.575e-06 sd=160n sca=14.4586 \
        scb=0.0128281 scc=0.000754439 m=(2)
mp2 (\10\:Y \1\:B \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22308e-07 sb=1.165e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(2)
mp3_1__rcx (\8\:Y \3\:C \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.32308e-07 sb=7.55e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(2)
ends NAND4BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:48 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BX4
// View name: extracted

simulator lang=spectre

subckt NAND4BX4 AN B C D VDD VSS Y
mp0 (\20\:net118 \1\:AN \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(1)
mp3 (\17\:Y C \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.654e-14 ad=6.24e-14 ps=1.1725e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.795e-06 sb=1.72e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp1_1__rcx (\6\:Y net118 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.191e-14 ad=6.24e-14 ps=1.0975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.4951 scb=0.0160444 \
        scc=0.00137992 m=(4)
mp2_1__rcx (Y \1\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.386e-14 ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=2e-06 sd=160n sca=17.2385 scb=0.0152696 \
        scc=0.00137893 m=(4)
mp4_1__rcx (\23\:Y \1\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.459e-14 ad=6.24e-14 ps=1.1625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.2385 scb=0.0152696 \
        scc=0.00137893 m=(4)
C1 (Y VSS) capacitor c=1.40387e-16
C2 (C VSS) capacitor c=5.42776e-16
C3 (VDD VSS) capacitor c=1.58976e-16
C4 (B VSS) capacitor c=9.66178e-17
C5 (AN VSS) capacitor c=2.02132e-17
C6 (D VSS) capacitor c=5.82619e-17
C7 (net118 VSS) capacitor c=3.36982e-16
C8 (net122 VSS) capacitor c=3.87046e-16
C9 (net126 VSS) capacitor c=2.35839e-16
C10 (net130 VSS) capacitor c=4.16595e-16
C11 (\1\:D VSS) capacitor c=3.10554e-16
C12 (\1\:B VSS) capacitor c=3.02249e-16
C13 (\1\:AN VSS) capacitor c=3.17949e-17
C14 (\4\:AN VSS) capacitor c=2.95472e-17
C15 (\3\:AN VSS) capacitor c=1.05263e-17
C16 (\1\:VDD VSS) capacitor c=5.3658e-16
C17 (\20\:net118 VSS) capacitor c=8.3097e-17
C18 (\14\:VDD VSS) capacitor c=3.23282e-17
C19 (\1\:Y VSS) capacitor c=3.66617e-16
C20 (\5\:net126 VSS) capacitor c=2.06261e-16
C21 (\18\:net118 VSS) capacitor c=2.13766e-17
C22 (\2\:AN VSS) capacitor c=1.06902e-17
C23 (\5\:AN VSS) capacitor c=8.10096e-17
C24 (\17\:net118 VSS) capacitor c=5.38429e-17
C25 (\5\:Y VSS) capacitor c=2.59301e-16
C26 (\6\:Y VSS) capacitor c=1.56448e-16
C27 (\17\:Y VSS) capacitor c=1.82939e-16
C28 (\23\:Y VSS) capacitor c=1.98707e-16
Rk26 (\5\:Y Y) resistor r=0.02031 c=0
Rk23 (\1\:Y \5\:Y) resistor r=1.9032 c=0
Rk24 (\5\:Y \6\:Y) resistor r=0.2682 c=0
Rk32 (Y \17\:Y) resistor r=0.3091 c=0
Rk36 (\17\:Y \23\:Y) resistor r=0.4323 c=0
Rk66 (\2\:VSS \3\:VSS) resistor r=1.1038 c=0
Rk69 (\4\:VSS VSS) resistor r=0.3085 c=0
Rk67 (\3\:VSS \4\:VSS) resistor r=0.03743 c=0
Rk70 (VSS \7\:VSS) resistor r=0.2823 c=0
Rk56 (\1\:VDD VDD) resistor r=0.2056 c=0
Rk57 (VDD \15\:VDD) resistor r=0.3173 c=0
Rk6 (B \1\:B) resistor r=0.01834 c=0
Rk1 (\5\:AN AN) resistor r=0.01142 c=0
Rk20 (\1\:D D) resistor r=0.006306 c=0
Rk3 (net118 \17\:net118) resistor r=0.3292 c=0
Rk4 (\17\:net118 \19\:net118) resistor r=0.1043 c=0
Rk5 (\17\:net118 \21\:net118) resistor r=0.3004 c=0
Rk14 (net126 \5\:net126) resistor r=0.4888 c=0
Rl1 (\1\:AN \2\:AN) resistor r=57.4064 c=0
Rl3 (\2\:AN \4\:AN) resistor r=34.3295 c=0
Rl2 (\2\:AN \3\:AN) resistor r=1.2666 c=0
Rz20 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\19\:net118 \18\:net118) resistor r=75 c=0
Ry20 (\2\:VSS \1\:VSS) resistor r=6.2 c=0
Ry21 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\21\:net118 \20\:net118) resistor r=20.6667 c=0
Rx1 (\3\:AN \5\:AN) resistor r=45 c=0
mn0 (\18\:net118 \4\:AN \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2_1__rcx (\5\:net126 \1\:B net122 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn4_1__rcx (\1\:Y \1\:D net130 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=7.8e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(4)
mn1_1__rcx (net122 net118 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn3_1__rcx (net130 C net126 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=6.24e-14 ps=8.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.77e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(4)
ends NAND4BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:49 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4BXL
// View name: extracted

simulator lang=spectre

subckt NAND4BXL AN B C D VDD VSS Y
mp4 (\4\:Y \3\:D \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=18.0123 \
        scb=0.019139 scc=0.000475418 m=(1)
mp3 (\4\:Y \1\:C \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.3e-07 sd=160n sca=13.4568 \
        scb=0.0111557 scc=0.000195491 m=(1)
mp2 (\1\:Y \1\:B \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.35e-07 sd=160n sca=12.6657 \
        scb=0.00981458 scc=0.000188357 m=(1)
mp1 (\1\:Y net118 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=4.3e-07 sd=160n sca=13.5027 \
        scb=0.0112382 scc=0.000196207 m=(1)
mp0 (\4\:net118 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.548e-14 ps=1.45e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.65e-07 sd=160n sca=21.9147 \
        scb=0.024825 scc=0.00104914 m=(1)
C1 (B VSS) capacitor c=3.09207e-17
C2 (VDD VSS) capacitor c=1.22141e-16
C3 (C VSS) capacitor c=1.23095e-16
C4 (D VSS) capacitor c=7.57814e-17
C5 (AN VSS) capacitor c=9.18193e-17
C6 (Y VSS) capacitor c=7.01679e-17
C7 (net130 VSS) capacitor c=9.49579e-19
C8 (net126 VSS) capacitor c=5.24897e-19
C9 (net122 VSS) capacitor c=4.42068e-19
C10 (net118 VSS) capacitor c=6.80873e-17
C11 (\1\:AN VSS) capacitor c=3.96037e-17
C12 (\1\:B VSS) capacitor c=7.65503e-17
C13 (\1\:C VSS) capacitor c=6.35828e-17
C14 (\3\:D VSS) capacitor c=5.25861e-17
C15 (\3\:AN VSS) capacitor c=5.09076e-17
C16 (\3\:net118 VSS) capacitor c=2.94712e-17
C17 (\3\:B VSS) capacitor c=3.15778e-17
C18 (\3\:C VSS) capacitor c=5.01541e-17
C19 (\1\:D VSS) capacitor c=3.40705e-17
C20 (\2\:AN VSS) capacitor c=4.99928e-17
C21 (\2\:net118 VSS) capacitor c=6.43813e-17
C22 (\2\:B VSS) capacitor c=6.71778e-17
C23 (\2\:C VSS) capacitor c=6.44475e-17
C24 (\2\:D VSS) capacitor c=5.49287e-17
C25 (\4\:net118 VSS) capacitor c=5.43156e-17
C26 (\1\:VDD VSS) capacitor c=2.13892e-17
C27 (\1\:Y VSS) capacitor c=2.98627e-17
C28 (\7\:VDD VSS) capacitor c=9.24763e-18
C29 (\4\:Y VSS) capacitor c=8.27347e-18
C30 (\9\:VDD VSS) capacitor c=2.53258e-17
C31 (\8\:net118 VSS) capacitor c=3.23143e-17
C32 (\6\:Y VSS) capacitor c=4.36987e-17
C33 (\4\:D VSS) capacitor c=4.27124e-17
C34 (\4\:B VSS) capacitor c=7.49227e-17
C35 (\3\:Y VSS) capacitor c=1.02067e-16
C36 (\6\:net118 VSS) capacitor c=5.00385e-17
C37 (\7\:net118 VSS) capacitor c=4.10938e-17
C38 (\4\:VDD VSS) capacitor c=1.24909e-17
C39 (\5\:VDD VSS) capacitor c=4.23851e-18
C40 (\6\:VDD VSS) capacitor c=5.61473e-18
Rk19 (\4\:VSS VSS) resistor r=0.3004 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.329 c=0
Rk3 (B \4\:B) resistor r=0.1018 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.2421 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.06746 c=0
Rk15 (\6\:VDD VDD) resistor r=0.04716 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.185 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.07334 c=0
Rk17 (\6\:VDD \10\:VDD) resistor r=0.2658 c=0
Rk2 (C \4\:C) resistor r=0.003963 c=0
Rk1 (D \4\:D) resistor r=0.08679 c=0
Rk8 (AN \4\:AN) resistor r=0.01485 c=0
Rk5 (\3\:Y Y) resistor r=0.661 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.351 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.03284 c=0
Rk7 (Y \7\:Y) resistor r=0.1702 c=0
Rk9 (\5\:net118 \6\:net118) resistor r=0.4822 c=0
Rk10 (\6\:net118 \7\:net118) resistor r=0.2454 c=0
Rk11 (\6\:net118 \9\:net118) resistor r=0.1824 c=0
Rl5 (\1\:B \2\:B) resistor r=226.098 c=0
Rl6 (\2\:B \3\:B) resistor r=26.098 c=0
Rl3 (\1\:C \2\:C) resistor r=166.076 c=0
Rl4 (\2\:C \3\:C) resistor r=92.9995 c=0
Rl2 (\2\:D \3\:D) resistor r=220.212 c=0
Rl1 (\1\:D \2\:D) resistor r=40.3846 c=0
Rl9 (\1\:AN \2\:AN) resistor r=100 c=0
Rl10 (\2\:AN \3\:AN) resistor r=160.989 c=0
Rl7 (net118 \2\:net118) resistor r=216.483 c=0
Rl8 (\2\:net118 \3\:net118) resistor r=35.7134 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\6\:Y \7\:Y) resistor r=75 c=0
Rz2 (\8\:net118 \9\:net118) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=62 c=0
Ry3 (\4\:net118 \5\:net118) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:net118 \7\:net118) resistor r=45 c=0
mn4 (\6\:Y \1\:D net130 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.03e-14 ps=5.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.85e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn3 (net130 \3\:C net126 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=1.595e-14 ps=5.2e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=7.3e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn2 (net126 \3\:B net122 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=1.668e-14 ps=6.5e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=5.7e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (net122 \3\:net118 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=3.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn0 (\8\:net118 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
ends NAND4BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:50 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4X1
// View name: extracted

simulator lang=spectre

subckt NAND4X1 A B C D VDD VSS Y
mp0 (\4\:Y \3\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=34.1345 scb=0.02948 \
        scc=0.00325161 m=(1)
mp1 (\4\:Y \1\:B \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=30.1089 \
        scb=0.0217941 scc=0.00297188 m=(1)
mp2 (\6\:Y \1\:C \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.435e-14 ps=1.12e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.5e-07 sd=160n sca=30.2583 \
        scb=0.0220944 scc=0.00297511 m=(1)
mp3 (\6\:Y \1\:D \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=35.3118 \
        scb=0.0314154 scc=0.00340463 m=(1)
C1 (B VSS) capacitor c=5.67645e-17
C2 (D VSS) capacitor c=4.98892e-17
C3 (A VSS) capacitor c=5.18308e-17
C4 (Y VSS) capacitor c=5.5883e-17
C5 (VDD VSS) capacitor c=5.87904e-17
C6 (C VSS) capacitor c=6.60757e-17
C7 (n2 VSS) capacitor c=4.43225e-18
C8 (n1 VSS) capacitor c=5.91565e-18
C9 (n0 VSS) capacitor c=3.68605e-19
C10 (\1\:D VSS) capacitor c=3.64935e-17
C11 (\1\:C VSS) capacitor c=4.72404e-17
C12 (\1\:B VSS) capacitor c=4.85966e-17
C13 (\3\:A VSS) capacitor c=3.5561e-17
C14 (\3\:D VSS) capacitor c=3.92379e-17
C15 (\3\:C VSS) capacitor c=4.42303e-17
C16 (\3\:B VSS) capacitor c=5.58043e-17
C17 (\1\:A VSS) capacitor c=5.70521e-17
C18 (\2\:D VSS) capacitor c=2.87033e-17
C19 (\2\:C VSS) capacitor c=3.40667e-17
C20 (\2\:B VSS) capacitor c=3.72928e-17
C21 (\2\:A VSS) capacitor c=3.35289e-17
C22 (\1\:VDD VSS) capacitor c=3.46868e-17
C23 (\6\:Y VSS) capacitor c=3.30168e-17
C24 (\5\:VDD VSS) capacitor c=4.66314e-17
C25 (\4\:Y VSS) capacitor c=7.08126e-17
C26 (\8\:VDD VSS) capacitor c=4.9316e-17
C27 (\1\:Y VSS) capacitor c=4.65178e-17
C28 (\4\:A VSS) capacitor c=3.62144e-17
C29 (\4\:B VSS) capacitor c=7.0741e-17
C30 (\4\:C VSS) capacitor c=7.968e-17
C31 (\4\:D VSS) capacitor c=7.73272e-17
C32 (\3\:Y VSS) capacitor c=4.6452e-17
C33 (\4\:VDD VSS) capacitor c=2.24443e-17
C34 (\7\:VDD VSS) capacitor c=6.94822e-18
Rk15 (\3\:VSS VSS) resistor r=0.09734 c=0
Rk16 (\3\:VSS \5\:VSS) resistor r=0.2911 c=0
Rk2 (\4\:B B) resistor r=0.1759 c=0
Rk4 (D \4\:D) resistor r=0.171 c=0
Rk1 (\4\:A A) resistor r=0.03899 c=0
Rk5 (\2\:Y Y) resistor r=0.1859 c=0
Rk6 (Y \3\:Y) resistor r=0.2953 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.38 c=0
Rk8 (\3\:Y \7\:Y) resistor r=0.05786 c=0
Rk9 (\2\:VDD \4\:VDD) resistor r=0.5152 c=0
Rk10 (\4\:VDD \6\:VDD) resistor r=0.3503 c=0
Rk13 (\7\:VDD VDD) resistor r=0.04719 c=0
Rk11 (\4\:VDD \7\:VDD) resistor r=0.2029 c=0
Rk12 (\7\:VDD \9\:VDD) resistor r=0.3578 c=0
Rk3 (C \4\:C) resistor r=0.291 c=0
Rl3 (\1\:B \2\:B) resistor r=41.0764 c=0
Rl4 (\2\:B \3\:B) resistor r=29.5379 c=0
Rl7 (\1\:D \2\:D) resistor r=46.1538 c=0
Rl8 (\2\:D \3\:D) resistor r=26.3736 c=0
Rl2 (\2\:A \3\:A) resistor r=33.8482 c=0
Rl1 (\1\:A \2\:A) resistor r=64.9387 c=0
Rl5 (\1\:C \2\:C) resistor r=41.0764 c=0
Rl6 (\2\:C \3\:C) resistor r=29.5379 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry5 (\8\:VDD \9\:VDD) resistor r=31 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (n2 \1\:A \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (n1 \3\:B n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.42e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.05e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn2 (n0 \3\:C n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=2.34e-14 ps=8.6e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 sa=4.6e-07 \
        sb=3.9e-07 sd=160n sca=17.5885 scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\1\:Y \3\:D n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.63e-14 ps=7e-07 pd=1.03e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.95e-07 sb=2.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
ends NAND4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:51 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4X2
// View name: extracted

simulator lang=spectre

subckt NAND4X2 A B C D VDD VSS Y
mp0 (\1\:Y A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=7.688e-14 \
        ad=7.312e-14 ps=1.33e-06 pd=1.155e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.55e-07 sb=1.84e-06 sd=160n sca=23.2428 scb=0.0263908 \
        scc=0.00131858 m=(2)
mp1_1__rcx (\1\:Y \1\:B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=7.312e-14 ps=1.67e-06 pd=1.155e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.635e-06 sd=160n sca=16.4248 \
        scb=0.0152088 scc=0.000666128 m=(2)
mp2 (\1\:Y \1\:C VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.37e-06 sd=160n sca=14.2658 \
        scb=0.0124744 scc=0.000647653 m=(2)
mp3_1__rcx (\1\:Y \3\:D \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.165e-06 sd=160n sca=13.6466 \
        scb=0.0121992 scc=0.000647514 m=(2)
C1 (C VSS) capacitor c=9.55576e-17
C2 (D VSS) capacitor c=2.60608e-17
C3 (A VSS) capacitor c=6.22122e-16
C4 (VDD VSS) capacitor c=3.69121e-16
C5 (Y VSS) capacitor c=1.38262e-16
C6 (10 VSS) capacitor c=7.24277e-18
C7 (11 VSS) capacitor c=3.04429e-18
C8 (12 VSS) capacitor c=7.41177e-18
C9 (13 VSS) capacitor c=7.41479e-18
C10 (\1\:C VSS) capacitor c=3.11015e-16
C11 (\1\:B VSS) capacitor c=5.03828e-16
C12 (\6\:A VSS) capacitor c=3.96774e-17
C13 (\6\:B VSS) capacitor c=5.11482e-17
C14 (\6\:C VSS) capacitor c=4.34411e-17
C15 (\1\:D VSS) capacitor c=4.84101e-17
C16 (\5\:D VSS) capacitor c=1.76904e-17
C17 (\3\:C VSS) capacitor c=4.0468e-17
C18 (\3\:B VSS) capacitor c=5.97794e-17
C19 (\1\:A VSS) capacitor c=5.45314e-17
C20 (\2\:D VSS) capacitor c=2.65979e-17
C21 (\1\:Y VSS) capacitor c=3.5143e-16
C22 (\7\:VDD VSS) capacitor c=2.71616e-17
C23 (\9\:Y VSS) capacitor c=1.30059e-16
C24 (\3\:D VSS) capacitor c=1.17895e-16
C25 (\7\:D VSS) capacitor c=6.98664e-17
Rk23 (\3\:VSS VSS) resistor r=0.0572 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.203 c=0
Rk24 (\3\:VSS \5\:VSS) resistor r=0.4434 c=0
Rk25 (\5\:VSS \7\:VSS) resistor r=0.6247 c=0
Rk2 (C \1\:C) resistor r=0.04063 c=0
Rk1 (\7\:D D) resistor r=0.1538 c=0
Rk17 (VDD \8\:VDD) resistor r=0.1021 c=0
Rk8 (Y \1\:Y) resistor r=0.2772 c=0
Rk12 (Y \10\:Y) resistor r=1.1724 c=0
Rk5 (\1\:B B) resistor r=0.005628 c=0
Rl13 (\1\:C \6\:C) resistor r=44.9225 c=0
Rl6 (\1\:C \3\:C) resistor r=102.615 c=0
Rl7 (\2\:D \1\:D) resistor r=105.323 c=0
Rl10 (\2\:D \5\:D) resistor r=31.9251 c=0
Rl8 (\3\:D \2\:D) resistor r=79.6836 c=0
Rl17 (A \6\:A) resistor r=120.33 c=0
Rl1 (A \1\:A) resistor r=115.18 c=0
Rl15 (\1\:B \6\:B) resistor r=129.538 c=0
Rl4 (\1\:B \3\:B) resistor r=114.153 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\10\:Y \9\:Y) resistor r=75 c=0
Ry7 (\8\:VDD \7\:VDD) resistor r=62 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0_1__rcx (8 \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.685e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (8 \3\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=2.34e-14 ps=9.6e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.55e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (10 \3\:C 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.89e-14 ps=9.6e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\9\:Y \5\:D 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=4.16e-14 ps=1.05e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=9.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\9\:Y \1\:D 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.055e-06 sb=7.7e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (12 \6\:C 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=5.72e-14 ps=7.5e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.215e-06 sb=6.1e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (12 \6\:B 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.48e-06 sb=3.45e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (13 \6\:A \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
ends NAND4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:52 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4X4
// View name: extracted

simulator lang=spectre

subckt NAND4X4 A B C D VDD VSS Y
mp1_1__rcx (Y \1\:B VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp0_1__rcx (\6\:Y A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=29.9299 scb=0.0335958 \
        scc=0.00259498 m=(4)
mp2_1__rcx (\16\:Y C VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-06 sb=1.8e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
mp3_1__rcx (\22\:Y D VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.239e-14 ad=6.24e-14 ps=1.2025e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.15e-07 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
C1 (B VSS) capacitor c=9.2377e-17
C2 (D VSS) capacitor c=3.50923e-16
C3 (A VSS) capacitor c=3.52064e-16
C4 (VDD VSS) capacitor c=6.49054e-16
C5 (Y VSS) capacitor c=3.9956e-16
C6 (C VSS) capacitor c=5.1651e-16
C7 (n2 VSS) capacitor c=3.51786e-16
C8 (n1 VSS) capacitor c=2.49169e-16
C9 (n0 VSS) capacitor c=4.19133e-16
C10 (\1\:B VSS) capacitor c=3.11848e-16
C11 (\1\:Y VSS) capacitor c=3.5956e-16
C12 (\5\:n1 VSS) capacitor c=1.99789e-16
C13 (\6\:Y VSS) capacitor c=1.58452e-16
C14 (\16\:Y VSS) capacitor c=1.856e-16
C15 (\22\:Y VSS) capacitor c=1.8751e-16
Rk59 (\2\:VSS \3\:VSS) resistor r=1.0035 c=0
Rk62 (\4\:VSS VSS) resistor r=0.1175 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.2281 c=0
Rk3 (B \1\:B) resistor r=0.006313 c=0
Rk20 (\1\:Y Y) resistor r=1.9594 c=0
Rk21 (Y \6\:Y) resistor r=0.3131 c=0
Rk28 (Y \16\:Y) resistor r=0.3303 c=0
Rk32 (\16\:Y \22\:Y) resistor r=0.445 c=0
Rk10 (n1 \5\:n1) resistor r=0.5145 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=7.75 c=0
Ry19 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn2_1__rcx (n0 C n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=6.565e-14 ps=8.4e-07 pd=1.025e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.79e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn3_1__rcx (\1\:Y D n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=7.75e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn1_1__rcx (\5\:n1 \1\:B n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
mn0_1__rcx (n2 A \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
ends NAND4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:53 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4X6
// View name: extracted

simulator lang=spectre

subckt NAND4X6 A B C D VDD VSS Y
mp1_1__rcx (\16\:Y \1\:B \7\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 \
        nf=1 as=7.52e-14 ad=1.0246e-13 ps=1.26e-06 pd=1.376e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.305e-06 sb=2e-06 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
mp3_1__rcx (\5\:Y \1\:D \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=8.601e-14 ps=1.252e-06 pd=1.306e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.95e-07 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
mp0 (\16\:Y \1\:A \13\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=8.836e-14 ps=1.252e-06 pd=1.316e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.7755 scb=0.0243055 \
        scc=0.00289785 m=(5)
mp2 (\5\:Y \1\:C \7\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=8.648e-14 ad=7.943e-14 ps=1.308e-06 pd=1.278e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
C1 (B VSS) capacitor c=1.90264e-17
C2 (D VSS) capacitor c=2.14078e-17
C3 (A VSS) capacitor c=3.20951e-17
C4 (Y VSS) capacitor c=2.69966e-17
C5 (VDD VSS) capacitor c=1.24093e-16
C6 (C VSS) capacitor c=2.54175e-17
C7 (n2 VSS) capacitor c=3.99687e-16
C8 (n1 VSS) capacitor c=3.56675e-16
C9 (n0 VSS) capacitor c=3.32559e-16
C10 (\1\:D VSS) capacitor c=3.23443e-16
C11 (\1\:B VSS) capacitor c=3.22833e-16
C12 (\1\:A VSS) capacitor c=3.00117e-16
C13 (\1\:C VSS) capacitor c=3.33087e-16
C14 (\1\:VDD VSS) capacitor c=2.48228e-17
C15 (\1\:Y VSS) capacitor c=1.8495e-16
C16 (\5\:Y VSS) capacitor c=4.23013e-16
C17 (\16\:Y VSS) capacitor c=4.55002e-16
C18 (\3\:VDD VSS) capacitor c=1.67326e-16
C19 (\7\:VDD VSS) capacitor c=2.7971e-16
C20 (\13\:VDD VSS) capacitor c=1.73013e-16
Rk67 (\2\:VSS \3\:VSS) resistor r=0.6515 c=0
Rk68 (\3\:VSS \4\:VSS) resistor r=1.2028 c=0
Rk72 (\5\:VSS VSS) resistor r=0.07723 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.06245 c=0
Rk4 (\1\:B B) resistor r=0.03625 c=0
Rk18 (\1\:D D) resistor r=0.02337 c=0
Rk1 (A \1\:A) resistor r=0.03292 c=0
Rk25 (\1\:Y Y) resistor r=0.1993 c=0
Rk26 (Y \5\:Y) resistor r=0.117 c=0
Rk33 (\5\:Y \16\:Y) resistor r=0.3276 c=0
Rk42 (\2\:VDD \3\:VDD) resistor r=0.09502 c=0
Rk45 (\3\:VDD \6\:VDD) resistor r=0.1276 c=0
Rk46 (\6\:VDD \7\:VDD) resistor r=0.1 c=0
Rk51 (\7\:VDD \12\:VDD) resistor r=0.2128 c=0
Rk55 (\13\:VDD VDD) resistor r=0.07723 c=0
Rk52 (\12\:VDD \13\:VDD) resistor r=0.06245 c=0
Rk12 (\1\:C C) resistor r=0.01297 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz20 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Ry23 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry24 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry25 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (n2 \1\:A \5\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.828e-14 ps=9.32e-07 pd=9.96e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn3 (\1\:Y \1\:D n0 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=5.549e-14 \
        ad=4.96e-14 ps=9.78e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=9.95e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn1_1__rcx (n1 \1\:B n2 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.828e-14 ad=5.425e-14 ps=9.96e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mn2_1__rcx (n0 \1\:C n1 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.107e-14 ad=5.301e-14 ps=1.014e-06 pd=9.62e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
ends NAND4X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:54 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4X8
// View name: extracted

simulator lang=spectre

subckt NAND4X8 A B C D VDD VSS Y
mp1_1__rcx (\16\:Y B \13\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
mp0_1__rcx (\16\:Y A VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=30.632 scb=0.0328204 \
        scc=0.00272371 m=(7)
mp2_1__rcx (\9\:Y \1\:C \13\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
mp3 (\9\:Y D \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
C1 (B VSS) capacitor c=4.72166e-16
C2 (D VSS) capacitor c=4.58531e-16
C3 (A VSS) capacitor c=4.36084e-16
C4 (Y VSS) capacitor c=1.49493e-17
C5 (VDD VSS) capacitor c=4.13018e-16
C6 (C VSS) capacitor c=2.10884e-17
C7 (n2 VSS) capacitor c=4.40725e-16
C8 (n1 VSS) capacitor c=4.97624e-16
C9 (n0 VSS) capacitor c=4.30981e-16
C10 (\1\:C VSS) capacitor c=4.47893e-16
C11 (\1\:VDD VSS) capacitor c=2.0629e-16
C12 (\3\:VDD VSS) capacitor c=5.21265e-17
C13 (\1\:Y VSS) capacitor c=2.20217e-16
C14 (\9\:Y VSS) capacitor c=6.08467e-16
C15 (\16\:Y VSS) capacitor c=6.11765e-16
C16 (\13\:VDD VSS) capacitor c=3.88141e-16
Rk92 (\3\:VSS VSS) resistor r=1.1301 c=0
Rk91 (\2\:VSS \3\:VSS) resistor r=0.9022 c=0
Rk34 (\1\:Y Y) resistor r=0.04342 c=0
Rk35 (Y \9\:Y) resistor r=0.227 c=0
Rk42 (\9\:Y \16\:Y) resistor r=0.3333 c=0
Rk82 (\13\:VDD VDD) resistor r=0.2051 c=0
Rk67 (\1\:VDD \13\:VDD) resistor r=0.2051 c=0
Rk15 (\1\:C C) resistor r=0.04316 c=0
Rz28 (VDD \3\:VDD) resistor r=6.25 c=0
Rz26 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz27 (\13\:VDD \3\:VDD) resistor r=6.25 c=0
Ry32 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\2\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry31 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn2_1__rcx (n0 \1\:C n1 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn1 (n1 B n2 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.575e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn3_1__rcx (\1\:Y D n0 VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn0_1__rcx (n2 A VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
ends NAND4X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:55 2013 )
// Library name: gsclib045_hvt
// Cell name: NAND4XL
// View name: extracted

simulator lang=spectre

subckt NAND4XL A B C D VDD VSS Y
mp0 (\5\:Y \3\:A \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.05e-07 sd=160n sca=65.5272 scb=0.0524355 \
        scc=0.00853103 m=(1)
mp1 (\5\:Y \1\:B \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5e-07 sd=160n sca=51.4512 scb=0.0349149 \
        scc=0.00596975 m=(1)
mp2 (\3\:Y \1\:C \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=3.05e-07 sd=160n sca=50.5093 scb=0.0329496 \
        scc=0.00591106 m=(1)
mp3 (\3\:Y \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1e-07 sd=160n sca=57.096 scb=0.0442069 \
        scc=0.00674539 m=(1)
C1 (Y VSS) capacitor c=4.63281e-17
C2 (B VSS) capacitor c=3.55125e-17
C3 (D VSS) capacitor c=3.72267e-17
C4 (A VSS) capacitor c=3.95921e-17
C5 (VDD VSS) capacitor c=6.178e-17
C6 (C VSS) capacitor c=2.3198e-17
C7 (n1 VSS) capacitor c=2.55518e-18
C8 (\1\:D VSS) capacitor c=2.63158e-17
C9 (\1\:C VSS) capacitor c=4.30189e-17
C10 (\1\:B VSS) capacitor c=4.23484e-17
C11 (\3\:A VSS) capacitor c=2.74092e-17
C12 (\3\:D VSS) capacitor c=3.66854e-17
C13 (\3\:C VSS) capacitor c=3.60815e-17
C14 (\3\:B VSS) capacitor c=3.34626e-17
C15 (\1\:A VSS) capacitor c=2.94146e-17
C16 (\2\:D VSS) capacitor c=2.94276e-17
C17 (\2\:C VSS) capacitor c=3.51946e-17
C18 (\2\:B VSS) capacitor c=3.52305e-17
C19 (\2\:A VSS) capacitor c=2.55357e-17
C20 (\1\:VDD VSS) capacitor c=1.0867e-17
C21 (\3\:Y VSS) capacitor c=4.87117e-17
C22 (\8\:VDD VSS) capacitor c=1.56544e-17
C23 (\5\:Y VSS) capacitor c=3.2014e-17
C24 (\6\:VDD VSS) capacitor c=4.01051e-18
C25 (\1\:Y VSS) capacitor c=6.16295e-17
C26 (\4\:A VSS) capacitor c=4.32252e-17
C27 (\4\:B VSS) capacitor c=5.53185e-17
C28 (\4\:C VSS) capacitor c=5.43796e-17
C29 (\5\:D VSS) capacitor c=5.9778e-17
C30 (\4\:VDD VSS) capacitor c=1.29976e-17
C31 (\5\:VDD VSS) capacitor c=3.70959e-18
Rk7 (\2\:Y Y) resistor r=0.2741 c=0
Rk8 (Y \4\:Y) resistor r=0.1629 c=0
Rk9 (\4\:Y \6\:Y) resistor r=0.2769 c=0
Rk2 (B \4\:B) resistor r=0.1283 c=0
Rk4 (\4\:D \5\:D) resistor r=0.001151 c=0
Rk5 (\6\:D D) resistor r=0.001266 c=0
Rk6 (\5\:D \6\:D) resistor r=0.04773 c=0
Rk1 (A \4\:A) resistor r=0.2237 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3862 c=0
Rk12 (\5\:VDD VDD) resistor r=0.1646 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.03475 c=0
Rk13 (VDD \7\:VDD) resistor r=0.2299 c=0
Rk14 (\5\:VDD \9\:VDD) resistor r=0.221 c=0
Rk16 (VSS \4\:VSS) resistor r=0.0778 c=0
Rk3 (C \4\:C) resistor r=0.03282 c=0
Rl3 (\1\:B \2\:B) resistor r=38.4615 c=0
Rl4 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl7 (\1\:D \2\:D) resistor r=28.8462 c=0
Rl8 (\2\:D \3\:D) resistor r=39.8352 c=0
Rl2 (\2\:A \3\:A) resistor r=33.7903 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rl5 (\1\:C \2\:C) resistor r=37.2302 c=0
Rl6 (\2\:C \3\:C) resistor r=29.5379 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry5 (\8\:VDD \9\:VDD) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (n2 \1\:A \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=1.305e-14 ps=1.5e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.35e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (n1 \3\:B n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.305e-14 \
        ad=2.973e-14 ps=4.7e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.35e-07 sb=6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (n0 \3\:C n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.973e-14 \
        ad=1.233e-14 ps=7e-07 pd=4.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.85e-07 sb=3.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (\1\:Y \3\:D n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=3.19e-14 ps=4.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends NAND4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:57 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2BX1
// View name: extracted

simulator lang=spectre

subckt NOR2BX1 AN B VDD VSS Y
mp2 (\3\:Y \1\:B net59 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.74551e-07 sd=160n sca=22.6423 \
        scb=0.024839 scc=0.000882584 m=(1)
mp1 (net59 \3\:net76 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.69551e-07 sd=160n sca=19.5802 \
        scb=0.0197242 scc=0.000428585 m=(1)
C1 (Y VSS) capacitor c=6.21874e-17
C2 (VDD VSS) capacitor c=9.81581e-17
C3 (B VSS) capacitor c=3.75768e-17
C4 (net76 VSS) capacitor c=5.55501e-17
C5 (\1\:AN VSS) capacitor c=3.73396e-17
C6 (\3\:net76 VSS) capacitor c=7.73674e-17
C7 (\1\:B VSS) capacitor c=7.64588e-17
C8 (\3\:AN VSS) capacitor c=4.1217e-17
C9 (\3\:B VSS) capacitor c=3.00489e-17
C10 (\2\:AN VSS) capacitor c=3.78605e-17
C11 (\2\:net76 VSS) capacitor c=5.06282e-17
C12 (\2\:B VSS) capacitor c=4.5952e-17
C13 (\4\:net76 VSS) capacitor c=4.20944e-17
C14 (\1\:VDD VSS) capacitor c=3.54736e-17
C15 (\3\:Y VSS) capacitor c=5.03459e-17
C16 (\8\:net76 VSS) capacitor c=6.24397e-17
C17 (\1\:Y VSS) capacitor c=9.17909e-17
C18 (\4\:B VSS) capacitor c=8.18416e-17
C19 (\6\:net76 VSS) capacitor c=9.44898e-17
C20 (\7\:net76 VSS) capacitor c=2.01887e-17
C21 (\4\:AN VSS) capacitor c=5.35535e-17
C22 (\6\:AN VSS) capacitor c=4.35411e-17
C23 (\4\:VDD VSS) capacitor c=1.93464e-17
Rk7 (\4\:AN \5\:AN) resistor r=0.005473 c=0
Rk8 (AN \6\:AN) resistor r=0.005473 c=0
Rk9 (\4\:AN \6\:AN) resistor r=0.02665 c=0
Rk1 (\2\:Y Y) resistor r=0.6199 c=0
Rk2 (Y \4\:Y) resistor r=0.1582 c=0
Rk14 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.2673 c=0
Rk3 (B \4\:B) resistor r=0.07664 c=0
Rk11 (\4\:VSS VSS) resistor r=0.1509 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.4021 c=0
Rk12 (VSS \6\:VSS) resistor r=0.07697 c=0
Rk4 (\5\:net76 \6\:net76) resistor r=0.2842 c=0
Rk5 (\6\:net76 \7\:net76) resistor r=0.04832 c=0
Rk6 (\6\:net76 \9\:net76) resistor r=0.4595 c=0
Rl5 (\1\:AN \2\:AN) resistor r=53.0211 c=0
Rl6 (\2\:AN \3\:AN) resistor r=87.6365 c=0
Rl1 (\1\:B \2\:B) resistor r=92.3077 c=0
Rl2 (\2\:B \3\:B) resistor r=56.8681 c=0
Rl4 (\2\:net76 \3\:net76) resistor r=29.5379 c=0
Rl3 (net76 \2\:net76) resistor r=115.365 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (\8\:net76 \9\:net76) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry2 (\4\:net76 \5\:net76) resistor r=62 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:net76 \7\:net76) resistor r=45 c=0
mn2 (\1\:Y \3\:B \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.85e-14 ad=4.16e-14 ps=1.41e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=4.41635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn1 (\1\:Y net76 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2.36635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn0 (\8\:net76 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp0 (\4\:net76 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=28.1856 \
        scb=0.0322489 scc=0.00190885 m=(1)
ends NOR2BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:58 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2BX2
// View name: extracted

simulator lang=spectre

subckt NOR2BX2 AN B VDD VSS Y
mp1_1__rcx (4 net76 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.14872e-07 sd=160n sca=18.7282 \
        scb=0.0166129 scc=0.00128578 m=(1)
mp2_1__rcx (\1\:Y \4\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.09872e-07 sd=160n sca=17.8946 \
        scb=0.015598 scc=0.00128132 m=(1)
mp2 (\1\:Y \6\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.07e-14 \
        ad=7.41e-14 ps=1.04e-06 pd=1.16e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.74872e-07 sd=160n sca=17.569 scb=0.0152136 \
        scc=0.00128067 m=(1)
mp1 (2 \6\:net76 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=5.07e-14 ps=1.21e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2.99872e-07 sd=160n sca=18.3606 \
        scb=0.0161225 scc=0.00128307 m=(1)
C1 (Y VSS) capacitor c=7.56318e-17
C2 (AN VSS) capacitor c=7.64311e-17
C3 (VDD VSS) capacitor c=8.44279e-17
C4 (B VSS) capacitor c=6.15933e-17
C5 (net76 VSS) capacitor c=8.23528e-17
C6 (2 VSS) capacitor c=5.48783e-18
C7 (\1\:AN VSS) capacitor c=3.06501e-17
C8 (\6\:net76 VSS) capacitor c=7.01606e-17
C9 (\6\:B VSS) capacitor c=3.27845e-17
C10 (\4\:B VSS) capacitor c=8.06572e-17
C11 (\3\:AN VSS) capacitor c=4.37489e-17
C12 (\1\:B VSS) capacitor c=8.69223e-17
C13 (\2\:AN VSS) capacitor c=3.52059e-17
C14 (\3\:B VSS) capacitor c=3.68951e-17
C15 (\2\:net76 VSS) capacitor c=3.07406e-16
C16 (\7\:net76 VSS) capacitor c=3.79408e-17
C17 (\1\:VDD VSS) capacitor c=4.1309e-17
C18 (\1\:Y VSS) capacitor c=1.23403e-16
C19 (\6\:VDD VSS) capacitor c=3.97995e-17
C20 (\12\:net76 VSS) capacitor c=1.82069e-17
C21 (\3\:Y VSS) capacitor c=1.68491e-16
C22 (\7\:B VSS) capacitor c=5.77197e-17
C23 (\4\:AN VSS) capacitor c=4.3183e-17
C24 (\9\:net76 VSS) capacitor c=3.50765e-17
C25 (\4\:VDD VSS) capacitor c=3.24935e-17
C26 (\5\:VDD VSS) capacitor c=7.01673e-18
Rk3 (Y \3\:Y) resistor r=0.5321 c=0
Rk2 (\2\:Y Y) resistor r=0.6537 c=0
Rk5 (\4\:AN AN) resistor r=0.175 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.4226 c=0
Rk18 (\5\:VDD VDD) resistor r=0.1596 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.1898 c=0
Rk19 (\5\:VDD \7\:VDD) resistor r=0.2514 c=0
Rk20 (\7\:VDD \8\:VDD) resistor r=0.1454 c=0
Rk13 (\1\:VSS VSS) resistor r=0.09957 c=0
Rk14 (\1\:VSS \8\:VSS) resistor r=0.2072 c=0
Rk1 (B \7\:B) resistor r=0.224 c=0
Rk7 (\9\:net76 \2\:net76) resistor r=0.236 c=0
Rk6 (\8\:net76 \9\:net76) resistor r=0.2654 c=0
Rk9 (\9\:net76 \13\:net76) resistor r=0.1308 c=0
Rl10 (\1\:AN \2\:AN) resistor r=28.079 c=0
Rl11 (\2\:AN \3\:AN) resistor r=105.002 c=0
Rl7 (\3\:B \6\:B) resistor r=25.7292 c=0
Rl5 (\3\:B \4\:B) resistor r=115.362 c=0
Rl4 (\1\:B \3\:B) resistor r=51.2569 c=0
Rl9 (\2\:net76 \6\:net76) resistor r=103.022 c=0
Rl1 (\2\:net76 net76) resistor r=103.846 c=0
Rz5 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\13\:net76 \12\:net76) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\8\:net76 \7\:net76) resistor r=62 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx1 (\7\:B \3\:B) resistor r=45 c=0
mn2 (\3\:Y \1\:B \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.55e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=6.78365e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn1 (\3\:Y \2\:net76 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.75e-14 ad=4.55e-14 ps=8.35e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=8.98365e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn0 (\12\:net76 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.465e-14 ps=8.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp0 (\7\:net76 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=3.655e-14 ps=1.21e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.7e-07 sd=160n sca=28.664 \
        scb=0.0305236 scc=0.00251465 m=(1)
ends NOR2BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:17:59 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2BX4
// View name: extracted

simulator lang=spectre

subckt NOR2BX4 AN B VDD VSS Y
mp1_1__rcx (2 net76 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52058e-06 sd=160n sca=23.4161 \
        scb=0.0245802 scc=0.00154433 m=(1)
mp2_1__rcx (\11\:Y \5\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.36058e-06 sd=160n sca=19.4464 \
        scb=0.0177092 scc=0.0012961 m=(1)
mp2_2__rcx (\11\:Y \1\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.15558e-06 sd=160n sca=17.6679 \
        scb=0.0153903 scc=0.00128092 m=(1)
mp1_2__rcx (5 \8\:net76 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.05058e-06 sd=160n sca=17.2206 \
        scb=0.0150864 scc=0.00128061 m=(1)
mp1_3__rcx (4 \9\:net76 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=8.45577e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp2_3__rcx (\13\:Y \10\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=7.40577e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp2 (\13\:Y \12\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=8.19e-14 \
        ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.125e-06 sb=5.35577e-07 sd=160n sca=16.8346 scb=0.0149419 \
        scc=0.00128056 m=(1)
mp1 (6 \12\:net76 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=8.19e-14 ps=1.16e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2.80577e-07 sd=160n sca=17.721 \
        scb=0.0154359 scc=0.00128099 m=(1)
C1 (AN VSS) capacitor c=4.09176e-17
C2 (Y VSS) capacitor c=7.17236e-18
C3 (VDD VSS) capacitor c=1.0681e-16
C4 (B VSS) capacitor c=4.3874e-16
C5 (net76 VSS) capacitor c=5.44231e-17
C6 (2 VSS) capacitor c=4.48317e-18
C7 (5 VSS) capacitor c=1.94645e-18
C8 (4 VSS) capacitor c=1.94645e-18
C9 (6 VSS) capacitor c=3.77711e-18
C10 (\3\:AN VSS) capacitor c=3.198e-17
C11 (\12\:net76 VSS) capacitor c=6.44655e-17
C12 (\12\:B VSS) capacitor c=2.70266e-17
C13 (\10\:B VSS) capacitor c=6.1707e-17
C14 (\9\:net76 VSS) capacitor c=7.42086e-17
C15 (\8\:net76 VSS) capacitor c=6.74881e-17
C16 (\1\:B VSS) capacitor c=5.922e-17
C17 (\5\:B VSS) capacitor c=4.90423e-17
C18 (\1\:AN VSS) capacitor c=5.26487e-17
C19 (\2\:AN VSS) capacitor c=3.47803e-17
C20 (\2\:net76 VSS) capacitor c=5.50268e-16
C21 (\13\:net76 VSS) capacitor c=3.68902e-17
C22 (\1\:VDD VSS) capacitor c=3.70622e-17
C23 (\13\:Y VSS) capacitor c=8.56498e-17
C24 (\7\:VDD VSS) capacitor c=3.80887e-17
C25 (\11\:Y VSS) capacitor c=2.89097e-17
C26 (\9\:VDD VSS) capacitor c=2.52661e-17
C27 (\16\:net76 VSS) capacitor c=2.66643e-17
C28 (\1\:Y VSS) capacitor c=3.26362e-16
C29 (\7\:net76 VSS) capacitor c=3.8779e-17
C30 (\9\:Y VSS) capacitor c=6.46343e-17
C31 (\10\:Y VSS) capacitor c=9.47407e-17
C32 (\4\:AN VSS) capacitor c=6.17692e-17
C33 (\15\:net76 VSS) capacitor c=3.56085e-17
C34 (\4\:VDD VSS) capacitor c=2.49925e-17
C35 (\5\:VDD VSS) capacitor c=1.49743e-17
C36 (\6\:VDD VSS) capacitor c=1.22083e-17
Rk11 (\4\:AN AN) resistor r=0.2087 c=0
Rk7 (\9\:Y Y) resistor r=0.003666 c=0
Rk6 (\1\:Y \9\:Y) resistor r=0.4045 c=0
Rk8 (\9\:Y \10\:Y) resistor r=0.4753 c=0
Rk9 (\10\:Y \12\:Y) resistor r=0.08564 c=0
Rk10 (\10\:Y \14\:Y) resistor r=0.5644 c=0
Rk26 (\2\:VDD \4\:VDD) resistor r=0.527 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.1126 c=0
Rk29 (\6\:VDD VDD) resistor r=0.04967 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.3379 c=0
Rk30 (\5\:VDD \8\:VDD) resistor r=0.2525 c=0
Rk31 (\6\:VDD \10\:VDD) resistor r=0.2525 c=0
Rk14 (\15\:net76 \2\:net76) resistor r=0.2148 c=0
Rk12 (\14\:net76 \15\:net76) resistor r=0.2592 c=0
Rk13 (\15\:net76 \17\:net76) resistor r=0.1285 c=0
Rl21 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rl20 (\1\:AN \2\:AN) resistor r=112.26 c=0
Rl17 (B \12\:B) resistor r=49.5541 c=0
Rl15 (B \10\:B) resistor r=52.4625 c=0
Rl3 (B \1\:B) resistor r=30.5643 c=0
Rl6 (B \5\:B) resistor r=82.6695 c=0
Rl19 (\2\:net76 \12\:net76) resistor r=94.0258 c=0
Rl1 (\2\:net76 net76) resistor r=97.3098 c=0
Rl12 (\7\:net76 \9\:net76) resistor r=117.766 c=0
Rl11 (\7\:net76 \8\:net76) resistor r=94.6893 c=0
Rl10 (\7\:net76 \2\:net76) resistor r=4.0691 c=0
Rz5 (\17\:net76 \16\:net76) resistor r=75 c=0
Ry1 (\12\:Y \11\:Y) resistor r=20.6667 c=0
Ry2 (\14\:Y \13\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry3 (\14\:net76 \13\:net76) resistor r=62 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (\1\:Y \2\:net76 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.858e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67163e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(4)
mn2_1__rcx (\1\:Y B VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.46663e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(4)
mn0 (\16\:net76 \1\:AN VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp0 (\13\:net76 \3\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.615e-06 sb=1.6e-07 sd=160n sca=25.3293 \
        scb=0.0247188 scc=0.0022828 m=(1)
ends NOR2BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:00 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2BXL
// View name: extracted

simulator lang=spectre

subckt NOR2BXL AN B VDD VSS Y
mp2 (\3\:Y \1\:B net59 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=16.4797 \
        scb=0.0152074 scc=0.000231472 m=(1)
mp1 (net59 \4\:net76 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=15.2571 \
        scb=0.0126505 scc=0.000156674 m=(1)
mp0 (\5\:net76 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=17.3518 \
        scb=0.0169054 scc=0.000309574 m=(1)
C1 (AN VSS) capacitor c=6.93215e-17
C2 (VDD VSS) capacitor c=1.08298e-16
C3 (B VSS) capacitor c=8.48092e-17
C4 (Y VSS) capacitor c=8.07788e-17
C5 (net76 VSS) capacitor c=2.19138e-17
C6 (\1\:AN VSS) capacitor c=4.13467e-17
C7 (\4\:net76 VSS) capacitor c=9.95998e-17
C8 (\1\:B VSS) capacitor c=7.56791e-17
C9 (\4\:AN VSS) capacitor c=4.90859e-17
C10 (\3\:net76 VSS) capacitor c=3.28222e-17
C11 (\3\:B VSS) capacitor c=3.65758e-17
C12 (\3\:AN VSS) capacitor c=2.28055e-17
C13 (\2\:B VSS) capacitor c=6.84407e-17
C14 (\5\:net76 VSS) capacitor c=5.38384e-17
C15 (\1\:VDD VSS) capacitor c=2.84147e-17
C16 (\3\:Y VSS) capacitor c=2.7097e-17
C17 (\9\:net76 VSS) capacitor c=2.52391e-17
C18 (\1\:Y VSS) capacitor c=1.21188e-16
C19 (\2\:net76 VSS) capacitor c=7.35498e-17
C20 (\2\:AN VSS) capacitor c=4.22525e-17
C21 (\4\:B VSS) capacitor c=3.75608e-17
C22 (\5\:AN VSS) capacitor c=4.69078e-17
C23 (\7\:net76 VSS) capacitor c=5.16359e-17
C24 (\8\:net76 VSS) capacitor c=4.20844e-17
C25 (\4\:VDD VSS) capacitor c=2.12018e-17
Rk4 (\5\:AN AN) resistor r=0.1908 c=0
Rk9 (\4\:VDD VDD) resistor r=0.2002 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.2886 c=0
Rk1 (B \4\:B) resistor r=0.09278 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.2363 c=0
Rk12 (\5\:VSS VSS) resistor r=0.02962 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.1702 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.1954 c=0
Rk2 (\2\:Y Y) resistor r=0.8073 c=0
Rk3 (Y \4\:Y) resistor r=0.1143 c=0
Rk5 (\6\:net76 \7\:net76) resistor r=0.4575 c=0
Rk6 (\7\:net76 \8\:net76) resistor r=0.1556 c=0
Rk7 (\7\:net76 \10\:net76) resistor r=0.1626 c=0
Rl6 (\1\:AN \2\:AN) resistor r=138.176 c=0
Rl8 (\2\:AN \4\:AN) resistor r=138.176 c=0
Rl7 (\2\:AN \3\:AN) resistor r=1.2666 c=0
Rl1 (\1\:B \2\:B) resistor r=161.516 c=0
Rl2 (\2\:B \3\:B) resistor r=95.9489 c=0
Rl5 (\2\:net76 \4\:net76) resistor r=227.726 c=0
Rl4 (\2\:net76 \3\:net76) resistor r=46.9565 c=0
Rl3 (net76 \2\:net76) resistor r=1.2334 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\9\:net76 \10\:net76) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:net76 \6\:net76) resistor r=62 c=0
Rx2 (\3\:AN \5\:AN) resistor r=45 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (net76 \8\:net76) resistor r=45 c=0
mn2 (\1\:Y \3\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (\1\:Y \3\:net76 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\9\:net76 \4\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
ends NOR2BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:00 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2X1
// View name: extracted

simulator lang=spectre

subckt NOR2X1 A B VDD VSS Y
mp0 (net41 \1\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3e-07 sd=160n sca=47.9961 scb=0.0439169 \
        scc=0.00481722 m=(1)
mp1 (\1\:Y \3\:B net41 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.605e-14 ps=9e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.95e-07 sd=160n sca=44.1 scb=0.0398973 \
        scc=0.00391616 m=(1)
C1 (A VSS) capacitor c=6.64294e-17
C2 (VDD VSS) capacitor c=4.10609e-17
C3 (Y VSS) capacitor c=3.8922e-17
C4 (B VSS) capacitor c=5.76317e-17
C5 (net41 VSS) capacitor c=1.01113e-18
C6 (\3\:B VSS) capacitor c=6.41479e-17
C7 (\1\:A VSS) capacitor c=6.44359e-17
C8 (\1\:B VSS) capacitor c=3.39562e-17
C9 (\4\:A VSS) capacitor c=3.25501e-17
C10 (\2\:B VSS) capacitor c=3.50524e-17
C11 (\3\:A VSS) capacitor c=1.24498e-17
C12 (\1\:Y VSS) capacitor c=7.46817e-17
C13 (\3\:VDD VSS) capacitor c=5.49787e-17
C14 (\3\:Y VSS) capacitor c=5.1272e-17
C15 (\2\:A VSS) capacitor c=2.63394e-17
C16 (\4\:B VSS) capacitor c=6.30393e-17
Rk1 (\5\:A A) resistor r=0.01003 c=0
Rk9 (VDD \4\:VDD) resistor r=0.3954 c=0
Rk3 (\2\:Y Y) resistor r=0.2872 c=0
Rk4 (Y \4\:Y) resistor r=0.2283 c=0
Rk6 (\4\:VSS VSS) resistor r=0.1004 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.1357 c=0
Rk7 (VSS \6\:VSS) resistor r=0.3123 c=0
Rk2 (\4\:B B) resistor r=0.1667 c=0
Rl1 (\1\:A \2\:A) resistor r=37.3411 c=0
Rl3 (\2\:A \4\:A) resistor r=64.2642 c=0
Rl2 (\2\:A \3\:A) resistor r=3.7301 c=0
Rl5 (\2\:B \3\:B) resistor r=28.079 c=0
Rl4 (\1\:B \2\:B) resistor r=72.7926 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Ry3 (\3\:VDD \4\:VDD) resistor r=20.6667 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (\3\:Y \4\:A \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.15e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn1 (\3\:Y \1\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.1e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
ends NOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:01 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2X2
// View name: extracted

simulator lang=spectre

subckt NOR2X2 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=20.7977 \
        scb=0.0219422 scc=0.000863938 m=(1)
mp1_1__rcx (\6\:Y \6\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.5e-07 sd=160n sca=18.3517 \
        scb=0.0171974 scc=0.00064315 m=(1)
mp1 (\6\:Y \1\:B 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=2.45e-07 sd=160n sca=18.6339 scb=0.0177874 scc=0.000660551 \
        m=(1)
mp0 (3 \6\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=21.6313 \
        scb=0.0233702 scc=0.000971691 m=(1)
C1 (A VSS) capacitor c=3.65644e-17
C2 (VDD VSS) capacitor c=6.8784e-17
C3 (B VSS) capacitor c=6.23833e-17
C4 (Y VSS) capacitor c=7.89104e-17
C5 (2 VSS) capacitor c=9.37954e-19
C6 (3 VSS) capacitor c=3.74697e-18
C7 (\6\:A VSS) capacitor c=7.25006e-17
C8 (\1\:B VSS) capacitor c=6.20797e-17
C9 (\6\:B VSS) capacitor c=5.66349e-17
C10 (\1\:A VSS) capacitor c=7.41277e-17
C11 (\2\:A VSS) capacitor c=3.26206e-16
C12 (\1\:VDD VSS) capacitor c=5.58315e-17
C13 (\6\:Y VSS) capacitor c=1.39889e-16
C14 (\6\:VDD VSS) capacitor c=4.41599e-17
C15 (\1\:Y VSS) capacitor c=1.81136e-16
C16 (\2\:B VSS) capacitor c=1.38445e-16
C17 (\7\:B VSS) capacitor c=3.55348e-17
C18 (\4\:VDD VSS) capacitor c=2.56489e-17
C19 (\5\:VDD VSS) capacitor c=5.24929e-18
Rk3 (\2\:A A) resistor r=0.1014 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.465 c=0
Rk14 (\5\:VDD VDD) resistor r=0.04977 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.1504 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.3144 c=0
Rk10 (VSS \6\:VSS) resistor r=0.3274 c=0
Rk1 (\7\:B B) resistor r=0.05499 c=0
Rk6 (\1\:Y Y) resistor r=0.09399 c=0
Rk7 (Y \7\:Y) resistor r=0.7537 c=0
Rl9 (\2\:A \6\:A) resistor r=72.5275 c=0
Rl1 (\2\:A \1\:A) resistor r=75.1972 c=0
Rl3 (\2\:B \1\:B) resistor r=47.3105 c=0
Rl7 (\2\:B \6\:B) resistor r=24.2328 c=0
Rz4 (\6\:VSS \5\:VSS) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=20.6667 c=0
Ry1 (\7\:Y \6\:Y) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\1\:Y \2\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.265e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn1 (\1\:Y \2\:B \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.1e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
ends NOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:03 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2X4
// View name: extracted

simulator lang=spectre

subckt NOR2X4 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.275e-06 sd=160n sca=17.191 \
        scb=0.0171908 scc=0.000536617 m=(1)
mp1_1__rcx (\9\:Y \5\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.17e-06 sd=160n sca=15.1734 \
        scb=0.013698 scc=0.000458097 m=(1)
mp1_2__rcx (\9\:Y \1\:B 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.65e-07 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_2__rcx (3 \10\:A \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=8.6e-07 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp0_3__rcx (6 \4\:A \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.095e-14 ps=1.1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.55e-07 sd=160n sca=12.8726 \
        scb=0.0111206 scc=0.000443921 m=(1)
mp1_3__rcx (\15\:Y \10\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=5.05e-07 sd=160n sca=13.4643 \
        scb=0.0114911 scc=0.000444259 m=(1)
mp1 (\15\:Y \12\:B 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=3e-07 sd=160n sca=15.2428 scb=0.01381 \
        scc=0.000459441 m=(1)
mp0 (7 \13\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.4e-07 sd=160n sca=19.2125 \
        scb=0.0206809 scc=0.000707669 m=(1)
C1 (B VSS) capacitor c=4.93373e-16
C2 (VDD VSS) capacitor c=1.11449e-16
C3 (A VSS) capacitor c=6.82108e-16
C4 (Y VSS) capacitor c=7.73261e-17
C5 (3 VSS) capacitor c=1.85973e-18
C6 (6 VSS) capacitor c=3.10844e-18
C7 (7 VSS) capacitor c=4.10496e-18
C8 (\13\:A VSS) capacitor c=5.03832e-17
C9 (\12\:B VSS) capacitor c=3.9746e-17
C10 (\10\:B VSS) capacitor c=4.01408e-17
C11 (\4\:A VSS) capacitor c=4.59148e-17
C12 (\10\:A VSS) capacitor c=6.65597e-17
C13 (\1\:B VSS) capacitor c=5.91799e-17
C14 (\5\:B VSS) capacitor c=7.34376e-17
C15 (\1\:A VSS) capacitor c=7.86499e-17
C16 (\1\:VDD VSS) capacitor c=5.65791e-17
C17 (\15\:Y VSS) capacitor c=3.60566e-17
C18 (\5\:VDD VSS) capacitor c=5.30514e-17
C19 (\9\:Y VSS) capacitor c=1.08677e-16
C20 (\8\:VDD VSS) capacitor c=3.98543e-17
C21 (\1\:Y VSS) capacitor c=5.0529e-16
C22 (\8\:Y VSS) capacitor c=1.40404e-16
C23 (\4\:VDD VSS) capacitor c=3.84244e-17
C24 (\7\:VDD VSS) capacitor c=1.42271e-17
Rk24 (\2\:VDD \4\:VDD) resistor r=0.641 c=0
Rk25 (\4\:VDD \6\:VDD) resistor r=0.2957 c=0
Rk28 (\7\:VDD VDD) resistor r=0.07986 c=0
Rk26 (\4\:VDD \7\:VDD) resistor r=0.3215 c=0
Rk27 (\7\:VDD \9\:VDD) resistor r=0.2895 c=0
Rk10 (\1\:Y Y) resistor r=0.3389 c=0
Rk11 (Y \8\:Y) resistor r=0.3891 c=0
Rk12 (\8\:Y \10\:Y) resistor r=0.5878 c=0
Rk15 (\8\:Y \16\:Y) resistor r=0.09058 c=0
Rl18 (B \12\:B) resistor r=43.4713 c=0
Rl16 (B \10\:B) resistor r=37.3423 c=0
Rl3 (B \1\:B) resistor r=34.766 c=0
Rl6 (B \5\:B) resistor r=57.3425 c=0
Rl20 (A \13\:A) resistor r=72.2527 c=0
Rl8 (A \4\:A) resistor r=77.7258 c=0
Rl13 (A \10\:A) resistor r=77.7258 c=0
Rl1 (A \1\:A) resistor r=100.988 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry1 (\10\:Y \9\:Y) resistor r=20.6667 c=0
Ry2 (\16\:Y \15\:Y) resistor r=20.6667 c=0
mn0_1__rcx (\1\:Y A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.223e-14 ad=4.16e-14 ps=9.85e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.575e-06 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(4)
mn1_1__rcx (\1\:Y B VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.37e-06 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(4)
ends NOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:04 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2X6
// View name: extracted

simulator lang=spectre

subckt NOR2X6 A B VDD VSS Y
mp0_1__rcx (1 \1\:A \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82e-06 sd=160n sca=17.8302 \
        scb=0.0172414 scc=0.000800052 m=(1)
mp1_1__rcx (\16\:Y \5\:B 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.715e-06 sd=160n sca=16.2541 \
        scb=0.014643 scc=0.000761282 m=(1)
mp1_2__rcx (\16\:Y \1\:B 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.51e-06 sd=160n sca=14.8213 \
        scb=0.0130288 scc=0.000754571 m=(1)
mp0_2__rcx (3 \10\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.405e-06 sd=160n sca=14.4437 \
        scb=0.0128219 scc=0.000754437 m=(1)
mp0_3__rcx (2 \4\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.2e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp1_3__rcx (\19\:Y \11\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.095e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp1_4__rcx (\19\:Y \12\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=8.9e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp0_4__rcx (5 \14\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=2.34e-14 ps=1.11e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=7.85e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp0_5__rcx (4 \16\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=2.34e-14 ps=1.11e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=5.75e-07 sd=160n sca=14.6601 \
        scb=0.0129275 scc=0.000754489 m=(1)
mp1_5__rcx (\21\:Y \16\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=4.7e-07 sd=160n sca=15.1439 \
        scb=0.0132876 scc=0.000754937 m=(1)
mp1 (\21\:Y \17\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.695e-06 sb=2.65e-07 sd=160n sca=17.1124 scb=0.0160045 \
        scc=0.000776708 m=(1)
mp0 (6 \17\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.6e-07 sd=160n sca=19.4933 \
        scb=0.0201815 scc=0.000898164 m=(1)
C1 (A VSS) capacitor c=8.51181e-16
C2 (VDD VSS) capacitor c=1.25246e-16
C3 (Y VSS) capacitor c=6.9023e-17
C4 (B VSS) capacitor c=7.95114e-16
C5 (1 VSS) capacitor c=1.86356e-18
C6 (3 VSS) capacitor c=1.9638e-18
C7 (2 VSS) capacitor c=1.85414e-18
C8 (5 VSS) capacitor c=1.94196e-18
C9 (4 VSS) capacitor c=1.9638e-18
C10 (\17\:A VSS) capacitor c=6.80891e-17
C11 (\17\:B VSS) capacitor c=6.03974e-17
C12 (\16\:B VSS) capacitor c=6.13717e-17
C13 (\16\:A VSS) capacitor c=6.80376e-17
C14 (\14\:A VSS) capacitor c=7.21656e-17
C15 (\12\:B VSS) capacitor c=6.39555e-17
C16 (\11\:B VSS) capacitor c=6.08068e-17
C17 (\4\:A VSS) capacitor c=6.75586e-17
C18 (\10\:A VSS) capacitor c=6.7827e-17
C19 (\1\:B VSS) capacitor c=6.08603e-17
C20 (\5\:B VSS) capacitor c=6.50813e-17
C21 (\1\:A VSS) capacitor c=7.88815e-17
C22 (\18\:A VSS) capacitor c=4.69218e-17
C23 (\1\:VDD VSS) capacitor c=4.07459e-17
C24 (\21\:Y VSS) capacitor c=3.78579e-17
C25 (\8\:VDD VSS) capacitor c=5.03718e-17
C26 (\19\:Y VSS) capacitor c=3.7669e-17
C27 (\10\:VDD VSS) capacitor c=5.04332e-17
C28 (\16\:Y VSS) capacitor c=3.76738e-17
C29 (\12\:VDD VSS) capacitor c=5.45605e-17
C30 (\1\:Y VSS) capacitor c=7.11587e-16
C31 (\15\:Y VSS) capacitor c=1.52051e-16
C32 (\18\:Y VSS) capacitor c=9.74832e-17
C33 (\19\:A VSS) capacitor c=7.29988e-17
C34 (\3\:VDD VSS) capacitor c=2.72667e-17
C35 (\5\:VDD VSS) capacitor c=1.64115e-17
C36 (\6\:VDD VSS) capacitor c=1.76592e-17
C37 (\7\:VDD VSS) capacitor c=1.34244e-17
Rk18 (\19\:A A) resistor r=0.5677 c=0
Rk22 (\2\:VDD \3\:VDD) resistor r=0.6282 c=0
Rk23 (\3\:VDD \5\:VDD) resistor r=0.173 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.1404 c=0
Rk26 (\7\:VDD VDD) resistor r=0.09995 c=0
Rk25 (\6\:VDD \7\:VDD) resistor r=0.3108 c=0
Rk27 (\3\:VDD \9\:VDD) resistor r=0.2731 c=0
Rk28 (\6\:VDD \11\:VDD) resistor r=0.2731 c=0
Rk29 (\7\:VDD \13\:VDD) resistor r=0.3135 c=0
Rk12 (\1\:Y \15\:Y) resistor r=0.8098 c=0
Rk13 (\15\:Y \17\:Y) resistor r=0.09073 c=0
Rk16 (\18\:Y Y) resistor r=0.4478 c=0
Rk14 (\15\:Y \18\:Y) resistor r=0.46 c=0
Rk15 (\18\:Y \20\:Y) resistor r=0.09073 c=0
Rk17 (Y \22\:Y) resistor r=0.1144 c=0
Rl23 (A \16\:A) resistor r=93.9956 c=0
Rl21 (A \14\:A) resistor r=109.535 c=0
Rl8 (A \4\:A) resistor r=89.2642 c=0
Rl13 (A \10\:A) resistor r=89.2642 c=0
Rl1 (A \1\:A) resistor r=107.281 c=0
Rl28 (\18\:A \17\:A) resistor r=51.098 c=0
Rl27 (B \17\:B) resistor r=45.1626 c=0
Rl26 (B \16\:B) resistor r=48.0781 c=0
Rl18 (B \12\:B) resistor r=52.5659 c=0
Rl17 (B \11\:B) resistor r=46.2322 c=0
Rl3 (B \1\:B) resistor r=45.369 c=0
Rl6 (B \5\:B) resistor r=52.5659 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry5 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry6 (\10\:VDD \11\:VDD) resistor r=31 c=0
Ry7 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry1 (\17\:Y \16\:Y) resistor r=20.6667 c=0
Ry2 (\20\:Y \19\:Y) resistor r=20.6667 c=0
Ry3 (\22\:Y \21\:Y) resistor r=20.6667 c=0
Rx4 (\19\:A \18\:A) resistor r=45 c=0
mn0_1__rcx (\1\:Y A VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.898e-14 ad=4.96e-14 ps=9.36e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.8347 scb=0.0112322 \
        scc=0.000626052 m=(5)
mn1_1__rcx (\1\:Y B VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.805e-06 sd=160n sca=11.8347 \
        scb=0.0112322 scc=0.000626052 m=(5)
ends NOR2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:05 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2X8
// View name: extracted

simulator lang=spectre

subckt NOR2X8 A B VDD VSS Y
mp0_1__rcx (1 \1\:A \14\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=2.67e-14 ps=1.17e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.537 scb=0.0176846 \
        scc=0.000953219 m=(1)
mp1_1__rcx (\23\:Y \5\:B 1 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.9609 scb=0.0150862 \
        scc=0.00091445 m=(1)
mp1_2__rcx (\23\:Y \1\:B 3 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.8e-06 sd=160n sca=15.5281 scb=0.013472 \
        scc=0.000907738 m=(1)
mp0_2__rcx (3 \10\:A \12\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.695e-06 sd=160n sca=15.1505 \
        scb=0.0132652 scc=0.000907605 m=(1)
mp0_3__rcx (2 \4\:A \12\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.49e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_3__rcx (\26\:Y \11\:B 2 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.385e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_4__rcx (\26\:Y \12\:B 5 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.18e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_4__rcx (5 \14\:A \10\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.075e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_5__rcx (4 \16\:A \10\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=8.65e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_5__rcx (\29\:Y \17\:B 4 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=7.6e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_6__rcx (\29\:Y \19\:B 7 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=5.55e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_6__rcx (7 \22\:A \8\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=4.5e-07 sd=160n sca=14.8079 scb=0.013166 \
        scc=0.000907585 m=(1)
mp0 (6 \23\:A \8\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=14.8666 scb=0.0131776 \
        scc=0.000907586 m=(1)
mp1 (\32\:Y \22\:B 6 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=6.23e-14 ps=1.01e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.1213 scb=0.0132536 \
        scc=0.000907601 m=(1)
C1 (A VSS) capacitor c=1.19346e-15
C2 (Y VSS) capacitor c=3.85999e-17
C3 (VDD VSS) capacitor c=1.7069e-16
C4 (B VSS) capacitor c=1.06606e-15
C5 (1 VSS) capacitor c=3.0278e-18
C6 (3 VSS) capacitor c=2.01655e-18
C7 (2 VSS) capacitor c=1.85065e-18
C8 (5 VSS) capacitor c=1.99569e-18
C9 (4 VSS) capacitor c=2.01655e-18
C10 (7 VSS) capacitor c=2.0385e-18
C11 (6 VSS) capacitor c=1.99569e-18
C12 (\22\:B VSS) capacitor c=9.72652e-17
C13 (\23\:A VSS) capacitor c=7.21774e-17
C14 (\22\:A VSS) capacitor c=8.30955e-17
C15 (\19\:B VSS) capacitor c=6.35596e-17
C16 (\17\:B VSS) capacitor c=6.46389e-17
C17 (\16\:A VSS) capacitor c=7.22305e-17
C18 (\14\:A VSS) capacitor c=7.56934e-17
C19 (\12\:B VSS) capacitor c=8.10176e-17
C20 (\11\:B VSS) capacitor c=6.40398e-17
C21 (\4\:A VSS) capacitor c=7.13019e-17
C22 (\10\:A VSS) capacitor c=7.17956e-17
C23 (\1\:B VSS) capacitor c=6.45287e-17
C24 (\5\:B VSS) capacitor c=8.2028e-17
C25 (\1\:A VSS) capacitor c=8.33517e-17
C26 (\32\:Y VSS) capacitor c=2.46804e-17
C27 (\8\:VDD VSS) capacitor c=5.02352e-17
C28 (\29\:Y VSS) capacitor c=3.85786e-17
C29 (\10\:VDD VSS) capacitor c=4.99871e-17
C30 (\26\:Y VSS) capacitor c=3.84964e-17
C31 (\12\:VDD VSS) capacitor c=4.99457e-17
C32 (\23\:Y VSS) capacitor c=3.84946e-17
C33 (\14\:VDD VSS) capacitor c=4.73703e-17
C34 (\1\:VDD VSS) capacitor c=4.68692e-17
C35 (\1\:Y VSS) capacitor c=9.76543e-16
C36 (\21\:A VSS) capacitor c=5.47377e-17
C37 (\34\:Y VSS) capacitor c=4.81011e-17
C38 (\22\:Y VSS) capacitor c=1.49389e-16
C39 (\25\:Y VSS) capacitor c=8.54477e-17
C40 (\28\:Y VSS) capacitor c=8.56036e-17
C41 (\31\:Y VSS) capacitor c=7.27861e-17
C42 (\3\:VDD VSS) capacitor c=2.07454e-17
C43 (\4\:VDD VSS) capacitor c=2.05973e-17
C44 (\6\:VDD VSS) capacitor c=1.96154e-17
C45 (\7\:VDD VSS) capacitor c=1.48164e-17
Rk31 (Y \34\:Y) resistor r=0.3651 c=0
Rk32 (\34\:Y \1\:Y) resistor r=0.07606 c=0
Rk22 (\1\:Y \22\:Y) resistor r=0.8362 c=0
Rk23 (\22\:Y \24\:Y) resistor r=0.09088 c=0
Rk24 (\22\:Y \25\:Y) resistor r=0.4605 c=0
Rk25 (\25\:Y \27\:Y) resistor r=0.09088 c=0
Rk26 (\25\:Y \28\:Y) resistor r=0.4641 c=0
Rk27 (\28\:Y \30\:Y) resistor r=0.08751 c=0
Rk30 (\31\:Y Y) resistor r=0.3427 c=0
Rk28 (\28\:Y \31\:Y) resistor r=0.4605 c=0
Rk29 (\31\:Y \33\:Y) resistor r=0.08751 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.3186 c=0
Rk50 (\3\:VDD \4\:VDD) resistor r=0.3109 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.173 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.1404 c=0
Rk54 (\7\:VDD VDD) resistor r=0.09997 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.3109 c=0
Rk55 (\3\:VDD \9\:VDD) resistor r=0.2499 c=0
Rk56 (\4\:VDD \11\:VDD) resistor r=0.2499 c=0
Rk57 (\6\:VDD \13\:VDD) resistor r=0.2499 c=0
Rk58 (\7\:VDD \15\:VDD) resistor r=0.2903 c=0
Rl23 (A \16\:A) resistor r=86.3033 c=0
Rl21 (A \14\:A) resistor r=101.842 c=0
Rl8 (A \4\:A) resistor r=81.5719 c=0
Rl13 (A \10\:A) resistor r=81.5719 c=0
Rl1 (A \1\:A) resistor r=99.5886 c=0
Rl33 (\21\:A A) resistor r=41.0733 c=0
Rl35 (\21\:A \23\:A) resistor r=65.6027 c=0
Rl34 (\21\:A \22\:A) resistor r=132.813 c=0
Rl37 (B \22\:B) resistor r=113.107 c=0
Rl29 (B \19\:B) resistor r=37.4703 c=0
Rl27 (B \17\:B) resistor r=40.3857 c=0
Rl18 (B \12\:B) resistor r=44.8736 c=0
Rl17 (B \11\:B) resistor r=38.5399 c=0
Rl3 (B \1\:B) resistor r=37.6767 c=0
Rl6 (B \5\:B) resistor r=44.8736 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz17 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Ry1 (\24\:Y \23\:Y) resistor r=20.6667 c=0
Ry2 (\27\:Y \26\:Y) resistor r=20.6667 c=0
Ry3 (\30\:Y \29\:Y) resistor r=20.6667 c=0
Ry4 (\33\:Y \32\:Y) resistor r=20.6667 c=0
Ry7 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry8 (\10\:VDD \11\:VDD) resistor r=31 c=0
Ry9 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry10 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
mn0_1__rcx (\1\:Y A VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.678e-14 ad=4.72e-14 ps=9.0714e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
mn1_1__rcx (\1\:Y B VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
ends NOR2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:06 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR2XL
// View name: extracted

simulator lang=spectre

subckt NOR2XL A B VDD VSS Y
mp0 (net41 \1\:A \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=29.8819 \
        scb=0.0359119 scc=0.00165852 m=(1)
mp1 (\1\:Y \3\:B net41 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=30.7015 \
        scb=0.0368156 scc=0.00184473 m=(1)
C1 (A VSS) capacitor c=6.27419e-17
C2 (VDD VSS) capacitor c=4.8689e-17
C3 (B VSS) capacitor c=1.37603e-17
C4 (\3\:B VSS) capacitor c=5.582e-17
C5 (\1\:A VSS) capacitor c=7.2094e-17
C6 (\1\:B VSS) capacitor c=2.54707e-17
C7 (\4\:A VSS) capacitor c=2.36966e-17
C8 (\2\:B VSS) capacitor c=3.49375e-17
C9 (\3\:A VSS) capacitor c=1.16867e-17
C10 (\1\:Y VSS) capacitor c=5.96858e-17
C11 (\4\:VDD VSS) capacitor c=2.06701e-17
C12 (\3\:Y VSS) capacitor c=7.95481e-17
C13 (\2\:A VSS) capacitor c=2.44568e-17
C14 (\4\:B VSS) capacitor c=6.78888e-17
C15 (\3\:VDD VSS) capacitor c=1.20799e-17
Rk1 (\5\:A A) resistor r=0.01612 c=0
Rk3 (Y \2\:Y) resistor r=0.003074 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.4895 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.2445 c=0
Rk7 (\5\:VSS VSS) resistor r=0.01703 c=0
Rk6 (\4\:VSS \5\:VSS) resistor r=0.08218 c=0
Rk8 (\5\:VSS \7\:VSS) resistor r=0.1617 c=0
Rk10 (\3\:VDD VDD) resistor r=0.02701 c=0
Rk11 (\3\:VDD \5\:VDD) resistor r=0.3297 c=0
Rk2 (\4\:B B) resistor r=0.07915 c=0
Rl1 (\1\:A \2\:A) resistor r=106.972 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl5 (\2\:B \3\:B) resistor r=72.8068 c=0
Rl4 (\1\:B \2\:B) resistor r=41.6242 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (\3\:Y \4\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.36e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn1 (\3\:Y \1\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.36e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
ends NOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:08 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3BX1
// View name: extracted

simulator lang=spectre

subckt NOR3BX1 AN B C VDD VSS Y
mp3 (\6\:Y \1\:C net90 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.84167e-07 sd=160n sca=25.1103 \
        scb=0.022702 scc=0.00204888 m=(1)
mp2 (net90 \3\:B net86 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.79167e-07 sd=160n sca=23.6464 \
        scb=0.01977 scc=0.00198868 m=(1)
mp1 (net86 \3\:net91 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.485e-14 ps=1.16e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.19167e-07 sd=160n sca=23.2415 \
        scb=0.0189596 scc=0.00198104 m=(1)
C1 (Y VSS) capacitor c=7.57623e-17
C2 (C VSS) capacitor c=4.43569e-17
C3 (AN VSS) capacitor c=7.22202e-17
C4 (VDD VSS) capacitor c=7.19522e-17
C5 (B VSS) capacitor c=5.46213e-17
C6 (net91 VSS) capacitor c=4.82023e-17
C7 (net86 VSS) capacitor c=1.7867e-18
C8 (\3\:AN VSS) capacitor c=3.32825e-17
C9 (\3\:net91 VSS) capacitor c=6.53998e-17
C10 (\3\:B VSS) capacitor c=9.81056e-17
C11 (\1\:C VSS) capacitor c=7.67428e-17
C12 (\1\:AN VSS) capacitor c=4.89238e-17
C13 (\1\:B VSS) capacitor c=4.04319e-17
C14 (\4\:C VSS) capacitor c=4.29401e-17
C15 (\2\:AN VSS) capacitor c=4.41686e-17
C16 (\2\:net91 VSS) capacitor c=5.45306e-17
C17 (\2\:B VSS) capacitor c=6.02049e-17
C18 (\3\:C VSS) capacitor c=4.78852e-17
C19 (\4\:net91 VSS) capacitor c=3.29109e-17
C20 (\1\:VDD VSS) capacitor c=4.90364e-17
C21 (\6\:Y VSS) capacitor c=5.55134e-17
C22 (\8\:net91 VSS) capacitor c=2.89126e-17
C23 (\1\:Y VSS) capacitor c=7.20705e-17
C24 (\4\:Y VSS) capacitor c=3.49536e-17
C25 (\7\:C VSS) capacitor c=7.12723e-17
C26 (\4\:B VSS) capacitor c=6.74597e-17
C27 (\3\:Y VSS) capacitor c=4.25413e-17
C28 (\6\:net91 VSS) capacitor c=4.86723e-17
C29 (\7\:net91 VSS) capacitor c=5.38442e-17
C30 (\4\:VDD VSS) capacitor c=2.4219e-17
Rk6 (\3\:Y Y) resistor r=0.1445 c=0
Rk5 (\2\:Y \3\:Y) resistor r=0.3587 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.03868 c=0
Rk8 (Y \7\:Y) resistor r=0.3946 c=0
Rk1 (\5\:C C) resistor r=0.001113 c=0
Rk3 (\5\:C \7\:C) resistor r=0.0315 c=0
Rk2 (\6\:C \7\:C) resistor r=0.001011 c=0
Rk9 (\4\:AN AN) resistor r=0.03051 c=0
Rk18 (\4\:VDD VDD) resistor r=0.2503 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4258 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3149 c=0
Rk15 (\5\:VSS VSS) resistor r=0.1775 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.07247 c=0
Rk16 (\5\:VSS \7\:VSS) resistor r=0.1812 c=0
Rk4 (B \4\:B) resistor r=0.2604 c=0
Rk10 (\5\:net91 \6\:net91) resistor r=0.2618 c=0
Rk11 (\6\:net91 \7\:net91) resistor r=0.2325 c=0
Rk12 (\6\:net91 \9\:net91) resistor r=0.229 c=0
Rl1 (\1\:C \2\:C) resistor r=91.8973 c=0
Rl3 (\2\:C \4\:C) resistor r=75.5064 c=0
Rl2 (\2\:C \3\:C) resistor r=2.257 c=0
Rl9 (\2\:AN \3\:AN) resistor r=39.8352 c=0
Rl8 (\1\:AN \2\:AN) resistor r=155.966 c=0
Rl5 (\2\:B \3\:B) resistor r=114.56 c=0
Rl4 (\1\:B \2\:B) resistor r=34.6154 c=0
Rl7 (\2\:net91 \3\:net91) resistor r=106.296 c=0
Rl6 (net91 \2\:net91) resistor r=46.1538 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\8\:net91 \9\:net91) resistor r=75 c=0
Ry1 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry2 (\4\:net91 \5\:net91) resistor r=62 c=0
Rx1 (\3\:C \6\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:net91 \7\:net91) resistor r=45 c=0
mn3 (\4\:Y \4\:C \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.46635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \1\:B \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.41635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\1\:Y net91 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.36635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\8\:net91 \1\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp0 (\4\:net91 \3\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.945e-14 ps=1.16e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.3e-07 sd=160n sca=34.5374 \
        scb=0.0325399 scc=0.0036632 m=(1)
ends NOR3BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:09 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3BX2
// View name: extracted

simulator lang=spectre

subckt NOR3BX2 AN B C VDD VSS Y
mp1_1__rcx (5 net91 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23109e-06 sd=160n sca=24.5401 \
        scb=0.0199717 scc=0.00228059 m=(1)
mp2_1__rcx (5 \1\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.12609e-06 sd=160n sca=23.5984 \
        scb=0.0187307 scc=0.00227355 m=(1)
mp3_1__rcx (\7\:Y \4\:C 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=8.19e-14 ps=1.01e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.6609e-07 sd=160n sca=22.7967 \
        scb=0.0180682 scc=0.00227241 m=(1)
mp3 (\7\:Y \6\:C 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=1.0725e-13 \
        ad=8.19e-14 ps=1.33e-06 pd=1.2e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.6e-07 sb=7.1109e-07 sd=160n sca=22.2743 scb=0.0178838 \
        scc=0.00227235 m=(1)
mp2 (7 \4\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.0725e-13 ps=9e-07 pd=1.33e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.8e-07 sb=3.9109e-07 sd=160n sca=23.235 scb=0.0183758 \
        scc=0.00227275 m=(1)
mp1 (6 \6\:net91 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=2.8609e-07 sd=160n sca=23.9435 \
        scb=0.0191387 scc=0.0022751 m=(1)
C1 (AN VSS) capacitor c=6.08569e-17
C2 (Y VSS) capacitor c=8.65434e-17
C3 (VDD VSS) capacitor c=1.01777e-16
C4 (B VSS) capacitor c=2.92745e-17
C5 (C VSS) capacitor c=4.61066e-17
C6 (net91 VSS) capacitor c=7.90177e-17
C7 (7 VSS) capacitor c=8.08845e-18
C8 (\3\:AN VSS) capacitor c=3.66047e-17
C9 (\6\:net91 VSS) capacitor c=9.12276e-17
C10 (\4\:B VSS) capacitor c=7.57983e-17
C11 (\6\:C VSS) capacitor c=1.8629e-17
C12 (\4\:C VSS) capacitor c=5.91723e-17
C13 (\1\:B VSS) capacitor c=9.62908e-17
C14 (\1\:AN VSS) capacitor c=4.24277e-17
C15 (\1\:C VSS) capacitor c=9.58085e-17
C16 (\2\:AN VSS) capacitor c=4.24545e-17
C17 (\3\:C VSS) capacitor c=2.93329e-17
C18 (\2\:B VSS) capacitor c=3.77932e-16
C19 (\2\:net91 VSS) capacitor c=4.94667e-16
C20 (\12\:net91 VSS) capacitor c=6.21005e-17
C21 (\1\:VDD VSS) capacitor c=3.39957e-17
C22 (\7\:Y VSS) capacitor c=1.08097e-16
C23 (\6\:VDD VSS) capacitor c=3.76527e-17
C24 (\7\:net91 VSS) capacitor c=1.97849e-17
C25 (\1\:Y VSS) capacitor c=1.92597e-16
C26 (\3\:Y VSS) capacitor c=9.76555e-17
C27 (\7\:C VSS) capacitor c=5.0622e-17
C28 (\4\:AN VSS) capacitor c=4.61338e-17
C29 (\9\:net91 VSS) capacitor c=5.2284e-17
C30 (\4\:VDD VSS) capacitor c=2.57585e-17
C31 (\5\:VDD VSS) capacitor c=1.07235e-17
Rk8 (\4\:AN AN) resistor r=0.06634 c=0
Rk6 (\1\:Y Y) resistor r=0.6077 c=0
Rk7 (Y \8\:Y) resistor r=0.7132 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.5599 c=0
Rk24 (\5\:VDD VDD) resistor r=0.1474 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.303 c=0
Rk25 (\5\:VDD \7\:VDD) resistor r=0.3388 c=0
Rk2 (B \2\:B) resistor r=0.09278 c=0
Rk18 (\1\:VSS VSS) resistor r=0.06721 c=0
Rk1 (C \7\:C) resistor r=0.1267 c=0
Rk10 (\9\:net91 \2\:net91) resistor r=0.2764 c=0
Rk9 (\8\:net91 \9\:net91) resistor r=0.1224 c=0
Rk12 (\9\:net91 \13\:net91) resistor r=0.4315 c=0
Rl15 (\2\:AN \3\:AN) resistor r=75.8439 c=0
Rl14 (\1\:AN \2\:AN) resistor r=101.923 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=87.2302 c=0
Rl9 (\3\:C \6\:C) resistor r=24.2328 c=0
Rl7 (\3\:C \4\:C) resistor r=124.554 c=0
Rl6 (\1\:C \3\:C) resistor r=60.4528 c=0
Rl13 (\2\:net91 \6\:net91) resistor r=103.022 c=0
Rl1 (\2\:net91 net91) resistor r=110.61 c=0
Rz2 (\1\:Y \3\:Y) resistor r=75 c=0
Rz4 (\8\:net91 \7\:net91) resistor r=75 c=0
Ry1 (\8\:Y \7\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry2 (\13\:net91 \12\:net91) resistor r=62 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn3 (\3\:Y \1\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=9.22788e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn1 (\1\:Y \2\:net91 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.025e-14 ad=4.16e-14 ps=1.03e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.39279e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn2 (\1\:Y \2\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.18779e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn0 (\7\:net91 \1\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=1.6e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mp0 (\12\:net91 \3\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=1.7e-07 sd=160n sca=37.4097 \
        scb=0.0335942 scc=0.00417864 m=(1)
ends NOR3BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:10 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3BX4
// View name: extracted

simulator lang=spectre

subckt NOR3BX4 AN B C VDD VSS Y
mp1_1__rcx (2 net91 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.8816 scb=0.0162884 \
        scc=0.00103352 m=(1)
mp2_1__rcx (2 \4\:B 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.866 scb=0.0148899 \
        scc=0.00102429 m=(1)
mp3_1__rcx (\15\:Y \5\:C 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2e-06 sd=160n sca=15.6796 scb=0.013986 \
        scc=0.00102272 m=(1)
mp3_2__rcx (\15\:Y \1\:C 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2e-06 sd=160n sca=15.4348 scb=0.0139233 \
        scc=0.00102271 m=(1)
mp2_2__rcx (9 \5\:B 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=8.58e-14 ps=1.01e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.86e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_2__rcx (10 \7\:net91 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=4.485e-14 ps=1.1e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.7e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_3__rcx (11 \9\:net91 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=1.0335e-13 ps=1.1e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.495e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_3__rcx (11 \8\:B 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.0335e-13 ps=9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.185e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp3_3__rcx (\17\:Y \10\:C 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=1.08e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp3 (\17\:Y \12\:C 12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.965e-06 sb=8.75e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2 (12 \11\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.482e-13 ps=9e-07 pd=1.54e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=16.3692 scb=0.0143929 scc=0.00102306 m=(1)
mp1 (4 \12\:net91 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=17.0619 scb=0.0151251 \
        scc=0.00102521 m=(1)
mp0 (\13\:net91 \3\:AN \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.2316 scb=0.0203333 \
        scc=0.00112395 m=(1)
C1 (C VSS) capacitor c=5.03765e-16
C2 (AN VSS) capacitor c=4.72494e-17
C3 (Y VSS) capacitor c=2.68854e-17
C4 (VDD VSS) capacitor c=1.73307e-16
C5 (B VSS) capacitor c=8.95951e-17
C6 (net91 VSS) capacitor c=6.24751e-17
C7 (2 VSS) capacitor c=2.46256e-18
C8 (8 VSS) capacitor c=1.02825e-17
C9 (9 VSS) capacitor c=1.09371e-17
C10 (10 VSS) capacitor c=4.61209e-18
C11 (11 VSS) capacitor c=1.22186e-17
C12 (3 VSS) capacitor c=2.46256e-18
C13 (12 VSS) capacitor c=1.01798e-17
C14 (4 VSS) capacitor c=1.69929e-18
C15 (\3\:AN VSS) capacitor c=4.94594e-17
C16 (\12\:net91 VSS) capacitor c=7.10778e-17
C17 (\11\:B VSS) capacitor c=7.80283e-17
C18 (\12\:C VSS) capacitor c=2.17198e-17
C19 (\10\:C VSS) capacitor c=7.87756e-17
C20 (\8\:B VSS) capacitor c=7.82268e-17
C21 (\9\:net91 VSS) capacitor c=2.17072e-17
C22 (\7\:net91 VSS) capacitor c=5.65832e-17
C23 (\5\:B VSS) capacitor c=5.25326e-17
C24 (\1\:C VSS) capacitor c=2.69451e-17
C25 (\5\:C VSS) capacitor c=3.7355e-17
C26 (\4\:B VSS) capacitor c=8.69692e-17
C27 (\1\:AN VSS) capacitor c=3.3694e-17
C28 (\2\:AN VSS) capacitor c=4.83855e-17
C29 (\1\:B VSS) capacitor c=7.53095e-16
C30 (\2\:net91 VSS) capacitor c=9.00512e-16
C31 (\13\:net91 VSS) capacitor c=3.84269e-17
C32 (\1\:VDD VSS) capacitor c=6.24255e-17
C33 (\17\:Y VSS) capacitor c=1.38731e-16
C34 (\6\:VDD VSS) capacitor c=4.40511e-17
C35 (\15\:Y VSS) capacitor c=1.9832e-17
C36 (\10\:VDD VSS) capacitor c=3.76921e-17
C37 (\3\:VDD VSS) capacitor c=6.05494e-17
C38 (\19\:net91 VSS) capacitor c=4.04709e-17
C39 (\1\:Y VSS) capacitor c=4.00297e-16
C40 (\2\:C VSS) capacitor c=1.75011e-17
C41 (\9\:C VSS) capacitor c=2.08447e-17
C42 (\13\:Y VSS) capacitor c=9.79037e-17
C43 (\14\:Y VSS) capacitor c=2.32726e-16
C44 (\4\:AN VSS) capacitor c=7.13914e-17
C45 (\15\:net91 VSS) capacitor c=4.78539e-17
C46 (\5\:VDD VSS) capacitor c=2.80538e-17
C47 (\9\:VDD VSS) capacitor c=1.62661e-17
Rk17 (AN \4\:AN) resistor r=0.1022 c=0
Rk13 (\13\:Y Y) resistor r=0.1217 c=0
Rk12 (\1\:Y \13\:Y) resistor r=0.1956 c=0
Rk14 (\13\:Y \14\:Y) resistor r=1.0042 c=0
Rk15 (\14\:Y \16\:Y) resistor r=0.04767 c=0
Rk16 (\14\:Y \18\:Y) resistor r=1.0031 c=0
Rk34 (\1\:VSS VSS) resistor r=0.05971 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.3818 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.6741 c=0
Rk40 (\5\:VDD \7\:VDD) resistor r=0.2386 c=0
Rk41 (\5\:VDD \8\:VDD) resistor r=0.1778 c=0
Rk44 (\9\:VDD VDD) resistor r=0.1249 c=0
Rk42 (\8\:VDD \9\:VDD) resistor r=0.4259 c=0
Rk43 (\9\:VDD \11\:VDD) resistor r=0.2386 c=0
Rk3 (B \1\:B) resistor r=0.01199 c=0
Rk19 (\15\:net91 \2\:net91) resistor r=0.2116 c=0
Rk18 (\14\:net91 \15\:net91) resistor r=0.1671 c=0
Rk22 (\15\:net91 \20\:net91) resistor r=0.3714 c=0
Rl7 (\2\:C C) resistor r=65.7741 c=0
Rl6 (\2\:C \1\:C) resistor r=35.772 c=0
Rl9 (\2\:C \5\:C) resistor r=100.426 c=0
Rl21 (\9\:C C) resistor r=60.4528 c=0
Rl24 (\9\:C \12\:C) resistor r=44.2087 c=0
Rl22 (\9\:C \10\:C) resistor r=88.4394 c=0
Rl31 (\2\:AN \3\:AN) resistor r=82.1429 c=0
Rl30 (\1\:AN \2\:AN) resistor r=55.6391 c=0
Rl25 (\1\:B \11\:B) resistor r=98.8796 c=0
Rl18 (\1\:B \8\:B) resistor r=75.6918 c=0
Rl11 (\1\:B \5\:B) resistor r=44.9225 c=0
Rl5 (\1\:B \4\:B) resistor r=110.418 c=0
Rl29 (\2\:net91 \12\:net91) resistor r=24.7951 c=0
Rl17 (\2\:net91 \9\:net91) resistor r=24.2328 c=0
Rl15 (\2\:net91 \7\:net91) resistor r=105.323 c=0
Rl1 (\2\:net91 net91) resistor r=24.2328 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz7 (\20\:net91 \19\:net91) resistor r=75 c=0
Ry1 (\16\:Y \15\:Y) resistor r=31 c=0
Ry2 (\18\:Y \17\:Y) resistor r=31 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry8 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\14\:net91 \13\:net91) resistor r=20.6667 c=0
Rx7 (\2\:AN \4\:AN) resistor r=45 c=0
mn0 (\19\:net91 \1\:AN \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.07e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.95e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\1\:Y \2\:net91 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.12e-14 ad=4.16e-14 ps=1.2575e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2_1__rcx (\1\:Y \1\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn3 (\1\:Y C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
ends NOR3BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:11 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3BXL
// View name: extracted

simulator lang=spectre

subckt NOR3BXL AN B C VDD VSS Y
mp3 (\6\:Y \1\:C net90 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.01e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.65e-07 sd=160n sca=16.2296 \
        scb=0.0157286 scc=0.000281388 m=(1)
mp2 (net90 \1\:B net86 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=1.828e-14 ps=7.2e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=5.35e-07 sd=160n sca=14.0893 \
        scb=0.0114914 scc=0.000172675 m=(1)
mp1 (net86 \3\:net91 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=3.45e-07 sd=160n sca=13.7313 \
        scb=0.0107733 scc=0.000165409 m=(1)
mp0 (\8\:net91 \3\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.4e-07 sd=160n sca=16.8204 \
        scb=0.0168333 scc=0.000331828 m=(1)
C1 (VDD VSS) capacitor c=1.29796e-16
C2 (C VSS) capacitor c=8.06676e-17
C3 (Y VSS) capacitor c=6.58493e-17
C4 (net91 VSS) capacitor c=3.40099e-17
C5 (\3\:AN VSS) capacitor c=3.90656e-17
C6 (\3\:net91 VSS) capacitor c=7.1931e-17
C7 (\1\:B VSS) capacitor c=4.62914e-17
C8 (\1\:C VSS) capacitor c=6.29865e-17
C9 (\1\:AN VSS) capacitor c=4.7883e-17
C10 (\3\:B VSS) capacitor c=6.85908e-17
C11 (\3\:C VSS) capacitor c=3.87726e-17
C12 (\2\:AN VSS) capacitor c=5.12079e-17
C13 (\2\:net91 VSS) capacitor c=6.13051e-17
C14 (\2\:B VSS) capacitor c=7.59842e-17
C15 (\2\:C VSS) capacitor c=6.25368e-17
C16 (\8\:net91 VSS) capacitor c=5.72533e-17
C17 (\1\:VDD VSS) capacitor c=3.07535e-17
C18 (\6\:Y VSS) capacitor c=5.72353e-17
C19 (\4\:net91 VSS) capacitor c=3.44302e-17
C20 (\4\:Y VSS) capacitor c=7.42728e-17
C21 (\1\:Y VSS) capacitor c=2.08145e-17
C22 (\4\:C VSS) capacitor c=4.52273e-17
C23 (\4\:B VSS) capacitor c=9.90428e-17
C24 (\3\:Y VSS) capacitor c=4.52412e-17
C25 (\4\:AN VSS) capacitor c=9.40873e-17
C26 (\6\:net91 VSS) capacitor c=4.82261e-17
C27 (\7\:net91 VSS) capacitor c=4.54465e-17
C28 (\4\:VDD VSS) capacitor c=2.59831e-17
Rk16 (\4\:VDD VDD) resistor r=0.2504 c=0
Rk15 (\2\:VDD \4\:VDD) resistor r=0.3465 c=0
Rk1 (C \4\:C) resistor r=0.09895 c=0
Rk7 (AN \4\:AN) resistor r=0.02603 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.2843 c=0
Rk13 (\5\:VSS VSS) resistor r=0.1374 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.1126 c=0
Rk14 (\5\:VSS \7\:VSS) resistor r=0.19 c=0
Rk4 (\3\:Y Y) resistor r=0.1536 c=0
Rk3 (\2\:Y \3\:Y) resistor r=0.097 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.3711 c=0
Rk6 (Y \7\:Y) resistor r=0.5063 c=0
Rk2 (\4\:B B) resistor r=0.01199 c=0
Rk8 (\5\:net91 \6\:net91) resistor r=0.1853 c=0
Rk9 (\6\:net91 \7\:net91) resistor r=0.2586 c=0
Rk10 (\6\:net91 \9\:net91) resistor r=0.5225 c=0
Rl1 (\1\:C \2\:C) resistor r=159.615 c=0
Rl2 (\2\:C \3\:C) resistor r=101.374 c=0
Rl8 (\2\:AN \3\:AN) resistor r=101.156 c=0
Rl7 (\1\:AN \2\:AN) resistor r=155.002 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=229.538 c=0
Rl6 (\2\:net91 \3\:net91) resistor r=206.867 c=0
Rl5 (net91 \2\:net91) resistor r=45.3288 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz3 (\4\:net91 \5\:net91) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\6\:Y \7\:Y) resistor r=62 c=0
Ry2 (\8\:net91 \9\:net91) resistor r=62 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:net91 \7\:net91) resistor r=45 c=0
mn3 (\1\:Y \3\:C \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn2 (\4\:Y \3\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn1 (\4\:Y net91 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn0 (\4\:net91 \1\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
ends NOR3BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:12 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3X1
// View name: extracted

simulator lang=spectre

subckt NOR3X1 A B C VDD VSS Y
mp0 (n0 \1\:A \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=25.2042 \
        scb=0.0229374 scc=0.00191469 m=(1)
mp1 (n1 \3\:B n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=4.29e-14 ps=1.01e-06 pd=1e-06 nrd=1.16667 nrs=1.16667 sa=3e-07 \
        sb=3.55e-07 sd=160n sca=24.2915 scb=0.021012 scc=0.00186223 m=(1)
mp2 (\1\:Y \3\:C n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=7.8e-14 ps=1e-06 pd=1.18e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=2e-07 sd=160n sca=27.0164 scb=0.0264192 \
        scc=0.00208493 m=(1)
C1 (C VSS) capacitor c=6.65842e-17
C2 (VDD VSS) capacitor c=4.43536e-17
C3 (B VSS) capacitor c=5.32064e-17
C4 (A VSS) capacitor c=9.22817e-18
C5 (n0 VSS) capacitor c=3.75124e-18
C6 (n1 VSS) capacitor c=1.21388e-18
C7 (\3\:C VSS) capacitor c=4.21609e-17
C8 (\3\:B VSS) capacitor c=5.88712e-17
C9 (\1\:A VSS) capacitor c=4.90339e-17
C10 (\1\:C VSS) capacitor c=4.02106e-17
C11 (\1\:B VSS) capacitor c=4.65043e-17
C12 (\4\:A VSS) capacitor c=3.44389e-17
C13 (\2\:C VSS) capacitor c=3.60931e-17
C14 (\2\:B VSS) capacitor c=5.14279e-17
C15 (\3\:A VSS) capacitor c=1.33072e-17
C16 (\1\:Y VSS) capacitor c=6.24964e-17
C17 (\4\:VDD VSS) capacitor c=4.63581e-17
C18 (\6\:Y VSS) capacitor c=2.58087e-17
C19 (\4\:Y VSS) capacitor c=9.69574e-17
C20 (\2\:A VSS) capacitor c=2.63659e-17
C21 (\5\:A VSS) capacitor c=6.91377e-17
C22 (\4\:B VSS) capacitor c=3.88075e-17
C23 (\4\:C VSS) capacitor c=6.90072e-17
C24 (\3\:Y VSS) capacitor c=9.32218e-17
C25 (\3\:VDD VSS) capacitor c=2.68237e-17
Rk10 (\2\:VSS \4\:VSS) resistor r=0.4057 c=0
Rk12 (\5\:VSS VSS) resistor r=0.08707 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.1123 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.2998 c=0
Rk5 (C \4\:C) resistor r=0.1298 c=0
Rk8 (\3\:Y Y) resistor r=0.09231 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3386 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4415 c=0
Rk9 (Y \7\:Y) resistor r=0.09364 c=0
Rk15 (\3\:VDD VDD) resistor r=0.08707 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.3472 c=0
Rk4 (\4\:B B) resistor r=0.03883 c=0
Rk2 (\4\:B \5\:B) resistor r=0.001025 c=0
Rk1 (A \5\:A) resistor r=0.0202 c=0
Rl7 (\2\:C \3\:C) resistor r=26.2482 c=0
Rl6 (\1\:C \2\:C) resistor r=77.4844 c=0
Rl5 (\2\:B \3\:B) resistor r=24.7951 c=0
Rl4 (\1\:B \2\:B) resistor r=76.9003 c=0
Rl1 (\1\:A \2\:A) resistor r=64.2642 c=0
Rl3 (\2\:A \4\:A) resistor r=54.6488 c=0
Rl2 (\2\:A \3\:A) resistor r=2.4801 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz1 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\6\:Y \7\:Y) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
mn0 (\4\:Y \4\:A \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn1 (\4\:Y \1\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn2 (\6\:Y \1\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
ends NOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:13 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3X2
// View name: extracted

simulator lang=spectre

subckt NOR3X2 A B C VDD VSS Y
mp0_1__rcx (2 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(1)
mp1_1__rcx (2 \1\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.75e-07 sd=160n sca=24.3732 \
        scb=0.019725 scc=0.00227862 m=(1)
mp2_1__rcx (\7\:Y \5\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=6.1e-07 sd=160n sca=23.0721 \
        scb=0.0181341 scc=0.00227242 m=(1)
mp2 (\7\:Y \1\:C 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=7.15e-07 sb=4.05e-07 sd=160n sca=23.4984 scb=0.0186248 \
        scc=0.00227326 m=(1)
mp1 (7 \4\:B 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=4.485e-14 ps=9e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.75e-07 sb=2.45e-07 sd=160n sca=25.0585 scb=0.0207887 \
        scc=0.00228936 m=(1)
mp0 (3 \7\:A \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=27.2119 \
        scb=0.0245429 scc=0.0023829 m=(1)
C1 (B VSS) capacitor c=2.89866e-17
C2 (VDD VSS) capacitor c=7.00392e-17
C3 (C VSS) capacitor c=4.99222e-17
C4 (A VSS) capacitor c=1.30546e-17
C5 (Y VSS) capacitor c=1.02319e-16
C6 (7 VSS) capacitor c=3.66078e-18
C7 (3 VSS) capacitor c=2.41617e-18
C8 (\7\:A VSS) capacitor c=7.91493e-17
C9 (\4\:B VSS) capacitor c=9.27523e-17
C10 (\1\:C VSS) capacitor c=5.29994e-17
C11 (\5\:C VSS) capacitor c=2.25529e-17
C12 (\1\:B VSS) capacitor c=8.12404e-17
C13 (\1\:A VSS) capacitor c=1.00891e-16
C14 (\2\:C VSS) capacitor c=2.18976e-17
C15 (\2\:B VSS) capacitor c=3.8976e-16
C16 (\6\:VDD VSS) capacitor c=3.14069e-17
C17 (\7\:Y VSS) capacitor c=8.66386e-17
C18 (\1\:VDD VSS) capacitor c=2.55059e-17
C19 (\1\:Y VSS) capacitor c=1.46403e-16
C20 (\3\:Y VSS) capacitor c=9.78022e-17
C21 (\2\:A VSS) capacitor c=4.45709e-16
C22 (\3\:C VSS) capacitor c=1.03407e-16
C23 (\7\:C VSS) capacitor c=5.04872e-17
C24 (\3\:VDD VSS) capacitor c=9.64684e-18
C25 (\5\:VDD VSS) capacitor c=2.52708e-17
Rk2 (B \2\:B) resistor r=0.09157 c=0
Rk18 (\3\:VDD VDD) resistor r=0.1022 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.3681 c=0
Rk19 (\3\:VDD \5\:VDD) resistor r=0.2477 c=0
Rk20 (\5\:VDD \7\:VDD) resistor r=0.5432 c=0
Rk1 (\7\:C C) resistor r=0.1869 c=0
Rk5 (\2\:A A) resistor r=0.02692 c=0
Rk8 (\1\:Y Y) resistor r=0.2446 c=0
Rk9 (Y \8\:Y) resistor r=0.8071 c=0
Rl11 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl6 (\2\:C \1\:C) resistor r=53.0601 c=0
Rl9 (\2\:C \5\:C) resistor r=24.2328 c=0
Rl7 (\3\:C \2\:C) resistor r=60.4528 c=0
Rl14 (\2\:A \7\:A) resistor r=95.3867 c=0
Rl1 (\2\:A \1\:A) resistor r=176.203 c=0
Rz2 (\1\:Y \3\:Y) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\8\:Y \7\:Y) resistor r=62 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn0 (\1\:Y \2\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=4.16e-14 ps=1.01e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.315e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn1 (\1\:Y \2\:B VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn2 (\3\:Y \3\:C VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=8.45e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
ends NOR3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:14 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3X4
// View name: extracted

simulator lang=spectre

subckt NOR3X4 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.8735 scb=0.0179349 \
        scc=0.00105762 m=(1)
mp1_1__rcx (3 \1\:B 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=2.34e-14 ps=1.33e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=17.4295 scb=0.0156155 \
        scc=0.00102793 m=(1)
mp2_1__rcx (\14\:Y \5\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.93e-06 sd=160n sca=15.7064 \
        scb=0.0139953 scc=0.00102272 m=(1)
mp2_2__rcx (\14\:Y \1\:C 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.725e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_2__rcx (4 \4\:B 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.62e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp0_2__rcx (9 \9\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.355e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp0_3__rcx (8 \5\:A \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.15e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_3__rcx (8 \7\:B 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=9.45e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_3__rcx (\16\:Y \10\:C 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=6.8e-07 sd=160n sca=15.5468 \
        scb=0.0139471 scc=0.00102271 m=(1)
mp2 (\16\:Y \7\:C 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=6.24e-14 ps=1.15e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.75e-07 sd=160n sca=16.1994 scb=0.0142604 \
        scc=0.00102289 m=(1)
mp1 (11 \12\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=7.215e-14 ps=9e-07 pd=1.15e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=18.0108 scb=0.016492 scc=0.00103567 m=(1)
mp0 (5 \13\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.9649 scb=0.0198601 \
        scc=0.0011076 m=(1)
C1 (A VSS) capacitor c=8.41693e-16
C2 (Y VSS) capacitor c=1.01981e-16
C3 (B VSS) capacitor c=2.05243e-17
C4 (VDD VSS) capacitor c=1.77853e-16
C5 (C VSS) capacitor c=1.50711e-16
C6 (3 VSS) capacitor c=1.33669e-18
C7 (6 VSS) capacitor c=7.31454e-18
C8 (4 VSS) capacitor c=2.46256e-18
C9 (9 VSS) capacitor c=1.09089e-17
C10 (8 VSS) capacitor c=7.53479e-18
C11 (10 VSS) capacitor c=1.09463e-17
C12 (11 VSS) capacitor c=8.72397e-18
C13 (5 VSS) capacitor c=2.46256e-18
C14 (\13\:A VSS) capacitor c=6.49451e-17
C15 (\12\:B VSS) capacitor c=8.48508e-17
C16 (\7\:C VSS) capacitor c=3.94023e-17
C17 (\10\:C VSS) capacitor c=2.70668e-17
C18 (\7\:B VSS) capacitor c=4.94973e-17
C19 (\5\:A VSS) capacitor c=2.7925e-17
C20 (\9\:A VSS) capacitor c=3.19822e-17
C21 (\4\:B VSS) capacitor c=7.30267e-17
C22 (\1\:C VSS) capacitor c=8.02948e-17
C23 (\5\:C VSS) capacitor c=2.32928e-17
C24 (\1\:B VSS) capacitor c=6.95174e-17
C25 (\1\:A VSS) capacitor c=8.49688e-17
C26 (\3\:C VSS) capacitor c=3.57666e-16
C27 (\2\:B VSS) capacitor c=8.00768e-16
C28 (\10\:VDD VSS) capacitor c=3.77468e-17
C29 (\16\:Y VSS) capacitor c=1.98087e-17
C30 (\8\:VDD VSS) capacitor c=4.40443e-17
C31 (\14\:Y VSS) capacitor c=1.42046e-16
C32 (\1\:VDD VSS) capacitor c=3.42366e-17
C33 (\4\:VDD VSS) capacitor c=5.49097e-17
C34 (\1\:Y VSS) capacitor c=3.9766e-16
C35 (\2\:C VSS) capacitor c=2.13567e-17
C36 (\8\:C VSS) capacitor c=2.14807e-17
C37 (\13\:Y VSS) capacitor c=2.27768e-16
C38 (\3\:VDD VSS) capacitor c=1.1875e-17
C39 (\6\:VDD VSS) capacitor c=2.19578e-17
Rk16 (\1\:Y Y) resistor r=0.2261 c=0
Rk17 (Y \13\:Y) resistor r=0.9688 c=0
Rk18 (\13\:Y \15\:Y) resistor r=1.0016 c=0
Rk19 (\13\:Y \17\:Y) resistor r=0.04758 c=0
Rk3 (B \2\:B) resistor r=0.04292 c=0
Rk38 (\3\:VDD VDD) resistor r=0.1073 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.2911 c=0
Rk35 (\3\:VDD \5\:VDD) resistor r=0.4434 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.1452 c=0
Rk37 (\6\:VDD \7\:VDD) resistor r=0.6063 c=0
Rk39 (\6\:VDD \9\:VDD) resistor r=0.2383 c=0
Rk40 (\7\:VDD \11\:VDD) resistor r=0.2832 c=0
Rk1 (C \3\:C) resistor r=0.004022 c=0
Rl28 (A \13\:A) resistor r=24.2328 c=0
Rl13 (A \5\:A) resistor r=24.2328 c=0
Rl16 (A \9\:A) resistor r=75.2759 c=0
Rl1 (A \1\:A) resistor r=109.125 c=0
Rl26 (\2\:B \12\:B) resistor r=80.5643 c=0
Rl18 (\2\:B \7\:B) resistor r=75.6918 c=0
Rl11 (\2\:B \4\:B) resistor r=44.9225 c=0
Rl4 (\2\:B \1\:B) resistor r=45.9489 c=0
Rl6 (\2\:C \1\:C) resistor r=88.4394 c=0
Rl9 (\2\:C \5\:C) resistor r=44.2087 c=0
Rl7 (\2\:C \3\:C) resistor r=68.1451 c=0
Rl20 (\8\:C \7\:C) resistor r=100.426 c=0
Rl22 (\8\:C \10\:C) resistor r=35.772 c=0
Rl21 (\8\:C \3\:C) resistor r=83.0817 c=0
Rz14 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\4\:VDD \7\:VDD) resistor r=25 c=0
Ry1 (\15\:Y \14\:Y) resistor r=31 c=0
Ry2 (\17\:Y \16\:Y) resistor r=31 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry7 (\10\:VDD \11\:VDD) resistor r=62 c=0
mn0_1__rcx (\1\:Y A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=4.16e-14 ps=1.18e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(4)
mn1_1__rcx (\1\:Y \2\:B VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8e-14 ad=4.16e-14 ps=1.34e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn2_1__rcx (\1\:Y \3\:C VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8e-14 ad=4.16e-14 ps=1.34e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(4)
ends NOR3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:15 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3X6
// View name: extracted

simulator lang=spectre

subckt NOR3X6 A B C VDD VSS Y
mp0_1__rcx (2 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.7415 scb=0.0157405 \
        scc=0.000674193 m=(1)
mp1_1__rcx (2 \1\:B 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=2.34e-14 ps=1.54e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=15.4152 scb=0.0136728 \
        scc=0.00065148 m=(1)
mp2_1__rcx (\13\:Y \7\:C 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_2__rcx (\13\:Y \1\:C 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (3 \4\:B 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (11 \9\:A \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (12 \8\:A \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (12 \7\:B 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=8.58e-14 ps=1.54e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_3__rcx (\11\:Y \14\:C 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.675e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_4__rcx (\11\:Y \8\:C 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.47e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_4__rcx (4 \10\:B 13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=2.34e-14 ps=1.2e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_4__rcx (13 \15\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.19e-14 ps=1.1e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.11e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_5__rcx (14 \14\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.05e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_5__rcx (14 \13\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.9e-07 sd=160n sca=13.8386 scb=0.012255 \
        scc=0.000647525 m=(1)
mp2_5__rcx (\9\:Y \17\:C 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.85e-07 sd=160n sca=14.1837 scb=0.0124217 \
        scc=0.000647608 m=(1)
mp2 (\9\:Y \15\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=3.8e-07 sd=160n sca=15.4628 scb=0.0137376 scc=0.00065186 m=(1)
mp1 (6 \16\:B 15 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=2.34e-14 ps=9.6e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.75e-07 sd=160n sca=16.8269 scb=0.0158863 scc=0.000676698 \
        m=(1)
mp0 (15 \16\:A \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.691 scb=0.0225653 \
        scc=0.00096071 m=(1)
C1 (C VSS) capacitor c=8.84588e-16
C2 (A VSS) capacitor c=1.92788e-17
C3 (Y VSS) capacitor c=1.16545e-16
C4 (VDD VSS) capacitor c=2.4221e-16
C5 (B VSS) capacitor c=6.35708e-17
C6 (2 VSS) capacitor c=1.56659e-18
C7 (8 VSS) capacitor c=1.13351e-17
C8 (3 VSS) capacitor c=2.44041e-18
C9 (11 VSS) capacitor c=7.46017e-18
C10 (12 VSS) capacitor c=9.69343e-18
C11 (9 VSS) capacitor c=1.84473e-17
C12 (4 VSS) capacitor c=2.44041e-18
C13 (13 VSS) capacitor c=8.81225e-18
C14 (14 VSS) capacitor c=7.9355e-18
C15 (5 VSS) capacitor c=2.44041e-18
C16 (6 VSS) capacitor c=2.37923e-18
C17 (15 VSS) capacitor c=3.57883e-18
C18 (\16\:A VSS) capacitor c=5.38206e-17
C19 (\16\:B VSS) capacitor c=1.0103e-16
C20 (\15\:C VSS) capacitor c=5.90069e-17
C21 (\17\:C VSS) capacitor c=7.64751e-17
C22 (\13\:B VSS) capacitor c=7.64549e-17
C23 (\14\:A VSS) capacitor c=2.8914e-17
C24 (\15\:A VSS) capacitor c=2.28843e-17
C25 (\10\:B VSS) capacitor c=8.1298e-17
C26 (\8\:C VSS) capacitor c=7.95296e-17
C27 (\14\:C VSS) capacitor c=2.77121e-17
C28 (\7\:B VSS) capacitor c=3.65204e-17
C29 (\8\:A VSS) capacitor c=2.41083e-17
C30 (\9\:A VSS) capacitor c=2.87504e-17
C31 (\4\:B VSS) capacitor c=7.78642e-17
C32 (\1\:C VSS) capacitor c=7.27932e-17
C33 (\7\:C VSS) capacitor c=2.72622e-17
C34 (\1\:B VSS) capacitor c=6.85128e-17
C35 (\1\:A VSS) capacitor c=6.33091e-17
C36 (\17\:A VSS) capacitor c=4.04018e-17
C37 (\17\:B VSS) capacitor c=6.29641e-17
C38 (\2\:B VSS) capacitor c=1.20991e-15
C39 (\2\:A VSS) capacitor c=1.08689e-15
C40 (\13\:VDD VSS) capacitor c=4.42617e-17
C41 (\9\:Y VSS) capacitor c=1.54748e-16
C42 (\10\:VDD VSS) capacitor c=3.6975e-17
C43 (\11\:Y VSS) capacitor c=2.17116e-16
C44 (\7\:VDD VSS) capacitor c=3.88275e-17
C45 (\13\:Y VSS) capacitor c=1.52801e-16
C46 (\1\:VDD VSS) capacitor c=3.32061e-17
C47 (\4\:VDD VSS) capacitor c=5.41813e-17
C48 (\1\:Y VSS) capacitor c=6.36279e-16
C49 (\16\:C VSS) capacitor c=3.29189e-17
C50 (\18\:B VSS) capacitor c=2.61388e-17
C51 (\20\:A VSS) capacitor c=1.57455e-16
C52 (\3\:VDD VSS) capacitor c=1.52036e-17
C53 (\6\:VDD VSS) capacitor c=2.88196e-17
C54 (\9\:VDD VSS) capacitor c=3.30491e-17
Rk15 (\2\:A A) resistor r=0.03773 c=0
Rk11 (\2\:A \20\:A) resistor r=0.9952 c=0
Rk19 (\1\:Y Y) resistor r=0.6777 c=0
Rk20 (Y \10\:Y) resistor r=0.464 c=0
Rk21 (\10\:Y \12\:Y) resistor r=0.8066 c=0
Rk22 (\12\:Y \14\:Y) resistor r=1.0442 c=0
Rk28 (\3\:VDD VDD) resistor r=0.1149 c=0
Rk27 (\2\:VDD \3\:VDD) resistor r=0.2677 c=0
Rk29 (\3\:VDD \5\:VDD) resistor r=0.4362 c=0
Rk30 (\5\:VDD \6\:VDD) resistor r=0.1754 c=0
Rk31 (\6\:VDD \8\:VDD) resistor r=0.2196 c=0
Rk32 (\6\:VDD \9\:VDD) resistor r=0.7319 c=0
Rk33 (\9\:VDD \11\:VDD) resistor r=0.2196 c=0
Rk34 (\9\:VDD \12\:VDD) resistor r=0.1453 c=0
Rk35 (\12\:VDD \14\:VDD) resistor r=0.5655 c=0
Rk37 (\1\:VSS VSS) resistor r=0.06476 c=0
Rk5 (B \2\:B) resistor r=0.2915 c=0
Rk4 (\18\:B B) resistor r=0.08133 c=0
Rl20 (C \8\:C) resistor r=159.593 c=0
Rl25 (C \14\:C) resistor r=101.605 c=0
Rl5 (C \1\:C) resistor r=119.762 c=0
Rl10 (C \7\:C) resistor r=103.431 c=0
Rl37 (C \16\:C) resistor r=70.5495 c=0
Rl35 (\16\:C \15\:C) resistor r=44.2087 c=0
Rl36 (\16\:C \17\:C) resistor r=88.4394 c=0
Rl41 (\17\:A \16\:A) resistor r=62.2302 c=0
Rl31 (\2\:A \14\:A) resistor r=49.5589 c=0
Rl32 (\2\:A \15\:A) resistor r=24.2328 c=0
Rl16 (\2\:A \8\:A) resistor r=24.2328 c=0
Rl17 (\2\:A \9\:A) resistor r=47.3105 c=0
Rl1 (\2\:A \1\:A) resistor r=44.208 c=0
Rl40 (\17\:B \16\:B) resistor r=74.2328 c=0
Rl33 (\2\:B \13\:B) resistor r=44.9225 c=0
Rl26 (\2\:B \10\:B) resistor r=75.6918 c=0
Rl18 (\2\:B \7\:B) resistor r=53.0211 c=0
Rl11 (\2\:B \4\:B) resistor r=44.9225 c=0
Rl3 (\2\:B \1\:B) resistor r=44.9225 c=0
Rz9 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz10 (\4\:VDD \12\:VDD) resistor r=8.3333 c=0
Ry1 (\10\:Y \9\:Y) resistor r=62 c=0
Ry2 (\12\:Y \11\:Y) resistor r=62 c=0
Ry3 (\14\:Y \13\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry7 (\13\:VDD \14\:VDD) resistor r=62 c=0
Rx11 (\20\:A \17\:A) resistor r=45 c=0
Rx4 (\18\:B \17\:B) resistor r=45 c=0
mn0_1__rcx (\1\:Y \2\:A \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.388e-14 ad=4.96e-14 ps=1.372e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
mn1_1__rcx (\1\:Y \2\:B \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
mn2 (\1\:Y C \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=9.4e-14 \
        ad=4.836e-14 ps=1.49e-06 pd=9.32e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
ends NOR3X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:16 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3X8
// View name: extracted

simulator lang=spectre

subckt NOR3X8 A B C VDD VSS Y
mp0_1__rcx (2 \1\:A \15\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=2.67e-14 ps=1.17e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.7728 scb=0.0232209 \
        scc=0.00300084 m=(1)
mp1_1__rcx (2 \1\:B 7 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=2.67e-14 ps=1.65e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=30.1491 scb=0.0205231 \
        scc=0.00295848 m=(1)
mp2_1__rcx (\30\:Y \6\:C 7 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=7.12e-14 ps=1.65e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=28.0095 scb=0.0185345 \
        scc=0.00295096 m=(1)
mp2_2__rcx (\30\:Y \1\:C 3 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_2__rcx (3 \4\:B 9 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_2__rcx (9 \10\:A \13\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp0_3__rcx (11 \9\:A \13\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=9.79e-14 ps=1.21e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_3__rcx (11 \7\:B 12 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=9.79e-14 ps=1.33e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=2e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp2_3__rcx (\28\:Y \12\:C 12 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=7.12e-14 ps=1.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp2_4__rcx (\28\:Y \7\:C 13 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=7.12e-14 ps=1.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_4__rcx (13 \10\:B 10 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=9.79e-14 ps=1.21e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_4__rcx (10 \17\:A \11\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_5__rcx (14 \15\:A \11\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.342e-14 ps=1.21e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.92e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_5__rcx (14 \15\:B 8 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=7.343e-14 ps=1.65e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.71e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp2_5__rcx (\26\:Y \18\:C 8 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=7.12e-14 ps=1.65e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.285e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp2_6__rcx (\26\:Y \13\:C 15 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=5.118e-14 ad=7.12e-14 ps=1.12e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.08e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_6__rcx (15 \16\:B 16 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=8.232e-14 ad=5.118e-14 ps=1.26e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.2e-07 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_6__rcx (16 \24\:A \9\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=8.232e-14 ps=1.21e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.9e-07 sd=160n sca=28.0414 scb=0.0185419 \
        scc=0.00295096 m=(1)
mp0 (17 \22\:A \9\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=8.677e-14 ps=1.21e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.85e-07 sd=160n sca=28.6826 scb=0.0188419 \
        scc=0.00295113 m=(1)
mp1 (17 \19\:B 4 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=2.67e-14 \
        ad=8.677e-14 ps=1.01e-06 pd=1.28e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2.45e-07 sd=160n sca=30.5839 scb=0.0211973 \
        scc=0.00296515 m=(1)
mp2 (\2\:Y \21\:C 4 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=2.67e-14 \
        ad=6.23e-14 ps=1.01e-06 pd=1.17e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.4e-07 sd=160n sca=32.6015 scb=0.02469 scc=0.00304367 \
        m=(1)
C1 (Y VSS) capacitor c=1.42476e-17
C2 (C VSS) capacitor c=1.41207e-15
C3 (B VSS) capacitor c=1.47364e-15
C4 (A VSS) capacitor c=2.06339e-17
C5 (VDD VSS) capacitor c=1.64481e-16
C6 (7 VSS) capacitor c=1.49425e-17
C7 (3 VSS) capacitor c=2.8629e-18
C8 (9 VSS) capacitor c=9.08279e-18
C9 (11 VSS) capacitor c=1.16539e-17
C10 (12 VSS) capacitor c=1.29223e-17
C11 (13 VSS) capacitor c=1.29409e-17
C12 (10 VSS) capacitor c=9.14969e-18
C13 (14 VSS) capacitor c=9.69562e-18
C14 (8 VSS) capacitor c=2.17145e-17
C15 (15 VSS) capacitor c=5.54185e-18
C16 (16 VSS) capacitor c=7.93447e-18
C17 (17 VSS) capacitor c=6.48887e-18
C18 (4 VSS) capacitor c=2.79218e-18
C19 (\21\:C VSS) capacitor c=8.01445e-17
C20 (\19\:B VSS) capacitor c=8.83086e-17
C21 (\22\:A VSS) capacitor c=3.33517e-17
C22 (\24\:A VSS) capacitor c=2.67902e-17
C23 (\16\:B VSS) capacitor c=6.60046e-17
C24 (\13\:C VSS) capacitor c=4.96135e-17
C25 (\18\:C VSS) capacitor c=2.6451e-17
C26 (\15\:B VSS) capacitor c=4.62809e-17
C27 (\15\:A VSS) capacitor c=3.5765e-17
C28 (\17\:A VSS) capacitor c=2.745e-17
C29 (\10\:B VSS) capacitor c=5.256e-17
C30 (\7\:C VSS) capacitor c=3.24969e-17
C31 (\12\:C VSS) capacitor c=3.22601e-17
C32 (\7\:B VSS) capacitor c=4.70365e-17
C33 (\9\:A VSS) capacitor c=2.47841e-17
C34 (\10\:A VSS) capacitor c=3.51364e-17
C35 (\4\:B VSS) capacitor c=9.17205e-17
C36 (\1\:C VSS) capacitor c=7.63308e-17
C37 (\6\:C VSS) capacitor c=2.65853e-17
C38 (\1\:B VSS) capacitor c=7.70808e-17
C39 (\1\:A VSS) capacitor c=6.69994e-17
C40 (\2\:A VSS) capacitor c=1.32105e-15
C41 (\2\:Y VSS) capacitor c=7.47761e-17
C42 (\9\:VDD VSS) capacitor c=4.03793e-17
C43 (\26\:Y VSS) capacitor c=2.21909e-16
C44 (\11\:VDD VSS) capacitor c=4.06411e-17
C45 (\28\:Y VSS) capacitor c=2.44076e-16
C46 (\13\:VDD VSS) capacitor c=4.33543e-17
C47 (\30\:Y VSS) capacitor c=1.37123e-16
C48 (\15\:VDD VSS) capacitor c=3.44731e-17
C49 (\1\:VDD VSS) capacitor c=6.98957e-17
C50 (\4\:Y VSS) capacitor c=9.95499e-16
C51 (\1\:Y VSS) capacitor c=4.88207e-17
C52 (\3\:VDD VSS) capacitor c=1.78702e-17
C53 (\5\:VDD VSS) capacitor c=3.07003e-17
C54 (\6\:VDD VSS) capacitor c=2.42875e-17
C55 (\8\:VDD VSS) capacitor c=1.15049e-17
Rk20 (Y \1\:Y) resistor r=0.0235 c=0
Rk22 (\1\:Y \4\:Y) resistor r=0.4843 c=0
Rk21 (\1\:Y \3\:Y) resistor r=0.07709 c=0
Rk33 (\3\:Y \27\:Y) resistor r=0.8154 c=0
Rk34 (\27\:Y \29\:Y) resistor r=1.1238 c=0
Rk35 (\29\:Y \31\:Y) resistor r=0.9267 c=0
Rk49 (\1\:VSS VSS) resistor r=0.04721 c=0
Rk3 (\2\:A A) resistor r=0.01663 c=0
Rk61 (\2\:VDD \3\:VDD) resistor r=0.3209 c=0
Rk62 (\3\:VDD \4\:VDD) resistor r=0.3811 c=0
Rk63 (\4\:VDD \5\:VDD) resistor r=0.3384 c=0
Rk64 (\5\:VDD \6\:VDD) resistor r=0.7069 c=0
Rk65 (\6\:VDD \7\:VDD) resistor r=0.1578 c=0
Rk67 (\8\:VDD VDD) resistor r=0.09737 c=0
Rk66 (\7\:VDD \8\:VDD) resistor r=0.4538 c=0
Rk68 (\3\:VDD \10\:VDD) resistor r=0.2601 c=0
Rk69 (\5\:VDD \12\:VDD) resistor r=0.2601 c=0
Rk70 (\6\:VDD \14\:VDD) resistor r=0.2601 c=0
Rk71 (\8\:VDD \16\:VDD) resistor r=0.2648 c=0
Rk72 (\16\:VDD \17\:VDD) resistor r=0.1539 c=0
Rl51 (C \21\:C) resistor r=83.0212 c=0
Rl35 (C \13\:C) resistor r=122.34 c=0
Rl39 (C \18\:C) resistor r=85.7463 c=0
Rl20 (C \7\:C) resistor r=85.7713 c=0
Rl24 (C \12\:C) resistor r=87.6951 c=0
Rl5 (C \1\:C) resistor r=110.155 c=0
Rl9 (C \6\:C) resistor r=84.1998 c=0
Rl48 (B \19\:B) resistor r=81.461 c=0
Rl40 (B \16\:B) resistor r=83.3841 c=0
Rl34 (B \15\:B) resistor r=83.7912 c=0
Rl25 (B \10\:B) resistor r=83.3841 c=0
Rl18 (B \7\:B) resistor r=75.6918 c=0
Rl10 (B \4\:B) resistor r=83.3841 c=0
Rl3 (B \1\:B) resistor r=62.2302 c=0
Rl45 (\2\:A \22\:A) resistor r=93.9123 c=0
Rl47 (\2\:A \24\:A) resistor r=24.2328 c=0
Rl30 (\2\:A \15\:A) resistor r=93.9123 c=0
Rl32 (\2\:A \17\:A) resistor r=24.848 c=0
Rl16 (\2\:A \9\:A) resistor r=24.2328 c=0
Rl17 (\2\:A \10\:A) resistor r=99.2335 c=0
Rl1 (\2\:A \1\:A) resistor r=30.5087 c=0
Rz23 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz24 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz25 (\1\:VDD \7\:VDD) resistor r=6.25 c=0
Ry1 (\3\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\27\:Y \26\:Y) resistor r=62 c=0
Ry3 (\29\:Y \28\:Y) resistor r=62 c=0
Ry4 (\31\:Y \30\:Y) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry10 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry11 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry12 (\15\:VDD \17\:VDD) resistor r=62 c=0
mn0_1__rcx (\4\:Y \2\:A \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=7.85e-14 ad=4.72e-14 ps=1.29e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.89726 scb=0.00719534 \
        scc=0.00020576 m=(7)
mn1_1__rcx (\4\:Y B \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=4.72e-14 ps=1.36e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=8.89726 \
        scb=0.00719534 scc=0.00020576 m=(7)
mn2_1__rcx (\4\:Y C \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=4.636e-14 ps=1.36e-06 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=8.89726 scb=0.00719534 \
        scc=0.00020576 m=(7)
ends NOR3X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:17 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR3XL
// View name: extracted

simulator lang=spectre

subckt NOR3XL A B C VDD VSS Y
mp0 (n0 \1\:A \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.688e-14 ps=7.1e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=17.0184 \
        scb=0.0161278 scc=0.000306233 m=(1)
mp1 (n1 \1\:B n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=2.688e-14 \
        ad=2.258e-14 ps=6.8e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.1e-07 sb=3.7e-07 sd=160n sca=15.9187 scb=0.0138219 \
        scc=0.000240159 m=(1)
mp2 (\4\:Y \3\:C n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=4.73e-14 ps=6.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.2e-07 sd=160n sca=18.4685 \
        scb=0.0189127 scc=0.000442866 m=(1)
C1 (C VSS) capacitor c=6.73779e-17
C2 (Y VSS) capacitor c=3.21459e-18
C3 (B VSS) capacitor c=9.01567e-17
C4 (A VSS) capacitor c=3.43691e-17
C5 (VDD VSS) capacitor c=9.77856e-17
C6 (n0 VSS) capacitor c=5.17527e-18
C7 (n1 VSS) capacitor c=1.68211e-19
C8 (\3\:C VSS) capacitor c=3.63796e-17
C9 (\1\:B VSS) capacitor c=4.12912e-17
C10 (\1\:A VSS) capacitor c=3.03439e-17
C11 (\1\:C VSS) capacitor c=3.74171e-17
C12 (\3\:B VSS) capacitor c=4.8412e-17
C13 (\3\:A VSS) capacitor c=4.20301e-17
C14 (\2\:C VSS) capacitor c=4.04674e-17
C15 (\2\:B VSS) capacitor c=5.53934e-17
C16 (\2\:A VSS) capacitor c=4.29101e-17
C17 (\4\:Y VSS) capacitor c=6.06935e-17
C18 (\4\:VDD VSS) capacitor c=3.88796e-17
C19 (\6\:Y VSS) capacitor c=1.52114e-17
C20 (\1\:Y VSS) capacitor c=4.44177e-17
C21 (\4\:A VSS) capacitor c=4.62723e-17
C22 (\4\:B VSS) capacitor c=2.92269e-17
C23 (\4\:C VSS) capacitor c=5.90765e-17
C24 (\3\:Y VSS) capacitor c=5.77758e-17
C25 (\3\:VDD VSS) capacitor c=3.46482e-17
Rk5 (C \4\:C) resistor r=0.1866 c=0
Rk8 (\3\:Y Y) resistor r=0.04375 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.4284 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.3569 c=0
Rk9 (Y \7\:Y) resistor r=0.05974 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.4114 c=0
Rk12 (\5\:VSS VSS) resistor r=0.08457 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.1148 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.073 c=0
Rk4 (\4\:B B) resistor r=0.0239 c=0
Rk1 (\4\:A A) resistor r=0.08564 c=0
Rk15 (\3\:VDD VDD) resistor r=0.08206 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.282 c=0
Rl6 (\2\:C \3\:C) resistor r=62.6374 c=0
Rl5 (\1\:C \2\:C) resistor r=101.923 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=133.384 c=0
Rl1 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl2 (\2\:A \3\:A) resistor r=135.771 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=62 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \3\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.95e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn1 (\1\:Y \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.9e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn2 (\6\:Y \1\:C \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.85e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
ends NOR3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:18 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BBX1
// View name: extracted

simulator lang=spectre

subckt NOR4BBX1 AN BN C D VDD VSS Y
mp1 (\8\:n1 \1\:BN \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=65.2419 scb=0.0523585 \
        scc=0.00853102 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=3.01e-14 ps=1.22e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=25.3128 \
        scb=0.0295551 scc=0.00162105 m=(1)
C1 (BN VSS) capacitor c=4.32601e-17
C2 (VDD VSS) capacitor c=1.07712e-16
C3 (C VSS) capacitor c=3.59346e-17
C4 (D VSS) capacitor c=5.22573e-17
C5 (Y VSS) capacitor c=2.9192e-17
C6 (n1 VSS) capacitor c=4.1135e-17
C7 (n0 VSS) capacitor c=4.08638e-17
C8 (n4 VSS) capacitor c=2.13646e-18
C9 (n3 VSS) capacitor c=4.76912e-18
C10 (n2 VSS) capacitor c=9.08344e-18
C11 (\1\:AN VSS) capacitor c=3.65818e-17
C12 (\3\:n0 VSS) capacitor c=5.6396e-17
C13 (\3\:n1 VSS) capacitor c=6.464e-17
C14 (\3\:C VSS) capacitor c=8.9555e-17
C15 (\1\:D VSS) capacitor c=7.66177e-17
C16 (\1\:BN VSS) capacitor c=2.47395e-17
C17 (\3\:AN VSS) capacitor c=4.58743e-17
C18 (\1\:C VSS) capacitor c=5.30212e-17
C19 (\3\:D VSS) capacitor c=4.325e-17
C20 (\4\:BN VSS) capacitor c=2.54038e-17
C21 (\2\:AN VSS) capacitor c=3.67256e-17
C22 (\2\:n0 VSS) capacitor c=4.88786e-17
C23 (\2\:n1 VSS) capacitor c=6.2581e-17
C24 (\2\:C VSS) capacitor c=7.40308e-17
C25 (\2\:D VSS) capacitor c=5.70246e-17
C26 (\3\:BN VSS) capacitor c=1.09736e-17
C27 (\4\:n0 VSS) capacitor c=7.83607e-17
C28 (\1\:VDD VSS) capacitor c=7.11778e-17
C29 (\2\:Y VSS) capacitor c=9.13166e-17
C30 (\8\:n1 VSS) capacitor c=4.81494e-17
C31 (\5\:VDD VSS) capacitor c=3.56196e-17
C32 (\7\:n0 VSS) capacitor c=4.63326e-17
C33 (\5\:Y VSS) capacitor c=3.63625e-17
C34 (\7\:Y VSS) capacitor c=6.80733e-17
C35 (\6\:n1 VSS) capacitor c=1.11939e-17
C36 (\2\:BN VSS) capacitor c=9.76106e-18
C37 (\5\:BN VSS) capacitor c=4.57809e-17
C38 (\4\:D VSS) capacitor c=6.53066e-17
C39 (\4\:C VSS) capacitor c=4.9798e-17
C40 (\4\:n1 VSS) capacitor c=8.13214e-17
C41 (\5\:n1 VSS) capacitor c=7.20774e-17
C42 (\1\:Y VSS) capacitor c=1.03835e-16
C43 (\4\:Y VSS) capacitor c=7.71986e-17
C44 (\6\:n0 VSS) capacitor c=1.07138e-16
C45 (\4\:AN VSS) capacitor c=7.97252e-17
C46 (\4\:VDD VSS) capacitor c=4.60102e-17
Rk1 (BN \5\:BN) resistor r=0.1688 c=0
Rk14 (AN \4\:AN) resistor r=0.03886 c=0
Rk22 (\4\:VDD VDD) resistor r=0.3513 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4528 c=0
Rk23 (VDD \6\:VDD) resistor r=0.2334 c=0
Rk3 (C \4\:C) resistor r=0.1 c=0
Rk2 (D \4\:D) resistor r=0.09253 c=0
Rk7 (Y \1\:Y) resistor r=0.002903 c=0
Rk8 (\1\:Y \3\:Y) resistor r=0.6634 c=0
Rk9 (\1\:Y \4\:Y) resistor r=0.4046 c=0
Rk10 (\4\:Y \6\:Y) resistor r=0.09051 c=0
Rk11 (\4\:Y \8\:Y) resistor r=0.3707 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.557 c=0
Rk17 (\5\:VSS VSS) resistor r=0.1479 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.203 c=0
Rk18 (\4\:VSS \7\:VSS) resistor r=0.2731 c=0
Rk19 (\5\:VSS \9\:VSS) resistor r=0.1378 c=0
Rk20 (VSS \11\:VSS) resistor r=0.1698 c=0
Rk4 (\4\:n1 \5\:n1) resistor r=0.4557 c=0
Rk5 (\5\:n1 \7\:n1) resistor r=0.08791 c=0
Rk6 (\5\:n1 \9\:n1) resistor r=0.2055 c=0
Rk12 (\5\:n0 \6\:n0) resistor r=0.5646 c=0
Rk13 (\6\:n0 \8\:n0) resistor r=0.3162 c=0
Rl1 (\1\:BN \2\:BN) resistor r=49.7141 c=0
Rl3 (\2\:BN \4\:BN) resistor r=34.3295 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl12 (\1\:AN \2\:AN) resistor r=74.2328 c=0
Rl13 (\2\:AN \3\:AN) resistor r=97.3098 c=0
Rl7 (\2\:C \3\:C) resistor r=68.4066 c=0
Rl6 (\1\:C \2\:C) resistor r=107.692 c=0
Rl4 (\1\:D \2\:D) resistor r=71.131 c=0
Rl5 (\2\:D \3\:D) resistor r=101.718 c=0
Rl9 (\2\:n1 \3\:n1) resistor r=126.374 c=0
Rl8 (n1 \2\:n1) resistor r=56.1096 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=155.689 c=0
Rl10 (n0 \2\:n0) resistor r=26.098 c=0
Rz2 (\5\:Y \6\:Y) resistor r=37.5 c=0
Rz3 (\7\:Y \8\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\2\:Y \3\:Y) resistor r=31 c=0
Ry1 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:BN \5\:BN) resistor r=45 c=0
Rx6 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx5 (\2\:n0 \6\:n0) resistor r=45 c=0
mn1 (\6\:n1 \4\:BN \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.295e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn5 (\7\:Y \3\:D \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.18e-14 ad=4.16e-14 ps=1.29e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=8.91635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn4 (\7\:Y \1\:C \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=6.86635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn3 (\5\:Y n1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.81e-14 ps=8.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=4.66635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn2 (\5\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.81e-14 ps=8.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=2.36635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mp5 (\2\:Y \1\:D n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.3609e-07 sd=160n sca=13.1685 scb=0.0109658 \
        scc=0.000276178 m=(1)
mp4 (n4 \3\:C n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.3109e-07 sd=160n sca=12.5855 scb=0.0103077 \
        scc=0.000274391 m=(1)
mp3 (n3 \3\:n1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=9.36e-14 \
        ad=4.485e-14 ps=1.26e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.7109e-07 sd=160n sca=12.4303 scb=0.0101252 \
        scc=0.000274165 m=(1)
mp2 (n2 \3\:n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=9.36e-14 ps=1.22e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.8609e-07 sd=160n sca=14.1331 \
        scb=0.0123288 scc=0.000285937 m=(1)
ends NOR4BBX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:19 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BBX2
// View name: extracted

simulator lang=spectre

subckt NOR4BBX2 AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.655e-14 ps=1.1e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.20814e-07 sd=160n sca=28.0767 \
        scb=0.0303449 scc=0.00237588 m=(1)
mp0 (\9\:n0 \1\:AN \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.35e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.55814e-07 sd=160n sca=22.8052 \
        scb=0.0215313 scc=0.00209094 m=(1)
C1 (BN VSS) capacitor c=5.11761e-17
C2 (D VSS) capacitor c=4.88067e-17
C3 (Y VSS) capacitor c=4.11715e-17
C4 (VDD VSS) capacitor c=1.22067e-16
C5 (C VSS) capacitor c=3.96326e-17
C6 (AN VSS) capacitor c=8.48176e-17
C7 (n1 VSS) capacitor c=1.97461e-16
C8 (n0 VSS) capacitor c=9.2593e-17
C9 (n2 VSS) capacitor c=2.48566e-16
C10 (n3 VSS) capacitor c=1.08436e-16
C11 (n4 VSS) capacitor c=1.83285e-16
C12 (\1\:D VSS) capacitor c=1.67733e-16
C13 (\1\:C VSS) capacitor c=1.97899e-16
C14 (\1\:AN VSS) capacitor c=3.13601e-17
C15 (\1\:BN VSS) capacitor c=4.17992e-17
C16 (\3\:AN VSS) capacitor c=4.49826e-17
C17 (\3\:BN VSS) capacitor c=3.07454e-17
C18 (\3\:n0 VSS) capacitor c=8.413e-17
C19 (\2\:AN VSS) capacitor c=2.78467e-17
C20 (\2\:BN VSS) capacitor c=2.87729e-17
C21 (\9\:Y VSS) capacitor c=6.17728e-17
C22 (\3\:n3 VSS) capacitor c=9.32122e-17
C23 (\6\:VDD VSS) capacitor c=6.30876e-17
C24 (\9\:n0 VSS) capacitor c=5.83608e-17
C25 (\8\:VDD VSS) capacitor c=3.20007e-17
C26 (\9\:n1 VSS) capacitor c=5.39244e-17
C27 (\1\:VDD VSS) capacitor c=7.64431e-17
C28 (\1\:Y VSS) capacitor c=5.6049e-17
C29 (\3\:Y VSS) capacitor c=6.74746e-17
C30 (\5\:Y VSS) capacitor c=6.22757e-17
C31 (\7\:Y VSS) capacitor c=5.64077e-17
C32 (\11\:n0 VSS) capacitor c=5.03123e-17
C33 (\7\:n1 VSS) capacitor c=1.90704e-16
C34 (\4\:AN VSS) capacitor c=3.9233e-17
C35 (\4\:BN VSS) capacitor c=7.44468e-17
C36 (\7\:n0 VSS) capacitor c=6.73098e-17
C37 (\8\:n0 VSS) capacitor c=5.4884e-17
C38 (\6\:n1 VSS) capacitor c=1.76774e-16
C39 (\8\:C VSS) capacitor c=7.74608e-17
C40 (\8\:D VSS) capacitor c=6.02011e-17
C41 (\4\:VDD VSS) capacitor c=1.03707e-17
C42 (\5\:VDD VSS) capacitor c=1.19637e-17
Rk2 (BN \4\:BN) resistor r=0.1085 c=0
Rk12 (\8\:D D) resistor r=0.1691 c=0
Rk16 (\2\:Y Y) resistor r=0.1955 c=0
Rk13 (\2\:Y \4\:Y) resistor r=0.2877 c=0
Rk14 (\4\:Y \6\:Y) resistor r=0.3704 c=0
Rk15 (\6\:Y \8\:Y) resistor r=0.2975 c=0
Rk17 (Y \10\:Y) resistor r=0.2495 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.752 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.0349 c=0
Rk37 (\5\:VDD VDD) resistor r=0.165 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.3505 c=0
Rk38 (\4\:VDD \7\:VDD) resistor r=0.3456 c=0
Rk39 (\5\:VDD \9\:VDD) resistor r=0.2898 c=0
Rk10 (C \8\:C) resistor r=0.06228 c=0
Rk1 (\4\:AN AN) resistor r=0.1266 c=0
Rk28 (\10\:VSS VSS) resistor r=0.165 c=0
Rk27 (\1\:VSS \10\:VSS) resistor r=0.343 c=0
Rk33 (\10\:VSS \20\:VSS) resistor r=0.186 c=0
Rk6 (\6\:n1 \8\:n1) resistor r=1.4337 c=0
Rk7 (\8\:n1 \10\:n1) resistor r=0.3995 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3198 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.1901 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.1986 c=0
Rk11 (\2\:n3 \4\:n3) resistor r=0.5146 c=0
Rl1 (\1\:BN \2\:BN) resistor r=98.7687 c=0
Rl2 (\2\:BN \3\:BN) resistor r=39.1533 c=0
Rl3 (\1\:AN \2\:AN) resistor r=26.098 c=0
Rl4 (\2\:AN \3\:AN) resistor r=104.944 c=0
Rl6 (\3\:n0 n0) resistor r=7.0216 c=0
Rz3 (\2\:Y \1\:Y) resistor r=75 c=0
Rz4 (\4\:Y \3\:Y) resistor r=75 c=0
Rz5 (\6\:Y \5\:Y) resistor r=75 c=0
Rz6 (\8\:Y \7\:Y) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz14 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\8\:n1 \7\:n1) resistor r=75 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry8 (\10\:Y \9\:Y) resistor r=62 c=0
Ry14 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\10\:n1 \9\:n1) resistor r=62 c=0
Ry1 (\10\:n0 \9\:n0) resistor r=62 c=0
Ry6 (\2\:n3 n3) resistor r=62 c=0
Ry7 (\4\:n3 \3\:n3) resistor r=62 c=0
Rx2 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\8\:D \1\:D) resistor r=45 c=0
Rx5 (\8\:C \1\:C) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\6\:n1 n1) resistor r=45 c=0
Rx3 (\7\:n0 \3\:n0) resistor r=45 c=0
mn1 (\7\:n1 \3\:BN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.03e-14 ps=1.05e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\11\:n0 \3\:AN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=3.263e-14 ps=1.05e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.25e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\7\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn5_1__rcx (\1\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (\5\:Y n1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.165e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn4_1__rcx (\3\:Y \1\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp3_1__rcx (\3\:n3 n1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22308e-07 sb=3.45e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp4 (n4 \1\:C n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.9574 scb=0.019118 \
        scc=0.00277828 m=(2)
mp2_1__rcx (n2 \3\:n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.31e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=7.55e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp5 (\9\:Y \1\:D n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.45e-07 sd=160n sca=28.791 scb=0.0224678 \
        scc=0.00280266 m=(2)
ends NOR4BBX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:20 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BBX4
// View name: extracted

simulator lang=spectre

subckt NOR4BBX4 AN BN C D VDD VSS Y
mp1 (\18\:n1 \1\:BN \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=16.9422 \
        scb=0.0172816 scc=0.000388705 m=(1)
mp0 (\17\:n0 \1\:AN \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=13.2347 \
        scb=0.0110279 scc=0.000235823 m=(1)
mp5_1__rcx (Y \1\:D n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=12.0193 \
        scb=0.0100773 scc=0.000291813 m=(4)
mp3_1__rcx (\5\:n3 n1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(4)
mp4_1__rcx (n4 \1\:C n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(4)
mp2 (n2 n0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=11.7201 scb=0.00999512 \
        scc=0.000291798 m=(4)
C1 (BN VSS) capacitor c=1.00058e-16
C2 (D VSS) capacitor c=3.49783e-17
C3 (VDD VSS) capacitor c=3.06657e-16
C4 (C VSS) capacitor c=4.87056e-17
C5 (AN VSS) capacitor c=7.94216e-17
C6 (Y VSS) capacitor c=1.84957e-16
C7 (n1 VSS) capacitor c=3.073e-16
C8 (n0 VSS) capacitor c=3.0437e-16
C9 (n2 VSS) capacitor c=3.93358e-16
C10 (n3 VSS) capacitor c=1.58867e-16
C11 (n4 VSS) capacitor c=3.68174e-16
C12 (\1\:D VSS) capacitor c=3.2137e-16
C13 (\1\:C VSS) capacitor c=3.13128e-16
C14 (\1\:AN VSS) capacitor c=4.44805e-17
C15 (\1\:BN VSS) capacitor c=4.66609e-17
C16 (\3\:AN VSS) capacitor c=3.44906e-17
C17 (\3\:BN VSS) capacitor c=3.08708e-17
C18 (\2\:AN VSS) capacitor c=3.23091e-17
C19 (\2\:BN VSS) capacitor c=3.89292e-17
C20 (\5\:n3 VSS) capacitor c=1.3516e-16
C21 (\17\:n0 VSS) capacitor c=5.97706e-17
C22 (\10\:VDD VSS) capacitor c=3.30995e-17
C23 (\18\:n1 VSS) capacitor c=8.46237e-17
C24 (\1\:VDD VSS) capacitor c=2.07908e-16
C25 (\7\:Y VSS) capacitor c=1.14224e-16
C26 (\11\:Y VSS) capacitor c=1.14865e-16
C27 (\15\:Y VSS) capacitor c=1.4361e-16
C28 (\19\:n0 VSS) capacitor c=5.76574e-17
C29 (\16\:n1 VSS) capacitor c=2.49252e-16
C30 (\4\:BN VSS) capacitor c=3.42037e-17
C31 (\4\:AN VSS) capacitor c=5.13404e-17
C32 (\15\:n0 VSS) capacitor c=5.59675e-17
C33 (\16\:n0 VSS) capacitor c=6.65793e-17
C34 (\15\:n1 VSS) capacitor c=1.6417e-16
C35 (\16\:D VSS) capacitor c=6.73414e-17
C36 (\4\:Y VSS) capacitor c=1.06587e-16
C37 (\3\:VDD VSS) capacitor c=1.28559e-16
C38 (\9\:VDD VSS) capacitor c=2.09487e-17
Rk1 (\4\:BN BN) resistor r=0.02098 c=0
Rk19 (\16\:D D) resistor r=0.04495 c=0
Rk58 (\2\:VDD \3\:VDD) resistor r=0.9423 c=0
Rk64 (\9\:VDD VDD) resistor r=0.1675 c=0
Rk62 (\3\:VDD \9\:VDD) resistor r=0.3833 c=0
Rk63 (\9\:VDD \11\:VDD) resistor r=0.1804 c=0
Rk13 (\15\:C C) resistor r=0.002997 c=0
Rk2 (AN \4\:AN) resistor r=0.1348 c=0
Rk49 (\15\:VSS VSS) resistor r=0.1299 c=0
Rk48 (\1\:VSS \15\:VSS) resistor r=0.3606 c=0
Rk57 (\15\:VSS \31\:VSS) resistor r=0.2791 c=0
Rk25 (\7\:Y \11\:Y) resistor r=0.2972 c=0
Rk27 (\11\:Y \15\:Y) resistor r=0.2969 c=0
Rk21 (Y \4\:Y) resistor r=0.341 c=0
Rk23 (\4\:Y \7\:Y) resistor r=0.2983 c=0
Rk6 (\15\:n1 \17\:n1) resistor r=1.5866 c=0
Rk7 (\17\:n1 \19\:n1) resistor r=0.6493 c=0
Rk3 (\15\:n0 \16\:n0) resistor r=0.3138 c=0
Rk4 (\16\:n0 \18\:n0) resistor r=0.2641 c=0
Rk5 (\16\:n0 \20\:n0) resistor r=0.2621 c=0
Rk15 (n3 \5\:n3) resistor r=0.4344 c=0
Rl1 (\1\:BN \2\:BN) resistor r=92.3077 c=0
Rl2 (\2\:BN \3\:BN) resistor r=57.1429 c=0
Rl3 (\1\:AN \2\:AN) resistor r=91.0764 c=0
Rl4 (\2\:AN \3\:AN) resistor r=56.461 c=0
Rz21 (\2\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz22 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz20 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz2 (\17\:n1 \16\:n1) resistor r=75 c=0
Rz1 (\20\:n0 \19\:n0) resistor r=75 c=0
Ry23 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\19\:n1 \18\:n1) resistor r=62 c=0
Ry1 (\18\:n0 \17\:n0) resistor r=20.6667 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\16\:D \1\:D) resistor r=45 c=0
Rx5 (\15\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\15\:n1 n1) resistor r=45 c=0
Rx3 (\15\:n0 n0) resistor r=45 c=0
mn1 (\16\:n1 \3\:BN \30\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\19\:n0 \3\:AN \30\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn5_1__rcx (\4\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.55e-14 ps=8.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mn4_1__rcx (\7\:Y \1\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=1.605e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mn3_1__rcx (\11\:Y n1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
mn2_1__rcx (\15\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
ends NOR4BBX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:22 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BBXL
// View name: extracted

simulator lang=spectre

subckt NOR4BBXL AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=49.4198 \
        scb=0.0326741 scc=0.00592591 m=(1)
mp5 (\4\:Y \1\:D n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.6e-07 sd=160n sca=10.2576 scb=0.00735405 \
        scc=7.25622e-05 m=(1)
mp4 (n4 \1\:C n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=2.472e-14 \
        ad=1.29e-14 ps=6.6e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.55e-07 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp3 (n3 n1 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.408e-14 \
        ad=2.473e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.95e-07 sd=160n sca=10.4338 scb=0.00740954 \
        scc=7.25741e-05 m=(1)
mp2 (n2 \4\:n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=3.45e-07 sd=160n sca=11.603 \
        scb=0.00833729 scc=7.42936e-05 m=(1)
mp0 (\5\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.4e-07 sd=160n sca=14.4159 \
        scb=0.0128226 scc=0.000143703 m=(1)
C1 (AN VSS) capacitor c=4.70827e-17
C2 (Y VSS) capacitor c=9.38392e-17
C3 (C VSS) capacitor c=3.71993e-17
C4 (D VSS) capacitor c=6.73577e-17
C5 (VDD VSS) capacitor c=1.6132e-16
C6 (n1 VSS) capacitor c=7.80214e-17
C7 (n0 VSS) capacitor c=2.25807e-17
C8 (n4 VSS) capacitor c=1.5042e-18
C9 (n3 VSS) capacitor c=2.65872e-18
C10 (n2 VSS) capacitor c=5.28568e-18
C11 (\1\:AN VSS) capacitor c=3.25888e-17
C12 (\4\:n0 VSS) capacitor c=7.55572e-17
C13 (\1\:C VSS) capacitor c=6.53781e-17
C14 (\1\:D VSS) capacitor c=7.21675e-17
C15 (\1\:BN VSS) capacitor c=2.81338e-17
C16 (\3\:AN VSS) capacitor c=7.50831e-17
C17 (\3\:n0 VSS) capacitor c=2.949e-17
C18 (\4\:n1 VSS) capacitor c=3.9988e-17
C19 (\3\:C VSS) capacitor c=7.92613e-17
C20 (\3\:D VSS) capacitor c=5.85066e-17
C21 (\3\:BN VSS) capacitor c=2.41369e-17
C22 (\2\:AN VSS) capacitor c=5.56846e-17
C23 (\3\:n1 VSS) capacitor c=2.78987e-17
C24 (\2\:C VSS) capacitor c=8.73646e-17
C25 (\2\:D VSS) capacitor c=5.59654e-17
C26 (\2\:BN VSS) capacitor c=2.33826e-17
C27 (\5\:n0 VSS) capacitor c=7.47057e-17
C28 (\1\:VDD VSS) capacitor c=5.25165e-17
C29 (\4\:Y VSS) capacitor c=7.79834e-17
C30 (\9\:n1 VSS) capacitor c=6.69379e-17
C31 (\6\:VDD VSS) capacitor c=4.32837e-17
C32 (\9\:n0 VSS) capacitor c=2.46753e-17
C33 (\1\:Y VSS) capacitor c=3.20497e-17
C34 (\6\:Y VSS) capacitor c=6.6607e-17
C35 (\7\:n1 VSS) capacitor c=1.44878e-17
C36 (\2\:n1 VSS) capacitor c=5.32926e-17
C37 (\2\:n0 VSS) capacitor c=5.26101e-17
C38 (\4\:BN VSS) capacitor c=3.23423e-17
C39 (\6\:BN VSS) capacitor c=5.6589e-17
C40 (\4\:D VSS) capacitor c=4.1533e-17
C41 (\4\:C VSS) capacitor c=6.47517e-17
C42 (\5\:n1 VSS) capacitor c=8.03686e-17
C43 (\6\:n1 VSS) capacitor c=6.80257e-17
C44 (\3\:Y VSS) capacitor c=6.48446e-17
C45 (\4\:AN VSS) capacitor c=5.34595e-17
C46 (\7\:n0 VSS) capacitor c=7.22209e-17
C47 (\8\:n0 VSS) capacitor c=3.92852e-17
C48 (\4\:VDD VSS) capacitor c=4.73724e-17
C49 (\5\:VDD VSS) capacitor c=1.35283e-17
Rk1 (\4\:BN BN) resistor r=0.009523 c=0
Rk3 (\4\:BN \6\:BN) resistor r=0.08106 c=0
Rk2 (\5\:BN \6\:BN) resistor r=0.009523 c=0
Rk13 (\4\:AN AN) resistor r=0.1852 c=0
Rk10 (\3\:Y Y) resistor r=0.2585 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.1247 c=0
Rk11 (Y \5\:Y) resistor r=0.6791 c=0
Rk12 (\3\:Y \7\:Y) resistor r=0.4067 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.4082 c=0
Rk22 (\3\:VSS \5\:VSS) resistor r=0.03239 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.1878 c=0
Rk25 (\7\:VSS VSS) resistor r=0.08478 c=0
Rk24 (\6\:VSS \7\:VSS) resistor r=0.1776 c=0
Rk26 (\3\:VSS \9\:VSS) resistor r=0.1787 c=0
Rk27 (\6\:VSS \11\:VSS) resistor r=0.07358 c=0
Rk28 (\7\:VSS \13\:VSS) resistor r=0.07358 c=0
Rk5 (\4\:C C) resistor r=0.05486 c=0
Rk4 (\4\:D D) resistor r=0.02433 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4632 c=0
Rk19 (\5\:VDD VDD) resistor r=0.1023 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.3482 c=0
Rk20 (\5\:VDD \7\:VDD) resistor r=0.4207 c=0
Rk6 (\5\:n1 \6\:n1) resistor r=0.397 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.1263 c=0
Rk8 (\6\:n1 \10\:n1) resistor r=0.316 c=0
Rk14 (\6\:n0 \7\:n0) resistor r=0.6684 c=0
Rk15 (\7\:n0 \8\:n0) resistor r=0.2776 c=0
Rk16 (\7\:n0 \10\:n0) resistor r=0.2342 c=0
Rl1 (\1\:BN \2\:BN) resistor r=48.0769 c=0
Rl2 (\2\:BN \3\:BN) resistor r=39.8352 c=0
Rl13 (\1\:AN \2\:AN) resistor r=33.3841 c=0
Rl14 (\2\:AN \3\:AN) resistor r=268 c=0
Rl5 (\1\:C \2\:C) resistor r=45.9489 c=0
Rl6 (\2\:C \3\:C) resistor r=253.823 c=0
Rl3 (\1\:D \2\:D) resistor r=80.7464 c=0
Rl4 (\2\:D \3\:D) resistor r=257.487 c=0
Rl7 (n1 \2\:n1) resistor r=220.033 c=0
Rl9 (\2\:n1 \4\:n1) resistor r=96.9565 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=2.4801 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=272.791 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=45.868 c=0
Rl10 (n0 \2\:n0) resistor r=2.0213 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\6\:Y \7\:Y) resistor r=75 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz4 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\4\:Y \5\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\2\:BN \5\:BN) resistor r=45 c=0
Rx5 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx6 (n0 \8\:n0) resistor r=45 c=0
mn1 (\7\:n1 \3\:BN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.215e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn5 (\6\:Y \3\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.005e-06 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn4 (\6\:Y \3\:C \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \4\:n1 \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.973e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.95e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.973e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\9\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
ends NOR4BBXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:23 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BX1
// View name: extracted

simulator lang=spectre

subckt NOR4BX1 AN B C D VDD VSS Y
mp4 (\6\:Y \1\:D n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.73846e-07 sd=160n sca=17.2376 scb=0.0171686 \
        scc=0.000563105 m=(1)
mp3 (n3 \1\:C n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.68846e-07 sd=160n sca=15.3527 scb=0.0138144 \
        scc=0.000491181 m=(1)
mp2 (n2 \1\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.825e-14 ps=1.01e-06 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=4.48846e-07 sd=160n sca=14.2604 scb=0.0119242 \
        scc=0.000478605 m=(1)
mp1 (n1 \3\:n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.485e-14 ps=1.16e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.88846e-07 sd=160n sca=14.7087 \
        scb=0.0126621 scc=0.000481524 m=(1)
C1 (Y VSS) capacitor c=1.26341e-17
C2 (B VSS) capacitor c=8.31429e-17
C3 (VDD VSS) capacitor c=1.14174e-16
C4 (C VSS) capacitor c=2.00009e-17
C5 (AN VSS) capacitor c=3.93306e-17
C6 (n0 VSS) capacitor c=4.26448e-17
C7 (n2 VSS) capacitor c=1.99728e-18
C8 (\3\:AN VSS) capacitor c=4.35936e-17
C9 (\3\:n0 VSS) capacitor c=7.64817e-17
C10 (\1\:B VSS) capacitor c=5.46374e-17
C11 (\1\:C VSS) capacitor c=7.59096e-17
C12 (\1\:D VSS) capacitor c=7.39531e-17
C13 (\1\:AN VSS) capacitor c=3.2864e-17
C14 (\3\:B VSS) capacitor c=5.28659e-17
C15 (\3\:C VSS) capacitor c=5.34318e-17
C16 (\3\:D VSS) capacitor c=3.88424e-17
C17 (\2\:AN VSS) capacitor c=4.32498e-17
C18 (\2\:n0 VSS) capacitor c=5.66721e-17
C19 (\2\:B VSS) capacitor c=5.61017e-17
C20 (\2\:C VSS) capacitor c=5.90679e-17
C21 (\2\:D VSS) capacitor c=5.68318e-17
C22 (\7\:n0 VSS) capacitor c=5.60337e-17
C23 (\1\:VDD VSS) capacitor c=4.70176e-17
C24 (\6\:Y VSS) capacitor c=5.10841e-17
C25 (\5\:n0 VSS) capacitor c=7.83558e-17
C26 (\1\:Y VSS) capacitor c=7.4278e-17
C27 (\3\:Y VSS) capacitor c=4.93178e-17
C28 (\4\:D VSS) capacitor c=7.86768e-17
C29 (\4\:C VSS) capacitor c=4.9241e-17
C30 (\5\:Y VSS) capacitor c=8.34583e-17
C31 (\4\:AN VSS) capacitor c=5.68229e-17
C32 (\4\:n0 VSS) capacitor c=7.44032e-17
C33 (\4\:VDD VSS) capacitor c=2.87413e-17
Rk11 (\2\:VSS \4\:VSS) resistor r=0.3492 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.06226 c=0
Rk14 (\6\:VSS VSS) resistor r=0.03203 c=0
Rk13 (\5\:VSS \6\:VSS) resistor r=0.2045 c=0
Rk15 (\5\:VSS \8\:VSS) resistor r=0.1982 c=0
Rk16 (\6\:VSS \10\:VSS) resistor r=0.1982 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.3382 c=0
Rk6 (\5\:Y Y) resistor r=0.004828 c=0
Rk5 (\4\:Y \5\:Y) resistor r=0.2692 c=0
Rk7 (\5\:Y \7\:Y) resistor r=0.5372 c=0
Rk3 (B \4\:B) resistor r=0.00406 c=0
Rk18 (\4\:VDD VDD) resistor r=0.2995 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4258 c=0
Rk2 (C \4\:C) resistor r=0.1134 c=0
Rk1 (\4\:D D) resistor r=0.01679 c=0
Rk8 (AN \4\:AN) resistor r=0.09359 c=0
Rk9 (\4\:n0 \6\:n0) resistor r=0.3044 c=0
Rk10 (\6\:n0 \8\:n0) resistor r=0.5005 c=0
Rl5 (\1\:B \2\:B) resistor r=62.2302 c=0
Rl6 (\2\:B \3\:B) resistor r=106.461 c=0
Rl3 (\1\:C \2\:C) resistor r=56.461 c=0
Rl4 (\2\:C \3\:C) resistor r=112.23 c=0
Rl1 (\1\:D \2\:D) resistor r=70.9439 c=0
Rl2 (\2\:D \3\:D) resistor r=101.099 c=0
Rl10 (\2\:AN \3\:AN) resistor r=116.54 c=0
Rl9 (\1\:AN \2\:AN) resistor r=49.2328 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=128.079 c=0
Rl7 (n0 \2\:n0) resistor r=37.6944 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry1 (\6\:Y \7\:Y) resistor r=31 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn4 (\3\:Y \3\:D \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.01058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn3 (\3\:Y \3\:C \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.96058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn2 (\1\:Y \3\:B \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.76058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1 (\1\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.71058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn0 (\5\:n0 \1\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp0 (\7\:n0 \3\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.762e-14 ps=1.16e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.75e-07 sd=160n sca=21.1756 \
        scb=0.0235868 scc=0.00103894 m=(1)
ends NOR4BX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:24 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BX2
// View name: extracted

simulator lang=spectre

subckt NOR4BX2 AN B C D VDD VSS Y
mp0 (\12\:n0 \1\:AN \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.41e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.58605e-07 sd=160n sca=36.537 \
        scb=0.0294967 scc=0.00430052 m=(1)
C1 (C VSS) capacitor c=4.08597e-17
C2 (Y VSS) capacitor c=1.65728e-16
C3 (VDD VSS) capacitor c=1.6905e-16
C4 (B VSS) capacitor c=5.31962e-17
C5 (AN VSS) capacitor c=3.81284e-17
C6 (D VSS) capacitor c=5.73956e-17
C7 (n0 VSS) capacitor c=7.03165e-17
C8 (n1 VSS) capacitor c=2.18383e-16
C9 (n2 VSS) capacitor c=9.82708e-17
C10 (n3 VSS) capacitor c=1.91683e-16
C11 (\1\:D VSS) capacitor c=8.5314e-17
C12 (\1\:C VSS) capacitor c=1.12004e-16
C13 (\1\:AN VSS) capacitor c=2.3598e-17
C14 (\1\:B VSS) capacitor c=7.66721e-17
C15 (\3\:AN VSS) capacitor c=2.49397e-17
C16 (\3\:D VSS) capacitor c=1.46504e-17
C17 (\3\:B VSS) capacitor c=1.0583e-16
C18 (\3\:n0 VSS) capacitor c=1.21537e-17
C19 (\2\:AN VSS) capacitor c=1.9221e-17
C20 (\10\:Y VSS) capacitor c=1.81052e-16
C21 (\3\:n2 VSS) capacitor c=9.19337e-17
C22 (\6\:VDD VSS) capacitor c=4.34258e-17
C23 (\12\:n0 VSS) capacitor c=1.49795e-17
C24 (\8\:VDD VSS) capacitor c=2.64843e-17
C25 (\1\:VDD VSS) capacitor c=9.93031e-17
C26 (\1\:Y VSS) capacitor c=4.45821e-17
C27 (\3\:Y VSS) capacitor c=7.07905e-17
C28 (\5\:Y VSS) capacitor c=3.83825e-17
C29 (\8\:Y VSS) capacitor c=2.93229e-17
C30 (\10\:n0 VSS) capacitor c=2.28354e-17
C31 (\4\:n0 VSS) capacitor c=8.0428e-17
C32 (\3\:C VSS) capacitor c=8.84287e-17
C33 (\4\:D VSS) capacitor c=7.58433e-17
C34 (\4\:AN VSS) capacitor c=4.96369e-17
C35 (\8\:n0 VSS) capacitor c=2.38369e-17
C36 (\9\:n0 VSS) capacitor c=3.39246e-17
C37 (\7\:B VSS) capacitor c=5.91421e-17
C38 (\7\:C VSS) capacitor c=7.74179e-17
C39 (\7\:Y VSS) capacitor c=3.6029e-17
C40 (\8\:D VSS) capacitor c=3.67188e-17
C41 (\4\:VDD VSS) capacitor c=1.49414e-17
C42 (\5\:VDD VSS) capacitor c=8.82321e-18
Rk21 (\2\:VSS \3\:VSS) resistor r=0.05493 c=0
Rk30 (\14\:VSS VSS) resistor r=0.1123 c=0
Rk29 (\3\:VSS \14\:VSS) resistor r=0.2276 c=0
Rk33 (\14\:VSS \20\:VSS) resistor r=0.362 c=0
Rk9 (C \7\:C) resistor r=0.06779 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.2725 c=0
Rk11 (\4\:Y \6\:Y) resistor r=0.2954 c=0
Rk14 (\7\:Y Y) resistor r=0.2136 c=0
Rk12 (\6\:Y \7\:Y) resistor r=0.07033 c=0
Rk13 (\7\:Y \9\:Y) resistor r=0.2141 c=0
Rk15 (Y \11\:Y) resistor r=0.9982 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.7016 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.1351 c=0
Rk37 (\5\:VDD VDD) resistor r=0.03965 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.3755 c=0
Rk38 (\4\:VDD \7\:VDD) resistor r=0.2191 c=0
Rk39 (\5\:VDD \9\:VDD) resistor r=0.3985 c=0
Rk7 (\7\:B B) resistor r=0.1211 c=0
Rk1 (\4\:AN AN) resistor r=0.1719 c=0
Rk16 (\8\:D \9\:D) resistor r=0.01775 c=0
Rk17 (\10\:D D) resistor r=0.01788 c=0
Rk18 (\9\:D \10\:D) resistor r=0.04313 c=0
Rk2 (\8\:n0 \9\:n0) resistor r=0.1459 c=0
Rk3 (\9\:n0 \11\:n0) resistor r=0.1384 c=0
Rk4 (\9\:n0 \13\:n0) resistor r=0.09946 c=0
Rk8 (\2\:n2 \4\:n2) resistor r=0.5221 c=0
Rl15 (\3\:C \1\:C) resistor r=62.4901 c=0
Rl10 (\3\:B \1\:B) resistor r=29.4415 c=0
Rl1 (\1\:AN \2\:AN) resistor r=35.7713 c=0
Rl2 (\2\:AN \3\:AN) resistor r=37.6944 c=0
Rl20 (\1\:D \3\:D) resistor r=78.2445 c=0
Rl21 (\4\:D \3\:D) resistor r=4.3511 c=0
Rl4 (\3\:n0 n0) resistor r=59.5407 c=0
Rl5 (\4\:n0 \3\:n0) resistor r=12.1383 c=0
Rz11 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\2\:Y \1\:Y) resistor r=75 c=0
Rz3 (\4\:Y \3\:Y) resistor r=75 c=0
Rz4 (\6\:Y \5\:Y) resistor r=75 c=0
Rz5 (\9\:Y \8\:Y) resistor r=75 c=0
Rz12 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz13 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\11\:Y \10\:Y) resistor r=62 c=0
Ry13 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry14 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry5 (\2\:n2 n2) resistor r=62 c=0
Ry6 (\4\:n2 \3\:n2) resistor r=62 c=0
Rx4 (\7\:C \1\:C) resistor r=45 c=0
Rx3 (\7\:B \3\:B) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\8\:D \3\:D) resistor r=45 c=0
Rx2 (\8\:n0 \3\:n0) resistor r=45 c=0
mn0 (\10\:n0 \3\:AN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1_1__rcx (\8\:Y n0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.263e-14 ad=4.16e-14 ps=1.035e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.615e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn2_1__rcx (\5\:Y \1\:B \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.205e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn3_1__rcx (\3\:Y \3\:C \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn4_1__rcx (\1\:Y \4\:D \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.45e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mp2_1__rcx (n2 \3\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.35641e-07 sb=3.45e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\10\:Y \1\:D n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.45e-07 sd=160n sca=17.0995 scb=0.0163575 \
        scc=0.000685689 m=(2)
mp1 (n1 \4\:n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.57e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25641e-07 sb=7.55e-07 sd=160n sca=13.7988 \
        scb=0.0122414 scc=0.000647521 m=(2)
mp3 (n3 \1\:C \3\:n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=13.895 scb=0.0122763 \
        scc=0.000647531 m=(2)
ends NOR4BX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:25 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BX4
// View name: extracted

simulator lang=spectre

subckt NOR4BX4 AN B C D VDD VSS Y
mp0 (\20\:n0 \1\:AN \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.8e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23077e-07 sd=160n sca=38.3623 \
        scb=0.0317516 scc=0.00376558 m=(1)
mp3 (n3 C n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp2_1__rcx (\4\:n2 B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.386e-14 ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.60641e-07 sb=7.65e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(4)
mp4_1__rcx (\18\:Y D n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=13.6362 \
        scb=0.0121968 scc=0.000647514 m=(4)
mp1 (n1 n0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.051e-14 ps=1.1e-06 pd=1.0975e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.25641e-07 sb=1.6e-06 sd=160n sca=12.8019 scb=0.0109628 \
        scc=0.00041245 m=(4)
C1 (C VSS) capacitor c=4.40254e-16
C2 (Y VSS) capacitor c=2.39114e-16
C3 (VDD VSS) capacitor c=2.47283e-16
C4 (B VSS) capacitor c=3.97884e-16
C5 (AN VSS) capacitor c=3.16387e-17
C6 (D VSS) capacitor c=3.95504e-16
C7 (n0 VSS) capacitor c=3.306e-16
C8 (n1 VSS) capacitor c=4.01476e-16
C9 (n2 VSS) capacitor c=1.73855e-16
C10 (n3 VSS) capacitor c=3.63303e-16
C11 (\1\:AN VSS) capacitor c=3.45106e-17
C12 (\3\:AN VSS) capacitor c=2.82929e-17
C13 (\2\:AN VSS) capacitor c=1.73094e-17
C14 (\18\:Y VSS) capacitor c=3.46618e-16
C15 (\4\:n2 VSS) capacitor c=1.63791e-16
C16 (\20\:n0 VSS) capacitor c=2.1481e-17
C17 (\11\:VDD VSS) capacitor c=2.67551e-17
C18 (\1\:VDD VSS) capacitor c=1.47134e-16
C19 (\1\:Y VSS) capacitor c=9.63472e-17
C20 (\5\:Y VSS) capacitor c=1.17002e-16
C21 (\9\:Y VSS) capacitor c=9.29682e-17
C22 (\14\:Y VSS) capacitor c=1.15427e-16
C23 (\18\:n0 VSS) capacitor c=1.89329e-17
C24 (\4\:AN VSS) capacitor c=6.1599e-17
C25 (\17\:n0 VSS) capacitor c=4.43246e-17
C26 (\13\:Y VSS) capacitor c=4.05608e-17
C27 (\3\:VDD VSS) capacitor c=1.40902e-16
C28 (\6\:VDD VSS) capacitor c=9.18494e-18
Rk48 (\14\:VSS VSS) resistor r=0.03712 c=0
Rk47 (\1\:VSS \14\:VSS) resistor r=0.2501 c=0
Rk57 (\14\:VSS \32\:VSS) resistor r=0.272 c=0
Rk31 (Y \18\:Y) resistor r=1.4551 c=0
Rk23 (\1\:Y \5\:Y) resistor r=0.2626 c=0
Rk25 (\5\:Y \9\:Y) resistor r=0.2626 c=0
Rk30 (\13\:Y Y) resistor r=0.3021 c=0
Rk27 (\9\:Y \13\:Y) resistor r=0.04705 c=0
Rk28 (\13\:Y \14\:Y) resistor r=0.237 c=0
Rk58 (\2\:VDD \3\:VDD) resistor r=1.0667 c=0
Rk62 (\6\:VDD VDD) resistor r=0.03712 c=0
Rk61 (\3\:VDD \6\:VDD) resistor r=0.3427 c=0
Rk65 (\6\:VDD \12\:VDD) resistor r=0.3383 c=0
Rk1 (\4\:AN AN) resistor r=0.08125 c=0
Rk3 (n0 \17\:n0) resistor r=0.3699 c=0
Rk4 (\17\:n0 \19\:n0) resistor r=0.1248 c=0
Rk5 (\17\:n0 \21\:n0) resistor r=0.1664 c=0
Rk16 (n2 \4\:n2) resistor r=0.4476 c=0
Rl1 (\1\:AN \2\:AN) resistor r=47.3097 c=0
Rl2 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rz19 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=7.5 c=0
Rz21 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry22 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\21\:n0 \20\:n0) resistor r=62 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
mn0 (\18\:n0 \3\:AN \31\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=5.06e-14 ps=8e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.94615e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn4_1__rcx (\1\:Y D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
mn3 (\5\:Y C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.575e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mn2 (\9\:Y B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
mn1 (\14\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.299e-14 ad=4.16e-14 ps=9.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
ends NOR4BX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:26 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4BXL
// View name: extracted

simulator lang=spectre

subckt NOR4BXL AN B C D VDD VSS Y
mp4 (\6\:Y \1\:D n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.01e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=34.5672 \
        scb=0.0266035 scc=0.00427242 m=(1)
mp3 (n3 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.7e-07 sb=7.75e-07 sd=160n sca=33.8938 scb=0.0260321 \
        scc=0.00427143 m=(1)
mp2 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.87e-14 \
        ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.75e-07 sb=5.7e-07 sd=160n sca=33.5475 scb=0.0258591 \
        scc=0.00427134 m=(1)
mp1 (n1 n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 nrs=1.16667 sa=7e-07 \
        sb=3.45e-07 sd=160n sca=34.4077 scb=0.0264408 scc=0.00427202 m=(1)
mp0 (\8\:n0 \1\:AN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.4e-07 sd=160n sca=36.537 \
        scb=0.0294967 scc=0.00430052 m=(1)
C1 (B VSS) capacitor c=5.53562e-17
C2 (Y VSS) capacitor c=8.88043e-17
C3 (C VSS) capacitor c=4.5168e-17
C4 (D VSS) capacitor c=4.55476e-17
C5 (AN VSS) capacitor c=7.56629e-17
C6 (VDD VSS) capacitor c=1.03374e-16
C7 (n0 VSS) capacitor c=5.12578e-17
C8 (n3 VSS) capacitor c=3.58718e-18
C9 (n2 VSS) capacitor c=1.31157e-18
C10 (n1 VSS) capacitor c=4.81392e-18
C11 (\1\:AN VSS) capacitor c=3.87347e-17
C12 (\1\:B VSS) capacitor c=3.79516e-17
C13 (\1\:C VSS) capacitor c=4.85632e-17
C14 (\1\:D VSS) capacitor c=4.36981e-17
C15 (\3\:AN VSS) capacitor c=4.05448e-17
C16 (\3\:n0 VSS) capacitor c=3.25921e-17
C17 (\3\:B VSS) capacitor c=4.25595e-17
C18 (\3\:C VSS) capacitor c=4.86018e-17
C19 (\3\:D VSS) capacitor c=4.23202e-17
C20 (\2\:AN VSS) capacitor c=4.08469e-17
C21 (\2\:n0 VSS) capacitor c=5.04891e-17
C22 (\2\:B VSS) capacitor c=5.06059e-17
C23 (\2\:C VSS) capacitor c=5.11645e-17
C24 (\2\:D VSS) capacitor c=4.88854e-17
C25 (\8\:n0 VSS) capacitor c=8.1842e-17
C26 (\1\:VDD VSS) capacitor c=3.29954e-17
C27 (\6\:Y VSS) capacitor c=6.9305e-17
C28 (\4\:n0 VSS) capacitor c=1.93484e-17
C29 (\4\:Y VSS) capacitor c=7.1936e-17
C30 (\1\:Y VSS) capacitor c=2.6436e-17
C31 (\4\:D VSS) capacitor c=6.77864e-17
C32 (\4\:C VSS) capacitor c=5.51588e-17
C33 (\3\:Y VSS) capacitor c=7.86611e-17
C34 (\4\:B VSS) capacitor c=3.68842e-17
C35 (\4\:AN VSS) capacitor c=2.61416e-17
C36 (\6\:n0 VSS) capacitor c=6.44997e-17
C37 (\7\:n0 VSS) capacitor c=3.78861e-17
C38 (\4\:VDD VSS) capacitor c=3.53644e-17
Rk7 (\4\:B B) resistor r=0.1578 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.3651 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.02978 c=0
Rk17 (\6\:VSS VSS) resistor r=0.1644 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.2045 c=0
Rk18 (\5\:VSS \8\:VSS) resistor r=0.1782 c=0
Rk19 (\6\:VSS \10\:VSS) resistor r=0.1777 c=0
Rk4 (\3\:Y Y) resistor r=0.4804 c=0
Rk3 (\2\:Y \3\:Y) resistor r=0.09909 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.3772 c=0
Rk6 (Y \7\:Y) resistor r=0.535 c=0
Rk2 (\4\:C C) resistor r=0.185 c=0
Rk1 (D \4\:D) resistor r=0.0638 c=0
Rk8 (AN \4\:AN) resistor r=0.1458 c=0
Rk13 (\4\:VDD VDD) resistor r=0.3995 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.5856 c=0
Rk9 (\5\:n0 \6\:n0) resistor r=0.09588 c=0
Rk10 (\6\:n0 \7\:n0) resistor r=0.2001 c=0
Rk11 (\6\:n0 \9\:n0) resistor r=0.6626 c=0
Rl5 (\1\:B \2\:B) resistor r=83.3841 c=0
Rl6 (\2\:B \3\:B) resistor r=100.692 c=0
Rl3 (\1\:C \2\:C) resistor r=64.1533 c=0
Rl4 (\2\:C \3\:C) resistor r=119.922 c=0
Rl1 (\1\:D \2\:D) resistor r=53.8233 c=0
Rl2 (\2\:D \3\:D) resistor r=140.18 c=0
Rl9 (\1\:AN \2\:AN) resistor r=81.9251 c=0
Rl10 (\2\:AN \3\:AN) resistor r=99.2328 c=0
Rl7 (n0 \2\:n0) resistor r=144.923 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz3 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry1 (\6\:Y \7\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:n0 \7\:n0) resistor r=45 c=0
mn4 (\1\:Y \3\:D \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y \3\:C \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\4\:Y \3\:B \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.7e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\4\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn0 (\4\:n0 \3\:AN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
ends NOR4BXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:27 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4X1
// View name: extracted

simulator lang=spectre

subckt NOR4X1 A B C D VDD VSS Y
mp0 (n0 \1\:A \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=39.8224 \
        scb=0.0332643 scc=0.00388272 m=(1)
mp1 (n1 \1\:B n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.65e-07 sd=160n sca=36.1614 scb=0.0267849 \
        scc=0.00344655 m=(1)
mp2 (n2 \1\:C n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.63e-14 \
        ad=4.095e-14 ps=1.12e-06 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=3.5e-07 sd=160n sca=35.408 scb=0.0252222 \
        scc=0.00339762 m=(1)
mp3 (\1\:Y \3\:D n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=7.8e-14 ps=9.9e-07 pd=1.18e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-07 sd=160n sca=39.5482 scb=0.03284 scc=0.00384048 \
        m=(1)
C1 (VDD VSS) capacitor c=4.66057e-17
C2 (B VSS) capacitor c=7.90819e-17
C3 (D VSS) capacitor c=3.02264e-17
C4 (A VSS) capacitor c=2.18523e-17
C5 (Y VSS) capacitor c=2.88164e-17
C6 (C VSS) capacitor c=6.07363e-17
C7 (n0 VSS) capacitor c=2.60266e-18
C8 (n1 VSS) capacitor c=7.65769e-18
C9 (n2 VSS) capacitor c=2.19493e-18
C10 (\3\:D VSS) capacitor c=4.29691e-17
C11 (\1\:C VSS) capacitor c=5.06627e-17
C12 (\1\:B VSS) capacitor c=6.94901e-17
C13 (\1\:A VSS) capacitor c=7.00855e-17
C14 (\1\:D VSS) capacitor c=3.30761e-17
C15 (\3\:C VSS) capacitor c=4.39098e-17
C16 (\3\:B VSS) capacitor c=4.72057e-17
C17 (\3\:A VSS) capacitor c=2.76906e-17
C18 (\2\:D VSS) capacitor c=2.79923e-17
C19 (\2\:C VSS) capacitor c=3.507e-17
C20 (\2\:B VSS) capacitor c=4.37818e-17
C21 (\2\:A VSS) capacitor c=4.18092e-17
C22 (\1\:Y VSS) capacitor c=7.27681e-17
C23 (\4\:VDD VSS) capacitor c=6.82707e-17
C24 (\3\:Y VSS) capacitor c=8.42843e-17
C25 (\5\:Y VSS) capacitor c=5.47018e-17
C26 (\4\:A VSS) capacitor c=3.30808e-17
C27 (\4\:B VSS) capacitor c=3.9619e-17
C28 (\4\:C VSS) capacitor c=7.57567e-17
C29 (\4\:D VSS) capacitor c=5.96172e-17
C30 (\3\:VDD VSS) capacitor c=4.03929e-17
Rk13 (\3\:VDD VDD) resistor r=0.02966 c=0
Rk14 (\3\:VDD \5\:VDD) resistor r=0.3943 c=0
Rk2 (\4\:B B) resistor r=0.1701 c=0
Rk4 (D \4\:D) resistor r=0.02918 c=0
Rk1 (\4\:A A) resistor r=0.06282 c=0
Rk9 (\4\:VSS VSS) resistor r=0.2018 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.4508 c=0
Rk10 (\4\:VSS \6\:VSS) resistor r=0.3016 c=0
Rk11 (VSS \8\:VSS) resistor r=0.06386 c=0
Rk5 (Y \2\:Y) resistor r=0.1984 c=0
Rk6 (\2\:Y \4\:Y) resistor r=0.4988 c=0
Rk7 (\4\:Y \6\:Y) resistor r=0.2869 c=0
Rk3 (\4\:C C) resistor r=0.3466 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=56.461 c=0
Rl8 (\2\:D \3\:D) resistor r=29.9451 c=0
Rl7 (\1\:D \2\:D) resistor r=57.6923 c=0
Rl1 (\1\:A \2\:A) resistor r=55.5593 c=0
Rl2 (\2\:A \3\:A) resistor r=33.7912 c=0
Rl5 (\1\:C \2\:C) resistor r=29.5379 c=0
Rl6 (\2\:C \3\:C) resistor r=56.461 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\5\:Y \6\:Y) resistor r=75 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (\5\:Y \3\:A \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.83e-14 ad=4.16e-14 ps=1.42e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.65e-07 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(1)
mn1 (\5\:Y \3\:B \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.6e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn2 (\3\:Y \3\:C \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn3 (\3\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
ends NOR4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:28 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4X2
// View name: extracted

simulator lang=spectre

subckt NOR4X2 A B C D VDD VSS Y
mp0_1__rcx (3 \1\:A \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.42e-06 sd=160n sca=18.6506 \
        scb=0.0190998 scc=0.000768188 m=(1)
mp1_1__rcx (3 \1\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.315e-06 sd=160n sca=16.4248 \
        scb=0.0152088 scc=0.000666128 m=(1)
mp2_1__rcx (8 \1\:C 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=9.75e-14 ps=1.13e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.095e-06 sd=160n sca=14.4756 \
        scb=0.0126313 scc=0.000647839 m=(1)
mp3_1__rcx (\9\:Y \4\:D 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.75e-14 ad=6.24e-14 ps=1.28e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=8e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3 (\9\:Y \1\:D 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.65e-07 sb=5.95e-07 sd=160n sca=13.8806 scb=0.0122706 \
        scc=0.000647529 m=(1)
mp2 (6 \4\:C 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=4.485e-14 ps=1.01e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.125e-06 sb=4.35e-07 sd=160n sca=14.5014 scb=0.0126527 \
        scc=0.000647871 m=(1)
mp1 (6 \6\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=4.485e-14 ps=9e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.285e-06 sb=2.75e-07 sd=160n sca=15.7201 scb=0.0141032 \
        scc=0.000654378 m=(1)
mp0 (4 \6\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=2.34e-14 ps=1.57e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.7e-07 sd=160n sca=17.2962 \
        scb=0.0167016 scc=0.000693147 m=(1)
C1 (C VSS) capacitor c=4.47206e-17
C2 (D VSS) capacitor c=7.9145e-17
C3 (A VSS) capacitor c=5.52587e-16
C4 (Y VSS) capacitor c=1.29743e-16
C5 (VDD VSS) capacitor c=1.30748e-16
C6 (3 VSS) capacitor c=2.71439e-18
C7 (2 VSS) capacitor c=6.11733e-18
C8 (8 VSS) capacitor c=1.14642e-17
C9 (5 VSS) capacitor c=6.26401e-18
C10 (6 VSS) capacitor c=5.8704e-18
C11 (4 VSS) capacitor c=3.24579e-18
C12 (\6\:A VSS) capacitor c=6.85606e-17
C13 (\6\:B VSS) capacitor c=8.08271e-17
C14 (\4\:C VSS) capacitor c=8.3525e-17
C15 (\1\:D VSS) capacitor c=5.6089e-17
C16 (\4\:D VSS) capacitor c=2.48911e-17
C17 (\1\:C VSS) capacitor c=4.17998e-17
C18 (\1\:B VSS) capacitor c=7.38468e-17
C19 (\1\:A VSS) capacitor c=6.27747e-17
C20 (\3\:D VSS) capacitor c=9.01316e-17
C21 (\2\:C VSS) capacitor c=3.8171e-16
C22 (\2\:B VSS) capacitor c=5.16878e-16
C23 (\1\:VDD VSS) capacitor c=4.25189e-17
C24 (\9\:Y VSS) capacitor c=9.79666e-17
C25 (\6\:VDD VSS) capacitor c=3.33774e-17
C26 (\1\:Y VSS) capacitor c=3.23037e-16
C27 (\2\:D VSS) capacitor c=2.22867e-17
C28 (\8\:D VSS) capacitor c=6.4611e-17
C29 (\4\:VDD VSS) capacitor c=3.52764e-17
C30 (\5\:VDD VSS) capacitor c=1.48365e-17
Rk18 (\1\:VSS VSS) resistor r=0.0151 c=0
Rk20 (\1\:VSS \10\:VSS) resistor r=0.2456 c=0
Rk6 (C \2\:C) resistor r=0.1193 c=0
Rk3 (D \8\:D) resistor r=0.0177 c=0
Rk13 (\1\:Y Y) resistor r=0.6934 c=0
Rk14 (Y \10\:Y) resistor r=0.6432 c=0
Rk24 (\2\:VDD \4\:VDD) resistor r=0.4119 c=0
Rk26 (\5\:VDD VDD) resistor r=0.07227 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.3784 c=0
Rk27 (\5\:VDD \7\:VDD) resistor r=0.224 c=0
Rk5 (\2\:B B) resistor r=0.005639 c=0
Rl12 (\2\:C \4\:C) resistor r=114.153 c=0
Rl5 (\2\:C \1\:C) resistor r=56.461 c=0
Rl7 (\2\:D \1\:D) resistor r=100.426 c=0
Rl9 (\2\:D \4\:D) resistor r=35.772 c=0
Rl8 (\2\:D \3\:D) resistor r=87.6951 c=0
Rl17 (A \6\:A) resistor r=59.8103 c=0
Rl1 (A \1\:A) resistor r=49.05 c=0
Rl15 (\2\:B \6\:B) resistor r=29.5379 c=0
Rl3 (\2\:B \1\:B) resistor r=44.9225 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Ry1 (\10\:Y \9\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx1 (\8\:D \3\:D) resistor r=45 c=0
mn3 (\1\:Y \3\:D \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.745e-14 ps=8.4e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.02e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn0_1__rcx (\1\:Y A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.55e-14 ps=8.15e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (\1\:Y \2\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.55e-14 ps=8.55e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.46e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2_1__rcx (\1\:Y \2\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.745e-14 ps=8.55e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.24e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
ends NOR4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:29 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4X4
// View name: extracted

simulator lang=spectre

subckt NOR4X4 A B C D VDD VSS Y
mp0 (n0 A \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.094e-14 ps=1.1e-06 pd=1.0925e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.58e-06 sd=160n sca=22.8747 scb=0.0261588 \
        scc=0.00121841 m=(4)
mp2 (n2 C n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp1 (\4\:n1 B n0 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.094e-14 \
        ad=6.24e-14 ps=1.0925e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.65e-07 sb=7.55e-07 sd=160n sca=12.0739 scb=0.0104574 \
        scc=0.000357242 m=(4)
mp3 (\18\:Y \1\:D n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=13.7486 \
        scb=0.0122257 scc=0.000647518 m=(4)
C1 (B VSS) capacitor c=4.47078e-16
C2 (D VSS) capacitor c=5.06074e-17
C3 (A VSS) capacitor c=3.7172e-16
C4 (Y VSS) capacitor c=2.35513e-16
C5 (VDD VSS) capacitor c=2.54359e-16
C6 (C VSS) capacitor c=3.80046e-16
C7 (n0 VSS) capacitor c=3.93183e-16
C8 (n1 VSS) capacitor c=1.75486e-16
C9 (n2 VSS) capacitor c=3.66458e-16
C10 (\1\:D VSS) capacitor c=3.2326e-16
C11 (\18\:Y VSS) capacitor c=3.42784e-16
C12 (\4\:n1 VSS) capacitor c=1.49442e-16
C13 (\1\:VDD VSS) capacitor c=1.61809e-16
C14 (\1\:Y VSS) capacitor c=1.05491e-16
C15 (\5\:Y VSS) capacitor c=1.20479e-16
C16 (\9\:Y VSS) capacitor c=1.07659e-16
C17 (\14\:Y VSS) capacitor c=7.95268e-17
C18 (\13\:Y VSS) capacitor c=2.8979e-17
C19 (\4\:VDD VSS) capacitor c=1.15657e-16
Rk49 (\1\:VSS VSS) resistor r=0.1575 c=0
Rk19 (\1\:D D) resistor r=0.1482 c=0
Rk29 (Y \18\:Y) resistor r=1.6043 c=0
Rk21 (\1\:Y \5\:Y) resistor r=0.281 c=0
Rk23 (\5\:Y \9\:Y) resistor r=0.2729 c=0
Rk28 (\13\:Y Y) resistor r=0.136 c=0
Rk25 (\9\:Y \13\:Y) resistor r=0.2413 c=0
Rk26 (\13\:Y \14\:Y) resistor r=0.05874 c=0
Rk53 (\2\:VDD \3\:VDD) resistor r=0.9527 c=0
Rk56 (\4\:VDD VDD) resistor r=0.1023 c=0
Rk54 (\3\:VDD \4\:VDD) resistor r=0.243 c=0
Rk15 (n1 \4\:n1) resistor r=0.4695 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz19 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
mn3 (\1\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
mn2 (\5\:Y C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(4)
mn1 (\9\:Y B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
mn0 (\14\:Y A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
ends NOR4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:30 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4X6
// View name: extracted

simulator lang=spectre

subckt NOR4X6 A B C D VDD VSS Y
mp2 (n2 \1\:C n1 VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=8.037e-14 \
        ad=8.225e-14 ps=1.282e-06 pd=1.29e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 scc=0.0027966 \
        m=(5)
mp3 (\1\:Y \1\:D n2 VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=8.225e-14 \
        ad=8.554e-14 ps=1.29e-06 pd=1.304e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.025e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
mp1 (n1 \1\:B n0 VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=8.554e-14 \
        ad=8.037e-14 ps=1.304e-06 pd=1.282e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.165e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
mp0 (n0 \1\:A \4\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.52e-14 ps=1.252e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=35.9918 scb=0.0311691 \
        scc=0.00336409 m=(5)
C1 (B VSS) capacitor c=2.76108e-17
C2 (D VSS) capacitor c=1.86942e-17
C3 (A VSS) capacitor c=2.02547e-17
C4 (Y VSS) capacitor c=1.65668e-17
C5 (VDD VSS) capacitor c=1.29815e-16
C6 (C VSS) capacitor c=1.87682e-17
C7 (n0 VSS) capacitor c=3.92273e-16
C8 (n1 VSS) capacitor c=3.83484e-16
C9 (n2 VSS) capacitor c=4.02522e-16
C10 (\1\:A VSS) capacitor c=3.29222e-16
C11 (\1\:D VSS) capacitor c=3.29953e-16
C12 (\1\:C VSS) capacitor c=3.93721e-16
C13 (\1\:B VSS) capacitor c=3.47481e-16
C14 (\1\:Y VSS) capacitor c=2.10696e-16
C15 (\1\:VDD VSS) capacitor c=1.86154e-16
C16 (\6\:Y VSS) capacitor c=4.27814e-16
C17 (\23\:Y VSS) capacitor c=4.34192e-16
C18 (\4\:VDD VSS) capacitor c=1.67951e-16
Rk47 (\1\:VSS \6\:VSS) resistor r=0.04743 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.2053 c=0
Rk53 (\7\:VSS \12\:VSS) resistor r=0.1201 c=0
Rk57 (\13\:VSS VSS) resistor r=0.02713 c=0
Rk54 (\12\:VSS \13\:VSS) resistor r=0.1126 c=0
Rk4 (\1\:B B) resistor r=0.02719 c=0
Rk16 (D \1\:D) resistor r=0.04317 c=0
Rk1 (A \1\:A) resistor r=0.03496 c=0
Rk24 (\1\:Y Y) resistor r=0.1752 c=0
Rk25 (Y \6\:Y) resistor r=0.03789 c=0
Rk36 (\6\:Y \23\:Y) resistor r=0.372 c=0
Rk68 (\2\:VDD \3\:VDD) resistor r=1.2032 c=0
Rk72 (\4\:VDD VDD) resistor r=0.02713 c=0
Rk69 (\3\:VDD \4\:VDD) resistor r=0.1126 c=0
Rk10 (C \1\:C) resistor r=0.03296 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry20 (\6\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry21 (\12\:VSS \5\:VSS) resistor r=5.1667 c=0
mn2 (\6\:Y \1\:C \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=5.549e-14 ps=9.84e-07 pd=9.78e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn3 (\6\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.549e-14 ps=9.32e-07 pd=9.78e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn1 (\23\:Y \1\:B \7\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=5.301e-14 ps=9.84e-07 pd=9.62e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn0 (\23\:Y \1\:A \13\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.301e-14 ps=9.32e-07 pd=9.62e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
ends NOR4X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:31 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4X8
// View name: extracted

simulator lang=spectre

subckt NOR4X8 A B C D VDD VSS Y
mp0 (n0 \1\:A VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=6.993e-14 \
        ad=7.438e-14 ps=1.20429e-06 pd=1.22429e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=40.0554 scb=0.035826 \
        scc=0.00405312 m=(7)
mp2 (n2 \1\:C n1 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=7.12e-14 \
        ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 scc=0.00295096 \
        m=(7)
mp3 (Y \1\:D n2 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=7.12e-14 \
        ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.37e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(7)
mp1 (n1 \1\:B n0 VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 as=7.438e-14 \
        ad=7.12e-14 ps=1.22429e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.625e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(7)
C1 (B VSS) capacitor c=2.58951e-17
C2 (D VSS) capacitor c=2.91596e-17
C3 (A VSS) capacitor c=1.86493e-17
C4 (VDD VSS) capacitor c=4.23234e-16
C5 (Y VSS) capacitor c=2.80659e-16
C6 (C VSS) capacitor c=2.40325e-17
C7 (n0 VSS) capacitor c=5.44463e-16
C8 (n1 VSS) capacitor c=4.72852e-16
C9 (n2 VSS) capacitor c=5.23467e-16
C10 (\1\:D VSS) capacitor c=4.75715e-16
C11 (\1\:C VSS) capacitor c=5.34816e-16
C12 (\1\:B VSS) capacitor c=4.28443e-16
C13 (\1\:A VSS) capacitor c=4.30874e-16
C14 (\1\:VDD VSS) capacitor c=2.17106e-16
C15 (\18\:Y VSS) capacitor c=3.49047e-16
C16 (\5\:Y VSS) capacitor c=3.81862e-16
Rk68 (\7\:VSS VSS) resistor r=0.23 c=0
Rk60 (\1\:VSS \7\:VSS) resistor r=0.205 c=0
Rk8 (\1\:B B) resistor r=0.002661 c=0
Rk29 (\1\:D D) resistor r=0.01651 c=0
Rk4 (\1\:A A) resistor r=0.01721 c=0
Rk88 (\3\:VDD VDD) resistor r=1.1293 c=0
Rk87 (\2\:VDD \3\:VDD) resistor r=0.9517 c=0
Rk39 (Y \5\:Y) resistor r=0.1924 c=0
Rk46 (\5\:Y \18\:Y) resistor r=0.2806 c=0
Rk26 (\1\:C C) resistor r=0.05244 c=0
Rz32 (VDD \1\:VDD) resistor r=6.25 c=0
Rz30 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz31 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry29 (VSS \3\:VSS) resistor r=5.1667 c=0
Ry27 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry28 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
mn2 (\5\:Y \1\:C \7\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.06566 scb=0.00745694 \
        scc=0.000223945 m=(7)
mn1 (\18\:Y \1\:B \7\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.931e-14 ps=9.1e-07 pd=9.2429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=2e-06 sd=160n sca=9.06566 \
        scb=0.00745694 scc=0.000223945 m=(7)
mn0 (\18\:Y \1\:A VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.931e-14 ps=9.0429e-07 pd=9.2429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.06566 scb=0.00745694 \
        scc=0.000223945 m=(7)
mn3 (\5\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=9.06566 \
        scb=0.00745694 scc=0.000223945 m=(7)
ends NOR4X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:33 2013 )
// Library name: gsclib045_hvt
// Cell name: NOR4XL
// View name: extracted

simulator lang=spectre

subckt NOR4XL A B C D VDD VSS Y
mp0 (n0 \1\:A \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=53.7316 \
        scb=0.0398978 scc=0.00628878 m=(1)
mp1 (n1 \1\:B n0 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=4.085e-14 ps=7.5e-07 pd=8.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=6.25e-07 sd=160n sca=48.9361 scb=0.0309872 \
        scc=0.00589512 m=(1)
mp2 (n2 \1\:C n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.085e-14 \
        ad=2.58e-14 ps=8.1e-07 pd=6.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.8e-07 sb=3.9e-07 sd=160n sca=48.9361 scb=0.0309872 \
        scc=0.00589512 m=(1)
mp3 (\1\:Y \3\:D n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=2.58e-14 \
        ad=4.838e-14 ps=6.7e-07 pd=8.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.45e-07 sb=2.25e-07 sd=160n sca=52.0454 scb=0.0370257 \
        scc=0.00608774 m=(1)
C1 (B VSS) capacitor c=8.01527e-17
C2 (D VSS) capacitor c=5.70754e-17
C3 (A VSS) capacitor c=5.50857e-17
C4 (VDD VSS) capacitor c=6.25601e-17
C5 (C VSS) capacitor c=6.66317e-17
C6 (n1 VSS) capacitor c=5.3189e-18
C7 (n2 VSS) capacitor c=1.84302e-19
C8 (\3\:D VSS) capacitor c=3.63199e-17
C9 (\1\:C VSS) capacitor c=3.95164e-17
C10 (\1\:B VSS) capacitor c=2.72507e-17
C11 (\1\:A VSS) capacitor c=3.11435e-17
C12 (\1\:D VSS) capacitor c=3.26698e-17
C13 (\3\:C VSS) capacitor c=4.01628e-17
C14 (\3\:B VSS) capacitor c=4.78542e-17
C15 (\3\:A VSS) capacitor c=3.5566e-17
C16 (\2\:D VSS) capacitor c=4.00648e-17
C17 (\2\:C VSS) capacitor c=5.07309e-17
C18 (\2\:B VSS) capacitor c=4.90383e-17
C19 (\2\:A VSS) capacitor c=3.52487e-17
C20 (\1\:Y VSS) capacitor c=7.77398e-17
C21 (\4\:VDD VSS) capacitor c=3.09516e-17
C22 (\6\:Y VSS) capacitor c=2.81784e-17
C23 (\4\:Y VSS) capacitor c=6.50659e-17
C24 (\4\:A VSS) capacitor c=3.44862e-17
C25 (\4\:B VSS) capacitor c=2.80062e-17
C26 (\4\:C VSS) capacitor c=6.09879e-17
C27 (\4\:D VSS) capacitor c=6.43454e-17
C28 (\3\:Y VSS) capacitor c=9.91605e-17
C29 (\3\:VDD VSS) capacitor c=2.8829e-17
Rk7 (Y \2\:Y) resistor r=0.002892 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.5939 c=0
Rk9 (\3\:Y \5\:Y) resistor r=0.4263 c=0
Rk10 (\3\:Y \7\:Y) resistor r=0.09641 c=0
Rk4 (\4\:B B) resistor r=0.03896 c=0
Rk6 (D \4\:D) resistor r=0.2144 c=0
Rk1 (\4\:A A) resistor r=0.1003 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.4285 c=0
Rk13 (\5\:VSS VSS) resistor r=0.03715 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.2133 c=0
Rk14 (\4\:VSS \7\:VSS) resistor r=0.247 c=0
Rk15 (\5\:VSS \9\:VSS) resistor r=0.1993 c=0
Rk17 (\3\:VDD VDD) resistor r=0.03715 c=0
Rk18 (\3\:VDD \5\:VDD) resistor r=0.4163 c=0
Rk5 (C \4\:C) resistor r=0.2038 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=133.384 c=0
Rl8 (\2\:D \3\:D) resistor r=72.5275 c=0
Rl7 (\1\:D \2\:D) resistor r=92.3077 c=0
Rl1 (\1\:A \2\:A) resistor r=72.3097 c=0
Rl2 (\2\:A \3\:A) resistor r=87.6944 c=0
Rl5 (\1\:C \2\:C) resistor r=62.2302 c=0
Rl6 (\2\:C \3\:C) resistor r=100.692 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (\4\:Y \3\:A \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.2e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn1 (\4\:Y \3\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.15e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (\6\:Y \3\:C \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.827e-14 ps=6.7e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.8e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn3 (\6\:Y \1\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.828e-14 ps=5.7e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.4e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
ends NOR4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:34 2013 )
// Library name: gsclib045_hvt
// Cell name: OA21X1
// View name: extracted

simulator lang=spectre

subckt OA21X1 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.85e-07 sd=160n sca=26.8266 \
        scb=0.0313637 scc=0.00190754 m=(1)
mp1 (\8\:net95 \1\:A1 net98 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.655e-14 ps=7.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.9e-07 sd=160n sca=17.3843 \
        scb=0.0171664 scc=0.000551089 m=(1)
mp2 (\8\:net95 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.75e-07 sd=160n sca=15.8515 \
        scb=0.0140891 scc=0.000503754 m=(1)
C1 (B0 VSS) capacitor c=4.14344e-17
C2 (A1 VSS) capacitor c=4.75601e-17
C3 (VDD VSS) capacitor c=9.00995e-17
C4 (Y VSS) capacitor c=1.2388e-17
C5 (net107 VSS) capacitor c=6.21057e-17
C6 (net95 VSS) capacitor c=3.96918e-17
C7 (net98 VSS) capacitor c=8.98266e-18
C8 (\4\:net95 VSS) capacitor c=4.78007e-17
C9 (\1\:B0 VSS) capacitor c=6.17557e-17
C10 (\1\:A1 VSS) capacitor c=3.99424e-17
C11 (\1\:A0 VSS) capacitor c=5.19338e-17
C12 (\3\:B0 VSS) capacitor c=2.82163e-17
C13 (\3\:A1 VSS) capacitor c=5.37297e-17
C14 (\4\:A0 VSS) capacitor c=3.12319e-17
C15 (\3\:net95 VSS) capacitor c=2.49392e-17
C16 (\2\:B0 VSS) capacitor c=5.14591e-17
C17 (\2\:A1 VSS) capacitor c=5.6571e-17
C18 (\3\:A0 VSS) capacitor c=1.47093e-17
C19 (\1\:Y VSS) capacitor c=7.16783e-17
C20 (\1\:VDD VSS) capacitor c=6.44544e-17
C21 (\8\:net95 VSS) capacitor c=6.17692e-17
C22 (\5\:VDD VSS) capacitor c=1.83031e-17
C23 (\3\:Y VSS) capacitor c=4.79845e-17
C24 (\5\:net95 VSS) capacitor c=5.66069e-17
C25 (\3\:net107 VSS) capacitor c=4.23115e-17
C26 (\2\:A0 VSS) capacitor c=3.2166e-17
C27 (\2\:net95 VSS) capacitor c=1.91589e-17
C28 (\5\:A0 VSS) capacitor c=3.93199e-17
C29 (\7\:A0 VSS) capacitor c=3.76015e-17
C30 (\4\:A1 VSS) capacitor c=3.20896e-17
C31 (\6\:B0 VSS) capacitor c=4.58861e-17
C32 (\7\:net95 VSS) capacitor c=7.35527e-17
C33 (\4\:VDD VSS) capacitor c=2.82308e-17
Rk6 (\4\:B0 B0) resistor r=0.006735 c=0
Rk8 (\4\:B0 \6\:B0) resistor r=0.02172 c=0
Rk7 (\5\:B0 \6\:B0) resistor r=0.006735 c=0
Rk4 (\4\:A1 A1) resistor r=0.1016 c=0
Rk18 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.3682 c=0
Rk19 (VDD \6\:VDD) resistor r=0.3148 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002221 c=0
Rk2 (A0 \7\:A0) resistor r=0.002132 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.1329 c=0
Rk12 (\4\:Y Y) resistor r=0.03658 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5453 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.2569 c=0
Rk15 (\5\:VSS VSS) resistor r=0.1173 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.1326 c=0
Rk16 (\5\:VSS \7\:VSS) resistor r=0.07346 c=0
Rk5 (\2\:net107 \4\:net107) resistor r=0.2251 c=0
Rk9 (\6\:net95 \7\:net95) resistor r=0.2976 c=0
Rk10 (\7\:net95 \9\:net95) resistor r=0.3018 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=153.021 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=26.098 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=62.6365 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.483 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.022 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=36.2526 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=4.3144 c=0
Rl10 (\2\:net95 \4\:net95) resistor r=57.4064 c=0
Rl8 (net95 \2\:net95) resistor r=122.357 c=0
Rl9 (\2\:net95 \3\:net95) resistor r=4.3144 c=0
Rz4 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\5\:net95 \6\:net95) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\8\:net95 \9\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
Rx4 (\3\:net95 \7\:net95) resistor r=45 c=0
mn0 (\3\:net107 \4\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (net107 \3\:A1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.465e-14 ps=1.31e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:net95 \3\:B0 net107 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.67e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp3 (\1\:Y \4\:net95 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95577e-07 sb=1.4e-07 sd=160n sca=17.0231 \
        scb=0.0168642 scc=0.000422034 m=(1)
ends OA21X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:35 2013 )
// Library name: gsclib045_hvt
// Cell name: OA21X2
// View name: extracted

simulator lang=spectre

subckt OA21X2 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=16.3381 \
        scb=0.0159051 scc=0.000527857 m=(1)
mp1 (\12\:net95 \1\:A1 net98 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=4.3e-14 ps=7.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=8.45e-07 sd=160n sca=14.3247 \
        scb=0.0130249 scc=0.000501931 m=(1)
mp2 (\12\:net95 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=4.3e-14 ps=1.2e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=6e-07 sd=160n sca=13.4265 scb=0.0124078 \
        scc=0.000501184 m=(1)
C1 (B0 VSS) capacitor c=4.52772e-17
C2 (A1 VSS) capacitor c=5.28147e-17
C3 (VDD VSS) capacitor c=9.49695e-17
C4 (A0 VSS) capacitor c=5.7874e-17
C5 (Y VSS) capacitor c=6.38028e-17
C6 (net107 VSS) capacitor c=4.06689e-17
C7 (net95 VSS) capacitor c=5.72391e-17
C8 (\1\:B0 VSS) capacitor c=5.85137e-17
C9 (\1\:A1 VSS) capacitor c=5.24188e-17
C10 (\1\:A0 VSS) capacitor c=4.45718e-17
C11 (\3\:B0 VSS) capacitor c=2.76433e-17
C12 (\3\:A1 VSS) capacitor c=3.60741e-17
C13 (\4\:A0 VSS) capacitor c=3.17701e-17
C14 (\5\:net95 VSS) capacitor c=1.75362e-17
C15 (\2\:B0 VSS) capacitor c=3.70883e-17
C16 (\2\:A1 VSS) capacitor c=4.48959e-17
C17 (\3\:A0 VSS) capacitor c=1.44158e-17
C18 (\1\:VDD VSS) capacitor c=1.16061e-16
C19 (\1\:Y VSS) capacitor c=9.79563e-17
C20 (\12\:net95 VSS) capacitor c=3.75985e-17
C21 (\10\:VDD VSS) capacitor c=2.4557e-17
C22 (\3\:Y VSS) capacitor c=1.1608e-17
C23 (\10\:net95 VSS) capacitor c=7.22655e-17
C24 (\3\:net107 VSS) capacitor c=6.20631e-17
C25 (\2\:A0 VSS) capacitor c=2.85585e-17
C26 (\3\:net95 VSS) capacitor c=7.97491e-17
C27 (\5\:A0 VSS) capacitor c=3.7272e-17
C28 (\4\:A1 VSS) capacitor c=3.82583e-17
C29 (\4\:B0 VSS) capacitor c=6.72328e-17
C30 (\9\:net95 VSS) capacitor c=7.51081e-17
C31 (\5\:VDD VSS) capacitor c=1.46617e-17
C32 (\6\:VDD VSS) capacitor c=1.01047e-17
Rk4 (B0 \4\:B0) resistor r=0.2022 c=0
Rk2 (\4\:A1 A1) resistor r=0.1814 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.06195 c=0
Rk18 (\6\:VDD VDD) resistor r=0.1139 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.2832 c=0
Rk21 (\6\:VDD \11\:VDD) resistor r=0.3012 c=0
Rk1 (A0 \5\:A0) resistor r=0.1398 c=0
Rk7 (\2\:Y Y) resistor r=0.4606 c=0
Rk8 (Y \4\:Y) resistor r=0.119 c=0
Rk10 (\1\:VSS \5\:VSS) resistor r=0.149 c=0
Rk12 (\6\:VSS VSS) resistor r=0.2307 c=0
Rk11 (\5\:VSS \6\:VSS) resistor r=0.1664 c=0
Rk14 (\6\:VSS \10\:VSS) resistor r=0.0722 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.233 c=0
Rk5 (\9\:net95 \11\:net95) resistor r=0.3825 c=0
Rk6 (\9\:net95 \13\:net95) resistor r=0.2905 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=156.461 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.5379 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=146.846 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=39.1533 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.022 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=36.2526 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=11.4953 c=0
Rl9 (\3\:net95 net95) resistor r=70.2199 c=0
Rl11 (\3\:net95 \5\:net95) resistor r=4.6885 c=0
Rz4 (\4\:Y \3\:Y) resistor r=75 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\11\:net95 \10\:net95) resistor r=75 c=0
Ry7 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry1 (\13\:net95 \12\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\9\:net95 \5\:net95) resistor r=45 c=0
mn0 (net107 \4\:A0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\3\:net107 \3\:A1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.9e-14 ps=1.31e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=4.8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\10\:net95 \3\:B0 \3\:net107 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=3.407e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.35e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mp3 (\1\:Y \3\:net95 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.23141e-07 sb=3.45e-07 sd=160n sca=12.736 \
        scb=0.0105861 scc=0.000311807 m=(2)
ends OA21X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:36 2013 )
// Library name: gsclib045_hvt
// Cell name: OA21X4
// View name: extracted

simulator lang=spectre

subckt OA21X4 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=21.318 \
        scb=0.0198005 scc=0.0015222 m=(1)
mp1 (\18\:net95 \1\:A1 net98 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.365e-06 sd=160n sca=19.8317 \
        scb=0.0173912 scc=0.00148974 m=(1)
mp2 (\18\:net95 \1\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=6.24e-14 ps=1.5e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.16e-06 sd=160n sca=18.4632 \
        scb=0.0159033 scc=0.00148415 m=(1)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.55e-07 sd=160n sca=17.7856 \
        scb=0.015626 scc=0.00148402 m=(4)
C1 (B0 VSS) capacitor c=7.49505e-17
C2 (VDD VSS) capacitor c=1.05324e-16
C3 (A1 VSS) capacitor c=3.28181e-17
C4 (A0 VSS) capacitor c=3.61158e-17
C5 (Y VSS) capacitor c=5.42048e-17
C6 (net107 VSS) capacitor c=6.28202e-17
C7 (net95 VSS) capacitor c=3.06692e-16
C8 (\1\:B0 VSS) capacitor c=4.55998e-17
C9 (\1\:A1 VSS) capacitor c=9.12662e-17
C10 (\1\:A0 VSS) capacitor c=7.84394e-17
C11 (\3\:B0 VSS) capacitor c=3.85282e-17
C12 (\3\:A1 VSS) capacitor c=4.4238e-17
C13 (\4\:A0 VSS) capacitor c=3.81571e-17
C14 (\2\:B0 VSS) capacitor c=3.67198e-17
C15 (\2\:A1 VSS) capacitor c=5.81938e-17
C16 (\3\:A0 VSS) capacitor c=1.7297e-17
C17 (\1\:VDD VSS) capacitor c=2.02558e-16
C18 (\1\:Y VSS) capacitor c=2.05821e-16
C19 (\18\:net95 VSS) capacitor c=8.99662e-17
C20 (\12\:VDD VSS) capacitor c=1.99422e-17
C21 (\4\:Y VSS) capacitor c=1.02728e-16
C22 (\20\:net95 VSS) capacitor c=5.81587e-17
C23 (\3\:net107 VSS) capacitor c=4.66882e-17
C24 (\2\:A0 VSS) capacitor c=5.04731e-17
C25 (\5\:A0 VSS) capacitor c=1.6271e-17
C26 (\4\:A1 VSS) capacitor c=7.05169e-17
C27 (\4\:B0 VSS) capacitor c=3.16787e-17
C28 (\17\:net95 VSS) capacitor c=9.83548e-17
C29 (\7\:VDD VSS) capacitor c=8.00273e-18
Rk4 (\4\:B0 B0) resistor r=0.164 c=0
Rk25 (\7\:VDD VDD) resistor r=0.1047 c=0
Rk24 (\1\:VDD \7\:VDD) resistor r=0.2576 c=0
Rk28 (\7\:VDD \13\:VDD) resistor r=0.2588 c=0
Rk2 (A1 \4\:A1) resistor r=0.06334 c=0
Rk18 (\8\:VSS VSS) resistor r=0.1573 c=0
Rk17 (\1\:VSS \8\:VSS) resistor r=0.3433 c=0
Rk20 (\8\:VSS \12\:VSS) resistor r=0.1726 c=0
Rk1 (A0 \5\:A0) resistor r=0.0987 c=0
Rk10 (\1\:Y Y) resistor r=0.1568 c=0
Rk11 (Y \4\:Y) resistor r=0.1759 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.2381 c=0
Rk6 (net95 \17\:net95) resistor r=0.1939 c=0
Rk7 (\17\:net95 \19\:net95) resistor r=0.6004 c=0
Rk8 (\17\:net95 \21\:net95) resistor r=0.3853 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=98.7687 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=56.461 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=102.615 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=52.6149 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=101.317 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=60.1705 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=22.7732 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\21\:net95 \20\:net95) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\19\:net95 \18\:net95) resistor r=31 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (\3\:net107 \4\:A0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.28462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (net107 \3\:A1 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.23462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\20\:net95 \3\:B0 net107 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.08e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.18462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\4\:Y net95 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
ends OA21X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:37 2013 )
// Library name: gsclib045_hvt
// Cell name: OA21XL
// View name: extracted

simulator lang=spectre

subckt OA21XL A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.398e-14 ps=7.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=19.249 scb=0.0210034 \
        scc=0.000704741 m=(1)
mp1 (\8\:net95 \4\:A1 net98 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.397e-14 ad=6.45e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=6.9e-07 sd=160n sca=16.4235 \
        scb=0.0160509 scc=0.000530362 m=(1)
mp2 (\8\:net95 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.45e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=13.9642 \
        scb=0.012601 scc=0.000501242 m=(1)
mp3 (\1\:Y \4\:net95 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.4e-07 sd=160n sca=14.3559 scb=0.0130561 \
        scc=0.000502004 m=(1)
C1 (B0 VSS) capacitor c=4.94787e-17
C2 (VDD VSS) capacitor c=7.84702e-17
C3 (A1 VSS) capacitor c=6.92271e-17
C4 (Y VSS) capacitor c=6.99414e-17
C5 (A0 VSS) capacitor c=8.98196e-17
C6 (net107 VSS) capacitor c=2.7809e-17
C7 (net95 VSS) capacitor c=2.73853e-17
C8 (\4\:net95 VSS) capacitor c=3.94431e-17
C9 (\1\:B0 VSS) capacitor c=4.78864e-17
C10 (\4\:A1 VSS) capacitor c=6.6623e-17
C11 (\1\:A0 VSS) capacitor c=5.05225e-17
C12 (\3\:B0 VSS) capacitor c=2.3562e-17
C13 (\3\:A1 VSS) capacitor c=3.88846e-17
C14 (\3\:A0 VSS) capacitor c=4.22302e-17
C15 (\3\:net95 VSS) capacitor c=2.26876e-17
C16 (\2\:B0 VSS) capacitor c=5.79708e-17
C17 (\1\:A1 VSS) capacitor c=1.71392e-17
C18 (\2\:A0 VSS) capacitor c=5.16938e-17
C19 (\1\:Y VSS) capacitor c=4.07087e-17
C20 (\1\:VDD VSS) capacitor c=3.14157e-17
C21 (\8\:net95 VSS) capacitor c=6.23456e-17
C22 (\6\:VDD VSS) capacitor c=1.31242e-17
C23 (\5\:net95 VSS) capacitor c=4.57544e-17
C24 (\3\:net107 VSS) capacitor c=6.48094e-17
C25 (\2\:A1 VSS) capacitor c=3.91764e-17
C26 (\2\:net95 VSS) capacitor c=2.30742e-17
C27 (\5\:A1 VSS) capacitor c=6.68426e-17
C28 (\4\:B0 VSS) capacitor c=7.6005e-17
C29 (\7\:net95 VSS) capacitor c=1.05484e-16
C30 (\4\:VDD VSS) capacitor c=2.33006e-17
C31 (\5\:VDD VSS) capacitor c=9.89852e-18
Rk4 (B0 \4\:B0) resistor r=0.2021 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.34 c=0
Rk15 (\5\:VDD VDD) resistor r=0.05668 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.2904 c=0
Rk16 (\5\:VDD \7\:VDD) resistor r=0.3008 c=0
Rk2 (A1 \5\:A1) resistor r=0.2229 c=0
Rk7 (\2\:Y Y) resistor r=0.3726 c=0
Rk8 (Y \4\:Y) resistor r=0.03525 c=0
Rk9 (\2\:VSS \4\:VSS) resistor r=0.2498 c=0
Rk11 (\5\:VSS VSS) resistor r=0.1312 c=0
Rk10 (\4\:VSS \5\:VSS) resistor r=0.2159 c=0
Rk12 (\5\:VSS \7\:VSS) resistor r=0.07209 c=0
Rk1 (\4\:A0 A0) resistor r=0.002972 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.2329 c=0
Rk5 (\6\:net95 \7\:net95) resistor r=0.2237 c=0
Rk6 (\7\:net95 \9\:net95) resistor r=0.3673 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=158.09 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.9451 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=146.957 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=54.6488 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=1.8584 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=71.1538 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=118.013 c=0
Rl10 (\2\:net95 \4\:net95) resistor r=92.9709 c=0
Rl8 (net95 \2\:net95) resistor r=121.462 c=0
Rl9 (\2\:net95 \3\:net95) resistor r=5.1011 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\5\:net95 \6\:net95) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry1 (\8\:net95 \9\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\1\:A1 \5\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\3\:net95 \7\:net95) resistor r=45 c=0
mn0 (net107 \3\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\3\:net107 \3\:A1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=3.045e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=4.8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:net95 \3\:B0 \3\:net107 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.045e-14 ad=3.263e-14 ps=7.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=2.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
ends OA21XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:38 2013 )
// Library name: gsclib045_hvt
// Cell name: OA22X1
// View name: extracted

simulator lang=spectre

subckt OA22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.11e-06 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
mp1 (\7\:net128 \1\:A1 net119 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=9.15e-07 sd=160n sca=15.1901 \
        scb=0.0142438 scc=0.000270537 m=(1)
mp3 (\7\:net128 \1\:B1 net115 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=7.1e-07 sd=160n sca=13.0859 \
        scb=0.0105161 scc=0.000221881 m=(1)
mp2 (net115 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=5.05e-07 sd=160n sca=13.1252 \
        scb=0.0105805 scc=0.000222119 m=(1)
C1 (Y VSS) capacitor c=6.95384e-17
C2 (B0 VSS) capacitor c=2.98063e-17
C3 (A0 VSS) capacitor c=2.51516e-17
C4 (VDD VSS) capacitor c=1.12885e-16
C5 (net124 VSS) capacitor c=6.37762e-17
C6 (net128 VSS) capacitor c=4.32679e-17
C7 (net115 VSS) capacitor c=5.90412e-18
C8 (\1\:B0 VSS) capacitor c=3.38135e-17
C9 (\1\:B1 VSS) capacitor c=3.92109e-17
C10 (\1\:A1 VSS) capacitor c=4.07023e-17
C11 (\1\:A0 VSS) capacitor c=5.22006e-17
C12 (\4\:net128 VSS) capacitor c=3.22948e-17
C13 (\3\:B0 VSS) capacitor c=5.37491e-17
C14 (\4\:B1 VSS) capacitor c=5.11032e-17
C15 (\3\:A1 VSS) capacitor c=5.59806e-17
C16 (\3\:A0 VSS) capacitor c=3.243e-17
C17 (\3\:net128 VSS) capacitor c=1.98439e-17
C18 (\2\:B0 VSS) capacitor c=4.35837e-17
C19 (\3\:B1 VSS) capacitor c=2.67932e-17
C20 (\2\:A1 VSS) capacitor c=6.58407e-17
C21 (\2\:A0 VSS) capacitor c=4.44408e-17
C22 (\1\:Y VSS) capacitor c=4.52399e-17
C23 (\1\:VDD VSS) capacitor c=3.34285e-17
C24 (\7\:net128 VSS) capacitor c=6.97749e-17
C25 (\5\:VDD VSS) capacitor c=1.79755e-17
C26 (\9\:net128 VSS) capacitor c=3.76472e-17
C27 (\3\:net124 VSS) capacitor c=7.58923e-17
C28 (\5\:net124 VSS) capacitor c=4.02099e-17
C29 (\2\:B1 VSS) capacitor c=3.74879e-17
C30 (\4\:A0 VSS) capacitor c=2.13228e-17
C31 (\4\:A1 VSS) capacitor c=2.91494e-17
C32 (\5\:A1 VSS) capacitor c=3.14025e-17
C33 (\5\:B1 VSS) capacitor c=4.72139e-17
C34 (\7\:B1 VSS) capacitor c=4.45613e-17
C35 (\5\:B0 VSS) capacitor c=4.52669e-17
C36 (\5\:net128 VSS) capacitor c=4.82432e-17
C37 (\6\:net128 VSS) capacitor c=1.00969e-16
C38 (\4\:VDD VSS) capacitor c=3.63829e-17
Rk2 (A1 \4\:A1) resistor r=0.008275 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.04592 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.008415 c=0
Rk17 (\4\:Y Y) resistor r=0.01657 c=0
Rk16 (\2\:Y \4\:Y) resistor r=0.4069 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.01028 c=0
Rk11 (\6\:B0 B0) resistor r=0.01028 c=0
Rk12 (\5\:B0 \6\:B0) resistor r=0.0192 c=0
Rk1 (A0 \4\:A0) resistor r=0.02361 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.2791 c=0
Rk20 (\5\:VSS VSS) resistor r=0.1172 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.1825 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.07311 c=0
Rk23 (\4\:VDD VDD) resistor r=0.3003 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.4626 c=0
Rk24 (VDD \6\:VDD) resistor r=0.2804 c=0
Rk5 (\5\:B1 \6\:B1) resistor r=0.005269 c=0
Rk6 (B1 \7\:B1) resistor r=0.005137 c=0
Rk7 (\5\:B1 \7\:B1) resistor r=0.05797 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.5039 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.2707 c=0
Rk13 (\5\:net128 \6\:net128) resistor r=0.2724 c=0
Rk14 (\6\:net128 \8\:net128) resistor r=0.526 c=0
Rk15 (\6\:net128 \10\:net128) resistor r=0.1688 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=47.2519 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=131.867 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=31.461 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=154.538 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=153.021 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.098 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=64.2642 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=137.341 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=1.8551 c=0
Rl10 (net128 \2\:net128) resistor r=72.791 c=0
Rl12 (\2\:net128 \4\:net128) resistor r=38.1757 c=0
Rl11 (\2\:net128 \3\:net128) resistor r=0.5166 c=0
Rz5 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\9\:net128 \10\:net128) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\7\:net128 \8\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
Rx5 (\3\:net128 \5\:net128) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.03e-14 ps=1.41e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\3\:net124 \3\:A1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn3 (\9\:net128 \4\:B1 \3\:net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\9\:net128 \3\:B0 net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn4 (\3\:Y \4\:net128 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.89e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
mp4 (\1\:Y net128 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=5.46e-14 ps=1.42e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.56795e-07 sb=1.4e-07 sd=160n sca=31.7169 \
        scb=0.0333373 scc=0.002913 m=(1)
ends OA22X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:39 2013 )
// Library name: gsclib045_hvt
// Cell name: OA22X2
// View name: extracted

simulator lang=spectre

subckt OA22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.375e-06 sd=160n sca=15.6738 \
        scb=0.0150674 scc=0.000231884 m=(1)
mp1 (\10\:net128 \1\:A1 net119 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.18e-06 sd=160n sca=12.1772 \
        scb=0.00916323 scc=9.24857e-05 m=(1)
mp3 (\10\:net128 \1\:B1 net115 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=9.75e-07 sd=160n sca=10.8981 \
        scb=0.00784736 scc=8.82336e-05 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=4.73e-14 ps=1.42e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=7.1e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
C1 (A1 VSS) capacitor c=1.17496e-16
C2 (Y VSS) capacitor c=2.45254e-17
C3 (B0 VSS) capacitor c=5.70107e-17
C4 (A0 VSS) capacitor c=5.97471e-17
C5 (VDD VSS) capacitor c=1.14874e-16
C6 (B1 VSS) capacitor c=7.10877e-17
C7 (net124 VSS) capacitor c=7.79451e-17
C8 (net128 VSS) capacitor c=6.21283e-17
C9 (net115 VSS) capacitor c=6.48807e-18
C10 (\3\:B0 VSS) capacitor c=3.1687e-17
C11 (\1\:B1 VSS) capacitor c=5.11134e-17
C12 (\1\:A1 VSS) capacitor c=3.91316e-17
C13 (\1\:A0 VSS) capacitor c=4.88685e-17
C14 (\1\:B0 VSS) capacitor c=5.06724e-17
C15 (\3\:B1 VSS) capacitor c=4.29566e-17
C16 (\3\:A1 VSS) capacitor c=6.64799e-17
C17 (\3\:A0 VSS) capacitor c=3.74197e-17
C18 (\4\:net128 VSS) capacitor c=1.85557e-17
C19 (\2\:B0 VSS) capacitor c=5.17613e-17
C20 (\2\:B1 VSS) capacitor c=5.23349e-17
C21 (\2\:A1 VSS) capacitor c=6.33863e-17
C22 (\2\:A0 VSS) capacitor c=4.81144e-17
C23 (\1\:VDD VSS) capacitor c=1.00851e-16
C24 (\1\:Y VSS) capacitor c=9.12678e-17
C25 (\10\:net128 VSS) capacitor c=6.5072e-17
C26 (\9\:VDD VSS) capacitor c=2.09546e-17
C27 (\3\:Y VSS) capacitor c=1.3776e-17
C28 (\12\:net128 VSS) capacitor c=4.71448e-17
C29 (\3\:net124 VSS) capacitor c=1.29316e-16
C30 (\5\:net124 VSS) capacitor c=5.96592e-17
C31 (\3\:net128 VSS) capacitor c=7.64289e-17
C32 (\4\:A0 VSS) capacitor c=3.00948e-17
C33 (\4\:B1 VSS) capacitor c=5.9259e-17
C34 (\4\:B0 VSS) capacitor c=6.06306e-17
C35 (\8\:net128 VSS) capacitor c=4.65249e-17
C36 (\9\:net128 VSS) capacitor c=1.14208e-16
C37 (\5\:VDD VSS) capacitor c=2.37893e-17
C38 (\6\:VDD VSS) capacitor c=1.60159e-17
Rk2 (\4\:A1 A1) resistor r=0.002985 c=0
Rk10 (\2\:Y Y) resistor r=0.3671 c=0
Rk11 (Y \4\:Y) resistor r=0.03241 c=0
Rk6 (B0 \4\:B0) resistor r=0.1526 c=0
Rk1 (A0 \4\:A0) resistor r=0.07164 c=0
Rk19 (\1\:VDD \5\:VDD) resistor r=0.07725 c=0
Rk21 (\6\:VDD VDD) resistor r=0.06701 c=0
Rk20 (\5\:VDD \6\:VDD) resistor r=0.382 c=0
Rk23 (\6\:VDD \10\:VDD) resistor r=0.2279 c=0
Rk13 (\1\:VSS \5\:VSS) resistor r=0.1597 c=0
Rk15 (\6\:VSS VSS) resistor r=0.1644 c=0
Rk14 (\5\:VSS \6\:VSS) resistor r=0.2846 c=0
Rk17 (\6\:VSS \10\:VSS) resistor r=0.2295 c=0
Rk3 (B1 \4\:B1) resistor r=0.1851 c=0
Rk4 (\2\:net124 \4\:net124) resistor r=0.6137 c=0
Rk5 (\4\:net124 \6\:net124) resistor r=0.503 c=0
Rk7 (\8\:net128 \9\:net128) resistor r=0.2755 c=0
Rk8 (\9\:net128 \11\:net128) resistor r=0.5091 c=0
Rk9 (\9\:net128 \13\:net128) resistor r=0.3314 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=41.0764 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=218 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=41.4835 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=219.231 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.944 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=97.2519 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=158.384 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=100.692 c=0
Rl10 (\3\:net128 net128) resistor r=57.0886 c=0
Rl11 (\3\:net128 \4\:net128) resistor r=10.0647 c=0
Rz5 (\4\:Y \3\:Y) resistor r=75 c=0
Rz8 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\13\:net128 \12\:net128) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry6 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\11\:net128 \10\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\8\:net128 \4\:net128) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn1 (\3\:net124 \3\:A1 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.65e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn3 (\12\:net128 \3\:B1 \3\:net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn2 (\12\:net128 \1\:B0 net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.988e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn4 (\3\:Y net128 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mp4 (\1\:Y \3\:net128 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.045e-14 ad=6.24e-14 ps=1.24e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.89872e-07 sb=3.45e-07 sd=160n sca=15.2316 \
        scb=0.0133702 scc=0.000755104 m=(2)
ends OA22X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:40 2013 )
// Library name: gsclib045_hvt
// Cell name: OA22X4
// View name: extracted

simulator lang=spectre

subckt OA22X4 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.525e-06 sd=160n sca=16.0461 \
        scb=0.0153344 scc=0.000433465 m=(1)
mp1 (\17\:net128 \1\:A1 net119 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.365e-06 sd=160n sca=13.8829 \
        scb=0.0118891 scc=0.000386328 m=(1)
mp3 (\17\:net128 \1\:B1 net115 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.16e-06 sd=160n sca=12.7362 \
        scb=0.0108186 scc=0.000383639 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=9.6e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp4_1__rcx (\4\:Y net128 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=7.55e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
C1 (B0 VSS) capacitor c=8.04933e-17
C2 (A0 VSS) capacitor c=7.40948e-17
C3 (Y VSS) capacitor c=2.12751e-17
C4 (VDD VSS) capacitor c=1.17329e-16
C5 (B1 VSS) capacitor c=8.82803e-17
C6 (net124 VSS) capacitor c=6.82653e-17
C7 (net128 VSS) capacitor c=3.59045e-16
C8 (net119 VSS) capacitor c=2.70639e-18
C9 (net115 VSS) capacitor c=8.08886e-18
C10 (\3\:B0 VSS) capacitor c=5.24202e-17
C11 (\1\:B1 VSS) capacitor c=5.74489e-17
C12 (\1\:A1 VSS) capacitor c=5.3171e-17
C13 (\1\:A0 VSS) capacitor c=5.35262e-17
C14 (\1\:B0 VSS) capacitor c=4.53683e-17
C15 (\4\:B1 VSS) capacitor c=4.57078e-17
C16 (\3\:A1 VSS) capacitor c=5.82862e-17
C17 (\3\:A0 VSS) capacitor c=3.6662e-17
C18 (\3\:B1 VSS) capacitor c=5.03437e-17
C19 (\2\:A1 VSS) capacitor c=5.53076e-17
C20 (\2\:A0 VSS) capacitor c=4.73593e-17
C21 (\1\:VDD VSS) capacitor c=2.02082e-16
C22 (\17\:net128 VSS) capacitor c=1.05144e-16
C23 (\12\:VDD VSS) capacitor c=3.68664e-17
C24 (\1\:Y VSS) capacitor c=1.22571e-16
C25 (\14\:net128 VSS) capacitor c=3.26989e-17
C26 (\3\:net124 VSS) capacitor c=9.61831e-17
C27 (\5\:net124 VSS) capacitor c=5.7454e-17
C28 (\2\:B0 VSS) capacitor c=4.13032e-17
C29 (\4\:A0 VSS) capacitor c=2.43437e-17
C30 (\4\:A1 VSS) capacitor c=1.308e-16
C31 (\5\:B1 VSS) capacitor c=6.45405e-17
C32 (\5\:B0 VSS) capacitor c=3.67844e-17
C33 (\16\:net128 VSS) capacitor c=1.33615e-16
C34 (\3\:Y VSS) capacitor c=3.81021e-17
C35 (\4\:Y VSS) capacitor c=1.77672e-16
C36 (\7\:VDD VSS) capacitor c=1.88839e-17
Rk4 (\4\:A1 A1) resistor r=0.003676 c=0
Rk21 (\1\:VSS \6\:VSS) resistor r=0.07243 c=0
Rk23 (\7\:VSS VSS) resistor r=0.1774 c=0
Rk22 (\6\:VSS \7\:VSS) resistor r=0.373 c=0
Rk26 (\7\:VSS \13\:VSS) resistor r=0.2573 c=0
Rk8 (B0 \5\:B0) resistor r=0.1375 c=0
Rk3 (\4\:A0 A0) resistor r=0.04486 c=0
Rk17 (\3\:Y Y) resistor r=0.06291 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.3638 c=0
Rk14 (\3\:Y \4\:Y) resistor r=0.2258 c=0
Rk31 (\7\:VDD VDD) resistor r=0.09723 c=0
Rk30 (\1\:VDD \7\:VDD) resistor r=0.3853 c=0
Rk34 (\7\:VDD \13\:VDD) resistor r=0.1991 c=0
Rk5 (B1 \5\:B1) resistor r=0.1585 c=0
Rk6 (\2\:net124 \4\:net124) resistor r=0.4671 c=0
Rk7 (\4\:net124 \6\:net124) resistor r=0.4212 c=0
Rk11 (\16\:net128 net128) resistor r=0.3532 c=0
Rk9 (\15\:net128 \16\:net128) resistor r=0.1366 c=0
