Rk10 (\16\:net128 \18\:net128) resistor r=0.6444 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=117.999 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=77.3776 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=88.9161 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=5.0149 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=96.3069 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=53.0211 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=99.7141 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=65.0987 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.5166 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\15\:net128 \14\:net128) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\18\:net128 \17\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B1 \5\:B1) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn1 (\3\:net124 \3\:A1 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn3 (\14\:net128 \4\:B1 \3\:net124 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn2 (\14\:net128 \1\:B0 net124 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.29e-14 ps=8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn4_1__rcx (\1\:Y net128 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.095e-14 ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
ends OA22X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:41 2013 )
// Library name: gsclib045_hvt
// Cell name: OA22XL
// View name: extracted

simulator lang=spectre

subckt OA22XL A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=15.0366 \
        scb=0.0139559 scc=0.00019117 m=(1)
mp1 (\6\:net128 \1\:A1 net119 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=4.192e-14 ps=7.3e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=8.4e-07 sd=160n sca=12.0447 \
        scb=0.00904147 scc=0.000101203 m=(1)
mp3 (\6\:net128 \1\:B1 net115 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=4.192e-14 ps=8.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6e-07 sd=160n sca=10.7796 \
        scb=0.00791215 scc=9.84845e-05 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=3.45e-07 sd=160n sca=10.9535 \
        scb=0.00800214 scc=9.85336e-05 m=(1)
mp4 (\3\:Y \3\:net128 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.4e-07 sd=160n sca=12.1773 \
        scb=0.00921403 scc=0.000102074 m=(1)
C1 (A1 VSS) capacitor c=1.11455e-16
C2 (VDD VSS) capacitor c=1.4553e-16
C3 (A0 VSS) capacitor c=3.11497e-17
C4 (Y VSS) capacitor c=6.80447e-17
C5 (B1 VSS) capacitor c=7.82952e-17
C6 (net124 VSS) capacitor c=8.18515e-17
C7 (net128 VSS) capacitor c=3.33906e-17
C8 (net115 VSS) capacitor c=3.22087e-18
C9 (\3\:net128 VSS) capacitor c=6.16443e-17
C10 (\3\:B0 VSS) capacitor c=5.06841e-17
C11 (\1\:B1 VSS) capacitor c=5.41512e-17
C12 (\1\:A1 VSS) capacitor c=6.67281e-17
C13 (\1\:A0 VSS) capacitor c=5.22555e-17
C14 (\1\:B0 VSS) capacitor c=4.54995e-17
C15 (\3\:B1 VSS) capacitor c=3.43576e-17
C16 (\3\:A1 VSS) capacitor c=3.73546e-17
C17 (\4\:A0 VSS) capacitor c=4.2681e-17
C18 (\2\:net128 VSS) capacitor c=5.86386e-17
C19 (\2\:B0 VSS) capacitor c=6.40225e-17
C20 (\2\:B1 VSS) capacitor c=4.98134e-17
C21 (\2\:A1 VSS) capacitor c=5.99456e-17
C22 (\3\:A0 VSS) capacitor c=4.64772e-17
C23 (\3\:Y VSS) capacitor c=3.12523e-17
C24 (\1\:VDD VSS) capacitor c=3.58986e-17
C25 (\6\:net128 VSS) capacitor c=9.61691e-17
C26 (\6\:VDD VSS) capacitor c=1.26104e-17
C27 (\1\:Y VSS) capacitor c=5.01181e-17
C28 (\8\:net128 VSS) capacitor c=2.90712e-17
C29 (\3\:net124 VSS) capacitor c=9.23196e-17
C30 (\5\:net124 VSS) capacitor c=3.23136e-17
C31 (\5\:A0 VSS) capacitor c=5.97127e-17
C32 (\4\:B1 VSS) capacitor c=4.81527e-17
C33 (\4\:B0 VSS) capacitor c=1.04681e-16
C34 (\4\:net128 VSS) capacitor c=3.372e-17
C35 (\5\:net128 VSS) capacitor c=1.07711e-16
C36 (\4\:VDD VSS) capacitor c=5.96587e-17
C37 (\5\:VDD VSS) capacitor c=1.44508e-17
Rk2 (A1 \4\:A1) resistor r=0.003947 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.306 c=0
Rk18 (\5\:VDD VDD) resistor r=0.07937 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.319 c=0
Rk19 (\5\:VDD \7\:VDD) resistor r=0.1713 c=0
Rk4 (\4\:B0 B0) resistor r=0.002981 c=0
Rk1 (A0 \5\:A0) resistor r=0.06559 c=0
Rk10 (\2\:Y Y) resistor r=0.6708 c=0
Rk11 (Y \4\:Y) resistor r=0.07319 c=0
Rk12 (\2\:VSS \4\:VSS) resistor r=0.3183 c=0
Rk14 (\5\:VSS VSS) resistor r=0.1966 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.2018 c=0
Rk15 (\5\:VSS \7\:VSS) resistor r=0.07265 c=0
Rk3 (\4\:B1 B1) resistor r=0.1925 c=0
Rk5 (\2\:net124 \4\:net124) resistor r=0.6714 c=0
Rk6 (\4\:net124 \6\:net124) resistor r=0.275 c=0
Rk7 (\4\:net128 \5\:net128) resistor r=0.2348 c=0
Rk8 (\5\:net128 \7\:net128) resistor r=0.633 c=0
Rk9 (\5\:net128 \9\:net128) resistor r=0.1357 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=219.923 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=39.1533 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=147.528 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=113.462 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=184.329 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=92.0218 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=0.5166 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=193 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=66.0764 c=0
Rl11 (\2\:net128 \3\:net128) resistor r=230.002 c=0
Rl10 (net128 \2\:net128) resistor r=104.386 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\8\:net128 \9\:net128) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry1 (\6\:net128 \7\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\2\:net128 \4\:net128) resistor r=45 c=0
mn0 (\5\:net124 \4\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.03e-14 ps=1.33e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\3\:net124 \3\:A1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.828e-14 ps=1.33e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=7.1e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\8\:net128 \3\:B1 \3\:net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=4.132e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=4.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\8\:net128 \1\:B0 net124 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.132e-14 ps=5.7e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (\1\:Y net128 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
ends OA22XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:42 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI211X1
// View name: extracted

simulator lang=spectre

subckt OAI211X1 A0 A1 B0 C0 VDD VSS Y
mp0 (n2 \1\:A0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=26.0122 \
        scb=0.0294337 scc=0.00173965 m=(1)
mp1 (\4\:Y \3\:A1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.165e-14 ps=9e-07 pd=1.25e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.25e-07 sd=160n sca=19.2311 scb=0.0199775 \
        scc=0.000575468 m=(1)
mp2 (\4\:Y \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.165e-14 ps=1.1e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=3.45e-07 sd=160n sca=16.9088 \
        scb=0.0154331 scc=0.000373012 m=(1)
mp3 (\6\:Y \1\:C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=25.4829 \
        scb=0.0288592 scc=0.00163037 m=(1)
C1 (Y VSS) capacitor c=3.34278e-17
C2 (C0 VSS) capacitor c=7.62193e-17
C3 (VDD VSS) capacitor c=9.10361e-17
C4 (n0 VSS) capacitor c=5.96235e-17
C5 (n1 VSS) capacitor c=3.39295e-18
C6 (\1\:C0 VSS) capacitor c=4.93989e-17
C7 (\3\:B0 VSS) capacitor c=5.20473e-17
C8 (\3\:A1 VSS) capacitor c=8.6448e-17
C9 (\1\:A0 VSS) capacitor c=6.29686e-17
C10 (\3\:C0 VSS) capacitor c=4.29072e-17
C11 (\1\:B0 VSS) capacitor c=5.49322e-17
C12 (\1\:A1 VSS) capacitor c=4.73208e-17
C13 (\4\:A0 VSS) capacitor c=5.51383e-17
C14 (\2\:C0 VSS) capacitor c=5.07672e-17
C15 (\2\:B0 VSS) capacitor c=5.81027e-17
C16 (\2\:A1 VSS) capacitor c=6.59008e-17
C17 (\3\:A0 VSS) capacitor c=1.44632e-17
C18 (\1\:VDD VSS) capacitor c=6.32332e-17
C19 (\4\:Y VSS) capacitor c=7.3039e-17
C20 (\5\:VDD VSS) capacitor c=3.82398e-17
C21 (\1\:Y VSS) capacitor c=8.48154e-17
C22 (\3\:n0 VSS) capacitor c=3.8718e-17
C23 (\2\:A0 VSS) capacitor c=4.97519e-17
C24 (\5\:A0 VSS) capacitor c=2.39587e-17
C25 (\7\:A0 VSS) capacitor c=2.71195e-17
C26 (\4\:A1 VSS) capacitor c=3.21236e-17
C27 (\6\:A1 VSS) capacitor c=3.11502e-17
C28 (\4\:B0 VSS) capacitor c=5.03811e-17
C29 (\5\:B0 VSS) capacitor c=5.30536e-17
C30 (\4\:C0 VSS) capacitor c=6.67243e-17
C31 (\3\:Y VSS) capacitor c=6.37622e-17
C32 (\4\:VDD VSS) capacitor c=3.06921e-17
Rk8 (B0 \4\:B0) resistor r=0.0105 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.05693 c=0
Rk9 (\5\:B0 \6\:B0) resistor r=0.01062 c=0
Rk14 (\3\:Y Y) resistor r=0.1013 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5242 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.3771 c=0
Rk15 (Y \7\:Y) resistor r=0.01164 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.004734 c=0
Rk5 (A1 \6\:A1) resistor r=0.004599 c=0
Rk6 (\4\:A1 \6\:A1) resistor r=0.05081 c=0
Rk20 (\3\:VSS VSS) resistor r=0.1024 c=0
Rk21 (\3\:VSS \5\:VSS) resistor r=0.1814 c=0
Rk11 (\4\:C0 C0) resistor r=0.1732 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002117 c=0
Rk2 (A0 \7\:A0) resistor r=0.001975 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.04803 c=0
Rk17 (\4\:VDD VDD) resistor r=0.2007 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3526 c=0
Rk18 (VDD \6\:VDD) resistor r=0.2435 c=0
Rk7 (\2\:n0 \4\:n0) resistor r=0.2718 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=76.903 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=110.307 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=101.718 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=86.5156 c=0
Rl8 (\1\:C0 \2\:C0) resistor r=89.6174 c=0
Rl9 (\2\:C0 \3\:C0) resistor r=97.3098 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=34.3295 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=172.791 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.9102 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx3 (\2\:B0 \6\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
mn0 (\3\:n0 \4\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (n0 \1\:A1 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.25e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (n1 \1\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.51e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.2e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn3 (\1\:Y \3\:C0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=3.64e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=7.3e-07 \
        sb=1.4e-07 sd=160n sca=8.09546 scb=0.00588493 scc=0.000117119 \
        m=(1)
ends OAI211X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:44 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI211X2
// View name: extracted

simulator lang=spectre

subckt OAI211X2 A0 A1 B0 C0 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.535e-14 ps=1.06e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=21.5541 \
        scb=0.0195467 scc=0.00162283 m=(1)
mp1_1__rcx (\4\:Y \5\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.535e-14 ad=7.215e-14 ps=9.1e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=1.48e-06 sd=160n sca=20.1813 \
        scb=0.0174167 scc=0.00159977 m=(1)
mp1 (\4\:Y \1\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=7.215e-14 ps=9e-07 pd=1.15e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=1.25e-06 sd=160n sca=18.8666 scb=0.016155 \
        scc=0.0015962 m=(1)
mp0 (4 \6\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3455e-13 ad=2.34e-14 ps=1.47e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.145e-06 sd=160n sca=18.5611 \
        scb=0.0160319 scc=0.00159616 m=(1)
mp3 (\9\:Y \3\:C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=3.45e-07 sd=160n sca=19.0572 \
        scb=0.0162666 scc=0.00159628 m=(2)
mp2_1__rcx (\7\:Y \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.848e-14 ad=6.24e-14 ps=1.285e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
C1 (C0 VSS) capacitor c=4.64526e-17
C2 (A1 VSS) capacitor c=4.03595e-17
C3 (Y VSS) capacitor c=9.86082e-17
C4 (A0 VSS) capacitor c=2.31726e-17
C5 (VDD VSS) capacitor c=1.04072e-16
C6 (n0 VSS) capacitor c=1.59858e-16
C7 (n1 VSS) capacitor c=1.71526e-16
C8 (1 VSS) capacitor c=5.82715e-18
C9 (4 VSS) capacitor c=2.26173e-18
C10 (\6\:A0 VSS) capacitor c=8.02403e-17
C11 (\1\:A1 VSS) capacitor c=7.77077e-17
C12 (\5\:A1 VSS) capacitor c=5.39823e-17
C13 (\1\:A0 VSS) capacitor c=6.39322e-17
C14 (\1\:C0 VSS) capacitor c=7.9291e-17
C15 (\1\:B0 VSS) capacitor c=7.87983e-17
C16 (\3\:B0 VSS) capacitor c=9.31159e-17
C17 (\2\:A1 VSS) capacitor c=2.27207e-17
C18 (\2\:A0 VSS) capacitor c=2.96758e-16
C19 (\1\:VDD VSS) capacitor c=2.01186e-16
C20 (\9\:Y VSS) capacitor c=8.34058e-17
C21 (\7\:Y VSS) capacitor c=2.90651e-17
C22 (\4\:Y VSS) capacitor c=7.5817e-17
C23 (\12\:VDD VSS) capacitor c=4.91072e-17
C24 (\1\:Y VSS) capacitor c=1.56178e-16
C25 (\5\:n0 VSS) capacitor c=1.24666e-16
C26 (\3\:A1 VSS) capacitor c=9.84836e-17
C27 (\3\:C0 VSS) capacitor c=9.81606e-17
C28 (\7\:A1 VSS) capacitor c=6.91461e-17
C29 (\8\:B0 VSS) capacitor c=6.02348e-17
C30 (\9\:B0 VSS) capacitor c=8.89714e-17
C31 (\3\:Y VSS) capacitor c=7.121e-17
C32 (\7\:C0 VSS) capacitor c=3.10534e-17
C33 (\7\:VDD VSS) capacitor c=1.28769e-17
Rk17 (\7\:C0 C0) resistor r=0.1521 c=0
Rk1 (\7\:A1 A1) resistor r=0.1413 c=0
Rk9 (\2\:Y Y) resistor r=0.9513 c=0
Rk10 (Y \3\:Y) resistor r=0.009359 c=0
Rk11 (\3\:Y \5\:Y) resistor r=0.5137 c=0
Rk12 (\3\:Y \6\:Y) resistor r=0.0712 c=0
Rk13 (\6\:Y \8\:Y) resistor r=0.05921 c=0
Rk14 (\6\:Y \10\:Y) resistor r=0.3907 c=0
Rk6 (\7\:B0 \8\:B0) resistor r=0.002322 c=0
Rk7 (\9\:B0 B0) resistor r=0.002322 c=0
Rk8 (\8\:B0 \9\:B0) resistor r=0.06937 c=0
Rk3 (\2\:A0 A0) resistor r=0.01892 c=0
Rk29 (\3\:VSS VSS) resistor r=0.04968 c=0
Rk31 (\3\:VSS \9\:VSS) resistor r=0.2051 c=0
Rk22 (\7\:VDD VDD) resistor r=0.1148 c=0
Rk21 (\1\:VDD \7\:VDD) resistor r=0.3254 c=0
Rk25 (\7\:VDD \13\:VDD) resistor r=0.3309 c=0
Rk5 (n0 \6\:n0) resistor r=0.5755 c=0
Rl16 (\3\:C0 \1\:C0) resistor r=130.542 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=94.9751 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=25.3108 c=0
Rl4 (\3\:A1 \2\:A1) resistor r=10.2925 c=0
Rl11 (\3\:B0 \1\:B0) resistor r=42.0732 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=97.5275 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=53.8233 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz10 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\6\:n0 \5\:n0) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=31 c=0
Ry2 (\8\:Y \7\:Y) resistor r=31 c=0
Ry3 (\10\:Y \9\:Y) resistor r=31 c=0
Ry7 (\13\:VDD \12\:VDD) resistor r=31 c=0
Rx5 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\7\:B0 \3\:B0) resistor r=45 c=0
mn2_1__rcx (n1 \1\:B0 \5\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.615e-14 ps=8.4e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=7.95e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn3 (\1\:Y \1\:C0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.05e-07 sb=3.45e-07 sd=160n sca=9.50447 scb=0.0081528 \
        scc=0.00025289 m=(2)
mn1 (n0 \3\:A1 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.615e-14 ps=8.4e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=5.5e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn0_1__rcx (n0 \2\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.615e-14 ps=8e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.9e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
ends OAI211X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:45 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI211X4
// View name: extracted

simulator lang=spectre

subckt OAI211X4 A0 A1 B0 C0 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=1.0335e-13 ps=1.06e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=24.4649 scb=0.024645 \
        scc=0.00179971 m=(1)
mp1_1__rcx (\9\:Y \5\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.24e-14 ps=1.31e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=19.5407 scb=0.0166665 \
        scc=0.0015969 m=(1)
mp1_2__rcx (\9\:Y \1\:A1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2e-06 sd=160n sca=18.6789 scb=0.0160714 \
        scc=0.00159617 m=(1)
mp0_2__rcx (5 \7\:A0 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=3.9e-14 ps=1.1e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0_3__rcx (3 \4\:A0 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=2e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp1_3__rcx (\7\:Y \11\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.11e-06 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp1 (\7\:Y \7\:A1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.315e-06 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0 (6 \10\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=4.485e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.84e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3_1__rcx (\17\:Y C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(4)
mp2_1__rcx (Y B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
C1 (B0 VSS) capacitor c=4.01851e-16
C2 (A0 VSS) capacitor c=1.85817e-17
C3 (Y VSS) capacitor c=3.0439e-16
C4 (C0 VSS) capacitor c=3.24373e-16
C5 (A1 VSS) capacitor c=4.34606e-16
C6 (VDD VSS) capacitor c=1.46743e-16
C7 (n0 VSS) capacitor c=2.05571e-16
C8 (n1 VSS) capacitor c=3.39171e-16
C9 (5 VSS) capacitor c=3.24837e-18
C10 (3 VSS) capacitor c=1.94902e-18
C11 (6 VSS) capacitor c=3.97122e-18
C12 (\10\:A0 VSS) capacitor c=6.09596e-17
C13 (\7\:A1 VSS) capacitor c=5.25111e-17
C14 (\11\:A1 VSS) capacitor c=5.91911e-17
C15 (\4\:A0 VSS) capacitor c=7.73685e-17
C16 (\7\:A0 VSS) capacitor c=4.20583e-17
C17 (\1\:A1 VSS) capacitor c=5.8571e-17
C18 (\5\:A1 VSS) capacitor c=2.3106e-17
C19 (\1\:A0 VSS) capacitor c=3.39915e-17
C20 (\2\:A0 VSS) capacitor c=5.42918e-16
C21 (\1\:VDD VSS) capacitor c=2.53281e-16
C22 (\7\:Y VSS) capacitor c=1.11378e-16
C23 (\18\:VDD VSS) capacitor c=3.75753e-17
C24 (\9\:Y VSS) capacitor c=9.11103e-17
C25 (\21\:VDD VSS) capacitor c=2.52765e-17
C26 (\3\:VDD VSS) capacitor c=3.98301e-17
C27 (\1\:Y VSS) capacitor c=2.35461e-16
C28 (\3\:n0 VSS) capacitor c=3.19787e-16
C29 (\5\:A0 VSS) capacitor c=2.59761e-17
C30 (\17\:Y VSS) capacitor c=1.49655e-16
C31 (\17\:VDD VSS) capacitor c=1.64539e-17
C32 (\20\:VDD VSS) capacitor c=1.22151e-17
Rk5 (\2\:A0 A0) resistor r=0.09652 c=0
Rk46 (\2\:VSS VSS) resistor r=0.6891 c=0
Rk16 (\1\:Y Y) resistor r=1.127 c=0
Rk17 (Y \8\:Y) resistor r=0.3902 c=0
Rk18 (\8\:Y \10\:Y) resistor r=0.5044 c=0
Rk19 (\10\:Y \11\:Y) resistor r=0.1464 c=0
Rk24 (\8\:Y \16\:Y) resistor r=0.1464 c=0
Rk25 (Y \17\:Y) resistor r=0.3091 c=0
Rk40 (\1\:VDD \16\:VDD) resistor r=0.278 c=0
Rk41 (\16\:VDD \17\:VDD) resistor r=0.05996 c=0
Rk42 (\17\:VDD \19\:VDD) resistor r=0.2632 c=0
Rk45 (\20\:VDD VDD) resistor r=0.0572 c=0
Rk43 (\17\:VDD \20\:VDD) resistor r=0.4332 c=0
Rk44 (\20\:VDD \22\:VDD) resistor r=0.3314 c=0
Rk8 (n0 \3\:n0) resistor r=0.4755 c=0
Rl18 (\2\:A0 \10\:A0) resistor r=91.0764 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=87.6944 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=82.1768 c=0
Rl10 (\5\:A0 \7\:A0) resistor r=38.0255 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=23.0585 c=0
Rl13 (A1 \7\:A1) resistor r=85.3597 c=0
Rl16 (A1 \11\:A1) resistor r=25.3108 c=0
Rl3 (A1 \1\:A1) resistor r=75.2759 c=0
Rl6 (A1 \5\:A1) resistor r=28.079 c=0
Rz14 (\1\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz15 (\16\:VDD \3\:VDD) resistor r=6.25 c=0
Ry18 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry2 (\8\:Y \7\:Y) resistor r=62 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry4 (\11\:Y \9\:Y) resistor r=62 c=0
Ry7 (\16\:Y \7\:Y) resistor r=62 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\22\:VDD \21\:VDD) resistor r=31 c=0
mn3_1__rcx (\1\:Y C0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn0_1__rcx (\3\:n0 \2\:A0 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn1_1__rcx (\3\:n0 A1 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn2_1__rcx (n1 B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.518e-14 ps=8.4e-07 pd=8.675e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.55e-07 sb=1.605e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
ends OAI211X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:46 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI211XL
// View name: extracted

simulator lang=spectre

subckt OAI211XL A0 A1 B0 C0 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=2.15e-14 ps=1.35e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.9e-07 sd=160n sca=16.7249 scb=0.0166366 \
        scc=0.000331722 m=(1)
mp1 (\5\:Y \3\:A1 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=4.623e-14 ps=6.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=14.2593 \
        scb=0.0117802 scc=0.000198925 m=(1)
mp2 (\5\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.623e-14 ps=1.45e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=3.85e-07 sd=160n sca=14.4951 \
        scb=0.0122555 scc=0.000205064 m=(1)
mp3 (\3\:Y \1\:C0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.085e-14 ps=1.45e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.9e-07 sd=160n sca=19.8673 scb=0.021958 \
        scc=0.00070962 m=(1)
C1 (B0 VSS) capacitor c=9.11027e-17
C2 (Y VSS) capacitor c=1.65011e-17
C3 (A1 VSS) capacitor c=1.23687e-16
C4 (VDD VSS) capacitor c=9.60935e-17
C5 (C0 VSS) capacitor c=6.15609e-17
C6 (A0 VSS) capacitor c=4.23146e-17
C7 (n0 VSS) capacitor c=4.7561e-17
C8 (\1\:C0 VSS) capacitor c=3.68429e-17
C9 (\1\:B0 VSS) capacitor c=6.14629e-17
C10 (\3\:A1 VSS) capacitor c=4.88174e-17
C11 (\1\:A0 VSS) capacitor c=4.10968e-17
C12 (\3\:C0 VSS) capacitor c=6.48189e-17
C13 (\3\:B0 VSS) capacitor c=5.23225e-17
C14 (\1\:A1 VSS) capacitor c=5.09184e-17
C15 (\3\:A0 VSS) capacitor c=4.59325e-17
C16 (\2\:C0 VSS) capacitor c=5.71333e-17
C17 (\2\:B0 VSS) capacitor c=6.56255e-17
C18 (\2\:A1 VSS) capacitor c=6.27665e-17
C19 (\2\:A0 VSS) capacitor c=5.2846e-17
C20 (\3\:Y VSS) capacitor c=7.99802e-17
C21 (\1\:VDD VSS) capacitor c=2.64432e-17
C22 (\5\:Y VSS) capacitor c=4.58441e-17
C23 (\6\:VDD VSS) capacitor c=1.78482e-17
C24 (\1\:Y VSS) capacitor c=6.92182e-17
C25 (\3\:n0 VSS) capacitor c=7.13063e-17
C26 (\4\:A0 VSS) capacitor c=4.15873e-17
C27 (\4\:B0 VSS) capacitor c=4.17237e-17
C28 (\4\:C0 VSS) capacitor c=6.98254e-17
C29 (\4\:VDD VSS) capacitor c=1.71001e-17
C30 (\5\:VDD VSS) capacitor c=3.72658e-18
Rk6 (\4\:B0 B0) resistor r=0.08091 c=0
Rk10 (\4\:Y Y) resistor r=0.03755 c=0
Rk8 (\2\:Y \4\:Y) resistor r=0.585 c=0
Rk9 (\4\:Y \6\:Y) resistor r=0.3026 c=0
Rk2 (\4\:A1 A1) resistor r=0.002987 c=0
Rk16 (\3\:VSS VSS) resistor r=0.1671 c=0
Rk17 (\3\:VSS \5\:VSS) resistor r=0.1994 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.2114 c=0
Rk13 (\5\:VDD VDD) resistor r=0.08707 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1623 c=0
Rk14 (\5\:VDD \7\:VDD) resistor r=0.073 c=0
Rk7 (C0 \4\:C0) resistor r=0.2091 c=0
Rk1 (A0 \4\:A0) resistor r=0.224 c=0
Rk3 (\2\:n0 \4\:n0) resistor r=0.4489 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=144.923 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=102.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=93.4066 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=155.769 c=0
Rl7 (\1\:C0 \2\:C0) resistor r=30.7692 c=0
Rl8 (\2\:C0 \3\:C0) resistor r=218.407 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=85.7134 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=154.944 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (n0 \3\:A0 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn1 (\3\:n0 \1\:A1 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.7e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn2 (n1 \3\:B0 \3\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.377e-14 ps=6.1e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.65e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn3 (\1\:Y \3\:C0 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.378e-14 ad=3.263e-14 ps=4.8e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.25e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
ends OAI211XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:47 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI21X1
// View name: extracted

simulator lang=spectre

subckt OAI21X1 A0 A1 B0 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=18.8564 \
        scb=0.0195514 scc=0.000495827 m=(1)
mp1 (\3\:Y \1\:A1 n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=3.45e-07 sd=160n sca=16.4103 scb=0.0148066 \
        scc=0.000275039 m=(1)
mp2 (\3\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=16.6925 \
        scb=0.0153965 scc=0.00029244 m=(1)
C1 (A1 VSS) capacitor c=1.87179e-17
C2 (VDD VSS) capacitor c=7.28144e-17
C3 (A0 VSS) capacitor c=2.07645e-17
C4 (Y VSS) capacitor c=8.74115e-17
C5 (B0 VSS) capacitor c=2.09903e-17
C6 (n0 VSS) capacitor c=7.37524e-17
C7 (\1\:B0 VSS) capacitor c=3.83262e-17
C8 (\1\:A1 VSS) capacitor c=9.11496e-17
C9 (\1\:A0 VSS) capacitor c=1.02686e-16
C10 (\3\:B0 VSS) capacitor c=5.39592e-17
C11 (\3\:A1 VSS) capacitor c=6.29054e-17
C12 (\3\:A0 VSS) capacitor c=4.39556e-17
C13 (\2\:B0 VSS) capacitor c=4.60171e-17
C14 (\2\:A1 VSS) capacitor c=5.79431e-17
C15 (\2\:A0 VSS) capacitor c=4.8116e-17
C16 (\1\:VDD VSS) capacitor c=4.89723e-17
C17 (\3\:Y VSS) capacitor c=7.50713e-17
C18 (\6\:VDD VSS) capacitor c=3.38283e-17
C19 (\1\:Y VSS) capacitor c=6.35276e-17
C20 (\3\:n0 VSS) capacitor c=6.84672e-17
C21 (\4\:A0 VSS) capacitor c=3.77566e-17
C22 (\4\:A1 VSS) capacitor c=4.88878e-17
C23 (\4\:B0 VSS) capacitor c=8.13436e-17
C24 (\4\:VDD VSS) capacitor c=2.08166e-17
C25 (\5\:VDD VSS) capacitor c=7.55964e-18
Rk2 (\4\:A1 A1) resistor r=0.05761 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.3335 c=0
Rk9 (\5\:VDD VDD) resistor r=0.0496 c=0
Rk8 (\4\:VDD \5\:VDD) resistor r=0.1499 c=0
Rk10 (\5\:VDD \7\:VDD) resistor r=0.2518 c=0
Rk1 (\4\:A0 A0) resistor r=0.0525 c=0
Rk5 (\2\:Y Y) resistor r=0.4894 c=0
Rk6 (Y \4\:Y) resistor r=0.2783 c=0
Rk12 (\3\:VSS VSS) resistor r=0.1012 c=0
Rk13 (\3\:VSS \5\:VSS) resistor r=0.1182 c=0
Rk4 (B0 \4\:B0) resistor r=0.03123 c=0
Rk3 (\2\:n0 \4\:n0) resistor r=0.4252 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=87.2302 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=117.999 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=169.894 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=49.1749 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=29.9442 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=168.406 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=37.5 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=20.6667 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=3.64e-14 ps=1.14e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (n0 \3\:A1 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=4.16e-14 ps=1.14e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \3\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=5.5e-07 \
        sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 scc=9.84911e-05 \
        m=(1)
ends OAI21X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:48 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI21X2
// View name: extracted

simulator lang=spectre

subckt OAI21X2 A0 A1 B0 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=3.315e-14 ps=1.08e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.025e-06 sd=160n sca=14.3979 \
        scb=0.0128198 scc=0.000254146 m=(1)
mp1_1__rcx (\6\:Y \6\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.315e-14 ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=8.95e-07 sd=160n sca=12.9324 \
        scb=0.0106401 scc=0.000233941 m=(1)
mp1 (\6\:Y \1\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.85e-07 sb=6.9e-07 sd=160n sca=11.8564 scb=0.00969513 \
        scc=0.0002319 m=(1)
mp0 (4 \6\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.605e-14 ad=2.34e-14 ps=1.17e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=5.85e-07 sd=160n sca=11.6462 \
        scb=0.00959597 scc=0.000231862 m=(1)
mp2 (\4\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.532e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=3.45e-07 sd=160n sca=12.2699 \
        scb=0.00996585 scc=0.000232152 m=(2)
C1 (B0 VSS) capacitor c=1.55439e-17
C2 (Y VSS) capacitor c=2.91841e-17
C3 (A0 VSS) capacitor c=3.25037e-16
C4 (A1 VSS) capacitor c=5.61425e-17
C5 (VDD VSS) capacitor c=1.05692e-16
C6 (n0 VSS) capacitor c=9.16589e-17
C7 (1 VSS) capacitor c=3.4798e-18
C8 (4 VSS) capacitor c=1.86068e-18
C9 (\6\:A0 VSS) capacitor c=8.4418e-17
C10 (\1\:A1 VSS) capacitor c=6.20032e-17
C11 (\6\:A1 VSS) capacitor c=4.29888e-17
C12 (\1\:A0 VSS) capacitor c=6.6294e-17
C13 (\1\:B0 VSS) capacitor c=1.56504e-16
C14 (\1\:VDD VSS) capacitor c=9.78645e-17
C15 (\4\:Y VSS) capacitor c=8.50857e-17
C16 (\6\:Y VSS) capacitor c=9.70182e-17
C17 (\9\:VDD VSS) capacitor c=5.18611e-17
C18 (\1\:Y VSS) capacitor c=4.18405e-17
C19 (\2\:A1 VSS) capacitor c=1.43298e-16
C20 (\7\:A1 VSS) capacitor c=6.37633e-17
C21 (\3\:Y VSS) capacitor c=4.59532e-17
C22 (\8\:B0 VSS) capacitor c=8.22814e-17
C23 (\2\:n0 VSS) capacitor c=1.70771e-16
C24 (\5\:VDD VSS) capacitor c=2.2763e-17
C25 (\6\:VDD VSS) capacitor c=1.29027e-17
Rk10 (B0 \8\:B0) resistor r=0.02037 c=0
Rk6 (\3\:Y Y) resistor r=0.1105 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.2433 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.2361 c=0
Rk7 (\5\:Y \7\:Y) resistor r=0.3796 c=0
Rk8 (\7\:Y \8\:Y) resistor r=0.1523 c=0
Rk9 (\5\:Y \9\:Y) resistor r=0.1555 c=0
Rk1 (\7\:A1 A1) resistor r=0.192 c=0
Rk22 (\1\:VSS VSS) resistor r=0.1843 c=0
Rk15 (\1\:VDD \5\:VDD) resistor r=0.04224 c=0
Rk17 (\6\:VDD VDD) resistor r=0.1144 c=0
Rk16 (\5\:VDD \6\:VDD) resistor r=0.2844 c=0
Rk19 (\6\:VDD \10\:VDD) resistor r=0.2616 c=0
Rl9 (A0 \6\:A0) resistor r=78.6412 c=0
Rl1 (A0 \1\:A0) resistor r=96.1538 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=47.3105 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=24.2328 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\2\:n0 n0) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\8\:Y \6\:Y) resistor r=62 c=0
Ry4 (\9\:Y \4\:Y) resistor r=62 c=0
Ry7 (\10\:VDD \9\:VDD) resistor r=20.6667 c=0
Rx4 (\8\:B0 \1\:B0) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
mn1 (n0 \2\:A1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.025e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\2\:n0 A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.745e-14 ps=8.4e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\1\:Y \1\:B0 \2\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.745e-14 ad=4.16e-14 ps=8.85e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
ends OAI21X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:49 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI21X4
// View name: extracted

simulator lang=spectre

subckt OAI21X4 A0 A1 B0 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=7.995e-14 ps=1.06e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.9101 scb=0.0232377 \
        scc=0.0012647 m=(1)
mp1_1__rcx (\12\:Y \5\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.985e-06 sd=160n sca=17.1039 \
        scb=0.0151782 scc=0.00102545 m=(1)
mp1_2__rcx (\12\:Y \1\:A1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.78e-06 sd=160n sca=15.9572 \
        scb=0.0141077 scc=0.00102277 m=(1)
mp0_2__rcx (5 \7\:A0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.675e-06 sd=160n sca=15.641 scb=0.0139735 \
        scc=0.00102271 m=(1)
mp0_3__rcx (6 \4\:A0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.47e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_3__rcx (\10\:Y \10\:A1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.365e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1 (\10\:Y \12\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=1.16e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp0 (3 \12\:A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=5.46e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=9.75e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_1__rcx (\1\:Y B0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.191e-14 ad=6.24e-14 ps=1.0975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62e-06 sb=7.55e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(4)
C1 (A0 VSS) capacitor c=4.14374e-17
C2 (A1 VSS) capacitor c=2.75138e-17
C3 (Y VSS) capacitor c=4.5075e-18
C4 (B0 VSS) capacitor c=3.36671e-16
C5 (VDD VSS) capacitor c=1.11623e-16
C6 (n0 VSS) capacitor c=4.91963e-16
C7 (5 VSS) capacitor c=1.92642e-18
C8 (6 VSS) capacitor c=1.92642e-18
C9 (3 VSS) capacitor c=5.39218e-18
C10 (\12\:A0 VSS) capacitor c=5.87066e-17
C11 (\12\:A1 VSS) capacitor c=4.45027e-17
C12 (\10\:A1 VSS) capacitor c=5.9542e-17
C13 (\4\:A0 VSS) capacitor c=7.52476e-17
C14 (\7\:A0 VSS) capacitor c=6.81789e-17
C15 (\1\:A1 VSS) capacitor c=6.41638e-17
C16 (\5\:A1 VSS) capacitor c=2.68717e-17
C17 (\1\:A0 VSS) capacitor c=4.25745e-17
C18 (\2\:A1 VSS) capacitor c=4.2778e-16
C19 (\2\:A0 VSS) capacitor c=5.50399e-16
C20 (\1\:Y VSS) capacitor c=2.12031e-16
C21 (\10\:Y VSS) capacitor c=1.07672e-16
C22 (\15\:VDD VSS) capacitor c=3.84444e-17
C23 (\12\:Y VSS) capacitor c=9.19968e-17
C24 (\17\:VDD VSS) capacitor c=3.13969e-17
C25 (\1\:VDD VSS) capacitor c=1.80747e-17
C26 (\6\:Y VSS) capacitor c=1.58743e-16
C27 (\5\:A0 VSS) capacitor c=3.38243e-17
C28 (\3\:VDD VSS) capacitor c=1.58943e-16
C29 (\7\:VDD VSS) capacitor c=1.8428e-17
C30 (\8\:VDD VSS) capacitor c=1.2584e-17
Rk3 (A0 \2\:A0) resistor r=0.1463 c=0
Rk2 (\2\:A1 A1) resistor r=0.06619 c=0
Rk41 (\3\:VSS VSS) resistor r=0.08978 c=0
Rk36 (\2\:VSS \3\:VSS) resistor r=0.5461 c=0
Rk15 (\1\:Y Y) resistor r=0.08385 c=0
Rk10 (\1\:Y \6\:Y) resistor r=0.4346 c=0
Rk12 (\1\:Y \11\:Y) resistor r=0.4446 c=0
Rk13 (\11\:Y \13\:Y) resistor r=0.4712 c=0
Rk14 (\13\:Y \14\:Y) resistor r=0.1562 c=0
Rk16 (Y \15\:Y) resistor r=0.04792 c=0
Rk17 (\11\:Y \16\:Y) resistor r=0.1562 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.04742 c=0
Rk27 (\3\:VDD \6\:VDD) resistor r=0.2354 c=0
Rk28 (\6\:VDD \7\:VDD) resistor r=0.1151 c=0
Rk30 (\8\:VDD VDD) resistor r=0.05218 c=0
Rk29 (\7\:VDD \8\:VDD) resistor r=0.3831 c=0
Rk34 (\7\:VDD \16\:VDD) resistor r=0.2429 c=0
Rk35 (\8\:VDD \18\:VDD) resistor r=0.3326 c=0
Rl19 (\2\:A0 \12\:A0) resistor r=91.7582 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=99.2328 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=128.331 c=0
Rl10 (\5\:A0 \7\:A0) resistor r=84.1794 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=6.3032 c=0
Rl17 (\2\:A1 \12\:A1) resistor r=82.6695 c=0
Rl15 (\2\:A1 \10\:A1) resistor r=30.5643 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=65.924 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=49.6216 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz11 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry4 (\11\:Y \10\:Y) resistor r=62 c=0
Ry5 (\13\:Y \12\:Y) resistor r=62 c=0
Ry6 (\14\:Y \12\:Y) resistor r=62 c=0
Ry7 (\15\:Y \1\:Y) resistor r=62 c=0
Ry8 (\16\:Y \10\:Y) resistor r=62 c=0
Ry12 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
mn2_1__rcx (\6\:Y B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn0_1__rcx (n0 \2\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn1_1__rcx (n0 \2\:A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
ends OAI21X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:51 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI21XL
// View name: extracted

simulator lang=spectre

subckt OAI21XL A0 A1 B0 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.45e-07 sd=160n sca=19.4229 \
        scb=0.0204259 scc=0.000577964 m=(1)
mp1 (\3\:Y \1\:A1 n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.4e-07 sd=160n sca=14.8962 \
        scb=0.0119773 scc=0.000116187 m=(1)
mp2 (\3\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=1.4e-07 sd=160n sca=22.0785 \
        scb=0.0241761 scc=0.00103379 m=(1)
C1 (A1 VSS) capacitor c=4.62877e-17
C2 (Y VSS) capacitor c=8.00603e-17
C3 (A0 VSS) capacitor c=6.92329e-17
C4 (B0 VSS) capacitor c=1.23861e-16
C5 (VDD VSS) capacitor c=1.15211e-16
C6 (n0 VSS) capacitor c=4.99754e-17
C7 (\1\:B0 VSS) capacitor c=4.4533e-17
C8 (\1\:A1 VSS) capacitor c=4.79558e-17
C9 (\1\:A0 VSS) capacitor c=3.40546e-17
C10 (\3\:B0 VSS) capacitor c=2.84243e-17
C11 (\3\:A1 VSS) capacitor c=4.58349e-17
C12 (\4\:A0 VSS) capacitor c=5.05288e-17
C13 (\2\:B0 VSS) capacitor c=4.93716e-17
C14 (\2\:A1 VSS) capacitor c=5.54226e-17
C15 (\3\:A0 VSS) capacitor c=1.72885e-17
C16 (\1\:VDD VSS) capacitor c=2.69072e-17
C17 (\3\:Y VSS) capacitor c=6.41863e-17
C18 (\6\:VDD VSS) capacitor c=1.90387e-17
C19 (\1\:Y VSS) capacitor c=6.23607e-17
C20 (\3\:n0 VSS) capacitor c=8.05906e-17
C21 (\2\:A0 VSS) capacitor c=3.73052e-17
C22 (\4\:A1 VSS) capacitor c=5.06674e-17
C23 (\4\:VDD VSS) capacitor c=2.04525e-17
C24 (\5\:VDD VSS) capacitor c=6.83594e-18
Rk2 (A1 \4\:A1) resistor r=0.2246 c=0
Rk5 (\2\:Y Y) resistor r=0.4753 c=0
Rk6 (Y \4\:Y) resistor r=0.3247 c=0
Rk1 (\5\:A0 A0) resistor r=0.002995 c=0
Rk12 (\3\:VSS VSS) resistor r=0.1349 c=0
Rk13 (\3\:VSS \5\:VSS) resistor r=0.2805 c=0
Rk4 (\4\:B0 B0) resistor r=0.002995 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.3613 c=0
Rk9 (\5\:VDD VDD) resistor r=0.03213 c=0
Rk8 (\4\:VDD \5\:VDD) resistor r=0.1677 c=0
Rk10 (\5\:VDD \7\:VDD) resistor r=0.1731 c=0
Rk3 (\2\:n0 \4\:n0) resistor r=0.4851 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=143 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.076 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=81.5719 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=193.11 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=14.2236 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=221.551 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=39.5604 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (n0 \4\:A0 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\3\:n0 \3\:A1 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.5e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\1\:Y \3\:B0 \3\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
ends OAI21XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:51 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI221X1
// View name: extracted

simulator lang=spectre

subckt OAI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (net115 \1\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.2e-07 sd=160n sca=20.0914 \
        scb=0.0223631 scc=0.000753507 m=(1)
mp1 (\6\:Y \1\:A1 net115 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.15e-07 sd=160n sca=15.9166 \
        scb=0.0154749 scc=0.000316749 m=(1)
mp3 (\6\:Y \1\:B1 net123 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.5e-07 sd=160n sca=12.9574 \
        scb=0.0102588 scc=0.000232318 m=(1)
mp2 (net123 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=3.45e-07 sd=160n sca=13.2989 \
        scb=0.010817 scc=0.000234376 m=(1)
mp4 (\4\:Y \3\:C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.4e-07 sd=160n sca=16.1834 \
        scb=0.0159482 scc=0.0003331 m=(1)
C1 (C0 VSS) capacitor c=4.50543e-17
C2 (A1 VSS) capacitor c=1.81174e-17
C3 (B0 VSS) capacitor c=4.65559e-17
C4 (A0 VSS) capacitor c=1.77759e-17
C5 (VDD VSS) capacitor c=1.16571e-16
C6 (Y VSS) capacitor c=4.53538e-18
C7 (B1 VSS) capacitor c=6.91296e-17
C8 (net128 VSS) capacitor c=1.12959e-16
C9 (net132 VSS) capacitor c=4.8752e-17
C10 (net115 VSS) capacitor c=1.40103e-18
C11 (net123 VSS) capacitor c=2.6962e-18
C12 (\3\:C0 VSS) capacitor c=4.71588e-17
C13 (\3\:B0 VSS) capacitor c=9.70051e-17
C14 (\1\:B1 VSS) capacitor c=7.84373e-17
C15 (\1\:A1 VSS) capacitor c=6.27468e-17
C16 (\1\:A0 VSS) capacitor c=7.42522e-17
C17 (\1\:C0 VSS) capacitor c=3.423e-17
C18 (\1\:B0 VSS) capacitor c=3.87367e-17
C19 (\3\:B1 VSS) capacitor c=5.06407e-17
C20 (\3\:A1 VSS) capacitor c=5.22917e-17
C21 (\3\:A0 VSS) capacitor c=3.40202e-17
C22 (\2\:C0 VSS) capacitor c=3.96712e-17
C23 (\2\:B0 VSS) capacitor c=6.08538e-17
C24 (\2\:B1 VSS) capacitor c=5.00457e-17
C25 (\2\:A1 VSS) capacitor c=4.73959e-17
C26 (\2\:A0 VSS) capacitor c=4.86632e-17
C27 (\4\:Y VSS) capacitor c=5.35853e-17
C28 (\1\:VDD VSS) capacitor c=6.45718e-17
C29 (\6\:Y VSS) capacitor c=7.31695e-17
C30 (\6\:VDD VSS) capacitor c=2.43265e-17
C31 (\1\:Y VSS) capacitor c=6.28543e-17
C32 (\3\:net132 VSS) capacitor c=6.27305e-17
C33 (\3\:net128 VSS) capacitor c=3.9841e-17
C34 (\4\:A0 VSS) capacitor c=2.08285e-17
C35 (\4\:A1 VSS) capacitor c=2.72935e-17
C36 (\4\:B0 VSS) capacitor c=4.16e-17
C37 (\4\:C0 VSS) capacitor c=6.00507e-17
C38 (\3\:Y VSS) capacitor c=8.80787e-17
C39 (\4\:VDD VSS) capacitor c=4.38429e-17
C40 (\5\:VDD VSS) capacitor c=1.25046e-17
Rk7 (C0 \4\:C0) resistor r=0.1175 c=0
Rk2 (\4\:A1 A1) resistor r=0.04077 c=0
Rk5 (B0 \4\:B0) resistor r=0.0569 c=0
Rk1 (\4\:A0 A0) resistor r=0.0408 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.3501 c=0
Rk14 (\5\:VDD VDD) resistor r=0.02963 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.2705 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.2263 c=0
Rk17 (\3\:VSS VSS) resistor r=0.1648 c=0
Rk18 (VSS \5\:VSS) resistor r=0.07952 c=0
Rk19 (\3\:VSS \7\:VSS) resistor r=0.06833 c=0
Rk9 (\3\:Y Y) resistor r=0.03094 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.3302 c=0
Rk10 (Y \5\:Y) resistor r=0.01294 c=0
Rk11 (\3\:Y \7\:Y) resistor r=0.5051 c=0
Rk3 (\4\:B1 B1) resistor r=0.002995 c=0
Rk4 (\2\:net128 \4\:net128) resistor r=0.4182 c=0
Rk6 (\2\:net132 \4\:net132) resistor r=0.3041 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=82.6695 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=55.5643 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=110.307 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=119.964 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=26.9231 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=78.8233 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=59.4104 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=79.5379 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=60.3072 c=0
Rz7 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz8 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (net128 \2\:net128) resistor r=75 c=0
Rz2 (\3\:net128 \4\:net128) resistor r=75 c=0
Rz3 (net132 \2\:net132) resistor r=75 c=0
Rz4 (\3\:net132 \4\:net132) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (\3\:net128 \3\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.63e-14 ad=4.16e-14 ps=1.54e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:net128 \3\:A1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.56e-14 ad=4.16e-14 ps=1.52e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn3 (\3\:net132 \3\:B1 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (net132 \1\:B0 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4 (\1\:Y \1\:C0 net132 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
ends OAI221X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:53 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI221X2
// View name: extracted

simulator lang=spectre

subckt OAI221X2 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.0138 scb=0.0145482 \
        scc=0.00065833 m=(1)
mp1_1__rcx (\6\:Y \6\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.9982 scb=0.0131496 \
        scc=0.000649094 m=(1)
mp1 (\6\:Y \1\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.875e-06 sd=160n sca=13.9871 scb=0.012316 \
        scc=0.000647546 m=(1)
mp0 (4 \6\:A0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.833e-13 ad=4.095e-14 ps=1.72e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.725e-06 sd=160n sca=13.6057 \
        scb=0.0121904 scc=0.000647513 m=(1)
mp2_1__rcx (5 \1\:B0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.833e-13 ad=4.095e-14 ps=1.72e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.21e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3_1__rcx (\4\:Y \7\:B1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.06e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (\4\:Y \1\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=7.995e-14 \
        ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.47e-06 sb=8.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2 (6 \6\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.995e-14 ps=1.1e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=6.05e-07 sd=160n sca=14.1837 \
        scb=0.0124217 scc=0.000647608 m=(1)
mp4 (\8\:Y \1\:C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.922e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=4e-07 sd=160n sca=15.4628 \
        scb=0.0137376 scc=0.00065186 m=(2)
C1 (B0 VSS) capacitor c=1.13057e-16
C2 (A1 VSS) capacitor c=5.30702e-17
C3 (Y VSS) capacitor c=7.75705e-17
C4 (B1 VSS) capacitor c=5.44061e-17
C5 (C0 VSS) capacitor c=3.68562e-17
C6 (A0 VSS) capacitor c=1.66507e-17
C7 (VDD VSS) capacitor c=1.3351e-16
C8 (net128 VSS) capacitor c=1.75624e-16
C9 (net132 VSS) capacitor c=1.72286e-16
C10 (1 VSS) capacitor c=1.56659e-18
C11 (4 VSS) capacitor c=4.27073e-18
C12 (5 VSS) capacitor c=4.42571e-18
C13 (6 VSS) capacitor c=9.7023e-18
C14 (\6\:B0 VSS) capacitor c=4.1937e-17
C15 (\1\:B1 VSS) capacitor c=3.38119e-17
C16 (\7\:B1 VSS) capacitor c=4.7816e-17
C17 (\1\:B0 VSS) capacitor c=4.24838e-17
C18 (\6\:A0 VSS) capacitor c=4.24604e-17
C19 (\1\:A1 VSS) capacitor c=4.8119e-17
C20 (\6\:A1 VSS) capacitor c=6.9974e-17
C21 (\1\:A0 VSS) capacitor c=9.22327e-17
C22 (\1\:C0 VSS) capacitor c=1.59882e-16
C23 (\2\:B0 VSS) capacitor c=2.79599e-16
C24 (\2\:A0 VSS) capacitor c=3.00929e-16
C25 (\1\:VDD VSS) capacitor c=1.24216e-16
C26 (\8\:Y VSS) capacitor c=3.52565e-17
C27 (\4\:Y VSS) capacitor c=1.31891e-16
C28 (\10\:VDD VSS) capacitor c=4.82831e-17
C29 (\6\:Y VSS) capacitor c=1.06721e-16
C30 (\13\:VDD VSS) capacitor c=1.64305e-17
C31 (\3\:VDD VSS) capacitor c=3.3922e-17
C32 (\1\:Y VSS) capacitor c=4.00049e-17
C33 (\5\:net132 VSS) capacitor c=8.23356e-17
C34 (\3\:net128 VSS) capacitor c=1.29207e-16
C35 (\2\:A1 VSS) capacitor c=1.00808e-16
C36 (\2\:B1 VSS) capacitor c=9.82301e-17
C37 (\7\:A1 VSS) capacitor c=6.83982e-17
C38 (\8\:B1 VSS) capacitor c=6.70597e-17
C39 (\9\:C0 VSS) capacitor c=8.75052e-17
C40 (\3\:Y VSS) capacitor c=9.0845e-17
C41 (\9\:VDD VSS) capacitor c=1.3299e-17
C42 (\12\:VDD VSS) capacitor c=1.58777e-17
Rk8 (B0 \2\:B0) resistor r=0.01196 c=0
Rk1 (\7\:A1 A1) resistor r=0.05745 c=0
Rk13 (\2\:Y Y) resistor r=0.221 c=0
Rk14 (Y \3\:Y) resistor r=0.306 c=0
Rk15 (\3\:Y \5\:Y) resistor r=0.4876 c=0
Rk16 (\5\:Y \7\:Y) resistor r=0.7161 c=0
Rk17 (\3\:Y \9\:Y) resistor r=0.04731 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.7007 c=0
Rk34 (\4\:VSS VSS) resistor r=0.01957 c=0
Rk31 (\3\:VSS \4\:VSS) resistor r=0.04985 c=0
Rk36 (\4\:VSS \10\:VSS) resistor r=0.2418 c=0
Rk4 (\8\:B1 B1) resistor r=0.05745 c=0
Rk12 (C0 \9\:C0) resistor r=0.03288 c=0
Rk3 (\2\:A0 A0) resistor r=0.01831 c=0
Rk24 (\1\:VDD \8\:VDD) resistor r=0.4678 c=0
Rk25 (\8\:VDD \9\:VDD) resistor r=0.09239 c=0
Rk26 (\9\:VDD \11\:VDD) resistor r=0.2175 c=0
Rk29 (\12\:VDD VDD) resistor r=0.1397 c=0
Rk27 (\9\:VDD \12\:VDD) resistor r=0.3174 c=0
Rk28 (\12\:VDD \14\:VDD) resistor r=0.222 c=0
Rk5 (net128 \3\:net128) resistor r=0.4025 c=0
Rl19 (\2\:B0 \6\:B0) resistor r=41.4835 c=0
Rl10 (\2\:B0 \1\:B0) resistor r=30.7692 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=99.7141 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=91.7582 c=0
Rl12 (\2\:B1 \1\:B1) resistor r=99.7141 c=0
Rl17 (\2\:B1 \7\:B1) resistor r=99.7141 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=29.9451 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=62.5949 c=0
Rz5 (\2\:Y \1\:Y) resistor r=75 c=0
Rz13 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz10 (\1\:VDD \3\:VDD) resistor r=37.5 c=0
Rz11 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz8 (net132 \5\:net132) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\9\:Y \8\:Y) resistor r=31 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\14\:VDD \13\:VDD) resistor r=62 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\8\:B1 \2\:B1) resistor r=45 c=0
Rx7 (\9\:C0 \1\:C0) resistor r=45 c=0
mn3 (\5\:net132 \2\:B1 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.16e-14 ps=9.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.105e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn1_1__rcx (\3\:net128 \2\:A1 \9\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.16e-14 ad=5.98e-14 ps=8.4e-07 pd=9.8e-07 \
        nrd=1.16667 nrs=1.16667 sa=4.85e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn4 (\1\:Y \1\:C0 net132 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn0_1__rcx (\3\:net128 \2\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=3.64e-14 ad=5.98e-14 ps=8e-07 pd=9.8e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.95e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn2 (net132 \2\:B0 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=9.4e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.31e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
ends OAI221X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:54 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI221X4
// View name: extracted

simulator lang=spectre

subckt OAI221X4 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.71923e-07 sd=160n sca=15.6591 \
        scb=0.0148836 scc=0.000346323 m=(1)
mp1_1__rcx (\15\:Y \5\:A1 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.99231e-07 sd=160n sca=13.9858 \
        scb=0.012083 scc=0.000300035 m=(1)
mp1_2__rcx (\15\:Y \1\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.57308e-07 sd=160n sca=12.4846 \
        scb=0.0103323 scc=0.000291984 m=(1)
mp0_2__rcx (3 \6\:A0 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.044e-13 ad=2.34e-14 ps=2.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=6.84615e-07 sd=160n sca=12.0928 \
        scb=0.0101069 scc=0.000291823 m=(1)
mp0_3__rcx (4 \4\:A0 \18\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.044e-13 ad=2.34e-14 ps=2.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp1_3__rcx (\13\:Y \12\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.88077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp1 (\13\:Y \7\:A1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.93077e-07 sb=2e-06 sd=160n sca=11.7201 scb=0.00999512 \
        scc=0.000291798 m=(1)
mp0 (5 \10\:A0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.6185e-13 ad=2.34e-14 ps=1.61e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_1__rcx (9 \1\:B0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.6185e-13 ad=6.24e-14 ps=1.61e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25808e-06 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_1__rcx (\11\:Y \6\:B1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43231e-06 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_2__rcx (\11\:Y \1\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.57423e-06 sb=1.91e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_2__rcx (6 \7\:B0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64692e-06 sb=1.805e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_3__rcx (7 \9\:B0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78885e-06 sb=1.6e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_3__rcx (\9\:Y \12\:B1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86154e-06 sb=1.495e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3 (\9\:Y \13\:B1 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.29e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2 (10 \12\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.385e-14 ps=1.1e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.03e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp4_1__rcx (\5\:Y C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.728e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=11.7295 \
        scb=0.00999684 scc=0.000291798 m=(4)
C1 (C0 VSS) capacitor c=3.36373e-16
C2 (A0 VSS) capacitor c=1.97825e-17
C3 (B0 VSS) capacitor c=6.15857e-16
C4 (A1 VSS) capacitor c=4.05582e-16
C5 (VDD VSS) capacitor c=2.94321e-16
C6 (Y VSS) capacitor c=4.1395e-17
C7 (net128 VSS) capacitor c=3.37966e-16
C8 (net132 VSS) capacitor c=4.44941e-16
C9 (3 VSS) capacitor c=1.84995e-18
C10 (4 VSS) capacitor c=1.84995e-18
C11 (5 VSS) capacitor c=1.84995e-18
C12 (9 VSS) capacitor c=7.40403e-18
C13 (6 VSS) capacitor c=2.39145e-18
C14 (7 VSS) capacitor c=2.39145e-18
C15 (10 VSS) capacitor c=9.90489e-18
C16 (\12\:B0 VSS) capacitor c=4.0664e-17
C17 (\13\:B1 VSS) capacitor c=3.23913e-17
C18 (\12\:B1 VSS) capacitor c=6.95997e-17
C19 (\9\:B0 VSS) capacitor c=5.76561e-17
C20 (\7\:B0 VSS) capacitor c=7.65343e-17
C21 (\1\:B1 VSS) capacitor c=6.75498e-17
C22 (\6\:B1 VSS) capacitor c=4.01614e-17
C23 (\1\:B0 VSS) capacitor c=3.4966e-17
C24 (\10\:A0 VSS) capacitor c=6.2371e-17
C25 (\7\:A1 VSS) capacitor c=7.33816e-17
C26 (\12\:A1 VSS) capacitor c=6.75628e-17
C27 (\4\:A0 VSS) capacitor c=8.53293e-17
C28 (\6\:A0 VSS) capacitor c=8.37609e-17
C29 (\1\:A1 VSS) capacitor c=6.39443e-17
C30 (\5\:A1 VSS) capacitor c=7.16094e-17
C31 (\1\:A0 VSS) capacitor c=6.97693e-17
C32 (\3\:B1 VSS) capacitor c=3.57945e-16
C33 (\2\:A0 VSS) capacitor c=5.53418e-16
C34 (\1\:VDD VSS) capacitor c=1.62283e-16
C35 (\5\:Y VSS) capacitor c=2.11528e-16
C36 (\9\:Y VSS) capacitor c=1.2021e-16
C37 (\11\:VDD VSS) capacitor c=3.37095e-17
C38 (\11\:Y VSS) capacitor c=1.39743e-16
C39 (\14\:VDD VSS) capacitor c=4.32116e-17
C40 (\13\:Y VSS) capacitor c=1.38579e-16
C41 (\18\:VDD VSS) capacitor c=3.27399e-17
C42 (\15\:Y VSS) capacitor c=8.90205e-17
C43 (\21\:VDD VSS) capacitor c=1.11674e-17
C44 (\4\:VDD VSS) capacitor c=4.59218e-17
C45 (\1\:Y VSS) capacitor c=1.18185e-16
C46 (\7\:net128 VSS) capacitor c=2.72714e-16
C47 (\8\:A1 VSS) capacitor c=4.31468e-17
C48 (\2\:B1 VSS) capacitor c=3.3092e-17
C49 (\10\:VDD VSS) capacitor c=4.10504e-17
C50 (\13\:VDD VSS) capacitor c=3.03952e-17
C51 (\17\:VDD VSS) capacitor c=1.80824e-17
C52 (\20\:VDD VSS) capacitor c=1.71616e-17
Rk5 (\2\:A0 A0) resistor r=0.01833 c=0
Rk39 (\1\:VDD \10\:VDD) resistor r=0.3832 c=0
Rk40 (\10\:VDD \12\:VDD) resistor r=0.1816 c=0
Rk41 (\10\:VDD \13\:VDD) resistor r=0.4882 c=0
Rk42 (\13\:VDD \15\:VDD) resistor r=0.1816 c=0
Rk43 (\13\:VDD \16\:VDD) resistor r=0.2804 c=0
Rk44 (\16\:VDD \17\:VDD) resistor r=0.1602 c=0
Rk45 (\17\:VDD \19\:VDD) resistor r=0.1816 c=0
Rk48 (\20\:VDD VDD) resistor r=0.09477 c=0
Rk46 (\17\:VDD \20\:VDD) resistor r=0.2953 c=0
Rk47 (\20\:VDD \22\:VDD) resistor r=0.1861 c=0
Rk55 (\3\:VSS VSS) resistor r=0.0196 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.8568 c=0
Rk23 (Y \5\:Y) resistor r=0.3502 c=0
Rk22 (\1\:Y Y) resistor r=0.1668 c=0
Rk25 (\5\:Y \10\:Y) resistor r=0.5056 c=0
Rk26 (\10\:Y \12\:Y) resistor r=0.4546 c=0
Rk27 (\12\:Y \14\:Y) resistor r=0.6899 c=0
Rk28 (\14\:Y \16\:Y) resistor r=0.6463 c=0
Rk7 (\3\:B1 B1) resistor r=0.005369 c=0
Rk10 (net128 \7\:net128) resistor r=0.4036 c=0
Rl19 (\2\:A0 \10\:A0) resistor r=24.2328 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=100.276 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=101.477 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=69.387 c=0
Rl40 (B0 \12\:B0) resistor r=29.9065 c=0
Rl33 (B0 \9\:B0) resistor r=21.9171 c=0
Rl31 (B0 \7\:B0) resistor r=77.1158 c=0
Rl21 (B0 \1\:B0) resistor r=40.3846 c=0
Rl3 (A1 \1\:A1) resistor r=62.2713 c=0
Rl6 (A1 \5\:A1) resistor r=109.593 c=0
Rl14 (\8\:A1 A1) resistor r=3.3726 c=0
Rl13 (\8\:A1 \7\:A1) resistor r=119.437 c=0
Rl17 (\8\:A1 \12\:A1) resistor r=83.3806 c=0
Rl38 (\3\:B1 \13\:B1) resistor r=88.6564 c=0
Rl37 (\3\:B1 \12\:B1) resistor r=100.195 c=0
Rl23 (\2\:B1 \1\:B1) resistor r=82.2563 c=0
Rl27 (\2\:B1 \6\:B1) resistor r=126.408 c=0
Rl24 (\2\:B1 \3\:B1) resistor r=3.9095 c=0
Rz18 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz19 (\16\:VDD \4\:VDD) resistor r=6.25 c=0
Ry10 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry12 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry13 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry4 (\12\:Y \11\:Y) resistor r=62 c=0
Ry5 (\14\:Y \13\:Y) resistor r=62 c=0
Ry6 (\16\:Y \15\:Y) resistor r=62 c=0
mn2_1__rcx (net132 B0 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn3_1__rcx (net132 \3\:B1 net128 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn0_1__rcx (\7\:net128 \2\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=3.9e-14 ad=4.225e-14 ps=8.2e-07 pd=8.45e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.585e-06 sd=160n \
        sca=16.9678 scb=0.0167861 scc=0.00150639 m=(4)
mn1_1__rcx (\7\:net128 A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.37e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn4_1__rcx (\1\:Y C0 net132 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=7.55e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
ends OAI221X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:55 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI221XL
// View name: extracted

simulator lang=spectre

subckt OAI221XL A0 A1 B0 B1 C0 VDD VSS Y
mp0 (net115 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.258e-14 ps=7.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=15.6738 \
        scb=0.0150674 scc=0.000231884 m=(1)
mp1 (\4\:Y \1\:A1 net115 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=1.1287e-13 ps=6.4e-07 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=1.14e-06 sd=160n sca=12.6662 \
        scb=0.00987777 scc=9.80167e-05 m=(1)
mp3 (\4\:Y \1\:B1 net123 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.1287e-13 ps=7.5e-07 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.7e-07 sd=160n sca=10.8786 \
        scb=0.00783555 scc=8.82249e-05 m=(1)
mp2 (net123 \3\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=3.65e-07 sd=160n sca=12.1296 \
        scb=0.0090984 scc=9.21052e-05 m=(1)
mp4 (\6\:Y \3\:C0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.01e-14 ps=7.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.4e-07 sd=160n sca=16.5578 \
        scb=0.0165885 scc=0.000310105 m=(1)
C1 (C0 VSS) capacitor c=1.02243e-16
C2 (A1 VSS) capacitor c=4.61577e-17
C3 (VDD VSS) capacitor c=1.47627e-16
C4 (B0 VSS) capacitor c=6.00346e-17
C5 (A0 VSS) capacitor c=4.83686e-17
C6 (B1 VSS) capacitor c=5.41926e-17
C7 (net128 VSS) capacitor c=6.1041e-17
C8 (net132 VSS) capacitor c=8.71019e-17
C9 (net115 VSS) capacitor c=5.51879e-18
C10 (net123 VSS) capacitor c=2.97781e-19
C11 (\3\:C0 VSS) capacitor c=5.68748e-17
C12 (\3\:B0 VSS) capacitor c=4.10397e-17
C13 (\1\:B1 VSS) capacitor c=4.00007e-17
C14 (\1\:A1 VSS) capacitor c=4.37671e-17
C15 (\1\:A0 VSS) capacitor c=5.27314e-17
C16 (\1\:C0 VSS) capacitor c=2.78201e-17
C17 (\1\:B0 VSS) capacitor c=5.21382e-17
C18 (\3\:B1 VSS) capacitor c=4.62694e-17
C19 (\3\:A1 VSS) capacitor c=3.87191e-17
C20 (\3\:A0 VSS) capacitor c=2.55432e-17
C21 (\2\:C0 VSS) capacitor c=5.5173e-17
C22 (\2\:B0 VSS) capacitor c=6.13682e-17
C23 (\2\:B1 VSS) capacitor c=4.77425e-17
C24 (\2\:A1 VSS) capacitor c=4.27872e-17
C25 (\2\:A0 VSS) capacitor c=4.63201e-17
C26 (\6\:Y VSS) capacitor c=2.33304e-17
C27 (\1\:VDD VSS) capacitor c=4.68981e-17
C28 (\4\:Y VSS) capacitor c=5.98228e-17
C29 (\6\:VDD VSS) capacitor c=1.84337e-17
C30 (\1\:Y VSS) capacitor c=6.95993e-17
C31 (\3\:net128 VSS) capacitor c=1.05328e-16
C32 (\3\:net132 VSS) capacitor c=9.76771e-17
C33 (\4\:A0 VSS) capacitor c=3.47984e-17
C34 (\4\:A1 VSS) capacitor c=5.27207e-17
C35 (\4\:B1 VSS) capacitor c=3.34095e-17
C36 (\4\:B0 VSS) capacitor c=5.08729e-17
C37 (\4\:C0 VSS) capacitor c=3.32613e-17
C38 (\3\:Y VSS) capacitor c=1.1605e-16
C39 (\4\:VDD VSS) capacitor c=2.42199e-17
C40 (\5\:VDD VSS) capacitor c=1.38034e-17
Rk9 (\4\:C0 C0) resistor r=0.04912 c=0
Rk2 (A1 \4\:A1) resistor r=0.2201 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.462 c=0
Rk16 (\5\:VDD VDD) resistor r=0.06706 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.3323 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2283 c=0
Rk5 (B0 \4\:B0) resistor r=0.1733 c=0
Rk1 (A0 \4\:A0) resistor r=0.1822 c=0
Rk12 (\3\:Y Y) resistor r=0.03931 c=0
Rk10 (\2\:Y \3\:Y) resistor r=0.5404 c=0
Rk11 (\3\:Y \5\:Y) resistor r=0.4972 c=0
Rk13 (Y \7\:Y) resistor r=0.001679 c=0
Rk20 (\4\:VSS VSS) resistor r=0.05956 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.1996 c=0
Rk21 (\3\:VSS \6\:VSS) resistor r=0.073 c=0
Rk22 (\4\:VSS \8\:VSS) resistor r=0.073 c=0
Rk3 (\4\:B1 B1) resistor r=0.07737 c=0
Rk4 (\2\:net128 \4\:net128) resistor r=0.6015 c=0
Rk6 (\2\:net132 \4\:net132) resistor r=0.4518 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=213.257 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=44.4893 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=108.384 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=77.6149 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=74.1758 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=184.615 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=157.692 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=29.9451 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=116.076 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=141.076 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (net128 \2\:net128) resistor r=75 c=0
Rz2 (\3\:net128 \4\:net128) resistor r=75 c=0
Rz3 (net132 \2\:net132) resistor r=75 c=0
Rz4 (\3\:net132 \4\:net132) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\6\:Y \7\:Y) resistor r=62 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (net128 \3\:A0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.315e-14 ad=2.32e-14 ps=1.44e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn1 (net128 \3\:A1 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.315e-14 ad=2.32e-14 ps=1.44e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn3 (\3\:net132 \3\:B1 \3\:net128 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.118e-14 ad=2.248e-14 ps=7.2e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=6.55e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (net132 \1\:B0 \3\:net128 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.045e-14 ps=7.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=3.95e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn4 (\1\:Y \1\:C0 net132 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.4e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
ends OAI221XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:56 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI222X1
// View name: extracted

simulator lang=spectre

subckt OAI222X1 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13e-06 sd=160n sca=19.3961 \
        scb=0.0212947 scc=0.000662871 m=(1)
mp1 (\4\:Y \1\:A1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.2675e-13 ps=9e-07 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.025e-06 sd=160n sca=15.6981 scb=0.0150296 \
        scc=0.000323375 m=(1)
mp3 (\4\:Y \1\:B1 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=1.2675e-13 ps=1.1e-06 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.15e-07 sb=6.55e-07 sd=160n sca=12.3518 scb=0.0100158 \
        scc=0.000258343 m=(1)
mp2 (n3 \1\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=4.5e-07 sd=160n sca=12.6156 \
        scb=0.0103368 scc=0.000258831 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.45e-07 sd=160n sca=14.6264 \
        scb=0.0131608 scc=0.000282649 m=(1)
mp5 (\6\:Y \3\:C1 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.13e-06 sb=1.4e-07 sd=160n sca=17.0903 scb=0.0174873 \
        scc=0.00041511 m=(1)
C1 (B0 VSS) capacitor c=5.21961e-17
C2 (A0 VSS) capacitor c=2.43549e-17
C3 (C1 VSS) capacitor c=2.02808e-17
C4 (VDD VSS) capacitor c=1.27921e-16
C5 (A1 VSS) capacitor c=4.78686e-17
C6 (Y VSS) capacitor c=2.35612e-17
C7 (n1 VSS) capacitor c=9.59904e-17
C8 (n0 VSS) capacitor c=6.28785e-17
C9 (n2 VSS) capacitor c=1.65716e-18
C10 (n3 VSS) capacitor c=6.31835e-18
C11 (n4 VSS) capacitor c=2.99166e-18
C12 (\3\:C1 VSS) capacitor c=7.49377e-17
C13 (\1\:C0 VSS) capacitor c=1.05572e-16
C14 (\1\:B0 VSS) capacitor c=5.63231e-17
C15 (\1\:B1 VSS) capacitor c=4.57237e-17
C16 (\1\:A1 VSS) capacitor c=7.39795e-17
C17 (\1\:A0 VSS) capacitor c=6.19781e-17
C18 (\1\:C1 VSS) capacitor c=4.36773e-17
C19 (\3\:C0 VSS) capacitor c=4.20834e-17
C20 (\3\:B0 VSS) capacitor c=5.5923e-17
C21 (\3\:B1 VSS) capacitor c=5.10351e-17
C22 (\3\:A1 VSS) capacitor c=4.4559e-17
C23 (\3\:A0 VSS) capacitor c=4.39191e-17
C24 (\2\:C1 VSS) capacitor c=6.13779e-17
C25 (\2\:C0 VSS) capacitor c=6.04915e-17
C26 (\2\:B0 VSS) capacitor c=5.98508e-17
C27 (\2\:B1 VSS) capacitor c=4.86431e-17
C28 (\2\:A1 VSS) capacitor c=4.16473e-17
C29 (\2\:A0 VSS) capacitor c=4.6931e-17
C30 (\6\:Y VSS) capacitor c=3.0091e-17
C31 (\1\:VDD VSS) capacitor c=5.42252e-17
C32 (\4\:Y VSS) capacitor c=1.17565e-16
C33 (\6\:VDD VSS) capacitor c=2.92612e-17
C34 (\1\:Y VSS) capacitor c=1.0401e-16
C35 (\3\:n0 VSS) capacitor c=8.04284e-17
C36 (\5\:n0 VSS) capacitor c=6.63917e-17
C37 (\3\:n1 VSS) capacitor c=5.20822e-17
C38 (\4\:A0 VSS) capacitor c=5.99106e-17
C39 (\4\:A1 VSS) capacitor c=1.06595e-16
C40 (\4\:B1 VSS) capacitor c=1.13366e-16
C41 (\4\:B0 VSS) capacitor c=3.97293e-17
C42 (\4\:C0 VSS) capacitor c=5.0917e-17
C43 (\5\:C0 VSS) capacitor c=3.90618e-17
C44 (\4\:C1 VSS) capacitor c=3.91342e-17
C45 (\3\:Y VSS) capacitor c=1.11322e-16
C46 (\4\:VDD VSS) capacitor c=6.05554e-17
C47 (\5\:VDD VSS) capacitor c=1.46089e-17
Rk5 (B0 \4\:B0) resistor r=0.1139 c=0
Rk1 (\4\:A0 A0) resistor r=0.03923 c=0
Rk9 (C1 \4\:C1) resistor r=0.01123 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3549 c=0
Rk18 (\5\:VDD VDD) resistor r=0.03721 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.3136 c=0
Rk19 (\5\:VDD \7\:VDD) resistor r=0.2435 c=0
Rk21 (\3\:VSS VSS) resistor r=0.1751 c=0
Rk22 (VSS \5\:VSS) resistor r=0.07638 c=0
Rk23 (\3\:VSS \7\:VSS) resistor r=0.05844 c=0
Rk3 (B1 \4\:B1) resistor r=0.00365 c=0
Rk6 (C0 \4\:C0) resistor r=0.003363 c=0
Rk8 (\4\:C0 \5\:C0) resistor r=0.09016 c=0
Rk7 (\5\:C0 \6\:C0) resistor r=0.003462 c=0
Rk2 (A1 \4\:A1) resistor r=0.1575 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5951 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.6465 c=0
Rk15 (\7\:Y Y) resistor r=0.06034 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.06822 c=0
Rk4 (\2\:n1 \4\:n1) resistor r=0.5007 c=0
Rk10 (\2\:n0 \4\:n0) resistor r=0.3063 c=0
Rk11 (\4\:n0 \6\:n0) resistor r=0.3082 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=72.2519 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=122.252 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=110.372 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=78.9444 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=126.923 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=75.6918 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=125.692 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=152.615 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=48.7687 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=79.9442 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=49.1749 c=0
Rz8 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (n1 \2\:n1) resistor r=75 c=0
Rz2 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz3 (n0 \2\:n0) resistor r=75 c=0
Rz4 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz5 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\2\:C0 \6\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n1 \3\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:n1 \3\:A1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.05e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\5\:n0 \3\:B1 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\3\:n0 \3\:B0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (\1\:Y \1\:C1 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.55e-07 sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
ends OAI222X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:57 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI222X2
// View name: extracted

simulator lang=spectre

subckt OAI222X2 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0_1__rcx (1 \1\:A0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.825e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.1227 scb=0.0199265 \
        scc=0.000804362 m=(1)
mp1_1__rcx (\7\:Y \6\:A1 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=15.2793 scb=0.0134932 \
        scc=0.000650526 m=(1)
mp1 (\7\:Y \1\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.65e-07 sb=2e-06 sd=160n sca=14.1076 scb=0.0123774 \
        scc=0.000647578 m=(1)
mp0 (4 \4\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.911e-13 ad=4.485e-14 ps=1.76e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.98e-06 sd=160n sca=13.6573 \
        scb=0.0122016 scc=0.000647515 m=(1)
mp2_1__rcx (5 \1\:B0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.911e-13 ad=4.485e-14 ps=1.76e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.445e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3_1__rcx (\5\:Y \5\:B1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.285e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (\5\:Y \7\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=1.08e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (6 \4\:B0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.0725e-13 ps=1.1e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.945e-06 sb=7.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp4_1__rcx (7 \1\:C0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp5_1__rcx (\3\:Y \4\:C1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=13.5861 scb=0.0121865 \
        scc=0.000647513 m=(1)
mp5 (\3\:Y \6\:C1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=14.1449 scb=0.0123986 scc=0.000647592 \
        m=(1)
mp4 (8 \7\:C0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.6385 scb=0.0127742 \
        scc=0.000648083 m=(1)
C1 (Y VSS) capacitor c=9.26337e-17
C2 (C0 VSS) capacitor c=4.20746e-16
C3 (B1 VSS) capacitor c=3.87866e-17
C4 (A0 VSS) capacitor c=8.14613e-17
C5 (C1 VSS) capacitor c=1.05737e-16
C6 (VDD VSS) capacitor c=1.67033e-16
C7 (n1 VSS) capacitor c=1.77587e-16
C8 (n0 VSS) capacitor c=1.74736e-16
C9 (1 VSS) capacitor c=4.56923e-18
C10 (4 VSS) capacitor c=4.50828e-18
C11 (5 VSS) capacitor c=4.44019e-18
C12 (6 VSS) capacitor c=1.33345e-17
C13 (7 VSS) capacitor c=2.44041e-18
C14 (8 VSS) capacitor c=2.44041e-18
C15 (\7\:C0 VSS) capacitor c=7.74245e-17
C16 (\6\:C1 VSS) capacitor c=6.61226e-17
C17 (\4\:C1 VSS) capacitor c=6.18829e-17
C18 (\1\:C0 VSS) capacitor c=7.35528e-17
C19 (\4\:B0 VSS) capacitor c=3.90272e-17
C20 (\7\:B1 VSS) capacitor c=3.03338e-17
C21 (\5\:B1 VSS) capacitor c=5.63882e-17
C22 (\1\:B0 VSS) capacitor c=4.20518e-17
C23 (\4\:A0 VSS) capacitor c=4.18267e-17
C24 (\1\:A1 VSS) capacitor c=5.58617e-17
C25 (\6\:A1 VSS) capacitor c=3.72904e-17
C26 (\1\:A0 VSS) capacitor c=3.02404e-17
C27 (\1\:C1 VSS) capacitor c=8.70309e-17
C28 (\1\:B1 VSS) capacitor c=7.6659e-17
C29 (\3\:C1 VSS) capacitor c=5.58326e-17
C30 (\2\:B0 VSS) capacitor c=3.67008e-16
C31 (\2\:A0 VSS) capacitor c=2.40882e-16
C32 (\8\:VDD VSS) capacitor c=3.24883e-17
C33 (\3\:Y VSS) capacitor c=1.77147e-16
C34 (\10\:VDD VSS) capacitor c=3.55049e-17
C35 (\5\:Y VSS) capacitor c=1.4056e-16
C36 (\12\:VDD VSS) capacitor c=4.83838e-17
C37 (\7\:Y VSS) capacitor c=1.01151e-16
C38 (\14\:VDD VSS) capacitor c=1.4379e-17
C39 (\1\:VDD VSS) capacitor c=3.92303e-17
C40 (\1\:Y VSS) capacitor c=1.45278e-16
C41 (\3\:n0 VSS) capacitor c=7.86165e-17
C42 (\7\:n0 VSS) capacitor c=8.91333e-17
C43 (\5\:n1 VSS) capacitor c=1.29071e-16
C44 (\2\:A1 VSS) capacitor c=1.23229e-16
C45 (\4\:B1 VSS) capacitor c=3.21063e-17
C46 (\7\:A1 VSS) capacitor c=3.21624e-17
C47 (\9\:A1 VSS) capacitor c=4.9416e-17
C48 (\8\:B1 VSS) capacitor c=5.93845e-17
C49 (\3\:VDD VSS) capacitor c=1.28089e-17
C50 (\4\:VDD VSS) capacitor c=2.85084e-17
C51 (\6\:VDD VSS) capacitor c=1.63573e-17
C52 (\7\:VDD VSS) capacitor c=1.45743e-17
Rk11 (\2\:B0 B0) resistor r=0.005612 c=0
Rk1 (\7\:A1 \8\:A1) resistor r=0.0129 c=0
Rk2 (A1 \9\:A1) resistor r=0.01276 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.04398 c=0
Rk34 (\2\:VSS \3\:VSS) resistor r=0.8508 c=0
Rk38 (\4\:VSS VSS) resistor r=0.03709 c=0
Rk35 (\3\:VSS \4\:VSS) resistor r=0.08989 c=0
Rk40 (\4\:VSS \10\:VSS) resistor r=0.2021 c=0
Rk19 (\1\:Y Y) resistor r=0.3767 c=0
Rk20 (Y \4\:Y) resistor r=0.8614 c=0
Rk21 (\4\:Y \6\:Y) resistor r=0.6011 c=0
Rk22 (\6\:Y \8\:Y) resistor r=0.7364 c=0
Rk6 (B1 \8\:B1) resistor r=0.1155 c=0
Rk4 (A0 \2\:A0) resistor r=0.01196 c=0
Rk12 (\7\:C1 C1) resistor r=0.00375 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.03484 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.3099 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.5053 c=0
Rk27 (\5\:VDD \6\:VDD) resistor r=0.1049 c=0
Rk29 (\7\:VDD VDD) resistor r=0.06462 c=0
Rk28 (\6\:VDD \7\:VDD) resistor r=0.38 c=0
Rk30 (\3\:VDD \9\:VDD) resistor r=0.2175 c=0
Rk31 (\4\:VDD \11\:VDD) resistor r=0.2175 c=0
Rk32 (\6\:VDD \13\:VDD) resistor r=0.2175 c=0
Rk33 (\7\:VDD \15\:VDD) resistor r=0.222 c=0
Rk8 (n1 \5\:n1) resistor r=0.505 c=0
Rl18 (\2\:B0 \4\:B0) resistor r=29.5379 c=0
Rl10 (\2\:B0 \1\:B0) resistor r=44.9225 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=146.132 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=105.002 c=0
Rl29 (C0 \7\:C0) resistor r=100.539 c=0
Rl20 (C0 \1\:C0) resistor r=37.3411 c=0
Rl13 (\1\:B1 \3\:B1) resistor r=0.075 c=0
Rl17 (\4\:B1 \7\:B1) resistor r=107.256 c=0
Rl15 (\4\:B1 \5\:B1) resistor r=151.408 c=0
Rl14 (\4\:B1 \3\:B1) resistor r=3.9095 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=41.0764 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.7692 c=0
Rl27 (\3\:C1 \6\:C1) resistor r=82.6695 c=0
Rl25 (\3\:C1 \4\:C1) resistor r=59.5926 c=0
Rl24 (\1\:C1 \3\:C1) resistor r=58.644 c=0
Rz15 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz13 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz6 (n0 \3\:n0) resistor r=75 c=0
Rz8 (n0 \7\:n0) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry2 (\6\:Y \5\:Y) resistor r=62 c=0
Ry3 (\8\:Y \7\:Y) resistor r=62 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry5 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry6 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry7 (\14\:VDD \15\:VDD) resistor r=62 c=0
Rx1 (\8\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\8\:B1 \3\:B1) resistor r=45 c=0
Rx7 (\7\:C1 \3\:C1) resistor r=45 c=0
mn0_1__rcx (\5\:n1 \2\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.485e-14 ps=8e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (\5\:n1 \2\:A1 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.485e-14 ps=8.4e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn3 (\7\:n0 \1\:B1 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.44e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn4_1__rcx (\1\:Y C0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=7.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn5_1__rcx (\1\:Y \1\:C1 \3\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2_1__rcx (n0 \2\:B0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=3.9e-14 ps=9.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.645e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
ends OAI222X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:18:59 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI222X4
// View name: extracted

simulator lang=spectre

subckt OAI222X4 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.1864 scb=0.011023 \
        scc=0.000312795 m=(1)
mp1_1__rcx (\17\:Y \4\:A1 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.592 scb=0.010475 \
        scc=0.000311666 m=(1)
mp1_2__rcx (\17\:Y \1\:A1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=6.24e-14 ps=1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=11.9394 scb=0.0101617 \
        scc=0.000311483 m=(1)
mp0_2__rcx (9 \9\:A0 \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.29e-14 ps=1.1e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp0_3__rcx (3 \4\:A0 \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp1_3__rcx (\15\:Y \13\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp1 (\15\:Y \8\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.12e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp0 (4 \11\:A0 \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=2.34e-14 ps=1.5e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=2e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp2_1__rcx (8 \1\:B0 \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=6.24e-14 ps=1.5e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3_1__rcx (\13\:Y \6\:B1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp3_2__rcx (\13\:Y \1\:B1 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp2_2__rcx (10 \9\:B0 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.36e-14 ps=1.1e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp2_3__rcx (11 \4\:B0 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.485e-14 ps=1.1e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3_3__rcx (\11\:Y \12\:B1 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.86e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3 (\11\:Y \7\:B1 12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.315e-14 ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.655e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp2 (12 \12\:B0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.165e-14 ad=3.315e-14 ps=1.25e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.525e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp4_1__rcx (13 \1\:C0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.165e-14 ad=4.875e-14 ps=1.25e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.245e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5_1__rcx (\9\:Y \4\:C1 13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.075e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5_2__rcx (\9\:Y \5\:C1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.7e-07 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp4_2__rcx (5 \7\:C0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.65e-07 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp4_3__rcx (14 \9\:C0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.535e-14 ps=1.1e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.6e-07 sd=160n sca=11.8465 scb=0.0101414 \
        scc=0.000311481 m=(1)
mp5_3__rcx (\7\:Y \10\:C1 14 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.535e-14 ad=6.24e-14 ps=9.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=12.099 scb=0.0102099 \
        scc=0.000311493 m=(1)
mp5 (\7\:Y \11\:C1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=12.9282 scb=0.0107566 scc=0.000312107 \
        m=(1)
mp4 (6 \12\:C0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.7232 scb=0.0116925 \
        scc=0.000315829 m=(1)
C1 (B0 VSS) capacitor c=6.44304e-16
C2 (A1 VSS) capacitor c=2.44526e-17
C3 (C0 VSS) capacitor c=6.20326e-16
C4 (Y VSS) capacitor c=6.41326e-17
C5 (VDD VSS) capacitor c=3.45062e-16
C6 (B1 VSS) capacitor c=2.71976e-17
C7 (A0 VSS) capacitor c=6.13597e-16
C8 (C1 VSS) capacitor c=4.44969e-16
C9 (n1 VSS) capacitor c=3.5227e-16
C10 (n0 VSS) capacitor c=5.87896e-16
C11 (9 VSS) capacitor c=3.21829e-18
C12 (3 VSS) capacitor c=1.75543e-18
C13 (4 VSS) capacitor c=1.75543e-18
C14 (8 VSS) capacitor c=4.6408e-18
C15 (10 VSS) capacitor c=7.46821e-18
C16 (11 VSS) capacitor c=3.36458e-18
C17 (12 VSS) capacitor c=2.48686e-18
C18 (13 VSS) capacitor c=3.31694e-18
C19 (5 VSS) capacitor c=1.75543e-18
C20 (14 VSS) capacitor c=1.90172e-18
C21 (6 VSS) capacitor c=1.75543e-18
C22 (\12\:C0 VSS) capacitor c=6.32253e-17
C23 (\11\:C1 VSS) capacitor c=6.62765e-17
C24 (\10\:C1 VSS) capacitor c=6.93177e-17
C25 (\9\:C0 VSS) capacitor c=5.48324e-17
C26 (\7\:C0 VSS) capacitor c=7.6507e-17
C27 (\5\:C1 VSS) capacitor c=6.84183e-17
C28 (\4\:C1 VSS) capacitor c=4.12338e-17
C29 (\1\:C0 VSS) capacitor c=5.13034e-17
C30 (\12\:B0 VSS) capacitor c=6.11341e-17
C31 (\7\:B1 VSS) capacitor c=5.42273e-17
C32 (\12\:B1 VSS) capacitor c=4.41057e-17
C33 (\4\:B0 VSS) capacitor c=4.04035e-17
C34 (\9\:B0 VSS) capacitor c=2.43736e-17
C35 (\1\:B1 VSS) capacitor c=3.04721e-17
C36 (\6\:B1 VSS) capacitor c=3.75168e-17
C37 (\1\:B0 VSS) capacitor c=3.58647e-17
C38 (\11\:A0 VSS) capacitor c=7.07011e-17
C39 (\8\:A1 VSS) capacitor c=7.14395e-17
C40 (\13\:A1 VSS) capacitor c=6.84327e-17
C41 (\4\:A0 VSS) capacitor c=6.28469e-17
C42 (\9\:A0 VSS) capacitor c=3.73384e-17
C43 (\1\:A1 VSS) capacitor c=4.97332e-17
C44 (\4\:A1 VSS) capacitor c=6.72197e-17
C45 (\1\:A0 VSS) capacitor c=8.40745e-17
C46 (\2\:B1 VSS) capacitor c=4.05908e-16
C47 (\3\:A1 VSS) capacitor c=3.76251e-16
C48 (\6\:VDD VSS) capacitor c=2.1932e-17
C49 (\7\:Y VSS) capacitor c=1.13923e-16
C50 (\8\:VDD VSS) capacitor c=2.4484e-17
C51 (\9\:Y VSS) capacitor c=1.1624e-16
C52 (\10\:VDD VSS) capacitor c=2.88056e-17
C53 (\11\:Y VSS) capacitor c=1.4911e-16
C54 (\13\:VDD VSS) capacitor c=2.69738e-17
C55 (\13\:Y VSS) capacitor c=1.39602e-16
C56 (\16\:VDD VSS) capacitor c=3.35013e-17
C57 (\15\:Y VSS) capacitor c=1.38729e-16
C58 (\20\:VDD VSS) capacitor c=2.49136e-17
C59 (\17\:Y VSS) capacitor c=7.32097e-17
C60 (\23\:VDD VSS) capacitor c=1.32896e-17
C61 (\1\:VDD VSS) capacitor c=5.15938e-17
C62 (\1\:Y VSS) capacitor c=3.08671e-16
C63 (\9\:n1 VSS) capacitor c=2.66144e-16
C64 (\2\:A1 VSS) capacitor c=5.51129e-17
C65 (\3\:VDD VSS) capacitor c=1.52686e-17
C66 (\4\:VDD VSS) capacitor c=2.80189e-17
C67 (\12\:VDD VSS) capacitor c=3.68087e-17
C68 (\15\:VDD VSS) capacitor c=3.09736e-17
C69 (\19\:VDD VSS) capacitor c=1.43222e-17
C70 (\22\:VDD VSS) capacitor c=1.95088e-17
Rk3 (\3\:A1 A1) resistor r=0.009916 c=0
Rk61 (\2\:VSS \3\:VSS) resistor r=0.7513 c=0
Rk68 (\4\:VSS VSS) resistor r=0.02209 c=0
Rk62 (\3\:VSS \4\:VSS) resistor r=0.9089 c=0
Rk29 (\1\:Y Y) resistor r=0.1729 c=0
Rk30 (Y \8\:Y) resistor r=0.5304 c=0
Rk31 (\8\:Y \10\:Y) resistor r=0.4577 c=0
Rk32 (\10\:Y \12\:Y) resistor r=0.5482 c=0
Rk33 (\12\:Y \14\:Y) resistor r=0.627 c=0
Rk34 (\14\:Y \16\:Y) resistor r=0.6475 c=0
Rk35 (\16\:Y \18\:Y) resistor r=0.4908 c=0
Rk45 (\2\:VDD \3\:VDD) resistor r=0.07995 c=0
Rk46 (\3\:VDD \4\:VDD) resistor r=0.3127 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.3579 c=0
Rk48 (\3\:VDD \7\:VDD) resistor r=0.1846 c=0
Rk49 (\4\:VDD \9\:VDD) resistor r=0.1846 c=0
Rk50 (\5\:VDD \11\:VDD) resistor r=0.2307 c=0
Rk51 (\5\:VDD \12\:VDD) resistor r=0.3736 c=0
Rk52 (\12\:VDD \14\:VDD) resistor r=0.1846 c=0
Rk53 (\12\:VDD \15\:VDD) resistor r=0.5506 c=0
Rk54 (\15\:VDD \17\:VDD) resistor r=0.1846 c=0
Rk55 (\15\:VDD \18\:VDD) resistor r=0.2778 c=0
Rk56 (\18\:VDD \19\:VDD) resistor r=0.03236 c=0
Rk57 (\19\:VDD \21\:VDD) resistor r=0.1846 c=0
Rk60 (\22\:VDD VDD) resistor r=0.1974 c=0
Rk58 (\19\:VDD \22\:VDD) resistor r=0.3202 c=0
Rk59 (\22\:VDD \24\:VDD) resistor r=0.1892 c=0
Rk9 (\2\:B1 B1) resistor r=0.01977 c=0
Rk13 (n1 \9\:n1) resistor r=0.4089 c=0
Rl40 (B0 \12\:B0) resistor r=70.3297 c=0
Rl29 (B0 \4\:B0) resistor r=67.2856 c=0
Rl33 (B0 \9\:B0) resistor r=22.4021 c=0
Rl22 (B0 \1\:B0) resistor r=29.5379 c=0
Rl15 (\3\:A1 \8\:A1) resistor r=119.539 c=0
Rl19 (\3\:A1 \13\:A1) resistor r=87.4359 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=124.484 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=80.3332 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=3.9095 c=0
Rl58 (C0 \12\:C0) resistor r=24.7951 c=0
Rl51 (C0 \9\:C0) resistor r=28.7343 c=0
Rl49 (C0 \7\:C0) resistor r=74.6548 c=0
Rl41 (C0 \1\:C0) resistor r=64.1533 c=0
Rl34 (\2\:B1 \7\:B1) resistor r=83.8489 c=0
Rl38 (\2\:B1 \12\:B1) resistor r=83.4251 c=0
Rl24 (\2\:B1 \1\:B1) resistor r=83.4251 c=0
Rl28 (\2\:B1 \6\:B1) resistor r=83.8489 c=0
Rl20 (A0 \11\:A0) resistor r=69.9225 c=0
Rl9 (A0 \4\:A0) resistor r=67.9002 c=0
Rl13 (A0 \9\:A0) resistor r=33.6242 c=0
Rl1 (A0 \1\:A0) resistor r=119.208 c=0
Rl56 (C1 \11\:C1) resistor r=75.2936 c=0
Rl55 (C1 \10\:C1) resistor r=120.873 c=0
Rl46 (C1 \5\:C1) resistor r=94.6378 c=0
Rl45 (C1 \4\:C1) resistor r=114.708 c=0
Rz22 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz23 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz24 (\1\:VDD \18\:VDD) resistor r=6.25 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:Y \7\:Y) resistor r=62 c=0
Ry2 (\10\:Y \9\:Y) resistor r=62 c=0
Ry3 (\12\:Y \11\:Y) resistor r=62 c=0
Ry4 (\14\:Y \13\:Y) resistor r=62 c=0
Ry5 (\16\:Y \15\:Y) resistor r=62 c=0
Ry6 (\18\:Y \17\:Y) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry11 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry12 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry13 (\23\:VDD \24\:VDD) resistor r=62 c=0
mn0_1__rcx (\9\:n1 A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn1_1__rcx (\9\:n1 \3\:A1 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn4_1__rcx (\1\:Y C0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn5_1__rcx (\1\:Y C1 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn2_1__rcx (n0 B0 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.388e-14 ad=4.03e-14 ps=8.575e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn3_1__rcx (n0 \2\:B1 n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.388e-14 ad=4.16e-14 ps=8.575e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
ends OAI222X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:00 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI222XL
// View name: extracted

simulator lang=spectre

subckt OAI222XL A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=18.9152 \
        scb=0.020298 scc=0.000602167 m=(1)
mp1 (\5\:Y \1\:A1 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.88e-14 ps=5.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.045e-06 sd=160n sca=14.7404 \
        scb=0.0134098 scc=0.000165408 m=(1)
mp3 (\5\:Y \1\:B1 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.88e-14 ps=7e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.8e-07 sd=160n sca=11.0531 \
        scb=0.00777426 scc=8.06272e-05 m=(1)
mp2 (n3 \3\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.903e-14 ps=8.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5e-07 sd=160n sca=11.1457 scb=0.00788341 \
        scc=8.07632e-05 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=1.29e-14 ps=8.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2.45e-07 sd=160n sca=13.3848 \
        scb=0.0110305 scc=0.000107196 m=(1)
mp5 (\3\:Y \3\:C1 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=15.9357 \
        scb=0.0155108 scc=0.000251633 m=(1)
C1 (B0 VSS) capacitor c=8.60203e-17
C2 (A0 VSS) capacitor c=1.67728e-17
C3 (C1 VSS) capacitor c=4.01412e-17
C4 (VDD VSS) capacitor c=1.70879e-16
C5 (C0 VSS) capacitor c=5.01366e-17
C6 (Y VSS) capacitor c=7.07251e-17
C7 (n1 VSS) capacitor c=9.7052e-17
C8 (n0 VSS) capacitor c=9.58396e-17
C9 (n3 VSS) capacitor c=3.04162e-18
C10 (n4 VSS) capacitor c=1.35183e-18
C11 (\3\:C1 VSS) capacitor c=7.01833e-17
C12 (\1\:C0 VSS) capacitor c=7.58691e-17
C13 (\3\:B0 VSS) capacitor c=5.252e-17
C14 (\1\:B1 VSS) capacitor c=3.78216e-17
C15 (\1\:A1 VSS) capacitor c=6.98184e-17
C16 (\1\:A0 VSS) capacitor c=5.03375e-17
C17 (\1\:C1 VSS) capacitor c=3.18284e-17
C18 (\3\:C0 VSS) capacitor c=3.72922e-17
C19 (\1\:B0 VSS) capacitor c=3.7119e-17
C20 (\3\:B1 VSS) capacitor c=4.52182e-17
C21 (\3\:A1 VSS) capacitor c=3.7131e-17
C22 (\3\:A0 VSS) capacitor c=4.87738e-17
C23 (\2\:C1 VSS) capacitor c=6.611e-17
C24 (\2\:C0 VSS) capacitor c=7.19886e-17
C25 (\2\:B0 VSS) capacitor c=5.9995e-17
C26 (\2\:B1 VSS) capacitor c=5.16822e-17
C27 (\2\:A1 VSS) capacitor c=4.49243e-17
C28 (\2\:A0 VSS) capacitor c=5.58901e-17
C29 (\3\:Y VSS) capacitor c=7.40153e-17
C30 (\1\:VDD VSS) capacitor c=3.81683e-17
C31 (\5\:Y VSS) capacitor c=1.03603e-16
C32 (\6\:VDD VSS) capacitor c=1.94932e-17
C33 (\5\:n0 VSS) capacitor c=7.00565e-17
C34 (\1\:Y VSS) capacitor c=1.05355e-16
C35 (\3\:n0 VSS) capacitor c=1.13961e-16
C36 (\3\:n1 VSS) capacitor c=5.99285e-17
C37 (\4\:A0 VSS) capacitor c=2.23006e-17
C38 (\5\:A1 VSS) capacitor c=1.3255e-17
C39 (\6\:A1 VSS) capacitor c=3.70873e-17
C40 (\4\:B1 VSS) capacitor c=8.22906e-17
C41 (\6\:B1 VSS) capacitor c=4.10427e-17
C42 (\4\:B0 VSS) capacitor c=4.44809e-17
C43 (\4\:C0 VSS) capacitor c=7.06709e-17
C44 (\4\:C1 VSS) capacitor c=7.43714e-17
C45 (\4\:VDD VSS) capacitor c=4.12883e-17
C46 (\5\:VDD VSS) capacitor c=1.19242e-17
Rk9 (\4\:B0 B0) resistor r=0.01901 c=0
Rk1 (A0 \4\:A0) resistor r=0.03137 c=0
Rk11 (C1 \4\:C1) resistor r=0.1316 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.2672 c=0
Rk19 (\5\:VDD VDD) resistor r=0.02964 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.3208 c=0
Rk20 (\5\:VDD \7\:VDD) resistor r=0.224 c=0
Rk23 (\4\:VSS VSS) resistor r=0.0151 c=0
Rk22 (\3\:VSS \4\:VSS) resistor r=0.1852 c=0
Rk24 (\3\:VSS \6\:VSS) resistor r=0.07381 c=0
Rk25 (\4\:VSS \8\:VSS) resistor r=0.07381 c=0
Rk5 (\4\:B1 \5\:B1) resistor r=0.002784 c=0
Rk6 (B1 \6\:B1) resistor r=0.002691 c=0
Rk7 (\4\:B1 \6\:B1) resistor r=0.02706 c=0
Rk10 (C0 \4\:C0) resistor r=0.1479 c=0
Rk2 (\4\:A1 \5\:A1) resistor r=0.004738 c=0
Rk3 (\6\:A1 A1) resistor r=0.004738 c=0
Rk4 (\5\:A1 \6\:A1) resistor r=0.03868 c=0
Rk12 (\2\:Y Y) resistor r=0.6481 c=0
Rk13 (Y \4\:Y) resistor r=0.04934 c=0
Rk14 (\4\:Y \6\:Y) resistor r=0.5229 c=0
Rk8 (\2\:n1 \4\:n1) resistor r=0.6051 c=0
Rk15 (\2\:n0 \4\:n0) resistor r=0.4682 c=0
Rk16 (\4\:n0 \6\:n0) resistor r=0.4818 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=129.538 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=74.9799 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=163.257 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=136.146 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=78.8462 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=59.6085 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=142.301 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=133.79 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=66.4826 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=127.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=79.5379 c=0
Rz8 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (n1 \2\:n1) resistor r=75 c=0
Rz2 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz6 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx3 (\2\:B1 \5\:B1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n1 \3\:A0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.37e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn1 (\3\:n1 \3\:A1 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.09e-14 ad=2.32e-14 ps=1.35e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn3 (n0 \3\:B1 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.85e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (\3\:n0 \1\:B0 n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.392e-14 ps=6.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.5e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn5 (\1\:Y \1\:C1 \5\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
ends OAI222XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:01 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI22X1
// View name: extracted

simulator lang=spectre

subckt OAI22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (net93 \1\:A0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.383 \
        scb=0.0290112 scc=0.00169816 m=(1)
mp1 (\3\:Y \3\:A1 net93 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=8.97e-14 ps=1.01e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=5.95e-07 sd=160n sca=16.6664 scb=0.0162415 \
        scc=0.000384527 m=(1)
mp3 (\3\:Y \1\:B1 net85 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.97e-14 ps=1.05e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.2e-07 sd=160n sca=14.4478 \
        scb=0.0118157 scc=0.000294931 m=(1)
mp2 (net85 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.265e-14 ps=1.06e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=16.2261 \
        scb=0.0153801 scc=0.000356933 m=(1)
C1 (B0 VSS) capacitor c=3.46524e-17
C2 (A0 VSS) capacitor c=4.1469e-17
C3 (VDD VSS) capacitor c=8.80125e-17
C4 (B1 VSS) capacitor c=3.98993e-17
C5 (A1 VSS) capacitor c=4.44451e-17
C6 (net102 VSS) capacitor c=8.50143e-17
C7 (net93 VSS) capacitor c=2.01834e-18
C8 (net85 VSS) capacitor c=8.01381e-18
C9 (\3\:B0 VSS) capacitor c=4.74096e-17
C10 (\1\:B1 VSS) capacitor c=4.22539e-17
C11 (\3\:A1 VSS) capacitor c=4.78736e-17
C12 (\1\:A0 VSS) capacitor c=5.63727e-17
C13 (\4\:B0 VSS) capacitor c=3.61301e-17
C14 (\3\:B1 VSS) capacitor c=5.12448e-17
C15 (\1\:A1 VSS) capacitor c=5.4827e-17
C16 (\4\:A0 VSS) capacitor c=4.21655e-17
C17 (\1\:B0 VSS) capacitor c=1.25535e-17
C18 (\2\:B1 VSS) capacitor c=4.89727e-17
C19 (\2\:A1 VSS) capacitor c=4.89624e-17
C20 (\3\:A0 VSS) capacitor c=1.35136e-17
C21 (\1\:VDD VSS) capacitor c=4.12481e-17
C22 (\3\:Y VSS) capacitor c=1.2214e-16
C23 (\5\:VDD VSS) capacitor c=3.42543e-17
C24 (\1\:Y VSS) capacitor c=1.16526e-16
C25 (\3\:net102 VSS) capacitor c=1.07985e-16
C26 (\5\:net102 VSS) capacitor c=6.55637e-17
C27 (\2\:A0 VSS) capacitor c=2.66365e-17
C28 (\2\:B0 VSS) capacitor c=3.1057e-17
C29 (\5\:A0 VSS) capacitor c=4.11457e-17
C30 (\4\:A1 VSS) capacitor c=5.78871e-17
C31 (\4\:B1 VSS) capacitor c=5.67771e-17
C32 (\5\:B0 VSS) capacitor c=4.2838e-17
C33 (\4\:VDD VSS) capacitor c=2.94805e-17
Rk6 (B0 \5\:B0) resistor r=0.1139 c=0
Rk1 (A0 \5\:A0) resistor r=0.08512 c=0
Rk10 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk9 (\2\:VDD \4\:VDD) resistor r=0.3927 c=0
Rk11 (VDD \6\:VDD) resistor r=0.2386 c=0
Rk5 (\4\:Y Y) resistor r=0.0929 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.6176 c=0
Rk13 (\3\:VSS VSS) resistor r=0.08728 c=0
Rk14 (\3\:VSS \5\:VSS) resistor r=0.2896 c=0
Rk3 (B1 \4\:B1) resistor r=0.1438 c=0
Rk2 (A1 \4\:A1) resistor r=0.1199 c=0
Rk7 (\2\:net102 \4\:net102) resistor r=0.5941 c=0
Rk8 (\4\:net102 \6\:net102) resistor r=0.4267 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=70.7981 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=64.7092 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=2.0623 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=106.572 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=41.1873 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=8.9604 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=24.2328 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=105.002 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=105.746 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz2 (net102 \2\:net102) resistor r=37.5 c=0
Rz3 (\3\:net102 \4\:net102) resistor r=37.5 c=0
Rz4 (\5\:net102 \6\:net102) resistor r=37.5 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\5\:net102 \4\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=3.64e-14 ps=1.48e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\3\:net102 \1\:A1 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=4.81e-14 ps=1.48e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\1\:Y \3\:B1 \3\:net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.16e-14 ps=8.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\1\:Y \4\:B0 net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
ends OAI22X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:03 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI22X2
// View name: extracted

simulator lang=spectre

subckt OAI22X2 A0 A1 B0 B1 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.445e-06 sd=160n sca=19.9512 \
        scb=0.0180582 scc=0.00139447 m=(1)
mp1_1__rcx (\9\:Y \5\:A1 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.34e-06 sd=160n sca=18.8244 \
        scb=0.0164205 scc=0.00138121 m=(1)
mp1 (\9\:Y \1\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=1.135e-06 sd=160n sca=17.7255 scb=0.0154354 scc=0.00137898 \
        m=(1)
mp0 (3 \4\:A0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.03e-06 sd=160n sca=17.42 \
        scb=0.0153123 scc=0.00137893 m=(1)
mp2_1__rcx (6 \4\:B0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.995e-14 ps=1.1e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=8.25e-07 sd=160n sca=17.3286 \
        scb=0.0152882 scc=0.00137893 m=(1)
mp3_1__rcx (\1\:Y \5\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=5.75e-07 sd=160n sca=18.1728 \
        scb=0.0157393 scc=0.00137928 m=(1)
mp3 (\1\:Y \1\:B1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.215e-06 sb=3.7e-07 sd=160n sca=19.9512 scb=0.0180582 \
        scc=0.00139447 m=(1)
mp2 (4 \7\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=2.34e-14 ps=1.31e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=2.65e-07 sd=160n sca=22.0353 \
        scb=0.0216797 scc=0.00148017 m=(1)
C1 (B1 VSS) capacitor c=7.20282e-17
C2 (A0 VSS) capacitor c=3.40637e-16
C3 (VDD VSS) capacitor c=8.80224e-17
C4 (B0 VSS) capacitor c=3.56028e-16
C5 (A1 VSS) capacitor c=5.92899e-17
C6 (Y VSS) capacitor c=1.60776e-17
C7 (net102 VSS) capacitor c=1.02053e-16
C8 (3 VSS) capacitor c=2.01268e-18
C9 (6 VSS) capacitor c=6.17026e-18
C10 (\7\:B0 VSS) capacitor c=7.92154e-17
C11 (\1\:B1 VSS) capacitor c=5.68933e-17
C12 (\5\:B1 VSS) capacitor c=3.80654e-17
C13 (\4\:B0 VSS) capacitor c=4.6036e-17
C14 (\4\:A0 VSS) capacitor c=9.13527e-17
C15 (\1\:A1 VSS) capacitor c=7.79791e-17
C16 (\5\:A1 VSS) capacitor c=5.78284e-17
C17 (\1\:A0 VSS) capacitor c=9.19065e-17
C18 (\2\:B1 VSS) capacitor c=3.66886e-17
C19 (\2\:A1 VSS) capacitor c=2.20909e-17
C20 (\1\:VDD VSS) capacitor c=5.3308e-17
C21 (\1\:Y VSS) capacitor c=7.02158e-17
C22 (\5\:VDD VSS) capacitor c=3.7308e-17
C23 (\9\:Y VSS) capacitor c=5.38247e-17
C24 (\8\:VDD VSS) capacitor c=2.76443e-17
C25 (\7\:net102 VSS) capacitor c=7.70496e-17
C26 (\5\:Y VSS) capacitor c=2.1165e-16
C27 (\3\:A1 VSS) capacitor c=1.14293e-16
C28 (\3\:B1 VSS) capacitor c=9.34611e-17
C29 (\7\:A1 VSS) capacitor c=5.47852e-17
C30 (\4\:Y VSS) capacitor c=6.30503e-17
C31 (\7\:B1 VSS) capacitor c=4.50348e-17
C32 (\2\:net102 VSS) capacitor c=1.59511e-16
C33 (\4\:VDD VSS) capacitor c=3.50682e-17
C34 (\7\:VDD VSS) capacitor c=1.45284e-17
Rk13 (B1 \7\:B1) resistor r=0.2077 c=0
Rk25 (\3\:VSS VSS) resistor r=0.09729 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.7822 c=0
Rk19 (\4\:VDD \6\:VDD) resistor r=0.3023 c=0
Rk22 (\7\:VDD VDD) resistor r=0.1299 c=0
Rk20 (\4\:VDD \7\:VDD) resistor r=0.3211 c=0
Rk21 (\7\:VDD \9\:VDD) resistor r=0.2562 c=0
Rk1 (\7\:A1 A1) resistor r=0.2826 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.1395 c=0
Rk8 (\4\:Y Y) resistor r=0.04356 c=0
Rk6 (\4\:Y \5\:Y) resistor r=0.4825 c=0
Rk5 (\3\:Y \4\:Y) resistor r=0.3433 c=0
Rk9 (Y \10\:Y) resistor r=0.1577 c=0
Rk10 (\10\:Y \11\:Y) resistor r=0.1395 c=0
Rl14 (\2\:B1 \1\:B1) resistor r=21.9779 c=0
Rl17 (\2\:B1 \5\:B1) resistor r=77.1158 c=0
Rl15 (\3\:B1 \2\:B1) resistor r=65.8294 c=0
Rl8 (A0 \4\:A0) resistor r=104.827 c=0
Rl1 (A0 \1\:A0) resistor r=151.489 c=0
Rl20 (B0 \7\:B0) resistor r=95.3297 c=0
Rl13 (B0 \4\:B0) resistor r=52.7257 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=84.7158 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=36.8321 c=0
Rl4 (\3\:A1 \2\:A1) resistor r=3.2713 c=0
Rz6 (\2\:net102 \7\:net102) resistor r=75 c=0
Rz3 (\2\:net102 net102) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry7 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=62 c=0
Ry2 (\3\:Y \1\:Y) resistor r=62 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry4 (\11\:Y \9\:Y) resistor r=62 c=0
Rx6 (\7\:B1 \2\:B1) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
mn0_1__rcx (\2\:net102 A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.55e-14 ad=4.225e-14 ps=8.7e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.615e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn3_1__rcx (\5\:Y \3\:B1 \7\:net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (net102 \3\:A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.395e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2_1__rcx (\5\:Y B0 \2\:net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=7.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
ends OAI22X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:04 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI22X4
// View name: extracted

simulator lang=spectre

subckt OAI22X4 A0 A1 B0 B1 VDD VSS Y
mp0_1__rcx (4 \1\:A0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.2882 scb=0.0164375 \
        scc=0.00159648 m=(1)
mp1_1__rcx (\15\:Y \5\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=18.8494 scb=0.0161462 \
        scc=0.00159619 m=(1)
mp1_2__rcx (\15\:Y \1\:A1 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0_2__rcx (3 \6\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0_3__rcx (9 \4\:A0 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp1_3__rcx (\11\:Y \11\:A1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=1.94e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp1 (\11\:Y \7\:A1 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=6.24e-14 ps=9.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.735e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp0 (11 \11\:A0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4115e-13 ad=3.12e-14 ps=1.67e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.61e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp2_1__rcx (10 \1\:B0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4115e-13 ad=4.875e-14 ps=1.67e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.24e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3_1__rcx (\18\:Y \4\:B1 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.07e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3_2__rcx (\18\:Y \6\:B1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp2_2__rcx (5 \8\:B0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp2_3__rcx (7 \10\:B0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=18.3986 scb=0.0159927 \
        scc=0.00159615 m=(1)
mp3_3__rcx (\21\:Y \10\:B1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=18.6377 scb=0.0160565 \
        scc=0.00159616 m=(1)
mp3 (\21\:Y \12\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=19.4511 scb=0.0165805 \
        scc=0.00159672 m=(1)
mp2 (6 \13\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.2277 scb=0.017479 \
        scc=0.00160012 m=(1)
C1 (B0 VSS) capacitor c=3.04103e-17
C2 (A1 VSS) capacitor c=4.62009e-16
C3 (VDD VSS) capacitor c=1.26649e-16
C4 (B1 VSS) capacitor c=4.33013e-16
C5 (A0 VSS) capacitor c=5.29906e-16
C6 (Y VSS) capacitor c=1.53126e-17
C7 (net102 VSS) capacitor c=5.8827e-16
C8 (3 VSS) capacitor c=2.0348e-18
C9 (9 VSS) capacitor c=3.88442e-18
C10 (11 VSS) capacitor c=2.32514e-18
C11 (10 VSS) capacitor c=3.90746e-18
C12 (5 VSS) capacitor c=2.02598e-18
C13 (7 VSS) capacitor c=2.19172e-18
C14 (\13\:B0 VSS) capacitor c=1.08431e-16
C15 (\12\:B1 VSS) capacitor c=5.98972e-17
C16 (\10\:B1 VSS) capacitor c=7.77661e-17
C17 (\10\:B0 VSS) capacitor c=6.87409e-17
C18 (\8\:B0 VSS) capacitor c=7.36754e-17
C19 (\6\:B1 VSS) capacitor c=5.87884e-17
C20 (\4\:B1 VSS) capacitor c=4.78602e-17
C21 (\1\:B0 VSS) capacitor c=6.06639e-17
C22 (\11\:A0 VSS) capacitor c=7.45608e-17
C23 (\7\:A1 VSS) capacitor c=6.72281e-17
C24 (\11\:A1 VSS) capacitor c=3.69054e-17
C25 (\4\:A0 VSS) capacitor c=5.5047e-17
C26 (\6\:A0 VSS) capacitor c=7.00635e-17
C27 (\1\:A1 VSS) capacitor c=7.73929e-17
C28 (\5\:A1 VSS) capacitor c=5.85745e-17
C29 (\1\:A0 VSS) capacitor c=1.17408e-16
C30 (\2\:B0 VSS) capacitor c=5.53054e-16
C31 (\1\:VDD VSS) capacitor c=4.00654e-17
C32 (\21\:Y VSS) capacitor c=9.15797e-17
C33 (\8\:VDD VSS) capacitor c=4.10705e-17
C34 (\18\:Y VSS) capacitor c=6.00071e-17
C35 (\10\:VDD VSS) capacitor c=2.91231e-17
C36 (\11\:Y VSS) capacitor c=2.73227e-17
C37 (\12\:VDD VSS) capacitor c=4.52814e-17
C38 (\15\:Y VSS) capacitor c=4.53906e-17
C39 (\15\:VDD VSS) capacitor c=3.85062e-17
C40 (\3\:VDD VSS) capacitor c=4.92342e-17
C41 (\1\:Y VSS) capacitor c=4.28144e-16
C42 (\7\:B0 VSS) capacitor c=3.85329e-17
C43 (\9\:Y VSS) capacitor c=5.7766e-17
C44 (\10\:Y VSS) capacitor c=5.65883e-17
C45 (\13\:Y VSS) capacitor c=2.23053e-17
C46 (\14\:Y VSS) capacitor c=4.92764e-17
C47 (\5\:VDD VSS) capacitor c=2.10937e-17
C48 (\6\:VDD VSS) capacitor c=2.30746e-17
C49 (\14\:VDD VSS) capacitor c=1.39022e-17
Rk25 (\2\:B0 B0) resistor r=0.08407 c=0
Rk34 (\2\:VDD \4\:VDD) resistor r=0.4848 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.1925 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.41 c=0
Rk37 (\6\:VDD \7\:VDD) resistor r=0.3476 c=0
Rk38 (\5\:VDD \9\:VDD) resistor r=0.2572 c=0
Rk39 (\6\:VDD \11\:VDD) resistor r=0.1778 c=0
Rk40 (\7\:VDD \13\:VDD) resistor r=0.3031 c=0
Rk43 (\14\:VDD VDD) resistor r=0.2348 c=0
Rk41 (\7\:VDD \14\:VDD) resistor r=0.3157 c=0
Rk42 (\14\:VDD \16\:VDD) resistor r=0.351 c=0
Rk11 (\1\:Y \9\:Y) resistor r=0.6175 c=0
Rk12 (\9\:Y \10\:Y) resistor r=0.2661 c=0
Rk13 (\10\:Y \12\:Y) resistor r=0.05031 c=0
Rk15 (\13\:Y Y) resistor r=0.03891 c=0
Rk14 (\9\:Y \13\:Y) resistor r=0.1352 c=0
Rk16 (\10\:Y \14\:Y) resistor r=0.4505 c=0
Rk17 (\14\:Y \16\:Y) resistor r=0.05702 c=0
Rk18 (\10\:Y \17\:Y) resistor r=0.1099 c=0
Rk19 (\13\:Y \19\:Y) resistor r=0.2419 c=0
Rk20 (\14\:Y \20\:Y) resistor r=0.1166 c=0
Rk21 (\19\:Y \22\:Y) resistor r=0.4349 c=0
Rk49 (\3\:VSS VSS) resistor r=0.1022 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.693 c=0
Rl38 (\2\:B0 \13\:B0) resistor r=163.4 c=0
Rl19 (\2\:B0 \1\:B0) resistor r=91.0764 c=0
Rl31 (\7\:B0 \10\:B0) resistor r=85.0356 c=0
Rl29 (\7\:B0 \8\:B0) resistor r=123.107 c=0
Rl28 (\7\:B0 \2\:B0) resistor r=3.8223 c=0
Rl12 (A1 \7\:A1) resistor r=106.514 c=0
Rl15 (A1 \11\:A1) resistor r=25.3108 c=0
Rl3 (A1 \1\:A1) resistor r=82.6695 c=0
Rl6 (A1 \5\:A1) resistor r=24.7951 c=0
Rl36 (B1 \12\:B1) resistor r=27.0846 c=0
Rl34 (B1 \10\:B1) resistor r=76.8424 c=0
Rl25 (B1 \6\:B1) resistor r=27.0846 c=0
Rl23 (B1 \4\:B1) resistor r=76.8424 c=0
Rl18 (A0 \11\:A0) resistor r=93.4636 c=0
Rl8 (A0 \4\:A0) resistor r=141.129 c=0
Rl9 (A0 \6\:A0) resistor r=94.5244 c=0
Rl1 (A0 \1\:A0) resistor r=237.546 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz15 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry11 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry1 (\12\:Y \11\:Y) resistor r=62 c=0
Ry2 (\16\:Y \15\:Y) resistor r=62 c=0
Ry3 (\17\:Y \11\:Y) resistor r=62 c=0
Ry4 (\19\:Y \18\:Y) resistor r=62 c=0
Ry5 (\20\:Y \15\:Y) resistor r=62 c=0
Ry6 (\22\:Y \21\:Y) resistor r=20.6667 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry13 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (net102 A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.55e-14 ps=1.35e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn1 (net102 A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.16e-14 ps=1.35e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn2_1__rcx (\1\:Y \2\:B0 net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn3_1__rcx (\1\:Y B1 net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
ends OAI22X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:05 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI22XL
// View name: extracted

simulator lang=spectre

subckt OAI22XL A0 A1 B0 B1 VDD VSS Y
mp0 (net93 \1\:A0 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.472e-14 ps=7.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=24.4755 \
        scb=0.0279779 scc=0.00151773 m=(1)
mp1 (\3\:Y \3\:A1 net93 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=5.375e-14 ps=6.6e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=6.35e-07 sd=160n sca=16.1871 scb=0.0155626 \
        scc=0.00030556 m=(1)
mp3 (\3\:Y \1\:B1 net85 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=5.375e-14 ps=7.4e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.4e-07 sd=160n sca=14.1665 \
        scb=0.0115254 scc=0.000225012 m=(1)
mp2 (net85 \3\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.333e-14 ps=7.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.4e-07 sd=160n sca=16.9689 \
        scb=0.0170565 scc=0.000364407 m=(1)
C1 (B0 VSS) capacitor c=4.39243e-17
C2 (A0 VSS) capacitor c=9.91736e-17
C3 (VDD VSS) capacitor c=9.20737e-17
C4 (Y VSS) capacitor c=8.78334e-17
C5 (B1 VSS) capacitor c=5.34684e-17
C6 (A1 VSS) capacitor c=8.23925e-17
C7 (net102 VSS) capacitor c=6.20892e-17
C8 (net85 VSS) capacitor c=6.83633e-18
C9 (\3\:B0 VSS) capacitor c=4.38962e-17
C10 (\1\:B1 VSS) capacitor c=3.78868e-17
C11 (\3\:A1 VSS) capacitor c=5.53813e-17
C12 (\1\:A0 VSS) capacitor c=5.28067e-17
C13 (\1\:B0 VSS) capacitor c=2.57862e-17
C14 (\3\:B1 VSS) capacitor c=4.50945e-17
C15 (\1\:A1 VSS) capacitor c=3.55925e-17
C16 (\4\:A0 VSS) capacitor c=3.46616e-17
C17 (\2\:B0 VSS) capacitor c=4.64913e-17
C18 (\2\:B1 VSS) capacitor c=4.60342e-17
C19 (\2\:A1 VSS) capacitor c=5.80589e-17
C20 (\3\:A0 VSS) capacitor c=1.44236e-17
C21 (\1\:VDD VSS) capacitor c=2.30577e-17
C22 (\3\:Y VSS) capacitor c=2.32688e-17
C23 (\5\:VDD VSS) capacitor c=2.73412e-17
C24 (\1\:Y VSS) capacitor c=9.20447e-17
C25 (\3\:net102 VSS) capacitor c=1.01201e-16
C26 (\5\:net102 VSS) capacitor c=3.92141e-17
C27 (\2\:A0 VSS) capacitor c=4.08403e-17
C28 (\4\:A1 VSS) capacitor c=4.72313e-17
C29 (\4\:B1 VSS) capacitor c=6.36177e-17
C30 (\4\:B0 VSS) capacitor c=3.66668e-17
C31 (\4\:VDD VSS) capacitor c=2.09914e-17
Rk6 (B0 \4\:B0) resistor r=0.2245 c=0
Rk1 (\5\:A0 A0) resistor r=0.002993 c=0
Rk10 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk9 (\2\:VDD \4\:VDD) resistor r=0.4559 c=0
Rk11 (VDD \6\:VDD) resistor r=0.2798 c=0
Rk4 (\2\:Y Y) resistor r=0.5695 c=0
Rk5 (Y \4\:Y) resistor r=0.08683 c=0
Rk13 (\3\:VSS VSS) resistor r=0.1198 c=0
Rk14 (\3\:VSS \5\:VSS) resistor r=0.07334 c=0
Rk3 (B1 \4\:B1) resistor r=0.2245 c=0
Rk2 (\4\:A1 A1) resistor r=0.1056 c=0
Rk7 (\2\:net102 \4\:net102) resistor r=0.6324 c=0
Rk8 (\4\:net102 \6\:net102) resistor r=0.2725 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=158.791 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=40.3846 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=170.868 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=43.9449 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=7.5059 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=85.3072 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=112.23 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=153.641 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=43.3029 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz2 (net102 \2\:net102) resistor r=75 c=0
Rz3 (\3\:net102 \4\:net102) resistor r=75 c=0
Rz4 (\5\:net102 \6\:net102) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\5\:net102 \4\:A0 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.5e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\3\:net102 \1\:A1 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=3.118e-14 ps=1.35e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=6.55e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\1\:Y \3\:B1 \3\:net102 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.045e-14 ps=7.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (\1\:Y \1\:B0 net102 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.045e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
ends OAI22XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:06 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB1X1
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y \3\:n0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.31026e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(1)
mp2 (\1\:Y \1\:B0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.26026e-07 sd=160n sca=24.0497 \
        scb=0.0216272 scc=0.0017588 m=(1)
C1 (A0N VSS) capacitor c=8.7725e-17
C2 (B0 VSS) capacitor c=5.18484e-17
C3 (VDD VSS) capacitor c=7.82562e-17
C4 (Y VSS) capacitor c=6.06986e-17
C5 (A1N VSS) capacitor c=4.26343e-17
C6 (n0 VSS) capacitor c=5.77466e-17
C7 (\1\:A1N VSS) capacitor c=4.53919e-17
C8 (\3\:A0N VSS) capacitor c=5.1101e-17
C9 (\1\:B0 VSS) capacitor c=6.13645e-17
C10 (\3\:n0 VSS) capacitor c=4.44817e-17
C11 (\3\:A1N VSS) capacitor c=5.25362e-17
C12 (\1\:A0N VSS) capacitor c=6.57625e-17
C13 (\3\:B0 VSS) capacitor c=7.65147e-17
C14 (\4\:A1N VSS) capacitor c=1.27527e-17
C15 (\2\:A0N VSS) capacitor c=6.29473e-17
C16 (\2\:B0 VSS) capacitor c=5.31261e-17
C17 (\2\:n0 VSS) capacitor c=5.19368e-17
C18 (\1\:VDD VSS) capacitor c=1.10106e-17
C19 (\4\:n0 VSS) capacitor c=6.19292e-17
C20 (\5\:VDD VSS) capacitor c=4.5061e-17
C21 (\1\:Y VSS) capacitor c=1.27783e-16
C22 (\7\:VDD VSS) capacitor c=5.08761e-17
C23 (\8\:n0 VSS) capacitor c=4.31151e-17
C24 (\3\:Y VSS) capacitor c=4.52611e-17
C25 (\2\:A1N VSS) capacitor c=4.46841e-17
C26 (\4\:B0 VSS) capacitor c=5.48624e-17
C27 (\4\:A0N VSS) capacitor c=5.30499e-17
C28 (\6\:n0 VSS) capacitor c=1.26199e-16
C29 (\7\:n0 VSS) capacitor c=8.2671e-17
C30 (\7\:A1N VSS) capacitor c=5.2483e-17
C31 (\4\:VDD VSS) capacitor c=1.79697e-17
Rk16 (\4\:VSS VSS) resistor r=0.2007 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.3044 c=0
Rk4 (\4\:A0N A0N) resistor r=0.1281 c=0
Rk3 (\4\:B0 B0) resistor r=0.1234 c=0
Rk13 (\4\:VDD VDD) resistor r=0.201 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.2661 c=0
Rk12 (\4\:VDD \6\:VDD) resistor r=0.3278 c=0
Rk14 (VDD \8\:VDD) resistor r=0.3287 c=0
Rk1 (\2\:Y Y) resistor r=0.6897 c=0
Rk2 (Y \4\:Y) resistor r=0.04817 c=0
Rk8 (\5\:A1N A1N) resistor r=0.002535 c=0
Rk10 (\5\:A1N \7\:A1N) resistor r=0.03925 c=0
Rk9 (\6\:A1N \7\:A1N) resistor r=0.002438 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.5312 c=0
Rk6 (\6\:n0 \7\:n0) resistor r=0.3644 c=0
Rk7 (\6\:n0 \9\:n0) resistor r=0.1721 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=92.2876 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=112.23 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=52.6149 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.2302 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=134.077 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=86.0481 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=4.5402 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.5604 c=0
Rl1 (n0 \2\:n0) resistor r=53.6362 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y n0 n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=4.45769e-07 sd=160n sca=8.65991 scb=0.00681295 scc=0.000165238 \
        m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.40769e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn0 (n1 \1\:A0N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=8.7e-15 ps=9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.65e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (\8\:n0 \3\:A1N n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp0 (\4\:n0 \3\:A0N \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.05e-07 sd=160n sca=16.4198 \
        scb=0.014982 scc=0.000248552 m=(1)
mp1 (\4\:n0 \1\:A1N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1e-07 sd=160n sca=27.6521 scb=0.0306729 \
        scc=0.00212413 m=(1)
ends OAI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:07 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB1X2
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X2 A0N A1N B0 VDD VSS Y
mp2 (\1\:Y \2\:B0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.496e-14 ad=6.24e-14 ps=1.335e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.90641e-07 sd=160n sca=17.4719 \
        scb=0.0181939 scc=0.00043542 m=(2)
mp3 (\1\:Y n0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.85641e-07 sd=160n sca=13.3812 \
        scb=0.0112303 scc=0.000237076 m=(2)
C1 (A0N VSS) capacitor c=2.66574e-17
C2 (B0 VSS) capacitor c=1.71276e-17
C3 (VDD VSS) capacitor c=1.64429e-16
C4 (Y VSS) capacitor c=1.94359e-17
C5 (A1N VSS) capacitor c=3.36761e-17
C6 (8 VSS) capacitor c=1.49756e-18
C7 (n0 VSS) capacitor c=8.79837e-17
C8 (\4\:A1N VSS) capacitor c=3.00066e-17
C9 (\1\:A0N VSS) capacitor c=4.96636e-17
C10 (\3\:A1N VSS) capacitor c=2.94001e-17
C11 (\3\:A0N VSS) capacitor c=2.85989e-17
C12 (\6\:B0 VSS) capacitor c=6.18272e-17
C13 (\4\:n0 VSS) capacitor c=5.57581e-17
C14 (\6\:n0 VSS) capacitor c=6.38255e-17
C15 (\1\:B0 VSS) capacitor c=5.43613e-17
C16 (\1\:A1N VSS) capacitor c=1.46313e-17
C17 (\2\:A0N VSS) capacitor c=3.75982e-17
C18 (\2\:B0 VSS) capacitor c=3.40143e-16
C19 (\1\:VDD VSS) capacitor c=1.80669e-17
C20 (\7\:n0 VSS) capacitor c=1.98354e-17
C21 (\1\:Y VSS) capacitor c=1.44785e-16
C22 (\10\:VDD VSS) capacitor c=3.50617e-17
C23 (\11\:n0 VSS) capacitor c=4.43448e-17
C24 (\7\:Y VSS) capacitor c=8.67361e-17
C25 (\3\:n0 VSS) capacitor c=4.40243e-17
C26 (\2\:A1N VSS) capacitor c=3.1025e-17
C27 (\4\:Y VSS) capacitor c=6.69238e-17
C28 (\4\:A0N VSS) capacitor c=7.18065e-17
C29 (\9\:n0 VSS) capacitor c=1.01128e-16
C30 (\10\:n0 VSS) capacitor c=8.7895e-17
C31 (\5\:A1N VSS) capacitor c=4.60803e-17
C32 (\3\:VDD VSS) capacitor c=7.92567e-17
Rk22 (\2\:VSS \4\:VSS) resistor r=0.3579 c=0
Rk24 (\5\:VSS VSS) resistor r=0.1068 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.2916 c=0
Rk25 (\5\:VSS \7\:VSS) resistor r=0.2766 c=0
Rk9 (\4\:A0N A0N) resistor r=0.07481 c=0
Rk8 (\2\:B0 B0) resistor r=0.005177 c=0
Rk18 (\3\:VDD VDD) resistor r=0.05692 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.2879 c=0
Rk20 (\3\:VDD \11\:VDD) resistor r=0.1812 c=0
Rk3 (\4\:Y Y) resistor r=0.03517 c=0
Rk2 (\1\:Y \4\:Y) resistor r=0.1798 c=0
Rk5 (\4\:Y \8\:Y) resistor r=0.5502 c=0
Rk13 (A1N \5\:A1N) resistor r=0.2077 c=0
Rk10 (\8\:n0 \9\:n0) resistor r=0.09629 c=0
Rk11 (\9\:n0 \10\:n0) resistor r=0.4716 c=0
Rk12 (\9\:n0 \12\:n0) resistor r=0.3874 c=0
Rl10 (\1\:A0N \2\:A0N) resistor r=98.7687 c=0
Rl11 (\2\:A0N \3\:A0N) resistor r=44.9225 c=0
Rl9 (\2\:B0 \6\:B0) resistor r=40.1797 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=40.1797 c=0
Rl14 (\2\:A1N \4\:A1N) resistor r=74.7141 c=0
Rl13 (\2\:A1N \3\:A1N) resistor r=86.2526 c=0
Rl12 (\1\:A1N \2\:A1N) resistor r=29.0533 c=0
Rl4 (\3\:n0 n0) resistor r=10.2925 c=0
Rl5 (\3\:n0 \4\:n0) resistor r=86.6019 c=0
Rl7 (\3\:n0 \6\:n0) resistor r=136.023 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Rz2 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry4 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry3 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx3 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx5 (\1\:A1N \5\:A1N) resistor r=45 c=0
Rx4 (\10\:n0 n0) resistor r=45 c=0
mn2_1__rcx (8 \1\:B0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.89615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn3_1__rcx (\7\:Y \6\:n0 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.84615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn3 (\7\:Y \4\:n0 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=5.79615e-07 sd=160n sca=16.3874 scb=0.0162972 \
        scc=0.00139495 m=(1)
mn2 (9 \6\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.74615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn0 (n1 \3\:A0N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=3.117e-14 ps=1.11e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=4e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn1 (\11\:n0 \3\:A1N n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mp0 (\7\:n0 \1\:A0N \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.532e-14 ad=4.622e-14 ps=1.61e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.6e-07 sd=160n sca=13.2854 \
        scb=0.0114741 scc=0.000332863 m=(1)
mp1 (\7\:n0 \4\:A1N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=4.622e-14 ps=1.42e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1e-07 sd=160n sca=16.6544 \
        scb=0.0167336 scc=0.000417003 m=(1)
ends OAI2BB1X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:09 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB1X4
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X4 A0N A1N B0 VDD VSS Y
mp0 (\19\:n0 \1\:A0N \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=1.053e-13 ps=1.22e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-06 sb=4.55e-07 sd=160n sca=13.3748 \
        scb=0.0113115 scc=0.000384334 m=(1)
mp1 (\19\:n0 \1\:A1N \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=1.053e-13 ps=1.06e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.4901 scb=0.0196141 \
        scc=0.000605547 m=(1)
mp2 (\1\:Y \2\:B0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.337e-14 ps=1.12e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.9187 scb=0.0234591 \
        scc=0.000905231 m=(4)
mp3_1__rcx (\1\:Y n0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.337e-14 ps=1.1e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96e-06 sd=160n sca=14.8572 \
        scb=0.0133107 scc=0.000397776 m=(4)
C1 (A0N VSS) capacitor c=4.31991e-17
C2 (B0 VSS) capacitor c=1.82022e-17
C3 (Y VSS) capacitor c=7.54033e-17
C4 (VDD VSS) capacitor c=1.79971e-16
C5 (A1N VSS) capacitor c=5.1413e-17
C6 (8 VSS) capacitor c=1.85166e-18
C7 (n0 VSS) capacitor c=5.11138e-16
C8 (9 VSS) capacitor c=3.55348e-18
C9 (10 VSS) capacitor c=3.80467e-18
C10 (\1\:A1N VSS) capacitor c=3.4306e-17
C11 (\1\:A0N VSS) capacitor c=3.87495e-17
C12 (\3\:A1N VSS) capacitor c=5.71162e-17
C13 (\3\:A0N VSS) capacitor c=4.35298e-17
C14 (\13\:B0 VSS) capacitor c=2.87719e-17
C15 (\12\:n0 VSS) capacitor c=2.66136e-17
C16 (\11\:n0 VSS) capacitor c=4.47534e-17
C17 (\8\:B0 VSS) capacitor c=3.18358e-17
C18 (\7\:B0 VSS) capacitor c=3.46035e-17
C19 (\6\:n0 VSS) capacitor c=2.90265e-17
C20 (\5\:n0 VSS) capacitor c=4.44726e-17
C21 (\1\:B0 VSS) capacitor c=5.18209e-17
C22 (\4\:A1N VSS) capacitor c=1.1953e-17
C23 (\2\:A0N VSS) capacitor c=3.60275e-17
C24 (\2\:B0 VSS) capacitor c=5.92499e-16
C25 (\10\:VDD VSS) capacitor c=2.90695e-17
C26 (\19\:n0 VSS) capacitor c=4.45084e-17
C27 (\1\:Y VSS) capacitor c=3.4179e-16
C28 (\1\:VDD VSS) capacitor c=1.68453e-17
C29 (\14\:n0 VSS) capacitor c=3.6731e-17
C30 (\14\:Y VSS) capacitor c=8.40413e-17
C31 (\12\:Y VSS) capacitor c=1.53153e-16
C32 (\2\:A1N VSS) capacitor c=1.71233e-17
C33 (\4\:A0N VSS) capacitor c=6.4527e-17
C34 (\16\:n0 VSS) capacitor c=1.19857e-16
C35 (\5\:A1N VSS) capacitor c=3.46342e-17
C36 (\3\:VDD VSS) capacitor c=1.44313e-17
C37 (\4\:VDD VSS) capacitor c=2.78487e-16
Rk35 (\2\:VSS \3\:VSS) resistor r=0.3457 c=0
Rk36 (\3\:VSS \4\:VSS) resistor r=0.3056 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.1477 c=0
Rk39 (\6\:VSS VSS) resistor r=0.06471 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.3379 c=0
Rk40 (\3\:VSS \8\:VSS) resistor r=0.2861 c=0
Rk41 (\5\:VSS \10\:VSS) resistor r=0.2815 c=0
Rk42 (\6\:VSS \12\:VSS) resistor r=0.2815 c=0
Rk14 (\4\:A0N A0N) resistor r=0.1012 c=0
Rk13 (\2\:B0 B0) resistor r=0.02733 c=0
Rk4 (\1\:Y Y) resistor r=0.2349 c=0
Rk8 (Y \13\:Y) resistor r=0.5999 c=0
Rk9 (\13\:Y \15\:Y) resistor r=0.5051 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.05494 c=0
Rk28 (\4\:VDD VDD) resistor r=0.02963 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.2903 c=0
Rk29 (\3\:VDD \11\:VDD) resistor r=0.2263 c=0
Rk20 (\5\:A1N A1N) resistor r=0.1642 c=0
Rk16 (\16\:n0 n0) resistor r=0.6413 c=0
Rk15 (\15\:n0 \16\:n0) resistor r=0.364 c=0
Rk18 (\16\:n0 \20\:n0) resistor r=0.1273 c=0
Rl22 (\1\:A0N \2\:A0N) resistor r=64.1533 c=0
Rl23 (\2\:A0N \3\:A0N) resistor r=60.3072 c=0
Rl21 (\2\:B0 \13\:B0) resistor r=41.1873 c=0
Rl12 (\2\:B0 \8\:B0) resistor r=28.6412 c=0
Rl11 (\2\:B0 \7\:B0) resistor r=71.1317 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=28.6412 c=0
Rl24 (\1\:A1N \2\:A1N) resistor r=73.7402 c=0
Rl25 (\2\:A1N \3\:A1N) resistor r=104.154 c=0
Rl26 (\2\:A1N \4\:A1N) resistor r=12.1383 c=0
Rl17 (n0 \12\:n0) resistor r=86.22 c=0
Rl16 (n0 \11\:n0) resistor r=119.208 c=0
Rl7 (n0 \6\:n0) resistor r=28.0797 c=0
Rl6 (n0 \5\:n0) resistor r=28.0797 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\13\:Y \12\:Y) resistor r=75 c=0
Rz2 (\15\:Y \14\:Y) resistor r=75 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz5 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\15\:n0 \14\:n0) resistor r=75 c=0
Ry12 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry13 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\20\:n0 \19\:n0) resistor r=20.6667 c=0
Rx4 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx7 (\4\:A1N \5\:A1N) resistor r=45 c=0
mn2_1__rcx (8 \1\:B0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.905e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_1__rcx (\12\:Y \5\:n0 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.8e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_2__rcx (\12\:Y \6\:n0 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.595e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_2__rcx (9 \7\:B0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.435e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_3__rcx (10 \8\:B0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.23e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_3__rcx (\14\:Y \11\:n0 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.07e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\14\:Y \12\:n0 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=8.65e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (11 \13\:B0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.76e-14 ps=9.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn0 (n1 \3\:A0N \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=2.86e-14 ps=9.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.95e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\14\:n0 \3\:A1N n1 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=3.64e-14 ps=7.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
ends OAI2BB1X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:10 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB1XL
// View name: extracted

simulator lang=spectre

subckt OAI2BB1XL A0N A1N B0 VDD VSS Y
mp3 (\3\:Y \3\:n0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.35e-07 sd=160n sca=16.7249 scb=0.0166366 \
        scc=0.000331722 m=(1)
mp2 (\3\:Y \1\:B0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.3e-07 sd=160n sca=13.903 \
        scb=0.0110664 scc=0.000192019 m=(1)
mp0 (\8\:n0 \1\:A0N \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.085e-14 ps=1.45e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=3.35e-07 sd=160n sca=14.4432 scb=0.0121509 \
        scc=0.000203603 m=(1)
mp1 (\8\:n0 \1\:A1N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=4.085e-14 ps=1.35e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1e-07 sd=160n sca=22.3297 scb=0.0253475 \
        scc=0.00112325 m=(1)
C1 (A0N VSS) capacitor c=2.86749e-17
C2 (B0 VSS) capacitor c=1.31273e-16
C3 (VDD VSS) capacitor c=1.01774e-16
C4 (Y VSS) capacitor c=8.9755e-17
C5 (A1N VSS) capacitor c=1.99336e-17
C6 (n0 VSS) capacitor c=4.2695e-17
C7 (\1\:A1N VSS) capacitor c=2.48303e-17
C8 (\1\:A0N VSS) capacitor c=4.0278e-17
C9 (\1\:B0 VSS) capacitor c=5.46577e-17
C10 (\3\:n0 VSS) capacitor c=5.84576e-17
C11 (\3\:A1N VSS) capacitor c=8.94183e-17
C12 (\3\:A0N VSS) capacitor c=9.29924e-17
C13 (\3\:B0 VSS) capacitor c=7.6877e-17
C14 (\4\:A1N VSS) capacitor c=1.43194e-17
C15 (\2\:A0N VSS) capacitor c=7.98431e-17
C16 (\2\:B0 VSS) capacitor c=6.64335e-17
C17 (\2\:n0 VSS) capacitor c=5.85456e-17
C18 (\1\:VDD VSS) capacitor c=1.16316e-17
C19 (\8\:n0 VSS) capacitor c=7.77789e-17
C20 (\7\:VDD VSS) capacitor c=4.86638e-18
C21 (\3\:Y VSS) capacitor c=8.43362e-17
C22 (\9\:VDD VSS) capacitor c=1.38226e-17
C23 (\4\:n0 VSS) capacitor c=1.81915e-17
C24 (\1\:Y VSS) capacitor c=3.40675e-17
C25 (\2\:A1N VSS) capacitor c=6.03497e-17
C26 (\4\:A0N VSS) capacitor c=1.03314e-16
C27 (\6\:n0 VSS) capacitor c=9.85557e-17
C28 (\7\:n0 VSS) capacitor c=5.48666e-17
C29 (\5\:A1N VSS) capacitor c=5.66004e-17
C30 (\3\:VDD VSS) capacitor c=5.1612e-18
C31 (\5\:VDD VSS) capacitor c=8.51965e-18
C32 (\6\:VDD VSS) capacitor c=5.30053e-18
Rk20 (\4\:VSS VSS) resistor r=0.25 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.2453 c=0
Rk6 (\4\:A0N A0N) resistor r=0.01793 c=0
Rk3 (\4\:B0 B0) resistor r=0.002989 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.2534 c=0
Rk14 (\3\:VDD \5\:VDD) resistor r=0.03734 c=0
Rk16 (\6\:VDD VDD) resistor r=0.08714 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.1625 c=0
Rk17 (\3\:VDD \8\:VDD) resistor r=0.07311 c=0
Rk18 (\6\:VDD \10\:VDD) resistor r=0.07311 c=0
Rk1 (\2\:Y Y) resistor r=0.2199 c=0
Rk2 (Y \4\:Y) resistor r=0.7547 c=0
Rk12 (\5\:A1N A1N) resistor r=0.01793 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.1651 c=0
Rk8 (\6\:n0 \7\:n0) resistor r=0.3581 c=0
Rk9 (\6\:n0 \9\:n0) resistor r=0.5336 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=29.5379 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=229.538 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=97.8081 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=162.637 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=24.4619 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=270.663 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=12.2705 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=232.143 c=0
Rl1 (n0 \2\:n0) resistor r=28.8462 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \5\:A1N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\1\:Y n0 n2 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.7e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.65e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn0 (n1 \3\:A0N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=2.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (\4\:n0 \3\:A1N n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
ends OAI2BB1XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:11 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB2X1
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X1 A0N A1N B0 B1 VDD VSS Y
mp1 (\6\:n1 \1\:A1N \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.45e-07 sd=160n sca=14.4258 \
        scb=0.0129222 scc=0.000259662 m=(1)
mp0 (\6\:n0 \3\:A0N \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5073 \
        scb=0.0103104 scc=0.000239765 m=(1)
C1 (B1 VSS) capacitor c=1.12677e-16
C2 (Y VSS) capacitor c=4.36652e-17
C3 (A0N VSS) capacitor c=4.70497e-17
C4 (B0 VSS) capacitor c=4.00323e-17
C5 (VDD VSS) capacitor c=1.33919e-16
C6 (A1N VSS) capacitor c=4.49848e-17
C7 (n1 VSS) capacitor c=5.95779e-17
C8 (n0 VSS) capacitor c=4.0585e-17
C9 (n4 VSS) capacitor c=6.61756e-17
C10 (n2 VSS) capacitor c=6.28521e-18
C11 (n3 VSS) capacitor c=9.49141e-18
C12 (\3\:B0 VSS) capacitor c=3.98587e-17
C13 (\3\:B1 VSS) capacitor c=5.21256e-17
C14 (\3\:A0N VSS) capacitor c=2.91637e-17
C15 (\1\:A1N VSS) capacitor c=3.57365e-17
C16 (\1\:B0 VSS) capacitor c=3.83905e-17
C17 (\1\:B1 VSS) capacitor c=3.88583e-17
C18 (\3\:n1 VSS) capacitor c=3.87969e-17
C19 (\3\:n0 VSS) capacitor c=4.50396e-17
C20 (\1\:A0N VSS) capacitor c=5.01883e-17
C21 (\3\:A1N VSS) capacitor c=3.72157e-17
C22 (\4\:B0 VSS) capacitor c=1.37945e-17
C23 (\2\:B1 VSS) capacitor c=4.8319e-17
C24 (\2\:n1 VSS) capacitor c=4.3287e-17
C25 (\2\:n0 VSS) capacitor c=3.1492e-17
C26 (\2\:A0N VSS) capacitor c=3.90331e-17
C27 (\2\:A1N VSS) capacitor c=3.69735e-17
C28 (\1\:VDD VSS) capacitor c=6.78967e-17
C29 (\3\:Y VSS) capacitor c=1.10733e-16
C30 (\7\:VDD VSS) capacitor c=7.11652e-17
C31 (\6\:n0 VSS) capacitor c=7.72622e-17
C32 (\9\:VDD VSS) capacitor c=3.39728e-17
C33 (\6\:n1 VSS) capacitor c=5.73099e-17
C34 (\5\:n4 VSS) capacitor c=5.83422e-17
C35 (\1\:Y VSS) capacitor c=1.35288e-16
C36 (\3\:n4 VSS) capacitor c=1.04578e-16
C37 (\8\:n0 VSS) capacitor c=6.18229e-17
C38 (\8\:n1 VSS) capacitor c=1.60949e-17
C39 (\2\:B0 VSS) capacitor c=2.19162e-17
C40 (\4\:A1N VSS) capacitor c=6.95361e-17
C41 (\4\:A0N VSS) capacitor c=6.73028e-17
C42 (\4\:n0 VSS) capacitor c=5.09774e-17
C43 (\5\:n0 VSS) capacitor c=7.69939e-17
C44 (\4\:n1 VSS) capacitor c=1.98636e-16
C45 (\5\:n1 VSS) capacitor c=2.23569e-16
C46 (\5\:B0 VSS) capacitor c=4.64126e-17
C47 (\3\:VDD VSS) capacitor c=2.77216e-17
C48 (\5\:VDD VSS) capacitor c=1.12701e-17
C49 (\6\:VDD VSS) capacitor c=1.7844e-17
Rk22 (\3\:VSS VSS) resistor r=0.2377 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.326 c=0
Rk23 (\3\:VSS \5\:VSS) resistor r=0.3132 c=0
Rk24 (\5\:VSS \7\:VSS) resistor r=0.3855 c=0
Rk9 (\4\:B1 B1) resistor r=0.002999 c=0
Rk11 (\4\:Y Y) resistor r=0.162 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.8246 c=0
Rk2 (\4\:A0N A0N) resistor r=0.00989 c=0
Rk14 (B0 \5\:B0) resistor r=0.1009 c=0
Rk15 (\2\:VDD \3\:VDD) resistor r=0.8178 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.05245 c=0
Rk18 (\6\:VDD VDD) resistor r=0.2252 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.3257 c=0
Rk19 (\3\:VDD \8\:VDD) resistor r=0.3795 c=0
Rk20 (\6\:VDD \10\:VDD) resistor r=0.2814 c=0
Rk1 (A1N \4\:A1N) resistor r=0.1066 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=1.4576 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.6195 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.09247 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.2654 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.5092 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.2704 c=0
Rk12 (\2\:n4 \4\:n4) resistor r=0.3145 c=0
Rk13 (\4\:n4 \6\:n4) resistor r=0.4324 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=87.6944 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=45.3867 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=29.9451 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=148.077 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=63.4394 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=99.9628 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=23.4664 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=77.6148 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=98.7687 c=0
Rl7 (n1 \2\:n1) resistor r=102.615 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=33.3841 c=0
Rl5 (n0 \2\:n0) resistor r=39.6174 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=93.4636 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz6 (\5\:n4 \6\:n4) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx4 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\8\:n0 \1\:A0N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2.25e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (n4 \3\:n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mn3 (\3\:n4 \3\:n1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.55e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.95e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn5 (\1\:Y \1\:B1 \3\:n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.94e-14 ps=8.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.75e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn4 (\1\:Y \1\:B0 \5\:n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.94e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=8e-07 sb=1.4e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mp2 (n2 n0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=7.8e-14 \
        ad=6.24e-14 ps=1.18e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-07 sb=8e-07 sd=160n sca=23.3582 scb=0.018284 scc=0.00243236 \
        m=(1)
mp3 (\3\:Y n1 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.95e-07 sd=160n sca=23.9563 scb=0.0185363 \
        scc=0.00243248 m=(1)
mp5 (\3\:Y \3\:B1 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.9e-07 sd=160n sca=25.2941 \
        scb=0.0199646 scc=0.00243758 m=(1)
mp4 (n3 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.825e-14 ps=1.12e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=29.982 scb=0.0279319 \
        scc=0.00269613 m=(1)
ends OAI2BB2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:12 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB2X2
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X2 A0N A1N B0 B1 VDD VSS Y
mp1 (\10\:n1 \1\:A1N \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=3.01e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=52.067 scb=0.0373106 \
        scc=0.00610613 m=(1)
mp0 (\13\:n0 \4\:A0N \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=3.44e-14 ps=1.18e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.6e-07 sd=160n sca=46.4272 \
        scb=0.0285818 scc=0.00588427 m=(1)
C1 (A0N VSS) capacitor c=5.50107e-17
C2 (B0 VSS) capacitor c=1.72402e-17
C3 (Y VSS) capacitor c=3.54616e-17
C4 (A1N VSS) capacitor c=1.2873e-16
C5 (VDD VSS) capacitor c=1.66073e-16
C6 (B1 VSS) capacitor c=8.4726e-17
C7 (n1 VSS) capacitor c=4.65766e-17
C8 (n0 VSS) capacitor c=5.6244e-17
C9 (n4 VSS) capacitor c=7.95853e-17
C10 (5 VSS) capacitor c=3.14137e-18
C11 (7 VSS) capacitor c=4.39937e-18
C12 (6 VSS) capacitor c=4.42239e-18
C13 (9 VSS) capacitor c=1.50384e-18
C14 (\6\:B0 VSS) capacitor c=8.51079e-17
C15 (\6\:B1 VSS) capacitor c=6.35406e-17
C16 (\5\:B1 VSS) capacitor c=4.53818e-17
C17 (\1\:B0 VSS) capacitor c=5.70578e-17
C18 (\4\:n0 VSS) capacitor c=5.33451e-17
C19 (\6\:n1 VSS) capacitor c=5.57491e-17
C20 (\4\:A0N VSS) capacitor c=2.28545e-17
C21 (\1\:A1N VSS) capacitor c=2.7023e-17
C22 (\1\:B1 VSS) capacitor c=1.07499e-16
C23 (\1\:A0N VSS) capacitor c=2.39614e-17
C24 (\3\:A1N VSS) capacitor c=1.86659e-17
C25 (\2\:B0 VSS) capacitor c=3.74841e-16
C26 (\2\:n0 VSS) capacitor c=3.26942e-16
C27 (\3\:A0N VSS) capacitor c=2.92287e-17
C28 (\2\:A1N VSS) capacitor c=2.91669e-17
C29 (\1\:VDD VSS) capacitor c=1.51877e-17
C30 (\8\:Y VSS) capacitor c=5.8758e-17
C31 (\6\:VDD VSS) capacitor c=3.8009e-17
C32 (\1\:Y VSS) capacitor c=3.68699e-17
C33 (\9\:VDD VSS) capacitor c=3.83623e-17
C34 (\13\:n0 VSS) capacitor c=1.84496e-17
C35 (\13\:VDD VSS) capacitor c=3.95887e-17
C36 (\10\:n1 VSS) capacitor c=5.83172e-17
C37 (\3\:VDD VSS) capacitor c=3.2619e-17
C38 (\7\:n4 VSS) capacitor c=9.40191e-17
C39 (\11\:n0 VSS) capacitor c=5.27752e-17
C40 (\8\:n1 VSS) capacitor c=2.10672e-16
C41 (\2\:n1 VSS) capacitor c=1.33746e-16
C42 (\4\:B1 VSS) capacitor c=2.92255e-17
C43 (\5\:A0N VSS) capacitor c=6.74873e-17
C44 (\7\:n1 VSS) capacitor c=1.94739e-16
C45 (\10\:n0 VSS) capacitor c=6.56151e-17
C46 (\3\:Y VSS) capacitor c=2.83883e-17
C47 (\4\:Y VSS) capacitor c=1.06375e-16
C48 (\5\:Y VSS) capacitor c=1.88292e-16
C49 (\7\:B1 VSS) capacitor c=3.60051e-17
C50 (\2\:n4 VSS) capacitor c=1.72765e-16
C51 (\5\:VDD VSS) capacitor c=3.12176e-17
C52 (\8\:VDD VSS) capacitor c=1.85287e-17
C53 (\12\:VDD VSS) capacitor c=1.15413e-17
Rk2 (\5\:A0N A0N) resistor r=0.1983 c=0
Rk18 (\2\:B0 B0) resistor r=0.01895 c=0
Rk10 (\3\:Y Y) resistor r=0.1229 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.1205 c=0
Rk11 (\3\:Y \4\:Y) resistor r=0.2838 c=0
Rk12 (\4\:Y \5\:Y) resistor r=0.4737 c=0
Rk14 (\4\:Y \9\:Y) resistor r=0.4072 c=0
Rk1 (A1N \4\:A1N) resistor r=0.00411 c=0
Rk32 (\2\:VSS \3\:VSS) resistor r=0.4709 c=0
Rk34 (\3\:VSS \5\:VSS) resistor r=0.1101 c=0
Rk36 (\6\:VSS VSS) resistor r=0.2025 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.3481 c=0
Rk39 (\6\:VSS \12\:VSS) resistor r=0.188 c=0
Rk23 (\2\:VDD \4\:VDD) resistor r=0.2424 c=0
Rk24 (\4\:VDD \5\:VDD) resistor r=0.3681 c=0
Rk25 (\5\:VDD \7\:VDD) resistor r=0.1849 c=0
Rk26 (\5\:VDD \8\:VDD) resistor r=0.3805 c=0
Rk27 (\8\:VDD \10\:VDD) resistor r=0.279 c=0
Rk28 (\8\:VDD \11\:VDD) resistor r=0.05242 c=0
Rk31 (\12\:VDD VDD) resistor r=0.1574 c=0
Rk29 (\11\:VDD \12\:VDD) resistor r=0.3932 c=0
Rk30 (\12\:VDD \14\:VDD) resistor r=0.4195 c=0
Rk16 (\7\:B1 B1) resistor r=0.06822 c=0
Rk3 (\7\:n1 \9\:n1) resistor r=1.4234 c=0
Rk4 (\9\:n1 \11\:n1) resistor r=0.4681 c=0
Rk6 (\2\:n0 \10\:n0) resistor r=0.3619 c=0
Rk7 (\10\:n0 \12\:n0) resistor r=0.2495 c=0
Rk8 (\10\:n0 \14\:n0) resistor r=0.1364 c=0
Rl5 (\2\:A0N \4\:A0N) resistor r=84.3339 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=67.0262 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=3.3229 c=0
Rl24 (\2\:B0 \6\:B0) resistor r=115.362 c=0
Rl16 (\2\:B0 \1\:B0) resistor r=75.6918 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=71.1538 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=53.022 c=0
Rl22 (\4\:B1 \6\:B1) resistor r=59.1794 c=0
Rl21 (\4\:B1 \5\:B1) resistor r=103.331 c=0
Rl20 (\4\:B1 \1\:B1) resistor r=6.3032 c=0
Rl8 (\2\:n1 n1) resistor r=181.926 c=0
Rl12 (\2\:n1 \6\:n1) resistor r=160.771 c=0
Rl13 (\2\:n0 \4\:n0) resistor r=105.483 c=0
Rl6 (\2\:n0 n0) resistor r=92.1028 c=0
Rz14 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz10 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz11 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz1 (\9\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\12\:n0 \11\:n0) resistor r=75 c=0
Rz8 (\2\:n4 \7\:n4) resistor r=75 c=0
Rz5 (\2\:n4 n4) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry4 (\9\:Y \8\:Y) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry10 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry8 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\14\:n0 \13\:n0) resistor r=62 c=0
Rx2 (\3\:A0N \5\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx3 (\7\:n1 \2\:n1) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.09e-13 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\11\:n0 \1\:A0N \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.09e-13 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2_1__rcx (\2\:n4 \2\:n0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.55e-14 ad=4.615e-14 ps=8.7e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.79e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn4 (\5\:Y \2\:B0 \2\:n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=6.045e-14 ps=8.6e-07 pd=9.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (n4 \2\:n1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.57e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn5_1__rcx (\5\:Y \1\:B1 \7\:n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=6.045e-14 ps=8.4e-07 pd=9.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=6.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp2_1__rcx (5 n0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.44e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp3_1__rcx (\1\:Y \6\:n1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.28e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3 (\1\:Y n1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.05e-07 sb=1.075e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp2 (7 \4\:n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=6.825e-14 ps=1.18e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=8.55e-07 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp4_1__rcx (6 \1\:B0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=4.485e-14 ps=1.18e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=6.1e-07 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5_1__rcx (\8\:Y \5\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=4.5e-07 sd=160n sca=12.2157 \
        scb=0.0102564 scc=0.000311508 m=(1)
mp5 (\8\:Y \6\:B1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.335e-06 sb=2.45e-07 sd=160n sca=13.1864 scb=0.011023 \
        scc=0.000312795 m=(1)
mp4 (9 \6\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=1.4e-07 sd=160n sca=14.1519 \
        scb=0.0123146 scc=0.000320502 m=(1)
ends OAI2BB2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:13 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB2X4
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X4 A0N A1N B0 B1 VDD VSS Y
mp1 (\19\:n1 \1\:A1N \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.8434 \
        scb=0.0211629 scc=0.00086948 m=(1)
mp0 (\18\:n0 \1\:A0N \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.6131 \
        scb=0.0139483 scc=0.000653233 m=(1)
mp2_1__rcx (6 n0 \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_1__rcx (\12\:Y \8\:n1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_2__rcx (\12\:Y n1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp2_2__rcx (7 \12\:n0 \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.215e-13 ad=2.34e-14 ps=1.77e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp2_3__rcx (9 \7\:n0 \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.215e-13 ad=3.51e-14 ps=1.77e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_3__rcx (\10\:Y \15\:n1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3 (\10\:Y \10\:n1 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp2 (10 \13\:n0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=8.58e-14 ps=1.75e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.945e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp4_1__rcx (11 \1\:B0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.655e-14 ps=1.75e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=1.68e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5_1__rcx (\3\:Y \10\:B1 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=1.3455e-13 ps=1.07e-06 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-06 sb=1.49e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5_2__rcx (\3\:Y \1\:B1 12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=1.3455e-13 ps=1.05e-06 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.1e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp4_2__rcx (12 \11\:B0 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.265e-14 ps=1.75e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.2e-07 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp4_3__rcx (13 \5\:B0 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.07e-14 ps=1.75e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.55e-07 sd=160n sca=16.4245 scb=0.0146155 \
        scc=0.00118862 m=(1)
mp5_3__rcx (\1\:Y \17\:B1 13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=6.24e-14 ps=1.04e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.8e-07 sd=160n sca=16.9872 scb=0.0148857 \
        scc=0.00118877 m=(1)
mp5 (\1\:Y \12\:B1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.75e-07 sd=160n sca=18.4199 scb=0.0164999 scc=0.00119548 m=(1)
mp4 (8 \14\:B0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.81e-14 ad=2.34e-14 ps=1.65e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.7e-07 sd=160n sca=19.996 scb=0.0190983 \
        scc=0.00123425 m=(1)
C1 (Y VSS) capacitor c=4.11482e-17
C2 (VDD VSS) capacitor c=3.64434e-16
C3 (A0N VSS) capacitor c=5.98442e-17
C4 (B0 VSS) capacitor c=4.27057e-17
C5 (A1N VSS) capacitor c=9.22423e-17
C6 (n1 VSS) capacitor c=7.32797e-17
C7 (n0 VSS) capacitor c=9.50593e-17
C8 (n4 VSS) capacitor c=1.74343e-15
C9 (6 VSS) capacitor c=2.26562e-18
C10 (7 VSS) capacitor c=2.72975e-18
C11 (9 VSS) capacitor c=3.41961e-18
C12 (10 VSS) capacitor c=5.80348e-18
C13 (11 VSS) capacitor c=3.46881e-18
C14 (12 VSS) capacitor c=5.49378e-18
C15 (13 VSS) capacitor c=4.25442e-18
C16 (8 VSS) capacitor c=7.05326e-19
C17 (\14\:B0 VSS) capacitor c=6.41813e-17
C18 (\12\:B1 VSS) capacitor c=7.60743e-17
C19 (\17\:B1 VSS) capacitor c=4.28995e-17
C20 (\5\:B0 VSS) capacitor c=4.16039e-17
C21 (\11\:B0 VSS) capacitor c=3.91064e-17
C22 (\1\:B1 VSS) capacitor c=3.68188e-17
C23 (\10\:B1 VSS) capacitor c=3.67286e-17
C24 (\1\:B0 VSS) capacitor c=5.2395e-17
C25 (\13\:n0 VSS) capacitor c=4.62676e-17
C26 (\10\:n1 VSS) capacitor c=4.63857e-17
C27 (\15\:n1 VSS) capacitor c=5.85091e-17
C28 (\7\:n0 VSS) capacitor c=5.38929e-17
C29 (\12\:n0 VSS) capacitor c=6.3289e-17
C30 (\8\:n1 VSS) capacitor c=7.58404e-17
C31 (\1\:A0N VSS) capacitor c=4.95462e-17
C32 (\1\:A1N VSS) capacitor c=4.55796e-17
C33 (\3\:A0N VSS) capacitor c=4.34236e-17
C34 (\3\:A1N VSS) capacitor c=3.28954e-17
C35 (\3\:B1 VSS) capacitor c=3.70937e-16
C36 (\2\:n1 VSS) capacitor c=3.72092e-16
C37 (\6\:n1 VSS) capacitor c=2.14421e-17
C38 (\4\:n0 VSS) capacitor c=3.48178e-17
C39 (\2\:A0N VSS) capacitor c=3.81369e-17
C40 (\2\:A1N VSS) capacitor c=3.26536e-17
C41 (\11\:VDD VSS) capacitor c=2.73956e-17
C42 (\1\:Y VSS) capacitor c=1.06969e-16
C43 (\13\:VDD VSS) capacitor c=2.7002e-17
C44 (\3\:Y VSS) capacitor c=1.43623e-16
C45 (\15\:VDD VSS) capacitor c=3.51555e-17
C46 (\10\:Y VSS) capacitor c=1.01028e-16
C47 (\17\:VDD VSS) capacitor c=3.17601e-17
C48 (\12\:Y VSS) capacitor c=9.8001e-17
C49 (\19\:VDD VSS) capacitor c=4.83059e-17
C50 (\18\:n0 VSS) capacitor c=6.43729e-17
C51 (\21\:VDD VSS) capacitor c=3.90929e-17
C52 (\19\:n1 VSS) capacitor c=8.10263e-17
C53 (\1\:VDD VSS) capacitor c=5.41731e-17
C54 (\6\:Y VSS) capacitor c=4.04724e-16
C55 (\20\:n0 VSS) capacitor c=5.02323e-17
C56 (\17\:n1 VSS) capacitor c=2.03298e-16
C57 (\2\:n0 VSS) capacitor c=6.99585e-16
C58 (\2\:B0 VSS) capacitor c=5.80839e-16
C59 (\11\:B1 VSS) capacitor c=1.57164e-17
C60 (\2\:B1 VSS) capacitor c=1.1183e-17
C61 (\9\:B1 VSS) capacitor c=2.30627e-17
C62 (\4\:A1N VSS) capacitor c=4.09034e-17
C63 (\4\:A0N VSS) capacitor c=5.66469e-17
C64 (\17\:n0 VSS) capacitor c=8.25905e-17
C65 (\16\:n1 VSS) capacitor c=1.66522e-16
C66 (\18\:B1 VSS) capacitor c=1.07914e-16
C67 (\5\:Y VSS) capacitor c=1.08687e-16
C68 (\3\:VDD VSS) capacitor c=1.95869e-17
C69 (\4\:VDD VSS) capacitor c=2.32158e-17
C70 (\6\:VDD VSS) capacitor c=4.91448e-17
C71 (\7\:VDD VSS) capacitor c=4.42076e-17
C72 (\8\:VDD VSS) capacitor c=1.77376e-17
C73 (\10\:VDD VSS) capacitor c=2.45353e-17
Rk12 (\2\:Y \4\:Y) resistor r=0.6698 c=0
Rk16 (\5\:Y Y) resistor r=0.02575 c=0
Rk14 (\5\:Y \6\:Y) resistor r=0.6799 c=0
Rk13 (\4\:Y \5\:Y) resistor r=0.4471 c=0
Rk17 (Y \11\:Y) resistor r=0.2404 c=0
Rk18 (\11\:Y \13\:Y) resistor r=0.5364 c=0
Rk10 (\18\:B1 B1) resistor r=0.009408 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.1002 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.3762 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.1755 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.3227 c=0
Rk37 (\6\:VDD \7\:VDD) resistor r=0.4505 c=0
Rk38 (\7\:VDD \8\:VDD) resistor r=0.3209 c=0
Rk39 (\8\:VDD \9\:VDD) resistor r=0.1077 c=0
Rk41 (\10\:VDD VDD) resistor r=0.1577 c=0
Rk40 (\9\:VDD \10\:VDD) resistor r=0.3939 c=0
Rk42 (\3\:VDD \12\:VDD) resistor r=0.1035 c=0
Rk43 (\4\:VDD \14\:VDD) resistor r=0.1035 c=0
Rk44 (\6\:VDD \16\:VDD) resistor r=0.04337 c=0
Rk45 (\7\:VDD \18\:VDD) resistor r=0.1035 c=0
Rk46 (\8\:VDD \20\:VDD) resistor r=0.2596 c=0
Rk47 (\10\:VDD \22\:VDD) resistor r=0.2364 c=0
Rk2 (A0N \4\:A0N) resistor r=0.1808 c=0
Rk21 (B0 \2\:B0) resistor r=0.04362 c=0
Rk48 (\2\:VSS \3\:VSS) resistor r=0.6527 c=0
Rk49 (\3\:VSS \4\:VSS) resistor r=0.4557 c=0
Rk53 (\4\:VSS \8\:VSS) resistor r=0.1077 c=0
Rk55 (\9\:VSS VSS) resistor r=0.1401 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.4115 c=0
Rk60 (\9\:VSS \19\:VSS) resistor r=0.2323 c=0
Rk1 (A1N \4\:A1N) resistor r=0.06631 c=0
Rk5 (\16\:n1 \18\:n1) resistor r=1.2382 c=0
Rk6 (\18\:n1 \20\:n1) resistor r=0.6321 c=0
Rk3 (\17\:n0 \19\:n0) resistor r=0.4471 c=0
Rk4 (\17\:n0 \21\:n0) resistor r=0.2298 c=0
Rl51 (\3\:B1 \12\:B1) resistor r=120.387 c=0
Rl55 (\3\:B1 \17\:B1) resistor r=90.1797 c=0
Rl40 (\3\:B1 \8\:B1) resistor r=3.9152 c=0
Rl34 (\2\:B1 \1\:B1) resistor r=40.1923 c=0
Rl35 (\2\:B1 \3\:B1) resistor r=43.2713 c=0
Rl44 (\2\:B1 \11\:B1) resistor r=46.3175 c=0
Rl42 (\9\:B1 \10\:B1) resistor r=43.1761 c=0
Rl41 (\9\:B1 \8\:B1) resistor r=21.0032 c=0
Rl43 (\9\:B1 \11\:B1) resistor r=50.1411 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=56.461 c=0
Rl57 (\2\:B0 \14\:B0) resistor r=24.7951 c=0
Rl45 (\2\:B0 \5\:B0) resistor r=55.7471 c=0
Rl50 (\2\:B0 \11\:B0) resistor r=34.3295 c=0
Rl31 (\2\:B0 \1\:B0) resistor r=37.477 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=87.6365 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=53.0211 c=0
Rl23 (\2\:n1 \10\:n1) resistor r=137.695 c=0
Rl27 (\2\:n1 \15\:n1) resistor r=110.513 c=0
Rl10 (\2\:n1 n1) resistor r=99.7951 c=0
Rl16 (\2\:n1 \8\:n1) resistor r=114.969 c=0
Rl14 (\2\:n1 \6\:n1) resistor r=9.3321 c=0
Rl28 (\2\:n0 \13\:n0) resistor r=37.3411 c=0
Rl18 (\2\:n0 \7\:n0) resistor r=69.2087 c=0
Rl22 (\2\:n0 \12\:n0) resistor r=28.079 c=0
Rl5 (\2\:n0 n0) resistor r=161.516 c=0
Rl7 (\2\:n0 \4\:n0) resistor r=158.53 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \9\:VDD) resistor r=6.25 c=0
Rz23 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz2 (\18\:n1 \17\:n1) resistor r=75 c=0
Rz1 (\21\:n0 \20\:n0) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=62 c=0
Ry4 (\4\:Y \3\:Y) resistor r=62 c=0
Ry5 (\11\:Y \10\:Y) resistor r=62 c=0
Ry6 (\13\:Y \12\:Y) resistor r=62 c=0
Ry7 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry8 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry9 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry10 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry12 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry2 (\20\:n1 \19\:n1) resistor r=62 c=0
Ry1 (\19\:n0 \18\:n0) resistor r=62 c=0
Rx10 (\18\:B1 \8\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx4 (\16\:n1 \6\:n1) resistor r=45 c=0
Rx3 (\17\:n0 \4\:n0) resistor r=45 c=0
mn1 (\17\:n1 \3\:A1N \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=3.64e-14 ps=9.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0 (\20\:n0 \3\:A0N \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=5.72e-14 ps=9.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2.2e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (n4 \2\:n0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=4.323e-14 ps=1.04e-06 pd=8.525e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn3_1__rcx (n4 \2\:n1 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=4.355e-14 ps=1.04e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn4_1__rcx (\6\:Y \2\:B0 n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.518e-14 ad=5.298e-14 ps=8.675e-07 pd=9.275e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn5_1__rcx (\6\:Y \3\:B1 n4 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=5.298e-14 ps=8.55e-07 pd=9.275e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
ends OAI2BB2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:14 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI2BB2XL
// View name: extracted

simulator lang=spectre

subckt OAI2BB2XL A0N A1N B0 B1 VDD VSS Y
mp1 (\7\:n1 \1\:A1N \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.45e-07 sd=160n sca=21.2082 \
        scb=0.024206 scc=0.000913232 m=(1)
mp0 (\8\:n0 \1\:A0N \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.16e-14 ps=7.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.4e-07 sd=160n sca=15.1467 \
        scb=0.0140576 scc=0.000405776 m=(1)
mp2 (n2 n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.6631 scb=0.00766851 \
        scc=8.4038e-05 m=(1)
mp3 (\3\:Y n1 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.5e-07 sd=160n sca=11.0775 scb=0.00792476 \
        scc=8.42509e-05 m=(1)
mp5 (\3\:Y \1\:B1 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.45e-07 sd=160n sca=12.6898 \
        scb=0.00990074 scc=9.48225e-05 m=(1)
mp4 (n3 \3\:B0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=14.5245 \
        scb=0.0130308 scc=0.000155148 m=(1)
C1 (A0N VSS) capacitor c=1.03316e-16
C2 (B0 VSS) capacitor c=5.37853e-17
C3 (VDD VSS) capacitor c=1.61097e-16
C4 (A1N VSS) capacitor c=7.24798e-17
C5 (n1 VSS) capacitor c=1.14538e-16
C6 (n0 VSS) capacitor c=9.26058e-17
C7 (n4 VSS) capacitor c=5.86839e-17
C8 (n3 VSS) capacitor c=6.6552e-18
C9 (\3\:B0 VSS) capacitor c=6.7608e-17
C10 (\1\:B1 VSS) capacitor c=7.5604e-17
C11 (\1\:A0N VSS) capacitor c=4.73899e-17
C12 (\1\:A1N VSS) capacitor c=3.24887e-17
C13 (\1\:B0 VSS) capacitor c=4.25401e-17
C14 (\3\:B1 VSS) capacitor c=4.6971e-17
C15 (\2\:n1 VSS) capacitor c=5.09694e-17
C16 (\3\:n0 VSS) capacitor c=3.29351e-17
C17 (\3\:A0N VSS) capacitor c=3.54066e-17
C18 (\3\:A1N VSS) capacitor c=4.53189e-17
C19 (\4\:B0 VSS) capacitor c=1.22587e-17
C20 (\2\:B1 VSS) capacitor c=5.91522e-17
C21 (\3\:n1 VSS) capacitor c=2.6058e-17
C22 (\2\:n0 VSS) capacitor c=4.13642e-17
C23 (\2\:A0N VSS) capacitor c=3.61426e-17
C24 (\2\:A1N VSS) capacitor c=3.97249e-17
C25 (\7\:VDD VSS) capacitor c=3.80073e-17
C26 (\3\:Y VSS) capacitor c=1.33433e-16
C27 (\1\:VDD VSS) capacitor c=1.54667e-17
C28 (\8\:n0 VSS) capacitor c=3.27551e-17
C29 (\9\:VDD VSS) capacitor c=2.56133e-17
C30 (\7\:n1 VSS) capacitor c=6.53433e-17
C31 (\1\:Y VSS) capacitor c=1.09206e-16
C32 (\3\:n4 VSS) capacitor c=1.91291e-16
C33 (\5\:n4 VSS) capacitor c=1.43478e-16
C34 (\6\:n0 VSS) capacitor c=5.984e-17
C35 (\5\:n1 VSS) capacitor c=2.21956e-16
C36 (\2\:B0 VSS) capacitor c=4.51078e-17
C37 (\4\:A1N VSS) capacitor c=5.24448e-17
C38 (\4\:A0N VSS) capacitor c=2.53737e-17
C39 (\4\:n0 VSS) capacitor c=4.04086e-17
C40 (\5\:n0 VSS) capacitor c=6.67764e-17
C41 (\4\:n1 VSS) capacitor c=2.31455e-16
C42 (\4\:B1 VSS) capacitor c=1.25519e-16
C43 (\5\:B0 VSS) capacitor c=4.08622e-17
C44 (\3\:VDD VSS) capacitor c=2.05619e-17
C45 (\5\:VDD VSS) capacitor c=1.14052e-17
C46 (\6\:VDD VSS) capacitor c=1.16752e-17
Rk11 (\2\:Y Y) resistor r=0.715 c=0
Rk12 (Y \4\:Y) resistor r=0.003012 c=0
Rk10 (\4\:B1 B1) resistor r=0.003 c=0
Rk22 (\2\:VSS \4\:VSS) resistor r=0.3339 c=0
Rk24 (\5\:VSS VSS) resistor r=0.1124 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.3885 c=0
Rk25 (\5\:VSS \7\:VSS) resistor r=0.07381 c=0
Rk4 (\4\:A0N A0N) resistor r=0.009001 c=0
Rk15 (B0 \5\:B0) resistor r=0.1827 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.2273 c=0
Rk17 (\3\:VDD \5\:VDD) resistor r=0.1026 c=0
Rk19 (\6\:VDD VDD) resistor r=0.1324 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.3684 c=0
Rk20 (\3\:VDD \8\:VDD) resistor r=0.5283 c=0
Rk21 (\6\:VDD \10\:VDD) resistor r=0.2974 c=0
Rk1 (A1N \4\:A1N) resistor r=0.165 c=0
Rk8 (\4\:n1 \6\:n1) resistor r=1.6729 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.5418 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.267 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.3793 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.1828 c=0
Rk13 (\2\:n4 \4\:n4) resistor r=0.5383 c=0
Rk14 (\4\:n4 \6\:n4) resistor r=1.0234 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=116.076 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=131.461 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=149.175 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=35.7134 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=124.51 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=166.77 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=4.5402 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=41.0764 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=150.692 c=0
Rl7 (n1 \2\:n1) resistor r=273.077 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=37.2302 c=0
Rl5 (n0 \2\:n0) resistor r=203.4 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=149.233 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz6 (\5\:n4 \6\:n4) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx4 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\5\:n1 \3\:A1N \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.465e-14 ps=1.32e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\6\:n0 \3\:A0N \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=3.19e-14 ps=1.32e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2.2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:n4 \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=3.698e-14 ps=1.01e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.005e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn3 (\3\:n4 \2\:n1 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.32e-14 ps=1.01e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=6e-07 sd=160n sca=8.70265 scb=0.00681258 \
        scc=0.000126945 m=(1)
mn5 (\1\:Y \3\:B1 \3\:n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.95e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn4 (\1\:Y \1\:B0 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.045e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
ends OAI2BB2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:16 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI31X1
// View name: extracted

simulator lang=spectre

subckt OAI31X1 A0 A1 A2 B0 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=15.9959 \
        scb=0.0151266 scc=0.000303017 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.07e-14 ps=9e-07 pd=1.04e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.2e-07 sd=160n sca=14.532 scb=0.0121946 \
        scc=0.000242813 m=(1)
mp2 (\3\:Y \3\:A2 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.07e-14 \
        ad=6.24e-14 ps=1.04e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.2e-07 sb=3.45e-07 sd=160n sca=14.1757 scb=0.0114808 \
        scc=0.000235907 m=(1)
mp3 (\3\:Y \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.4e-07 sd=160n sca=16.9977 \
        scb=0.017051 scc=0.00037561 m=(1)
C1 (B0 VSS) capacitor c=8.33932e-17
C2 (A0 VSS) capacitor c=4.21916e-17
C3 (A2 VSS) capacitor c=1.20969e-16
C4 (A1 VSS) capacitor c=4.54516e-17
C5 (Y VSS) capacitor c=8.9617e-17
C6 (VDD VSS) capacitor c=8.13337e-17
C7 (n0 VSS) capacitor c=8.30946e-17
C8 (n2 VSS) capacitor c=2.06673e-18
C9 (\3\:B0 VSS) capacitor c=3.9126e-17
C10 (\3\:A2 VSS) capacitor c=5.95038e-17
C11 (\1\:A1 VSS) capacitor c=1.04506e-16
C12 (\1\:A0 VSS) capacitor c=9.5475e-17
C13 (\1\:B0 VSS) capacitor c=4.96643e-17
C14 (\1\:A2 VSS) capacitor c=5.42172e-17
C15 (\3\:A1 VSS) capacitor c=4.38156e-17
C16 (\4\:A0 VSS) capacitor c=3.72809e-17
C17 (\2\:B0 VSS) capacitor c=4.32512e-17
C18 (\2\:A2 VSS) capacitor c=5.58261e-17
C19 (\2\:A1 VSS) capacitor c=6.54818e-17
C20 (\3\:A0 VSS) capacitor c=1.33714e-17
C21 (\1\:VDD VSS) capacitor c=4.96033e-17
C22 (\3\:Y VSS) capacitor c=1.27522e-16
C23 (\6\:VDD VSS) capacitor c=3.73107e-17
C24 (\1\:Y VSS) capacitor c=2.76202e-17
C25 (\3\:n0 VSS) capacitor c=7.19974e-17
C26 (\2\:A0 VSS) capacitor c=5.10448e-17
C27 (\5\:A0 VSS) capacitor c=2.62904e-17
C28 (\4\:A1 VSS) capacitor c=5.6259e-17
C29 (\5\:B0 VSS) capacitor c=4.12543e-17
C30 (\4\:VDD VSS) capacitor c=2.46747e-17
C31 (\5\:VDD VSS) capacitor c=7.50264e-18
Rk7 (B0 \5\:B0) resistor r=0.06633 c=0
Rk1 (\5\:A0 A0) resistor r=0.1432 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.1212 c=0
Rk16 (\5\:VSS VSS) resistor r=0.03716 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2137 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2228 c=0
Rk3 (\4\:A2 A2) resistor r=0.003 c=0
Rk2 (A1 \4\:A1) resistor r=0.225 c=0
Rk8 (\2\:Y Y) resistor r=0.07668 c=0
Rk9 (Y \4\:Y) resistor r=0.8007 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.4069 c=0
Rk12 (\5\:VDD VDD) resistor r=0.08731 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.1628 c=0
Rk13 (\5\:VDD \7\:VDD) resistor r=0.264 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.4289 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=37.6374 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=169.231 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=178.356 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=51.385 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=4.5402 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=76.098 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=122.252 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=148.769 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=56.461 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (n0 \2\:n0) resistor r=37.5 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=20.6667 c=0
Rx4 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \4\:A0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:n0 \3\:A1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (n0 \1\:A2 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.55e-14 ps=8.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.55e-14 \
        ad=3.64e-14 ps=8.7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=7.8e-07 \
        sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 scc=9.84911e-05 \
        m=(1)
ends OAI31X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:17 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI31X2
// View name: extracted

simulator lang=spectre

subckt OAI31X2 A0 A1 A2 B0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.505e-06 sd=160n sca=15.7135 \
        scb=0.0146768 scc=0.000444335 m=(1)
mp1_1__rcx (2 \1\:A1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=2.34e-14 ps=1.31e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-06 sd=160n sca=14.3102 \
        scb=0.0124442 scc=0.000417178 m=(1)
mp2_1__rcx (\6\:Y \5\:A2 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.24e-14 ps=1.31e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.09e-06 sd=160n sca=12.6509 \
        scb=0.0108992 scc=0.000412427 m=(1)
mp2 (\6\:Y \1\:A2 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=7.6e-07 sb=8.85e-07 sd=160n sca=12.3656 scb=0.0108222 \
        scc=0.000412413 m=(1)
mp1 (6 \4\:A1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.07e-14 \
        ad=4.485e-14 ps=1.04e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.2e-07 sb=7.25e-07 sd=160n sca=12.3656 scb=0.0108222 \
        scc=0.000412413 m=(1)
mp0 (7 \6\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.07e-14 ps=1.1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=5.5e-07 sd=160n sca=12.6936 \
        scb=0.0109155 scc=0.000412431 m=(1)
mp3 (\4\:Y \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=3.45e-07 sd=160n sca=13.5897 \
        scb=0.0115632 scc=0.000413321 m=(2)
C1 (A0 VSS) capacitor c=4.83815e-16
C2 (VDD VSS) capacitor c=1.03847e-16
C3 (A1 VSS) capacitor c=1.47342e-17
C4 (B0 VSS) capacitor c=6.98954e-17
C5 (Y VSS) capacitor c=1.68087e-17
C6 (A2 VSS) capacitor c=5.87288e-17
C7 (n0 VSS) capacitor c=2.98568e-16
C8 (2 VSS) capacitor c=9.07463e-20
C9 (4 VSS) capacitor c=9.96283e-20
C10 (6 VSS) capacitor c=4.04974e-18
C11 (7 VSS) capacitor c=4.86917e-18
C12 (\6\:A0 VSS) capacitor c=6.42477e-17
C13 (\4\:A1 VSS) capacitor c=7.08329e-17
C14 (\1\:A2 VSS) capacitor c=3.5653e-17
C15 (\5\:A2 VSS) capacitor c=2.98127e-17
C16 (\1\:A1 VSS) capacitor c=7.89405e-17
C17 (\1\:A0 VSS) capacitor c=8.10425e-17
C18 (\1\:B0 VSS) capacitor c=6.8658e-17
C19 (\2\:A2 VSS) capacitor c=3.06313e-17
C20 (\2\:A1 VSS) capacitor c=3.50224e-16
C21 (\1\:VDD VSS) capacitor c=1.12561e-16
C22 (\4\:Y VSS) capacitor c=9.73737e-17
C23 (\6\:Y VSS) capacitor c=6.63777e-17
C24 (\9\:VDD VSS) capacitor c=2.79916e-17
C25 (\1\:Y VSS) capacitor c=7.42012e-17
C26 (\3\:A2 VSS) capacitor c=1.06586e-16
C27 (\3\:B0 VSS) capacitor c=7.62188e-17
C28 (\7\:A2 VSS) capacitor c=6.53026e-17
C29 (\3\:Y VSS) capacitor c=6.93534e-17
C30 (\7\:B0 VSS) capacitor c=2.79612e-17
C31 (\5\:VDD VSS) capacitor c=2.73107e-17
C32 (\6\:VDD VSS) capacitor c=1.3573e-17
Rk19 (\1\:VDD \5\:VDD) resistor r=0.1748 c=0
Rk21 (\6\:VDD VDD) resistor r=0.1096 c=0
Rk20 (\5\:VDD \6\:VDD) resistor r=0.3899 c=0
Rk23 (\6\:VDD \10\:VDD) resistor r=0.291 c=0
Rk3 (\2\:A1 A1) resistor r=0.02427 c=0
Rk24 (VSS \1\:VSS) resistor r=0.1321 c=0
Rk27 (\1\:VSS \6\:VSS) resistor r=0.1015 c=0
Rk13 (\7\:B0 B0) resistor r=0.05078 c=0
Rk9 (\3\:Y Y) resistor r=0.01229 c=0
Rk7 (\2\:Y \3\:Y) resistor r=0.5074 c=0
Rk8 (\3\:Y \5\:Y) resistor r=0.02358 c=0
Rk10 (\5\:Y \7\:Y) resistor r=0.5598 c=0
Rk4 (A2 \7\:A2) resistor r=0.02393 c=0
Rl13 (A0 \6\:A0) resistor r=101.06 c=0
Rl1 (A0 \1\:A0) resistor r=111.004 c=0
Rl10 (\2\:A1 \4\:A1) resistor r=87.2302 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=87.2302 c=0
Rl15 (\3\:B0 \1\:B0) resistor r=69.0037 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=21.9779 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=77.1158 c=0
Rl6 (\3\:A2 \2\:A2) resistor r=58.1371 c=0
Rz9 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Ry5 (\10\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry1 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Rx6 (\7\:B0 \1\:B0) resistor r=45 c=0
Rx3 (\7\:A2 \2\:A2) resistor r=45 c=0
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.59e-06 sb=3.45e-07 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(2)
mn2_1__rcx (n0 \3\:A2 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.26e-14 ad=4.16e-14 ps=1.55e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.325e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(2)
mn0 (n0 A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=9.26e-14 \
        ad=4.42e-14 ps=1.55e-06 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.795e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(2)
mn1_1__rcx (n0 \2\:A1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.26e-14 ad=4.16e-14 ps=1.55e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.53e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(2)
ends OAI31X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:18 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI31X4
// View name: extracted

simulator lang=spectre

subckt OAI31X4 A0 A1 A2 B0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.9706 scb=0.0178952 \
        scc=0.000725233 m=(1)
mp1_1__rcx (2 \1\:A1 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=2.34e-14 ps=1.42e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.0776 scb=0.014648 \
        scc=0.000659357 m=(1)
mp2_1__rcx (\11\:Y \5\:A2 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=6.24e-14 ps=1.42e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=13.8386 scb=0.012255 \
        scc=0.000647525 m=(1)
mp2_2__rcx (\11\:Y \1\:A2 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (3 \4\:A1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (8 \9\:A0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=8.58e-14 ps=1.11e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (7 \4\:A0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (7 \9\:A1 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=1.925e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2_3__rcx (\13\:Y \11\:A2 10 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86e-06 sb=1.665e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (\13\:Y \12\:A2 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.46e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1 (9 \10\:A1 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.655e-14 \
        ad=8.58e-14 ps=1.07e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.195e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0 (11 \13\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=5.655e-14 ps=1.19e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (\1\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
C1 (Y VSS) capacitor c=2.94569e-17
C2 (A2 VSS) capacitor c=4.8302e-16
C3 (A0 VSS) capacitor c=2.56677e-17
C4 (VDD VSS) capacitor c=1.95475e-16
C5 (A1 VSS) capacitor c=8.38342e-16
C6 (n0 VSS) capacitor c=5.39437e-16
C7 (5 VSS) capacitor c=8.75165e-18
C8 (3 VSS) capacitor c=2.23753e-18
C9 (8 VSS) capacitor c=1.00673e-17
C10 (7 VSS) capacitor c=7.2061e-18
C11 (10 VSS) capacitor c=9.57681e-18
C12 (9 VSS) capacitor c=9.83567e-18
C13 (11 VSS) capacitor c=5.54553e-18
C14 (\13\:A0 VSS) capacitor c=4.32839e-17
C15 (\10\:A1 VSS) capacitor c=5.90175e-17
C16 (\12\:A2 VSS) capacitor c=3.70303e-17
C17 (\11\:A2 VSS) capacitor c=2.71769e-17
C18 (\9\:A1 VSS) capacitor c=4.5856e-17
C19 (\4\:A0 VSS) capacitor c=3.13434e-17
C20 (\9\:A0 VSS) capacitor c=2.39627e-17
C21 (\4\:A1 VSS) capacitor c=7.53492e-17
C22 (\1\:A2 VSS) capacitor c=6.39519e-17
C23 (\5\:A2 VSS) capacitor c=2.28873e-17
C24 (\1\:A1 VSS) capacitor c=8.3543e-17
C25 (\1\:A0 VSS) capacitor c=6.64063e-17
C26 (\1\:B0 VSS) capacitor c=3.37148e-16
C27 (\2\:A0 VSS) capacitor c=8.58735e-16
C28 (\1\:VDD VSS) capacitor c=1.81199e-16
C29 (\1\:Y VSS) capacitor c=2.05152e-16
C30 (\13\:Y VSS) capacitor c=2.03136e-17
C31 (\14\:VDD VSS) capacitor c=3.56602e-17
C32 (\11\:Y VSS) capacitor c=1.3736e-16
C33 (\16\:VDD VSS) capacitor c=3.57007e-17
C34 (\4\:VDD VSS) capacitor c=4.19594e-17
C35 (\4\:Y VSS) capacitor c=1.52726e-16
C36 (\2\:A2 VSS) capacitor c=3.56349e-17
C37 (\10\:A2 VSS) capacitor c=2.22957e-17
C38 (\10\:Y VSS) capacitor c=1.80775e-16
C39 (\7\:VDD VSS) capacitor c=3.14965e-17
C40 (\9\:VDD VSS) capacitor c=1.60605e-17
Rk20 (\1\:B0 B0) resistor r=0.009285 c=0
Rk12 (\1\:Y Y) resistor r=0.02446 c=0
Rk13 (Y \4\:Y) resistor r=0.3546 c=0
Rk16 (\1\:Y \10\:Y) resistor r=0.6786 c=0
Rk17 (\10\:Y \12\:Y) resistor r=1.0047 c=0
Rk18 (\10\:Y \14\:Y) resistor r=0.05744 c=0
Rk9 (\2\:A0 A0) resistor r=0.01764 c=0
Rk32 (\1\:VDD \7\:VDD) resistor r=0.6686 c=0
Rk33 (\7\:VDD \8\:VDD) resistor r=0.1602 c=0
Rk35 (\9\:VDD VDD) resistor r=0.08475 c=0
Rk34 (\8\:VDD \9\:VDD) resistor r=0.4659 c=0
Rk38 (\7\:VDD \15\:VDD) resistor r=0.2226 c=0
Rk39 (\9\:VDD \17\:VDD) resistor r=0.3056 c=0
Rk49 (\3\:VSS VSS) resistor r=0.1073 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.2679 c=0
Rl6 (\2\:A2 A2) resistor r=71.9912 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=65.3625 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=67.2856 c=0
Rl22 (\10\:A2 A2) resistor r=77.3125 c=0
Rl24 (\10\:A2 \12\:A2) resistor r=100.426 c=0
Rl23 (\10\:A2 \11\:A2) resistor r=35.772 c=0
Rl28 (\2\:A0 \13\:A0) resistor r=26.3736 c=0
Rl12 (\2\:A0 \4\:A0) resistor r=68.032 c=0
Rl16 (\2\:A0 \9\:A0) resistor r=34.3295 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=39.6174 c=0
Rl25 (A1 \10\:A1) resistor r=114.153 c=0
Rl19 (A1 \9\:A1) resistor r=56.8681 c=0
Rl10 (A1 \4\:A1) resistor r=56.461 c=0
Rl3 (A1 \1\:A1) resistor r=114.153 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Ry3 (\12\:Y \11\:Y) resistor r=31 c=0
Ry4 (\14\:Y \13\:Y) resistor r=31 c=0
Ry8 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry9 (\17\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=7.75 c=0
Ry11 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (n0 \2\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.485e-14 ps=1.43e-06 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn1_1__rcx (n0 A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2 (n0 A2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=8.54e-14 \
        ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn3_1__rcx (\4\:Y \1\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
ends OAI31X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:19 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI31XL
// View name: extracted

simulator lang=spectre

subckt OAI31XL A0 A1 A2 B0 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.05e-07 sd=160n sca=16.0188 \
        scb=0.015713 scc=0.000313368 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6e-07 sd=160n sca=14.06 scb=0.0122317 \
        scc=0.00023485 m=(1)
mp2 (\3\:Y \1\:A2 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.95e-07 sd=160n sca=12.9232 \
        scb=0.0102558 scc=0.000221094 m=(1)
mp3 (\3\:Y \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.4e-07 sd=160n sca=14.0029 \
        scb=0.0121262 scc=0.000233621 m=(1)
C1 (B0 VSS) capacitor c=1.31791e-16
C2 (A0 VSS) capacitor c=5.71047e-17
C3 (Y VSS) capacitor c=7.91239e-17
C4 (A2 VSS) capacitor c=7.58989e-17
C5 (A1 VSS) capacitor c=1.60082e-17
C6 (VDD VSS) capacitor c=1.01819e-16
C7 (n0 VSS) capacitor c=6.53882e-17
C8 (\1\:B0 VSS) capacitor c=4.05708e-17
C9 (\1\:A2 VSS) capacitor c=5.50587e-17
C10 (\1\:A1 VSS) capacitor c=5.3828e-17
C11 (\1\:A0 VSS) capacitor c=7.8497e-17
C12 (\3\:B0 VSS) capacitor c=3.30888e-17
C13 (\3\:A2 VSS) capacitor c=4.05185e-17
C14 (\3\:A1 VSS) capacitor c=6.12855e-17
C15 (\4\:A0 VSS) capacitor c=3.13973e-17
C16 (\2\:B0 VSS) capacitor c=4.83348e-17
C17 (\2\:A2 VSS) capacitor c=5.84417e-17
C18 (\2\:A1 VSS) capacitor c=6.72111e-17
C19 (\3\:A0 VSS) capacitor c=1.16046e-17
C20 (\1\:VDD VSS) capacitor c=3.43504e-17
C21 (\3\:Y VSS) capacitor c=7.44147e-17
C22 (\6\:VDD VSS) capacitor c=1.74867e-17
C23 (\1\:Y VSS) capacitor c=6.73446e-17
C24 (\3\:n0 VSS) capacitor c=7.84467e-17
C25 (\2\:A0 VSS) capacitor c=3.7137e-17
C26 (\4\:A1 VSS) capacitor c=7.6366e-17
C27 (\4\:A2 VSS) capacitor c=4.52873e-17
C28 (\4\:VDD VSS) capacitor c=2.39671e-17
C29 (\5\:VDD VSS) capacitor c=5.75697e-18
Rk1 (\5\:A0 A0) resistor r=0.002987 c=0
Rk6 (\2\:Y Y) resistor r=0.5268 c=0
Rk7 (Y \4\:Y) resistor r=0.2612 c=0
Rk3 (A2 \4\:A2) resistor r=0.1105 c=0
Rk2 (\4\:A1 A1) resistor r=0.0239 c=0
Rk13 (\3\:VSS VSS) resistor r=0.2349 c=0
Rk14 (VSS \5\:VSS) resistor r=0.181 c=0
Rk15 (\3\:VSS \7\:VSS) resistor r=0.1774 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.4422 c=0
Rk10 (\5\:VDD VDD) resistor r=0.07956 c=0
Rk9 (\4\:VDD \5\:VDD) resistor r=0.2198 c=0
Rk11 (\5\:VDD \7\:VDD) resistor r=0.2712 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.4883 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=162.23 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=96.8456 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=213.83 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=104.649 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.6709 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=158.384 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=100.692 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=229.538 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx4 (\2\:B0 B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (n0 \4\:A0 \4\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.19e-14 ps=5.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (n0 \3\:A1 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\3\:n0 \3\:A2 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \3\:B0 \3\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.19e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2.2e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
ends OAI31XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:20 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI32X1
// View name: extracted

simulator lang=spectre

subckt OAI32X1 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (n1 \1\:A0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.25e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
mp1 (n2 \3\:A1 n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=7.215e-14 ps=1.01e-06 pd=1.15e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=7.65e-07 sd=160n sca=21.3946 scb=0.02109 \
        scc=0.00137328 m=(1)
mp2 (\3\:Y \4\:A2 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=9.555e-14 ps=1.15e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.35e-07 sd=160n sca=18.501 \
        scb=0.0159575 scc=0.00128203 m=(1)
mp4 (\3\:Y \1\:B1 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.555e-14 ps=9e-07 pd=1.27e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.2e-07 sb=2.45e-07 sd=160n sca=18.9491 scb=0.0167251 \
        scc=0.00128629 m=(1)
mp3 (n4 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.4e-07 sd=160n sca=20.266 \
        scb=0.0190952 scc=0.00131874 m=(1)
C1 (A2 VSS) capacitor c=5.95579e-17
C2 (A1 VSS) capacitor c=5.56118e-17
C3 (Y VSS) capacitor c=2.46695e-17
C4 (A0 VSS) capacitor c=1.03549e-16
C5 (VDD VSS) capacitor c=8.1931e-17
C6 (n0 VSS) capacitor c=9.44218e-17
C7 (n1 VSS) capacitor c=7.98026e-18
C8 (n2 VSS) capacitor c=5.42414e-18
C9 (\3\:B0 VSS) capacitor c=7.93321e-17
C10 (\1\:B1 VSS) capacitor c=6.55356e-17
C11 (\4\:A2 VSS) capacitor c=4.27711e-17
C12 (\3\:A1 VSS) capacitor c=4.71833e-17
C13 (\1\:A0 VSS) capacitor c=4.41642e-17
C14 (\1\:B0 VSS) capacitor c=3.14405e-17
C15 (\3\:B1 VSS) capacitor c=5.42347e-17
C16 (\1\:A2 VSS) capacitor c=4.53184e-17
C17 (\1\:A1 VSS) capacitor c=5.11571e-17
C18 (\4\:A0 VSS) capacitor c=3.9634e-17
C19 (\4\:B0 VSS) capacitor c=1.16685e-17
C20 (\2\:B1 VSS) capacitor c=5.22265e-17
C21 (\3\:A2 VSS) capacitor c=5.02448e-17
C22 (\2\:A1 VSS) capacitor c=6.22969e-17
C23 (\3\:A0 VSS) capacitor c=1.48757e-17
C24 (\1\:VDD VSS) capacitor c=5.0074e-17
C25 (\3\:Y VSS) capacitor c=1.33595e-16
C26 (\5\:VDD VSS) capacitor c=6.32253e-17
C27 (\1\:Y VSS) capacitor c=1.16611e-16
C28 (\3\:n0 VSS) capacitor c=1.0857e-16
C29 (\5\:n0 VSS) capacitor c=8.17975e-17
C30 (\2\:A0 VSS) capacitor c=3.10775e-17
C31 (\2\:B0 VSS) capacitor c=2.9631e-17
C32 (\4\:A1 VSS) capacitor c=6.90001e-17
C33 (\5\:A2 VSS) capacitor c=6.32851e-17
C34 (\5\:B1 VSS) capacitor c=4.04478e-17
C35 (\6\:B1 VSS) capacitor c=4.42727e-17
C36 (\5\:B0 VSS) capacitor c=1.08796e-16
C37 (\4\:VDD VSS) capacitor c=3.29167e-17
Rk3 (\5\:A2 A2) resistor r=0.174 c=0
Rk11 (B0 \5\:B0) resistor r=0.004147 c=0
Rk2 (A1 \4\:A1) resistor r=0.2257 c=0
Rk5 (\4\:Y Y) resistor r=0.1563 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.6306 c=0
Rk1 (\5\:A0 A0) resistor r=0.006012 c=0
Rk16 (\3\:VSS VSS) resistor r=0.1905 c=0
Rk17 (VSS \5\:VSS) resistor r=0.2792 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2245 c=0
Rk13 (\4\:VDD VDD) resistor r=0.3011 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.5318 c=0
Rk14 (VDD \6\:VDD) resistor r=0.3529 c=0
Rk6 (\4\:B1 \5\:B1) resistor r=0.003102 c=0
Rk7 (B1 \6\:B1) resistor r=0.003102 c=0
Rk8 (\4\:B1 \6\:B1) resistor r=0.02258 c=0
Rk9 (\2\:n0 \4\:n0) resistor r=0.5786 c=0
Rk10 (\4\:n0 \6\:n0) resistor r=0.4268 c=0
Rl8 (\2\:A2 \4\:A2) resistor r=88.9346 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=71.7177 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=1.2666 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=117.577 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=26.5731 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=3.8588 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=105.746 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=37.3411 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=110.418 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=6.3288 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=26.9231 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=106.437 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (n0 \2\:n0) resistor r=37.5 c=0
Rz3 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Rx3 (\3\:A2 \5\:A2) resistor r=45 c=0
Rx5 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B1 \5\:B1) resistor r=45 c=0
mn0 (\5\:n0 \4\:A0 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (\5\:n0 \1\:A1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (\3\:n0 \1\:A2 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.5e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\1\:Y \3\:B1 \3\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=3.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=9.6e-07 \
        sb=1.4e-07 sd=160n sca=10.104 scb=0.00906063 scc=0.000325539 m=(1)
ends OAI32X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:21 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI32X2
// View name: extracted

simulator lang=spectre

subckt OAI32X2 A0 A1 A2 B0 B1 VDD VSS Y
mp0_1__rcx (3 \1\:A0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=20.0993 \
        scb=0.0192799 scc=0.0012385 m=(1)
mp1_1__rcx (3 \1\:A1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.765e-06 sd=160n sca=18.4756 \
        scb=0.0165821 scc=0.00119613 m=(1)
mp2_1__rcx (\6\:Y \5\:A2 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.53e-06 sd=160n sca=16.8836 \
        scb=0.0148184 scc=0.00118871 m=(1)
mp2 (\6\:Y \6\:A2 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=7.02e-14 \
        ad=6.24e-14 ps=1.14e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.85e-07 sb=1.325e-06 sd=160n sca=16.3055 scb=0.014587 \
        scc=0.00118861 m=(1)
mp1 (7 \4\:A1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.1e-07 sb=1.1e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp0 (8 \6\:A0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=5.265e-14 ps=1.63e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=9.2e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3_1__rcx (4 \1\:B0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=2.34e-14 ps=1.63e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.8e-07 sd=160n sca=16.3679 \
        scb=0.0146009 scc=0.00118861 m=(1)
mp4_1__rcx (\9\:Y \4\:B1 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.75e-07 sd=160n sca=16.6397 \
        scb=0.0146915 scc=0.00118864 m=(1)
mp4 (\9\:Y \6\:B1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=3.315e-14 \
        ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.74e-06 sb=2.7e-07 sd=160n sca=17.591 scb=0.0154265 \
        scc=0.00118981 m=(1)
mp3 (9 \6\:B0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.315e-14 ps=1.06e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.4e-07 sd=160n sca=18.843 \
        scb=0.0171484 scc=0.00120158 m=(1)
C1 (A0 VSS) capacitor c=4.86641e-16
C2 (B0 VSS) capacitor c=3.20137e-17
C3 (A1 VSS) capacitor c=2.76115e-17
C4 (VDD VSS) capacitor c=1.02008e-16
C5 (Y VSS) capacitor c=3.55825e-17
C6 (A2 VSS) capacitor c=5.86833e-17
C7 (B1 VSS) capacitor c=3.80474e-17
C8 (n0 VSS) capacitor c=3.34711e-16
C9 (3 VSS) capacitor c=1.24857e-18
C10 (6 VSS) capacitor c=1.52163e-18
C11 (7 VSS) capacitor c=6.05118e-18
C12 (8 VSS) capacitor c=5.17503e-18
C13 (4 VSS) capacitor c=1.73737e-18
C14 (\6\:B0 VSS) capacitor c=6.60956e-17
C15 (\6\:B1 VSS) capacitor c=4.4404e-17
C16 (\4\:B1 VSS) capacitor c=6.08533e-17
C17 (\1\:B0 VSS) capacitor c=8.63558e-17
C18 (\6\:A0 VSS) capacitor c=6.15817e-17
C19 (\4\:A1 VSS) capacitor c=5.74405e-17
C20 (\6\:A2 VSS) capacitor c=4.08175e-17
C21 (\5\:A2 VSS) capacitor c=2.46857e-17
C22 (\1\:A1 VSS) capacitor c=8.7569e-17
C23 (\1\:A0 VSS) capacitor c=8.25668e-17
C24 (\1\:B1 VSS) capacitor c=9.72318e-17
C25 (\1\:A2 VSS) capacitor c=1.02618e-16
C26 (\3\:B1 VSS) capacitor c=4.92893e-17
C27 (\2\:B0 VSS) capacitor c=3.17346e-16
C28 (\3\:A2 VSS) capacitor c=2.91441e-17
C29 (\2\:A1 VSS) capacitor c=3.65674e-16
C30 (\7\:VDD VSS) capacitor c=3.66554e-17
C31 (\9\:Y VSS) capacitor c=5.99834e-17
C32 (\9\:VDD VSS) capacitor c=3.53014e-17
C33 (\6\:Y VSS) capacitor c=5.71542e-17
C34 (\11\:VDD VSS) capacitor c=4.59699e-17
C35 (\1\:VDD VSS) capacitor c=2.40799e-17
C36 (\9\:n0 VSS) capacitor c=8.00082e-17
C37 (\1\:Y VSS) capacitor c=2.23402e-16
C38 (\7\:A2 VSS) capacitor c=4.28237e-17
C39 (\7\:B1 VSS) capacitor c=6.01473e-17
C40 (\5\:Y VSS) capacitor c=9.60874e-17
C41 (\3\:VDD VSS) capacitor c=1.78778e-17
C42 (\4\:VDD VSS) capacitor c=1.79058e-17
C43 (\6\:VDD VSS) capacitor c=1.66697e-17
Rk15 (\2\:B0 B0) resistor r=0.09124 c=0
Rk2 (A1 \2\:A1) resistor r=0.05061 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.135 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.3903 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.125 c=0
Rk25 (\6\:VDD VDD) resistor r=0.09723 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.4531 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.3383 c=0
Rk27 (\4\:VDD \10\:VDD) resistor r=0.1581 c=0
Rk28 (\6\:VDD \12\:VDD) resistor r=0.3383 c=0
Rk10 (\5\:Y Y) resistor r=0.08382 c=0
Rk9 (\1\:Y \5\:Y) resistor r=0.6159 c=0
Rk11 (Y \7\:Y) resistor r=0.3161 c=0
Rk12 (\7\:Y \8\:Y) resistor r=0.1458 c=0
Rk13 (\5\:Y \10\:Y) resistor r=0.447 c=0
Rk33 (\3\:VSS VSS) resistor r=0.1148 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.6159 c=0
Rk35 (\3\:VSS \10\:VSS) resistor r=0.1018 c=0
Rk1 (\7\:A2 A2) resistor r=0.2015 c=0
Rk7 (B1 \7\:B1) resistor r=0.1011 c=0
Rl13 (A0 \6\:A0) resistor r=103.079 c=0
Rl1 (A0 \1\:A0) resistor r=124.566 c=0
Rl22 (\2\:B0 \6\:B0) resistor r=105.708 c=0
Rl14 (\2\:B0 \1\:B0) resistor r=94.9225 c=0
Rl10 (\2\:A1 \4\:A1) resistor r=79.9442 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=90.1797 c=0
Rl9 (\3\:A2 \6\:A2) resistor r=105.323 c=0
Rl8 (\3\:A2 \5\:A2) resistor r=24.2328 c=0
Rl6 (\1\:A2 \3\:A2) resistor r=68.1451 c=0
Rl20 (\3\:B1 \6\:B1) resistor r=42.1458 c=0
Rl18 (\3\:B1 \4\:B1) resistor r=56.2772 c=0
Rl17 (\1\:B1 \3\:B1) resistor r=60.4528 c=0
Rz9 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz10 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz12 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (n0 \9\:n0) resistor r=75 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry1 (\7\:Y \6\:Y) resistor r=62 c=0
Ry2 (\8\:Y \6\:Y) resistor r=62 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
Rx6 (\7\:B1 \3\:B1) resistor r=45 c=0
mn4_1__rcx (\1\:Y \1\:B1 \9\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.5e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn0_1__rcx (n0 A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=4.55e-14 ps=1.37e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.50447 scb=0.0081528 \
        scc=0.00025289 m=(2)
mn1 (n0 \2\:A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=4.16e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.95e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn3_1__rcx (\1\:Y \2\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=7.55e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn2_1__rcx (n0 \1\:A2 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=4.16e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.745e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
ends OAI32X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:22 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI32X4
// View name: extracted

simulator lang=spectre

subckt OAI32X4 A0 A1 A2 B0 B1 VDD VSS Y
mp0_1__rcx (3 \1\:A0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.1962 scb=0.0165264 \
        scc=0.000689254 m=(1)
mp1_1__rcx (3 \1\:A1 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=2.34e-14 ps=1.33e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=15.6659 scb=0.0140242 \
        scc=0.000653779 m=(1)
mp2_1__rcx (\13\:Y \5\:A2 9 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=13.8663 scb=0.0122652 \
        scc=0.000647528 m=(1)
mp2_2__rcx (\13\:Y \1\:A2 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (4 \4\:A1 11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=2.34e-14 ps=1.45e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (11 \8\:A0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.3065e-13 ps=1.1e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (5 \4\:A0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (5 \9\:A1 12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=2.34e-14 ps=1.19e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_3__rcx (\11\:Y \11\:A2 12 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2 (\11\:Y \12\:A2 13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.96e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1 (13 \10\:A1 14 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.435e-14 \
        ad=8.58e-14 ps=1.11e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.695e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0 (14 \12\:A0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=6.435e-14 ps=1.34e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.485e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (15 \1\:B0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=4.095e-14 ps=1.34e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.22e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_1__rcx (\15\:Y \5\:B1 15 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.07e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_2__rcx (\15\:Y \6\:B1 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_2__rcx (6 \7\:B0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_3__rcx (8 \9\:B0 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_3__rcx (\17\:Y \10\:B1 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4 (\17\:Y \12\:B1 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=13.9711 scb=0.0123086 \
        scc=0.000647543 m=(1)
mp3 (7 \12\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.3777 scb=0.0125541 \
        scc=0.000647737 m=(1)
C1 (A0 VSS) capacitor c=1.51173e-17
C2 (B0 VSS) capacitor c=2.39396e-17
C3 (A1 VSS) capacitor c=8.37949e-16
C4 (Y VSS) capacitor c=1.08349e-17
C5 (VDD VSS) capacitor c=2.62445e-16
C6 (A2 VSS) capacitor c=4.62414e-16
C7 (B1 VSS) capacitor c=4.01046e-16
C8 (n0 VSS) capacitor c=6.6856e-16
C9 (3 VSS) capacitor c=1.56659e-18
C10 (9 VSS) capacitor c=7.85867e-18
C11 (4 VSS) capacitor c=2.44041e-18
C12 (11 VSS) capacitor c=1.61022e-17
C13 (5 VSS) capacitor c=2.44041e-18
C14 (12 VSS) capacitor c=1.01999e-17
C15 (13 VSS) capacitor c=9.28055e-18
C16 (14 VSS) capacitor c=6.77142e-18
C17 (15 VSS) capacitor c=4.03715e-18
C18 (6 VSS) capacitor c=2.44041e-18
C19 (8 VSS) capacitor c=2.44041e-18
C20 (7 VSS) capacitor c=1.54387e-18
C21 (\12\:B0 VSS) capacitor c=6.0889e-17
C22 (\12\:B1 VSS) capacitor c=6.30944e-17
C23 (\10\:B1 VSS) capacitor c=6.94515e-17
C24 (\9\:B0 VSS) capacitor c=5.72403e-17
C25 (\7\:B0 VSS) capacitor c=7.66e-17
C26 (\6\:B1 VSS) capacitor c=6.5913e-17
C27 (\5\:B1 VSS) capacitor c=5.54868e-17
C28 (\1\:B0 VSS) capacitor c=6.01206e-17
C29 (\12\:A0 VSS) capacitor c=4.95393e-17
C30 (\10\:A1 VSS) capacitor c=4.35032e-17
C31 (\12\:A2 VSS) capacitor c=3.94727e-17
C32 (\11\:A2 VSS) capacitor c=2.65197e-17
C33 (\9\:A1 VSS) capacitor c=7.31081e-17
C34 (\4\:A0 VSS) capacitor c=8.04531e-17
C35 (\8\:A0 VSS) capacitor c=1.94154e-17
C36 (\4\:A1 VSS) capacitor c=7.03788e-17
C37 (\1\:A2 VSS) capacitor c=6.22419e-17
C38 (\5\:A2 VSS) capacitor c=2.49487e-17
C39 (\1\:A1 VSS) capacitor c=7.18736e-17
C40 (\1\:A0 VSS) capacitor c=6.30375e-17
C41 (\2\:B0 VSS) capacitor c=6.17093e-16
C42 (\2\:A0 VSS) capacitor c=8.921e-16
C43 (\1\:VDD VSS) capacitor c=3.0514e-17
C44 (\17\:Y VSS) capacitor c=7.61515e-17
C45 (\5\:VDD VSS) capacitor c=3.48646e-17
C46 (\15\:Y VSS) capacitor c=9.312e-17
C47 (\8\:VDD VSS) capacitor c=2.96607e-17
C48 (\11\:Y VSS) capacitor c=1.47108e-16
C49 (\11\:VDD VSS) capacitor c=3.90083e-17
C50 (\13\:Y VSS) capacitor c=1.21399e-16
C51 (\15\:VDD VSS) capacitor c=2.14923e-17
C52 (\3\:VDD VSS) capacitor c=6.04981e-17
C53 (\1\:Y VSS) capacitor c=3.47072e-16
C54 (\2\:A2 VSS) capacitor c=3.74675e-17
C55 (\10\:A2 VSS) capacitor c=2.28659e-17
C56 (\4\:B1 VSS) capacitor c=3.23407e-17
C57 (\9\:Y VSS) capacitor c=1.0803e-16
C58 (\10\:Y VSS) capacitor c=5.56901e-17
C59 (\7\:VDD VSS) capacitor c=3.48672e-17
C60 (\10\:VDD VSS) capacitor c=3.24465e-17
C61 (\14\:VDD VSS) capacitor c=1.66496e-17
Rk10 (\2\:A0 A0) resistor r=0.03156 c=0
Rk13 (B0 \2\:B0) resistor r=0.1123 c=0
Rk20 (\1\:Y \9\:Y) resistor r=0.5732 c=0
Rk25 (\10\:Y Y) resistor r=0.009903 c=0
Rk21 (\9\:Y \10\:Y) resistor r=0.3024 c=0
Rk22 (\10\:Y \12\:Y) resistor r=0.2417 c=0
Rk23 (\12\:Y \14\:Y) resistor r=0.9153 c=0
Rk24 (\9\:Y \16\:Y) resistor r=0.2873 c=0
Rk26 (\16\:Y \18\:Y) resistor r=0.4527 c=0
Rk37 (\2\:VDD \4\:VDD) resistor r=0.5283 c=0
Rk38 (\4\:VDD \6\:VDD) resistor r=0.2631 c=0
Rk39 (\4\:VDD \7\:VDD) resistor r=0.368 c=0
Rk40 (\7\:VDD \9\:VDD) resistor r=0.1775 c=0
Rk41 (\7\:VDD \10\:VDD) resistor r=0.6347 c=0
Rk42 (\10\:VDD \12\:VDD) resistor r=0.2171 c=0
Rk43 (\10\:VDD \13\:VDD) resistor r=0.1973 c=0
Rk46 (\14\:VDD VDD) resistor r=0.1021 c=0
Rk44 (\13\:VDD \14\:VDD) resistor r=0.4474 c=0
Rk45 (\14\:VDD \16\:VDD) resistor r=0.2217 c=0
Rk56 (\3\:VSS VSS) resistor r=0.1021 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.4724 c=0
Rl27 (\2\:A0 \12\:A0) resistor r=24.2328 c=0
Rl12 (\2\:A0 \4\:A0) resistor r=105.323 c=0
Rl15 (\2\:A0 \8\:A0) resistor r=24.2328 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=45.6195 c=0
Rl46 (\2\:B0 \12\:B0) resistor r=24.2328 c=0
Rl39 (\2\:B0 \9\:B0) resistor r=24.2328 c=0
Rl37 (\2\:B0 \7\:B0) resistor r=75.6352 c=0
Rl28 (\2\:B0 \1\:B0) resistor r=26.098 c=0
Rl24 (A1 \10\:A1) resistor r=44.9225 c=0
Rl18 (A1 \9\:A1) resistor r=41.4826 c=0
Rl10 (A1 \4\:A1) resistor r=52.6149 c=0
Rl3 (A1 \1\:A1) resistor r=52.6149 c=0
Rl6 (\2\:A2 A2) resistor r=71.9912 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=65.3625 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=67.2856 c=0
Rl21 (\10\:A2 A2) resistor r=77.3125 c=0
Rl23 (\10\:A2 \12\:A2) resistor r=100.426 c=0
Rl22 (\10\:A2 \11\:A2) resistor r=35.772 c=0
Rl44 (B1 \12\:B1) resistor r=52.6559 c=0
Rl42 (B1 \10\:B1) resistor r=99.9772 c=0
Rl32 (\4\:B1 B1) resistor r=6.3032 c=0
Rl34 (\4\:B1 \6\:B1) resistor r=74.564 c=0
Rl33 (\4\:B1 \5\:B1) resistor r=118.715 c=0
Rz16 (\3\:VDD \4\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \13\:VDD) resistor r=6.25 c=0
Ry1 (\12\:Y \11\:Y) resistor r=62 c=0
Ry2 (\14\:Y \13\:Y) resistor r=62 c=0
Ry3 (\16\:Y \15\:Y) resistor r=62 c=0
Ry4 (\18\:Y \17\:Y) resistor r=62 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry7 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry8 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry9 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn3_1__rcx (\1\:Y \2\:B0 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn4_1__rcx (\1\:Y B1 n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn0_1__rcx (n0 \2\:A0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.03e-14 ps=1.43e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn1_1__rcx (n0 A1 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2 (n0 A2 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=8.54e-14 \
        ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
ends OAI32X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:24 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI32XL
// View name: extracted

simulator lang=spectre

subckt OAI32XL A0 A1 A2 B0 B1 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=15.8878 \
        scb=0.0154804 scc=0.000305546 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=9.95e-07 sd=160n sca=12.9037 scb=0.0106456 \
        scc=0.000222738 m=(1)
mp2 (\4\:Y \1\:A2 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=9.567e-14 ps=7.5e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.9e-07 sd=160n sca=11.8276 \
        scb=0.00970062 scc=0.000220696 m=(1)
mp4 (\4\:Y \1\:B1 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=9.567e-14 ps=6.6e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=3e-07 sd=160n sca=13.2535 scb=0.0110982 \
        scc=0.000225 m=(1)
mp3 (n4 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.472e-14 ps=7.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=15.7614 \
        scb=0.0152558 scc=0.000298372 m=(1)
C1 (Y VSS) capacitor c=1.21508e-17
C2 (VDD VSS) capacitor c=1.14031e-16
C3 (A2 VSS) capacitor c=3.44021e-17
C4 (B0 VSS) capacitor c=3.18311e-17
C5 (A1 VSS) capacitor c=1.07072e-16
C6 (A0 VSS) capacitor c=4.93074e-17
C7 (B1 VSS) capacitor c=4.59149e-17
C8 (n0 VSS) capacitor c=7.35465e-17
C9 (n1 VSS) capacitor c=7.42025e-18
C10 (\1\:B0 VSS) capacitor c=5.60637e-17
C11 (\1\:B1 VSS) capacitor c=3.3925e-17
C12 (\1\:A2 VSS) capacitor c=3.7422e-17
C13 (\1\:A1 VSS) capacitor c=4.2819e-17
C14 (\1\:A0 VSS) capacitor c=4.20825e-17
C15 (\3\:B0 VSS) capacitor c=3.17754e-17
C16 (\3\:B1 VSS) capacitor c=6.79869e-17
C17 (\3\:A2 VSS) capacitor c=3.27004e-17
C18 (\3\:A1 VSS) capacitor c=4.55293e-17
C19 (\4\:A0 VSS) capacitor c=2.80906e-17
C20 (\2\:B0 VSS) capacitor c=5.75695e-17
C21 (\2\:B1 VSS) capacitor c=5.1884e-17
C22 (\2\:A2 VSS) capacitor c=4.30258e-17
C23 (\2\:A1 VSS) capacitor c=5.96624e-17
C24 (\3\:A0 VSS) capacitor c=9.79543e-18
C25 (\1\:VDD VSS) capacitor c=3.55469e-17
C26 (\4\:Y VSS) capacitor c=1.39763e-17
C27 (\6\:VDD VSS) capacitor c=2.59737e-17
C28 (\1\:Y VSS) capacitor c=7.16589e-17
C29 (\3\:n0 VSS) capacitor c=1.23571e-16
C30 (\5\:n0 VSS) capacitor c=7.20809e-17
C31 (\2\:A0 VSS) capacitor c=3.65335e-17
C32 (\5\:A0 VSS) capacitor c=3.62823e-17
C33 (\4\:A2 VSS) capacitor c=6.60087e-17
C34 (\3\:Y VSS) capacitor c=6.30424e-17
C35 (\4\:B1 VSS) capacitor c=4.78455e-17
C36 (\4\:B0 VSS) capacitor c=4.37576e-17
C37 (\4\:VDD VSS) capacitor c=2.51695e-17
C38 (\5\:VDD VSS) capacitor c=1.23114e-17
Rk5 (\3\:Y Y) resistor r=0.003054 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.4944 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.101 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.5845 c=0
Rk13 (\5\:VDD VDD) resistor r=0.08179 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.3163 c=0
Rk14 (\5\:VDD \7\:VDD) resistor r=0.2696 c=0
Rk3 (A2 \4\:A2) resistor r=0.05396 c=0
Rk10 (B0 \4\:B0) resistor r=0.1867 c=0
Rk2 (A1 \4\:A1) resistor r=0.003944 c=0
Rk17 (\4\:VSS VSS) resistor r=0.08179 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.189 c=0
Rk18 (\3\:VSS \6\:VSS) resistor r=0.2779 c=0
Rk19 (\4\:VSS \8\:VSS) resistor r=0.2788 c=0
Rk1 (A0 \5\:A0) resistor r=0.2235 c=0
Rk9 (\4\:B1 B1) resistor r=0.1663 c=0
Rk7 (\2\:n0 \4\:n0) resistor r=0.6168 c=0
Rk8 (\4\:n0 \6\:n0) resistor r=0.4906 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=118.464 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=76.1559 c=0
Rl10 (\1\:B0 \2\:B0) resistor r=136.333 c=0
Rl11 (\2\:B0 \3\:B0) resistor r=63.4387 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=87.6944 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=106.925 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=166.187 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=46.9565 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=1.2301 c=0
Rl8 (\1\:B1 \2\:B1) resistor r=46.8456 c=0
Rl9 (\2\:B1 \3\:B1) resistor r=171.411 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (n0 \2\:n0) resistor r=75 c=0
Rz3 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx5 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (\5\:n0 \4\:A0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\5\:n0 \3\:A1 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (\3\:n0 \3\:A2 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.003e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.35e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:B1 \3\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.32e-14 ps=9.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\1\:Y \3\:B0 n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
ends OAI32XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:25 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI33X1
// View name: extracted

simulator lang=spectre

subckt OAI33X1 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=16.1236 \
        scb=0.0157073 scc=0.000369518 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.85e-07 sd=160n sca=14.2305 scb=0.0124601 \
        scc=0.000303643 m=(1)
mp2 (\5\:Y \1\:A2 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.8e-07 sd=160n sca=12.6688 scb=0.0104218 \
        scc=0.00029207 m=(1)
mp5 (\5\:Y \1\:B2 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=7.41e-14 ps=1.09e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=4.45e-07 sd=160n sca=12.6688 \
        scb=0.0104218 scc=0.00029207 m=(1)
mp3 (n3 \3\:B1 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.045e-14 \
        ad=2.34e-14 ps=1.09e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.85e-07 sb=2.45e-07 sd=160n sca=14.1668 scb=0.0123603 \
        scc=0.000302616 m=(1)
mp4 (\1\:VDD \3\:B0 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.4e-07 sd=160n sca=16.0015 \
        scb=0.0154903 scc=0.000362941 m=(1)
C1 (A1 VSS) capacitor c=5.13504e-17
C2 (VDD VSS) capacitor c=1.0294e-16
C3 (B1 VSS) capacitor c=6.05831e-17
C4 (A0 VSS) capacitor c=6.25433e-17
C5 (B2 VSS) capacitor c=6.09105e-17
C6 (B0 VSS) capacitor c=6.90391e-17
C7 (Y VSS) capacitor c=1.19918e-16
C8 (A2 VSS) capacitor c=2.60741e-17
C9 (no VSS) capacitor c=5.18045e-17
C10 (n2 VSS) capacitor c=2.11046e-18
C11 (n4 VSS) capacitor c=6.59856e-18
C12 (n3 VSS) capacitor c=2.33123e-18
C13 (\3\:B0 VSS) capacitor c=6.82694e-17
C14 (\3\:B1 VSS) capacitor c=9.89122e-17
C15 (\1\:B2 VSS) capacitor c=6.34155e-17
C16 (\1\:A2 VSS) capacitor c=4.00243e-17
C17 (\1\:A1 VSS) capacitor c=9.7338e-17
C18 (\1\:A0 VSS) capacitor c=8.47607e-17
C19 (\1\:B0 VSS) capacitor c=4.99281e-17
C20 (\1\:B1 VSS) capacitor c=4.29548e-17
C21 (\3\:B2 VSS) capacitor c=4.21903e-17
C22 (\3\:A2 VSS) capacitor c=6.38813e-17
C23 (\3\:A1 VSS) capacitor c=4.45679e-17
C24 (\3\:A0 VSS) capacitor c=3.49324e-17
C25 (\2\:B0 VSS) capacitor c=5.18983e-17
C26 (\2\:B1 VSS) capacitor c=5.21462e-17
C27 (\2\:B2 VSS) capacitor c=4.76542e-17
C28 (\2\:A2 VSS) capacitor c=4.78232e-17
C29 (\2\:A1 VSS) capacitor c=6.95691e-17
C30 (\2\:A0 VSS) capacitor c=6.37564e-17
C31 (\1\:VDD VSS) capacitor c=4.93844e-17
C32 (\5\:Y VSS) capacitor c=8.17876e-17
C33 (\6\:VDD VSS) capacitor c=3.49394e-17
C34 (\3\:Y VSS) capacitor c=8.04969e-17
C35 (\5\:no VSS) capacitor c=6.31971e-17
C36 (\1\:Y VSS) capacitor c=6.02833e-17
C37 (\3\:no VSS) capacitor c=8.59997e-17
C38 (\4\:A0 VSS) capacitor c=2.60339e-17
C39 (\4\:A1 VSS) capacitor c=6.53777e-17
C40 (\4\:A2 VSS) capacitor c=9.14658e-17
C41 (\4\:B2 VSS) capacitor c=5.6901e-17
C42 (\4\:B1 VSS) capacitor c=6.44387e-17
C43 (\4\:B0 VSS) capacitor c=6.71207e-17
C44 (\4\:VDD VSS) capacitor c=3.19036e-17
C45 (\5\:VDD VSS) capacitor c=1.31674e-17
Rk2 (A1 \4\:A1) resistor r=0.2253 c=0
Rk20 (\4\:VSS VSS) resistor r=0.03467 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.2053 c=0
Rk21 (\3\:VSS \6\:VSS) resistor r=0.1804 c=0
Rk22 (\4\:VSS \8\:VSS) resistor r=0.1744 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.3945 c=0
Rk16 (\5\:VDD VDD) resistor r=0.08483 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.2657 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2313 c=0
Rk7 (B1 \4\:B1) resistor r=0.2253 c=0
Rk1 (A0 \4\:A0) resistor r=0.1112 c=0
Rk6 (B2 \4\:B2) resistor r=0.2253 c=0
Rk10 (B0 \4\:B0) resistor r=0.04807 c=0
Rk12 (\4\:Y Y) resistor r=0.4427 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.3019 c=0
Rk13 (Y \6\:Y) resistor r=0.6371 c=0
Rk5 (\4\:A2 A2) resistor r=0.05107 c=0
Rk8 (\2\:no \4\:no) resistor r=0.4175 c=0
Rk9 (\4\:no \6\:no) resistor r=0.3343 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=141.076 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=56.461 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=136.333 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=53.0142 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=144.021 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=56.8681 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=141.076 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=56.461 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=44.208 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=153.641 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=29.5379 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=168 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\3\:Y \4\:Y) resistor r=75 c=0
Rz1 (no \2\:no) resistor r=75 c=0
Rz2 (\3\:no \4\:no) resistor r=75 c=0
Rz3 (\5\:no \6\:no) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry1 (\5\:Y \6\:Y) resistor r=31 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
mn0 (no \3\:A0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (no \3\:A1 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\3\:no \3\:A2 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.94e-14 ps=8.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (\1\:Y \3\:B2 \3\:no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \1\:B1 \5\:no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\3\:Y \1\:B0 \5\:no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
ends OAI33X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:26 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI33X2
// View name: extracted

simulator lang=spectre

subckt OAI33X2 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0_1__rcx (3 \1\:A0 \1\:VDD VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.71e-14 ad=1.59e-14 ps=8.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98151e-06 sd=160n sca=14.2659 \
        scb=0.0126092 scc=0.000180096 m=(1)
mp1_1__rcx (3 \1\:A1 6 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=1.59e-14 ps=9.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.97953e-06 sd=160n sca=12.7796 \
        scb=0.0101999 scc=0.00014764 m=(1)
mp2_1__rcx (\8\:Y \1\:A2 6 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=4.505e-14 ps=9.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.97453e-06 sd=160n sca=11.1864 \
        scb=0.00858333 scc=0.000141961 m=(1)
mp2_2__rcx (\8\:Y \4\:A2 7 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.048e-14 ad=4.505e-14 ps=7.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.97047e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp1_2__rcx (7 \6\:A1 4 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=1.59e-14 ad=3.048e-14 ps=6.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.96745e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp0_2__rcx (4 \8\:A0 \7\:VDD VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=1.59e-14 ps=1.09e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.96547e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp5_1__rcx (\6\:Y \1\:B2 5 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=1.59e-14 ad=7.85e-14 ps=6.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96415e-06 sb=1.58406e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp3_1__rcx (5 \4\:B1 10 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=4.373e-14 ad=1.59e-14 ps=8.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96613e-06 sb=1.47906e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp4_1__rcx (\10\:VDD \1\:B0 10 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=4.373e-14 ad=6.55e-14 ps=8.6e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.97009e-06 sb=1.26906e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp4_2__rcx (\10\:VDD \4\:B0 12 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.313e-14 ad=6.55e-14 ps=7.8e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.97509e-06 sb=1.00406e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp3_2__rcx (12 \5\:B1 11 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.18e-14 ad=3.313e-14 ps=7.7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9783e-06 sb=8.34057e-07 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp5_2__rcx (\1\:Y \6\:B2 11 VDD) g45p1hvt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.18e-14 ad=4.47e-14 ps=7.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98142e-06 sb=6.69057e-07 sd=160n sca=10.7821 \
        scb=0.00844411 scc=0.000141921 m=(1)
C1 (A0 VSS) capacitor c=4.87793e-16
C2 (B2 VSS) capacitor c=2.47601e-17
C3 (B0 VSS) capacitor c=5.58594e-16
C4 (VDD VSS) capacitor c=3.32162e-16
C5 (A2 VSS) capacitor c=5.50428e-16
C6 (A1 VSS) capacitor c=6.47053e-16
C7 (Y VSS) capacitor c=2.91182e-17
C8 (B1 VSS) capacitor c=2.45554e-17
C9 (n0 VSS) capacitor c=7.27792e-16
C10 (7 VSS) capacitor c=3.54575e-18
C11 (4 VSS) capacitor c=1.84995e-18
C12 (8 VSS) capacitor c=1.19208e-17
C13 (9 VSS) capacitor c=6.08751e-18
C14 (5 VSS) capacitor c=2.1945e-18
C15 (10 VSS) capacitor c=5.0251e-18
C16 (12 VSS) capacitor c=3.59117e-18
C17 (11 VSS) capacitor c=3.62862e-18
C18 (14 VSS) capacitor c=3.47743e-18
C19 (15 VSS) capacitor c=2.70296e-18
C20 (\9\:B0 VSS) capacitor c=4.13399e-17
C21 (\10\:B1 VSS) capacitor c=6.74207e-17
C22 (\9\:B2 VSS) capacitor c=4.85975e-17
C23 (\6\:B2 VSS) capacitor c=4.7128e-17
C24 (\5\:B1 VSS) capacitor c=5.87322e-17
C25 (\4\:B0 VSS) capacitor c=3.18852e-17
C26 (\1\:B0 VSS) capacitor c=2.53622e-17
C27 (\4\:B1 VSS) capacitor c=6.08727e-17
C28 (\1\:B2 VSS) capacitor c=8.84814e-17
C29 (\7\:A2 VSS) capacitor c=3.77539e-17
C30 (\7\:A1 VSS) capacitor c=3.83779e-17
C31 (\10\:A0 VSS) capacitor c=2.329e-17
C32 (\8\:A0 VSS) capacitor c=7.35364e-17
C33 (\6\:A1 VSS) capacitor c=8.66331e-17
C34 (\4\:A2 VSS) capacitor c=2.99952e-17
C35 (\1\:A2 VSS) capacitor c=2.0173e-17
C36 (\1\:A1 VSS) capacitor c=7.07638e-17
C37 (\1\:A0 VSS) capacitor c=8.25206e-17
C38 (\1\:B1 VSS) capacitor c=6.98896e-16
C39 (\2\:B2 VSS) capacitor c=5.61303e-16
C40 (\13\:VDD VSS) capacitor c=4.31925e-17
C41 (\1\:Y VSS) capacitor c=2.02708e-16
C42 (\10\:VDD VSS) capacitor c=3.17894e-17
C43 (\6\:Y VSS) capacitor c=1.69865e-16
C44 (\7\:VDD VSS) capacitor c=3.70212e-17
C45 (\8\:Y VSS) capacitor c=1.27669e-16
C46 (\1\:VDD VSS) capacitor c=1.07195e-17
C47 (\4\:VDD VSS) capacitor c=6.27018e-17
C48 (\7\:A0 VSS) capacitor c=3.22721e-17
C49 (\3\:Y VSS) capacitor c=4.68651e-16
C50 (\3\:VDD VSS) capacitor c=1.37967e-17
C51 (\6\:VDD VSS) capacitor c=2.89499e-17
C52 (\9\:VDD VSS) capacitor c=4.03368e-17
Rk11 (\2\:B2 B2) resistor r=0.08585 c=0
Rk56 (\3\:VSS VSS) resistor r=0.05469 c=0
Rk50 (\2\:VSS \3\:VSS) resistor r=0.6815 c=0
Rk42 (\3\:VDD VDD) resistor r=0.1048 c=0
Rk41 (\2\:VDD \3\:VDD) resistor r=0.2263 c=0
Rk43 (\3\:VDD \5\:VDD) resistor r=0.4459 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.08251 c=0
Rk45 (\6\:VDD \8\:VDD) resistor r=0.1818 c=0
Rk46 (\6\:VDD \9\:VDD) resistor r=0.8016 c=0
Rk47 (\9\:VDD \11\:VDD) resistor r=0.1818 c=0
Rk48 (\9\:VDD \12\:VDD) resistor r=0.2178 c=0
Rk49 (\12\:VDD \14\:VDD) resistor r=0.5315 c=0
Rk40 (\3\:Y Y) resistor r=0.01995 c=0
Rk29 (\2\:Y \3\:Y) resistor r=0.8504 c=0
Rk31 (\2\:Y \7\:Y) resistor r=0.9077 c=0
Rk32 (\7\:Y \9\:Y) resistor r=1.0469 c=0
Rk14 (\1\:B1 B1) resistor r=0.0584 c=0
Rl1 (A0 \1\:A0) resistor r=159.411 c=0
Rl13 (\7\:A0 A0) resistor r=119.604 c=0
Rl16 (\7\:A0 \10\:A0) resistor r=49.9779 c=0
Rl14 (\7\:A0 \8\:A0) resistor r=105.747 c=0
Rl36 (\2\:B2 \9\:B2) resistor r=145.949 c=0
Rl34 (\2\:B2 \6\:B2) resistor r=149.176 c=0
Rl22 (\2\:B2 \1\:B2) resistor r=144.026 c=0
Rl40 (B0 \9\:B0) resistor r=34.4104 c=0
Rl29 (B0 \4\:B0) resistor r=24.2328 c=0
Rl27 (B0 \1\:B0) resistor r=24.2328 c=0
Rl20 (A2 \7\:A2) resistor r=29.5379 c=0
Rl7 (A2 \4\:A2) resistor r=29.5379 c=0
Rl5 (A2 \1\:A2) resistor r=29.5379 c=0
Rl17 (A1 \7\:A1) resistor r=106.572 c=0
Rl10 (A1 \6\:A1) resistor r=94.0258 c=0
Rl3 (A1 \1\:A1) resistor r=98.7687 c=0
Rl38 (\1\:B1 \10\:B1) resistor r=84.4104 c=0
Rl31 (\1\:B1 \5\:B1) resistor r=87.2302 c=0
Rl26 (\1\:B1 \4\:B1) resistor r=54.6488 c=0
Rz15 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz16 (\4\:VDD \12\:VDD) resistor r=7.5 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=6.2 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry7 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\9\:Y \8\:Y) resistor r=62 c=0
mn0_1__rcx (n0 A0 \3\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.438e-14 ad=2.8e-14 ps=7.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98071e-06 sd=160n sca=9.07807 \
        scb=0.007472 scc=0.000167841 m=(2)
mn1_1__rcx (n0 A1 \3\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=4.45e-14 ad=2.8e-14 ps=8.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.97486e-06 sd=160n sca=9.07807 \
        scb=0.007472 scc=0.000167841 m=(2)
mn2 (n0 A2 \3\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 as=4.45e-14 \
        ad=2.975e-14 ps=8.9e-07 pd=6.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=1.96729e-06 sd=160n sca=9.07807 scb=0.007472 \
        scc=0.000167841 m=(2)
mn5 (\3\:Y \2\:B2 n0 VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.11e-14 ad=3.063e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94571e-06 sb=1.85043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn3_1__rcx (\3\:Y \1\:B1 n0 VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=2.844e-14 ad=3.063e-14 ps=6.75e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.952e-06 sb=1.63043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn4_1__rcx (\3\:Y B0 n0 VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=2.844e-14 ad=3.238e-14 ps=6.75e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.958e-06 sb=1.42043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn0_2__rcx (n0 A0 \3\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=4.425e-14 ad=2.72e-14 ps=8.9e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=1.99662e-06 sd=160n sca=9.14613 \
        scb=0.00758408 scc=0.000172013 m=(1)
mn1_2__rcx (n0 A1 \3\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=2.72e-14 ps=8.9e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=1.99059e-06 sd=160n sca=9.14613 \
        scb=0.00758408 scc=0.000172013 m=(1)
mn2_2__rcx (n0 A2 \3\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=3.195e-14 ps=8.9e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.98279e-06 sd=160n sca=9.14613 \
        scb=0.00758408 scc=0.000172013 m=(1)
mn5_2__rcx (\3\:Y \2\:B2 n0 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=3.025e-14 ad=2.975e-14 ps=7e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9825e-06 sb=5.65e-07 sd=160n sca=9.31415 \
        scb=0.0078649 scc=0.000187493 m=(1)
mn3_2__rcx (\3\:Y \1\:B1 n0 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=2.72e-14 ad=2.975e-14 ps=6.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98897e-06 sb=3.45e-07 sd=160n sca=9.31415 \
        scb=0.0078649 scc=0.000187493 m=(1)
mn4_2__rcx (\3\:Y B0 n0 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=2.72e-14 ad=2.38e-14 ps=6.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=1.4e-07 sd=160n sca=9.31415 \
        scb=0.0078649 scc=0.000187493 m=(1)
mp0 (8 \10\:A0 \7\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=9.49e-14 ps=1.09e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=2e-06 sd=160n sca=10.7426 \
        scb=0.0084509 scc=0.000143085 m=(1)
mp1 (8 \7\:A1 9 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=9.49e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.665e-06 sb=1.99279e-06 sd=160n sca=10.7426 scb=0.0084509 \
        scc=0.000143085 m=(1)
mp2 (\6\:Y \7\:A2 9 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=7.85e-14 ps=9.6e-07 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.93e-06 sb=1.92885e-06 sd=160n sca=10.7426 scb=0.0084509 \
        scc=0.000143085 m=(1)
mp5 (\1\:Y \9\:B2 14 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.47e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98519e-06 sb=4.65e-07 sd=160n sca=11.3498 scb=0.00860452 \
        scc=0.000134096 m=(1)
mp3 (14 \10\:B1 15 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=2.99e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98827e-06 sb=3.05e-07 sd=160n sca=12.2993 scb=0.00952904 \
        scc=0.000136475 m=(1)
mp4 (\13\:VDD \9\:B0 15 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.14e-14 ps=7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99087e-06 sb=1.7e-07 sd=160n sca=13.932 \
        scb=0.0120305 scc=0.000163154 m=(1)
ends OAI33X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:27 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI33X4
// View name: extracted

simulator lang=spectre

subckt OAI33X4 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp2_1__rcx (\15\:Y A2 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.595e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp1_1__rcx (\5\:n2 A1 n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=14.7189 \
        scb=0.0133035 scc=0.000878755 m=(4)
mp4_1__rcx (\1\:VDD B0 n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=15.4443 \
        scb=0.013925 scc=0.00102271 m=(4)
mp0_1__rcx (n1 A0 \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=20.9952 \
        scb=0.0222834 scc=0.00110072 m=(4)
mp5_1__rcx (\15\:Y B2 \5\:n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=7.65e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3_1__rcx (n3 B1 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=15.4348 scb=0.0139233 \
        scc=0.00102271 m=(4)
C1 (A1 VSS) capacitor c=3.78808e-16
C2 (B1 VSS) capacitor c=3.85596e-16
C3 (A0 VSS) capacitor c=3.36738e-16
C4 (VDD VSS) capacitor c=2.43562e-16
C5 (B2 VSS) capacitor c=3.77258e-16
C6 (B0 VSS) capacitor c=3.60507e-16
C7 (Y VSS) capacitor c=1.38079e-17
C8 (A2 VSS) capacitor c=3.98733e-16
C9 (no VSS) capacitor c=8.85002e-16
C10 (n1 VSS) capacitor c=3.58538e-16
C11 (n2 VSS) capacitor c=1.34976e-16
C12 (n4 VSS) capacitor c=1.22215e-16
C13 (n3 VSS) capacitor c=3.57514e-16
C14 (\1\:VDD VSS) capacitor c=9.15804e-17
C15 (\5\:n4 VSS) capacitor c=1.33529e-16
C16 (\5\:n2 VSS) capacitor c=1.24973e-16
C17 (\3\:VDD VSS) capacitor c=2.15807e-16
C18 (\1\:Y VSS) capacitor c=1.46598e-16
C19 (\5\:Y VSS) capacitor c=1.65888e-16
C20 (\9\:Y VSS) capacitor c=2.21921e-16
C21 (\14\:Y VSS) capacitor c=1.34668e-16
C22 (\15\:Y VSS) capacitor c=3.76429e-16
C23 (\10\:VDD VSS) capacitor c=1.11498e-16
Rk74 (\2\:VSS \3\:VSS) resistor r=0.852 c=0
Rk75 (\3\:VSS \4\:VSS) resistor r=0.4759 c=0
Rk77 (\4\:VSS \6\:VSS) resistor r=0.2051 c=0
Rk79 (\6\:VSS \8\:VSS) resistor r=0.105 c=0
Rk82 (\9\:VSS VSS) resistor r=0.2451 c=0
Rk80 (\8\:VSS \9\:VSS) resistor r=0.1 c=0
Rk67 (\1\:VDD \8\:VDD) resistor r=0.6738 c=0
Rk68 (\8\:VDD \9\:VDD) resistor r=1.2028 c=0
Rk73 (\10\:VDD VDD) resistor r=0.1574 c=0
Rk69 (\9\:VDD \10\:VDD) resistor r=0.1877 c=0
Rk27 (\1\:Y \5\:Y) resistor r=0.2789 c=0
Rk29 (\5\:Y \9\:Y) resistor r=0.2789 c=0
Rk33 (\14\:Y Y) resistor r=0.003068 c=0
Rk32 (\9\:Y \14\:Y) resistor r=0.9402 c=0
Rk34 (\14\:Y \15\:Y) resistor r=0.1112 c=0
Rk14 (n2 \5\:n2) resistor r=0.4078 c=0
Rk24 (n4 \5\:n4) resistor r=0.4061 c=0
Rz20 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz21 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz22 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Ry29 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry30 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry31 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
mn2_1__rcx (no A2 \4\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn1_1__rcx (no A1 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn4_1__rcx (\1\:Y B0 no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn3_1__rcx (\5\:Y B1 no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn5_1__rcx (\9\:Y B2 no VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn0_1__rcx (no A0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
ends OAI33X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:28 2013 )
// Library name: gsclib045_hvt
// Cell name: OAI33XL
// View name: extracted

simulator lang=spectre

subckt OAI33XL A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (n1 \1\:A0 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=14.5245 \
        scb=0.0130308 scc=0.000155148 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.1e-06 sd=160n sca=12.6898 scb=0.00990074 \
        scc=9.48225e-05 m=(1)
mp2 (\4\:Y \1\:A2 n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.203e-14 ps=8.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=8.65e-07 sd=160n sca=10.9418 \
        scb=0.00782693 scc=8.41447e-05 m=(1)
mp5 (\4\:Y \1\:B2 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=7.203e-14 ps=7.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=4.85e-07 sd=160n sca=11.0076 \
        scb=0.00787274 scc=8.41904e-05 m=(1)
mp3 (n3 \1\:B1 n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.762e-14 \
        ad=1.72e-14 ps=7.8e-07 pd=5.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.08e-06 sb=2.65e-07 sd=160n sca=12.6898 scb=0.00990074 \
        scc=9.48225e-05 m=(1)
mp4 (\1\:VDD \3\:B0 n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.01e-14 ps=5.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=15.0399 \
        scb=0.0139456 scc=0.00018525 m=(1)
C1 (A1 VSS) capacitor c=7.66163e-17
C2 (A0 VSS) capacitor c=2.57534e-17
C3 (Y VSS) capacitor c=1.02532e-16
C4 (B2 VSS) capacitor c=4.27248e-17
C5 (VDD VSS) capacitor c=1.63854e-16
C6 (no VSS) capacitor c=6.43305e-17
C7 (n2 VSS) capacitor c=6.10291e-18
C8 (n4 VSS) capacitor c=2.97781e-19
C9 (\3\:B0 VSS) capacitor c=7.461e-17
C10 (\1\:B1 VSS) capacitor c=6.95324e-17
C11 (\1\:B2 VSS) capacitor c=3.47479e-17
C12 (\1\:A2 VSS) capacitor c=3.94709e-17
C13 (\1\:A1 VSS) capacitor c=7.73384e-17
C14 (\1\:A0 VSS) capacitor c=9.00932e-17
C15 (\1\:B0 VSS) capacitor c=3.66777e-17
C16 (\3\:B1 VSS) capacitor c=5.47641e-17
C17 (\3\:B2 VSS) capacitor c=5.84461e-17
C18 (\3\:A2 VSS) capacitor c=4.58401e-17
C19 (\3\:A1 VSS) capacitor c=5.09082e-17
C20 (\3\:A0 VSS) capacitor c=4.00249e-17
C21 (\2\:B0 VSS) capacitor c=7.19184e-17
C22 (\2\:B1 VSS) capacitor c=8.17109e-17
C23 (\2\:B2 VSS) capacitor c=5.66699e-17
C24 (\2\:A2 VSS) capacitor c=6.12637e-17
C25 (\2\:A1 VSS) capacitor c=8.95814e-17
C26 (\2\:A0 VSS) capacitor c=7.41564e-17
C27 (\1\:VDD VSS) capacitor c=4.0931e-17
C28 (\4\:Y VSS) capacitor c=8.31107e-17
C29 (\6\:VDD VSS) capacitor c=1.46702e-17
C30 (\6\:Y VSS) capacitor c=3.02292e-17
C31 (\5\:no VSS) capacitor c=1.12001e-16
C32 (\1\:Y VSS) capacitor c=7.20292e-17
C33 (\3\:no VSS) capacitor c=1.0318e-16
C34 (\4\:A0 VSS) capacitor c=4.32932e-17
C35 (\4\:A1 VSS) capacitor c=2.54496e-17
C36 (\4\:A2 VSS) capacitor c=1.16934e-16
C37 (\4\:B2 VSS) capacitor c=6.0212e-17
C38 (\4\:B1 VSS) capacitor c=1.11211e-16
C39 (\4\:B0 VSS) capacitor c=1.22268e-16
C40 (\3\:Y VSS) capacitor c=7.05626e-17
C41 (\4\:VDD VSS) capacitor c=3.34873e-17
C42 (\5\:VDD VSS) capacitor c=1.61229e-17
Rk4 (\4\:A1 A1) resistor r=0.02997 c=0
Rk7 (\4\:B1 B1) resistor r=0.002997 c=0
Rk1 (\4\:A0 A0) resistor r=0.08702 c=0
Rk12 (\3\:Y Y) resistor r=0.439 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.3711 c=0
Rk13 (Y \5\:Y) resistor r=0.6486 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.05799 c=0
Rk6 (\4\:B2 B2) resistor r=0.2018 c=0
Rk10 (\4\:B0 B0) resistor r=0.008207 c=0
Rk21 (\4\:VSS VSS) resistor r=0.03715 c=0
Rk20 (\3\:VSS \4\:VSS) resistor r=0.2051 c=0
Rk22 (\3\:VSS \6\:VSS) resistor r=0.1843 c=0
Rk23 (\4\:VSS \8\:VSS) resistor r=0.1793 c=0
Rk15 (\2\:VDD \4\:VDD) resistor r=0.5073 c=0
Rk17 (\5\:VDD VDD) resistor r=0.08728 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.3131 c=0
Rk18 (\5\:VDD \7\:VDD) resistor r=0.1834 c=0
Rk5 (\4\:A2 A2) resistor r=0.002997 c=0
Rk8 (\2\:no \4\:no) resistor r=0.5366 c=0
Rk9 (\4\:no \6\:no) resistor r=0.5703 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=158.384 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=150.692 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=141.076 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=168 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=219.208 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=109.41 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=69.9225 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=239.153 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=215.18 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=96.2379 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=141.076 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=168 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\6\:Y \7\:Y) resistor r=75 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (no \2\:no) resistor r=75 c=0
Rz2 (\3\:no \4\:no) resistor r=75 c=0
Rz3 (\5\:no \6\:no) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
mn0 (no \3\:A0 \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (no \3\:A1 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.18e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\3\:no \3\:A2 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=4.857e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=9.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn5 (\1\:Y \3\:B2 \3\:no VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.537e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=5.65e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y \3\:B1 \5\:no VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=3.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn4 (\6\:Y \1\:B0 \5\:no VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
ends OAI33XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:29 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2X1
// View name: extracted

simulator lang=spectre

subckt OR2X1 A B VDD VSS Y
mp1 (\6\:n0 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=56.6055 \
        scb=0.0430318 scc=0.00645527 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=53.5433 \
        scb=0.0379171 scc=0.00600127 m=(1)
C1 (A VSS) capacitor c=7.17933e-17
C2 (VDD VSS) capacitor c=4.53937e-17
C3 (B VSS) capacitor c=2.99567e-17
C4 (Y VSS) capacitor c=4.7365e-17
C5 (n0 VSS) capacitor c=4.43431e-17
C6 (n1 VSS) capacitor c=9.48821e-19
C7 (\3\:A VSS) capacitor c=5.37917e-17
C8 (\1\:B VSS) capacitor c=5.70167e-17
C9 (\3\:n0 VSS) capacitor c=3.93729e-17
C10 (\1\:A VSS) capacitor c=3.89545e-17
C11 (\4\:B VSS) capacitor c=2.78982e-17
C12 (\2\:n0 VSS) capacitor c=3.60103e-17
C13 (\2\:A VSS) capacitor c=4.95308e-17
C14 (\3\:B VSS) capacitor c=1.57766e-17
C15 (\1\:Y VSS) capacitor c=3.49646e-17
C16 (\1\:VDD VSS) capacitor c=8.26809e-17
C17 (\6\:n0 VSS) capacitor c=6.87481e-17
C18 (\3\:Y VSS) capacitor c=4.8217e-17
C19 (\8\:n0 VSS) capacitor c=2.47413e-17
C20 (\2\:B VSS) capacitor c=2.48493e-17
C21 (\5\:B VSS) capacitor c=3.8239e-17
C22 (\4\:A VSS) capacitor c=6.76579e-17
C23 (\4\:n0 VSS) capacitor c=7.58772e-17
C24 (\5\:n0 VSS) capacitor c=6.37949e-17
C25 (\4\:VDD VSS) capacitor c=1.84662e-17
Rk2 (\4\:A A) resistor r=0.1787 c=0
Rk9 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.4545 c=0
Rk1 (B \5\:B) resistor r=0.04349 c=0
Rk6 (\2\:Y Y) resistor r=0.1673 c=0
Rk7 (Y \4\:Y) resistor r=0.2251 c=0
Rk10 (\2\:VSS VSS) resistor r=0.1107 c=0
Rk11 (VSS \4\:VSS) resistor r=0.1511 c=0
Rk12 (\4\:VSS \6\:VSS) resistor r=0.393 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.2897 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.3221 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.05545 c=0
Rl5 (\2\:A \3\:A) resistor r=26.098 c=0
Rl4 (\1\:A \2\:A) resistor r=43.4057 c=0
Rl1 (\1\:B \2\:B) resistor r=69.5391 c=0
Rl3 (\2\:B \4\:B) resistor r=25.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=9.7447 c=0
Rl6 (n0 \2\:n0) resistor r=41.4826 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=28.0211 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\8\:n0 \4\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.04e-14 ad=2.32e-14 ps=1.45e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn0 (\8\:n0 \1\:A \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.45e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn2 (\3\:Y \3\:n0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.28654e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.27436e-07 sb=1.4e-07 sd=160n sca=45.5228 \
        scb=0.0401019 scc=0.00476865 m=(1)
ends OR2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:30 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2X2
// View name: extracted

simulator lang=spectre

subckt OR2X2 A B VDD VSS Y
mp1 (\9\:n0 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=2.63e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.45e-07 sd=160n sca=35.2408 \
        scb=0.036114 scc=0.00353857 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.27326e-07 sb=5.4e-07 sd=160n sca=31.5798 \
        scb=0.0296345 scc=0.00310241 m=(1)
C1 (A VSS) capacitor c=6.43293e-17
C2 (B VSS) capacitor c=4.24822e-17
C3 (Y VSS) capacitor c=5.60764e-17
C4 (VDD VSS) capacitor c=5.97683e-17
C5 (n0 VSS) capacitor c=1.57073e-16
C6 (n1 VSS) capacitor c=2.34162e-18
C7 (\1\:A VSS) capacitor c=5.72843e-17
C8 (\1\:B VSS) capacitor c=6.73692e-17
C9 (\3\:A VSS) capacitor c=4.20589e-17
C10 (\4\:B VSS) capacitor c=2.45876e-17
C11 (\2\:A VSS) capacitor c=5.81748e-17
C12 (\3\:B VSS) capacitor c=1.28788e-17
C13 (\1\:VDD VSS) capacitor c=9.44473e-17
C14 (\1\:Y VSS) capacitor c=4.79837e-17
C15 (\9\:n0 VSS) capacitor c=4.44001e-17
C16 (\3\:Y VSS) capacitor c=2.61122e-17
C17 (\11\:n0 VSS) capacitor c=3.53929e-17
C18 (\2\:B VSS) capacitor c=3.61184e-17
C19 (\5\:B VSS) capacitor c=4.83408e-17
C20 (\4\:A VSS) capacitor c=8.62169e-17
C21 (\7\:n0 VSS) capacitor c=7.19892e-17
C22 (\8\:n0 VSS) capacitor c=1.07528e-16
Rk2 (\4\:A A) resistor r=0.1524 c=0
Rk12 (\1\:VSS VSS) resistor r=0.2016 c=0
Rk14 (VSS \8\:VSS) resistor r=0.08557 c=0
Rk1 (B \5\:B) resistor r=0.1051 c=0
Rk6 (\2\:Y Y) resistor r=0.2027 c=0
Rk7 (Y \4\:Y) resistor r=0.2241 c=0
Rk9 (\1\:VDD VDD) resistor r=0.2006 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3016 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.3347 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.1024 c=0
Rl4 (\1\:A \2\:A) resistor r=48.7687 c=0
Rl5 (\2\:A \3\:A) resistor r=75.6918 c=0
Rl1 (\1\:B \2\:B) resistor r=131.078 c=0
Rl3 (\2\:B \4\:B) resistor r=23.7402 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rz6 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry1 (\10\:n0 \9\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\11\:n0 \4\:B \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.32e-14 ps=1.32e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.45e-07 sd=160n sca=12.2839 scb=0.0124725 \
        scc=0.000542081 m=(1)
mn0 (\11\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.521e-14 ad=4.16e-14 ps=1.19e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45385e-07 sb=3.05e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(2)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.363e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17692e-07 sb=3.05e-07 sd=160n sca=24.1823 \
        scb=0.0219058 scc=0.0017667 m=(2)
ends OR2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:31 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2X4
// View name: extracted

simulator lang=spectre

subckt OR2X4 A B VDD VSS Y
mp1 (\16\:n0 \1\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.095e-06 sd=160n sca=18.2281 \
        scb=0.0183524 scc=0.000740229 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.9e-07 sd=160n sca=16.2105 \
        scb=0.0148596 scc=0.000661709 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.7e-07 sd=160n sca=14.5024 \
        scb=0.0125934 scc=0.000647761 m=(4)
C1 (A VSS) capacitor c=5.2396e-17
C2 (VDD VSS) capacitor c=9.38269e-17
C3 (Y VSS) capacitor c=3.37762e-17
C4 (B VSS) capacitor c=5.79227e-17
C5 (n0 VSS) capacitor c=3.90439e-16
C6 (n1 VSS) capacitor c=1.04006e-18
C7 (\1\:A VSS) capacitor c=8.11036e-17
C8 (\1\:B VSS) capacitor c=8.72247e-17
C9 (\3\:A VSS) capacitor c=5.16512e-17
C10 (\4\:B VSS) capacitor c=3.47015e-17
C11 (\2\:A VSS) capacitor c=5.72131e-17
C12 (\3\:B VSS) capacitor c=1.35915e-17
C13 (\1\:VDD VSS) capacitor c=2.37654e-16
C14 (\1\:Y VSS) capacitor c=2.51803e-16
C15 (\16\:n0 VSS) capacitor c=9.92402e-17
C16 (\18\:n0 VSS) capacitor c=4.91262e-17
C17 (\2\:B VSS) capacitor c=4.61273e-17
C18 (\5\:B VSS) capacitor c=4.12032e-17
C19 (\4\:A VSS) capacitor c=5.93755e-17
C20 (\15\:n0 VSS) capacitor c=1.05267e-16
C21 (\4\:Y VSS) capacitor c=2.05416e-16
Rk2 (\4\:A A) resistor r=0.1336 c=0
Rk16 (\1\:VDD VDD) resistor r=0.2355 c=0
Rk8 (\1\:Y Y) resistor r=0.1468 c=0
Rk9 (Y \4\:Y) resistor r=0.1025 c=0
Rk1 (\5\:B B) resistor r=0.1316 c=0
Rk23 (\7\:VSS VSS) resistor r=0.02968 c=0
Rk22 (\1\:VSS \7\:VSS) resistor r=0.2055 c=0
Rk26 (\7\:VSS \13\:VSS) resistor r=0.2327 c=0
Rk4 (n0 \15\:n0) resistor r=0.3857 c=0
Rk5 (\15\:n0 \17\:n0) resistor r=0.405 c=0
Rk6 (\15\:n0 \19\:n0) resistor r=0.1942 c=0
Rl4 (\1\:A \2\:A) resistor r=69.9225 c=0
Rl5 (\2\:A \3\:A) resistor r=106.461 c=0
Rl1 (\1\:B \2\:B) resistor r=156.078 c=0
Rl3 (\2\:B \4\:B) resistor r=50.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=7.3511 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=37.5 c=0
Ry1 (\17\:n0 \16\:n0) resistor r=20.6667 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
mn1 (\18\:n0 \4\:B \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\18\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.323e-14 ad=4.16e-14 ps=8.525e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.7e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
ends OR2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:32 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2X6
// View name: extracted

simulator lang=spectre

subckt OR2X6 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.68e-06 sd=160n sca=18.0856 \
        scb=0.0187649 scc=0.00060075 m=(1)
mp1_1__rcx (\23\:n0 \5\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.545e-06 sd=160n sca=15.1734 \
        scb=0.013698 scc=0.000458097 m=(1)
mp1 (\23\:n0 \1\:B 4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.8e-07 \
        sb=1.34e-06 sd=160n sca=13.4386 scb=0.0114697 scc=0.000444227 \
        m=(1)
mp0 (4 \6\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=2.34e-14 ps=1.4e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.235e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
C1 (A VSS) capacitor c=2.66716e-17
C2 (VDD VSS) capacitor c=1.1077e-16
C3 (Y VSS) capacitor c=2.24538e-17
C4 (B VSS) capacitor c=3.48008e-17
C5 (n0 VSS) capacitor c=4.29497e-16
C6 (2 VSS) capacitor c=1.21067e-18
C7 (4 VSS) capacitor c=1.33527e-18
C8 (\6\:A VSS) capacitor c=8.68457e-17
C9 (\1\:B VSS) capacitor c=7.70357e-17
C10 (\5\:B VSS) capacitor c=4.23577e-17
C11 (\1\:A VSS) capacitor c=5.95335e-17
C12 (\2\:B VSS) capacitor c=2.93177e-17
C13 (\2\:A VSS) capacitor c=3.59883e-16
C14 (\1\:Y VSS) capacitor c=2.88429e-16
C15 (\1\:VDD VSS) capacitor c=2.86926e-16
C16 (\23\:n0 VSS) capacitor c=9.37255e-17
C17 (\12\:VDD VSS) capacitor c=4.36101e-17
C18 (\3\:B VSS) capacitor c=9.77736e-17
C19 (\7\:B VSS) capacitor c=3.63971e-17
C20 (\19\:n0 VSS) capacitor c=1.21403e-16
C21 (\20\:n0 VSS) capacitor c=2.34948e-16
C22 (\4\:Y VSS) capacitor c=2.99725e-16
C23 (\7\:VDD VSS) capacitor c=1.5657e-17
Rk37 (VSS \15\:VSS) resistor r=0.3168 c=0
Rk3 (\2\:A A) resistor r=0.01427 c=0
Rk25 (\7\:VDD VDD) resistor r=0.06481 c=0
Rk24 (\1\:VDD \7\:VDD) resistor r=0.3259 c=0
Rk28 (\7\:VDD \13\:VDD) resistor r=0.3 c=0
Rk20 (\4\:Y Y) resistor r=0.06242 c=0
Rk11 (\1\:Y \4\:Y) resistor r=0.1348 c=0
Rk1 (B \7\:B) resistor r=0.04792 c=0
Rk5 (n0 \19\:n0) resistor r=0.2354 c=0
Rk6 (\19\:n0 \20\:n0) resistor r=0.3061 c=0
Rk8 (\19\:n0 \24\:n0) resistor r=0.6687 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=37.5 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry1 (\24\:n0 \23\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn1 (\20\:n0 \3\:B \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.59e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn0_1__rcx (\20\:n0 \2\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=4.355e-14 ps=8.85e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.81e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn2_1__rcx (\4\:Y n0 VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.978e-14 ad=4.836e-14 ps=9.46e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.46452e-07 sb=9.6e-07 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mp2_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=7.332e-14 ps=1.288e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30638e-07 sb=9.6e-07 sd=160n sca=16.497 \
        scb=0.0142421 scc=0.00124485 m=(5)
ends OR2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:34 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2X8
// View name: extracted

simulator lang=spectre

subckt OR2X8 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.0856 scb=0.0187649 \
        scc=0.00060075 m=(1)
mp1_1__rcx (\30\:n0 \5\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.955e-06 sd=160n sca=15.1734 \
        scb=0.013698 scc=0.000458097 m=(1)
mp1 (\30\:n0 \1\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.8e-07 \
        sb=1.75e-06 sd=160n sca=13.4386 scb=0.0114697 scc=0.000444227 \
        m=(1)
mp0 (5 \6\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.57e-14 ad=2.34e-14 ps=1.36e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.645e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
C1 (A VSS) capacitor c=2.4612e-17
C2 (Y VSS) capacitor c=1.97285e-17
C3 (VDD VSS) capacitor c=1.44053e-16
C4 (B VSS) capacitor c=3.56816e-17
C5 (n0 VSS) capacitor c=6.32827e-16
C6 (2 VSS) capacitor c=1.2068e-18
C7 (5 VSS) capacitor c=1.33304e-18
C8 (\6\:A VSS) capacitor c=8.68428e-17
C9 (\1\:B VSS) capacitor c=7.69941e-17
C10 (\5\:B VSS) capacitor c=4.23158e-17
C11 (\1\:A VSS) capacitor c=5.95434e-17
C12 (\2\:B VSS) capacitor c=2.91966e-17
C13 (\2\:A VSS) capacitor c=3.58986e-16
C14 (\1\:Y VSS) capacitor c=4.21908e-16
C15 (\30\:n0 VSS) capacitor c=9.40942e-17
C16 (\17\:VDD VSS) capacitor c=4.23443e-17
C17 (\1\:VDD VSS) capacitor c=2.75184e-17
C18 (\3\:B VSS) capacitor c=9.77709e-17
C19 (\7\:B VSS) capacitor c=3.61177e-17
C20 (\26\:n0 VSS) capacitor c=1.20677e-16
C21 (\27\:n0 VSS) capacitor c=2.34589e-16
C22 (\4\:Y VSS) capacitor c=4.37485e-16
C23 (\3\:VDD VSS) capacitor c=3.47066e-16
C24 (\8\:VDD VSS) capacitor c=1.56784e-17
Rk38 (\2\:VSS VSS) resistor r=0.1605 c=0
Rk50 (VSS \20\:VSS) resistor r=0.3178 c=0
Rk3 (\2\:A A) resistor r=0.01429 c=0
Rk25 (\4\:Y Y) resistor r=0.05758 c=0
Rk12 (\1\:Y \4\:Y) resistor r=0.1288 c=0
Rk26 (\2\:VDD \3\:VDD) resistor r=0.1605 c=0
Rk32 (\8\:VDD VDD) resistor r=0.06483 c=0
Rk31 (\3\:VDD \8\:VDD) resistor r=0.326 c=0
Rk37 (\8\:VDD \18\:VDD) resistor r=0.3009 c=0
Rk1 (B \7\:B) resistor r=0.04793 c=0
Rk6 (n0 \26\:n0) resistor r=0.2362 c=0
Rk7 (\26\:n0 \27\:n0) resistor r=0.3069 c=0
Rk9 (\26\:n0 \31\:n0) resistor r=0.6715 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz14 (\20\:VSS \19\:VSS) resistor r=37.5 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz8 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry12 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry1 (\31\:n0 \30\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0_1__rcx (\27\:n0 \2\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=4.355e-14 ps=8.75e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn1 (\27\:n0 \3\:B \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn2_1__rcx (\4\:Y n0 VSS VSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.821e-14 ad=4.714e-14 ps=9.2429e-07 pd=9.1429e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.71333e-07 sb=1.37e-06 sd=160n sca=15.1988 \
        scb=0.0148036 scc=0.00121652 m=(7)
mp2_1__rcx (\1\:Y n0 \3\:VDD VDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.539e-14 ad=7.071e-14 ps=1.24e-06 pd=1.21429e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.58667e-07 sb=1.37e-06 sd=160n sca=15.101 \
        scb=0.013378 scc=0.000967521 m=(7)
ends OR2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:35 2013 )
// Library name: gsclib045_hvt
// Cell name: OR2XL
// View name: extracted

simulator lang=spectre

subckt OR2XL A B VDD VSS Y
mp1 (\7\:n0 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=33.4025 \
        scb=0.0357193 scc=0.00295004 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=30.554 \
        scb=0.0308989 scc=0.00253599 m=(1)
mp2 (\3\:Y n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=35.6113 \
        scb=0.0387304 scc=0.00336179 m=(1)
C1 (A VSS) capacitor c=6.32582e-17
C2 (Y VSS) capacitor c=3.92013e-17
C3 (B VSS) capacitor c=2.98766e-17
C4 (VDD VSS) capacitor c=5.35883e-17
C5 (n0 VSS) capacitor c=4.14599e-17
C6 (n1 VSS) capacitor c=1.01303e-18
C7 (\1\:A VSS) capacitor c=5.34902e-17
C8 (\1\:B VSS) capacitor c=6.45544e-17
C9 (\3\:n0 VSS) capacitor c=3.23313e-17
C10 (\3\:A VSS) capacitor c=5.03122e-17
C11 (\4\:B VSS) capacitor c=2.86088e-17
C12 (\2\:n0 VSS) capacitor c=3.45433e-17
C13 (\2\:A VSS) capacitor c=5.5723e-17
C14 (\3\:B VSS) capacitor c=1.20072e-17
C15 (\3\:Y VSS) capacitor c=2.75928e-17
C16 (\1\:VDD VSS) capacitor c=3.83653e-17
C17 (\7\:n0 VSS) capacitor c=4.85782e-17
C18 (\1\:Y VSS) capacitor c=3.60123e-17
C19 (\4\:n0 VSS) capacitor c=1.3289e-17
C20 (\2\:B VSS) capacitor c=3.38542e-17
C21 (\5\:B VSS) capacitor c=3.43006e-17
C22 (\4\:A VSS) capacitor c=3.60364e-17
C23 (\6\:n0 VSS) capacitor c=6.50724e-17
C24 (\9\:n0 VSS) capacitor c=5.67076e-17
C25 (\4\:VDD VSS) capacitor c=1.28254e-17
Rk2 (\4\:A A) resistor r=0.05173 c=0
Rk6 (\2\:Y Y) resistor r=0.2341 c=0
Rk7 (Y \4\:Y) resistor r=0.1131 c=0
Rk9 (\4\:VSS VSS) resistor r=0.1509 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.1159 c=0
Rk10 (VSS \6\:VSS) resistor r=0.07913 c=0
Rk1 (B \5\:B) resistor r=0.09876 c=0
Rk12 (\4\:VDD VDD) resistor r=0.1501 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.4078 c=0
Rk3 (\5\:n0 \6\:n0) resistor r=0.1202 c=0
Rk4 (\6\:n0 \8\:n0) resistor r=0.4183 c=0
Rk5 (\6\:n0 \9\:n0) resistor r=0.1765 c=0
Rl4 (\1\:A \2\:A) resistor r=31.461 c=0
Rl5 (\2\:A \3\:A) resistor r=100.692 c=0
Rl1 (\1\:B \2\:B) resistor r=125.308 c=0
Rl3 (\2\:B \4\:B) resistor r=37.2017 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl6 (n0 \2\:n0) resistor r=100.692 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=31.461 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\2\:n0 \9\:n0) resistor r=45 c=0
mn1 (\4\:n0 \4\:B \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.32e-14 ps=1.32e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.6e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn0 (\4\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn2 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.175e-14 ps=1.41e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
ends OR2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:36 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3X1
// View name: extracted

simulator lang=spectre

subckt OR3X1 A B C VDD VSS Y
mp2 (\11\:n0 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=25.9711 scb=0.030099 \
        scc=0.00176698 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.548e-14 \
        ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=5.95e-07 sd=160n sca=16.3573 scb=0.0155593 \
        scc=0.000402391 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=3.548e-14 ps=1.18e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=15.0007 \
        scb=0.0128338 scc=0.000363258 m=(1)
C1 (Y VSS) capacitor c=1.96131e-17
C2 (C VSS) capacitor c=3.48191e-17
C3 (A VSS) capacitor c=4.58283e-17
C4 (VDD VSS) capacitor c=8.65599e-17
C5 (n0 VSS) capacitor c=4.91402e-17
C6 (n2 VSS) capacitor c=9.4585e-18
C7 (n1 VSS) capacitor c=6.32316e-18
C8 (\1\:A VSS) capacitor c=5.29623e-17
C9 (\1\:B VSS) capacitor c=3.84031e-17
C10 (\1\:C VSS) capacitor c=4.98552e-17
C11 (\3\:n0 VSS) capacitor c=3.61473e-17
C12 (\3\:A VSS) capacitor c=4.1036e-17
C13 (\4\:B VSS) capacitor c=5.28242e-17
C14 (\4\:C VSS) capacitor c=3.50314e-17
C15 (\2\:n0 VSS) capacitor c=2.50019e-17
C16 (\2\:A VSS) capacitor c=4.75731e-17
C17 (\3\:B VSS) capacitor c=2.49242e-17
C18 (\3\:C VSS) capacitor c=1.39237e-17
C19 (\3\:Y VSS) capacitor c=6.54793e-17
C20 (\1\:VDD VSS) capacitor c=4.54255e-17
C21 (\11\:n0 VSS) capacitor c=8.5091e-17
C22 (\1\:Y VSS) capacitor c=7.06836e-17
C23 (\9\:n0 VSS) capacitor c=2.99653e-17
C24 (\7\:n0 VSS) capacitor c=5.85463e-17
C25 (\2\:C VSS) capacitor c=4.26937e-17
C26 (\2\:B VSS) capacitor c=4.12838e-17
C27 (\5\:C VSS) capacitor c=1.88198e-17
C28 (\5\:B VSS) capacitor c=3.19861e-17
C29 (\7\:B VSS) capacitor c=4.91384e-17
C30 (\4\:A VSS) capacitor c=4.71826e-17
C31 (\4\:n0 VSS) capacitor c=7.90044e-17
C32 (\6\:n0 VSS) capacitor c=1.48933e-16
C33 (\4\:VDD VSS) capacitor c=2.34686e-17
Rk11 (Y \2\:Y) resistor r=0.05713 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.4047 c=0
Rk1 (C \5\:C) resistor r=0.01625 c=0
Rk5 (A \4\:A) resistor r=0.09354 c=0
Rk14 (\4\:VDD VDD) resistor r=0.2504 c=0
Rk13 (\2\:VDD \4\:VDD) resistor r=0.3947 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.3022 c=0
Rk17 (\5\:VSS VSS) resistor r=0.1023 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1477 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.2428 c=0
Rk2 (\5\:B \6\:B) resistor r=0.005209 c=0
Rk3 (B \7\:B) resistor r=0.005093 c=0
Rk4 (\5\:B \7\:B) resistor r=0.07853 c=0
Rk6 (\4\:n0 \5\:n0) resistor r=0.3674 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.04641 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.3505 c=0
Rk9 (\5\:n0 \10\:n0) resistor r=0.07643 c=0
Rk10 (\6\:n0 \12\:n0) resistor r=0.7331 c=0
Rl1 (\1\:C \2\:C) resistor r=141.187 c=0
Rl3 (\2\:C \4\:C) resistor r=85.4181 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl7 (\1\:A \2\:A) resistor r=133.384 c=0
Rl8 (\2\:A \3\:A) resistor r=77.6149 c=0
Rl4 (\1\:B \2\:B) resistor r=68.1104 c=0
Rl6 (\2\:B \4\:B) resistor r=158.495 c=0
Rl5 (\2\:B \3\:B) resistor r=1.8551 c=0
Rl9 (n0 \2\:n0) resistor r=66.0764 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=33.3841 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\11\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\3\:B \6\:B) resistor r=45 c=0
Rx4 (\2\:n0 \4\:n0) resistor r=45 c=0
mn2 (\7\:n0 \4\:C \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn1 (\9\:n0 \4\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.95e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn0 (\9\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=2.393e-14 ps=9.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn3 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.90385e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp3 (\3\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=5.46e-14 ps=1.18e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.03846e-07 sb=1.4e-07 sd=160n sca=32.724 \
        scb=0.0269508 scc=0.00310791 m=(1)
ends OR3X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:37 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3X2
// View name: extracted

simulator lang=spectre

subckt OR3X2 A B C VDD VSS Y
mp2 (\15\:n0 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05e-06 sd=160n sca=25.9711 \
        scb=0.030099 scc=0.00176698 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.655e-14 \
        ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=8.45e-07 sd=160n sca=15.9373 scb=0.0154264 \
        scc=0.000402358 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=6.3e-07 sd=160n sca=13.9701 \
        scb=0.0119484 scc=0.000361488 m=(1)
C1 (C VSS) capacitor c=2.88828e-17
C2 (A VSS) capacitor c=7.64402e-17
C3 (VDD VSS) capacitor c=9.33752e-17
C4 (B VSS) capacitor c=3.07466e-17
C5 (n0 VSS) capacitor c=1.75401e-16
C6 (n2 VSS) capacitor c=5.11997e-18
C7 (n1 VSS) capacitor c=7.68444e-18
C8 (\3\:A VSS) capacitor c=5.57996e-17
C9 (\1\:B VSS) capacitor c=4.19314e-17
C10 (\1\:C VSS) capacitor c=4.83244e-17
C11 (\1\:A VSS) capacitor c=4.06474e-17
C12 (\4\:B VSS) capacitor c=5.35893e-17
C13 (\4\:C VSS) capacitor c=3.86158e-17
C14 (\2\:A VSS) capacitor c=6.51792e-17
C15 (\3\:B VSS) capacitor c=2.83231e-17
C16 (\3\:C VSS) capacitor c=1.68262e-17
C17 (\1\:VDD VSS) capacitor c=1.09769e-16
C18 (\2\:Y VSS) capacitor c=7.81703e-17
C19 (\15\:n0 VSS) capacitor c=7.86272e-17
C20 (\4\:Y VSS) capacitor c=6.08426e-17
C21 (\13\:n0 VSS) capacitor c=2.72943e-17
C22 (\11\:n0 VSS) capacitor c=5.40998e-17
C23 (\2\:C VSS) capacitor c=4.46071e-17
C24 (\2\:B VSS) capacitor c=4.12343e-17
C25 (\5\:C VSS) capacitor c=4.15819e-17
C26 (\5\:B VSS) capacitor c=5.88357e-17
C27 (\8\:n0 VSS) capacitor c=6.31827e-17
C28 (\9\:n0 VSS) capacitor c=2.73322e-17
C29 (\10\:n0 VSS) capacitor c=1.13847e-16
C30 (\1\:Y VSS) capacitor c=5.33783e-17
Rk9 (Y \1\:Y) resistor r=0.02462 c=0
Rk10 (\1\:Y \3\:Y) resistor r=0.3696 c=0
Rk11 (\1\:Y \5\:Y) resistor r=0.2381 c=0
Rk1 (C \5\:C) resistor r=0.1167 c=0
Rk3 (\4\:A A) resistor r=0.004839 c=0
Rk19 (\1\:VDD VDD) resistor r=0.3004 c=0
Rk14 (\5\:VSS VSS) resistor r=0.1023 c=0
Rk13 (\1\:VSS \5\:VSS) resistor r=0.1978 c=0
Rk16 (\5\:VSS \9\:VSS) resistor r=0.1755 c=0
Rk2 (B \5\:B) resistor r=0.1047 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.3198 c=0
Rk5 (\9\:n0 \10\:n0) resistor r=0.04884 c=0
Rk6 (\10\:n0 \12\:n0) resistor r=0.3857 c=0
Rk7 (\9\:n0 \14\:n0) resistor r=0.09798 c=0
Rk8 (\10\:n0 \16\:n0) resistor r=0.7681 c=0
Rl1 (\1\:C \2\:C) resistor r=154.649 c=0
Rl3 (\2\:C \4\:C) resistor r=108.495 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl8 (\2\:A \3\:A) resistor r=145.69 c=0
Rl7 (\1\:A \2\:A) resistor r=101.718 c=0
Rl4 (\1\:B \2\:B) resistor r=85.4181 c=0
Rl6 (\2\:B \4\:B) resistor r=177.726 c=0
Rl5 (\2\:B \3\:B) resistor r=3.1183 c=0
Rz3 (\5\:Y \4\:Y) resistor r=37.5 c=0
Rz6 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Rz2 (\14\:n0 \13\:n0) resistor r=75 c=0
Ry2 (\3\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\16\:n0 \15\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\3\:B \5\:B) resistor r=45 c=0
Rx4 (\8\:n0 n0) resistor r=45 c=0
mn2 (\11\:n0 \4\:C \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.095e-06 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\13\:n0 \4\:B \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.972e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\13\:n0 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.775e-14 ad=2.972e-14 ps=1.02e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=6.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.207e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.40577e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp3 (\2\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.973e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.0109e-07 sb=3.95e-07 sd=160n sca=29.1463 \
        scb=0.0209237 scc=0.00296778 m=(2)
ends OR3X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:38 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3X4
// View name: extracted

simulator lang=spectre

subckt OR3X4 A B C VDD VSS Y
mp2 (\19\:n0 \1\:C n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=22.1268 \
        scb=0.0251863 scc=0.00108449 m=(1)
mp1 (n2 \3\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=9.36e-14 \
        ad=2.34e-14 ps=1.26e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.245e-06 sd=160n sca=16.9551 scb=0.0171783 \
        scc=0.000423515 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.36e-14 ps=1.1e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=9.6e-07 sd=160n sca=12.8811 \
        scb=0.0106724 scc=0.000292552 m=(1)
mp3 (\2\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.55e-07 sd=160n sca=12.0193 \
        scb=0.0100773 scc=0.000291813 m=(4)
C1 (VDD VSS) capacitor c=1.35446e-16
C2 (C VSS) capacitor c=3.20123e-17
C3 (A VSS) capacitor c=4.49851e-17
C4 (Y VSS) capacitor c=1.95039e-17
C5 (B VSS) capacitor c=6.64999e-17
C6 (n0 VSS) capacitor c=3.72855e-16
C7 (n2 VSS) capacitor c=6.99106e-18
C8 (n1 VSS) capacitor c=1.03954e-17
C9 (\3\:A VSS) capacitor c=4.9826e-17
C10 (\3\:B VSS) capacitor c=8.40416e-17
C11 (\1\:C VSS) capacitor c=8.80416e-17
C12 (\4\:A VSS) capacitor c=4.98395e-17
C13 (\1\:B VSS) capacitor c=4.82335e-17
C14 (\4\:C VSS) capacitor c=3.78354e-17
C15 (\2\:B VSS) capacitor c=6.73861e-17
C16 (\3\:C VSS) capacitor c=1.67417e-17
C17 (\1\:VDD VSS) capacitor c=2.30602e-16
C18 (\19\:n0 VSS) capacitor c=8.26719e-17
C19 (\21\:n0 VSS) capacitor c=3.11698e-17
C20 (\17\:n0 VSS) capacitor c=4.82835e-17
C21 (\2\:C VSS) capacitor c=4.54984e-17
C22 (\2\:A VSS) capacitor c=4.78185e-17
C23 (\5\:C VSS) capacitor c=3.08648e-17
C24 (\4\:B VSS) capacitor c=4.52407e-17
C25 (\5\:A VSS) capacitor c=4.79367e-17
C26 (\15\:n0 VSS) capacitor c=1.49461e-16
C27 (\16\:n0 VSS) capacitor c=3.17585e-17
C28 (\1\:Y VSS) capacitor c=3.07743e-17
C29 (\2\:Y VSS) capacitor c=2.34572e-16
C30 (\5\:Y VSS) capacitor c=1.69831e-16
Rk21 (\7\:VSS VSS) resistor r=0.1124 c=0
Rk20 (\1\:VSS \7\:VSS) resistor r=0.2053 c=0
Rk24 (\7\:VSS \13\:VSS) resistor r=0.1811 c=0
Rk28 (\1\:VDD VDD) resistor r=0.3156 c=0
Rk1 (C \5\:C) resistor r=0.1112 c=0
Rk3 (A \5\:A) resistor r=0.1472 c=0
Rk10 (Y \1\:Y) resistor r=0.005323 c=0
Rk11 (\1\:Y \2\:Y) resistor r=0.2944 c=0
Rk13 (\1\:Y \5\:Y) resistor r=0.2054 c=0
Rk2 (\4\:B B) resistor r=0.194 c=0
Rk5 (n0 \15\:n0) resistor r=0.3625 c=0
Rk6 (\15\:n0 \16\:n0) resistor r=0.1086 c=0
Rk7 (\16\:n0 \18\:n0) resistor r=0.3418 c=0
Rk8 (\15\:n0 \20\:n0) resistor r=0.7963 c=0
Rk9 (\16\:n0 \22\:n0) resistor r=0.09038 c=0
Rl1 (\1\:C \2\:C) resistor r=151.157 c=0
Rl3 (\2\:C \4\:C) resistor r=68.7458 c=0
Rl2 (\2\:C \3\:C) resistor r=10.2762 c=0
Rl7 (\2\:A \3\:A) resistor r=100.412 c=0
Rl8 (\2\:A \4\:A) resistor r=116.083 c=0
Rl6 (\1\:A \2\:A) resistor r=2.0692 c=0
Rl5 (\2\:B \3\:B) resistor r=118.407 c=0
Rl4 (\1\:B \2\:B) resistor r=80.5087 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\18\:n0 \17\:n0) resistor r=37.5 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=37.5 c=0
Ry1 (\20\:n0 \19\:n0) resistor r=31 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\1\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn2 (\17\:n0 \4\:C \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\21\:n0 \1\:B \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.23e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\21\:n0 \4\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.025e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\5\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.355e-14 ps=8.55e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
ends OR3X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:39 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3X6
// View name: extracted

simulator lang=spectre

subckt OR3X6 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.2198 scb=0.0165162 \
        scc=0.00111264 m=(1)
mp1_1__rcx (3 \1\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.96e-06 sd=160n sca=17.2297 \
        scb=0.0151721 scc=0.00110421 m=(1)
mp2_1__rcx (\21\:n0 \5\:C 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.695e-06 sd=160n sca=16.0668 \
        scb=0.0143054 scc=0.00110277 m=(1)
mp2 (\21\:n0 \1\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.49e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp1 (6 \4\:B 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.68e-14 \
        ad=4.485e-14 ps=1.02e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.75e-07 sb=1.33e-06 sd=160n sca=15.8351 scb=0.0142471 \
        scc=0.00110276 m=(1)
mp0 (7 \6\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.04e-14 ad=4.68e-14 ps=1.26e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.165e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
C1 (A VSS) capacitor c=4.63712e-16
C2 (VDD VSS) capacitor c=9.43233e-17
C3 (B VSS) capacitor c=2.85838e-17
C4 (C VSS) capacitor c=5.55892e-17
C5 (n0 VSS) capacitor c=3.78482e-16
C6 (5 VSS) capacitor c=5.29833e-18
C7 (6 VSS) capacitor c=3.40734e-18
C8 (7 VSS) capacitor c=4.02839e-18
C9 (\6\:A VSS) capacitor c=7.67704e-17
C10 (\4\:B VSS) capacitor c=6.93169e-17
C11 (\1\:C VSS) capacitor c=5.01241e-17
C12 (\5\:C VSS) capacitor c=2.31745e-17
C13 (\1\:B VSS) capacitor c=8.1727e-17
C14 (\1\:A VSS) capacitor c=8.6689e-17
C15 (\2\:C VSS) capacitor c=2.32578e-17
C16 (\2\:B VSS) capacitor c=3.72938e-16
C17 (\21\:n0 VSS) capacitor c=8.80718e-17
C18 (\14\:VDD VSS) capacitor c=3.64428e-17
C19 (\1\:VDD VSS) capacitor c=3.54928e-17
C20 (\1\:Y VSS) capacitor c=1.9293e-16
C21 (\23\:n0 VSS) capacitor c=1.60238e-16
C22 (\25\:n0 VSS) capacitor c=8.83724e-17
C23 (\3\:C VSS) capacitor c=1.055e-16
C24 (\7\:C VSS) capacitor c=5.1355e-17
C25 (\20\:n0 VSS) capacitor c=1.02521e-16
C26 (\4\:Y VSS) capacitor c=2.83232e-16
C27 (\3\:VDD VSS) capacitor c=2.19625e-16
C28 (\7\:VDD VSS) capacitor c=1.74177e-17
Rk37 (\2\:VDD \3\:VDD) resistor r=0.1451 c=0
Rk40 (\3\:VDD \6\:VDD) resistor r=0.1451 c=0
Rk42 (\7\:VDD VDD) resistor r=0.1424 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.4082 c=0
Rk46 (\7\:VDD \15\:VDD) resistor r=0.3354 c=0
Rk2 (B \2\:B) resistor r=0.0343 c=0
Rk15 (\1\:Y Y) resistor r=0.02579 c=0
Rk16 (Y \4\:Y) resistor r=0.1697 c=0
Rk30 (\3\:VSS VSS) resistor r=0.03965 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.06495 c=0
Rk1 (\7\:C C) resistor r=0.1956 c=0
Rk8 (n0 \20\:n0) resistor r=0.2124 c=0
Rk10 (\20\:n0 \23\:n0) resistor r=0.4007 c=0
Rk9 (\20\:n0 \22\:n0) resistor r=0.5856 c=0
Rk13 (\22\:n0 \29\:n0) resistor r=0.146 c=0
Rl13 (A \6\:A) resistor r=99.4612 c=0
Rl1 (A \1\:A) resistor r=143.796 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl5 (\2\:C \1\:C) resistor r=77.4283 c=0
Rl8 (\2\:C \5\:C) resistor r=21.9171 c=0
Rl6 (\3\:C \2\:C) resistor r=58.1371 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz14 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\25\:n0 \23\:n0) resistor r=75 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\22\:n0 \21\:n0) resistor r=62 c=0
Ry2 (\29\:n0 \21\:n0) resistor r=62 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn2 (\25\:n0 \3\:C \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.48e-14 ad=4.16e-14 ps=1.42e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.78846e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn0 (\23\:n0 A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=4.16e-14 ps=1.2e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.89462e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn1 (\23\:n0 \2\:B \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.48e-14 ad=4.16e-14 ps=1.42e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.86308e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn3_1__rcx (\1\:Y n0 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.548e-14 ad=4.836e-14 ps=1.12e-06 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12903e-06 sb=1.02e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mp3_1__rcx (\4\:Y n0 \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.05011e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends OR3X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:40 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3X8
// View name: extracted

simulator lang=spectre

subckt OR3X8 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.1638 scb=0.0188942 \
        scc=0.00161316 m=(1)
mp1_1__rcx (3 \1\:B 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=20.0067 scb=0.0171911 \
        scc=0.00159866 m=(1)
mp2_1__rcx (\35\:n0 \5\:C 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2e-06 sd=160n sca=18.6931 scb=0.0160768 \
        scc=0.00159617 m=(1)
mp2 (\35\:n0 \1\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.9e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp1 (6 \4\:B 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.68e-14 \
        ad=4.485e-14 ps=1.02e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.75e-07 sb=1.74e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0 (7 \6\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.79e-14 ad=4.68e-14 ps=1.21e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
C1 (VDD VSS) capacitor c=1.00489e-16
C2 (B VSS) capacitor c=3.66588e-17
C3 (Y VSS) capacitor c=1.20997e-17
C4 (C VSS) capacitor c=3.28136e-17
C5 (n0 VSS) capacitor c=5.34368e-16
C6 (5 VSS) capacitor c=5.41575e-18
C7 (6 VSS) capacitor c=3.36624e-18
C8 (7 VSS) capacitor c=4.14525e-18
C9 (\6\:A VSS) capacitor c=7.45721e-17
C10 (\4\:B VSS) capacitor c=6.91757e-17
C11 (\1\:C VSS) capacitor c=5.00663e-17
C12 (\5\:C VSS) capacitor c=2.29198e-17
C13 (\1\:B VSS) capacitor c=8.14141e-17
C14 (\1\:A VSS) capacitor c=8.40301e-17
C15 (\2\:C VSS) capacitor c=2.29606e-17
C16 (\2\:B VSS) capacitor c=3.66559e-16
C17 (\2\:A VSS) capacitor c=4.66937e-16
C18 (\1\:Y VSS) capacitor c=4.08517e-16
C19 (\35\:n0 VSS) capacitor c=8.78277e-17
C20 (\17\:VDD VSS) capacitor c=3.72575e-17
C21 (\1\:VDD VSS) capacitor c=3.50369e-17
C22 (\29\:n0 VSS) capacitor c=1.61618e-16
C23 (\31\:n0 VSS) capacitor c=9.1549e-17
C24 (\3\:C VSS) capacitor c=1.04311e-16
C25 (\7\:C VSS) capacitor c=6.86794e-17
C26 (\28\:n0 VSS) capacitor c=1.12156e-16
C27 (\4\:Y VSS) capacitor c=2.02381e-16
C28 (\3\:VDD VSS) capacitor c=2.95678e-16
C29 (\8\:VDD VSS) capacitor c=1.53356e-17
Rk5 (\2\:A A) resistor r=0.002993 c=0
Rk40 (\2\:VDD \3\:VDD) resistor r=0.05493 c=0
Rk44 (\3\:VDD \7\:VDD) resistor r=0.1301 c=0
Rk46 (\8\:VDD VDD) resistor r=0.1273 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.4233 c=0
Rk51 (\8\:VDD \18\:VDD) resistor r=0.352 c=0
Rk2 (B \2\:B) resistor r=0.06925 c=0
Rk14 (\1\:Y Y) resistor r=0.1633 c=0
Rk15 (Y \4\:Y) resistor r=0.01235 c=0
Rk33 (\1\:VSS VSS) resistor r=0.02461 c=0
Rk1 (\7\:C C) resistor r=0.1926 c=0
Rk8 (n0 \28\:n0) resistor r=0.236 c=0
Rk9 (\28\:n0 \29\:n0) resistor r=0.4278 c=0
Rk12 (\28\:n0 \36\:n0) resistor r=0.6699 c=0
Rl13 (\2\:A \6\:A) resistor r=82.4874 c=0
Rl1 (\2\:A \1\:A) resistor r=134.181 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl5 (\2\:C \1\:C) resistor r=77.4283 c=0
Rl8 (\2\:C \5\:C) resistor r=21.9171 c=0
Rl6 (\3\:C \2\:C) resistor r=52.3679 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz16 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\31\:n0 \29\:n0) resistor r=75 c=0
Ry12 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry1 (\36\:n0 \35\:n0) resistor r=31 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn0_1__rcx (\29\:n0 \2\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.338e-14 ad=4.16e-14 ps=1.2e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82875e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn1_1__rcx (\29\:n0 \2\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.36e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7775e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn2 (\31\:n0 \3\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.36e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.71125e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn3_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.336e-14 ad=4.636e-14 ps=1.00857e-06 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05847e-06 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mp3_1__rcx (\1\:Y n0 \3\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10348e-06 sb=1.37e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(7)
ends OR3X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:42 2013 )
// Library name: gsclib045_hvt
// Cell name: OR3XL
// View name: extracted

simulator lang=spectre

subckt OR3XL A B C VDD VSS Y
mp2 (\4\:n0 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=25.7873 \
        scb=0.0298129 scc=0.00173847 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.225e-14 \
        ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=5.4e-07 sd=160n sca=16.1735 scb=0.0152732 \
        scc=0.000373884 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.225e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=14.8074 \
        scb=0.0125288 scc=0.000334622 m=(1)
mp3 (\3\:Y \3\:n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=16.4362 \
        scb=0.0157971 scc=0.000386659 m=(1)
C1 (VDD VSS) capacitor c=1.00891e-16
C2 (C VSS) capacitor c=7.00447e-17
C3 (A VSS) capacitor c=7.46347e-17
C4 (Y VSS) capacitor c=1.9082e-17
C5 (n0 VSS) capacitor c=2.92326e-17
C6 (n2 VSS) capacitor c=5.37616e-18
C7 (n1 VSS) capacitor c=7.71032e-18
C8 (\3\:n0 VSS) capacitor c=5.46482e-17
C9 (\3\:A VSS) capacitor c=5.21702e-17
C10 (\1\:B VSS) capacitor c=5.49365e-17
C11 (\1\:C VSS) capacitor c=4.652e-17
C12 (\1\:A VSS) capacitor c=4.71051e-17
C13 (\3\:B VSS) capacitor c=4.59444e-17
C14 (\4\:C VSS) capacitor c=3.86287e-17
C15 (\2\:n0 VSS) capacitor c=5.50096e-17
C16 (\4\:A VSS) capacitor c=6.96697e-17
C17 (\2\:B VSS) capacitor c=6.37842e-17
C18 (\3\:C VSS) capacitor c=1.76132e-17
C19 (\3\:Y VSS) capacitor c=6.99859e-17
C20 (\1\:VDD VSS) capacitor c=4.37369e-17
C21 (\4\:n0 VSS) capacitor c=8.11034e-17
C22 (\1\:Y VSS) capacitor c=7.81672e-17
C23 (\9\:n0 VSS) capacitor c=2.6825e-17
C24 (\7\:n0 VSS) capacitor c=6.18603e-17
C25 (\2\:C VSS) capacitor c=4.44068e-17
C26 (\5\:B VSS) capacitor c=5.75461e-17
C27 (\6\:B VSS) capacitor c=3.84784e-17
C28 (\5\:A VSS) capacitor c=5.5298e-17
C29 (\6\:n0 VSS) capacitor c=1.51718e-16
C30 (\11\:n0 VSS) capacitor c=5.33365e-17
C31 (\4\:VDD VSS) capacitor c=2.70531e-17
Rk12 (\2\:VSS \4\:VSS) resistor r=0.2459 c=0
Rk14 (\5\:VSS VSS) resistor r=0.1024 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1477 c=0
Rk15 (\5\:VSS \7\:VSS) resistor r=0.1831 c=0
Rk17 (\4\:VDD VDD) resistor r=0.2505 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3523 c=0
Rk1 (C \5\:C) resistor r=0.005129 c=0
Rk5 (\5\:A A) resistor r=0.1712 c=0
Rk11 (\4\:Y Y) resistor r=0.04601 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.4975 c=0
Rk2 (\4\:B \5\:B) resistor r=0.008389 c=0
Rk3 (B \6\:B) resistor r=0.008277 c=0
Rk4 (\4\:B \6\:B) resistor r=0.0651 c=0
Rk6 (\5\:n0 \6\:n0) resistor r=0.8776 c=0
Rk7 (\6\:n0 \8\:n0) resistor r=0.4127 c=0
Rk8 (\6\:n0 \10\:n0) resistor r=0.1271 c=0
Rk9 (\6\:n0 \11\:n0) resistor r=0.2034 c=0
Rl1 (\1\:C \2\:C) resistor r=154.649 c=0
Rl3 (\2\:C \4\:C) resistor r=108.495 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl7 (\2\:A \3\:A) resistor r=144.685 c=0
Rl6 (\1\:A \2\:A) resistor r=121.608 c=0
Rl8 (\2\:A \4\:A) resistor r=3.0741 c=0
Rl4 (\1\:B \2\:B) resistor r=133.79 c=0
Rl5 (\2\:B \3\:B) resistor r=106.867 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=204.944 c=0
Rl9 (n0 \2\:n0) resistor r=35.7134 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry1 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\4\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx4 (\2\:n0 \11\:n0) resistor r=45 c=0
mn2 (\7\:n0 \4\:C \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\9\:n0 \3\:B \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn0 (\9\:n0 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
ends OR3XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:43 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4X1
// View name: extracted

simulator lang=spectre

subckt OR4X1 A B C D VDD VSS Y
mp3 (\7\:n0 \1\:D n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.4e-07 sd=160n sca=21.9447 \
        scb=0.0249743 scc=0.00106646 m=(1)
mp2 (n3 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=2.795e-14 \
        ad=1.29e-14 ps=6.9e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.35e-07 sd=160n sca=18.6566 scb=0.0189947 \
        scc=0.000754481 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=2.795e-14 ps=7.5e-07 pd=6.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.2e-07 sb=5.6e-07 sd=160n sca=16.9775 scb=0.0156264 \
        scc=0.000698003 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.22e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.55e-07 sd=160n sca=17.9287 \
        scb=0.0175381 scc=0.000721605 m=(1)
C1 (B VSS) capacitor c=7.53621e-17
C2 (Y VSS) capacitor c=5.1243e-17
C3 (VDD VSS) capacitor c=9.86554e-17
C4 (C VSS) capacitor c=6.26809e-17
C5 (D VSS) capacitor c=3.16018e-17
C6 (A VSS) capacitor c=2.25446e-17
C7 (n0 VSS) capacitor c=4.2542e-17
C8 (n3 VSS) capacitor c=6.34833e-19
C9 (n2 VSS) capacitor c=7.74952e-18
C10 (n1 VSS) capacitor c=3.35121e-18
C11 (\1\:A VSS) capacitor c=5.97332e-17
C12 (\1\:B VSS) capacitor c=4.98772e-17
C13 (\1\:C VSS) capacitor c=8.28354e-17
C14 (\1\:D VSS) capacitor c=6.75879e-17
C15 (\4\:n0 VSS) capacitor c=5.5953e-17
C16 (\3\:A VSS) capacitor c=4.01531e-17
C17 (\3\:B VSS) capacitor c=4.28931e-17
C18 (\3\:C VSS) capacitor c=3.88825e-17
C19 (\3\:D VSS) capacitor c=3.51877e-17
C20 (\3\:n0 VSS) capacitor c=2.5803e-17
C21 (\2\:A VSS) capacitor c=6.01701e-17
C22 (\2\:B VSS) capacitor c=5.47057e-17
C23 (\2\:C VSS) capacitor c=6.61964e-17
C24 (\2\:D VSS) capacitor c=5.04783e-17
C25 (\1\:Y VSS) capacitor c=7.34422e-17
C26 (\1\:VDD VSS) capacitor c=8.35993e-17
C27 (\7\:n0 VSS) capacitor c=5.70911e-17
C28 (\3\:Y VSS) capacitor c=3.09435e-17
C29 (\9\:n0 VSS) capacitor c=5.95102e-17
C30 (\11\:n0 VSS) capacitor c=3.58386e-17
C31 (\2\:n0 VSS) capacitor c=2.72658e-17
C32 (\4\:D VSS) capacitor c=2.63638e-17
C33 (\4\:C VSS) capacitor c=4.45081e-17
C34 (\4\:B VSS) capacitor c=5.99338e-17
C35 (\4\:A VSS) capacitor c=5.83188e-17
C36 (\5\:n0 VSS) capacitor c=4.84941e-17
C37 (\6\:n0 VSS) capacitor c=1.28558e-16
C38 (\5\:VDD VSS) capacitor c=1.95132e-17
Rk3 (\4\:B B) resistor r=0.1951 c=0
Rk9 (\2\:Y Y) resistor r=0.4801 c=0
Rk10 (Y \4\:Y) resistor r=0.06502 c=0
Rk11 (\2\:VDD \3\:VDD) resistor r=0.3038 c=0
Rk13 (\5\:VDD VDD) resistor r=0.2506 c=0
Rk12 (\3\:VDD \5\:VDD) resistor r=0.1965 c=0
Rk2 (\4\:C C) resistor r=0.1309 c=0
Rk1 (\4\:D D) resistor r=0.07059 c=0
Rk4 (A \4\:A) resistor r=0.08218 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.432 c=0
Rk16 (\5\:VSS VSS) resistor r=0.2 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.04902 c=0
Rk17 (VSS \7\:VSS) resistor r=0.06384 c=0
Rk18 (\5\:VSS \9\:VSS) resistor r=0.04332 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.1655 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.5921 c=0
Rk7 (\6\:n0 \10\:n0) resistor r=0.3734 c=0
Rk8 (\10\:n0 \12\:n0) resistor r=0.2679 c=0
Rl5 (\1\:B \2\:B) resistor r=108.79 c=0
Rl6 (\2\:B \3\:B) resistor r=62.6365 c=0
Rl3 (\1\:C \2\:C) resistor r=139.666 c=0
Rl4 (\2\:C \3\:C) resistor r=34.4104 c=0
Rl1 (\1\:D \2\:D) resistor r=132.996 c=0
Rl2 (\2\:D \3\:D) resistor r=81.9251 c=0
Rl7 (\1\:A \2\:A) resistor r=110.713 c=0
Rl8 (\2\:A \3\:A) resistor r=60.7134 c=0
Rl9 (n0 \2\:n0) resistor r=34.3295 c=0
Rl11 (\2\:n0 \4\:n0) resistor r=142.022 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=3.5166 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz2 (\11\:n0 \12\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\1\:VDD \3\:VDD) resistor r=62 c=0
Ry1 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\3\:n0 \5\:n0) resistor r=45 c=0
mn3 (\11\:n0 \3\:D \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.78e-14 ad=2.32e-14 ps=1.23e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=9.6e-07 sd=160n sca=10.0732 scb=0.00911402 \
        scc=0.000253284 m=(1)
mn2 (\11\:n0 \3\:C \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.32e-14 ps=1.31e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=7.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\9\:n0 \3\:B \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.32e-14 ps=1.31e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=5.6e-07 sd=160n sca=10.0732 scb=0.00911402 \
        scc=0.000253284 m=(1)
mn0 (\9\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=3.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn4 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=3.64e-14 ps=8.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.57308e-07 sb=1.4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mp4 (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.22e-14 ad=5.46e-14 ps=1.71e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.14359e-07 sb=1.4e-07 sd=160n sca=26.8339 \
        scb=0.0306087 scc=0.00198091 m=(1)
ends OR4X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:44 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4X2
// View name: extracted

simulator lang=spectre

subckt OR4X2 A B C D VDD VSS Y
mp3 (\11\:n0 \1\:D n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.535e-06 sd=160n sca=26.6819 \
        scb=0.0261048 scc=0.0024743 m=(1)
mp2 (n3 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=6.342e-14 \
        ad=2.472e-14 ps=1.02e-06 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.375e-06 sd=160n sca=24.5186 scb=0.0226595 \
        scc=0.00242717 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=5.483e-14 \
        ad=6.342e-14 ps=9.4e-07 pd=1.02e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.4e-07 sb=1.035e-06 sd=160n sca=22.9839 scb=0.0214342 \
        scc=0.00242442 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.867e-14 ad=5.482e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=7.35e-07 sd=160n sca=23.2378 \
        scb=0.0215231 scc=0.00242444 m=(1)
C1 (B VSS) capacitor c=4.22631e-17
C2 (Y VSS) capacitor c=3.15631e-17
C3 (VDD VSS) capacitor c=9.59621e-17
C4 (C VSS) capacitor c=1.18375e-16
C5 (D VSS) capacitor c=6.73593e-17
C6 (A VSS) capacitor c=2.1485e-17
C7 (n0 VSS) capacitor c=1.47342e-16
C8 (n3 VSS) capacitor c=4.10478e-18
C9 (n2 VSS) capacitor c=1.16927e-17
C10 (n1 VSS) capacitor c=8.49871e-18
C11 (\3\:A VSS) capacitor c=3.47821e-17
C12 (\1\:B VSS) capacitor c=4.12124e-17
C13 (\1\:C VSS) capacitor c=3.52241e-17
C14 (\1\:D VSS) capacitor c=5.83094e-17
C15 (\1\:A VSS) capacitor c=3.05497e-17
C16 (\3\:B VSS) capacitor c=2.8412e-17
C17 (\3\:C VSS) capacitor c=5.54303e-17
C18 (\3\:D VSS) capacitor c=2.86843e-17
C19 (\5\:n0 VSS) capacitor c=1.34772e-17
C20 (\2\:A VSS) capacitor c=3.85523e-17
C21 (\2\:B VSS) capacitor c=3.22804e-17
C22 (\2\:C VSS) capacitor c=5.28035e-17
C23 (\2\:D VSS) capacitor c=4.20667e-17
C24 (\1\:VDD VSS) capacitor c=1.29575e-16
C25 (\3\:Y VSS) capacitor c=1.06527e-16
C26 (\11\:n0 VSS) capacitor c=7.28429e-17
C27 (\1\:Y VSS) capacitor c=1.90432e-17
C28 (\13\:n0 VSS) capacitor c=1.01241e-16
C29 (\15\:n0 VSS) capacitor c=6.36491e-17
C30 (\4\:D VSS) capacitor c=3.06538e-17
C31 (\4\:B VSS) capacitor c=6.31953e-17
C32 (\4\:A VSS) capacitor c=8.5512e-17
C33 (\9\:n0 VSS) capacitor c=6.1193e-17
C34 (\10\:n0 VSS) capacitor c=1.12525e-16
C35 (\5\:VDD VSS) capacitor c=2.12764e-17
Rk3 (\4\:B B) resistor r=0.152 c=0
Rk9 (Y \2\:Y) resistor r=0.1223 c=0
Rk10 (Y \4\:Y) resistor r=0.2953 c=0
Rk13 (\5\:VDD VDD) resistor r=0.4491 c=0
Rk12 (\1\:VDD \5\:VDD) resistor r=0.2419 c=0
Rk2 (\4\:C C) resistor r=0.003667 c=0
Rk1 (\4\:D D) resistor r=0.1867 c=0
Rk4 (A \4\:A) resistor r=0.02802 c=0
Rk17 (\1\:VSS \5\:VSS) resistor r=0.2419 c=0
Rk18 (\5\:VSS \6\:VSS) resistor r=0.1546 c=0
Rk20 (\7\:VSS VSS) resistor r=0.07444 c=0
Rk19 (\6\:VSS \7\:VSS) resistor r=0.2193 c=0
Rk22 (\6\:VSS \11\:VSS) resistor r=0.07277 c=0
Rk23 (\7\:VSS \13\:VSS) resistor r=0.1958 c=0
Rk5 (\9\:n0 \10\:n0) resistor r=0.312 c=0
Rk6 (\10\:n0 \12\:n0) resistor r=0.6423 c=0
Rk7 (\10\:n0 \14\:n0) resistor r=0.4307 c=0
Rk8 (\14\:n0 \16\:n0) resistor r=0.3991 c=0
Rl5 (\1\:B \2\:B) resistor r=150.692 c=0
Rl6 (\2\:B \3\:B) resistor r=39.1533 c=0
Rl3 (\1\:C \2\:C) resistor r=31.461 c=0
Rl4 (\2\:C \3\:C) resistor r=158.384 c=0
Rl1 (\1\:D \2\:D) resistor r=156.735 c=0
Rl2 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl8 (\2\:A \3\:A) resistor r=95.3297 c=0
Rl7 (\1\:A \2\:A) resistor r=96.1538 c=0
Rl12 (n0 \5\:n0) resistor r=1.2666 c=0
Rz3 (\2\:Y \1\:Y) resistor r=75 c=0
Rz7 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\14\:n0 \13\:n0) resistor r=75 c=0
Rz2 (\16\:n0 \15\:n0) resistor r=75 c=0
Ry2 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry1 (\12\:n0 \11\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\9\:n0 \5\:n0) resistor r=45 c=0
mn3 (\15\:n0 \3\:D \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.58e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\15\:n0 \3\:C \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.437e-14 ad=2.32e-14 ps=1.24e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.375e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (\13\:n0 \3\:B \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.437e-14 ad=4.495e-14 ps=1.24e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=1.035e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\13\:n0 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.355e-14 ad=4.495e-14 ps=1.1e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=6.8e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\1\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.497e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.11058e-07 sb=3.45e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mp4 (\3\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.664e-14 ad=6.24e-14 ps=1.265e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.96026e-07 sb=3.45e-07 sd=160n sca=20.7709 \
        scb=0.0194441 scc=0.0014171 m=(2)
ends OR4X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:45 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4X4
// View name: extracted

simulator lang=spectre

subckt OR4X4 A B C D VDD VSS Y
mp3 (\18\:n0 \1\:D n3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=1.01e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.71e-06 sd=160n sca=20.5659 \
        scb=0.0196209 scc=0.00133045 m=(1)
mp2 (n3 \3\:C n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=4.485e-14 ps=1.13e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.55e-06 sd=160n sca=18.4027 scb=0.0161756 \
        scc=0.00128331 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=8.385e-14 \
        ad=6.825e-14 ps=1.21e-06 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.2e-07 sb=1.33e-06 sd=160n sca=17.2034 scb=0.0150777 \
        scc=0.00128061 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=8.385e-14 ps=1.24e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.07e-06 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp4_1__rcx (\5\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.117e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=7.95e-07 sd=160n sca=16.8912 \
        scb=0.0149565 scc=0.00128057 m=(4)
C1 (Y VSS) capacitor c=4.0065e-17
C2 (D VSS) capacitor c=3.69665e-17
C3 (A VSS) capacitor c=6.68145e-17
C4 (VDD VSS) capacitor c=1.1559e-16
C5 (n0 VSS) capacitor c=3.33972e-16
C6 (n3 VSS) capacitor c=8.0169e-18
C7 (n2 VSS) capacitor c=1.03527e-17
C8 (n1 VSS) capacitor c=8.18171e-18
C9 (\1\:A VSS) capacitor c=4.62563e-17
C10 (\1\:B VSS) capacitor c=3.95483e-17
C11 (\3\:C VSS) capacitor c=5.03249e-17
C12 (\1\:D VSS) capacitor c=4.17224e-17
C13 (\3\:A VSS) capacitor c=2.99517e-17
C14 (\4\:B VSS) capacitor c=4.96649e-17
C15 (\1\:C VSS) capacitor c=5.45548e-17
C16 (\4\:D VSS) capacitor c=4.43782e-17
C17 (\2\:A VSS) capacitor c=3.22324e-17
C18 (\3\:B VSS) capacitor c=2.23236e-17
C19 (\2\:C VSS) capacitor c=5.94165e-17
C20 (\3\:D VSS) capacitor c=1.15017e-17
C21 (\1\:VDD VSS) capacitor c=2.14691e-16
C22 (\18\:n0 VSS) capacitor c=8.63541e-17
C23 (\1\:Y VSS) capacitor c=9.81077e-17
C24 (\16\:n0 VSS) capacitor c=6.04848e-17
C25 (\20\:n0 VSS) capacitor c=4.09446e-17
C26 (\2\:D VSS) capacitor c=3.39789e-17
C27 (\2\:B VSS) capacitor c=2.65901e-17
C28 (\5\:D VSS) capacitor c=5.48315e-17
C29 (\4\:C VSS) capacitor c=1.32124e-16
C30 (\5\:B VSS) capacitor c=1.50145e-16
C31 (\4\:A VSS) capacitor c=4.56503e-17
C32 (\15\:n0 VSS) capacitor c=1.54118e-16
C33 (\5\:Y VSS) capacitor c=1.74183e-16
Rk14 (\5\:Y Y) resistor r=0.02436 c=0
Rk11 (\1\:Y \5\:Y) resistor r=0.3767 c=0
Rk3 (\5\:B B) resistor r=0.002899 c=0
Rk18 (\1\:VSS \8\:VSS) resistor r=0.2128 c=0
Rk20 (\9\:VSS VSS) resistor r=0.08226 c=0
Rk19 (\8\:VSS \9\:VSS) resistor r=0.2051 c=0
Rk22 (\8\:VSS \13\:VSS) resistor r=0.1964 c=0
Rk23 (\9\:VSS \15\:VSS) resistor r=0.1964 c=0
Rk2 (\4\:C C) resistor r=0.003681 c=0
Rk1 (D \5\:D) resistor r=0.1048 c=0
Rk4 (\4\:A A) resistor r=0.1374 c=0
Rk28 (\1\:VDD VDD) resistor r=0.501 c=0
Rk6 (n0 \15\:n0) resistor r=0.4717 c=0
Rk7 (\15\:n0 \17\:n0) resistor r=0.3016 c=0
Rk8 (\15\:n0 \19\:n0) resistor r=0.6798 c=0
Rk9 (\17\:n0 \21\:n0) resistor r=0.2953 c=0
Rl6 (\1\:B \2\:B) resistor r=41.1873 c=0
Rl8 (\2\:B \4\:B) resistor r=120.033 c=0
Rl7 (\2\:B \3\:B) resistor r=1.8551 c=0
Rl5 (\2\:C \3\:C) resistor r=29.5379 c=0
Rl4 (\1\:C \2\:C) resistor r=113.042 c=0
Rl1 (\1\:D \2\:D) resistor r=34.4574 c=0
Rl3 (\2\:D \4\:D) resistor r=118.933 c=0
Rl2 (\2\:D \3\:D) resistor r=4.4012 c=0
Rl9 (\1\:A \2\:A) resistor r=98.7687 c=0
Rl10 (\2\:A \3\:A) resistor r=46.8456 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz9 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\17\:n0 \16\:n0) resistor r=75 c=0
Rz2 (\21\:n0 \20\:n0) resistor r=75 c=0
Ry1 (\19\:n0 \18\:n0) resistor r=62 c=0
Rx3 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
mn3 (\20\:n0 \4\:D \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.755e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn2 (\20\:n0 \1\:C \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.55e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn1 (\16\:n0 \4\:B \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.59e-14 ps=8.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.345e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn0 (\16\:n0 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=5.59e-14 ps=1.09e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.085e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn4_1__rcx (\1\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.843e-14 ad=4.16e-14 ps=8.925e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=7.55e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(4)
ends OR4X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:46 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4X6
// View name: extracted

simulator lang=spectre

subckt OR4X6 A B C D VDD VSS Y
mp0_1__rcx (2 \1\:A \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88615e-06 sd=160n sca=15.9946 \
        scb=0.0153756 scc=0.000392843 m=(1)
mp1_1__rcx (4 \1\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.825e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.86462e-06 sd=160n sca=14.2697 \
        scb=0.0124687 scc=0.000342275 m=(1)
mp2_1__rcx (4 \1\:C 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.825e-14 ps=1.26e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.81949e-06 sd=160n sca=12.6655 \
        scb=0.010598 scc=0.000333408 m=(1)
mp3_1__rcx (\29\:n0 \5\:D 6 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.67359e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp3 (\29\:n0 \1\:D 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.46859e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp2 (7 \4\:C 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=4.485e-14 ps=1.08e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.115e-06 sb=1.30859e-06 sd=160n sca=11.9453 scb=0.010292 \
        scc=0.000333254 m=(1)
mp1 (3 \6\:B 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=2.34e-14 ps=1.08e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.31e-06 sb=1.11359e-06 sd=160n sca=11.9453 scb=0.010292 \
        scc=0.000333254 m=(1)
mp0 (3 \6\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.194e-13 ad=2.34e-14 ps=1.9e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.00859e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
C1 (Y VSS) capacitor c=2.4759e-16
C2 (B VSS) capacitor c=2.74149e-17
C3 (VDD VSS) capacitor c=1.41556e-16
C4 (C VSS) capacitor c=9.40362e-17
C5 (D VSS) capacitor c=9.06653e-17
C6 (A VSS) capacitor c=6.2539e-16
C7 (n0 VSS) capacitor c=3.65741e-16
C8 (2 VSS) capacitor c=2.75713e-18
C9 (4 VSS) capacitor c=6.37875e-18
C10 (6 VSS) capacitor c=1.04894e-17
C11 (7 VSS) capacitor c=6.21517e-18
C12 (8 VSS) capacitor c=8.53471e-18
C13 (3 VSS) capacitor c=3.20036e-18
C14 (\6\:A VSS) capacitor c=8.60657e-17
C15 (\6\:B VSS) capacitor c=7.62272e-17
C16 (\4\:C VSS) capacitor c=7.84682e-17
C17 (\1\:D VSS) capacitor c=5.21616e-17
C18 (\5\:D VSS) capacitor c=3.53775e-17
C19 (\1\:C VSS) capacitor c=4.35221e-17
C20 (\1\:B VSS) capacitor c=7.07507e-17
C21 (\1\:A VSS) capacitor c=6.029e-17
C22 (\2\:D VSS) capacitor c=5.16156e-17
C23 (\2\:C VSS) capacitor c=2.9834e-16
C24 (\2\:B VSS) capacitor c=5.18719e-16
C25 (\29\:n0 VSS) capacitor c=1.43415e-16
C26 (\14\:VDD VSS) capacitor c=3.2952e-17
C27 (\1\:VDD VSS) capacitor c=5.17522e-17
C28 (\1\:Y VSS) capacitor c=2.09529e-16
C29 (\21\:n0 VSS) capacitor c=2.63218e-16
C30 (\3\:D VSS) capacitor c=7.19214e-17
C31 (\7\:D VSS) capacitor c=3.33612e-17
C32 (\20\:n0 VSS) capacitor c=1.41451e-16
C33 (\3\:VDD VSS) capacitor c=1.98596e-16
C34 (\7\:VDD VSS) capacitor c=2.13019e-17
Rk16 (\1\:Y Y) resistor r=0.275 c=0
Rk5 (\2\:B B) resistor r=0.054 c=0
Rk33 (\3\:VSS VSS) resistor r=0.03465 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.03239 c=0
Rk38 (\3\:VSS \20\:VSS) resistor r=0.1987 c=0
Rk41 (\2\:VDD \3\:VDD) resistor r=0.07751 c=0
Rk44 (\3\:VDD \6\:VDD) resistor r=0.2971 c=0
Rk46 (\7\:VDD VDD) resistor r=0.0923 c=0
Rk45 (\6\:VDD \7\:VDD) resistor r=0.4585 c=0
Rk50 (\7\:VDD \15\:VDD) resistor r=0.1934 c=0
Rk2 (C \2\:C) resistor r=0.02267 c=0
Rk1 (\7\:D D) resistor r=0.1117 c=0
Rk9 (n0 \20\:n0) resistor r=0.1826 c=0
Rk10 (\20\:n0 \21\:n0) resistor r=0.2773 c=0
Rk14 (\20\:n0 \30\:n0) resistor r=1.0277 c=0
Rl15 (\2\:B \6\:B) resistor r=29.5379 c=0
Rl3 (\2\:B \1\:B) resistor r=29.5379 c=0
Rl12 (\2\:C \4\:C) resistor r=131.461 c=0
Rl5 (\2\:C \1\:C) resistor r=56.461 c=0
Rl7 (\2\:D \1\:D) resistor r=149.977 c=0
Rl10 (\2\:D \5\:D) resistor r=130.746 c=0
Rl8 (\3\:D \2\:D) resistor r=2.7713 c=0
Rl17 (A \6\:A) resistor r=57.4874 c=0
Rl1 (A \1\:A) resistor r=30.5087 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz16 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry10 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\30\:n0 \29\:n0) resistor r=62 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0 (\21\:n0 A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=4.55e-14 ps=8.85e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn1_1__rcx (\21\:n0 \2\:B \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=4.55e-14 ps=8.65e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn2 (\21\:n0 \2\:C \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.615e-14 ps=8.65e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn3 (\21\:n0 \3\:D \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.615e-14 ps=8.4e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn4_1__rcx (\1\:Y n0 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.978e-14 ad=4.836e-14 ps=9.46e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5971e-06 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp4_1__rcx (Y n0 \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=8.404e-14 ad=7.332e-14 ps=1.388e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14213e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends OR4X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:47 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4X8
// View name: extracted

simulator lang=spectre

subckt OR4X8 A B C D VDD VSS Y
mp0_1__rcx (2 \1\:A \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.85596e-06 sd=160n sca=15.9946 \
        scb=0.0153756 scc=0.000392843 m=(1)
mp1_1__rcx (3 \1\:B 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.825e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.82769e-06 sd=160n sca=14.2697 \
        scb=0.0124687 scc=0.000342275 m=(1)
mp2_1__rcx (3 \1\:C 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.825e-14 ps=1.26e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.76846e-06 sd=160n sca=12.6655 \
        scb=0.010598 scc=0.000333408 m=(1)
mp3_1__rcx (\35\:n0 \5\:D 5 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.69173e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp3 (\35\:n0 \1\:D 8 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.63654e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp2 (8 \4\:C 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=4.485e-14 ps=1.05e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.115e-06 sb=1.56423e-06 sd=160n sca=11.9453 scb=0.010292 \
        scc=0.000333254 m=(1)
mp1 (6 \6\:B 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=3.705e-14 ps=1.05e-06 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.295e-06 sb=1.38423e-06 sd=160n sca=11.9453 scb=0.010292 \
        scc=0.000333254 m=(1)
mp0 (6 \6\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1957e-13 ad=3.705e-14 ps=1.91e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.435e-06 sb=1.24423e-06 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
C1 (Y VSS) capacitor c=1.18449e-17
C2 (B VSS) capacitor c=3.1419e-17
C3 (VDD VSS) capacitor c=1.50518e-16
C4 (C VSS) capacitor c=9.44537e-17
C5 (D VSS) capacitor c=9.06344e-17
C6 (A VSS) capacitor c=5.99567e-16
C7 (n0 VSS) capacitor c=5.70914e-16
C8 (2 VSS) capacitor c=2.7576e-18
C9 (3 VSS) capacitor c=6.37875e-18
C10 (5 VSS) capacitor c=1.06733e-17
C11 (8 VSS) capacitor c=6.15809e-18
C12 (7 VSS) capacitor c=7.58764e-18
C13 (6 VSS) capacitor c=5.85e-18
C14 (\6\:A VSS) capacitor c=6.71452e-17
C15 (\6\:B VSS) capacitor c=6.13515e-17
C16 (\4\:C VSS) capacitor c=8.6396e-17
C17 (\1\:D VSS) capacitor c=5.21353e-17
C18 (\5\:D VSS) capacitor c=3.53078e-17
C19 (\1\:C VSS) capacitor c=4.35086e-17
C20 (\1\:B VSS) capacitor c=7.08209e-17
C21 (\1\:A VSS) capacitor c=6.30287e-17
C22 (\2\:D VSS) capacitor c=5.15859e-17
C23 (\2\:C VSS) capacitor c=2.99176e-16
C24 (\2\:B VSS) capacitor c=5.11597e-16
C25 (\1\:Y VSS) capacitor c=4.64249e-16
C26 (\1\:VDD VSS) capacitor c=3.14679e-16
C27 (\35\:n0 VSS) capacitor c=1.45793e-16
C28 (\16\:VDD VSS) capacitor c=3.59139e-17
C29 (\3\:VDD VSS) capacitor c=6.13542e-17
C30 (\27\:n0 VSS) capacitor c=2.74943e-16
C31 (\3\:D VSS) capacitor c=7.18986e-17
C32 (\7\:D VSS) capacitor c=3.33432e-17
C33 (\26\:n0 VSS) capacitor c=1.44028e-16
C34 (\4\:Y VSS) capacitor c=2.0828e-16
C35 (\9\:VDD VSS) capacitor c=2.14955e-17
Rk17 (\1\:Y Y) resistor r=0.09033 c=0
Rk18 (Y \4\:Y) resistor r=0.06634 c=0
Rk5 (\2\:B B) resistor r=0.05402 c=0
Rk37 (\1\:VSS VSS) resistor r=0.03465 c=0
Rk42 (\1\:VSS \22\:VSS) resistor r=0.199 c=0
Rk49 (\1\:VDD \8\:VDD) resistor r=0.3072 c=0
Rk51 (\9\:VDD VDD) resistor r=0.09231 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.4586 c=0
Rk55 (\9\:VDD \17\:VDD) resistor r=0.1936 c=0
Rk2 (C \2\:C) resistor r=0.02269 c=0
Rk1 (\7\:D D) resistor r=0.1118 c=0
Rk10 (n0 \26\:n0) resistor r=0.2011 c=0
Rk11 (\26\:n0 \27\:n0) resistor r=0.2717 c=0
Rk15 (\26\:n0 \36\:n0) resistor r=1.0799 c=0
Rl15 (\2\:B \6\:B) resistor r=24.2328 c=0
Rl3 (\2\:B \1\:B) resistor r=29.5379 c=0
Rl12 (\2\:C \4\:C) resistor r=131.461 c=0
Rl5 (\2\:C \1\:C) resistor r=56.461 c=0
Rl7 (\2\:D \1\:D) resistor r=149.977 c=0
Rl10 (\2\:D \5\:D) resistor r=130.746 c=0
Rl8 (\3\:D \2\:D) resistor r=2.7713 c=0
Rl17 (A \6\:A) resistor r=69.0258 c=0
Rl1 (A \1\:A) resistor r=48.0541 c=0
Rz14 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz17 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz18 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Ry12 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\36\:n0 \35\:n0) resistor r=62 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0 (\27\:n0 A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.27e-14 ad=4.55e-14 ps=8.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn1_1__rcx (\27\:n0 \2\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=4.55e-14 ps=8.65e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn2_1__rcx (\27\:n0 \2\:C \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=4.615e-14 ps=8.65e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn3 (\27\:n0 \3\:D \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.615e-14 ps=8.4e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn4_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.746e-14 ad=4.636e-14 ps=9.1429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67322e-06 sb=1.37e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mp4_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.811e-14 ad=6.993e-14 ps=1.31e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12792e-06 sb=1.37e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(7)
ends OR4X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:48 2013 )
// Library name: gsclib045_hvt
// Cell name: OR4XL
// View name: extracted

simulator lang=spectre

subckt OR4XL A B C D VDD VSS Y
mp3 (\6\:n0 \1\:D n3 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13e-06 sd=160n sca=14.0155 \
        scb=0.0121212 scc=0.000127529 m=(1)
mp2 (n3 \1\:C n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=3.225e-14 \
        ad=2.472e-14 ps=7.3e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=9.7e-07 sd=160n sca=11.8523 scb=0.00867586 \
        scc=8.03921e-05 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=5.697e-14 \
        ad=3.225e-14 ps=9.6e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.95e-07 sb=7.75e-07 sd=160n sca=11.0003 scb=0.00769296 \
        scc=7.77264e-05 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=5.697e-14 ps=8.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=4.65e-07 sd=160n sca=12.0313 \
        scb=0.00891071 scc=8.16109e-05 m=(1)
mp4 (\3\:Y \3\:n0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=4.837e-14 ps=8.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2.25e-07 sd=160n sca=17.0817 \
        scb=0.0174363 scc=0.000365094 m=(1)
C1 (Y VSS) capacitor c=3.95712e-17
C2 (B VSS) capacitor c=2.69959e-17
C3 (VDD VSS) capacitor c=1.35453e-16
C4 (C VSS) capacitor c=1.24804e-16
C5 (D VSS) capacitor c=8.33664e-17
C6 (A VSS) capacitor c=9.7743e-17
C7 (n0 VSS) capacitor c=4.859e-17
C8 (n3 VSS) capacitor c=3.82095e-18
C9 (n2 VSS) capacitor c=5.6746e-18
C10 (n1 VSS) capacitor c=5.67102e-18
C11 (\3\:n0 VSS) capacitor c=2.66891e-17
C12 (\3\:A VSS) capacitor c=5.01938e-17
C13 (\1\:B VSS) capacitor c=5.23682e-17
C14 (\1\:C VSS) capacitor c=4.42053e-17
C15 (\1\:D VSS) capacitor c=6.48919e-17
C16 (\1\:A VSS) capacitor c=2.46875e-17
C17 (\3\:B VSS) capacitor c=3.86129e-17
C18 (\3\:C VSS) capacitor c=6.97146e-17
C19 (\3\:D VSS) capacitor c=2.80816e-17
C20 (\2\:n0 VSS) capacitor c=4.04584e-17
C21 (\2\:A VSS) capacitor c=4.20263e-17
C22 (\2\:B VSS) capacitor c=5.04384e-17
C23 (\2\:C VSS) capacitor c=6.62215e-17
C24 (\2\:D VSS) capacitor c=5.09372e-17
C25 (\3\:Y VSS) capacitor c=6.89425e-17
C26 (\1\:VDD VSS) capacitor c=4.62024e-17
C27 (\6\:n0 VSS) capacitor c=5.07723e-17
C28 (\1\:Y VSS) capacitor c=1.55332e-17
C29 (\8\:n0 VSS) capacitor c=8.51134e-17
C30 (\10\:n0 VSS) capacitor c=3.39474e-17
C31 (\4\:B VSS) capacitor c=1.00364e-16
C32 (\4\:n0 VSS) capacitor c=7.52892e-17
C33 (\5\:n0 VSS) capacitor c=1.05469e-16
C34 (\4\:VDD VSS) capacitor c=3.13206e-17
Rk9 (Y \2\:Y) resistor r=0.02687 c=0
Rk10 (Y \4\:Y) resistor r=0.4657 c=0
Rk3 (B \4\:B) resistor r=0.02479 c=0
Rk18 (\4\:VDD VDD) resistor r=0.3495 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4016 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.4751 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.05477 c=0
Rk14 (\6\:VSS VSS) resistor r=0.09449 c=0
Rk13 (\5\:VSS \6\:VSS) resistor r=0.1995 c=0
Rk15 (\5\:VSS \8\:VSS) resistor r=0.07288 c=0
Rk16 (\6\:VSS \10\:VSS) resistor r=0.07288 c=0
Rk2 (\4\:C C) resistor r=0.003669 c=0
Rk1 (\4\:D D) resistor r=0.002985 c=0
Rk4 (\4\:A A) resistor r=0.006404 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.3414 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.4795 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.5125 c=0
Rk8 (\9\:n0 \11\:n0) resistor r=0.2875 c=0
Rl5 (\1\:B \2\:B) resistor r=173.769 c=0
Rl6 (\2\:B \3\:B) resistor r=62.2302 c=0
Rl3 (\1\:C \2\:C) resistor r=46.8456 c=0
Rl4 (\2\:C \3\:C) resistor r=189.153 c=0
Rl1 (\1\:D \2\:D) resistor r=202.043 c=0
Rl2 (\2\:D \3\:D) resistor r=41.5405 c=0
Rl8 (\2\:A \3\:A) resistor r=197.253 c=0
Rl7 (\1\:A \2\:A) resistor r=40.3846 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=29.9451 c=0
Rl9 (n0 \2\:n0) resistor r=207.692 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz2 (\10\:n0 \11\:n0) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn3 (\10\:n0 \3\:D \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.74e-14 ad=2.32e-14 ps=1.21e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.175e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\10\:n0 \3\:C \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.32e-14 ps=1.31e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.7e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\8\:n0 \3\:B \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=4.64e-14 ps=1.31e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=7.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\8\:n0 \1\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=4.64e-14 ps=6.8e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=4.1e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn4 (\1\:Y n0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.465e-14 ps=6.8e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=1.7e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
ends OR4XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:49 2013 )
// Library name: gsclib045_hvt
// Cell name: TIEHI
// View name: extracted

simulator lang=spectre

subckt TIEHI VDD VSS Y
mp0 (\1\:Y net25 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=8.53014e-17
C2 (VDD VSS) capacitor c=3.46211e-17
C3 (net25 VSS) capacitor c=3.42719e-17
C4 (\3\:net25 VSS) capacitor c=2.09088e-17
C5 (\2\:net25 VSS) capacitor c=1.67874e-17
C6 (\1\:VDD VSS) capacitor c=5.52866e-17
C7 (\5\:net25 VSS) capacitor c=3.20839e-17
C8 (\4\:net25 VSS) capacitor c=2.64357e-17
C9 (\4\:VDD VSS) capacitor c=1.59733e-18
Rk1 (Y \2\:Y) resistor r=0.02976 c=0
Rk6 (\4\:VSS VSS) resistor r=0.09927 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.3126 c=0
Rk4 (\4\:VDD VDD) resistor r=0.09927 c=0
Rk3 (\2\:VDD \4\:VDD) resistor r=0.4506 c=0
Rk2 (\4\:net25 \6\:net25) resistor r=0.1853 c=0
Rl1 (net25 \2\:net25) resistor r=48.7687 c=0
Rl2 (\2\:net25 \3\:net25) resistor r=29.5379 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\5\:net25 \6\:net25) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Rx1 (\2\:net25 \4\:net25) resistor r=45 c=0
mn0 (\5\:net25 \3\:net25 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
ends TIEHI
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:50 2013 )
// Library name: gsclib045_hvt
// Cell name: TIELO
// View name: extracted

simulator lang=spectre

subckt TIELO VDD VSS Y
mp0 (\4\:net25 net25 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=8.64584e-17
C2 (VDD VSS) capacitor c=2.90221e-17
C3 (net25 VSS) capacitor c=2.2898e-17
C4 (\3\:net25 VSS) capacitor c=2.75968e-17
C5 (\2\:net25 VSS) capacitor c=1.67382e-17
C6 (\1\:VDD VSS) capacitor c=4.76542e-17
C7 (\4\:net25 VSS) capacitor c=4.28072e-17
C8 (\6\:net25 VSS) capacitor c=2.77863e-17
C9 (\4\:VDD VSS) capacitor c=1.29212e-18
Rk1 (\2\:Y Y) resistor r=0.00298 c=0
Rk7 (\4\:VSS VSS) resistor r=0.09943 c=0
Rk6 (\2\:VSS \4\:VSS) resistor r=0.3495 c=0
Rk5 (\4\:VDD VDD) resistor r=0.09943 c=0
Rk3 (\2\:VDD \4\:VDD) resistor r=0.3452 c=0
Rk4 (\2\:VDD \5\:VDD) resistor r=0.1606 c=0
Rk2 (\5\:net25 \6\:net25) resistor r=0.1727 c=0
Rl1 (net25 \2\:net25) resistor r=24.2328 c=0
Rl2 (\2\:net25 \3\:net25) resistor r=39.6174 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\1\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (\4\:net25 \5\:net25) resistor r=20.6667 c=0
Rx1 (\2\:net25 \6\:net25) resistor r=45 c=0
mn0 (\1\:Y \3\:net25 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
ends TIELO
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:51 2013 )
// Library name: gsclib045_hvt
// Cell name: TLATNCAX12
// View name: extracted

simulator lang=spectre

subckt TLATNCAX12 CK E ECK VDD VSS
mp0 (\9\:CKb \1\:CK \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.262e-14 ad=3.44e-14 ps=1.68e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=57.0065 scb=0.0445545 \
        scc=0.00681945 m=(1)
mp1 (\19\:CKbb CKb \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.125e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp15 (net205 \7\:Eint \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.27e-14 ad=4.73e-14 ps=1.74e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=1.095e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp16 (\4\:n0 \5\:CKb net205 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.3e-14 ps=8.7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=8.3e-07 sd=160n sca=14.0993 \
        scb=0.0134558 scc=0.000640581 m=(1)
mp6 (\4\:n0 \12\:CKbb net217 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.85e-07 sd=160n sca=14.9963 scb=0.0139879 \
        scc=0.000641097 m=(1)
mp5 (net217 \1\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.902e-14 ps=1.16e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=16.5968 scb=0.0160997 \
        scc=0.000654774 m=(1)
C1 (CK VSS) capacitor c=5.39585e-17
C2 (ECK VSS) capacitor c=1.39048e-17
C3 (VDD VSS) capacitor c=3.29411e-16
C4 (E VSS) capacitor c=6.18068e-17
C5 (CKb VSS) capacitor c=4.10139e-17
C6 (ECKb VSS) capacitor c=5.13887e-16
C7 (CKbb VSS) capacitor c=6.82249e-17
C8 (13 VSS) capacitor c=2.21455e-18
C9 (Eint VSS) capacitor c=5.30461e-16
C10 (14 VSS) capacitor c=3.80903e-18
C11 (15 VSS) capacitor c=3.98847e-19
C12 (n0 VSS) capacitor c=5.38398e-17
C13 (net254 VSS) capacitor c=5.09891e-18
C14 (net205 VSS) capacitor c=2.74045e-18
C15 (net217 VSS) capacitor c=2.41405e-18
C16 (\1\:E VSS) capacitor c=3.91844e-17
C17 (\12\:CKbb VSS) capacitor c=4.20915e-17
C18 (\5\:CKb VSS) capacitor c=5.77245e-17
C19 (\7\:Eint VSS) capacitor c=3.74176e-17
C20 (\1\:CK VSS) capacitor c=3.62275e-17
C21 (\3\:n0 VSS) capacitor c=4.38462e-17
C22 (\3\:E VSS) capacitor c=4.19133e-17
C23 (\4\:CKb VSS) capacitor c=5.98443e-17
C24 (\10\:CKbb VSS) capacitor c=6.4279e-17
C25 (\10\:Eint VSS) capacitor c=4.28321e-17
C26 (\12\:Eint VSS) capacitor c=2.10143e-17
C27 (\8\:CKbb VSS) capacitor c=2.46262e-17
C28 (\7\:CKbb VSS) capacitor c=4.48771e-17
C29 (\5\:Eint VSS) capacitor c=3.21255e-17
C30 (\4\:Eint VSS) capacitor c=5.22217e-17
C31 (\2\:CKb VSS) capacitor c=4.98278e-17
C32 (\3\:CK VSS) capacitor c=2.37096e-17
C33 (\2\:n0 VSS) capacitor c=3.19037e-17
C34 (\2\:E VSS) capacitor c=4.14467e-17
C35 (\13\:CKbb VSS) capacitor c=3.98629e-17
C36 (\6\:CKb VSS) capacitor c=2.68775e-17
C37 (\11\:CKbb VSS) capacitor c=6.46428e-17
C38 (\2\:CKbb VSS) capacitor c=4.77929e-16
C39 (\3\:CKb VSS) capacitor c=2.97885e-17
C40 (\2\:CK VSS) capacitor c=2.31541e-17
C41 (\13\:Eint VSS) capacitor c=6.89353e-17
C42 (\1\:VDD VSS) capacitor c=3.87459e-17
C43 (\4\:n0 VSS) capacitor c=5.55679e-17
C44 (\31\:ECKb VSS) capacitor c=3.63196e-16
C45 (\19\:CKbb VSS) capacitor c=2.81317e-17
C46 (\1\:ECK VSS) capacitor c=2.57207e-16
C47 (\9\:CKb VSS) capacitor c=2.48877e-16
C48 (\3\:VDD VSS) capacitor c=5.6337e-17
C49 (\15\:Eint VSS) capacitor c=1.85462e-16
C50 (\7\:n0 VSS) capacitor c=5.81726e-17
C51 (\41\:ECKb VSS) capacitor c=8.62824e-17
C52 (\38\:ECKb VSS) capacitor c=1.38468e-16
C53 (\21\:CKbb VSS) capacitor c=7.04732e-17
C54 (\11\:CKb VSS) capacitor c=4.26221e-17
C55 (\8\:Eint VSS) capacitor c=3.66745e-17
C56 (\4\:CK VSS) capacitor c=2.76964e-17
C57 (\9\:ECK VSS) capacitor c=3.13899e-16
C58 (\37\:ECKb VSS) capacitor c=1.52287e-16
C59 (\40\:ECKb VSS) capacitor c=3.64445e-17
C60 (\7\:CKb VSS) capacitor c=1.85904e-16
C61 (\8\:CKb VSS) capacitor c=4.55371e-16
C62 (\14\:CKbb VSS) capacitor c=4.33303e-17
C63 (\15\:CKbb VSS) capacitor c=8.19372e-17
C64 (\18\:CKbb VSS) capacitor c=3.59637e-17
C65 (\4\:E VSS) capacitor c=5.27195e-17
C66 (\6\:n0 VSS) capacitor c=1.03003e-16
C67 (\9\:n0 VSS) capacitor c=5.92345e-17
C68 (\5\:VDD VSS) capacitor c=1.82378e-16
C69 (\10\:VDD VSS) capacitor c=2.50825e-16
Rk1 (CK \4\:CK) resistor r=0.08922 c=0
Rk5 (\1\:ECK ECK) resistor r=0.04211 c=0
Rk6 (ECK \9\:ECK) resistor r=0.2193 c=0
Rk56 (\2\:VDD \4\:VDD) resistor r=0.2366 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.4462 c=0
Rk78 (\10\:VDD VDD) resistor r=0.1525 c=0
Rk62 (\5\:VDD \10\:VDD) resistor r=0.1927 c=0
Rk30 (\4\:E E) resistor r=0.109 c=0
Rk37 (\2\:VSS \4\:VSS) resistor r=0.2933 c=0
Rk38 (\4\:VSS \5\:VSS) resistor r=0.4738 c=0
Rk39 (\5\:VSS \6\:VSS) resistor r=0.3283 c=0
Rk40 (\6\:VSS \7\:VSS) resistor r=0.1453 c=0
Rk52 (\8\:VSS VSS) resistor r=0.1676 c=0
Rk41 (\7\:VSS \8\:VSS) resistor r=0.4134 c=0
Rk45 (\5\:VSS \13\:VSS) resistor r=0.2959 c=0
Rk46 (\7\:VSS \15\:VSS) resistor r=0.2831 c=0
Rk21 (\7\:CKb \8\:CKb) resistor r=1.5284 c=0
Rk22 (\8\:CKb \10\:CKb) resistor r=2.1189 c=0
Rk23 (\10\:CKb \12\:CKb) resistor r=0.3349 c=0
Rk17 (\31\:ECKb \37\:ECKb) resistor r=0.7589 c=0
Rk18 (\37\:ECKb \39\:ECKb) resistor r=0.7269 c=0
Rk19 (\37\:ECKb \40\:ECKb) resistor r=0.2317 c=0
Rk20 (\39\:ECKb \42\:ECKb) resistor r=0.5671 c=0
Rk25 (\15\:CKbb \2\:CKbb) resistor r=0.6456 c=0
Rk24 (\14\:CKbb \15\:CKbb) resistor r=0.1664 c=0
Rk27 (\2\:CKbb \18\:CKbb) resistor r=0.1521 c=0
Rk28 (\18\:CKbb \20\:CKbb) resistor r=0.06532 c=0
Rk29 (\18\:CKbb \22\:CKbb) resistor r=0.2883 c=0
Rk35 (\16\:Eint Eint) resistor r=1.3031 c=0
Rk34 (\14\:Eint \16\:Eint) resistor r=0.5017 c=0
Rk31 (\5\:n0 \6\:n0) resistor r=0.3739 c=0
Rk32 (\6\:n0 \8\:n0) resistor r=0.3835 c=0
Rk33 (\6\:n0 \9\:n0) resistor r=0.2604 c=0
Rl1 (\1\:CK \2\:CK) resistor r=74.2328 c=0
Rl2 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl55 (\1\:E \2\:E) resistor r=29.5379 c=0
Rl56 (\2\:E \3\:E) resistor r=117.999 c=0
Rl52 (\4\:CKb \5\:CKb) resistor r=172.643 c=0
Rl32 (CKb \2\:CKb) resistor r=126.923 c=0
Rl53 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl33 (CKb \3\:CKb) resistor r=61.0982 c=0
Rl54 (\13\:CKbb \12\:CKbb) resistor r=57.6695 c=0
Rl51 (\11\:CKbb \10\:CKbb) resistor r=98.7687 c=0
Rl44 (\2\:CKbb \8\:CKbb) resistor r=86.22 c=0
Rl43 (\2\:CKbb \7\:CKbb) resistor r=119.208 c=0
Rl34 (\2\:CKbb CKbb) resistor r=126.477 c=0
Rl50 (Eint \12\:Eint) resistor r=53.0285 c=0
Rl39 (Eint \5\:Eint) resistor r=28.6412 c=0
Rl38 (Eint \4\:Eint) resistor r=58.8489 c=0
Rl46 (\8\:Eint \7\:Eint) resistor r=89.6181 c=0
Rl47 (\8\:Eint Eint) resistor r=68.9123 c=0
Rl48 (\8\:Eint \10\:Eint) resistor r=80.0028 c=0
Rl57 (n0 \2\:n0) resistor r=102.615 c=0
Rl58 (\2\:n0 \3\:n0) resistor r=44.9225 c=0
Rz21 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz22 (\5\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz6 (\39\:ECKb \38\:ECKb) resistor r=75 c=0
Rz7 (\42\:ECKb \41\:ECKb) resistor r=75 c=0
Rz9 (\22\:CKbb \21\:CKbb) resistor r=75 c=0
Rz11 (\16\:Eint \15\:Eint) resistor r=75 c=0
Rz10 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry16 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry13 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry14 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry9 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry10 (\20\:CKbb \19\:CKbb) resistor r=62 c=0
Ry12 (\14\:Eint \13\:Eint) resistor r=20.6667 c=0
Ry11 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx9 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\6\:CKb \7\:CKb) resistor r=45 c=0
Rx4 (\3\:CKb \8\:CKb) resistor r=45 c=0
Rx2 (\40\:ECKb ECKb) resistor r=45 c=0
Rx5 (\14\:CKbb \13\:CKbb) resistor r=45 c=0
Rx6 (\15\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\2\:n0 \9\:n0) resistor r=45 c=0
mn0 (\11\:CKb \3\:CK \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.152e-14 ad=2.392e-14 ps=1.15e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=2e-06 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn1 (\21\:CKbb \2\:CKb \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.065e-14 ad=3.262e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn15 (net230 \10\:Eint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.922e-14 ad=8.7e-15 ps=1.01e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=1.065e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn16 (\7\:n0 \10\:CKbb net230 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=9.6e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn6 (\7\:n0 \4\:CKb net254 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=7.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn5 (net254 \3\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.857e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.75e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn22_1__rcx (\9\:ECK ECKb \8\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.09e-14 ad=4.96e-14 ps=9.67e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.96694e-07 sb=1.99202e-06 sd=160n sca=9.82009 \
        scb=0.00857019 scc=0.000324687 m=(10)
mn21_1__rcx (\38\:ECKb CKbb 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.61923e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20_1__rcx (13 \4\:Eint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.29e-14 ad=1.56e-14 ps=8.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.57279e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20_2__rcx (14 \5\:Eint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.29e-14 ad=2.99e-14 ps=8.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.4799e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21_2__rcx (\41\:ECKb \7\:CKbb 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.35337e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21 (\41\:ECKb \8\:CKbb 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.14837e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (15 \12\:Eint \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.922e-14 ad=7.67e-14 ps=1.01e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=8.08365e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn10 (\15\:Eint \3\:n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.17731e-06 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mp22_1__rcx (\1\:ECK ECKb \10\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 \
        nf=1 as=7.755e-14 ad=7.52e-14 ps=1.348e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.81915e-07 sb=1.97016e-06 sd=160n sca=28.8268 \
        scb=0.0193852 scc=0.00280057 m=(10)
mp10 (\13\:Eint n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.63e-14 ps=1.16e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16538e-06 sb=1.7e-07 sd=160n sca=23.0147 \
        scb=0.0263355 scc=0.00124475 m=(1)
mp21_1__rcx (\31\:ECKb \2\:CKbb \5\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.88e-14 ad=6.24e-14 ps=1.30667e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.10769e-07 sb=1.66122e-06 sd=160n \
        sca=12.2138 scb=0.0106342 scc=0.00038358 m=(3)
mp20 (\31\:ECKb Eint \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.957e-14 ad=6.24e-14 ps=1.47333e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15769e-07 sb=1.56923e-06 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(3)
ends TLATNCAX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:51 2013 )
// Library name: gsclib045_hvt
// Cell name: TLATNCAX16
// View name: extracted

simulator lang=spectre

subckt TLATNCAX16 CK E ECK VDD VSS
mp0 (\11\:CKb \3\:CK \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.305e-14 ad=3.01e-14 ps=1.27e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.1157 scb=0.029461 \
        scc=0.0022003 m=(1)
mp15 (net205 \13\:Eint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.907e-14 ad=2.687e-14 ps=1.56e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.245e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp16 (\12\:n0 \2\:CKb net205 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.3e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.075e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp6 (\12\:n0 \13\:CKbb net217 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=4.3e-14 ps=1.23e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.3e-07 sd=160n sca=16.4857 scb=0.0163525 \
        scc=0.00112485 m=(1)
mp5 (net217 \1\:E \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=8.6e-14 ps=8.3e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.85e-07 sd=160n sca=18.6197 scb=0.0182692 \
        scc=0.00113172 m=(1)
mp1 (\22\:CKbb \7\:CKb \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=25.1716 scb=0.0291739 \
        scc=0.0016465 m=(1)
C1 (CK VSS) capacitor c=4.07155e-17
C2 (VDD VSS) capacitor c=3.79261e-16
C3 (ECK VSS) capacitor c=6.46337e-16
C4 (CKb VSS) capacitor c=3.64926e-17
C5 (ECKb VSS) capacitor c=7.03302e-16
C6 (Eint VSS) capacitor c=7.40842e-17
C7 (CKbb VSS) capacitor c=6.64598e-16
C8 (14 VSS) capacitor c=4.59195e-18
C9 (15 VSS) capacitor c=4.51456e-18
C10 (n0 VSS) capacitor c=1.7865e-16
C11 (net230 VSS) capacitor c=4.12072e-18
C12 (net254 VSS) capacitor c=5.19245e-18
C13 (net205 VSS) capacitor c=2.66516e-18
C14 (net217 VSS) capacitor c=6.0142e-18
C15 (\7\:CKb VSS) capacitor c=3.40188e-17
C16 (\1\:E VSS) capacitor c=3.33294e-17
C17 (\13\:CKbb VSS) capacitor c=5.33459e-17
C18 (\2\:CKb VSS) capacitor c=3.74952e-17
C19 (\13\:Eint VSS) capacitor c=5.41485e-17
C20 (\3\:CK VSS) capacitor c=3.98293e-17
C21 (\5\:CKb VSS) capacitor c=2.81456e-17
C22 (\3\:E VSS) capacitor c=4.0131e-17
C23 (\3\:CKb VSS) capacitor c=4.85613e-17
C24 (\14\:CKbb VSS) capacitor c=2.78379e-17
C25 (\15\:Eint VSS) capacitor c=3.12272e-17
C26 (\12\:Eint VSS) capacitor c=7.039e-17
C27 (\10\:CKbb VSS) capacitor c=4.45323e-17
C28 (\11\:CKbb VSS) capacitor c=2.40511e-17
C29 (\8\:Eint VSS) capacitor c=3.68512e-17
C30 (\7\:Eint VSS) capacitor c=3.6681e-17
C31 (\5\:CKbb VSS) capacitor c=2.53471e-17
C32 (\4\:CKbb VSS) capacitor c=4.65227e-17
C33 (\1\:CK VSS) capacitor c=2.71364e-17
C34 (\6\:CKb VSS) capacitor c=3.11994e-17
C35 (\2\:E VSS) capacitor c=4.05909e-17
C36 (\4\:CKb VSS) capacitor c=2.68845e-17
C37 (\15\:CKbb VSS) capacitor c=2.07149e-17
C38 (\14\:Eint VSS) capacitor c=3.25587e-17
C39 (\2\:Eint VSS) capacitor c=7.20916e-16
C40 (\2\:CK VSS) capacitor c=3.12924e-17
C41 (\22\:CKbb VSS) capacitor c=4.51383e-17
C42 (\1\:VDD VSS) capacitor c=4.56006e-17
C43 (\12\:n0 VSS) capacitor c=6.36928e-17
C44 (\16\:Eint VSS) capacitor c=3.11425e-17
C45 (\56\:ECKb VSS) capacitor c=4.35358e-16
C46 (\11\:CKb VSS) capacitor c=6.69082e-16
C47 (\3\:VDD VSS) capacitor c=6.33174e-16
C48 (\20\:CKbb VSS) capacitor c=1.2611e-16
C49 (\8\:n0 VSS) capacitor c=7.87869e-17
C50 (\23\:Eint VSS) capacitor c=3.04546e-17
C51 (\68\:ECKb VSS) capacitor c=1.09423e-16
C52 (\65\:ECKb VSS) capacitor c=1.16878e-16
C53 (\13\:CKb VSS) capacitor c=4.03931e-17
C54 (\4\:CK VSS) capacitor c=6.8276e-17
C55 (\64\:ECKb VSS) capacitor c=6.38678e-17
C56 (\67\:ECKb VSS) capacitor c=3.29204e-17
C57 (\18\:Eint VSS) capacitor c=3.7874e-17
C58 (\22\:Eint VSS) capacitor c=3.51436e-17
C59 (\25\:Eint VSS) capacitor c=5.48958e-17
C60 (\10\:n0 VSS) capacitor c=8.72018e-17
C61 (\11\:n0 VSS) capacitor c=5.84111e-17
C62 (\4\:E VSS) capacitor c=4.49062e-17
C63 (\6\:E VSS) capacitor c=5.00329e-17
C64 (\8\:CKb VSS) capacitor c=9.87113e-17
C65 (\9\:CKb VSS) capacitor c=8.09484e-17
C66 (\10\:CKb VSS) capacitor c=5.90765e-16
C67 (\15\:CKb VSS) capacitor c=4.57631e-17
C68 (\19\:CKbb VSS) capacitor c=2.03803e-16
Rk1 (\4\:CK CK) resistor r=0.1076 c=0
Rk100 (\3\:VDD VDD) resistor r=0.1525 c=0
Rk73 (\4\:VDD \3\:VDD) resistor r=0.2012 c=0
Rk72 (\2\:VDD \4\:VDD) resistor r=0.7393 c=0
Rk33 (\4\:E \5\:E) resistor r=0.00188 c=0
Rk34 (E \6\:E) resistor r=0.001786 c=0
Rk35 (\4\:E \6\:E) resistor r=0.06016 c=0
Rk60 (\3\:VSS VSS) resistor r=0.1951 c=0
Rk46 (\2\:VSS \4\:VSS) resistor r=0.5516 c=0
Rk47 (\4\:VSS \5\:VSS) resistor r=0.1502 c=0
Rk50 (\7\:VSS \3\:VSS) resistor r=0.3106 c=0
Rk49 (\5\:VSS \7\:VSS) resistor r=0.4207 c=0
Rk63 (\7\:VSS \23\:VSS) resistor r=0.2054 c=0
Rk36 (\8\:CKb \9\:CKb) resistor r=0.6063 c=0
Rk37 (\9\:CKb \10\:CKb) resistor r=0.1379 c=0
Rk38 (\10\:CKb \12\:CKb) resistor r=4.9485 c=0
Rk39 (\12\:CKb \14\:CKb) resistor r=0.3164 c=0
Rk40 (\10\:CKb \15\:CKb) resistor r=0.2442 c=0
Rk19 (\56\:ECKb \64\:ECKb) resistor r=0.3419 c=0
Rk20 (\64\:ECKb \66\:ECKb) resistor r=0.4673 c=0
Rk21 (\64\:ECKb \67\:ECKb) resistor r=0.1264 c=0
Rk22 (\66\:ECKb \69\:ECKb) resistor r=0.7007 c=0
Rk24 (\18\:Eint \2\:Eint) resistor r=0.2342 c=0
Rk23 (\17\:Eint \18\:Eint) resistor r=0.1161 c=0
Rk27 (\18\:Eint \22\:Eint) resistor r=0.1613 c=0
Rk28 (\22\:Eint \24\:Eint) resistor r=0.09357 c=0
Rk29 (\22\:Eint \25\:Eint) resistor r=0.2657 c=0
Rk43 (CKbb \19\:CKbb) resistor r=1.4213 c=0
Rk44 (\19\:CKbb \21\:CKbb) resistor r=0.7402 c=0
Rk45 (\21\:CKbb \23\:CKbb) resistor r=0.3798 c=0
Rk30 (\9\:n0 \10\:n0) resistor r=0.5107 c=0
Rk31 (\10\:n0 \11\:n0) resistor r=0.2657 c=0
Rk32 (\10\:n0 \13\:n0) resistor r=0.2281 c=0
Rl2 (\2\:CK \3\:CK) resistor r=74.3312 c=0
Rl1 (\1\:CK \2\:CK) resistor r=24.7951 c=0
Rl88 (\1\:E \2\:E) resistor r=94.9225 c=0
Rl89 (\2\:E \3\:E) resistor r=29.5379 c=0
Rl91 (\6\:CKb \7\:CKb) resistor r=80.5643 c=0
Rl90 (\5\:CKb \6\:CKb) resistor r=39.6664 c=0
Rl87 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl84 (CKb \2\:CKb) resistor r=57.6695 c=0
Rl82 (\14\:Eint \13\:Eint) resistor r=97.3098 c=0
Rl83 (\14\:Eint \15\:Eint) resistor r=24.2328 c=0
Rl75 (\2\:Eint \12\:Eint) resistor r=98.4922 c=0
Rl67 (\2\:Eint \8\:Eint) resistor r=72.3105 c=0
Rl66 (\2\:Eint \7\:Eint) resistor r=71.8867 c=0
Rl57 (\2\:Eint Eint) resistor r=74.2328 c=0
Rl85 (\14\:CKbb \13\:CKbb) resistor r=150 c=0
Rl71 (CKbb \10\:CKbb) resistor r=28.0797 c=0
Rl72 (CKbb \11\:CKbb) resistor r=24.2328 c=0
Rl62 (CKbb \5\:CKbb) resistor r=22.5951 c=0
Rl61 (CKbb \4\:CKbb) resistor r=28.0797 c=0
Rl86 (\15\:CKbb \14\:CKbb) resistor r=26.1559 c=0
Rz14 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz17 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz12 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz8 (\66\:ECKb \65\:ECKb) resistor r=75 c=0
Rz9 (\69\:ECKb \68\:ECKb) resistor r=75 c=0
Rz10 (\24\:Eint \23\:Eint) resistor r=75 c=0
Rz13 (\21\:CKbb \20\:CKbb) resistor r=75 c=0
Rz11 (\9\:n0 \8\:n0) resistor r=75 c=0
Ry19 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry14 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry12 (\17\:Eint \16\:Eint) resistor r=62 c=0
Ry15 (\23\:CKbb \22\:CKbb) resistor r=62 c=0
Ry13 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:E \5\:E) resistor r=45 c=0
Rx9 (\6\:CKb \8\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \9\:CKb) resistor r=45 c=0
Rx11 (CKb \15\:CKb) resistor r=45 c=0
Rx2 (\67\:ECKb ECKb) resistor r=45 c=0
Rx6 (\25\:Eint \14\:Eint) resistor r=45 c=0
Rx14 (\19\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\11\:n0 n0) resistor r=45 c=0
mn0 (\13\:CKb \1\:CK \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.218e-14 ad=2.465e-14 ps=1.02e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn15 (net230 \15\:Eint \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.418e-14 ad=5.365e-14 ps=1.64e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.275e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn16 (\8\:n0 \14\:CKbb net230 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=3.553e-14 ps=1.03e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn6 (\8\:n0 \3\:CKb net254 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=3.553e-14 ps=5.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.7e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn5 (net254 \3\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.595e-14 ps=1.37e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.15e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn1 (\20\:CKbb \5\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=2.175e-14 ps=1.37e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.5e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn22_1__rcx (ECK ECKb \3\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.843e-14 ad=4.825e-14 ps=9.2571e-07 pd=9.1714e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.82542e-07 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(14)
mn20_1__rcx (13 Eint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.94e-14 ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.90587e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_1__rcx (\65\:ECKb \4\:CKbb 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.88365e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_2__rcx (\65\:ECKb \5\:CKbb 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78721e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_2__rcx (14 \7\:Eint \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.68e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.69654e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_3__rcx (15 \8\:Eint \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.68e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.57933e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_3__rcx (\68\:ECKb \11\:CKbb 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.48865e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21 (\68\:ECKb \10\:CKbb 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37144e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20 (16 \12\:Eint \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.408e-14 ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.325e-06 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn10_1__rcx (\23\:Eint n0 \5\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.913e-14 ad=3.895e-14 ps=1.355e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.42902e-06 sd=160n sca=15.5643 \
        scb=0.0161016 scc=0.00117276 m=(2)
mp22_1__rcx (ECK ECKb \3\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.223e-14 ad=7.12e-14 ps=1.21929e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53539e-07 sb=2e-06 sd=160n sca=16.9974 \
        scb=0.0149208 scc=0.00098088 m=(14)
mp20_1__rcx (\56\:ECKb \2\:Eint \3\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=8.805e-14 ad=6.24e-14 ps=1.4325e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=1.94154e-06 sd=160n \
        sca=15.8351 scb=0.0142471 scc=0.00110276 m=(4)
mp21_1__rcx (\56\:ECKb CKbb \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.24e-14 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.89365e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(4)
mp10 (\16\:Eint n0 \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.136e-14 ad=4.96e-14 ps=1.675e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.3554e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
ends TLATNCAX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:19:52 2013 )
