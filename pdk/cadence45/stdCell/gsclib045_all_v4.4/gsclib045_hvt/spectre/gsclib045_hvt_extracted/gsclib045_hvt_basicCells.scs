C16 (Eb VSS) capacitor c=3.36518e-17
C17 (qint VSS) capacitor c=2.97484e-16
C18 (net342 VSS) capacitor c=1.62677e-18
C19 (net362 VSS) capacitor c=4.18216e-18
C20 (n1 VSS) capacitor c=1.84799e-18
C21 (\19\:qbint VSS) capacitor c=5.06444e-17
C22 (\4\:qbint VSS) capacitor c=2.91956e-16
C23 (\5\:E VSS) capacitor c=5.38606e-17
C24 (\1\:E VSS) capacitor c=2.63778e-17
C25 (\2\:Eb VSS) capacitor c=6.94766e-17
C26 (\1\:D VSS) capacitor c=6.31871e-17
C27 (\7\:CKbb VSS) capacitor c=5.08994e-17
C28 (\2\:Ckb VSS) capacitor c=1.29036e-16
C29 (\3\:Ckb VSS) capacitor c=1.43567e-16
C30 (\8\:Ckb VSS) capacitor c=5.05286e-17
C31 (\3\:CK VSS) capacitor c=4.33323e-17
C32 (\17\:qbint VSS) capacitor c=2.4811e-17
C33 (\7\:E VSS) capacitor c=3.76674e-17
C34 (\3\:Eb VSS) capacitor c=4.55123e-17
C35 (\3\:E VSS) capacitor c=7.29248e-17
C36 (\3\:D VSS) capacitor c=5.19948e-17
C37 (\3\:qbint VSS) capacitor c=3.44802e-17
C38 (\5\:CKbb VSS) capacitor c=5.88655e-17
C39 (\3\:n20 VSS) capacitor c=4.11365e-17
C40 (\3\:mout VSS) capacitor c=5.0111e-17
C41 (\3\:CKbb VSS) capacitor c=8.43317e-17
C42 (\7\:Ckb VSS) capacitor c=2.38698e-17
C43 (\9\:Ckb VSS) capacitor c=2.34915e-17
C44 (\1\:CK VSS) capacitor c=3.94081e-17
C45 (\18\:qbint VSS) capacitor c=4.8203e-17
C46 (\6\:E VSS) capacitor c=3.354e-17
C47 (\4\:E VSS) capacitor c=1.63761e-17
C48 (\4\:Eb VSS) capacitor c=3.29968e-17
C49 (\2\:D VSS) capacitor c=5.37035e-17
C50 (\4\:n30 VSS) capacitor c=2.26543e-17
C51 (\2\:qbint VSS) capacitor c=4.70725e-17
C52 (\8\:CKbb VSS) capacitor c=5.40981e-17
C53 (\6\:CKbb VSS) capacitor c=2.27775e-17
C54 (\2\:n20 VSS) capacitor c=3.54333e-17
C55 (\2\:mout VSS) capacitor c=5.21472e-17
C56 (\4\:CKbb VSS) capacitor c=2.44148e-17
C57 (\2\:CKbb VSS) capacitor c=4.24117e-17
C58 (\6\:Ckb VSS) capacitor c=5.40946e-17
C59 (\2\:CK VSS) capacitor c=5.19031e-17
C60 (\20\:qint VSS) capacitor c=6.23855e-17
C61 (\1\:VDD VSS) capacitor c=3.57438e-16
C62 (\1\:QN VSS) capacitor c=1.49414e-16
C63 (\1\:Q VSS) capacitor c=1.57865e-16
C64 (\5\:Eb VSS) capacitor c=7.07193e-17
C65 (\21\:qbint VSS) capacitor c=1.23699e-16
C66 (\8\:Db VSS) capacitor c=3.08276e-17
C67 (\33\:qbint VSS) capacitor c=6.16481e-17
C68 (\13\:n30 VSS) capacitor c=1.20082e-19
C69 (\4\:mout VSS) capacitor c=6.57225e-17
C70 (\27\:VDD VSS) capacitor c=6.98318e-17
C71 (\8\:n20 VSS) capacitor c=4.2547e-17
C72 (\3\:Db VSS) capacitor c=3.28094e-16
C73 (\16\:CKbb VSS) capacitor c=8.34382e-17
C74 (\29\:VDD VSS) capacitor c=2.65233e-17
C75 (\13\:Ckb VSS) capacitor c=7.65667e-17
C76 (\3\:VDD VSS) capacitor c=9.82264e-17
C77 (\16\:qint VSS) capacitor c=3.39321e-17
C78 (\10\:Eb VSS) capacitor c=7.00929e-17
C79 (\25\:qbint VSS) capacitor c=2.07658e-16
C80 (\6\:Db VSS) capacitor c=9.71209e-17
C81 (\31\:qbint VSS) capacitor c=2.00602e-17
C82 (\11\:n30 VSS) capacitor c=7.84192e-17
C83 (\8\:mout VSS) capacitor c=3.26057e-17
C84 (\6\:n20 VSS) capacitor c=5.08688e-17
C85 (\13\:CKbb VSS) capacitor c=1.06058e-16
C86 (\10\:Ckb VSS) capacitor c=1.91993e-17
C87 (\4\:Ckb VSS) capacitor c=5.88304e-17
C88 (\5\:n30 VSS) capacitor c=9.28497e-17
C89 (\2\:E VSS) capacitor c=4.23433e-17
C90 (\4\:CK VSS) capacitor c=3.00454e-17
C91 (\12\:Ckb VSS) capacitor c=7.35131e-17
C92 (\15\:Ckb VSS) capacitor c=4.39961e-17
C93 (\4\:n20 VSS) capacitor c=7.50316e-17
C94 (\5\:n20 VSS) capacitor c=6.30179e-17
C95 (\6\:mout VSS) capacitor c=5.83822e-17
C96 (\7\:mout VSS) capacitor c=5.99888e-17
C97 (\9\:CKbb VSS) capacitor c=8.9347e-17
C98 (\10\:CKbb VSS) capacitor c=1.2593e-16
C99 (\11\:CKbb VSS) capacitor c=8.3203e-17
C100 (\12\:CKbb VSS) capacitor c=7.24023e-17
C101 (\15\:CKbb VSS) capacitor c=7.15104e-17
C102 (\9\:n30 VSS) capacitor c=7.33723e-17
C103 (\10\:n30 VSS) capacitor c=1.01903e-16
C104 (\4\:D VSS) capacitor c=5.57209e-17
C105 (\5\:Db VSS) capacitor c=2.69702e-16
C106 (\7\:Eb VSS) capacitor c=1.02759e-16
C107 (\8\:Eb VSS) capacitor c=2.95342e-17
C108 (\9\:Eb VSS) capacitor c=7.57063e-17
C109 (\9\:E VSS) capacitor c=5.2907e-17
C110 (\10\:E VSS) capacitor c=2.01453e-17
C111 (\20\:qbint VSS) capacitor c=9.57247e-17
C112 (\4\:Q VSS) capacitor c=1.35671e-16
C113 (\4\:QN VSS) capacitor c=1.28251e-16
C114 (\23\:qbint VSS) capacitor c=1.61867e-16
C115 (\24\:qbint VSS) capacitor c=2.08545e-16
C116 (\27\:qbint VSS) capacitor c=1.33445e-16
C117 (\29\:qbint VSS) capacitor c=4.37097e-17
C118 (\30\:qbint VSS) capacitor c=2.78194e-17
C119 (\18\:qint VSS) capacitor c=3.67327e-17
C120 (\19\:qint VSS) capacitor c=3.59175e-17
C121 (\10\:VDD VSS) capacitor c=9.74118e-17
C122 (\12\:VDD VSS) capacitor c=3.31134e-17
C123 (\14\:VDD VSS) capacitor c=2.24776e-17
Rk22 (\4\:D D) resistor r=0.03526 c=0
Rk43 (\1\:QN QN) resistor r=0.02532 c=0
Rk44 (QN \4\:QN) resistor r=0.2812 c=0
Rk84 (\1\:VDD \9\:VDD) resistor r=0.3158 c=0
Rk85 (\9\:VDD \10\:VDD) resistor r=0.3058 c=0
Rk87 (\10\:VDD \12\:VDD) resistor r=0.4962 c=0
Rk88 (\12\:VDD \13\:VDD) resistor r=0.1653 c=0
Rk90 (\14\:VDD VDD) resistor r=0.1626 c=0
Rk89 (\13\:VDD \14\:VDD) resistor r=0.3886 c=0
Rk97 (\12\:VDD \28\:VDD) resistor r=0.3228 c=0
Rk98 (\14\:VDD \30\:VDD) resistor r=0.1744 c=0
Rk3 (\4\:CK CK) resistor r=0.01803 c=0
Rk31 (\8\:E \9\:E) resistor r=0.001297 c=0
Rk34 (\10\:E E) resistor r=0.003305 c=0
Rk33 (\9\:E \10\:E) resistor r=0.1142 c=0
Rk32 (\10\:E \11\:E) resistor r=0.001297 c=0
Rk37 (\1\:Q Q) resistor r=0.00338 c=0
Rk38 (Q \4\:Q) resistor r=0.2935 c=0
Rk64 (\1\:VSS \9\:VSS) resistor r=0.192 c=0
Rk65 (\9\:VSS \10\:VSS) resistor r=0.3209 c=0
Rk67 (\10\:VSS \12\:VSS) resistor r=0.4962 c=0
Rk68 (\12\:VSS \13\:VSS) resistor r=0.1653 c=0
Rk70 (\14\:VSS VSS) resistor r=0.1475 c=0
Rk69 (\13\:VSS \14\:VSS) resistor r=0.4036 c=0
Rk77 (\12\:VSS \28\:VSS) resistor r=0.1229 c=0
Rk78 (\14\:VSS \30\:VSS) resistor r=0.2846 c=0
Rk4 (\11\:Ckb \12\:Ckb) resistor r=0.09749 c=0
Rk5 (\12\:Ckb \14\:Ckb) resistor r=0.6273 c=0
Rk6 (\12\:Ckb \15\:Ckb) resistor r=0.2017 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.5389 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.5003 c=0
Rk15 (\11\:CKbb \12\:CKbb) resistor r=0.2237 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.3037 c=0
Rk17 (\12\:CKbb \15\:CKbb) resistor r=0.3894 c=0
Rk18 (\14\:CKbb \17\:CKbb) resistor r=0.6438 c=0
Rk7 (\4\:n20 \5\:n20) resistor r=0.3382 c=0
Rk8 (\5\:n20 \7\:n20) resistor r=0.2526 c=0
Rk9 (\5\:n20 \9\:n20) resistor r=0.1688 c=0
Rk23 (\2\:Db \4\:Db) resistor r=0.6131 c=0
Rk24 (\4\:Db \5\:Db) resistor r=2.1284 c=0
Rk25 (\5\:Db \7\:Db) resistor r=0.4704 c=0
Rk26 (\5\:Db \9\:Db) resistor r=0.03526 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.3093 c=0
Rk11 (\6\:mout \7\:mout) resistor r=0.309 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.135 c=0
Rk19 (\9\:n30 \10\:n30) resistor r=0.4482 c=0
Rk20 (\10\:n30 \12\:n30) resistor r=0.4237 c=0
Rk21 (\10\:n30 \14\:n30) resistor r=0.03453 c=0
Rk35 (\20\:qbint \22\:qbint) resistor r=0.4768 c=0
Rk48 (\23\:qbint \24\:qbint) resistor r=1.0513 c=0
Rk49 (\24\:qbint \26\:qbint) resistor r=0.9532 c=0
Rk50 (\26\:qbint \27\:qbint) resistor r=0.8797 c=0
Rk51 (\27\:qbint \28\:qbint) resistor r=0.0618 c=0
Rk52 (\28\:qbint \29\:qbint) resistor r=0.1843 c=0
Rk53 (\24\:qbint \30\:qbint) resistor r=0.2363 c=0
Rk54 (\27\:qbint \32\:qbint) resistor r=0.08109 c=0
Rk55 (\28\:qbint \34\:qbint) resistor r=0.2832 c=0
Rk27 (\6\:Eb \7\:Eb) resistor r=0.3848 c=0
Rk28 (\7\:Eb \8\:Eb) resistor r=0.2027 c=0
Rk29 (\7\:Eb \9\:Eb) resistor r=0.4689 c=0
Rk30 (\9\:Eb \11\:Eb) resistor r=0.3055 c=0
Rk56 (\17\:qint \18\:qint) resistor r=0.2457 c=0
Rk57 (\18\:qint \19\:qint) resistor r=0.2602 c=0
Rk58 (\18\:qint \21\:qint) resistor r=0.1449 c=0
Rl28 (\1\:D \2\:D) resistor r=35.796 c=0
Rl29 (\2\:D \3\:D) resistor r=120.479 c=0
Rl2 (\2\:CK \3\:CK) resistor r=155.002 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.2328 c=0
Rl35 (\5\:E \6\:E) resistor r=102.931 c=0
Rl36 (\6\:E \7\:E) resistor r=66.0764 c=0
Rl32 (\1\:E \2\:E) resistor r=67.9709 c=0
Rl33 (\2\:E \3\:E) resistor r=209.283 c=0
Rl34 (\2\:E \4\:E) resistor r=16.1277 c=0
Rl11 (\2\:Ckb \3\:Ckb) resistor r=397.208 c=0
Rl10 (Ckb \2\:Ckb) resistor r=202.977 c=0
Rl17 (\6\:Ckb \9\:Ckb) resistor r=45.6101 c=0
Rl12 (\3\:Ckb \4\:Ckb) resistor r=247.62 c=0
Rl15 (\4\:Ckb \7\:Ckb) resistor r=30.4507 c=0
Rl16 (\5\:Ckb \8\:Ckb) resistor r=204.928 c=0
Rl14 (\5\:Ckb \6\:Ckb) resistor r=14.7598 c=0
Rl13 (\4\:Ckb \5\:Ckb) resistor r=150.075 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl9 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=46.8456 c=0
Rl3 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl7 (n20 \2\:n20) resistor r=50.6918 c=0
Rl8 (\2\:n20 \3\:n20) resistor r=91.0764 c=0
Rl5 (mout \2\:mout) resistor r=112.23 c=0
Rl6 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl23 (n30 \4\:n30) resistor r=9.7447 c=0
Rl24 (\5\:n30 n30) resistor r=31.6073 c=0
Rl64 (\18\:qbint \19\:qbint) resistor r=97.3098 c=0
Rl63 (\18\:qbint \17\:qbint) resistor r=28.1859 c=0
Rl19 (\2\:qbint qbint) resistor r=108.848 c=0
Rl20 (\2\:qbint \3\:qbint) resistor r=30.0021 c=0
Rl31 (\3\:Eb \4\:Eb) resistor r=26.1559 c=0
Rl30 (Eb \2\:Eb) resistor r=45.6844 c=0
Rz25 (\1\:VDD \3\:VDD) resistor r=9.375 c=0
Rz26 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz27 (\13\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz24 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz1 (\10\:Ckb \11\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\6\:Db \7\:Db) resistor r=75 c=0
Rz3 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz13 (\26\:qbint \25\:qbint) resistor r=75 c=0
Rz14 (\32\:qbint \31\:qbint) resistor r=75 c=0
Rz8 (\10\:Eb \11\:Eb) resistor r=75 c=0
Rz15 (\17\:qint \16\:qint) resistor r=75 c=0
Ry26 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry27 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \3\:VSS) resistor r=7.75 c=0
Ry17 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\13\:Ckb \14\:Ckb) resistor r=62 c=0
Ry4 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\8\:Db \9\:Db) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry5 (\14\:n30 \13\:n30) resistor r=62 c=0
Ry9 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry14 (\34\:qbint \33\:qbint) resistor r=62 c=0
Ry8 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry15 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx13 (\4\:E \8\:E) resistor r=45 c=0
Rx14 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\6\:Ckb \15\:Ckb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\9\:n30 \4\:n30) resistor r=45 c=0
Rx15 (\20\:qbint \4\:qbint) resistor r=45 c=0
Rx16 (\23\:qbint \18\:qbint) resistor r=45 c=0
Rx17 (\29\:qbint \2\:qbint) resistor r=45 c=0
Rx18 (\30\:qbint \4\:qbint) resistor r=45 c=0
Rx11 (Eb \8\:Eb) resistor r=45 c=0
Rx12 (\4\:Eb \9\:Eb) resistor r=45 c=0
Rx19 (\19\:qint qint) resistor r=45 c=0
mn20 (\10\:Ckb \1\:CK \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn21 (\13\:CKbb \9\:Ckb \29\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn25 (Db \7\:Ckb \6\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn36 (\6\:n20 \3\:CKbb net411 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.93e-14 ps=4.2e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.88828e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn35 (net411 \3\:mout \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=9.42e-15 ps=1.37e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.85414e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (\8\:mout \3\:n20 \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=3.987e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.69948e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn40 (\8\:mout \5\:CKbb \11\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.987e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.37948e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn51 (\11\:n30 Ckb net415 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=1.17448e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn50 (net415 \3\:qbint \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.535e-14 ad=2.247e-14 ps=7.9e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=9.74483e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn2 (n0 \3\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.992e-14 ad=1.885e-14 ps=7.4e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55155e-06 sb=5.2e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\6\:Db \3\:E n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.32e-14 ps=5.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60586e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn1 (\25\:qbint \3\:Eb \6\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66948e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\10\:Eb \7\:E \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\31\:qbint \5\:n30 \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.264e-14 ad=3.28e-14 ps=7.65e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35366e-06 sb=7.5061e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(2)
mn56 (\16\:qint \17\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.98e-14 ad=3.64e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.611e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.31058e-07 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\4\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.665e-14 ad=5.135e-14 ps=1.445e-06 pd=9.15e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.17106e-06 sb=1.165e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mp45_1__rcx (\33\:qbint n30 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.465e-14 ad=4.96e-14 ps=1.58e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24153e-06 sb=8.32742e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(2)
mp56 (\20\:qint \19\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91923e-06 sb=1.4e-07 sd=160n sca=16.2631 \
        scb=0.0157178 scc=0.000443168 m=(1)
mp57 (\1\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10955e-06 sb=9.8e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.314e-14 ad=6.63e-14 ps=1.115e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.82e-06 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
ends EDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:17 2013 )
// Library name: gsclib045_hvt
// Cell name: EDFFXL
// View name: extracted

simulator lang=spectre

subckt EDFFXL CK D E Q QN VDD VSS
mp20 (\14\:Ckb \3\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=18.237 scb=0.0193375 \
        scc=0.000503065 m=(1)
mp21 (\18\:CKbb \7\:Ckb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp25 (\6\:n20 CKbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp36 (\6\:n20 \5\:Ckb net342 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp35 (net342 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=6.773e-14 ps=1.48e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp30 (\8\:mout n20 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=9.997e-14 ps=1.48e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp40 (\7\:n30 \10\:Ckb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.997e-14 ad=4.837e-14 ps=1.36e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=1.98e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\7\:n30 \7\:CKbb net362 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.837e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.71e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net362 \4\:qbint \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=1.72e-14 ps=1.64e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.585e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp45 (\17\:qbint n30 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.87e-14 ps=1.64e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.32e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp1 (\17\:qbint \1\:E Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.095e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp3 (Db Eb n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=7.418e-14 \
        ad=3.44e-14 ps=1.12e-06 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.9e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (n1 \1\:D \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.093e-14 ad=7.418e-14 ps=1.51e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp0 (\5\:Eb \5\:E \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.093e-14 ad=3.87e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.8e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp55 (\3\:Q \11\:qbint \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\7\:qint \5\:qbint \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.3496 \
        scb=0.0285354 scc=0.00588424 m=(1)
mp57 (\3\:QN qint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.8e-07 sd=160n sca=24.9702 \
        scb=0.0291896 scc=0.0015765 m=(1)
C1 (D VSS) capacitor c=7.22126e-17
C2 (QN VSS) capacitor c=2.8031e-17
C3 (VDD VSS) capacitor c=3.72761e-16
C4 (CK VSS) capacitor c=7.76437e-17
C5 (E VSS) capacitor c=1.16744e-16
C6 (Q VSS) capacitor c=1.93522e-17
C7 (Ckb VSS) capacitor c=2.40914e-17
C8 (CKbb VSS) capacitor c=4.13607e-17
C9 (n20 VSS) capacitor c=4.18788e-17
C10 (Db VSS) capacitor c=3.08111e-16
C11 (mout VSS) capacitor c=3.37393e-17
C12 (n30 VSS) capacitor c=5.08158e-17
C13 (qbint VSS) capacitor c=1.83435e-17
C14 (Eb VSS) capacitor c=3.06006e-17
C15 (n0 VSS) capacitor c=3.1646e-18
C16 (qint VSS) capacitor c=3.6384e-17
C17 (net342 VSS) capacitor c=6.18079e-18
C18 (net362 VSS) capacitor c=4.46496e-19
C19 (n1 VSS) capacitor c=6.74446e-18
C20 (\5\:qbint VSS) capacitor c=1.97151e-17
C21 (\11\:qbint VSS) capacitor c=2.10634e-17
C22 (\5\:E VSS) capacitor c=3.16289e-17
C23 (\1\:D VSS) capacitor c=3.42528e-17
C24 (\1\:E VSS) capacitor c=5.31613e-17
C25 (\4\:qbint VSS) capacitor c=4.90087e-17
C26 (\7\:CKbb VSS) capacitor c=5.99733e-17
C27 (\10\:Ckb VSS) capacitor c=7.13975e-17
C28 (\5\:Ckb VSS) capacitor c=5.53996e-17
C29 (\7\:Ckb VSS) capacitor c=4.82579e-17
C30 (\3\:CK VSS) capacitor c=4.33429e-17
C31 (\3\:qint VSS) capacitor c=2.54774e-17
C32 (\10\:qbint VSS) capacitor c=1.59388e-17
C33 (\8\:qbint VSS) capacitor c=1.15982e-17
C34 (\7\:E VSS) capacitor c=3.82561e-17
C35 (\3\:D VSS) capacitor c=3.0842e-17
C36 (\3\:E VSS) capacitor c=3.5992e-17
C37 (\3\:Eb VSS) capacitor c=5.27909e-17
C38 (\3\:n30 VSS) capacitor c=2.55653e-17
C39 (\3\:qbint VSS) capacitor c=5.89752e-17
C40 (\9\:Ckb VSS) capacitor c=8.54543e-17
C41 (\5\:CKbb VSS) capacitor c=2.67259e-17
C42 (\3\:n20 VSS) capacitor c=3.14227e-17
C43 (\3\:mout VSS) capacitor c=4.63254e-17
C44 (\3\:CKbb VSS) capacitor c=4.23821e-17
C45 (\8\:Ckb VSS) capacitor c=2.65791e-17
C46 (\1\:CK VSS) capacitor c=3.8352e-17
C47 (\2\:qint VSS) capacitor c=2.00367e-17
C48 (\9\:qbint VSS) capacitor c=1.51158e-17
C49 (\6\:E VSS) capacitor c=2.37713e-17
C50 (\2\:D VSS) capacitor c=3.34921e-17
C51 (\4\:Eb VSS) capacitor c=3.1323e-17
C52 (\4\:E VSS) capacitor c=4.02477e-17
C53 (\2\:E VSS) capacitor c=2.52198e-17
C54 (\2\:n30 VSS) capacitor c=3.82516e-17
C55 (\8\:CKbb VSS) capacitor c=4.1863e-17
C56 (\6\:CKbb VSS) capacitor c=3.21027e-17
C57 (\11\:Ckb VSS) capacitor c=2.93549e-17
C58 (\2\:n20 VSS) capacitor c=3.17532e-17
C59 (\2\:mout VSS) capacitor c=3.69345e-17
C60 (\4\:CKbb VSS) capacitor c=2.02466e-17
C61 (\6\:Ckb VSS) capacitor c=2.46961e-17
C62 (\2\:CKbb VSS) capacitor c=4.05936e-17
C63 (\4\:Ckb VSS) capacitor c=5.48285e-17
C64 (\2\:CK VSS) capacitor c=5.31766e-17
C65 (\3\:QN VSS) capacitor c=2.07962e-17
C66 (\1\:VDD VSS) capacitor c=1.83727e-17
C67 (\7\:qint VSS) capacitor c=2.56596e-17
C68 (\6\:VDD VSS) capacitor c=3.75863e-17
C69 (\3\:Q VSS) capacitor c=4.37745e-17
C70 (\5\:Eb VSS) capacitor c=6.13636e-17
C71 (\9\:VDD VSS) capacitor c=3.36017e-17
C72 (\17\:qbint VSS) capacitor c=3.68187e-17
C73 (\13\:VDD VSS) capacitor c=1.05449e-17
C74 (\7\:n30 VSS) capacitor c=7.03388e-17
C75 (\8\:mout VSS) capacitor c=5.74285e-17
C76 (\16\:VDD VSS) capacitor c=3.05945e-17
C77 (\6\:n20 VSS) capacitor c=4.94772e-17
C78 (\3\:Db VSS) capacitor c=3.06954e-16
C79 (\18\:CKbb VSS) capacitor c=7.90889e-17
C80 (\20\:VDD VSS) capacitor c=2.70794e-17
C81 (\14\:Ckb VSS) capacitor c=7.675e-17
C82 (\3\:VDD VSS) capacitor c=8.36559e-17
C83 (\1\:QN VSS) capacitor c=3.62351e-17
C84 (\5\:qint VSS) capacitor c=3.64661e-17
C85 (\1\:Q VSS) capacitor c=3.45737e-17
C86 (\7\:Eb VSS) capacitor c=1.22019e-16
C87 (\7\:Db VSS) capacitor c=6.86621e-17
C88 (\13\:qbint VSS) capacitor c=1.43538e-16
C89 (\4\:n30 VSS) capacitor c=3.58361e-17
C90 (\6\:mout VSS) capacitor c=5.07504e-17
C91 (\8\:n20 VSS) capacitor c=3.74035e-17
C92 (\5\:Db VSS) capacitor c=7.20559e-17
C93 (\13\:CKbb VSS) capacitor c=9.92866e-17
C94 (\16\:Ckb VSS) capacitor c=1.93206e-17
C95 (\2\:Ckb VSS) capacitor c=4.76401e-17
C96 (\2\:qbint VSS) capacitor c=2.99197e-17
C97 (\2\:Eb VSS) capacitor c=5.61918e-17
C98 (\6\:qbint VSS) capacitor c=1.01211e-17
C99 (\7\:qbint VSS) capacitor c=9.55633e-18
C100 (\4\:CK VSS) capacitor c=3.157e-17
C101 (\12\:Ckb VSS) capacitor c=4.78313e-17
C102 (\13\:Ckb VSS) capacitor c=7.63492e-17
C103 (\4\:n20 VSS) capacitor c=6.95872e-17
C104 (\5\:n20 VSS) capacitor c=6.44023e-17
C105 (\18\:Ckb VSS) capacitor c=1.15647e-16
C106 (\19\:Ckb VSS) capacitor c=1.17625e-16
C107 (\4\:mout VSS) capacitor c=6.19239e-17
C108 (\5\:mout VSS) capacitor c=6.26701e-17
C109 (\9\:CKbb VSS) capacitor c=3.27242e-17
C110 (\10\:CKbb VSS) capacitor c=1.15351e-16
C111 (\11\:CKbb VSS) capacitor c=1.09355e-16
C112 (\12\:CKbb VSS) capacitor c=6.15245e-17
C113 (\15\:CKbb VSS) capacitor c=3.52555e-17
C114 (\16\:CKbb VSS) capacitor c=1.91704e-17
C115 (\17\:CKbb VSS) capacitor c=8.00769e-17
C116 (\6\:n30 VSS) capacitor c=6.50546e-17
C117 (\9\:n30 VSS) capacitor c=5.84014e-17
C118 (\5\:D VSS) capacitor c=6.97749e-17
C119 (\8\:E VSS) capacitor c=8.42355e-17
C120 (\9\:E VSS) capacitor c=1.29608e-16
C121 (\10\:E VSS) capacitor c=5.01329e-17
C122 (\9\:Eb VSS) capacitor c=1.19241e-16
C123 (\12\:qbint VSS) capacitor c=1.39949e-16
C124 (\15\:qbint VSS) capacitor c=4.96668e-17
C125 (\16\:qbint VSS) capacitor c=5.29455e-17
C126 (\4\:qint VSS) capacitor c=4.12788e-17
C127 (\5\:VDD VSS) capacitor c=1.08383e-17
C128 (\8\:VDD VSS) capacitor c=1.5866e-17
C129 (\12\:VDD VSS) capacitor c=4.60375e-17
C130 (\15\:VDD VSS) capacitor c=4.28387e-17
C131 (\19\:VDD VSS) capacitor c=2.23245e-17
Rk28 (\4\:D \5\:D) resistor r=0.01193 c=0
Rk29 (\6\:D D) resistor r=0.01193 c=0
Rk30 (\5\:D \6\:D) resistor r=0.01198 c=0
Rk45 (\2\:QN QN) resistor r=0.2459 c=0
Rk46 (QN \4\:QN) resistor r=0.1533 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.3837 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.243 c=0
Rk49 (\5\:VDD \7\:VDD) resistor r=0.4169 c=0
Rk50 (\5\:VDD \8\:VDD) resistor r=0.4082 c=0
Rk51 (\8\:VDD \10\:VDD) resistor r=0.149 c=0
Rk52 (\8\:VDD \11\:VDD) resistor r=0.1502 c=0
Rk53 (\11\:VDD \12\:VDD) resistor r=0.3784 c=0
Rk54 (\12\:VDD \14\:VDD) resistor r=0.07369 c=0
Rk55 (\12\:VDD \15\:VDD) resistor r=0.5712 c=0
Rk56 (\15\:VDD \17\:VDD) resistor r=0.1224 c=0
Rk57 (\15\:VDD \18\:VDD) resistor r=0.253 c=0
Rk60 (\19\:VDD VDD) resistor r=0.1625 c=0
Rk58 (\18\:VDD \19\:VDD) resistor r=0.3884 c=0
Rk59 (\19\:VDD \21\:VDD) resistor r=0.1736 c=0
Rk3 (\4\:CK CK) resistor r=0.01799 c=0
Rk33 (\9\:E E) resistor r=0.7475 c=0
Rk31 (\8\:E \9\:E) resistor r=0.4181 c=0
Rk32 (\9\:E \10\:E) resistor r=0.2745 c=0
Rk34 (E \11\:E) resistor r=0.002705 c=0
Rk37 (\2\:Q Q) resistor r=0.03458 c=0
Rk38 (Q \4\:Q) resistor r=0.1761 c=0
Rk61 (\2\:VSS \4\:VSS) resistor r=0.3316 c=0
Rk62 (\4\:VSS \5\:VSS) resistor r=0.2279 c=0
Rk63 (\5\:VSS \6\:VSS) resistor r=0.4233 c=0
Rk64 (\6\:VSS \7\:VSS) resistor r=0.1502 c=0
Rk65 (\7\:VSS \8\:VSS) resistor r=0.4084 c=0
Rk66 (\8\:VSS \9\:VSS) resistor r=0.5712 c=0
Rk67 (\9\:VSS \10\:VSS) resistor r=0.2229 c=0
Rk69 (\11\:VSS VSS) resistor r=0.1475 c=0
Rk68 (\10\:VSS \11\:VSS) resistor r=0.4034 c=0
Rk70 (\5\:VSS \13\:VSS) resistor r=0.07369 c=0
Rk71 (\6\:VSS \15\:VSS) resistor r=0.139 c=0
Rk72 (\8\:VSS \17\:VSS) resistor r=0.3556 c=0
Rk73 (\9\:VSS \19\:VSS) resistor r=0.1457 c=0
Rk74 (\11\:VSS \21\:VSS) resistor r=0.2823 c=0
Rk4 (\12\:Ckb \13\:Ckb) resistor r=0.264 c=0
Rk5 (\13\:Ckb \15\:Ckb) resistor r=0.6247 c=0
Rk6 (\13\:Ckb \17\:Ckb) resistor r=0.097 c=0
Rk10 (\18\:Ckb \19\:Ckb) resistor r=0.7787 c=0
Rk14 (\9\:CKbb \10\:CKbb) resistor r=0.06544 c=0
Rk15 (\10\:CKbb \11\:CKbb) resistor r=1.0271 c=0
Rk16 (\11\:CKbb \12\:CKbb) resistor r=0.206 c=0
Rk17 (\12\:CKbb \14\:CKbb) resistor r=0.2701 c=0
Rk18 (\10\:CKbb \15\:CKbb) resistor r=0.1694 c=0
Rk19 (\11\:CKbb \16\:CKbb) resistor r=0.03536 c=0
Rk20 (\12\:CKbb \17\:CKbb) resistor r=0.3682 c=0
Rk21 (\14\:CKbb \19\:CKbb) resistor r=0.6437 c=0
Rk7 (\4\:n20 \5\:n20) resistor r=0.418 c=0
Rk8 (\5\:n20 \7\:n20) resistor r=0.2991 c=0
Rk9 (\5\:n20 \9\:n20) resistor r=0.1276 c=0
Rk25 (\2\:Db \4\:Db) resistor r=2.2342 c=0
Rk26 (\4\:Db \6\:Db) resistor r=0.4026 c=0
Rk27 (\2\:Db \8\:Db) resistor r=0.4021 c=0
Rk11 (\4\:mout \5\:mout) resistor r=0.2686 c=0
Rk12 (\5\:mout \7\:mout) resistor r=0.2496 c=0
Rk13 (\5\:mout \9\:mout) resistor r=0.1967 c=0
Rk22 (\5\:n30 \6\:n30) resistor r=0.1777 c=0
Rk23 (\6\:n30 \8\:n30) resistor r=0.3393 c=0
Rk24 (\6\:n30 \9\:n30) resistor r=0.2477 c=0
Rk39 (\12\:qbint \14\:qbint) resistor r=1.1577 c=0
Rk40 (\14\:qbint \15\:qbint) resistor r=0.2845 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.1978 c=0
Rk42 (\15\:qbint \18\:qbint) resistor r=0.09309 c=0
Rk35 (\6\:Eb \8\:Eb) resistor r=0.4001 c=0
Rk36 (\8\:Eb \9\:Eb) resistor r=0.7067 c=0
Rk43 (\4\:qint \6\:qint) resistor r=0.2017 c=0
Rk44 (\6\:qint \8\:qint) resistor r=0.2148 c=0
Rl30 (\1\:D \2\:D) resistor r=81.461 c=0
Rl31 (\2\:D \3\:D) resistor r=37.2302 c=0
Rl2 (\2\:CK \3\:CK) resistor r=155.002 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.2328 c=0
Rl32 (\5\:E \6\:E) resistor r=56.461 c=0
Rl33 (\6\:E \7\:E) resistor r=62.2302 c=0
Rl26 (\3\:E \4\:E) resistor r=29.5379 c=0
Rl25 (\1\:E \2\:E) resistor r=60.3072 c=0
Rl18 (\9\:Ckb \10\:Ckb) resistor r=238.027 c=0
Rl19 (\10\:Ckb \11\:Ckb) resistor r=101.436 c=0
Rl8 (\5\:Ckb \6\:Ckb) resistor r=50.6918 c=0
Rl10 (\4\:Ckb \8\:Ckb) resistor r=57.1486 c=0
Rl7 (\2\:Ckb \5\:Ckb) resistor r=168.774 c=0
Rl4 (Ckb \2\:Ckb) resistor r=30.4507 c=0
Rl9 (\3\:Ckb \7\:Ckb) resistor r=193.39 c=0
Rl6 (\3\:Ckb \4\:Ckb) resistor r=14.7598 c=0
Rl5 (\2\:Ckb \3\:Ckb) resistor r=155.844 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=47.0254 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=64.6174 c=0
Rl3 (CKbb \2\:CKbb) resistor r=39.1533 c=0
Rl14 (n20 \2\:n20) resistor r=89.1533 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl12 (mout \2\:mout) resistor r=24.2328 c=0
Rl13 (\2\:mout \3\:mout) resistor r=91.5405 c=0
Rl23 (n30 \2\:n30) resistor r=85.7134 c=0
Rl24 (\2\:n30 \3\:n30) resistor r=26.098 c=0
Rl37 (\8\:qbint \9\:qbint) resistor r=29.5379 c=0
Rl22 (\2\:qbint \4\:qbint) resistor r=36.2526 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=99.7141 c=0
Rl20 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl34 (\5\:qbint \6\:qbint) resistor r=44.4949 c=0
Rl38 (\6\:qbint \10\:qbint) resistor r=47.7584 c=0
Rl39 (\7\:qbint \11\:qbint) resistor r=35.772 c=0
Rl36 (\7\:qbint \8\:qbint) resistor r=53.0797 c=0
Rl35 (\6\:qbint \7\:qbint) resistor r=77.7612 c=0
Rl27 (Eb \2\:Eb) resistor r=23.5324 c=0
Rl28 (\2\:Eb \3\:Eb) resistor r=149.587 c=0
Rl29 (\2\:Eb \4\:Eb) resistor r=33.1028 c=0
Rl40 (qint \2\:qint) resistor r=133.848 c=0
Rl41 (\2\:qint \3\:qint) resistor r=26.1559 c=0
Rz12 (\1\:QN \2\:QN) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz14 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz15 (\3\:VDD \18\:VDD) resistor r=6.25 c=0
Rz9 (\1\:Q \2\:Q) resistor r=75 c=0
Rz16 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz17 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\16\:Ckb \17\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz6 (\5\:Db \6\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz10 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\7\:Eb \8\:Eb) resistor r=75 c=0
Rz11 (\5\:qint \6\:qint) resistor r=75 c=0
Ry12 (\3\:QN \4\:QN) resistor r=62 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry14 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry15 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry9 (\3\:Q \4\:Q) resistor r=62 c=0
Ry19 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry20 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry21 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry1 (\14\:Ckb \15\:Ckb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry6 (Db \2\:Db) resistor r=62 c=0
Ry7 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry8 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry11 (\7\:qint \8\:qint) resistor r=62 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx13 (\4\:E \8\:E) resistor r=45 c=0
Rx14 (\2\:E \10\:E) resistor r=45 c=0
Rx15 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\4\:Ckb \12\:Ckb) resistor r=45 c=0
Rx4 (\11\:Ckb \18\:Ckb) resistor r=45 c=0
Rx5 (\6\:Ckb \19\:Ckb) resistor r=45 c=0
Rx7 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx17 (\9\:qbint \12\:qbint) resistor r=45 c=0
Rx18 (qbint \16\:qbint) resistor r=45 c=0
Rx16 (\4\:Eb \9\:Eb) resistor r=45 c=0
Rx19 (\2\:qint \4\:qint) resistor r=45 c=0
mn20 (\16\:Ckb \1\:CK \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn21 (\13\:CKbb \8\:Ckb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn25 (\5\:Db Ckb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn36 (\8\:n20 \3\:CKbb net411 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=4.422e-14 ps=6.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn35 (net411 \3\:mout \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=2.9e-14 ps=1.36e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn30 (\6\:mout \3\:n20 \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.97e-14 ad=5.22e-14 ps=1.36e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn40 (\6\:mout \5\:CKbb \4\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=5.22e-14 ps=9.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=2e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn51 (\4\:n30 \9\:Ckb net415 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.71e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn50 (net415 \3\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.605e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn45 (\13\:qbint \3\:n30 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.34e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn1 (\13\:qbint \3\:Eb \7\:Db VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.553e-14 ad=2.61e-14 ps=7.8e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.115e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\7\:Db \3\:E n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=3.553e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn2 (n0 \3\:D \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.888e-14 ad=3.77e-14 ps=1.49e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.2e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn0 (\7\:Eb \7\:E \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.888e-14 ad=2.9e-14 ps=1.49e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn55 (\1\:Q \8\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\5\:qint \10\:qbint \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn57 (\1\:QN \3\:qint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=2.755e-14 ps=6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.9e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
ends EDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:19 2013 )
// Library name: gsclib045_hvt
// Cell name: MDFFHQX1
// View name: extracted

simulator lang=spectre

subckt MDFFHQX1 CK D0 D1 Q S0 VDD VSS
mp55 (\1\:Q \4\:qbint \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.98462e-07 sd=160n sca=19.586 \
        scb=0.0215989 scc=0.000684683 m=(1)
mp11 (n11 \1\:D0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.12e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.43462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp12 (\7\:D0b \2\:S0 n11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=7.02e-14 ps=9.4e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.94551e-07 sb=8.18462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp14 (\7\:D0b S0b n13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.02e-14 ps=1.2e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19551e-07 sb=5.93462e-07 sd=160n sca=12.4887 \
        scb=0.0108489 scc=0.000412416 m=(1)
mp13 (n13 \3\:D1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=8.19e-14 ps=1.41e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.74551e-07 sb=3.38462e-07 sd=160n sca=13.4085 \
        scb=0.011387 scc=0.000412933 m=(1)
C1 (D0 VSS) capacitor c=4.3507e-17
C2 (Q VSS) capacitor c=1.52712e-17
C3 (S0 VSS) capacitor c=4.40103e-17
C4 (VDD VSS) capacitor c=2.89827e-16
C5 (CK VSS) capacitor c=1.09244e-16
C6 (D1 VSS) capacitor c=6.07727e-17
C7 (qbint VSS) capacitor c=1.79908e-17
C8 (CKb VSS) capacitor c=2.17351e-17
C9 (n30 VSS) capacitor c=3.43217e-17
C10 (n35 VSS) capacitor c=5.82309e-18
C11 (mout VSS) capacitor c=5.64258e-17
C12 (CKbb VSS) capacitor c=3.44304e-17
C13 (n20 VSS) capacitor c=3.73077e-17
C14 (n25 VSS) capacitor c=9.11373e-19
C15 (D0b VSS) capacitor c=9.0433e-17
C16 (n10 VSS) capacitor c=8.55872e-18
C17 (S0b VSS) capacitor c=3.83858e-17
C18 (n36 VSS) capacitor c=6.50403e-18
C19 (n26 VSS) capacitor c=5.33809e-18
C20 (n11 VSS) capacitor c=2.75167e-18
C21 (n13 VSS) capacitor c=6.08103e-18
C22 (\7\:S0 VSS) capacitor c=4.05118e-17
C23 (\3\:D1 VSS) capacitor c=4.86977e-17
C24 (\2\:S0 VSS) capacitor c=6.66823e-17
C25 (\1\:D0 VSS) capacitor c=9.03799e-17
C26 (\5\:CKb VSS) capacitor c=4.65943e-17
C27 (\7\:CKbb VSS) capacitor c=3.9191e-17
C28 (\8\:CKb VSS) capacitor c=4.26069e-17
C29 (\5\:qbint VSS) capacitor c=4.7028e-17
C30 (\3\:n30 VSS) capacitor c=4.04187e-17
C31 (\3\:CK VSS) capacitor c=4.81678e-17
C32 (\4\:qbint VSS) capacitor c=6.42521e-17
C33 (\5\:S0 VSS) capacitor c=2.54409e-17
C34 (\1\:D1 VSS) capacitor c=7.53961e-17
C35 (\3\:S0 VSS) capacitor c=7.0182e-17
C36 (\3\:S0b VSS) capacitor c=6.05378e-17
C37 (\4\:D0 VSS) capacitor c=3.88157e-17
C38 (\10\:CKb VSS) capacitor c=3.34568e-17
C39 (\11\:CKb VSS) capacitor c=2.51137e-17
C40 (\5\:CKbb VSS) capacitor c=5.91905e-17
C41 (\4\:mout VSS) capacitor c=6.61451e-17
C42 (\3\:n20 VSS) capacitor c=3.92417e-17
C43 (\3\:CKbb VSS) capacitor c=3.10207e-17
C44 (\3\:CKb VSS) capacitor c=6.78524e-17
C45 (\8\:qbint VSS) capacitor c=3.72698e-17
C46 (\1\:CK VSS) capacitor c=5.02182e-17
C47 (\3\:qbint VSS) capacitor c=3.01153e-17
C48 (\6\:S0 VSS) capacitor c=3.05036e-17
C49 (\2\:D1 VSS) capacitor c=4.74764e-17
C50 (\4\:S0 VSS) capacitor c=4.42107e-17
C51 (\2\:S0b VSS) capacitor c=5.49748e-17
C52 (\1\:S0 VSS) capacitor c=5.21226e-17
C53 (\3\:D0 VSS) capacitor c=2.67226e-17
C54 (\8\:CKbb VSS) capacitor c=4.13885e-17
C55 (\9\:CKb VSS) capacitor c=2.79099e-17
C56 (\6\:CKbb VSS) capacitor c=4.03023e-17
C57 (\3\:mout VSS) capacitor c=2.54298e-17
C58 (\2\:n20 VSS) capacitor c=4.334e-17
C59 (\4\:CKb VSS) capacitor c=1.61597e-17
C60 (\4\:CKbb VSS) capacitor c=4.17501e-17
C61 (\2\:CKbb VSS) capacitor c=4.14319e-17
C62 (\7\:qbint VSS) capacitor c=2.4774e-17
C63 (\2\:n30 VSS) capacitor c=4.25727e-17
C64 (\2\:CK VSS) capacitor c=4.60188e-17
C65 (\6\:S0b VSS) capacitor c=1.03387e-16
C66 (\5\:VDD VSS) capacitor c=3.14574e-17
C67 (\7\:D0b VSS) capacitor c=6.77514e-17
C68 (\7\:VDD VSS) capacitor c=5.22805e-17
C69 (\9\:CKbb VSS) capacitor c=1.02209e-16
C70 (\5\:D0b VSS) capacitor c=1.0499e-16
C71 (\4\:n20 VSS) capacitor c=3.43118e-17
C72 (\10\:VDD VSS) capacitor c=3.474e-17
C73 (\9\:mout VSS) capacitor c=7.42701e-17
C74 (\8\:n30 VSS) capacitor c=5.21829e-17
C75 (\14\:VDD VSS) capacitor c=4.18852e-17
C76 (\14\:qbint VSS) capacitor c=7.12629e-17
C77 (\18\:CKb VSS) capacitor c=2.53667e-17
C78 (\17\:VDD VSS) capacitor c=2.56049e-17
C79 (\1\:Q VSS) capacitor c=5.46859e-17
C80 (\1\:VDD VSS) capacitor c=8.09952e-17
C81 (\4\:S0b VSS) capacitor c=5.50045e-17
C82 (\15\:CKbb VSS) capacitor c=4.24774e-17
C83 (\9\:D0b VSS) capacitor c=6.88754e-17
C84 (\8\:n20 VSS) capacitor c=8.33314e-17
C85 (\7\:mout VSS) capacitor c=5.47566e-17
C86 (\4\:n30 VSS) capacitor c=7.27477e-17
C87 (\11\:qbint VSS) capacitor c=8.14101e-17
C88 (\15\:CKb VSS) capacitor c=9.31232e-17
C89 (\3\:Q VSS) capacitor c=5.61288e-17
C90 (\2\:qbint VSS) capacitor c=2.18605e-17
C91 (\6\:qbint VSS) capacitor c=2.38217e-17
C92 (\2\:CKb VSS) capacitor c=4.43845e-17
C93 (\2\:mout VSS) capacitor c=2.93226e-17
C94 (\6\:CKb VSS) capacitor c=5.8753e-17
C95 (\7\:CKb VSS) capacitor c=6.89886e-17
C96 (\2\:D0 VSS) capacitor c=2.85326e-17
C97 (\9\:qbint VSS) capacitor c=7.10184e-17
C98 (\10\:qbint VSS) capacitor c=6.63644e-17
C99 (\13\:qbint VSS) capacitor c=1.05921e-16
C100 (\6\:n30 VSS) capacitor c=1.03561e-16
C101 (\7\:n30 VSS) capacitor c=7.07379e-17
C102 (\5\:mout VSS) capacitor c=6.45752e-17
C103 (\6\:mout VSS) capacitor c=5.97447e-17
C104 (\12\:CKb VSS) capacitor c=5.74216e-17
C105 (\13\:CKb VSS) capacitor c=1.49149e-16
C106 (\14\:CKb VSS) capacitor c=1.66308e-16
C107 (\17\:CKb VSS) capacitor c=8.14976e-17
C108 (\6\:n20 VSS) capacitor c=7.96164e-17
C109 (\7\:n20 VSS) capacitor c=8.51778e-17
C110 (\11\:CKbb VSS) capacitor c=1.16902e-16
C111 (\12\:CKbb VSS) capacitor c=7.68595e-17
C112 (\13\:CKbb VSS) capacitor c=1.01213e-16
C113 (\14\:CKbb VSS) capacitor c=1.33197e-16
C114 (\17\:CKbb VSS) capacitor c=6.1439e-17
C115 (\18\:CKbb VSS) capacitor c=5.30683e-17
C116 (\5\:D0 VSS) capacitor c=6.15795e-17
C117 (\3\:D0b VSS) capacitor c=1.29956e-16
C118 (\4\:D1 VSS) capacitor c=7.60448e-17
C119 (\8\:S0 VSS) capacitor c=7.43302e-17
C120 (\9\:S0 VSS) capacitor c=7.40405e-17
C121 (\10\:S0 VSS) capacitor c=2.61063e-17
C122 (\8\:S0b VSS) capacitor c=9.68955e-17
C123 (\3\:VDD VSS) capacitor c=2.03154e-17
C124 (\9\:VDD VSS) capacitor c=4.8161e-17
C125 (\13\:VDD VSS) capacitor c=1.24761e-17
C126 (\16\:VDD VSS) capacitor c=2.07533e-17
Rk29 (\5\:D0 D0) resistor r=0.08856 c=0
Rk2 (\4\:Q Q) resistor r=0.02908 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.4952 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1954 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4568 c=0
Rk43 (\3\:VSS \6\:VSS) resistor r=0.2907 c=0
Rk44 (\4\:VSS \7\:VSS) resistor r=0.6041 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.5991 c=0
Rk47 (\9\:VSS VSS) resistor r=0.1375 c=0
Rk46 (\8\:VSS \9\:VSS) resistor r=0.4139 c=0
Rk48 (\4\:VSS \11\:VSS) resistor r=0.2657 c=0
Rk49 (\7\:VSS \13\:VSS) resistor r=0.1225 c=0
Rk50 (\8\:VSS \15\:VSS) resistor r=0.3173 c=0
Rk51 (\9\:VSS \17\:VSS) resistor r=0.2933 c=0
Rk37 (\9\:S0 S0) resistor r=0.3377 c=0
Rk36 (\8\:S0 \9\:S0) resistor r=0.3554 c=0
Rk38 (S0 \10\:S0) resistor r=0.02105 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.223 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.4292 c=0
Rk54 (\3\:VDD \6\:VDD) resistor r=0.2039 c=0
Rk55 (\4\:VDD \8\:VDD) resistor r=0.2986 c=0
Rk56 (\4\:VDD \9\:VDD) resistor r=0.6041 c=0
Rk57 (\9\:VDD \11\:VDD) resistor r=0.1859 c=0
Rk58 (\9\:VDD \12\:VDD) resistor r=0.5991 c=0
Rk59 (\12\:VDD \13\:VDD) resistor r=0.02989 c=0
Rk60 (\13\:VDD \15\:VDD) resistor r=0.236 c=0
Rk63 (\16\:VDD VDD) resistor r=0.1375 c=0
Rk61 (\13\:VDD \16\:VDD) resistor r=0.3832 c=0
Rk62 (\16\:VDD \18\:VDD) resistor r=0.1817 c=0
Rk35 (\4\:D1 D1) resistor r=0.03273 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.3153 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06062 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6904 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.3182 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2788 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9711 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4234 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.5459 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.1224 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.4975 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.3813 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1685 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3192 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.145 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3096 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.6368 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3322 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3239 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.5248 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.235 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2608 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.08271 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.4677 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.3854 c=0
Rk30 (\2\:D0b \3\:D0b) resistor r=0.6465 c=0
Rk31 (\3\:D0b \4\:D0b) resistor r=0.417 c=0
Rk32 (\4\:D0b \6\:D0b) resistor r=0.04616 c=0
Rk33 (\3\:D0b \8\:D0b) resistor r=0.2642 c=0
Rk34 (\4\:D0b \10\:D0b) resistor r=0.3646 c=0
Rk39 (\5\:S0b \7\:S0b) resistor r=0.5139 c=0
Rk40 (\7\:S0b \8\:S0b) resistor r=0.6394 c=0
Rl29 (\1\:D0 \2\:D0) resistor r=123.88 c=0
Rl31 (\2\:D0 \4\:D0) resistor r=54.6488 c=0
Rl30 (\2\:D0 \3\:D0) resistor r=6.9867 c=0
Rl39 (\6\:S0 \7\:S0) resistor r=126.099 c=0
Rl38 (\5\:S0 \6\:S0) resistor r=40.3846 c=0
Rl35 (\3\:S0 \4\:S0) resistor r=48.6653 c=0
Rl32 (\1\:S0 \2\:S0) resistor r=55.6561 c=0
Rl5 (\2\:CK \3\:CK) resistor r=96.3431 c=0
Rl4 (\1\:CK \2\:CK) resistor r=109.615 c=0
Rl37 (\2\:D1 \3\:D1) resistor r=64.5604 c=0
Rl36 (\1\:D1 \2\:D1) resistor r=100 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=120.868 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=42.0218 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=38.143 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=174.543 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=36.87 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=139.618 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=89.6181 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=32.3738 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=31.8681 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl18 (mout \2\:mout) resistor r=48.8796 c=0
Rl20 (\2\:mout \4\:mout) resistor r=75.8027 c=0
Rl19 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=24.2328 c=0
Rl11 (CKbb \2\:CKbb) resistor r=30.0021 c=0
Rl16 (n20 \2\:n20) resistor r=29.5379 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=79.5379 c=0
Rl33 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl34 (\2\:S0b \3\:S0b) resistor r=135.771 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \12\:VDD) resistor r=6.25 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (D0b \2\:D0b) resistor r=75 c=0
Rz9 (\9\:D0b \10\:D0b) resistor r=75 c=0
Rz10 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry14 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\5\:D0b \6\:D0b) resistor r=62 c=0
Ry9 (\7\:D0b \8\:D0b) resistor r=20.6667 c=0
Ry10 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx15 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\2\:CK CK) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn11 (n10 \4\:D0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=7.93e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=9.99808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.03365e-07 sb=6.49808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.08365e-07 sb=4.44808e-07 sd=160n sca=9.89531 scb=0.00874901 \
        scc=0.000299334 m=(1)
mn13 (n12 \1\:D1 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=1.56e-14 ps=1.15e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13365e-07 sb=3.39808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn20 (\15\:CKb \1\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.972e-14 ps=9.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09879e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\4\:S0b \5\:S0 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=2.465e-14 ps=1.15e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18638e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn45 (\11\:qbint n30 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(1)
mn50 (n35 \8\:qbint \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.383e-14 ad=4.408e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.945e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (\4\:n30 \3\:CKb n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.535e-14 ps=8.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.685e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.535e-14 ad=7.585e-14 ps=9.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.37e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (\7\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=7.585e-14 ps=1.27e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=9.55e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (n25 \4\:mout \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=6.9e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.613e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=5.85e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (\9\:D0b \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=6.458e-14 ps=8.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=3.15e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mp20 (\18\:CKb \3\:CK \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.483e-14 ps=1.1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=12.8361 \
        scb=0.0101573 scc=0.000104788 m=(1)
mp21 (\9\:CKbb \5\:CKb \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34e-06 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp10 (\6\:S0b \7\:S0 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=1.4e-07 sd=160n sca=21.6088 \
        scb=0.0245661 scc=0.00103605 m=(1)
mp45 (\14\:qbint \3\:n30 \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.56e-14 ad=4.315e-14 ps=1.35e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39194e-07 sb=2e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp50 (n36 \5\:qbint \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.56e-14 ad=5.27e-14 ps=1.35e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04194e-07 sb=1.915e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\8\:n30 CKbb n36 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.145e-14 ps=9.6e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19194e-07 sb=1.7e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.209e-13 ad=9.145e-14 ps=1.4e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59194e-07 sb=1.36e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp30 (\9\:mout n20 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=1.209e-13 ps=1.5e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39419e-06 sb=9.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (n26 mout \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=4.805e-14 ps=1.5e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65919e-06 sb=6.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85919e-06 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:D0b VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=26.7199 scb=0.0211429 \
        scc=0.00304348 m=(1)
ends MDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:20 2013 )
// Library name: gsclib045_hvt
// Cell name: MDFFHQX2
// View name: extracted

simulator lang=spectre

subckt MDFFHQX2 CK D0 D1 Q S0 VDD VSS
mp11 (n11 \1\:D0 \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.85833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (\6\:D0b \1\:S0 n11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.59551e-07 sb=7.95833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp14 (\6\:D0b S0b n13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.84551e-07 sb=5.70833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (n13 \3\:D1 \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=5.265e-14 ps=1.6e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.64551e-07 sb=3.90833e-07 sd=160n sca=16.239 \
        scb=0.0143727 scc=0.00110279 m=(1)
mp55 (\1\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=30.9465 \
        scb=0.0329575 scc=0.002778 m=(2)
C1 (D0 VSS) capacitor c=5.86585e-17
C2 (Q VSS) capacitor c=3.45083e-17
C3 (VDD VSS) capacitor c=3.42065e-16
C4 (CK VSS) capacitor c=5.83872e-17
C5 (D1 VSS) capacitor c=1.10775e-16
C6 (qbint VSS) capacitor c=1.42921e-16
C7 (CKb VSS) capacitor c=1.68871e-17
C8 (n30 VSS) capacitor c=3.72615e-17
C9 (mout VSS) capacitor c=6.00805e-17
C10 (CKbb VSS) capacitor c=3.53933e-17
C11 (n20 VSS) capacitor c=3.96373e-17
C12 (n25 VSS) capacitor c=1.65965e-18
C13 (D0b VSS) capacitor c=1.07303e-16
C14 (n10 VSS) capacitor c=1.17545e-17
C15 (S0b VSS) capacitor c=4.5651e-17
C16 (n12 VSS) capacitor c=1.47994e-18
C17 (n36 VSS) capacitor c=9.04161e-18
C18 (n26 VSS) capacitor c=6.19945e-18
C19 (n11 VSS) capacitor c=5.59536e-18
C20 (n13 VSS) capacitor c=3.91527e-18
C21 (\7\:S0 VSS) capacitor c=3.10912e-17
C22 (\3\:D1 VSS) capacitor c=5.11695e-17
C23 (\1\:S0 VSS) capacitor c=4.97908e-17
C24 (\1\:D0 VSS) capacitor c=6.54026e-17
C25 (\10\:CKb VSS) capacitor c=5.3274e-17
C26 (\7\:CKbb VSS) capacitor c=3.94237e-17
C27 (\8\:CKb VSS) capacitor c=4.39846e-17
C28 (\4\:CKb VSS) capacitor c=2.1519e-17
C29 (\8\:qbint VSS) capacitor c=4.78273e-17
C30 (\3\:n30 VSS) capacitor c=4.30002e-17
C31 (\3\:CK VSS) capacitor c=3.95459e-17
C32 (\5\:S0 VSS) capacitor c=2.96943e-17
C33 (\1\:D1 VSS) capacitor c=7.46974e-17
C34 (\3\:S0 VSS) capacitor c=6.63223e-17
C35 (\3\:S0b VSS) capacitor c=5.95274e-17
C36 (\4\:D0 VSS) capacitor c=4.3845e-17
C37 (\5\:CKb VSS) capacitor c=3.20886e-17
C38 (\11\:CKb VSS) capacitor c=2.44232e-17
C39 (\5\:CKbb VSS) capacitor c=5.21993e-17
C40 (\4\:mout VSS) capacitor c=5.50107e-17
C41 (\3\:n20 VSS) capacitor c=4.36534e-17
C42 (\3\:CKbb VSS) capacitor c=3.00472e-17
C43 (\3\:CKb VSS) capacitor c=6.77966e-17
C44 (\11\:qbint VSS) capacitor c=3.57889e-17
C45 (\1\:CK VSS) capacitor c=4.22686e-17
C46 (\6\:S0 VSS) capacitor c=2.65133e-17
C47 (\2\:D1 VSS) capacitor c=5.05078e-17
C48 (\4\:S0 VSS) capacitor c=4.74044e-17
C49 (\2\:S0b VSS) capacitor c=6.68526e-17
C50 (\2\:S0 VSS) capacitor c=3.84466e-17
C51 (\3\:D0 VSS) capacitor c=2.76836e-17
C52 (\8\:CKbb VSS) capacitor c=3.96293e-17
C53 (\9\:CKb VSS) capacitor c=2.41808e-17
C54 (\6\:CKbb VSS) capacitor c=4.74902e-17
C55 (\3\:mout VSS) capacitor c=1.84103e-17
C56 (\2\:n20 VSS) capacitor c=3.54151e-17
C57 (\4\:CKbb VSS) capacitor c=3.88909e-17
C58 (\2\:CKbb VSS) capacitor c=4.35208e-17
C59 (\10\:qbint VSS) capacitor c=2.49612e-17
C60 (\2\:n30 VSS) capacitor c=4.31174e-17
C61 (\2\:CK VSS) capacitor c=3.65523e-17
C62 (\6\:qbint VSS) capacitor c=2.596e-17
C63 (\5\:S0b VSS) capacitor c=1.06163e-16
C64 (\12\:VDD VSS) capacitor c=3.83257e-17
C65 (\6\:D0b VSS) capacitor c=6.55996e-17
C66 (\14\:VDD VSS) capacitor c=5.47512e-17
C67 (\9\:CKbb VSS) capacitor c=7.45193e-17
C68 (\4\:D0b VSS) capacitor c=9.126e-17
C69 (\4\:n20 VSS) capacitor c=6.12637e-17
C70 (\16\:VDD VSS) capacitor c=3.5225e-17
C71 (\9\:mout VSS) capacitor c=6.27091e-17
C72 (\6\:n30 VSS) capacitor c=5.93577e-17
C73 (\18\:VDD VSS) capacitor c=2.86758e-17
C74 (\14\:qbint VSS) capacitor c=7.53905e-17
C75 (\15\:CKb VSS) capacitor c=3.65219e-17
C76 (\1\:Q VSS) capacitor c=8.10944e-17
C77 (\1\:VDD VSS) capacitor c=5.8476e-17
C78 (\7\:S0b VSS) capacitor c=6.85301e-17
C79 (\15\:CKbb VSS) capacitor c=5.92557e-17
C80 (\8\:D0b VSS) capacitor c=7.20809e-17
C81 (\8\:n20 VSS) capacitor c=6.67022e-17
C82 (\7\:mout VSS) capacitor c=5.95759e-17
C83 (\8\:n30 VSS) capacitor c=8.96019e-17
C84 (\16\:qbint VSS) capacitor c=7.57164e-17
C85 (\18\:CKb VSS) capacitor c=8.95627e-17
C86 (\3\:Q VSS) capacitor c=1.51928e-17
C87 (\9\:qbint VSS) capacitor c=2.44775e-17
C88 (\2\:CKb VSS) capacitor c=4.32357e-17
C89 (\2\:mout VSS) capacitor c=3.34305e-17
C90 (\6\:CKb VSS) capacitor c=7.6933e-17
C91 (\7\:CKb VSS) capacitor c=7.02433e-17
C92 (\2\:D0 VSS) capacitor c=2.48941e-17
C93 (\4\:CK VSS) capacitor c=7.23277e-17
C94 (\12\:qbint VSS) capacitor c=6.72714e-17
C95 (\13\:qbint VSS) capacitor c=6.08996e-17
C96 (\18\:qbint VSS) capacitor c=9.49802e-17
C97 (\4\:n30 VSS) capacitor c=7.30267e-17
C98 (\5\:n30 VSS) capacitor c=9.11922e-17
C99 (\5\:mout VSS) capacitor c=5.12745e-17
C100 (\6\:mout VSS) capacitor c=4.82322e-17
C101 (\12\:CKb VSS) capacitor c=5.42788e-17
C102 (\13\:CKb VSS) capacitor c=1.43598e-16
C103 (\14\:CKb VSS) capacitor c=1.4286e-16
C104 (\17\:CKb VSS) capacitor c=8.12018e-17
C105 (\6\:n20 VSS) capacitor c=7.25667e-17
C106 (\7\:n20 VSS) capacitor c=6.22133e-17
C107 (\11\:CKbb VSS) capacitor c=1.29025e-16
C108 (\12\:CKbb VSS) capacitor c=7.63497e-17
C109 (\13\:CKbb VSS) capacitor c=1.28425e-16
C110 (\14\:CKbb VSS) capacitor c=1.33018e-16
C111 (\17\:CKbb VSS) capacitor c=4.68267e-17
C112 (\18\:CKbb VSS) capacitor c=6.0968e-17
C113 (\5\:D0 VSS) capacitor c=5.41637e-17
C114 (\3\:D0b VSS) capacitor c=1.48383e-16
C115 (\8\:S0 VSS) capacitor c=1.4458e-17
C116 (\9\:S0 VSS) capacitor c=1.21238e-16
C117 (\10\:S0 VSS) capacitor c=5.649e-17
C118 (\11\:S0 VSS) capacitor c=9.79259e-17
C119 (\4\:S0b VSS) capacitor c=9.18656e-17
C120 (\3\:VDD VSS) capacitor c=1.56441e-17
C121 (\4\:VDD VSS) capacitor c=1.66881e-17
C122 (\6\:VDD VSS) capacitor c=3.79881e-17
C123 (\7\:VDD VSS) capacitor c=2.10421e-17
Rk29 (\5\:D0 D0) resistor r=0.1122 c=0
Rk1 (\2\:Q Q) resistor r=0.2051 c=0
Rk2 (Q \4\:Q) resistor r=0.166 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1677 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4307 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.1527 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.4485 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.6563 c=0
Rk47 (\8\:VSS VSS) resistor r=0.3332 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.09756 c=0
Rk50 (\3\:VSS \13\:VSS) resistor r=0.2067 c=0
Rk51 (\4\:VSS \15\:VSS) resistor r=0.2111 c=0
Rk52 (\6\:VSS \17\:VSS) resistor r=0.1222 c=0
Rk53 (\7\:VSS \19\:VSS) resistor r=0.237 c=0
Rk35 (\8\:S0 \9\:S0) resistor r=0.04037 c=0
Rk36 (\9\:S0 \10\:S0) resistor r=0.4299 c=0
Rk38 (\11\:S0 S0) resistor r=0.004282 c=0
Rk37 (\9\:S0 \11\:S0) resistor r=0.6809 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.1978 c=0
Rk56 (\3\:VDD \4\:VDD) resistor r=0.4007 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.1527 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.4786 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.6388 c=0
Rk61 (\8\:VDD VDD) resistor r=0.3332 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.08503 c=0
Rk64 (\3\:VDD \13\:VDD) resistor r=0.2466 c=0
Rk65 (\4\:VDD \15\:VDD) resistor r=0.3102 c=0
Rk66 (\6\:VDD \17\:VDD) resistor r=0.242 c=0
Rk67 (\7\:VDD \19\:VDD) resistor r=0.2266 c=0
Rk3 (\4\:CK CK) resistor r=0.1297 c=0
Rk34 (\4\:D1 D1) resistor r=0.003482 c=0
Rk4 (\12\:qbint \13\:qbint) resistor r=0.3074 c=0
Rk5 (\13\:qbint \15\:qbint) resistor r=0.3138 c=0
Rk6 (\13\:qbint \17\:qbint) resistor r=0.05799 c=0
Rk7 (\17\:qbint \18\:qbint) resistor r=0.7082 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2506 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9254 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.1459 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.6495 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.4111 c=0
Rk8 (\4\:n30 \5\:n30) resistor r=0.3724 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.1741 c=0
Rk10 (\5\:n30 \9\:n30) resistor r=0.5381 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.241 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1153 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2348 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.5667 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3076 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3291 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.858 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2539 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1934 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3963 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2531 c=0
Rk30 (\2\:D0b \3\:D0b) resistor r=0.6822 c=0
Rk31 (\3\:D0b \5\:D0b) resistor r=0.3925 c=0
Rk32 (\3\:D0b \7\:D0b) resistor r=0.3379 c=0
Rk33 (\5\:D0b \9\:D0b) resistor r=0.3871 c=0
Rk39 (\4\:S0b \6\:S0b) resistor r=0.649 c=0
Rk40 (\6\:S0b \8\:S0b) resistor r=0.5281 c=0
Rl32 (\1\:D0 \2\:D0) resistor r=101.637 c=0
Rl34 (\2\:D0 \4\:D0) resistor r=59.3295 c=0
Rl33 (\2\:D0 \3\:D0) resistor r=8.3038 c=0
Rl42 (\6\:S0 \7\:S0) resistor r=39.5604 c=0
Rl41 (\5\:S0 \6\:S0) resistor r=105.769 c=0
Rl38 (\3\:S0 \4\:S0) resistor r=29.4849 c=0
Rl35 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl8 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl7 (\1\:CK \2\:CK) resistor r=96.1338 c=0
Rl40 (\2\:D1 \3\:D1) resistor r=48.0541 c=0
Rl39 (\1\:D1 \2\:D1) resistor r=99.7951 c=0
Rl5 (qbint \6\:qbint) resistor r=9.5287 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=49.7141 c=0
Rl13 (\9\:qbint \11\:qbint) resistor r=84.3295 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl18 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl17 (\2\:CKb \3\:CKb) resistor r=178.39 c=0
Rl16 (CKb \2\:CKb) resistor r=37.675 c=0
Rl30 (\6\:CKb \10\:CKb) resistor r=199.259 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=76.0085 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=143.774 c=0
Rl31 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=198.915 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=33.7912 c=0
Rl9 (n30 \2\:n30) resistor r=84.6154 c=0
Rl21 (mout \2\:mout) resistor r=99.7141 c=0
Rl23 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl22 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=39.6174 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=33.8482 c=0
Rl14 (CKbb \2\:CKbb) resistor r=37.6944 c=0
Rl19 (n20 \2\:n20) resistor r=29.5379 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=87.2302 c=0
Rl36 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl37 (\2\:S0b \3\:S0b) resistor r=131.73 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz17 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz18 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (D0b \2\:D0b) resistor r=75 c=0
Rz9 (\8\:D0b \9\:D0b) resistor r=75 c=0
Rz10 (\7\:S0b \8\:S0b) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=31 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry2 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\6\:n30 \7\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry9 (\6\:D0b \7\:D0b) resistor r=20.6667 c=0
Ry10 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx15 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\18\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \4\:S0b) resistor r=45 c=0
mn11 (n10 \4\:D0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=7.67e-14 ps=8.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.07942e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=7.39423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.69e-14 \
        ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.81635e-07 sb=5.34423e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn13 (n12 \1\:D1 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=1.69e-14 ps=1.33e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91635e-07 sb=4.24423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn55_1__rcx (\3\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.73654e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\18\:CKb \1\:CK VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.567e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \5\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10552e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn10 (\7\:S0b \5\:S0 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=2.9e-14 ps=1.33e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25569e-06 sb=2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn45 (\16\:qbint n30 \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn50 (n35 \11\:qbint \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=5.432e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\8\:n30 \3\:CKb n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=4.51e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.725e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=8.61e-14 ps=8.5e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.46e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=8.61e-14 ps=1.18e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.95e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (n25 \4\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=1.435e-14 ps=1.18e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=7.3e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=6.15e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn25 (\8\:D0b \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mp20 (\15\:CKb \3\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.3324 \
        scb=0.00994664 scc=0.000204208 m=(1)
mp21 (\9\:CKbb \10\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05465e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp10 (\5\:S0b \7\:S0 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23372e-06 sb=1.4e-07 sd=160n sca=25.6683 \
        scb=0.0269847 scc=0.00206824 m=(1)
mp45 (\14\:qbint \3\:n30 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.1e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp50 (n36 \8\:qbint \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.1e-14 ad=5.27e-14 ps=1.44e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.92871e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\6\:n30 CKbb n36 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.765e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.71597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\6\:n30 \4\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.302e-13 ad=9.765e-14 ps=1.46e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.35597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout n20 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.302e-13 ps=1.38e-06 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=8.90968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (n26 mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.045e-14 ps=1.38e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=6.25968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.58e-14 ps=1.01e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=3.85968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:D0b VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.60968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends MDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:21 2013 )
// Library name: gsclib045_hvt
// Cell name: MDFFHQX4
// View name: extracted

simulator lang=spectre

subckt MDFFHQX4 CK D0 D1 Q S0 VDD VSS
mp20 (\14\:CKb \4\:CK \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.8563 scb=0.0365862 \
        scc=0.0028968 m=(1)
mp21 (\9\:CKbb \5\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.17093e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp10 (\7\:S0b \5\:S0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=3.01e-14 ps=1.25e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45581e-07 sb=1.4e-07 sd=160n sca=26.9589 \
        scb=0.0303196 scc=0.00206685 m=(1)
C1 (D0 VSS) capacitor c=5.3443e-17
C2 (Q VSS) capacitor c=1.91576e-16
C3 (S0 VSS) capacitor c=6.29762e-17
C4 (VDD VSS) capacitor c=3.39466e-16
C5 (CK VSS) capacitor c=6.75849e-17
C6 (D1 VSS) capacitor c=1.01565e-16
C7 (CKb VSS) capacitor c=2.27527e-17
C8 (qbint VSS) capacitor c=3.10951e-16
C9 (n30 VSS) capacitor c=1.86821e-16
C10 (n35 VSS) capacitor c=5.33374e-18
C11 (mout VSS) capacitor c=6.83587e-17
C12 (CKbb VSS) capacitor c=4.81422e-17
C13 (n20 VSS) capacitor c=3.7159e-17
C14 (n25 VSS) capacitor c=1.08109e-18
C15 (D0b VSS) capacitor c=9.00921e-17
C16 (n10 VSS) capacitor c=6.92234e-18
C17 (S0b VSS) capacitor c=4.35599e-17
C18 (n36 VSS) capacitor c=5.48591e-18
C19 (n26 VSS) capacitor c=2.64832e-18
C20 (n11 VSS) capacitor c=1.91748e-18
C21 (n13 VSS) capacitor c=4.24869e-18
C22 (\5\:S0 VSS) capacitor c=4.43532e-17
C23 (\3\:D1 VSS) capacitor c=5.41372e-17
C24 (\2\:S0 VSS) capacitor c=7.26427e-17
C25 (\1\:D0 VSS) capacitor c=8.8584e-17
C26 (\5\:CKb VSS) capacitor c=6.58779e-17
C27 (\7\:CKbb VSS) capacitor c=3.97048e-17
C28 (\8\:CKb VSS) capacitor c=5.8083e-17
C29 (\4\:CKb VSS) capacitor c=2.72877e-17
C30 (\15\:qbint VSS) capacitor c=6.36695e-17
C31 (\4\:CK VSS) capacitor c=4.06127e-17
C32 (\7\:S0 VSS) capacitor c=3.39365e-17
C33 (\1\:D1 VSS) capacitor c=8.53288e-17
C34 (\3\:S0 VSS) capacitor c=7.08876e-17
C35 (\3\:S0b VSS) capacitor c=6.01583e-17
C36 (\4\:D0 VSS) capacitor c=4.22705e-17
C37 (\10\:CKb VSS) capacitor c=2.56451e-17
C38 (\11\:CKb VSS) capacitor c=2.53675e-17
C39 (\5\:CKbb VSS) capacitor c=4.39748e-17
C40 (\4\:mout VSS) capacitor c=4.38937e-17
C41 (\3\:n20 VSS) capacitor c=4.3638e-17
C42 (\3\:CKbb VSS) capacitor c=3.08907e-17
C43 (\3\:CKb VSS) capacitor c=5.19528e-17
C44 (\18\:qbint VSS) capacitor c=3.00496e-17
C45 (\3\:CK VSS) capacitor c=3.05327e-17
C46 (\6\:S0 VSS) capacitor c=3.5913e-17
C47 (\2\:D1 VSS) capacitor c=5.79505e-17
C48 (\4\:S0 VSS) capacitor c=4.32969e-17
C49 (\1\:S0 VSS) capacitor c=4.86954e-17
C50 (\3\:D0 VSS) capacitor c=3.15008e-17
C51 (\8\:CKbb VSS) capacitor c=3.79741e-17
C52 (\9\:CKb VSS) capacitor c=2.9056e-17
C53 (\6\:CKbb VSS) capacitor c=3.88791e-17
C54 (\3\:mout VSS) capacitor c=1.73077e-17
C55 (\2\:n20 VSS) capacitor c=3.88755e-17
C56 (\4\:CKbb VSS) capacitor c=3.63133e-17
C57 (\2\:CKbb VSS) capacitor c=4.58211e-17
C58 (\17\:qbint VSS) capacitor c=3.05735e-17
C59 (\1\:CK VSS) capacitor c=2.62933e-17
C60 (\7\:S0b VSS) capacitor c=9.29662e-17
C61 (\9\:VDD VSS) capacitor c=3.23234e-17
C62 (\4\:D0b VSS) capacitor c=6.77058e-17
C63 (\11\:VDD VSS) capacitor c=3.39707e-17
C64 (\9\:CKbb VSS) capacitor c=8.41382e-17
C65 (\6\:D0b VSS) capacitor c=1.25765e-16
C66 (\4\:n20 VSS) capacitor c=5.86714e-17
C67 (\13\:VDD VSS) capacitor c=3.29528e-17
C68 (\9\:mout VSS) capacitor c=6.30858e-17
C69 (\11\:n30 VSS) capacitor c=5.64274e-17
C70 (\19\:qbint VSS) capacitor c=4.8367e-17
C71 (\14\:CKb VSS) capacitor c=2.25241e-16
C72 (\1\:VDD VSS) capacitor c=6.10822e-17
C73 (\5\:S0b VSS) capacitor c=4.88885e-17
C74 (\15\:CKbb VSS) capacitor c=5.66474e-17
C75 (\8\:D0b VSS) capacitor c=7.35497e-17
C76 (\8\:n20 VSS) capacitor c=6.65326e-17
C77 (\7\:mout VSS) capacitor c=4.87515e-17
C78 (\7\:n30 VSS) capacitor c=6.00782e-17
C79 (\24\:qbint VSS) capacitor c=2.42858e-17
C80 (\16\:CKb VSS) capacitor c=4.30079e-17
C81 (\2\:CK VSS) capacitor c=1.81098e-17
C82 (\16\:qbint VSS) capacitor c=2.51358e-17
C83 (\2\:CKb VSS) capacitor c=5.62676e-17
C84 (\2\:mout VSS) capacitor c=3.66725e-17
C85 (\6\:CKb VSS) capacitor c=5.31334e-17
C86 (\7\:CKb VSS) capacitor c=5.46864e-17
C87 (\2\:D0 VSS) capacitor c=3.59182e-17
C88 (\2\:S0b VSS) capacitor c=5.67207e-17
C89 (\5\:CK VSS) capacitor c=5.76949e-17
C90 (\21\:qbint VSS) capacitor c=2.32092e-17
C91 (\22\:qbint VSS) capacitor c=4.10132e-17
C92 (\23\:qbint VSS) capacitor c=1.44032e-17
C93 (\26\:qbint VSS) capacitor c=4.78203e-17
C94 (\9\:n30 VSS) capacitor c=8.16954e-17
C95 (\10\:n30 VSS) capacitor c=4.94205e-17
C96 (\5\:mout VSS) capacitor c=4.98683e-17
C97 (\6\:mout VSS) capacitor c=5.60969e-17
C98 (\12\:CKb VSS) capacitor c=5.1513e-17
C99 (\13\:CKb VSS) capacitor c=2.35216e-16
C100 (\18\:CKb VSS) capacitor c=7.77548e-17
C101 (\6\:n20 VSS) capacitor c=6.58656e-17
C102 (\7\:n20 VSS) capacitor c=6.57828e-17
C103 (\11\:CKbb VSS) capacitor c=1.41509e-16
C104 (\12\:CKbb VSS) capacitor c=7.74418e-17
C105 (\13\:CKbb VSS) capacitor c=1.0955e-16
C106 (\14\:CKbb VSS) capacitor c=1.0236e-16
C107 (\17\:CKbb VSS) capacitor c=5.45041e-17
C108 (\18\:CKbb VSS) capacitor c=6.09077e-17
C109 (\5\:D0 VSS) capacitor c=5.98806e-17
C110 (\3\:D0b VSS) capacitor c=1.2469e-16
C111 (\8\:S0 VSS) capacitor c=7.33504e-17
C112 (\9\:S0 VSS) capacitor c=5.97364e-17
C113 (\9\:S0b VSS) capacitor c=8.48647e-17
C114 (\3\:VDD VSS) capacitor c=1.30053e-17
C115 (\4\:VDD VSS) capacitor c=2.68924e-17
C116 (\6\:VDD VSS) capacitor c=4.07048e-17
C117 (\7\:VDD VSS) capacitor c=1.80594e-16
Rk31 (\5\:D0 D0) resistor r=0.1545 c=0
Rk38 (\8\:S0 \9\:S0) resistor r=0.3401 c=0
Rk40 (\10\:S0 S0) resistor r=0.003095 c=0
Rk39 (\9\:S0 \10\:S0) resistor r=0.2335 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.07749 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.363 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.3106 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.3607 c=0
Rk75 (\7\:VDD VDD) resistor r=0.0998 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.6011 c=0
Rk66 (\3\:VDD \10\:VDD) resistor r=0.2396 c=0
Rk67 (\4\:VDD \12\:VDD) resistor r=0.2396 c=0
Rk68 (\6\:VDD \14\:VDD) resistor r=0.1619 c=0
Rk1 (CK \5\:CK) resistor r=0.1707 c=0
Rk37 (\4\:D1 D1) resistor r=0.007054 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.0399 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.4357 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.2755 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.3306 c=0
Rk52 (\7\:VSS VSS) resistor r=0.1249 c=0
Rk47 (\6\:VSS \7\:VSS) resistor r=0.6312 c=0
Rk53 (\3\:VSS \13\:VSS) resistor r=0.2894 c=0
Rk54 (\4\:VSS \15\:VSS) resistor r=0.316 c=0
Rk55 (\6\:VSS \17\:VSS) resistor r=0.1253 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2989 c=0
Rk18 (\13\:CKb \15\:CKb) resistor r=1.7741 c=0
Rk19 (\15\:CKb \17\:CKb) resistor r=0.392 c=0
Rk20 (\13\:CKb \18\:CKb) resistor r=0.5387 c=0
Rk6 (\20\:qbint \21\:qbint) resistor r=0.3027 c=0
Rk7 (\21\:qbint \22\:qbint) resistor r=0.2096 c=0
Rk8 (\21\:qbint \23\:qbint) resistor r=0.07797 c=0
Rk9 (\23\:qbint \25\:qbint) resistor r=0.07084 c=0
Rk10 (\23\:qbint \26\:qbint) resistor r=0.1852 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.4493 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.2117 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.3038 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.2333 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.1994 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.2599 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.6608 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.3715 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.2829 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.8171 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.3533 c=0
Rk29 (\13\:CKbb \17\:CKbb) resistor r=0.2213 c=0
Rk30 (\14\:CKbb \18\:CKbb) resistor r=0.2549 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.171 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3369 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.286 c=0
Rk32 (\2\:D0b \3\:D0b) resistor r=0.6162 c=0
Rk33 (\3\:D0b \5\:D0b) resistor r=0.1478 c=0
Rk34 (\3\:D0b \7\:D0b) resistor r=0.5202 c=0
Rk35 (\7\:D0b \9\:D0b) resistor r=0.3715 c=0
Rk36 (\5\:D0b \10\:D0b) resistor r=0.1569 c=0
Rk41 (\6\:S0b \8\:S0b) resistor r=0.4631 c=0
Rk42 (\8\:S0b \9\:S0b) resistor r=0.533 c=0
Rl43 (\1\:D0 \2\:D0) resistor r=50.8027 c=0
Rl45 (\2\:D0 \4\:D0) resistor r=98.8796 c=0
Rl44 (\2\:D0 \3\:D0) resistor r=12.2499 c=0
Rl53 (\5\:S0 \6\:S0) resistor r=104.538 c=0
Rl54 (\6\:S0 \7\:S0) resistor r=39.1533 c=0
Rl50 (\3\:S0 \4\:S0) resistor r=28.079 c=0
Rl46 (\1\:S0 \2\:S0) resistor r=37.7189 c=0
Rl3 (\2\:CK \4\:CK) resistor r=82.4064 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.3295 c=0
Rl1 (\1\:CK \2\:CK) resistor r=3.5213 c=0
Rl52 (\2\:D1 \3\:D1) resistor r=43.6813 c=0
Rl51 (\1\:D1 \2\:D1) resistor r=92.3077 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl29 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl28 (\2\:CKb \3\:CKb) resistor r=145.697 c=0
Rl27 (CKb \2\:CKb) resistor r=84.5407 c=0
Rl37 (\5\:CKb \6\:CKb) resistor r=185.338 c=0
Rl41 (\6\:CKb \10\:CKb) resistor r=47.3105 c=0
Rl39 (\7\:CKb \8\:CKb) resistor r=170.697 c=0
Rl42 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl38 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl22 (\16\:qbint \15\:qbint) resistor r=103.56 c=0
Rl24 (\16\:qbint \18\:qbint) resistor r=34.3295 c=0
Rl23 (\16\:qbint \17\:qbint) resistor r=11.4953 c=0
Rl32 (mout \2\:mout) resistor r=98.8796 c=0
Rl34 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl33 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl36 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl35 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl26 (\3\:CKbb \4\:CKbb) resistor r=33.3841 c=0
Rl25 (CKbb \2\:CKbb) resistor r=41.0764 c=0
Rl30 (n20 \2\:n20) resistor r=26.098 c=0
Rl31 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl47 (S0b \2\:S0b) resistor r=67.4757 c=0
Rl48 (\2\:S0b \3\:S0b) resistor r=147.664 c=0
Rl49 (\2\:S0b \4\:S0b) resistor r=1.2666 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz20 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz6 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz3 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (D0b \2\:D0b) resistor r=75 c=0
Rz10 (\8\:D0b \9\:D0b) resistor r=75 c=0
Rz11 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry16 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry14 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry6 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\20\:qbint \19\:qbint) resistor r=62 c=0
Ry4 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry10 (\6\:D0b \7\:D0b) resistor r=62 c=0
Ry11 (\4\:D0b \10\:D0b) resistor r=62 c=0
Ry12 (\7\:S0b \8\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx15 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \18\:CKb) resistor r=45 c=0
Rx2 (\22\:qbint qbint) resistor r=45 c=0
Rx3 (\26\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:S0b \9\:S0b) resistor r=45 c=0
mn20 (\16\:CKb \3\:CK \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\5\:S0b \7\:S0 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.045e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16069e-06 sb=2.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n10 \4\:D0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=9.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75673e-07 sb=8.70673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.60673e-07 sb=5.85673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.65673e-07 sb=3.80673e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn13 (n12 \1\:D1 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70673e-07 sb=2.75673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.42e-14 ps=9.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=1.74721e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn50 (n35 \18\:qbint \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=3.28e-14 ps=8.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63317e-06 sb=1.94e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\7\:n30 \3\:CKb n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.92e-14 ps=7.3e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83817e-06 sb=1.735e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:mout \3\:CKbb \7\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=8.2e-14 ps=8.9e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.45e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=8.2e-14 ps=1.32e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (n25 \4\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.358e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.4e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=4.51e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.8e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:D0b \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=6.458e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn45_1__rcx (\24\:qbint n30 \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.273e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16317e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mp11 (n11 \1\:D0 \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.14359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp12 (\4\:D0b \2\:S0 n11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.09359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp14 (\4\:D0b S0b n13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.84359e-07 sd=160n sca=15.6414 \
        scb=0.0138242 scc=0.000948215 m=(1)
mp13 (n13 \3\:D1 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=5.655e-14 ps=1.25e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55064e-07 sb=2.94359e-07 sd=160n sca=16.7327 \
        scb=0.0148635 scc=0.000950884 m=(1)
mp55_1__rcx (Q qbint \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=6.24e-14 ps=1.605e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.40577e-07 sb=1.76308e-06 sd=160n sca=18.6093 \
        scb=0.0174808 scc=0.00104939 m=(4)
mp50 (n36 \15\:qbint \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.76e-14 ad=3.875e-14 ps=1.55e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68685e-06 sb=1.78685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\11\:n30 CKbb n36 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85685e-06 sb=1.61685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\11\:n30 \4\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.5965e-13 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.41185e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\9\:mout n20 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=1.5965e-13 ps=1.45e-06 pd=1.65e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.51855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (n26 mout \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.86855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=5.58e-14 ps=9.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.96855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:D0b VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.328e-14 ad=5.58e-14 ps=1.15e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.71855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp45 (\19\:qbint n30 \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.96e-14 ad=4.96e-14 ps=1.55e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21685e-06 sb=2e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(2)
ends MDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:22 2013 )
// Library name: gsclib045_hvt
// Cell name: MDFFHQX8
// View name: extracted

simulator lang=spectre

subckt MDFFHQX8 CK D0 D1 Q S0 VDD VSS
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.271e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.92213e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D0 VSS) capacitor c=6.49673e-17
C2 (S0 VSS) capacitor c=4.48209e-17
C3 (VDD VSS) capacitor c=3.08551e-16
C4 (CK VSS) capacitor c=7.54957e-17
C5 (D1 VSS) capacitor c=5.27971e-17
C6 (Q VSS) capacitor c=4.96042e-16
C7 (qbint VSS) capacitor c=3.78492e-16
C8 (n30 VSS) capacitor c=2.08232e-16
C9 (CKb VSS) capacitor c=4.87722e-17
C10 (n35 VSS) capacitor c=2.75049e-18
C11 (mout VSS) capacitor c=6.59019e-17
C12 (CKbb VSS) capacitor c=2.58852e-17
C13 (n20 VSS) capacitor c=3.8911e-17
C14 (n25 VSS) capacitor c=1.12961e-18
C15 (D0b VSS) capacitor c=9.71518e-17
C16 (n10 VSS) capacitor c=5.74422e-18
C17 (S0b VSS) capacitor c=3.48579e-17
C18 (n36 VSS) capacitor c=3.48222e-18
C19 (n26 VSS) capacitor c=3.30937e-18
C20 (n11 VSS) capacitor c=1.73603e-18
C21 (n13 VSS) capacitor c=7.01633e-18
C22 (\8\:S0 VSS) capacitor c=4.99456e-17
C23 (\1\:D1 VSS) capacitor c=5.11973e-17
C24 (\2\:S0 VSS) capacitor c=7.24278e-17
C25 (\4\:D0 VSS) capacitor c=9.27815e-17
C26 (\10\:CKb VSS) capacitor c=6.61966e-17
C27 (\7\:CKbb VSS) capacitor c=3.86159e-17
C28 (\8\:CKb VSS) capacitor c=4.00274e-17
C29 (\3\:CKb VSS) capacitor c=2.37466e-17
C30 (\3\:CKbb VSS) capacitor c=6.58069e-17
C31 (\22\:qbint VSS) capacitor c=4.91411e-17
C32 (\1\:CK VSS) capacitor c=3.51269e-17
C33 (\7\:S0 VSS) capacitor c=3.12974e-17
C34 (\3\:D1 VSS) capacitor c=8.00885e-17
C35 (\3\:S0 VSS) capacitor c=7.07879e-17
C36 (\3\:S0b VSS) capacitor c=6.82559e-17
C37 (\1\:D0 VSS) capacitor c=4.71662e-17
C38 (\5\:CKb VSS) capacitor c=2.71449e-17
C39 (\11\:CKb VSS) capacitor c=2.61405e-17
C40 (\5\:CKbb VSS) capacitor c=6.05531e-17
C41 (\4\:mout VSS) capacitor c=5.80067e-17
C42 (\3\:n20 VSS) capacitor c=4.56406e-17
C43 (\24\:qbint VSS) capacitor c=5.98316e-17
C44 (\3\:CK VSS) capacitor c=3.19822e-17
C45 (\5\:S0 VSS) capacitor c=1.77018e-17
C46 (\2\:D1 VSS) capacitor c=4.72738e-17
C47 (\4\:S0 VSS) capacitor c=4.39177e-17
C48 (\2\:S0b VSS) capacitor c=5.08214e-17
C49 (\1\:S0 VSS) capacitor c=5.66692e-17
C50 (\3\:D0 VSS) capacitor c=2.92488e-17
C51 (\8\:CKbb VSS) capacitor c=4.18371e-17
C52 (\9\:CKb VSS) capacitor c=2.73771e-17
C53 (\6\:CKbb VSS) capacitor c=4.00656e-17
C54 (\3\:mout VSS) capacitor c=1.75549e-17
C55 (\2\:n20 VSS) capacitor c=3.53188e-17
C56 (\4\:CKbb VSS) capacitor c=2.5985e-17
C57 (\4\:CKb VSS) capacitor c=3.72989e-17
C58 (\2\:CKb VSS) capacitor c=3.89957e-17
C59 (\23\:qbint VSS) capacitor c=4.71774e-17
C60 (\2\:CK VSS) capacitor c=3.18424e-17
C61 (\6\:S0b VSS) capacitor c=1.12556e-16
C62 (\1\:VDD VSS) capacitor c=4.57902e-17
C63 (\8\:D0b VSS) capacitor c=5.02821e-17
C64 (\15\:VDD VSS) capacitor c=4.16571e-17
C65 (\15\:CKbb VSS) capacitor c=8.11758e-17
C66 (\4\:D0b VSS) capacitor c=1.1283e-16
C67 (\4\:n20 VSS) capacitor c=6.06044e-17
C68 (\17\:VDD VSS) capacitor c=3.50802e-17
C69 (\9\:mout VSS) capacitor c=5.79217e-17
C70 (\14\:n30 VSS) capacitor c=1.09092e-16
C71 (\19\:VDD VSS) capacitor c=1.03065e-17
C72 (\18\:CKb VSS) capacitor c=1.03595e-16
C73 (\26\:qbint VSS) capacitor c=3.77231e-16
C74 (\3\:VDD VSS) capacitor c=5.41478e-17
C75 (\4\:S0b VSS) capacitor c=8.99586e-17
C76 (\9\:CKbb VSS) capacitor c=6.43422e-17
C77 (\6\:D0b VSS) capacitor c=7.70912e-17
C78 (\8\:n20 VSS) capacitor c=7.06562e-17
C79 (\7\:mout VSS) capacitor c=5.25937e-17
C80 (\12\:n30 VSS) capacitor c=2.07422e-16
C81 (\15\:CKb VSS) capacitor c=1.54769e-16
C82 (\2\:CKbb VSS) capacitor c=4.85884e-17
C83 (\2\:mout VSS) capacitor c=3.64409e-17
C84 (\6\:CKb VSS) capacitor c=6.51288e-17
C85 (\7\:CKb VSS) capacitor c=6.62711e-17
C86 (\2\:D0 VSS) capacitor c=4.63008e-17
C87 (\6\:S0 VSS) capacitor c=2.50368e-17
C88 (\4\:CK VSS) capacitor c=3.80795e-17
C89 (\25\:qbint VSS) capacitor c=1.19782e-16
C90 (\31\:qbint VSS) capacitor c=3.04795e-17
C91 (\11\:n30 VSS) capacitor c=1.53987e-16
C92 (\5\:mout VSS) capacitor c=5.11922e-17
C93 (\6\:mout VSS) capacitor c=5.58036e-17
C94 (\12\:CKb VSS) capacitor c=5.31736e-17
C95 (\13\:CKb VSS) capacitor c=1.31064e-16
C96 (\14\:CKb VSS) capacitor c=1.5935e-16
C97 (\17\:CKb VSS) capacitor c=1.01771e-16
C98 (\6\:n20 VSS) capacitor c=7.47254e-17
C99 (\7\:n20 VSS) capacitor c=7.5359e-17
C100 (\11\:CKbb VSS) capacitor c=9.10933e-17
C101 (\12\:CKbb VSS) capacitor c=1.11671e-16
C102 (\13\:CKbb VSS) capacitor c=1.18485e-16
C103 (\14\:CKbb VSS) capacitor c=1.31394e-16
C104 (\17\:CKbb VSS) capacitor c=6.48844e-17
C105 (\5\:D0 VSS) capacitor c=4.66662e-17
C106 (\3\:D0b VSS) capacitor c=1.17995e-16
C107 (\4\:D1 VSS) capacitor c=7.88451e-17
C108 (\9\:S0 VSS) capacitor c=6.47639e-17
C109 (\10\:S0 VSS) capacitor c=8.12759e-17
C110 (\11\:S0 VSS) capacitor c=3.03286e-17
C111 (\8\:S0b VSS) capacitor c=8.57459e-17
C112 (\5\:VDD VSS) capacitor c=4.00316e-17
C113 (\6\:VDD VSS) capacitor c=3.19021e-17
C114 (\8\:VDD VSS) capacitor c=2.805e-17
C115 (\9\:VDD VSS) capacitor c=5.12572e-16
Rk42 (\5\:D0 D0) resistor r=0.05403 c=0
Rk49 (\10\:S0 S0) resistor r=0.3407 c=0
Rk48 (\9\:S0 \10\:S0) resistor r=0.3756 c=0
Rk50 (S0 \11\:S0) resistor r=0.03909 c=0
Rk73 (\2\:VSS \4\:VSS) resistor r=0.4882 c=0
Rk74 (\4\:VSS \5\:VSS) resistor r=0.1829 c=0
Rk75 (\5\:VSS \6\:VSS) resistor r=0.6107 c=0
Rk76 (\6\:VSS \7\:VSS) resistor r=0.2572 c=0
Rk77 (\7\:VSS \8\:VSS) resistor r=0.3726 c=0
Rk84 (\9\:VSS VSS) resistor r=0.1024 c=0
Rk78 (\8\:VSS \9\:VSS) resistor r=0.4552 c=0
Rk85 (\5\:VSS \16\:VSS) resistor r=0.2341 c=0
Rk86 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk87 (\8\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.4189 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.218 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5916 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.2431 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.3209 c=0
Rk64 (\9\:VDD VDD) resistor r=0.1024 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.4937 c=0
Rk65 (\5\:VDD \16\:VDD) resistor r=0.2268 c=0
Rk66 (\6\:VDD \18\:VDD) resistor r=0.2199 c=0
Rk67 (\8\:VDD \20\:VDD) resistor r=0.07405 c=0
Rk14 (\4\:CK CK) resistor r=0.1318 c=0
Rk47 (\4\:D1 D1) resistor r=0.0251 c=0
Rk15 (\25\:qbint \26\:qbint) resistor r=0.8718 c=0
Rk19 (\26\:qbint \31\:qbint) resistor r=0.1663 c=0
Rk23 (\11\:n30 \13\:n30) resistor r=1.2398 c=0
Rk24 (\13\:n30 \15\:n30) resistor r=0.4642 c=0
Rk28 (\12\:CKb \13\:CKb) resistor r=0.2504 c=0
Rk29 (\13\:CKb \14\:CKb) resistor r=0.687 c=0
Rk30 (\14\:CKb \16\:CKb) resistor r=0.637 c=0
Rk31 (\13\:CKb \17\:CKb) resistor r=0.7147 c=0
Rk32 (\16\:CKb \19\:CKb) resistor r=0.5734 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2281 c=0
Rk26 (\6\:mout \8\:mout) resistor r=0.193 c=0
Rk27 (\6\:mout \10\:mout) resistor r=0.2421 c=0
Rk36 (\10\:CKbb \11\:CKbb) resistor r=0.3958 c=0
Rk37 (\11\:CKbb \12\:CKbb) resistor r=0.2849 c=0
Rk38 (\12\:CKbb \13\:CKbb) resistor r=0.8474 c=0
Rk39 (\11\:CKbb \14\:CKbb) resistor r=0.3429 c=0
Rk40 (\14\:CKbb \16\:CKbb) resistor r=0.6275 c=0
Rk41 (\12\:CKbb \17\:CKbb) resistor r=0.2249 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.1647 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3859 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.3046 c=0
Rk43 (\2\:D0b \3\:D0b) resistor r=0.6476 c=0
Rk44 (\3\:D0b \5\:D0b) resistor r=0.4237 c=0
Rk45 (\5\:D0b \7\:D0b) resistor r=0.4045 c=0
Rk46 (\3\:D0b \9\:D0b) resistor r=0.2015 c=0
Rk51 (\5\:S0b \7\:S0b) resistor r=0.7143 c=0
Rk52 (\7\:S0b \8\:S0b) resistor r=0.5705 c=0
Rl54 (\2\:D0 \4\:D0) resistor r=58.495 c=0
Rl52 (\1\:D0 \2\:D0) resistor r=109.984 c=0
Rl53 (\2\:D0 \3\:D0) resistor r=9.6183 c=0
Rl58 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl55 (\1\:S0 \2\:S0) resistor r=36.4253 c=0
Rl63 (\6\:S0 \8\:S0) resistor r=121.957 c=0
Rl62 (\6\:S0 \7\:S0) resistor r=46.9565 c=0
Rl61 (\5\:S0 \6\:S0) resistor r=13.569 c=0
Rl30 (\1\:CK \2\:CK) resistor r=96.1538 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl59 (\1\:D1 \2\:D1) resistor r=55.0021 c=0
Rl60 (\2\:D1 \3\:D1) resistor r=85.7713 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=65.3618 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=80.5643 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=193.478 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=61.5164 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=41.9892 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=185.006 c=0
Rl41 (mout \2\:mout) resistor r=102.726 c=0
Rl43 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl42 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=37.2302 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=138.005 c=0
Rl36 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=92.233 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=94.9225 c=0
Rl56 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl57 (\2\:S0b \3\:S0b) resistor r=121.943 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz16 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\7\:mout \8\:mout) resistor r=75 c=0
Rz11 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (D0b \2\:D0b) resistor r=75 c=0
Rz13 (\6\:D0b \7\:D0b) resistor r=75 c=0
Rz14 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry13 (\8\:D0b \9\:D0b) resistor r=31 c=0
Ry14 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx15 (\1\:S0 \9\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \10\:S0) resistor r=45 c=0
Rx17 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\31\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn11 (n10 \1\:D0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.94e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=7.98365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.06058e-07 sb=5.63365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.11058e-07 sb=3.58365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn13 (n12 \3\:D1 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16058e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn45_1__rcx (\26\:qbint n30 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn21 (\9\:CKbb \5\:CKb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10759e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\4\:S0b \7\:S0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11448e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (n35 \24\:qbint \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.95e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\12\:n30 CKb n35 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=3.895e-14 ps=6.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.79e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\7\:mout CKbb \12\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.895e-14 ad=1.1377e-13 ps=7.9e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3378e-07 sb=1.555e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.63e-14 ad=1.1377e-13 ps=1.37e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43378e-06 sb=9.55e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (n25 \4\:mout \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.23e-14 ps=1.37e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69878e-06 sb=6.9e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.612e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80378e-06 sb=5.85e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\6\:D0b \11\:CKb \8\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=6.458e-14 ps=8.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.94293e-06 sb=3.15e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mp11 (n11 \4\:D0 \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\8\:D0b \2\:S0 n11 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\8\:D0b S0b n13 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=13.6902 \
        scb=0.0122097 scc=0.000647516 m=(1)
mp13 (n13 \1\:D1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=14.7912 \
        scb=0.012924 scc=0.00064842 m=(1)
mp45_1__rcx (\26\:qbint n30 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.887e-14 ad=5.98e-14 ps=1.15667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.01e-14 ps=1.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99814e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp21 (\15\:CKbb \10\:CKb \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp10 (\6\:S0b \8\:S0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=20.6301 \
        scb=0.0216347 scc=0.00118997 m=(1)
mp50 (n36 \22\:qbint \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.1e-14 ps=1.93e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67661e-07 sb=1.75185e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp51 (\14\:n30 \3\:CKbb n36 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.12661e-07 sb=1.60685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp40 (\14\:n30 \3\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.82661e-07 sb=1.33685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp30 (\9\:mout n20 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25766e-06 sb=8.61855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp35 (n26 mout \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.805e-14 ps=1.38e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52266e-06 sb=5.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72266e-06 sb=3.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:D0b VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.328e-14 ad=5.58e-14 ps=1.15e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=1.71855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
ends MDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:23 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFHQX1 CK D Q SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.98462e-07 sd=160n sca=19.586 \
        scb=0.0215989 scc=0.000684683 m=(1)
mp11 (net342 \1\:D \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.12e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.43462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp12 (\7\:Db \2\:SE net342 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=7.02e-14 ps=9.4e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.94551e-07 sb=8.18462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp14 (\7\:Db SEb net350 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.02e-14 ps=1.2e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19551e-07 sb=5.93462e-07 sd=160n sca=12.4887 \
        scb=0.0108489 scc=0.000412416 m=(1)
mp13 (net350 \3\:SI \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=8.19e-14 ps=1.41e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.74551e-07 sb=3.38462e-07 sd=160n sca=13.4085 \
        scb=0.011387 scc=0.000412933 m=(1)
C1 (D VSS) capacitor c=4.3507e-17
C2 (Q VSS) capacitor c=1.52712e-17
C3 (VDD VSS) capacitor c=2.89827e-16
C4 (CK VSS) capacitor c=1.09244e-16
C5 (SE VSS) capacitor c=4.40103e-17
C6 (SI VSS) capacitor c=6.07727e-17
C7 (qbint VSS) capacitor c=1.79908e-17
C8 (CKb VSS) capacitor c=2.17351e-17
C9 (n30 VSS) capacitor c=3.43217e-17
C10 (net391 VSS) capacitor c=5.82309e-18
C11 (mout VSS) capacitor c=5.64258e-17
C12 (CKbb VSS) capacitor c=3.44304e-17
C13 (n20 VSS) capacitor c=3.73077e-17
C14 (net378 VSS) capacitor c=9.11373e-19
C15 (Db VSS) capacitor c=9.0433e-17
C16 (net399 VSS) capacitor c=8.55872e-18
C17 (SEb VSS) capacitor c=3.83858e-17
C18 (net334 VSS) capacitor c=6.50403e-18
C19 (net319 VSS) capacitor c=5.33809e-18
C20 (net342 VSS) capacitor c=2.75167e-18
C21 (net350 VSS) capacitor c=6.08103e-18
C22 (\7\:SE VSS) capacitor c=4.05118e-17
C23 (\3\:SI VSS) capacitor c=4.86977e-17
C24 (\2\:SE VSS) capacitor c=6.66823e-17
C25 (\1\:D VSS) capacitor c=9.03799e-17
C26 (\5\:CKb VSS) capacitor c=4.65943e-17
C27 (\7\:CKbb VSS) capacitor c=3.9191e-17
C28 (\8\:CKb VSS) capacitor c=4.26069e-17
C29 (\5\:qbint VSS) capacitor c=4.7028e-17
C30 (\3\:n30 VSS) capacitor c=4.04187e-17
C31 (\3\:CK VSS) capacitor c=4.81678e-17
C32 (\4\:qbint VSS) capacitor c=6.42521e-17
C33 (\5\:SE VSS) capacitor c=2.54409e-17
C34 (\1\:SI VSS) capacitor c=7.53961e-17
C35 (\3\:SE VSS) capacitor c=7.0182e-17
C36 (\3\:SEb VSS) capacitor c=6.05378e-17
C37 (\4\:D VSS) capacitor c=3.88157e-17
C38 (\10\:CKb VSS) capacitor c=3.34568e-17
C39 (\11\:CKb VSS) capacitor c=2.51137e-17
C40 (\5\:CKbb VSS) capacitor c=5.91905e-17
C41 (\4\:mout VSS) capacitor c=6.61451e-17
C42 (\3\:n20 VSS) capacitor c=3.92417e-17
C43 (\3\:CKbb VSS) capacitor c=3.10207e-17
C44 (\3\:CKb VSS) capacitor c=6.78524e-17
C45 (\8\:qbint VSS) capacitor c=3.72698e-17
C46 (\1\:CK VSS) capacitor c=5.02182e-17
C47 (\3\:qbint VSS) capacitor c=3.01153e-17
C48 (\6\:SE VSS) capacitor c=3.05036e-17
C49 (\2\:SI VSS) capacitor c=4.74764e-17
C50 (\4\:SE VSS) capacitor c=4.42107e-17
C51 (\2\:SEb VSS) capacitor c=5.49748e-17
C52 (\1\:SE VSS) capacitor c=5.21226e-17
C53 (\3\:D VSS) capacitor c=2.67226e-17
C54 (\8\:CKbb VSS) capacitor c=4.13885e-17
C55 (\9\:CKb VSS) capacitor c=2.79099e-17
C56 (\6\:CKbb VSS) capacitor c=4.03023e-17
C57 (\3\:mout VSS) capacitor c=2.54298e-17
C58 (\2\:n20 VSS) capacitor c=4.334e-17
C59 (\4\:CKb VSS) capacitor c=1.61597e-17
C60 (\4\:CKbb VSS) capacitor c=4.17501e-17
C61 (\2\:CKbb VSS) capacitor c=4.14319e-17
C62 (\7\:qbint VSS) capacitor c=2.4774e-17
C63 (\2\:n30 VSS) capacitor c=4.25727e-17
C64 (\2\:CK VSS) capacitor c=4.60188e-17
C65 (\6\:SEb VSS) capacitor c=1.03387e-16
C66 (\5\:VDD VSS) capacitor c=3.14574e-17
C67 (\7\:Db VSS) capacitor c=6.77514e-17
C68 (\7\:VDD VSS) capacitor c=5.22805e-17
C69 (\9\:CKbb VSS) capacitor c=1.02209e-16
C70 (\5\:Db VSS) capacitor c=1.0499e-16
C71 (\4\:n20 VSS) capacitor c=3.43118e-17
C72 (\10\:VDD VSS) capacitor c=3.474e-17
C73 (\9\:mout VSS) capacitor c=7.42701e-17
C74 (\8\:n30 VSS) capacitor c=5.21829e-17
C75 (\14\:VDD VSS) capacitor c=4.18852e-17
C76 (\14\:qbint VSS) capacitor c=7.12629e-17
C77 (\18\:CKb VSS) capacitor c=2.53667e-17
C78 (\17\:VDD VSS) capacitor c=2.56049e-17
C79 (\1\:Q VSS) capacitor c=5.46859e-17
C80 (\1\:VDD VSS) capacitor c=8.09952e-17
C81 (\4\:SEb VSS) capacitor c=5.50045e-17
C82 (\15\:CKbb VSS) capacitor c=4.24774e-17
C83 (\9\:Db VSS) capacitor c=6.88754e-17
C84 (\8\:n20 VSS) capacitor c=8.33314e-17
C85 (\7\:mout VSS) capacitor c=5.47566e-17
C86 (\4\:n30 VSS) capacitor c=7.27477e-17
C87 (\11\:qbint VSS) capacitor c=8.14101e-17
C88 (\15\:CKb VSS) capacitor c=9.31232e-17
C89 (\3\:Q VSS) capacitor c=5.61288e-17
C90 (\2\:qbint VSS) capacitor c=2.18605e-17
C91 (\6\:qbint VSS) capacitor c=2.38217e-17
C92 (\2\:CKb VSS) capacitor c=4.43845e-17
C93 (\2\:mout VSS) capacitor c=2.93226e-17
C94 (\6\:CKb VSS) capacitor c=5.8753e-17
C95 (\7\:CKb VSS) capacitor c=6.89886e-17
C96 (\2\:D VSS) capacitor c=2.85326e-17
C97 (\9\:qbint VSS) capacitor c=7.10184e-17
C98 (\10\:qbint VSS) capacitor c=6.63644e-17
C99 (\13\:qbint VSS) capacitor c=1.05921e-16
C100 (\6\:n30 VSS) capacitor c=1.03561e-16
C101 (\7\:n30 VSS) capacitor c=7.07379e-17
C102 (\5\:mout VSS) capacitor c=6.45752e-17
C103 (\6\:mout VSS) capacitor c=5.97447e-17
C104 (\12\:CKb VSS) capacitor c=5.74216e-17
C105 (\13\:CKb VSS) capacitor c=1.49149e-16
C106 (\14\:CKb VSS) capacitor c=1.66308e-16
C107 (\17\:CKb VSS) capacitor c=8.14976e-17
C108 (\6\:n20 VSS) capacitor c=7.96164e-17
C109 (\7\:n20 VSS) capacitor c=8.51778e-17
C110 (\11\:CKbb VSS) capacitor c=1.16902e-16
C111 (\12\:CKbb VSS) capacitor c=7.68595e-17
C112 (\13\:CKbb VSS) capacitor c=1.01213e-16
C113 (\14\:CKbb VSS) capacitor c=1.33197e-16
C114 (\17\:CKbb VSS) capacitor c=6.1439e-17
C115 (\18\:CKbb VSS) capacitor c=5.30683e-17
C116 (\5\:D VSS) capacitor c=6.15795e-17
C117 (\3\:Db VSS) capacitor c=1.29956e-16
C118 (\4\:SI VSS) capacitor c=7.60448e-17
C119 (\8\:SE VSS) capacitor c=7.43302e-17
C120 (\9\:SE VSS) capacitor c=7.40405e-17
C121 (\10\:SE VSS) capacitor c=2.61063e-17
C122 (\8\:SEb VSS) capacitor c=9.68955e-17
C123 (\3\:VDD VSS) capacitor c=2.03154e-17
C124 (\9\:VDD VSS) capacitor c=4.8161e-17
C125 (\13\:VDD VSS) capacitor c=1.24761e-17
C126 (\16\:VDD VSS) capacitor c=2.07533e-17
Rk29 (\5\:D D) resistor r=0.08856 c=0
Rk2 (\4\:Q Q) resistor r=0.02908 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.4952 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1954 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4568 c=0
Rk43 (\3\:VSS \6\:VSS) resistor r=0.2907 c=0
Rk44 (\4\:VSS \7\:VSS) resistor r=0.6041 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.5991 c=0
Rk47 (\9\:VSS VSS) resistor r=0.1375 c=0
Rk46 (\8\:VSS \9\:VSS) resistor r=0.4139 c=0
Rk48 (\4\:VSS \11\:VSS) resistor r=0.2657 c=0
Rk49 (\7\:VSS \13\:VSS) resistor r=0.1225 c=0
Rk50 (\8\:VSS \15\:VSS) resistor r=0.3173 c=0
Rk51 (\9\:VSS \17\:VSS) resistor r=0.2933 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.223 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.4292 c=0
Rk54 (\3\:VDD \6\:VDD) resistor r=0.2039 c=0
Rk55 (\4\:VDD \8\:VDD) resistor r=0.2986 c=0
Rk56 (\4\:VDD \9\:VDD) resistor r=0.6041 c=0
Rk57 (\9\:VDD \11\:VDD) resistor r=0.1859 c=0
Rk58 (\9\:VDD \12\:VDD) resistor r=0.5991 c=0
Rk59 (\12\:VDD \13\:VDD) resistor r=0.02989 c=0
Rk60 (\13\:VDD \15\:VDD) resistor r=0.236 c=0
Rk63 (\16\:VDD VDD) resistor r=0.1375 c=0
Rk61 (\13\:VDD \16\:VDD) resistor r=0.3832 c=0
Rk62 (\16\:VDD \18\:VDD) resistor r=0.1817 c=0
Rk37 (\9\:SE SE) resistor r=0.3377 c=0
Rk36 (\8\:SE \9\:SE) resistor r=0.3554 c=0
Rk38 (SE \10\:SE) resistor r=0.02105 c=0
Rk35 (\4\:SI SI) resistor r=0.03273 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.3153 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06062 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6904 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.3182 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2788 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9711 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4234 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.5459 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.1224 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.4975 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.3813 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1685 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3192 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.145 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3096 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.6368 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3322 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3239 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.5248 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.235 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2608 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.08271 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.4677 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.3854 c=0
Rk30 (\2\:Db \3\:Db) resistor r=0.6465 c=0
Rk31 (\3\:Db \4\:Db) resistor r=0.417 c=0
Rk32 (\4\:Db \6\:Db) resistor r=0.04616 c=0
Rk33 (\3\:Db \8\:Db) resistor r=0.2642 c=0
Rk34 (\4\:Db \10\:Db) resistor r=0.3646 c=0
Rk39 (\5\:SEb \7\:SEb) resistor r=0.5139 c=0
Rk40 (\7\:SEb \8\:SEb) resistor r=0.6394 c=0
Rl29 (\1\:D \2\:D) resistor r=123.88 c=0
Rl31 (\2\:D \4\:D) resistor r=54.6488 c=0
Rl30 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl5 (\2\:CK \3\:CK) resistor r=96.3431 c=0
Rl4 (\1\:CK \2\:CK) resistor r=109.615 c=0
Rl39 (\6\:SE \7\:SE) resistor r=126.099 c=0
Rl38 (\5\:SE \6\:SE) resistor r=40.3846 c=0
Rl35 (\3\:SE \4\:SE) resistor r=48.6653 c=0
Rl32 (\1\:SE \2\:SE) resistor r=55.6561 c=0
Rl37 (\2\:SI \3\:SI) resistor r=64.5604 c=0
Rl36 (\1\:SI \2\:SI) resistor r=100 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=120.868 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=42.0218 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=38.143 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=174.543 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=36.87 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=139.618 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=89.6181 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=32.3738 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=31.8681 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl18 (mout \2\:mout) resistor r=48.8796 c=0
Rl20 (\2\:mout \4\:mout) resistor r=75.8027 c=0
Rl19 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=24.2328 c=0
Rl11 (CKbb \2\:CKbb) resistor r=30.0021 c=0
Rl16 (n20 \2\:n20) resistor r=29.5379 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=79.5379 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.771 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \12\:VDD) resistor r=6.25 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\9\:Db \10\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry14 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\5\:Db \6\:Db) resistor r=62 c=0
Ry9 (\7\:Db \8\:Db) resistor r=20.6667 c=0
Ry10 (\6\:SEb \7\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK CK) resistor r=45 c=0
Rx15 (\1\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\6\:SE \10\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn11 (net399 \4\:D \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=7.93e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=9.99808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.03365e-07 sb=6.49808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.08365e-07 sb=4.44808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn13 (net411 \1\:SI \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=1.56e-14 ps=1.15e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13365e-07 sb=3.39808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn20 (\15\:CKb \1\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.972e-14 ps=9.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09879e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\4\:SEb \5\:SE \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=2.465e-14 ps=1.15e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18638e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn45 (\11\:qbint n30 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(1)
mn50 (net391 \8\:qbint \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.383e-14 ad=4.408e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.945e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (\4\:n30 \3\:CKb net391 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.535e-14 ps=8.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.685e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.535e-14 ad=7.585e-14 ps=9.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.37e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (\7\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=7.585e-14 ps=1.27e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=9.55e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (net378 \4\:mout \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=6.9e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.613e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=5.85e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (\8\:n20 \11\:CKb \9\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=3.15e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mp20 (\18\:CKb \3\:CK \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.483e-14 ps=1.1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=12.8361 \
        scb=0.0101573 scc=0.000104788 m=(1)
mp21 (\9\:CKbb \5\:CKb \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34e-06 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp10 (\6\:SEb \7\:SE \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=1.4e-07 sd=160n sca=21.6088 \
        scb=0.0245661 scc=0.00103605 m=(1)
mp45 (\14\:qbint \3\:n30 \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.56e-14 ad=4.315e-14 ps=1.35e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39194e-07 sb=2e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp50 (net334 \5\:qbint \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.56e-14 ad=5.27e-14 ps=1.35e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04194e-07 sb=1.915e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\8\:n30 CKbb net334 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.145e-14 ps=9.6e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19194e-07 sb=1.7e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.209e-13 ad=9.145e-14 ps=1.4e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59194e-07 sb=1.36e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp30 (\9\:mout n20 \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=1.209e-13 ps=1.5e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39419e-06 sb=9.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (net319 mout \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=4.805e-14 ps=1.5e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65919e-06 sb=6.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85919e-06 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\5\:Db \7\:CKbb \4\:n20 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=7.285e-14 ps=9.8e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=26.7199 scb=0.0211429 \
        scc=0.00304348 m=(1)
ends SDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:24 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFHQX2 CK D Q SE SI VDD VSS
mp11 (net342 \1\:D \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.85833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (\6\:Db \1\:SE net342 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.59551e-07 sb=7.95833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp14 (\6\:Db SEb net350 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.84551e-07 sb=5.70833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (net350 \3\:SI \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=5.265e-14 ps=1.6e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.64551e-07 sb=3.90833e-07 sd=160n sca=16.239 \
        scb=0.0143727 scc=0.00110279 m=(1)
mp55 (\1\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=30.9465 \
        scb=0.0329575 scc=0.002778 m=(2)
C1 (D VSS) capacitor c=5.86585e-17
C2 (Q VSS) capacitor c=3.45083e-17
C3 (VDD VSS) capacitor c=3.42065e-16
C4 (CK VSS) capacitor c=5.83872e-17
C5 (SI VSS) capacitor c=1.10775e-16
C6 (qbint VSS) capacitor c=1.42921e-16
C7 (CKb VSS) capacitor c=1.68871e-17
C8 (n30 VSS) capacitor c=3.72615e-17
C9 (mout VSS) capacitor c=6.00805e-17
C10 (CKbb VSS) capacitor c=3.53933e-17
C11 (n20 VSS) capacitor c=3.96373e-17
C12 (net378 VSS) capacitor c=1.65965e-18
C13 (Db VSS) capacitor c=1.07303e-16
C14 (net399 VSS) capacitor c=1.17545e-17
C15 (SEb VSS) capacitor c=4.5651e-17
C16 (net411 VSS) capacitor c=1.47994e-18
C17 (net334 VSS) capacitor c=9.04161e-18
C18 (net319 VSS) capacitor c=6.19945e-18
C19 (net342 VSS) capacitor c=5.59536e-18
C20 (net350 VSS) capacitor c=3.91527e-18
C21 (\7\:SE VSS) capacitor c=3.10912e-17
C22 (\3\:SI VSS) capacitor c=5.11695e-17
C23 (\1\:SE VSS) capacitor c=4.97908e-17
C24 (\1\:D VSS) capacitor c=6.54026e-17
C25 (\10\:CKb VSS) capacitor c=5.3274e-17
C26 (\7\:CKbb VSS) capacitor c=3.94237e-17
C27 (\8\:CKb VSS) capacitor c=4.39846e-17
C28 (\4\:CKb VSS) capacitor c=2.1519e-17
C29 (\8\:qbint VSS) capacitor c=4.78273e-17
C30 (\3\:n30 VSS) capacitor c=4.30002e-17
C31 (\3\:CK VSS) capacitor c=3.95459e-17
C32 (\5\:SE VSS) capacitor c=2.96943e-17
C33 (\1\:SI VSS) capacitor c=7.46974e-17
C34 (\3\:SE VSS) capacitor c=6.63223e-17
C35 (\3\:SEb VSS) capacitor c=5.95274e-17
C36 (\4\:D VSS) capacitor c=4.3845e-17
C37 (\5\:CKb VSS) capacitor c=3.20886e-17
C38 (\11\:CKb VSS) capacitor c=2.44232e-17
C39 (\5\:CKbb VSS) capacitor c=5.21993e-17
C40 (\4\:mout VSS) capacitor c=5.50107e-17
C41 (\3\:n20 VSS) capacitor c=4.36534e-17
C42 (\3\:CKbb VSS) capacitor c=3.00472e-17
C43 (\3\:CKb VSS) capacitor c=6.77966e-17
C44 (\11\:qbint VSS) capacitor c=3.57889e-17
C45 (\1\:CK VSS) capacitor c=4.22686e-17
C46 (\6\:SE VSS) capacitor c=2.65133e-17
C47 (\2\:SI VSS) capacitor c=5.05078e-17
C48 (\4\:SE VSS) capacitor c=4.74044e-17
C49 (\2\:SEb VSS) capacitor c=6.68526e-17
C50 (\2\:SE VSS) capacitor c=3.84466e-17
C51 (\3\:D VSS) capacitor c=2.76836e-17
C52 (\8\:CKbb VSS) capacitor c=3.96293e-17
C53 (\9\:CKb VSS) capacitor c=2.41808e-17
C54 (\6\:CKbb VSS) capacitor c=4.74902e-17
C55 (\3\:mout VSS) capacitor c=1.84103e-17
C56 (\2\:n20 VSS) capacitor c=3.54151e-17
C57 (\4\:CKbb VSS) capacitor c=3.88909e-17
C58 (\2\:CKbb VSS) capacitor c=4.35208e-17
C59 (\10\:qbint VSS) capacitor c=2.49612e-17
C60 (\2\:n30 VSS) capacitor c=4.31174e-17
C61 (\2\:CK VSS) capacitor c=3.65523e-17
C62 (\6\:qbint VSS) capacitor c=2.596e-17
C63 (\5\:SEb VSS) capacitor c=1.06163e-16
C64 (\12\:VDD VSS) capacitor c=3.83257e-17
C65 (\6\:Db VSS) capacitor c=6.55996e-17
C66 (\14\:VDD VSS) capacitor c=5.47512e-17
C67 (\9\:CKbb VSS) capacitor c=7.45193e-17
C68 (\4\:Db VSS) capacitor c=9.126e-17
C69 (\4\:n20 VSS) capacitor c=6.12637e-17
C70 (\16\:VDD VSS) capacitor c=3.5225e-17
C71 (\9\:mout VSS) capacitor c=6.27091e-17
C72 (\6\:n30 VSS) capacitor c=5.93577e-17
C73 (\18\:VDD VSS) capacitor c=2.86758e-17
C74 (\14\:qbint VSS) capacitor c=7.53905e-17
C75 (\15\:CKb VSS) capacitor c=3.65219e-17
C76 (\1\:Q VSS) capacitor c=8.10944e-17
C77 (\1\:VDD VSS) capacitor c=5.8476e-17
C78 (\7\:SEb VSS) capacitor c=6.85301e-17
C79 (\15\:CKbb VSS) capacitor c=5.92557e-17
C80 (\8\:Db VSS) capacitor c=7.20809e-17
C81 (\8\:n20 VSS) capacitor c=6.67022e-17
C82 (\7\:mout VSS) capacitor c=5.95759e-17
C83 (\8\:n30 VSS) capacitor c=8.96019e-17
C84 (\16\:qbint VSS) capacitor c=7.57164e-17
C85 (\18\:CKb VSS) capacitor c=8.95627e-17
C86 (\3\:Q VSS) capacitor c=1.51928e-17
C87 (\9\:qbint VSS) capacitor c=2.44775e-17
C88 (\2\:CKb VSS) capacitor c=4.32357e-17
C89 (\2\:mout VSS) capacitor c=3.34305e-17
C90 (\6\:CKb VSS) capacitor c=7.6933e-17
C91 (\7\:CKb VSS) capacitor c=7.02433e-17
C92 (\2\:D VSS) capacitor c=2.48941e-17
C93 (\4\:CK VSS) capacitor c=7.23277e-17
C94 (\12\:qbint VSS) capacitor c=6.72714e-17
C95 (\13\:qbint VSS) capacitor c=6.08996e-17
C96 (\18\:qbint VSS) capacitor c=9.49802e-17
C97 (\4\:n30 VSS) capacitor c=7.30267e-17
C98 (\5\:n30 VSS) capacitor c=9.11922e-17
C99 (\5\:mout VSS) capacitor c=5.12745e-17
C100 (\6\:mout VSS) capacitor c=4.82322e-17
C101 (\12\:CKb VSS) capacitor c=5.42788e-17
C102 (\13\:CKb VSS) capacitor c=1.43598e-16
C103 (\14\:CKb VSS) capacitor c=1.4286e-16
C104 (\17\:CKb VSS) capacitor c=8.12018e-17
C105 (\6\:n20 VSS) capacitor c=7.25667e-17
C106 (\7\:n20 VSS) capacitor c=6.22133e-17
C107 (\11\:CKbb VSS) capacitor c=1.29025e-16
C108 (\12\:CKbb VSS) capacitor c=7.63497e-17
C109 (\13\:CKbb VSS) capacitor c=1.28425e-16
C110 (\14\:CKbb VSS) capacitor c=1.33018e-16
C111 (\17\:CKbb VSS) capacitor c=4.68267e-17
C112 (\18\:CKbb VSS) capacitor c=6.0968e-17
C113 (\5\:D VSS) capacitor c=5.41637e-17
C114 (\3\:Db VSS) capacitor c=1.48383e-16
C115 (\8\:SE VSS) capacitor c=1.4458e-17
C116 (\9\:SE VSS) capacitor c=1.21238e-16
C117 (\10\:SE VSS) capacitor c=5.649e-17
C118 (\11\:SE VSS) capacitor c=9.79259e-17
C119 (\4\:SEb VSS) capacitor c=9.18656e-17
C120 (\3\:VDD VSS) capacitor c=1.56441e-17
C121 (\4\:VDD VSS) capacitor c=1.66881e-17
C122 (\6\:VDD VSS) capacitor c=3.79881e-17
C123 (\7\:VDD VSS) capacitor c=2.10421e-17
Rk29 (\5\:D D) resistor r=0.1122 c=0
Rk1 (\2\:Q Q) resistor r=0.2051 c=0
Rk2 (Q \4\:Q) resistor r=0.166 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1677 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4307 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.1527 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.4485 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.6563 c=0
Rk47 (\8\:VSS VSS) resistor r=0.3332 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.09756 c=0
Rk50 (\3\:VSS \13\:VSS) resistor r=0.2067 c=0
Rk51 (\4\:VSS \15\:VSS) resistor r=0.2111 c=0
Rk52 (\6\:VSS \17\:VSS) resistor r=0.1222 c=0
Rk53 (\7\:VSS \19\:VSS) resistor r=0.237 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.1978 c=0
Rk56 (\3\:VDD \4\:VDD) resistor r=0.4007 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.1527 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.4786 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.6388 c=0
Rk61 (\8\:VDD VDD) resistor r=0.3332 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.08503 c=0
Rk64 (\3\:VDD \13\:VDD) resistor r=0.2466 c=0
Rk65 (\4\:VDD \15\:VDD) resistor r=0.3102 c=0
Rk66 (\6\:VDD \17\:VDD) resistor r=0.242 c=0
Rk67 (\7\:VDD \19\:VDD) resistor r=0.2266 c=0
Rk3 (\4\:CK CK) resistor r=0.1297 c=0
Rk35 (\8\:SE \9\:SE) resistor r=0.04037 c=0
Rk36 (\9\:SE \10\:SE) resistor r=0.4299 c=0
Rk38 (\11\:SE SE) resistor r=0.004282 c=0
Rk37 (\9\:SE \11\:SE) resistor r=0.6809 c=0
Rk34 (\4\:SI SI) resistor r=0.003482 c=0
Rk4 (\12\:qbint \13\:qbint) resistor r=0.3074 c=0
Rk5 (\13\:qbint \15\:qbint) resistor r=0.3138 c=0
Rk6 (\13\:qbint \17\:qbint) resistor r=0.05799 c=0
Rk7 (\17\:qbint \18\:qbint) resistor r=0.7082 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2506 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9254 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.1459 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.6495 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.4111 c=0
Rk8 (\4\:n30 \5\:n30) resistor r=0.3724 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.1741 c=0
Rk10 (\5\:n30 \9\:n30) resistor r=0.5381 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.241 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1153 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2348 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.5667 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3076 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3291 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.858 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2539 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1934 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3963 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2531 c=0
Rk30 (\2\:Db \3\:Db) resistor r=0.6822 c=0
Rk31 (\3\:Db \5\:Db) resistor r=0.3925 c=0
Rk32 (\3\:Db \7\:Db) resistor r=0.3379 c=0
Rk33 (\5\:Db \9\:Db) resistor r=0.3871 c=0
Rk39 (\4\:SEb \6\:SEb) resistor r=0.649 c=0
Rk40 (\6\:SEb \8\:SEb) resistor r=0.5281 c=0
Rl32 (\1\:D \2\:D) resistor r=101.637 c=0
Rl34 (\2\:D \4\:D) resistor r=59.3295 c=0
Rl33 (\2\:D \3\:D) resistor r=8.3038 c=0
Rl8 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl7 (\1\:CK \2\:CK) resistor r=96.1338 c=0
Rl42 (\6\:SE \7\:SE) resistor r=39.5604 c=0
Rl41 (\5\:SE \6\:SE) resistor r=105.769 c=0
Rl38 (\3\:SE \4\:SE) resistor r=29.4849 c=0
Rl35 (\1\:SE \2\:SE) resistor r=48.7687 c=0
Rl40 (\2\:SI \3\:SI) resistor r=48.0541 c=0
Rl39 (\1\:SI \2\:SI) resistor r=99.7951 c=0
Rl5 (qbint \6\:qbint) resistor r=9.5287 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=49.7141 c=0
Rl13 (\9\:qbint \11\:qbint) resistor r=84.3295 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl18 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl17 (\2\:CKb \3\:CKb) resistor r=178.39 c=0
Rl16 (CKb \2\:CKb) resistor r=37.675 c=0
Rl30 (\6\:CKb \10\:CKb) resistor r=199.259 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=76.0085 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=143.774 c=0
Rl31 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=198.915 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=33.7912 c=0
Rl9 (n30 \2\:n30) resistor r=84.6154 c=0
Rl21 (mout \2\:mout) resistor r=99.7141 c=0
Rl23 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl22 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=39.6174 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=33.8482 c=0
Rl14 (CKbb \2\:CKbb) resistor r=37.6944 c=0
Rl19 (n20 \2\:n20) resistor r=29.5379 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=87.2302 c=0
Rl36 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=131.73 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz17 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz18 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=31 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry2 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\6\:n30 \7\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=20.6667 c=0
Ry10 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\4\:SE \8\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\6\:SE \11\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\18\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn11 (net399 \4\:D \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=7.67e-14 ps=8.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.07942e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=7.39423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.69e-14 ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.81635e-07 sb=5.34423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn13 (net411 \1\:SI \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=1.69e-14 ps=1.33e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91635e-07 sb=4.24423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn55_1__rcx (\3\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.73654e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\18\:CKb \1\:CK VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.567e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \5\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10552e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn10 (\7\:SEb \5\:SE \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=2.9e-14 ps=1.33e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25569e-06 sb=2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn45 (\16\:qbint n30 \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn50 (net391 \11\:qbint \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.382e-14 ad=5.432e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\8\:n30 \3\:CKb net391 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=4.51e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.725e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=8.61e-14 ps=8.5e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.46e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=8.61e-14 ps=1.18e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.95e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (net378 \4\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=1.435e-14 ps=1.18e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=7.3e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=6.15e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn25 (\8\:n20 \11\:CKb \8\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=5.228e-14 ps=1.04e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mp20 (\15\:CKb \3\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.3324 \
        scb=0.00994664 scc=0.000204208 m=(1)
mp21 (\9\:CKbb \10\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05465e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp10 (\5\:SEb \7\:SE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23372e-06 sb=1.4e-07 sd=160n sca=25.6683 \
        scb=0.0269847 scc=0.00206824 m=(1)
mp45 (\14\:qbint \3\:n30 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.1e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp50 (net334 \8\:qbint \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.1e-14 ad=5.27e-14 ps=1.44e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.92871e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\6\:n30 CKbb net334 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.765e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.71597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\6\:n30 \4\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.302e-13 ad=9.765e-14 ps=1.46e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.35597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout n20 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.302e-13 ps=1.38e-06 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=8.90968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net319 mout \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.045e-14 ps=1.38e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=6.25968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.58e-14 ps=1.01e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=3.85968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:Db \7\:CKbb \4\:n20 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.99e-14 ps=9.8e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.60968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends SDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:26 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFHQX4 CK D Q SE SI VDD VSS
mp20 (\14\:CKb \4\:CK \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.8563 scb=0.0365862 \
        scc=0.0028968 m=(1)
mp21 (\9\:CKbb \5\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.17093e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp10 (\7\:SEb \5\:SE \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=3.01e-14 ps=1.25e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45581e-07 sb=1.4e-07 sd=160n sca=26.9589 \
        scb=0.0303196 scc=0.00206685 m=(1)
C1 (D VSS) capacitor c=5.3443e-17
C2 (Q VSS) capacitor c=1.89934e-16
C3 (VDD VSS) capacitor c=3.3931e-16
C4 (CK VSS) capacitor c=6.75849e-17
C5 (SE VSS) capacitor c=6.31657e-17
C6 (SI VSS) capacitor c=1.01606e-16
C7 (CKb VSS) capacitor c=2.27527e-17
C8 (qbint VSS) capacitor c=3.099e-16
C9 (n30 VSS) capacitor c=1.86832e-16
C10 (net391 VSS) capacitor c=5.33374e-18
C11 (mout VSS) capacitor c=6.83587e-17
C12 (CKbb VSS) capacitor c=4.81422e-17
C13 (n20 VSS) capacitor c=3.7159e-17
C14 (net378 VSS) capacitor c=1.08109e-18
C15 (Db VSS) capacitor c=8.39311e-17
C16 (net399 VSS) capacitor c=6.57884e-18
C17 (SEb VSS) capacitor c=4.35599e-17
C18 (net334 VSS) capacitor c=5.48591e-18
C19 (net319 VSS) capacitor c=2.64832e-18
C20 (net342 VSS) capacitor c=1.75166e-18
C21 (net350 VSS) capacitor c=4.24869e-18
C22 (\5\:SE VSS) capacitor c=4.43532e-17
C23 (\3\:SI VSS) capacitor c=5.41372e-17
C24 (\2\:SE VSS) capacitor c=7.23839e-17
C25 (\1\:D VSS) capacitor c=8.85769e-17
C26 (\5\:CKb VSS) capacitor c=6.58779e-17
C27 (\7\:CKbb VSS) capacitor c=3.97048e-17
C28 (\8\:CKb VSS) capacitor c=5.8083e-17
C29 (\4\:CKb VSS) capacitor c=2.72877e-17
C30 (\14\:qbint VSS) capacitor c=6.36695e-17
C31 (\4\:CK VSS) capacitor c=4.06127e-17
C32 (\7\:SE VSS) capacitor c=3.393e-17
C33 (\1\:SI VSS) capacitor c=8.55139e-17
C34 (\3\:SE VSS) capacitor c=7.08739e-17
C35 (\3\:SEb VSS) capacitor c=6.06079e-17
C36 (\4\:D VSS) capacitor c=4.16628e-17
C37 (\10\:CKb VSS) capacitor c=2.55803e-17
C38 (\11\:CKb VSS) capacitor c=2.53307e-17
C39 (\5\:CKbb VSS) capacitor c=4.39748e-17
C40 (\4\:mout VSS) capacitor c=4.38937e-17
C41 (\3\:n20 VSS) capacitor c=4.3638e-17
C42 (\3\:CKbb VSS) capacitor c=3.08907e-17
C43 (\3\:CKb VSS) capacitor c=5.19528e-17
C44 (\17\:qbint VSS) capacitor c=3.00496e-17
C45 (\3\:CK VSS) capacitor c=3.05327e-17
C46 (\6\:SE VSS) capacitor c=3.58674e-17
C47 (\2\:SI VSS) capacitor c=5.79746e-17
C48 (\4\:SE VSS) capacitor c=4.32745e-17
C49 (\1\:SE VSS) capacitor c=4.72747e-17
C50 (\3\:D VSS) capacitor c=3.15008e-17
C51 (\8\:CKbb VSS) capacitor c=3.79741e-17
C52 (\9\:CKb VSS) capacitor c=2.9056e-17
C53 (\6\:CKbb VSS) capacitor c=3.88791e-17
C54 (\3\:mout VSS) capacitor c=1.73077e-17
C55 (\2\:n20 VSS) capacitor c=3.88755e-17
C56 (\4\:CKbb VSS) capacitor c=3.63133e-17
C57 (\2\:CKbb VSS) capacitor c=4.58211e-17
C58 (\16\:qbint VSS) capacitor c=3.05735e-17
C59 (\1\:CK VSS) capacitor c=2.62933e-17
C60 (\7\:SEb VSS) capacitor c=9.29221e-17
C61 (\9\:VDD VSS) capacitor c=3.23234e-17
C62 (\4\:Db VSS) capacitor c=6.65857e-17
C63 (\11\:VDD VSS) capacitor c=3.39707e-17
C64 (\9\:CKbb VSS) capacitor c=8.41382e-17
C65 (\6\:Db VSS) capacitor c=1.25765e-16
C66 (\4\:n20 VSS) capacitor c=5.86714e-17
C67 (\13\:VDD VSS) capacitor c=3.29528e-17
C68 (\9\:mout VSS) capacitor c=6.30858e-17
C69 (\11\:n30 VSS) capacitor c=5.64274e-17
C70 (\18\:qbint VSS) capacitor c=4.8367e-17
C71 (\14\:CKb VSS) capacitor c=2.25223e-16
C72 (\1\:VDD VSS) capacitor c=6.10822e-17
C73 (\5\:SEb VSS) capacitor c=4.88877e-17
C74 (\15\:CKbb VSS) capacitor c=5.66474e-17
C75 (\8\:Db VSS) capacitor c=7.33357e-17
C76 (\8\:n20 VSS) capacitor c=6.65326e-17
C77 (\7\:mout VSS) capacitor c=4.87515e-17
C78 (\7\:n30 VSS) capacitor c=6.00782e-17
C79 (\23\:qbint VSS) capacitor c=2.42858e-17
C80 (\16\:CKb VSS) capacitor c=4.30079e-17
C81 (\2\:CK VSS) capacitor c=1.81098e-17
C82 (\15\:qbint VSS) capacitor c=2.51358e-17
C83 (\2\:CKb VSS) capacitor c=5.62676e-17
C84 (\2\:mout VSS) capacitor c=3.66725e-17
C85 (\6\:CKb VSS) capacitor c=5.29034e-17
C86 (\7\:CKb VSS) capacitor c=5.47364e-17
C87 (\2\:D VSS) capacitor c=3.60809e-17
C88 (\2\:SEb VSS) capacitor c=5.68908e-17
C89 (\5\:CK VSS) capacitor c=5.76949e-17
C90 (\20\:qbint VSS) capacitor c=2.32092e-17
C91 (\21\:qbint VSS) capacitor c=4.10132e-17
C92 (\22\:qbint VSS) capacitor c=1.44032e-17
C93 (\25\:qbint VSS) capacitor c=4.78203e-17
C94 (\9\:n30 VSS) capacitor c=8.16954e-17
C95 (\10\:n30 VSS) capacitor c=4.94205e-17
C96 (\5\:mout VSS) capacitor c=4.98683e-17
C97 (\6\:mout VSS) capacitor c=5.60969e-17
C98 (\12\:CKb VSS) capacitor c=5.1513e-17
C99 (\13\:CKb VSS) capacitor c=2.35216e-16
C100 (\18\:CKb VSS) capacitor c=7.77548e-17
C101 (\6\:n20 VSS) capacitor c=6.58656e-17
C102 (\7\:n20 VSS) capacitor c=6.57828e-17
C103 (\11\:CKbb VSS) capacitor c=1.41509e-16
C104 (\12\:CKbb VSS) capacitor c=7.74418e-17
C105 (\13\:CKbb VSS) capacitor c=1.0955e-16
C106 (\14\:CKbb VSS) capacitor c=1.0236e-16
C107 (\17\:CKbb VSS) capacitor c=5.45041e-17
C108 (\18\:CKbb VSS) capacitor c=6.09077e-17
C109 (\5\:D VSS) capacitor c=6.15955e-17
C110 (\3\:Db VSS) capacitor c=1.27278e-16
C111 (\9\:SE VSS) capacitor c=5.45955e-17
C112 (\10\:SE VSS) capacitor c=7.81969e-17
C113 (\9\:SEb VSS) capacitor c=8.8449e-17
C114 (\3\:VDD VSS) capacitor c=1.29915e-17
C115 (\4\:VDD VSS) capacitor c=2.66746e-17
C116 (\6\:VDD VSS) capacitor c=4.07048e-17
C117 (\7\:VDD VSS) capacitor c=1.80846e-16
Rk31 (\5\:D D) resistor r=0.1545 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.07749 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.363 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.3106 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.3607 c=0
Rk75 (\7\:VDD VDD) resistor r=0.0998 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.6011 c=0
Rk66 (\3\:VDD \10\:VDD) resistor r=0.2396 c=0
Rk67 (\4\:VDD \12\:VDD) resistor r=0.2396 c=0
Rk68 (\6\:VDD \14\:VDD) resistor r=0.1619 c=0
Rk1 (CK \5\:CK) resistor r=0.1707 c=0
Rk38 (SE \8\:SE) resistor r=0.003095 c=0
Rk39 (\8\:SE \9\:SE) resistor r=0.2335 c=0
Rk40 (\9\:SE \10\:SE) resistor r=0.3245 c=0
Rk37 (\4\:SI SI) resistor r=0.007054 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.0399 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.4357 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.2755 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.3306 c=0
Rk52 (\7\:VSS VSS) resistor r=0.1249 c=0
Rk47 (\6\:VSS \7\:VSS) resistor r=0.6312 c=0
Rk53 (\3\:VSS \13\:VSS) resistor r=0.2894 c=0
Rk54 (\4\:VSS \15\:VSS) resistor r=0.316 c=0
Rk55 (\6\:VSS \17\:VSS) resistor r=0.1253 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2989 c=0
Rk18 (\13\:CKb \15\:CKb) resistor r=1.7741 c=0
Rk19 (\15\:CKb \17\:CKb) resistor r=0.392 c=0
Rk20 (\13\:CKb \18\:CKb) resistor r=0.5387 c=0
Rk6 (\19\:qbint \20\:qbint) resistor r=0.3027 c=0
Rk7 (\20\:qbint \21\:qbint) resistor r=0.2096 c=0
Rk8 (\20\:qbint \22\:qbint) resistor r=0.07797 c=0
Rk9 (\22\:qbint \24\:qbint) resistor r=0.07084 c=0
Rk10 (\22\:qbint \25\:qbint) resistor r=0.1852 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.4493 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.2117 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.3038 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.2333 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.1994 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.2599 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.6608 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.3715 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.2829 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.8171 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.3533 c=0
Rk29 (\13\:CKbb \17\:CKbb) resistor r=0.2213 c=0
Rk30 (\14\:CKbb \18\:CKbb) resistor r=0.2549 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.171 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3369 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.286 c=0
Rk32 (\2\:Db \3\:Db) resistor r=0.6566 c=0
Rk33 (\3\:Db \5\:Db) resistor r=0.1478 c=0
Rk34 (\3\:Db \7\:Db) resistor r=0.5202 c=0
Rk35 (\7\:Db \9\:Db) resistor r=0.3715 c=0
Rk36 (\5\:Db \10\:Db) resistor r=0.1569 c=0
Rk41 (\6\:SEb \8\:SEb) resistor r=0.4631 c=0
Rk42 (\8\:SEb \9\:SEb) resistor r=0.533 c=0
Rl42 (\1\:D \2\:D) resistor r=50.8027 c=0
Rl44 (\2\:D \4\:D) resistor r=98.8796 c=0
Rl43 (\2\:D \3\:D) resistor r=12.2499 c=0
Rl3 (\2\:CK \4\:CK) resistor r=82.4064 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.3295 c=0
Rl1 (\1\:CK \2\:CK) resistor r=3.5213 c=0
Rl52 (\5\:SE \6\:SE) resistor r=104.538 c=0
Rl53 (\6\:SE \7\:SE) resistor r=39.1533 c=0
Rl49 (\3\:SE \4\:SE) resistor r=28.079 c=0
Rl45 (\1\:SE \2\:SE) resistor r=37.7189 c=0
Rl51 (\2\:SI \3\:SI) resistor r=43.6813 c=0
Rl50 (\1\:SI \2\:SI) resistor r=92.3077 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl28 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=145.697 c=0
Rl26 (CKb \2\:CKb) resistor r=84.5407 c=0
Rl36 (\5\:CKb \6\:CKb) resistor r=185.338 c=0
Rl40 (\6\:CKb \10\:CKb) resistor r=47.3105 c=0
Rl38 (\7\:CKb \8\:CKb) resistor r=170.697 c=0
Rl41 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl37 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl21 (\15\:qbint \14\:qbint) resistor r=103.56 c=0
Rl23 (\15\:qbint \17\:qbint) resistor r=34.3295 c=0
Rl22 (\15\:qbint \16\:qbint) resistor r=11.4953 c=0
Rl31 (mout \2\:mout) resistor r=98.8796 c=0
Rl33 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl32 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl35 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl25 (\3\:CKbb \4\:CKbb) resistor r=33.3841 c=0
Rl24 (CKbb \2\:CKbb) resistor r=41.0764 c=0
Rl29 (n20 \2\:n20) resistor r=26.098 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl46 (SEb \2\:SEb) resistor r=67.4757 c=0
Rl47 (\2\:SEb \3\:SEb) resistor r=147.664 c=0
Rl48 (\2\:SEb \4\:SEb) resistor r=1.2666 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz20 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz6 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz3 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry16 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry14 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry6 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\19\:qbint \18\:qbint) resistor r=62 c=0
Ry4 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:Db \5\:Db) resistor r=62 c=0
Ry10 (\6\:Db \7\:Db) resistor r=62 c=0
Ry11 (\4\:Db \10\:Db) resistor r=62 c=0
Ry12 (\7\:SEb \8\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx15 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\1\:SE \10\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \18\:CKb) resistor r=45 c=0
Rx2 (\21\:qbint qbint) resistor r=45 c=0
Rx3 (\25\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \9\:SEb) resistor r=45 c=0
mn20 (\16\:CKb \3\:CK \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\5\:SEb \7\:SE \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.045e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16069e-06 sb=2.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net399 \4\:D \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=9.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75673e-07 sb=8.70673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.60673e-07 sb=5.85673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65673e-07 sb=3.80673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net411 \1\:SI \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70673e-07 sb=2.75673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.7e-14 ad=4.81e-14 ps=9e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.74721e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mn50 (net391 \17\:qbint \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.51e-14 ad=3.28e-14 ps=8.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63317e-06 sb=1.94e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\7\:n30 \3\:CKb net391 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.92e-14 ps=7.3e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83817e-06 sb=1.735e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:mout \3\:CKbb \7\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=8.2e-14 ps=8.9e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.45e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=8.2e-14 ps=1.32e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net378 \4\:mout \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.358e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.4e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=4.51e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.8e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:n20 \11\:CKb \8\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.51e-14 ps=1.04e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn45_1__rcx (\23\:qbint n30 \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.273e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16317e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mp11 (net342 \1\:D \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.14359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp12 (\4\:Db \2\:SE net342 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.09359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp14 (\4\:Db SEb net350 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.84359e-07 sd=160n sca=15.6414 \
        scb=0.0138242 scc=0.000948215 m=(1)
mp13 (net350 \3\:SI \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=5.655e-14 ps=1.25e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55064e-07 sb=2.94359e-07 sd=160n sca=16.7327 \
        scb=0.0148635 scc=0.000950884 m=(1)
mp55_1__rcx (Q qbint \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=6.24e-14 ps=1.605e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.40577e-07 sb=1.76308e-06 sd=160n sca=18.6093 \
        scb=0.0174808 scc=0.00104939 m=(4)
mp50 (net334 \14\:qbint \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.76e-14 ad=3.875e-14 ps=1.55e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68685e-06 sb=1.78685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\11\:n30 CKbb net334 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85685e-06 sb=1.61685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\11\:n30 \4\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.5965e-13 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.41185e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\9\:mout n20 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=1.5965e-13 ps=1.45e-06 pd=1.65e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.51855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (net319 mout \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.86855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=5.58e-14 ps=9.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.96855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp25 (\6\:Db \7\:CKbb \4\:n20 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=5.328e-14 ps=9.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.71855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp45 (\18\:qbint n30 \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.96e-14 ad=4.96e-14 ps=1.55e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21685e-06 sb=2e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(2)
ends SDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:27 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFHQX8 CK D Q SE SI VDD VSS
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.271e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.92213e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D VSS) capacitor c=6.49673e-17
C2 (VDD VSS) capacitor c=3.08551e-16
C3 (CK VSS) capacitor c=7.54957e-17
C4 (SE VSS) capacitor c=4.48209e-17
C5 (Q VSS) capacitor c=4.96042e-16
C6 (SI VSS) capacitor c=5.27971e-17
C7 (qbint VSS) capacitor c=3.78492e-16
C8 (n30 VSS) capacitor c=2.08232e-16
C9 (CKb VSS) capacitor c=4.87722e-17
C10 (net391 VSS) capacitor c=2.75049e-18
C11 (mout VSS) capacitor c=6.59019e-17
C12 (CKbb VSS) capacitor c=2.58852e-17
C13 (n20 VSS) capacitor c=3.8911e-17
C14 (net378 VSS) capacitor c=1.12961e-18
C15 (Db VSS) capacitor c=9.71518e-17
C16 (net399 VSS) capacitor c=5.74422e-18
C17 (SEb VSS) capacitor c=3.48579e-17
C18 (net334 VSS) capacitor c=3.48222e-18
C19 (net319 VSS) capacitor c=3.30937e-18
C20 (net342 VSS) capacitor c=1.73603e-18
C21 (net350 VSS) capacitor c=7.01633e-18
C22 (\8\:SE VSS) capacitor c=4.99456e-17
C23 (\1\:SI VSS) capacitor c=5.11973e-17
C24 (\2\:SE VSS) capacitor c=7.24278e-17
C25 (\4\:D VSS) capacitor c=9.27815e-17
C26 (\10\:CKb VSS) capacitor c=6.61966e-17
C27 (\7\:CKbb VSS) capacitor c=3.86159e-17
C28 (\8\:CKb VSS) capacitor c=4.00274e-17
C29 (\3\:CKb VSS) capacitor c=2.37466e-17
C30 (\3\:CKbb VSS) capacitor c=6.58069e-17
C31 (\22\:qbint VSS) capacitor c=4.91411e-17
C32 (\1\:CK VSS) capacitor c=3.51269e-17
C33 (\7\:SE VSS) capacitor c=3.12974e-17
C34 (\3\:SI VSS) capacitor c=8.00885e-17
C35 (\3\:SE VSS) capacitor c=7.07879e-17
C36 (\3\:SEb VSS) capacitor c=6.82559e-17
C37 (\1\:D VSS) capacitor c=4.71662e-17
C38 (\5\:CKb VSS) capacitor c=2.71449e-17
C39 (\11\:CKb VSS) capacitor c=2.61405e-17
C40 (\5\:CKbb VSS) capacitor c=6.05531e-17
C41 (\4\:mout VSS) capacitor c=5.80067e-17
C42 (\3\:n20 VSS) capacitor c=4.56406e-17
C43 (\24\:qbint VSS) capacitor c=5.98316e-17
C44 (\3\:CK VSS) capacitor c=3.19822e-17
C45 (\5\:SE VSS) capacitor c=1.77018e-17
C46 (\2\:SI VSS) capacitor c=4.72738e-17
C47 (\4\:SE VSS) capacitor c=4.39177e-17
C48 (\2\:SEb VSS) capacitor c=5.08214e-17
C49 (\1\:SE VSS) capacitor c=5.66692e-17
C50 (\3\:D VSS) capacitor c=2.92488e-17
C51 (\8\:CKbb VSS) capacitor c=4.18371e-17
C52 (\9\:CKb VSS) capacitor c=2.73771e-17
C53 (\6\:CKbb VSS) capacitor c=4.00656e-17
C54 (\3\:mout VSS) capacitor c=1.75549e-17
C55 (\2\:n20 VSS) capacitor c=3.53188e-17
C56 (\4\:CKbb VSS) capacitor c=2.5985e-17
C57 (\4\:CKb VSS) capacitor c=3.72989e-17
C58 (\2\:CKb VSS) capacitor c=3.89957e-17
C59 (\23\:qbint VSS) capacitor c=4.71774e-17
C60 (\2\:CK VSS) capacitor c=3.18424e-17
C61 (\6\:SEb VSS) capacitor c=1.12556e-16
C62 (\1\:VDD VSS) capacitor c=4.57902e-17
C63 (\8\:Db VSS) capacitor c=5.02821e-17
C64 (\15\:VDD VSS) capacitor c=4.16571e-17
C65 (\15\:CKbb VSS) capacitor c=8.11758e-17
C66 (\4\:Db VSS) capacitor c=1.1283e-16
C67 (\4\:n20 VSS) capacitor c=6.06044e-17
C68 (\17\:VDD VSS) capacitor c=3.50802e-17
C69 (\9\:mout VSS) capacitor c=5.79217e-17
C70 (\14\:n30 VSS) capacitor c=1.09092e-16
C71 (\19\:VDD VSS) capacitor c=1.03065e-17
C72 (\18\:CKb VSS) capacitor c=1.03595e-16
C73 (\26\:qbint VSS) capacitor c=3.77231e-16
C74 (\3\:VDD VSS) capacitor c=5.41478e-17
C75 (\4\:SEb VSS) capacitor c=8.99586e-17
C76 (\9\:CKbb VSS) capacitor c=6.43422e-17
C77 (\6\:Db VSS) capacitor c=7.70912e-17
C78 (\8\:n20 VSS) capacitor c=7.06562e-17
C79 (\7\:mout VSS) capacitor c=5.25937e-17
C80 (\12\:n30 VSS) capacitor c=2.07422e-16
C81 (\15\:CKb VSS) capacitor c=1.54769e-16
C82 (\2\:CKbb VSS) capacitor c=4.85884e-17
C83 (\2\:mout VSS) capacitor c=3.64409e-17
C84 (\6\:CKb VSS) capacitor c=6.51288e-17
C85 (\7\:CKb VSS) capacitor c=6.62711e-17
C86 (\2\:D VSS) capacitor c=4.63008e-17
C87 (\6\:SE VSS) capacitor c=2.50368e-17
C88 (\4\:CK VSS) capacitor c=3.80795e-17
C89 (\25\:qbint VSS) capacitor c=1.19782e-16
C90 (\31\:qbint VSS) capacitor c=3.04795e-17
C91 (\11\:n30 VSS) capacitor c=1.53987e-16
C92 (\5\:mout VSS) capacitor c=5.11922e-17
C93 (\6\:mout VSS) capacitor c=5.58036e-17
C94 (\12\:CKb VSS) capacitor c=5.31736e-17
C95 (\13\:CKb VSS) capacitor c=1.31064e-16
C96 (\14\:CKb VSS) capacitor c=1.5935e-16
C97 (\17\:CKb VSS) capacitor c=1.01771e-16
C98 (\6\:n20 VSS) capacitor c=7.47254e-17
C99 (\7\:n20 VSS) capacitor c=7.5359e-17
C100 (\11\:CKbb VSS) capacitor c=9.10933e-17
C101 (\12\:CKbb VSS) capacitor c=1.11671e-16
C102 (\13\:CKbb VSS) capacitor c=1.18485e-16
C103 (\14\:CKbb VSS) capacitor c=1.31394e-16
C104 (\17\:CKbb VSS) capacitor c=6.48844e-17
C105 (\5\:D VSS) capacitor c=4.66662e-17
C106 (\3\:Db VSS) capacitor c=1.17995e-16
C107 (\4\:SI VSS) capacitor c=7.88451e-17
C108 (\9\:SE VSS) capacitor c=6.47639e-17
C109 (\10\:SE VSS) capacitor c=8.12759e-17
C110 (\11\:SE VSS) capacitor c=3.03286e-17
C111 (\8\:SEb VSS) capacitor c=8.57459e-17
C112 (\5\:VDD VSS) capacitor c=4.00316e-17
C113 (\6\:VDD VSS) capacitor c=3.19021e-17
C114 (\8\:VDD VSS) capacitor c=2.805e-17
C115 (\9\:VDD VSS) capacitor c=5.12572e-16
Rk42 (\5\:D D) resistor r=0.05403 c=0
Rk73 (\2\:VSS \4\:VSS) resistor r=0.4882 c=0
Rk74 (\4\:VSS \5\:VSS) resistor r=0.1829 c=0
Rk75 (\5\:VSS \6\:VSS) resistor r=0.6107 c=0
Rk76 (\6\:VSS \7\:VSS) resistor r=0.2572 c=0
Rk77 (\7\:VSS \8\:VSS) resistor r=0.3726 c=0
Rk84 (\9\:VSS VSS) resistor r=0.1024 c=0
Rk78 (\8\:VSS \9\:VSS) resistor r=0.4552 c=0
Rk85 (\5\:VSS \16\:VSS) resistor r=0.2341 c=0
Rk86 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk87 (\8\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.4189 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.218 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5916 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.2431 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.3209 c=0
Rk64 (\9\:VDD VDD) resistor r=0.1024 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.4937 c=0
Rk65 (\5\:VDD \16\:VDD) resistor r=0.2268 c=0
Rk66 (\6\:VDD \18\:VDD) resistor r=0.2199 c=0
Rk67 (\8\:VDD \20\:VDD) resistor r=0.07405 c=0
Rk14 (\4\:CK CK) resistor r=0.1318 c=0
Rk49 (\10\:SE SE) resistor r=0.3407 c=0
Rk48 (\9\:SE \10\:SE) resistor r=0.3756 c=0
Rk50 (SE \11\:SE) resistor r=0.03909 c=0
Rk47 (\4\:SI SI) resistor r=0.0251 c=0
Rk15 (\25\:qbint \26\:qbint) resistor r=0.8718 c=0
Rk19 (\26\:qbint \31\:qbint) resistor r=0.1663 c=0
Rk23 (\11\:n30 \13\:n30) resistor r=1.2398 c=0
Rk24 (\13\:n30 \15\:n30) resistor r=0.4642 c=0
Rk28 (\12\:CKb \13\:CKb) resistor r=0.2504 c=0
Rk29 (\13\:CKb \14\:CKb) resistor r=0.687 c=0
Rk30 (\14\:CKb \16\:CKb) resistor r=0.637 c=0
Rk31 (\13\:CKb \17\:CKb) resistor r=0.7147 c=0
Rk32 (\16\:CKb \19\:CKb) resistor r=0.5734 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2281 c=0
Rk26 (\6\:mout \8\:mout) resistor r=0.193 c=0
Rk27 (\6\:mout \10\:mout) resistor r=0.2421 c=0
Rk36 (\10\:CKbb \11\:CKbb) resistor r=0.3958 c=0
Rk37 (\11\:CKbb \12\:CKbb) resistor r=0.2849 c=0
Rk38 (\12\:CKbb \13\:CKbb) resistor r=0.8474 c=0
Rk39 (\11\:CKbb \14\:CKbb) resistor r=0.3429 c=0
Rk40 (\14\:CKbb \16\:CKbb) resistor r=0.6275 c=0
Rk41 (\12\:CKbb \17\:CKbb) resistor r=0.2249 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.1647 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3859 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.3046 c=0
Rk43 (\2\:Db \3\:Db) resistor r=0.6476 c=0
Rk44 (\3\:Db \5\:Db) resistor r=0.4237 c=0
Rk45 (\5\:Db \7\:Db) resistor r=0.4045 c=0
Rk46 (\3\:Db \9\:Db) resistor r=0.2015 c=0
Rk51 (\5\:SEb \7\:SEb) resistor r=0.7143 c=0
Rk52 (\7\:SEb \8\:SEb) resistor r=0.5705 c=0
Rl54 (\2\:D \4\:D) resistor r=58.495 c=0
Rl52 (\1\:D \2\:D) resistor r=109.984 c=0
Rl53 (\2\:D \3\:D) resistor r=9.6183 c=0
Rl30 (\1\:CK \2\:CK) resistor r=96.1538 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl58 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl55 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl63 (\6\:SE \8\:SE) resistor r=121.957 c=0
Rl62 (\6\:SE \7\:SE) resistor r=46.9565 c=0
Rl61 (\5\:SE \6\:SE) resistor r=13.569 c=0
Rl59 (\1\:SI \2\:SI) resistor r=55.0021 c=0
Rl60 (\2\:SI \3\:SI) resistor r=85.7713 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=65.3618 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=80.5643 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=193.478 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=61.5164 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=41.9892 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=185.006 c=0
Rl41 (mout \2\:mout) resistor r=102.726 c=0
Rl43 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl42 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=37.2302 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=138.005 c=0
Rl36 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=92.233 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=94.9225 c=0
Rl56 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl57 (\2\:SEb \3\:SEb) resistor r=121.943 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz16 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\7\:mout \8\:mout) resistor r=75 c=0
Rz11 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\6\:Db \7\:Db) resistor r=75 c=0
Rz14 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=31 c=0
Ry14 (\6\:SEb \7\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\1\:SE \9\:SE) resistor r=45 c=0
Rx16 (\4\:SE \10\:SE) resistor r=45 c=0
Rx17 (\5\:SE \11\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\31\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn11 (net399 \1\:D \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.94e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=7.98365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.06058e-07 sb=5.63365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.11058e-07 sb=3.58365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net411 \3\:SI \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16058e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn45_1__rcx (\26\:qbint n30 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn21 (\9\:CKbb \5\:CKb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10759e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11448e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (net391 \24\:qbint \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.95e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\12\:n30 CKb net391 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=3.895e-14 ps=6.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.79e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\7\:mout CKbb \12\:n30 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.895e-14 ad=1.1377e-13 ps=7.9e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3378e-07 sb=1.555e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.63e-14 ad=1.1377e-13 ps=1.37e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43378e-06 sb=9.55e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (net378 \4\:mout \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.23e-14 ps=1.37e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69878e-06 sb=6.9e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.612e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80378e-06 sb=5.85e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\8\:n20 \11\:CKb \6\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94293e-06 sb=3.15e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mp11 (net342 \4\:D \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\8\:Db \2\:SE net342 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\8\:Db SEb net350 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=13.6902 \
        scb=0.0122097 scc=0.000647516 m=(1)
mp13 (net350 \1\:SI \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=14.7912 \
        scb=0.012924 scc=0.00064842 m=(1)
mp45_1__rcx (\26\:qbint n30 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.887e-14 ad=5.98e-14 ps=1.15667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.01e-14 ps=1.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99814e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp21 (\15\:CKbb \10\:CKb \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp10 (\6\:SEb \8\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=20.6301 \
        scb=0.0216347 scc=0.00118997 m=(1)
mp50 (net334 \22\:qbint \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.204e-13 ad=3.1e-14 ps=1.93e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67661e-07 sb=1.75185e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp51 (\14\:n30 \3\:CKbb net334 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.12661e-07 sb=1.60685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp40 (\14\:n30 \3\:CKb \9\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.82661e-07 sb=1.33685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp30 (\9\:mout n20 \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25766e-06 sb=8.61855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp35 (net319 mout \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.805e-14 ps=1.38e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52266e-06 sb=5.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72266e-06 sb=3.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\4\:Db \7\:CKbb \4\:n20 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=5.328e-14 ps=9.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=1.71855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
ends SDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:28 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFNSRX1
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX1 CKN D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:qint \30\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
mp55 (\1\:Q \5\:qbint \27\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=5.46e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.01218e-07 sd=160n sca=12.7076 \
        scb=0.0112318 scc=0.000478212 m=(1)
C1 (SE VSS) capacitor c=4.19628e-17
C2 (SN VSS) capacitor c=2.95378e-16
C3 (SI VSS) capacitor c=7.37479e-17
C4 (QN VSS) capacitor c=2.29645e-17
C5 (VDD VSS) capacitor c=5.37872e-16
C6 (RN VSS) capacitor c=9.0983e-17
C7 (D VSS) capacitor c=1.41783e-16
C8 (Q VSS) capacitor c=6.65284e-17
C9 (qint VSS) capacitor c=2.0377e-17
C10 (qbint VSS) capacitor c=2.92086e-17
C11 (RNb VSS) capacitor c=7.56315e-17
C12 (n35 VSS) capacitor c=4.01964e-17
C13 (net498 VSS) capacitor c=9.06534e-17
C14 (net0363 VSS) capacitor c=7.30516e-17
C15 (CKNbb VSS) capacitor c=4.68903e-17
C16 (mout VSS) capacitor c=6.63689e-17
C17 (CKNb VSS) capacitor c=2.7227e-17
C18 (net521 VSS) capacitor c=7.87951e-17
C19 (n20 VSS) capacitor c=5.52088e-17
C20 (Db VSS) capacitor c=1.18954e-16
C21 (SEb VSS) capacitor c=6.11984e-17
C22 (net566 VSS) capacitor c=1.15171e-16
C23 (net414 VSS) capacitor c=1.07971e-18
C24 (net478 VSS) capacitor c=3.56466e-18
C25 (net486 VSS) capacitor c=6.62353e-19
C26 (net461 VSS) capacitor c=1.96861e-18
C27 (net453 VSS) capacitor c=1.92664e-18
C28 (\4\:SE VSS) capacitor c=5.89487e-17
C29 (\3\:SI VSS) capacitor c=7.81982e-17
C30 (\3\:SEb VSS) capacitor c=6.04665e-17
C31 (\3\:SE VSS) capacitor c=7.3531e-17
C32 (\1\:D VSS) capacitor c=3.61837e-17
C33 (\1\:CKN VSS) capacitor c=5.45375e-17
C34 (\8\:CKNb VSS) capacitor c=1.72565e-17
C35 (\9\:CKNb VSS) capacitor c=2.87462e-17
C36 (\6\:CKNbb VSS) capacitor c=6.07165e-17
C37 (\4\:SN VSS) capacitor c=5.84399e-17
C38 (\4\:RNb VSS) capacitor c=6.30609e-17
C39 (\4\:CKNbb VSS) capacitor c=3.59257e-17
C40 (\7\:CKNb VSS) capacitor c=6.08488e-17
C41 (\2\:RNb VSS) capacitor c=7.83253e-17
C42 (\7\:qbint VSS) capacitor c=9.59559e-17
C43 (\1\:SN VSS) capacitor c=3.40714e-17
C44 (\1\:RN VSS) capacitor c=4.09632e-17
C45 (\5\:qbint VSS) capacitor c=4.87568e-17
C46 (\6\:qbint VSS) capacitor c=2.94457e-17
C47 (\4\:qint VSS) capacitor c=4.49963e-17
C48 (\6\:SE VSS) capacitor c=3.46009e-17
C49 (\1\:SI VSS) capacitor c=6.49902e-17
C50 (\1\:SE VSS) capacitor c=3.65266e-17
C51 (\3\:D VSS) capacitor c=9.15627e-17
C52 (\3\:CKN VSS) capacitor c=3.86549e-17
C53 (\8\:CKNbb VSS) capacitor c=5.23156e-17
C54 (\5\:CKNb VSS) capacitor c=1.70034e-16
C55 (\4\:mout VSS) capacitor c=5.30338e-17
C56 (\6\:SN VSS) capacitor c=6.27416e-17
C57 (\3\:n20 VSS) capacitor c=3.82136e-17
C58 (\6\:RNb VSS) capacitor c=5.20989e-17
C59 (\6\:CKNb VSS) capacitor c=1.2463e-16
C60 (\8\:qbint VSS) capacitor c=5.71271e-17
C61 (\3\:SN VSS) capacitor c=5.97005e-17
C62 (\3\:n35 VSS) capacitor c=2.84445e-17
C63 (\3\:RN VSS) capacitor c=4.71581e-17
C64 (\4\:qbint VSS) capacitor c=2.69855e-17
C65 (\3\:qint VSS) capacitor c=3.49122e-17
C66 (\5\:SE VSS) capacitor c=6.03134e-17
C67 (\2\:SI VSS) capacitor c=7.09533e-17
C68 (\2\:SE VSS) capacitor c=7.54309e-17
C69 (\4\:SEb VSS) capacitor c=4.48104e-17
C70 (\2\:SEb VSS) capacitor c=4.72432e-17
C71 (\2\:D VSS) capacitor c=6.12359e-17
C72 (\2\:CKN VSS) capacitor c=4.1341e-17
C73 (\9\:CKNbb VSS) capacitor c=3.42418e-17
C74 (\7\:CKNbb VSS) capacitor c=4.15704e-17
C75 (\3\:mout VSS) capacitor c=2.49659e-17
C76 (\5\:SN VSS) capacitor c=3.56268e-17
C77 (\2\:n20 VSS) capacitor c=3.71833e-17
C78 (\5\:CKNbb VSS) capacitor c=3.26245e-17
C79 (\5\:RNb VSS) capacitor c=1.96892e-17
C80 (\3\:CKNbb VSS) capacitor c=3.41315e-17
C81 (\2\:CKNbb VSS) capacitor c=3.21101e-17
C82 (\3\:RNb VSS) capacitor c=2.72493e-17
C83 (\9\:qbint VSS) capacitor c=2.79955e-17
C84 (\2\:SN VSS) capacitor c=4.30064e-17
C85 (\2\:n35 VSS) capacitor c=2.9378e-17
C86 (\2\:RN VSS) capacitor c=3.90621e-17
C87 (\2\:qbint VSS) capacitor c=3.78229e-17
C88 (\5\:SEb VSS) capacitor c=6.61132e-18
C89 (\13\:VDD VSS) capacitor c=3.54407e-17
C90 (\15\:VDD VSS) capacitor c=4.79952e-17
C91 (\10\:CKNb VSS) capacitor c=7.43328e-17
C92 (\17\:VDD VSS) capacitor c=7.07081e-17
C93 (\17\:CKNbb VSS) capacitor c=8.79104e-17
C94 (\8\:Db VSS) capacitor c=1.00863e-16
C95 (\4\:n20 VSS) capacitor c=7.83963e-17
C96 (\19\:VDD VSS) capacitor c=1.57701e-17
C97 (\11\:mout VSS) capacitor c=3.89186e-17
C98 (\21\:VDD VSS) capacitor c=2.39828e-17
C99 (\9\:mout VSS) capacitor c=8.11302e-17
C100 (\8\:n35 VSS) capacitor c=4.33188e-17
C101 (\23\:VDD VSS) capacitor c=3.8664e-17
C102 (\3\:net566 VSS) capacitor c=1.16554e-16
C103 (\25\:VDD VSS) capacitor c=6.80581e-17
C104 (\14\:qbint VSS) capacitor c=8.15971e-17
C105 (\9\:RNb VSS) capacitor c=1.93784e-16
C106 (\27\:VDD VSS) capacitor c=3.67913e-17
C107 (\1\:Q VSS) capacitor c=4.46882e-17
C108 (\5\:qint VSS) capacitor c=3.56605e-17
C109 (\30\:VDD VSS) capacitor c=5.79745e-17
C110 (\1\:QN VSS) capacitor c=4.79312e-17
C111 (\1\:VDD VSS) capacitor c=8.84738e-17
C112 (\10\:SEb VSS) capacitor c=7.52923e-17
C113 (\6\:Db VSS) capacitor c=2.01113e-17
C114 (\14\:CKNb VSS) capacitor c=4.69219e-17
C115 (\19\:CKNbb VSS) capacitor c=5.7099e-17
C116 (\4\:Db VSS) capacitor c=1.72644e-16
C117 (\7\:n20 VSS) capacitor c=3.66419e-17
C118 (\13\:mout VSS) capacitor c=3.5846e-17
C119 (\3\:net521 VSS) capacitor c=7.16512e-17
C120 (\15\:mout VSS) capacitor c=3.07998e-17
C121 (\4\:n35 VSS) capacitor c=4.075e-17
C122 (\3\:net498 VSS) capacitor c=8.09537e-17
C123 (\3\:net0363 VSS) capacitor c=9.22664e-17
C124 (\11\:qbint VSS) capacitor c=1.52881e-16
C125 (\11\:RNb VSS) capacitor c=9.25158e-17
C126 (\3\:Q VSS) capacitor c=6.87228e-17
C127 (\9\:qint VSS) capacitor c=3.27183e-17
C128 (\3\:QN VSS) capacitor c=3.64168e-17
C129 (\2\:qint VSS) capacitor c=8.29322e-18
C130 (\3\:qbint VSS) capacitor c=3.12911e-17
C131 (\2\:mout VSS) capacitor c=3.76339e-17
C132 (\7\:qint VSS) capacitor c=2.83642e-17
C133 (\8\:qint VSS) capacitor c=2.88464e-17
C134 (\3\:CKNb VSS) capacitor c=2.6036e-17
C135 (\4\:CKNb VSS) capacitor c=6.39705e-17
C136 (\4\:RN VSS) capacitor c=3.87454e-17
C137 (\10\:qbint VSS) capacitor c=7.2917e-17
C138 (\13\:qbint VSS) capacitor c=1.19945e-16
C139 (\6\:n35 VSS) capacitor c=1.70121e-16
C140 (\7\:n35 VSS) capacitor c=1.58674e-16
C141 (\10\:CKNbb VSS) capacitor c=6.89976e-17
C142 (\11\:CKNbb VSS) capacitor c=1.16849e-16
C143 (\7\:RNb VSS) capacitor c=1.37525e-16
C144 (\8\:RNb VSS) capacitor c=3.08792e-16
C145 (\7\:SN VSS) capacitor c=2.62394e-16
C146 (\8\:SN VSS) capacitor c=3.71588e-17
C147 (\5\:mout VSS) capacitor c=4.40426e-17
C148 (\6\:mout VSS) capacitor c=6.22962e-17
C149 (\7\:mout VSS) capacitor c=5.09799e-17
C150 (\8\:mout VSS) capacitor c=5.87382e-17
C151 (\6\:n20 VSS) capacitor c=8.95238e-17
C152 (\9\:n20 VSS) capacitor c=1.01011e-16
C153 (\12\:CKNbb VSS) capacitor c=4.58169e-17
C154 (\13\:CKNbb VSS) capacitor c=1.25533e-16
C155 (\14\:CKNbb VSS) capacitor c=1.49087e-16
C156 (\15\:CKNbb VSS) capacitor c=9.83533e-17
C157 (\16\:CKNbb VSS) capacitor c=9.38172e-17
C158 (\12\:CKNb VSS) capacitor c=6.13384e-17
C159 (\13\:CKNb VSS) capacitor c=3.32995e-17
C160 (\4\:CKN VSS) capacitor c=3.87906e-17
C161 (\6\:CKN VSS) capacitor c=7.83773e-17
C162 (\3\:Db VSS) capacitor c=2.16286e-16
C163 (\7\:SE VSS) capacitor c=3.49437e-17
C164 (\8\:SE VSS) capacitor c=2.69753e-17
C165 (\5\:SI VSS) capacitor c=7.18995e-17
C166 (\7\:SEb VSS) capacitor c=1.08585e-16
C167 (\8\:SEb VSS) capacitor c=1.20851e-16
C168 (\9\:SEb VSS) capacitor c=1.47912e-16
C169 (\12\:SEb VSS) capacitor c=4.11729e-17
C170 (\3\:VDD VSS) capacitor c=2.30328e-17
C171 (\4\:VDD VSS) capacitor c=3.18662e-17
C172 (\6\:VDD VSS) capacitor c=3.08383e-17
C173 (\7\:VDD VSS) capacitor c=5.07725e-17
C174 (\8\:VDD VSS) capacitor c=2.32256e-17
C175 (\10\:VDD VSS) capacitor c=3.86476e-17
C176 (\11\:VDD VSS) capacitor c=3.38959e-17
C177 (\29\:VDD VSS) capacitor c=1.9326e-17
Rk44 (\4\:CKN \5\:CKN) resistor r=0.002026 c=0
Rk45 (CKN \6\:CKN) resistor r=0.001959 c=0
Rk46 (\4\:CKN \6\:CKN) resistor r=0.0678 c=0
Rk62 (\2\:VSS \3\:VSS) resistor r=0.08511 c=0
Rk63 (\3\:VSS \4\:VSS) resistor r=0.4136 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.2532 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.1419 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.5356 c=0
Rk67 (\7\:VSS \8\:VSS) resistor r=0.5242 c=0
Rk68 (\8\:VSS \9\:VSS) resistor r=0.8102 c=0
Rk69 (\9\:VSS \10\:VSS) resistor r=0.3937 c=0
Rk70 (\3\:VSS \12\:VSS) resistor r=0.238 c=0
Rk71 (\4\:VSS \14\:VSS) resistor r=0.2336 c=0
Rk72 (\6\:VSS \16\:VSS) resistor r=0.04334 c=0
Rk73 (\7\:VSS \18\:VSS) resistor r=0.3181 c=0
Rk74 (\9\:VSS \20\:VSS) resistor r=0.07428 c=0
Rk76 (\21\:VSS VSS) resistor r=0.2003 c=0
Rk75 (\10\:VSS \21\:VSS) resistor r=0.3516 c=0
Rk77 (\10\:VSS \23\:VSS) resistor r=0.4344 c=0
Rk78 (\21\:VSS \25\:VSS) resistor r=0.3721 c=0
Rk52 (\7\:SE SE) resistor r=0.09481 c=0
Rk53 (SE \8\:SE) resistor r=0.1194 c=0
Rk23 (\7\:SN SN) resistor r=2.0205 c=0
Rk24 (SN \8\:SN) resistor r=0.07777 c=0
Rk54 (\4\:SI \5\:SI) resistor r=0.004909 c=0
Rk55 (\6\:SI SI) resistor r=0.005032 c=0
Rk56 (\5\:SI \6\:SI) resistor r=0.03605 c=0
Rk2 (\4\:QN QN) resistor r=0.09293 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3065 c=0
Rk79 (\2\:VDD \3\:VDD) resistor r=0.09264 c=0
Rk80 (\3\:VDD \4\:VDD) resistor r=0.4236 c=0
Rk81 (\4\:VDD \5\:VDD) resistor r=0.2357 c=0
Rk82 (\5\:VDD \6\:VDD) resistor r=0.07257 c=0
Rk83 (\6\:VDD \7\:VDD) resistor r=0.6068 c=0
Rk84 (\7\:VDD \8\:VDD) resistor r=0.4578 c=0
Rk85 (\8\:VDD \9\:VDD) resistor r=0.06409 c=0
Rk86 (\9\:VDD \10\:VDD) resistor r=0.4163 c=0
Rk87 (\10\:VDD \11\:VDD) resistor r=0.3785 c=0
Rk88 (\11\:VDD \12\:VDD) resistor r=0.4088 c=0
Rk89 (\3\:VDD \14\:VDD) resistor r=0.2004 c=0
Rk90 (\4\:VDD \16\:VDD) resistor r=0.2615 c=0
Rk91 (\6\:VDD \18\:VDD) resistor r=0.4646 c=0
Rk92 (\7\:VDD \20\:VDD) resistor r=0.1031 c=0
Rk93 (\8\:VDD \22\:VDD) resistor r=0.04334 c=0
Rk94 (\10\:VDD \24\:VDD) resistor r=0.1467 c=0
Rk95 (\11\:VDD \26\:VDD) resistor r=0.3354 c=0
Rk96 (\12\:VDD \28\:VDD) resistor r=0.2629 c=0
Rk99 (\29\:VDD VDD) resistor r=0.2003 c=0
Rk97 (\12\:VDD \29\:VDD) resistor r=0.3517 c=0
Rk98 (\29\:VDD \31\:VDD) resistor r=0.4374 c=0
Rk8 (\4\:RN RN) resistor r=0.06442 c=0
Rk47 (\4\:D D) resistor r=0.003698 c=0
Rk6 (\2\:Q Q) resistor r=0.1666 c=0
Rk7 (Q \4\:Q) resistor r=0.3594 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.115 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1197 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.109 c=0
Rk9 (\10\:qbint \12\:qbint) resistor r=0.5127 c=0
Rk10 (\12\:qbint \13\:qbint) resistor r=0.8441 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.521 c=0
Rk19 (\7\:RNb \8\:RNb) resistor r=1.0744 c=0
Rk20 (\8\:RNb \10\:RNb) resistor r=1.1727 c=0
Rk21 (\10\:RNb \12\:RNb) resistor r=0.4929 c=0
Rk15 (\5\:n35 \6\:n35) resistor r=0.1601 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=1.1429 c=0
Rk17 (\6\:n35 \9\:n35) resistor r=0.1633 c=0
Rk12 (\2\:net498 \4\:net498) resistor r=0.566 c=0
Rk14 (\2\:net0363 \4\:net0363) resistor r=0.362 c=0
Rk18 (\10\:CKNbb \11\:CKNbb) resistor r=0.6298 c=0
Rk35 (\12\:CKNbb \13\:CKNbb) resistor r=0.2124 c=0
Rk36 (\13\:CKNbb \14\:CKNbb) resistor r=0.9087 c=0
Rk37 (\13\:CKNbb \15\:CKNbb) resistor r=0.3464 c=0
Rk38 (\15\:CKNbb \16\:CKNbb) resistor r=0.4627 c=0
Rk39 (\15\:CKNbb \18\:CKNbb) resistor r=0.5214 c=0
Rk40 (\18\:CKNbb \20\:CKNbb) resistor r=0.2704 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2305 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.3334 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3185 c=0
Rk28 (\8\:mout \10\:mout) resistor r=0.3831 c=0
Rk29 (\6\:mout \12\:mout) resistor r=0.09453 c=0
Rk30 (\7\:mout \14\:mout) resistor r=0.1023 c=0
Rk31 (\8\:mout \16\:mout) resistor r=0.05885 c=0
Rk41 (\11\:CKNb \12\:CKNb) resistor r=0.5232 c=0
Rk42 (\12\:CKNb \13\:CKNb) resistor r=0.1508 c=0
Rk43 (\12\:CKNb \15\:CKNb) resistor r=0.1836 c=0
Rk22 (\2\:net521 \4\:net521) resistor r=0.4977 c=0
Rk32 (\5\:n20 \6\:n20) resistor r=0.3353 c=0
Rk33 (\6\:n20 \8\:n20) resistor r=0.1457 c=0
Rk34 (\6\:n20 \9\:n20) resistor r=0.5442 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.52 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.3689 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.07507 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.6202 c=0
Rk57 (\6\:SEb \7\:SEb) resistor r=0.02809 c=0
Rk58 (\7\:SEb \8\:SEb) resistor r=0.3525 c=0
Rk59 (\8\:SEb \9\:SEb) resistor r=0.8647 c=0
Rk60 (\7\:SEb \11\:SEb) resistor r=0.6988 c=0
Rk61 (\8\:SEb \12\:SEb) resistor r=0.1307 c=0
Rk13 (\2\:net566 \4\:net566) resistor r=0.3956 c=0
Rl41 (\1\:CKN \2\:CKN) resistor r=151.923 c=0
Rl42 (\2\:CKN \3\:CKN) resistor r=53.2967 c=0
Rl51 (\4\:SE \5\:SE) resistor r=193.812 c=0
Rl52 (\5\:SE \6\:SE) resistor r=67.9995 c=0
Rl48 (\2\:SE \3\:SE) resistor r=254.568 c=0
Rl47 (\1\:SE \2\:SE) resistor r=74.2328 c=0
Rl27 (\4\:SN \6\:SN) resistor r=157.692 c=0
Rl26 (\4\:SN \5\:SN) resistor r=59.5926 c=0
Rl13 (\1\:SN \2\:SN) resistor r=62.2302 c=0
Rl14 (\2\:SN \3\:SN) resistor r=112.23 c=0
Rl50 (\2\:SI \3\:SI) resistor r=99.2818 c=0
Rl49 (\1\:SI \2\:SI) resistor r=141.668 c=0
Rl9 (\1\:RN \2\:RN) resistor r=96.8456 c=0
Rl10 (\2\:RN \3\:RN) resistor r=89.1533 c=0
Rl43 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl44 (\2\:D \3\:D) resistor r=212.694 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl15 (\7\:qbint \8\:qbint) resistor r=200 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=46.2406 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=89.9037 c=0
Rl4 (qbint \2\:qbint) resistor r=26.1559 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=39.6181 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=49.2335 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=161.953 c=0
Rl23 (\4\:RNb \6\:RNb) resistor r=157.692 c=0
Rl17 (RNb \2\:RNb) resistor r=264.95 c=0
Rl22 (\4\:RNb \5\:RNb) resistor r=99.5131 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl11 (n35 \2\:n35) resistor r=119.922 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=39.1533 c=0
Rl32 (\8\:CKNbb \9\:CKNbb) resistor r=49.5519 c=0
Rl31 (\6\:CKNbb \7\:CKNbb) resistor r=24.2328 c=0
Rl20 (\3\:CKNbb \4\:CKNbb) resistor r=53.3592 c=0
Rl21 (\3\:CKNbb \5\:CKNbb) resistor r=97.5374 c=0
Rl19 (CKNbb \2\:CKNbb) resistor r=93.4636 c=0
Rl28 (mout \2\:mout) resistor r=60.4181 c=0
Rl30 (\2\:mout \4\:mout) resistor r=110.418 c=0
Rl29 (\2\:mout \3\:mout) resistor r=7.6446 c=0
Rl38 (\6\:CKNb \7\:CKNb) resistor r=147.208 c=0
Rl37 (\5\:CKNb \6\:CKNb) resistor r=747.643 c=0
Rl33 (CKNb \2\:CKNb) resistor r=30.5643 c=0
Rl39 (\3\:CKNb \8\:CKNb) resistor r=26.0821 c=0
Rl34 (\2\:CKNb \3\:CKNb) resistor r=9.6894 c=0
Rl40 (\4\:CKNb \9\:CKNb) resistor r=57.3738 c=0
Rl36 (\4\:CKNb \5\:CKNb) resistor r=221.132 c=0
Rl35 (\3\:CKNb \4\:CKNb) resistor r=157.767 c=0
Rl24 (n20 \2\:n20) resistor r=102.615 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl46 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl45 (SEb \2\:SEb) resistor r=78.079 c=0
Rz21 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz28 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz29 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz30 (\1\:VDD \9\:VDD) resistor r=6.25 c=0
Rz31 (\1\:VDD \12\:VDD) resistor r=6.25 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (net498 \2\:net498) resistor r=75 c=0
Rz6 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz7 (net0363 \2\:net0363) resistor r=75 c=0
Rz8 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz16 (\19\:CKNbb \20\:CKNbb) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz14 (\15\:mout \16\:mout) resistor r=75 c=0
Rz17 (\14\:CKNb \15\:CKNb) resistor r=75 c=0
Rz11 (net521 \2\:net521) resistor r=75 c=0
Rz12 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz15 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz18 (\4\:Db \5\:Db) resistor r=75 c=0
Rz19 (\6\:Db \7\:Db) resistor r=75 c=0
Rz20 (\10\:SEb \11\:SEb) resistor r=75 c=0
Ry17 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry18 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry20 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry21 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry22 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry23 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry24 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry25 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry26 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry27 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry28 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry29 (\30\:VDD \31\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\17\:CKNbb \18\:CKNbb) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\11\:mout \12\:mout) resistor r=62 c=0
Ry13 (\10\:CKNb \11\:CKNb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry14 (Db \2\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net566 \2\:net566) resistor r=62 c=0
Ry6 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx18 (\2\:CKN \5\:CKN) resistor r=45 c=0
Rx20 (\5\:SE \7\:SE) resistor r=45 c=0
Rx21 (\2\:SE \8\:SE) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx22 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \10\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \13\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\3\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx14 (\7\:CKNbb \12\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx17 (\2\:CKNb \13\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx24 (\4\:SEb \12\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \24\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.833e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q qbint \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.267e-14 ad=3.64e-14 ps=9.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.00769e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=2.03e-14 ps=8.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\11\:RNb \3\:RN \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.267e-14 ad=2.9e-14 ps=9.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\11\:qbint \3\:n35 \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.548e-14 ad=2.03e-14 ps=1.55e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.44483e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn50 (net498 \3\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.548e-14 ad=3.335e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.22414e-07 sb=7.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn52 (\3\:net0363 \8\:qbint net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.335e-14 ad=3.988e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.97414e-07 sb=4.65e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn51 (\3\:net0363 RNb \3\:net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.103e-14 ad=3.988e-14 ps=5.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.17414e-07 sb=1.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn53 (\4\:n35 CKNbb net0363 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\15\:mout \6\:CKNb \4\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.698e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\13\:mout \6\:RNb \3\:net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn32 (\13\:mout \3\:n20 net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.755e-14 ps=6.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=9.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn30 (net521 \6\:SN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.537e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=7.65e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn35 (net582 \4\:mout \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.595e-14 ps=7.3e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn36 (\7\:n20 \5\:CKNb net582 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=3.45e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn25 (\4\:Db \8\:CKNbb \7\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn21 (\19\:CKNbb CKNb \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.025e-14 ad=2.03e-14 ps=1.76e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\14\:CKNb \3\:CKN \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=3.407e-14 ps=9.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.06897e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (net546 \3\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71034e-07 sb=9.95e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn12 (\6\:Db SEb net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.857e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.76034e-07 sb=8.9e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn14 (\6\:Db \1\:SE net538 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=4.857e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.56034e-07 sb=5.1e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn13 (net538 \1\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.21034e-07 sb=3.45e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn10 (\10\:SEb \6\:SE \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12603e-06 sb=1.4e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mp56 (\5\:qint \6\:qbint \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp22 (\9\:RNb \1\:RN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=4.3e-14 ps=1.22e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp45 (\14\:qbint n35 \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.483e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=9.25e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (\3\:net566 \1\:SN \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.407e-14 ad=4.945e-14 ps=8.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=6.75e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp52 (\3\:net566 \7\:qbint net414 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=4.945e-14 ps=5.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=4e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp51 (net414 \2\:RNb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2.95e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp53 (\8\:n35 \7\:CKNb net566 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.762e-14 ps=1.06e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.6e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\8\:n35 \4\:CKNbb \9\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (net478 \4\:RNb \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.928e-14 ad=4.085e-14 ps=2.06e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=1.13919e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp32 (\11\:mout n20 net478 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.762e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=9.04186e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\11\:mout \4\:SN \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.762e-14 ps=1.71e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=6.84186e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp35 (net486 mout \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.00814e-07 sb=5.22442e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp36 (\4\:n20 \6\:CKNbb net486 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.85e-14 ps=5.5e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.05814e-07 sb=4.17442e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp25 (\4\:n20 \9\:CKNb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=6.85e-14 ps=7.1e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12209e-06 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp21 (\17\:CKNbb \8\:CKNb \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\10\:CKNb \1\:CKN \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13686e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp11 (net461 \1\:D \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.333e-14 ps=7.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=9.2686e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp12 (Db \3\:SE net461 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=6.128e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.2686e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp14 (Db \3\:SEb net453 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=3.9686e-07 sd=160n sca=11.3725 \
        scb=0.00850478 scc=0.000119858 m=(1)
mp13 (net453 \3\:SI \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.41e-14 ad=1.29e-14 ps=9.4e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.9186e-07 sd=160n sca=11.993 \
        scb=0.00910029 scc=0.000121216 m=(1)
mp10 (\5\:SEb \4\:SE \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.41e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93488e-07 sb=1.4e-07 sd=160n sca=15.0667 \
        scb=0.0139761 scc=0.000182543 m=(1)
ends SDFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:29 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFNSRX2
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX2 CKN D Q QN RN SE SI SN VDD VSS
mp10 (\7\:SEb \1\:SE \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.227e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.62558e-07 sd=160n sca=26.8497 \
        scb=0.0316789 scc=0.0018946 m=(1)
mp13 (net453 \1\:SI \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.227e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.02791e-07 sb=1.05e-06 sd=160n sca=13.4953 \
        scb=0.011285 scc=0.000140006 m=(1)
mp14 (\8\:Db SEb net453 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.655e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07791e-07 sb=9.45e-07 sd=160n sca=12.2741 \
        scb=0.0094438 scc=0.000122647 m=(1)
mp12 (\8\:Db \4\:SE net461 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.655e-14 ps=9.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.22791e-07 sb=7.3e-07 sd=160n sca=11.0664 \
        scb=0.00830854 scc=0.000119688 m=(1)
mp11 (net461 \3\:D \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=5.375e-14 ps=9.3e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.17791e-07 sb=4.35e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp20 (\13\:CKNb \3\:CKN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.375e-14 ad=3.01e-14 ps=9.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11279e-06 sb=1.4e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp21 (\13\:CKNbb \9\:CKNb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp25 (\7\:n20 \8\:CKNb Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=7.203e-14 ps=7.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.485e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\7\:n20 \3\:CKNbb net486 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.203e-14 ps=5.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.105e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (net486 mout \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3178e-13 ad=1.29e-14 ps=2.08e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp30 (\14\:mout \4\:SN \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.3178e-13 ad=5.697e-14 ps=2.08e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=6.1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp32 (\14\:mout \3\:n20 net478 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=5.697e-14 ps=7.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=3e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (net478 \4\:RNb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.765e-14 ad=3.332e-14 ps=1.48e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n35 \5\:CKNbb \10\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=5.482e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=4.4e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp53 (\7\:n35 CKNb \3\:net566 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp51 (net414 \2\:RNb \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.69e-14 ad=2.902e-14 ps=1.85e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6.6093e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp52 (net566 qbint net414 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.58e-14 ps=7e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=4.8093e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp50 (net566 \6\:SN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.005e-14 ad=3.58e-14 ps=1.79e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.22326e-07 sb=3.5e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp22 (\10\:RNb \1\:RN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.22442e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp56 (\8\:qint \11\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.333e-14 ad=3.655e-14 ps=1.29e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.69651e-07 sb=1.7e-07 sd=160n sca=18.4729 \
        scb=0.019884 scc=0.000529148 m=(1)
C1 (D VSS) capacitor c=5.99304e-17
C2 (RN VSS) capacitor c=6.6084e-17
C3 (SN VSS) capacitor c=5.37819e-17
C4 (Q VSS) capacitor c=3.2512e-17
C5 (VDD VSS) capacitor c=6.09251e-16
C6 (SE VSS) capacitor c=3.10553e-17
C7 (SI VSS) capacitor c=4.04003e-17
C8 (CKN VSS) capacitor c=4.1167e-17
C9 (QN VSS) capacitor c=3.80325e-17
C10 (SEb VSS) capacitor c=6.03137e-17
C11 (Db VSS) capacitor c=8.03014e-17
C12 (CKNb VSS) capacitor c=6.97143e-17
C13 (CKNbb VSS) capacitor c=4.09279e-17
C14 (n20 VSS) capacitor c=4.04073e-17
C15 (mout VSS) capacitor c=5.76441e-17
C16 (net521 VSS) capacitor c=6.29801e-17
C17 (RNb VSS) capacitor c=5.28819e-17
C18 (n35 VSS) capacitor c=5.05777e-17
C19 (net0363 VSS) capacitor c=8.10305e-17
C20 (net498 VSS) capacitor c=8.59232e-17
C21 (qbint VSS) capacitor c=6.43075e-17
C22 (qint VSS) capacitor c=1.62171e-16
C23 (net453 VSS) capacitor c=3.39026e-19
C24 (net461 VSS) capacitor c=4.24823e-18
C25 (net486 VSS) capacitor c=4.25379e-19
C26 (net478 VSS) capacitor c=2.54471e-18
C27 (net566 VSS) capacitor c=1.37938e-16
C28 (net414 VSS) capacitor c=4.1836e-18
C29 (\11\:qbint VSS) capacitor c=3.33531e-17
C30 (\4\:qbint VSS) capacitor c=4.99015e-16
C31 (\1\:RN VSS) capacitor c=5.66354e-17
C32 (\6\:SN VSS) capacitor c=7.8052e-17
C33 (\2\:RNb VSS) capacitor c=3.70547e-17
C34 (\5\:CKNbb VSS) capacitor c=3.97122e-17
C35 (\4\:RNb VSS) capacitor c=1.32456e-16
C36 (\3\:n20 VSS) capacitor c=4.77876e-17
C37 (\4\:SN VSS) capacitor c=3.41311e-17
C38 (\3\:CKNbb VSS) capacitor c=7.23711e-17
C39 (\8\:CKNb VSS) capacitor c=1.9555e-17
C40 (\9\:CKNb VSS) capacitor c=1.62926e-17
C41 (\3\:CKN VSS) capacitor c=3.90769e-17
C42 (\3\:D VSS) capacitor c=3.48465e-17
C43 (\4\:SE VSS) capacitor c=8.2189e-17
C44 (\1\:SI VSS) capacitor c=8.03029e-17
C45 (\1\:SE VSS) capacitor c=6.22786e-17
C46 (\13\:qbint VSS) capacitor c=5.63797e-17
C47 (\3\:RN VSS) capacitor c=3.91114e-17
C48 (\4\:n35 VSS) capacitor c=4.20112e-17
C49 (\8\:SN VSS) capacitor c=6.00061e-17
C50 (\3\:qbint VSS) capacitor c=3.52994e-17
C51 (\7\:CKNbb VSS) capacitor c=4.30944e-17
C52 (\2\:CKNb VSS) capacitor c=1.37759e-16
C53 (\5\:RNb VSS) capacitor c=4.92555e-17
C54 (\1\:SN VSS) capacitor c=5.86289e-17
C55 (\3\:mout VSS) capacitor c=7.24592e-17
C56 (\3\:CKNb VSS) capacitor c=2.11133e-16
C57 (\10\:CKNb VSS) capacitor c=2.77224e-17
C58 (\1\:CKN VSS) capacitor c=2.59282e-17
C59 (\1\:D VSS) capacitor c=5.86161e-17
C60 (\3\:SEb VSS) capacitor c=4.28277e-17
C61 (\6\:SE VSS) capacitor c=3.3788e-17
C62 (\3\:SI VSS) capacitor c=7.26745e-17
C63 (\3\:SE VSS) capacitor c=2.84571e-17
C64 (\12\:qbint VSS) capacitor c=4.48631e-17
C65 (\6\:qint VSS) capacitor c=2.08192e-17
C66 (\2\:RN VSS) capacitor c=5.08559e-17
C67 (\3\:n35 VSS) capacitor c=2.20754e-17
C68 (\7\:SN VSS) capacitor c=3.31128e-17
C69 (\2\:qbint VSS) capacitor c=4.23613e-17
C70 (\3\:RNb VSS) capacitor c=1.19578e-16
C71 (\8\:CKNbb VSS) capacitor c=3.22152e-17
C72 (\6\:CKNbb VSS) capacitor c=3.04115e-17
C73 (\2\:n20 VSS) capacitor c=4.96131e-17
C74 (\5\:SN VSS) capacitor c=2.21333e-17
C75 (\3\:SN VSS) capacitor c=4.05616e-17
C76 (\2\:mout VSS) capacitor c=5.2013e-17
C77 (\4\:CKNbb VSS) capacitor c=2.74822e-17
C78 (\2\:CKNbb VSS) capacitor c=4.28194e-17
C79 (\7\:CKNb VSS) capacitor c=1.00758e-17
C80 (\2\:CKN VSS) capacitor c=3.23261e-17
C81 (\2\:D VSS) capacitor c=5.45989e-17
C82 (\4\:SEb VSS) capacitor c=4.01799e-17
C83 (\5\:SE VSS) capacitor c=6.23074e-17
C84 (\2\:SEb VSS) capacitor c=4.30089e-17
C85 (\2\:SI VSS) capacitor c=6.43341e-17
C86 (\2\:SE VSS) capacitor c=4.34135e-17
C87 (\8\:qint VSS) capacitor c=3.92722e-17
C88 (\1\:QN VSS) capacitor c=5.25659e-17
C89 (\1\:Q VSS) capacitor c=4.95386e-17
C90 (\1\:VDD VSS) capacitor c=1.44794e-16
C91 (\10\:RNb VSS) capacitor c=2.06755e-17
C92 (\20\:qbint VSS) capacitor c=5.7422e-17
C93 (\16\:VDD VSS) capacitor c=1.53559e-17
C94 (\18\:VDD VSS) capacitor c=3.0296e-17
C95 (\3\:net566 VSS) capacitor c=1.326e-16
C96 (\7\:n35 VSS) capacitor c=2.21775e-17
C97 (\10\:mout VSS) capacitor c=3.58322e-17
C98 (\20\:VDD VSS) capacitor c=3.02704e-17
C99 (\14\:mout VSS) capacitor c=3.31507e-17
C100 (\22\:VDD VSS) capacitor c=3.398e-17
C101 (\7\:n20 VSS) capacitor c=7.51635e-17
C102 (\13\:CKNbb VSS) capacitor c=7.26858e-17
C103 (\25\:VDD VSS) capacitor c=4.31278e-17
C104 (\13\:CKNb VSS) capacitor c=5.22449e-17
C105 (\27\:VDD VSS) capacitor c=3.15395e-17
C106 (\8\:Db VSS) capacitor c=1.24861e-16
C107 (\33\:VDD VSS) capacitor c=9.12668e-18
C108 (\7\:SEb VSS) capacitor c=6.63688e-17
C109 (\5\:VDD VSS) capacitor c=1.2122e-16
C110 (\12\:qint VSS) capacitor c=2.08846e-17
C111 (\3\:QN VSS) capacitor c=3.01933e-17
C112 (\4\:Q VSS) capacitor c=7.94207e-17
C113 (\6\:RNb VSS) capacitor c=1.15486e-16
C114 (\17\:qbint VSS) capacitor c=6.56592e-17
C115 (\3\:net0363 VSS) capacitor c=1.1429e-16
C116 (\3\:net498 VSS) capacitor c=6.83497e-17
C117 (\9\:n35 VSS) capacitor c=6.33204e-17
C118 (\4\:mout VSS) capacitor c=4.25046e-17
C119 (\12\:mout VSS) capacitor c=4.30649e-17
C120 (\3\:net521 VSS) capacitor c=7.73926e-17
C121 (\5\:n20 VSS) capacitor c=1.92369e-16
C122 (\3\:Db VSS) capacitor c=1.92414e-16
C123 (\17\:CKNbb VSS) capacitor c=5.08338e-17
C124 (\15\:CKNb VSS) capacitor c=4.4735e-17
C125 (\6\:Db VSS) capacitor c=1.95816e-17
C126 (\9\:SEb VSS) capacitor c=7.45446e-17
C127 (\2\:SN VSS) capacitor c=3.17557e-17
C128 (\4\:SI VSS) capacitor c=6.43544e-17
C129 (\7\:SE VSS) capacitor c=4.89284e-17
C130 (\8\:SE VSS) capacitor c=3.21936e-17
C131 (\4\:CKNb VSS) capacitor c=5.70421e-17
C132 (\5\:CKNb VSS) capacitor c=2.00903e-17
C133 (\5\:SEb VSS) capacitor c=1.77922e-16
C134 (\6\:SEb VSS) capacitor c=1.37607e-16
C135 (\11\:SEb VSS) capacitor c=4.09563e-17
C136 (\4\:D VSS) capacitor c=4.58691e-17
C137 (\4\:CKN VSS) capacitor c=5.59471e-17
C138 (\2\:n35 VSS) capacitor c=1.52141e-17
C139 (\11\:CKNb VSS) capacitor c=4.79752e-17
C140 (\12\:CKNb VSS) capacitor c=5.99366e-17
C141 (\5\:Db VSS) capacitor c=2.37532e-16
C142 (\9\:SN VSS) capacitor c=6.08864e-17
C143 (\4\:n20 VSS) capacitor c=1.7277e-16
C144 (\6\:mout VSS) capacitor c=5.50605e-17
C145 (\7\:mout VSS) capacitor c=8.38154e-17
C146 (\8\:mout VSS) capacitor c=7.45116e-17
C147 (\9\:mout VSS) capacitor c=5.84333e-17
C148 (\9\:CKNbb VSS) capacitor c=8.11993e-17
C149 (\10\:CKNbb VSS) capacitor c=3.20411e-16
C150 (\11\:CKNbb VSS) capacitor c=2.0917e-16
C151 (\12\:CKNbb VSS) capacitor c=6.7034e-17
C152 (\15\:CKNbb VSS) capacitor c=1.73626e-17
C153 (\16\:CKNbb VSS) capacitor c=6.39142e-17
C154 (\10\:SN VSS) capacitor c=2.71789e-16
C155 (\11\:SN VSS) capacitor c=2.78709e-16
C156 (\5\:n35 VSS) capacitor c=1.75253e-16
C157 (\6\:n35 VSS) capacitor c=1.49006e-16
C158 (\8\:RNb VSS) capacitor c=1.35585e-16
C159 (\9\:RNb VSS) capacitor c=1.14692e-16
C160 (\4\:RN VSS) capacitor c=6.13246e-17
C161 (\3\:Q VSS) capacitor c=5.12148e-17
C162 (\14\:qbint VSS) capacitor c=1.10416e-16
C163 (\19\:qbint VSS) capacitor c=6.44683e-17
C164 (\23\:qbint VSS) capacitor c=7.2705e-17
C165 (\10\:qint VSS) capacitor c=3.88769e-17
C166 (\11\:qint VSS) capacitor c=3.27452e-17
C167 (\4\:VDD VSS) capacitor c=3.2375e-17
C168 (\7\:VDD VSS) capacitor c=4.96373e-17
C169 (\8\:VDD VSS) capacitor c=5.73577e-17
C170 (\10\:VDD VSS) capacitor c=2.30923e-17
C171 (\11\:VDD VSS) capacitor c=2.80807e-17
C172 (\32\:VDD VSS) capacitor c=3.32651e-17
Rk10 (\4\:D D) resistor r=0.015 c=0
Rk47 (RN \4\:RN) resistor r=0.177 c=0
Rk89 (\1\:VSS \7\:VSS) resistor r=0.3296 c=0
Rk90 (\7\:VSS \8\:VSS) resistor r=0.2706 c=0
Rk91 (\8\:VSS \9\:VSS) resistor r=1.1256 c=0
Rk92 (\9\:VSS \10\:VSS) resistor r=0.07753 c=0
Rk93 (\10\:VSS \11\:VSS) resistor r=0.7335 c=0
Rk94 (\11\:VSS \12\:VSS) resistor r=0.4124 c=0
Rk95 (\12\:VSS \13\:VSS) resistor r=0.05497 c=0
Rk97 (\14\:VSS VSS) resistor r=0.1149 c=0
Rk96 (\13\:VSS \14\:VSS) resistor r=0.4361 c=0
Rk100 (\7\:VSS \20\:VSS) resistor r=0.3564 c=0
Rk101 (\9\:VSS \22\:VSS) resistor r=0.338 c=0
Rk102 (\11\:VSS \24\:VSS) resistor r=0.0433 c=0
Rk103 (\12\:VSS \26\:VSS) resistor r=0.1726 c=0
Rk104 (\14\:VSS \28\:VSS) resistor r=0.1817 c=0
Rk19 (\9\:SN SN) resistor r=0.1631 c=0
Rk40 (\10\:SN \11\:SN) resistor r=2.1227 c=0
Rk49 (\3\:Q Q) resistor r=0.05081 c=0
Rk48 (\2\:Q \3\:Q) resistor r=0.1385 c=0
Rk50 (\3\:Q \5\:Q) resistor r=0.4019 c=0
Rk64 (\1\:VDD \4\:VDD) resistor r=0.3256 c=0
Rk65 (\4\:VDD \6\:VDD) resistor r=0.2907 c=0
Rk66 (\6\:VDD \7\:VDD) resistor r=0.1302 c=0
Rk67 (\7\:VDD \8\:VDD) resistor r=0.7393 c=0
Rk68 (\8\:VDD \9\:VDD) resistor r=0.3333 c=0
Rk69 (\9\:VDD \10\:VDD) resistor r=0.09759 c=0
Rk70 (\10\:VDD \11\:VDD) resistor r=0.5838 c=0
Rk71 (\11\:VDD \12\:VDD) resistor r=0.5213 c=0
Rk74 (\4\:VDD \17\:VDD) resistor r=0.07381 c=0
Rk75 (\7\:VDD \19\:VDD) resistor r=0.1572 c=0
Rk76 (\8\:VDD \21\:VDD) resistor r=0.1526 c=0
Rk77 (\10\:VDD \23\:VDD) resistor r=0.07381 c=0
Rk78 (\23\:VDD \24\:VDD) resistor r=0.1501 c=0
Rk79 (\11\:VDD \26\:VDD) resistor r=0.4058 c=0
Rk80 (\12\:VDD \28\:VDD) resistor r=0.3003 c=0
Rk85 (\32\:VDD VDD) resistor r=0.1074 c=0
Rk83 (\12\:VDD \32\:VDD) resistor r=0.4442 c=0
Rk84 (\32\:VDD \34\:VDD) resistor r=0.07381 c=0
Rk2 (\7\:SE SE) resistor r=0.1426 c=0
Rk3 (SE \8\:SE) resistor r=0.05367 c=0
Rk1 (SI \4\:SI) resistor r=0.02867 c=0
Rk11 (CKN \4\:CKN) resistor r=0.1124 c=0
Rk51 (\2\:QN QN) resistor r=0.1716 c=0
Rk52 (QN \4\:QN) resistor r=0.05987 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=1.1937 c=0
Rk5 (\6\:SEb \8\:SEb) resistor r=0.2534 c=0
Rk6 (\8\:SEb \10\:SEb) resistor r=0.6366 c=0
Rk7 (\6\:SEb \11\:SEb) resistor r=0.1561 c=0
Rk15 (\2\:Db \4\:Db) resistor r=0.4096 c=0
Rk16 (\4\:Db \5\:Db) resistor r=1.532 c=0
Rk17 (\5\:Db \7\:Db) resistor r=0.1012 c=0
Rk18 (\5\:Db \9\:Db) resistor r=0.7111 c=0
Rk12 (\11\:CKNb \12\:CKNb) resistor r=0.3582 c=0
Rk13 (\12\:CKNb \14\:CKNb) resistor r=0.4916 c=0
Rk14 (\12\:CKNb \16\:CKNb) resistor r=0.178 c=0
Rk30 (\9\:CKNbb \10\:CKNbb) resistor r=0.6269 c=0
Rk31 (\10\:CKNbb \11\:CKNbb) resistor r=1.6418 c=0
Rk32 (\11\:CKNbb \12\:CKNbb) resistor r=0.2063 c=0
Rk33 (\12\:CKNbb \14\:CKNbb) resistor r=0.4036 c=0
Rk34 (\11\:CKNbb \15\:CKNbb) resistor r=0.05041 c=0
Rk35 (\12\:CKNbb \16\:CKNbb) resistor r=0.3465 c=0
Rk36 (\14\:CKNbb \18\:CKNbb) resistor r=0.2847 c=0
Rk20 (\4\:n20 \6\:n20) resistor r=1.2023 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.3838 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.2236 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.4568 c=0
Rk25 (\7\:mout \8\:mout) resistor r=0.3521 c=0
Rk26 (\8\:mout \9\:mout) resistor r=0.3157 c=0
Rk27 (\6\:mout \11\:mout) resistor r=0.1203 c=0
Rk28 (\7\:mout \13\:mout) resistor r=0.215 c=0
Rk29 (\8\:mout \15\:mout) resistor r=0.1168 c=0
Rk22 (\2\:net521 \4\:net521) resistor r=0.5226 c=0
Rk44 (\7\:RNb \8\:RNb) resistor r=0.6011 c=0
Rk45 (\8\:RNb \9\:RNb) resistor r=0.7204 c=0
Rk46 (\8\:RNb \11\:RNb) resistor r=0.0503 c=0
Rk41 (\5\:n35 \6\:n35) resistor r=1.125 c=0
Rk42 (\6\:n35 \8\:n35) resistor r=0.05676 c=0
Rk43 (\6\:n35 \10\:n35) resistor r=0.2943 c=0
Rk37 (\2\:net0363 \4\:net0363) resistor r=0.7252 c=0
Rk38 (\2\:net498 \4\:net498) resistor r=0.3862 c=0
Rk53 (\14\:qbint \4\:qbint) resistor r=0.8478 c=0
Rk55 (\4\:qbint \18\:qbint) resistor r=0.5105 c=0
Rk56 (\18\:qbint \19\:qbint) resistor r=0.1593 c=0
Rk57 (\19\:qbint \21\:qbint) resistor r=0.2594 c=0
Rk59 (\19\:qbint \23\:qbint) resistor r=0.3557 c=0
Rk60 (\9\:qint \10\:qint) resistor r=0.3681 c=0
Rk61 (\10\:qint \11\:qint) resistor r=0.1802 c=0
Rk62 (\10\:qint \13\:qint) resistor r=0.1138 c=0
Rk39 (\2\:net566 \4\:net566) resistor r=0.7765 c=0
Rl10 (\2\:D \3\:D) resistor r=112.637 c=0
Rl9 (\1\:D \2\:D) resistor r=161.538 c=0
Rl45 (\1\:RN \2\:RN) resistor r=156.925 c=0
Rl46 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl41 (\6\:SN \8\:SN) resistor r=140.385 c=0
Rl40 (\6\:SN \7\:SN) resistor r=70.3288 c=0
Rl20 (\4\:SN \5\:SN) resistor r=50.6918 c=0
Rl19 (\2\:SN \4\:SN) resistor r=99.6815 c=0
Rl17 (\1\:SN \2\:SN) resistor r=105.747 c=0
Rl18 (\2\:SN \3\:SN) resistor r=78.0596 c=0
Rl6 (\4\:SE \5\:SE) resistor r=276.489 c=0
Rl7 (\5\:SE \6\:SE) resistor r=26.3736 c=0
Rl1 (\1\:SE \2\:SE) resistor r=193 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl3 (\1\:SI \2\:SI) resistor r=104.538 c=0
Rl4 (\2\:SI \3\:SI) resistor r=168 c=0
Rl12 (\2\:CKN \3\:CKN) resistor r=135.714 c=0
Rl11 (\1\:CKN \2\:CKN) resistor r=30.7692 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=93.4636 c=0
Rl5 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl24 (CKNb \2\:CKNb) resistor r=158.747 c=0
Rl25 (\2\:CKNb \3\:CKNb) resistor r=905.335 c=0
Rl30 (\4\:CKNb \8\:CKNb) resistor r=30.4507 c=0
Rl26 (\3\:CKNb \4\:CKNb) resistor r=224.543 c=0
Rl31 (\5\:CKNb \9\:CKNb) resistor r=28.0797 c=0
Rl27 (\4\:CKNb \5\:CKNb) resistor r=149.196 c=0
Rl32 (\6\:CKNb \10\:CKNb) resistor r=46.9565 c=0
Rl29 (\6\:CKNb \7\:CKNb) resistor r=3.7301 c=0
Rl28 (\5\:CKNb \6\:CKNb) resistor r=25.0362 c=0
Rl33 (\7\:CKNbb \8\:CKNbb) resistor r=81.9251 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=24.2328 c=0
Rl14 (\3\:CKNbb \4\:CKNbb) resistor r=37.6944 c=0
Rl13 (CKNbb \2\:CKNbb) resistor r=39.1533 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=89.5604 c=0
Rl21 (n20 \2\:n20) resistor r=33.4411 c=0
Rl15 (mout \2\:mout) resistor r=24.2328 c=0
Rl16 (\2\:mout \3\:mout) resistor r=91.5405 c=0
Rl34 (RNb \2\:RNb) resistor r=132.325 c=0
Rl37 (\4\:RNb \5\:RNb) resistor r=172.643 c=0
Rl35 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl36 (\3\:RNb \4\:RNb) resistor r=987.26 c=0
Rl42 (n35 \2\:n35) resistor r=34.3295 c=0
Rl44 (\2\:n35 \4\:n35) resistor r=74.7141 c=0
Rl43 (\2\:n35 \3\:n35) resistor r=2.0166 c=0
Rl58 (\12\:qbint \11\:qbint) resistor r=26.098 c=0
Rl59 (\12\:qbint \13\:qbint) resistor r=137.637 c=0
Rl38 (\2\:qbint qbint) resistor r=60.7713 c=0
Rl39 (\2\:qbint \3\:qbint) resistor r=37.6944 c=0
Rl56 (qint \6\:qint) resistor r=4.9938 c=0
Rz28 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz29 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz30 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz31 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz32 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz17 (\5\:Q \4\:Q) resistor r=75 c=0
Rz24 (\1\:VDD \5\:VDD) resistor r=10.7143 c=0
Rz21 (\6\:VDD \5\:VDD) resistor r=6.25 c=0
Rz22 (\9\:VDD \5\:VDD) resistor r=6.25 c=0
Rz23 (\12\:VDD \5\:VDD) resistor r=6.25 c=0
Rz18 (\4\:QN \3\:QN) resistor r=75 c=0
Rz1 (\9\:SEb \10\:SEb) resistor r=75 c=0
Rz3 (\3\:Db \4\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\15\:CKNb \16\:CKNb) resistor r=75 c=0
Rz10 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz5 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\12\:mout \13\:mout) resistor r=75 c=0
Rz6 (net521 \2\:net521) resistor r=75 c=0
Rz7 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz16 (\6\:RNb \7\:RNb) resistor r=75 c=0
Rz15 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (net0363 \2\:net0363) resistor r=75 c=0
Rz12 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz13 (net498 \2\:net498) resistor r=75 c=0
Rz14 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz19 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz20 (\13\:qint \12\:qint) resistor r=75 c=0
Ry28 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry29 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry30 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry31 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry13 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry19 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry23 (\24\:VDD \22\:VDD) resistor r=62 c=0
Ry24 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry25 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry27 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry14 (\2\:QN \1\:QN) resistor r=62 c=0
Ry1 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry3 (Db \2\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\13\:CKNb \14\:CKNb) resistor r=62 c=0
Ry8 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry5 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (\10\:mout \11\:mout) resistor r=62 c=0
Ry7 (\14\:mout \15\:mout) resistor r=62 c=0
Ry12 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry11 (\7\:n35 \8\:n35) resistor r=62 c=0
Ry15 (\21\:qbint \20\:qbint) resistor r=62 c=0
Ry16 (\9\:qint \8\:qint) resistor r=62 c=0
Ry9 (net566 \2\:net566) resistor r=62 c=0
Ry10 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx20 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\3\:SN \9\:SN) resistor r=45 c=0
Rx16 (\7\:SN \10\:SN) resistor r=45 c=0
Rx17 (\5\:SN \11\:SN) resistor r=45 c=0
Rx2 (\2\:SE \7\:SE) resistor r=45 c=0
Rx3 (\5\:SE \8\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \11\:SEb) resistor r=45 c=0
Rx8 (\7\:CKNb \11\:CKNb) resistor r=45 c=0
Rx12 (\8\:CKNbb \9\:CKNbb) resistor r=45 c=0
Rx13 (\6\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx14 (\4\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx15 (\2\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx10 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx11 (\2\:mout \9\:mout) resistor r=45 c=0
Rx19 (\3\:RNb \9\:RNb) resistor r=45 c=0
Rx18 (\3\:n35 \5\:n35) resistor r=45 c=0
Rx21 (\14\:qbint \12\:qbint) resistor r=45 c=0
Rx24 (\23\:qbint \2\:qbint) resistor r=45 c=0
Rx25 (\11\:qint \6\:qint) resistor r=45 c=0
mn10 (\9\:SEb \3\:SE \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.103e-14 ps=6.4e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.09e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn13 (net538 \3\:SI \27\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=1.16e-14 ps=6.4e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=8.7e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn14 (\6\:Db \6\:SE net538 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=5.075e-14 ps=4.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=7.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn12 (\6\:Db \3\:SEb net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=5.075e-14 ps=5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.5e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn11 (net546 \1\:D \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.025e-14 ad=1.522e-14 ps=1.35e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=2e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn20 (\15\:CKNb \1\:CKN \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.025e-14 ad=4.132e-14 ps=1.35e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2.85e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\17\:CKNbb \10\:CKNb \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=2.61e-14 ps=1.66e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60345e-07 sb=1.8e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn25 (\3\:Db CKNbb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.53e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn36 (\5\:n20 \3\:CKNb net582 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.265e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (net582 \3\:mout \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.975e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.16e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn30 (\3\:net521 \1\:SN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.975e-14 ad=2.32e-14 ps=1.39e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=5.65e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\12\:mout n20 \3\:net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=3.6e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\12\:mout \5\:RNb net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\4\:mout \2\:CKNb \9\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.132e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn53 (\9\:n35 \7\:CKNbb net0363 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn51 (\3\:net0363 RNb \3\:net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn52 (\3\:net0363 \3\:qbint net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn50 (net498 \8\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn22 (\6\:RNb \3\:RN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.685e-14 ad=2.03e-14 ps=1.53e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn56 (\12\:qint \13\:qbint \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn45 (\17\:qbint \4\:n35 \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.63293e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\4\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.027e-14 ad=4.94e-14 ps=1.27e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=9.66635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(2)
mn57 (\3\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=4.16e-14 ps=9.25e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.61635e-07 sb=4.41635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(2)
mp45 (\20\:qbint n35 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.005e-14 ad=4.495e-14 ps=1.79e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65726e-07 sb=1.45e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.342e-14 ad=7.41e-14 ps=1.305e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.25385e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(2)
mp57_1__rcx (\1\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.914e-14 ad=6.24e-14 ps=1.4e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.23141e-07 sb=4.40385e-07 sd=160n sca=31.0979 \
        scb=0.0204275 scc=0.00336106 m=(2)
ends SDFFNSRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:30 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFNSRX4
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX4 CKN D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \39\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.80233e-07 sd=160n sca=12.896 \
        scb=0.0102095 scc=9.31837e-05 m=(1)
mp13 (net453 \1\:SI \39\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75233e-07 sd=160n sca=11.1175 \
        scb=0.00789061 scc=7.80015e-05 m=(1)
mp14 (\5\:Db \3\:SEb net453 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.70233e-07 sd=160n sca=10.6702 \
        scb=0.0075867 scc=7.76926e-05 m=(1)
mp12 (\5\:Db \6\:SE net461 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=6.128e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=3.40233e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp11 (net461 \1\:D \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.215e-14 ad=2.473e-14 ps=1.73e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.80233e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp20 (\21\:CKNb \1\:CKN \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.215e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61628e-07 sb=1.6e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp25 (\5\:n20 CKNb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.73e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.73488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp36 (\5\:n20 CKNbb net486 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.73e-14 ps=7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.08488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp35 (net486 mout \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.86e-14 ad=2.903e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.28488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp21 (\8\:CKNbb \9\:CKNb \32\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.86e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05814e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp31 (net478 RNb \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.205e-14 ad=1.29e-14 ps=2.66e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83721e-07 sb=1.11e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\8\:mout n20 net478 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.88721e-07 sb=1.005e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout \5\:SN \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6557e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.93721e-07 sb=8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \3\:RN \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6557e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13372e-06 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\12\:n35 \5\:CKNbb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp53 (\12\:n35 \14\:CKNb \3\:net566 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp51 (net414 \4\:RNb \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp52 (net566 qbint net414 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (net566 \1\:SN \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.863e-14 ad=3.44e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
C1 (D VSS) capacitor c=6.42218e-17
C2 (RN VSS) capacitor c=6.42486e-17
C3 (Q VSS) capacitor c=1.72582e-17
C4 (SN VSS) capacitor c=5.22756e-17
C5 (QN VSS) capacitor c=1.73932e-17
C6 (VDD VSS) capacitor c=6.18817e-16
C7 (SE VSS) capacitor c=9.74158e-17
C8 (SI VSS) capacitor c=6.15335e-17
C9 (CKN VSS) capacitor c=7.65273e-17
C10 (SEb VSS) capacitor c=7.36246e-17
C11 (net538 VSS) capacitor c=7.30944e-19
C12 (Db VSS) capacitor c=9.43388e-17
C13 (net546 VSS) capacitor c=1.37725e-18
C14 (CKNb VSS) capacitor c=3.4432e-17
C15 (n20 VSS) capacitor c=8.36975e-17
C16 (CKNbb VSS) capacitor c=3.34707e-17
C17 (net582 VSS) capacitor c=1.44418e-19
C18 (mout VSS) capacitor c=7.17029e-17
C19 (RNb VSS) capacitor c=7.53824e-17
C20 (net521 VSS) capacitor c=9.21558e-17
C21 (n35 VSS) capacitor c=1.95548e-16
C22 (net0363 VSS) capacitor c=7.9362e-17
C23 (net498 VSS) capacitor c=8.80294e-17
C24 (qbint VSS) capacitor c=8.72438e-17
C25 (qint VSS) capacitor c=2.64546e-16
C26 (net461 VSS) capacitor c=4.43802e-18
C27 (net478 VSS) capacitor c=2.70109e-19
C28 (net566 VSS) capacitor c=1.05001e-16
C29 (net414 VSS) capacitor c=3.22857e-18
C30 (\19\:qbint VSS) capacitor c=5.02992e-17
C31 (\1\:SN VSS) capacitor c=6.9977e-17
C32 (\4\:RNb VSS) capacitor c=7.55898e-17
C33 (\14\:CKNb VSS) capacitor c=5.54139e-17
C34 (\5\:CKNbb VSS) capacitor c=6.45328e-17
C35 (\3\:RN VSS) capacitor c=2.95802e-17
C36 (\5\:SN VSS) capacitor c=3.67715e-17
C37 (\9\:CKNb VSS) capacitor c=3.80829e-17
C38 (\1\:CKN VSS) capacitor c=4.27673e-17
C39 (\1\:D VSS) capacitor c=7.21185e-17
C40 (\6\:SE VSS) capacitor c=4.33579e-17
C41 (\3\:SEb VSS) capacitor c=4.74268e-17
C42 (\1\:SI VSS) capacitor c=8.41357e-17
C43 (\1\:SE VSS) capacitor c=5.94087e-17
C44 (\17\:qbint VSS) capacitor c=2.39121e-17
C45 (\4\:qbint VSS) capacitor c=2.58566e-16
C46 (\2\:SN VSS) capacitor c=1.66785e-16
C47 (\3\:qbint VSS) capacitor c=3.99157e-17
C48 (\6\:RNb VSS) capacitor c=4.19874e-17
C49 (\4\:CKNbb VSS) capacitor c=5.69194e-17
C50 (\11\:CKNb VSS) capacitor c=5.21788e-17
C51 (\1\:RN VSS) capacitor c=3.9034e-17
C52 (\3\:SN VSS) capacitor c=1.42416e-16
C53 (\3\:n20 VSS) capacitor c=6.15918e-17
C54 (\2\:RNb VSS) capacitor c=6.87677e-17
C55 (\5\:CKNb VSS) capacitor c=2.9526e-17
C56 (\2\:mout VSS) capacitor c=6.1026e-17
C57 (\3\:CKNb VSS) capacitor c=4.87282e-17
C58 (\3\:CKNbb VSS) capacitor c=6.24291e-17
C59 (\3\:CKN VSS) capacitor c=2.87635e-17
C60 (\3\:D VSS) capacitor c=3.47485e-17
C61 (\4\:SE VSS) capacitor c=5.55685e-17
C62 (\3\:SI VSS) capacitor c=6.07037e-17
C63 (\3\:SE VSS) capacitor c=2.45633e-17
C64 (\18\:qbint VSS) capacitor c=3.76e-17
C65 (\2\:qbint VSS) capacitor c=5.89612e-17
C66 (\5\:RNb VSS) capacitor c=5.66502e-17
C67 (\13\:CKNb VSS) capacitor c=2.15393e-17
C68 (\6\:CKNbb VSS) capacitor c=2.06479e-17
C69 (\12\:CKNb VSS) capacitor c=3.49485e-17
C70 (\2\:RN VSS) capacitor c=3.0054e-17
C71 (\3\:RNb VSS) capacitor c=4.37972e-17
C72 (\4\:SN VSS) capacitor c=4.95094e-17
C73 (\2\:n20 VSS) capacitor c=2.96714e-17
C74 (\10\:CKNb VSS) capacitor c=2.78802e-17
C75 (\7\:CKNb VSS) capacitor c=1.83288e-17
C76 (\3\:mout VSS) capacitor c=2.71542e-17
C77 (\4\:CKNb VSS) capacitor c=4.71999e-17
C78 (\2\:CKNbb VSS) capacitor c=6.04122e-17
C79 (\2\:CKNb VSS) capacitor c=3.19431e-17
C80 (\2\:CKN VSS) capacitor c=4.09455e-17
C81 (\2\:D VSS) capacitor c=6.15375e-17
C82 (\7\:SE VSS) capacitor c=5.22459e-17
C83 (\2\:SEb VSS) capacitor c=8.09315e-17
C84 (\5\:SE VSS) capacitor c=4.29107e-17
C85 (\2\:SI VSS) capacitor c=6.18264e-17
C86 (\2\:SE VSS) capacitor c=5.93405e-17
C87 (\20\:qint VSS) capacitor c=4.13888e-17
C88 (\1\:VDD VSS) capacitor c=4.3825e-16
C89 (\25\:qbint VSS) capacitor c=6.53879e-17
C90 (\22\:VDD VSS) capacitor c=4.40913e-17
C91 (\3\:net566 VSS) capacitor c=1.0094e-16
C92 (\12\:n35 VSS) capacitor c=4.0498e-17
C93 (\6\:mout VSS) capacitor c=1.73679e-16
C94 (\11\:RNb VSS) capacitor c=5.60103e-17
C95 (\25\:VDD VSS) capacitor c=3.90786e-17
C96 (\8\:mout VSS) capacitor c=1.62729e-16
C97 (\29\:VDD VSS) capacitor c=2.21101e-17
C98 (\8\:CKNbb VSS) capacitor c=2.5564e-16
C99 (\32\:VDD VSS) capacitor c=2.7287e-17
C100 (\5\:n20 VSS) capacitor c=1.76501e-16
C101 (\3\:Db VSS) capacitor c=1.39382e-16
C102 (\21\:CKNb VSS) capacitor c=9.49731e-17
C103 (\35\:VDD VSS) capacitor c=1.69096e-17
C104 (\5\:Db VSS) capacitor c=1.41045e-16
C105 (\39\:VDD VSS) capacitor c=2.93744e-17
C106 (\8\:SEb VSS) capacitor c=1.4483e-17
C107 (\3\:VDD VSS) capacitor c=1.19947e-16
C108 (\16\:qint VSS) capacitor c=3.08873e-17
C109 (\1\:QN VSS) capacitor c=1.23912e-16
C110 (\1\:Q VSS) capacitor c=1.21022e-16
C111 (\27\:qbint VSS) capacitor c=2.05519e-17
C112 (\3\:net0363 VSS) capacitor c=1.04504e-16
C113 (\3\:net498 VSS) capacitor c=8.57221e-17
C114 (\10\:n35 VSS) capacitor c=5.9381e-17
C115 (\4\:mout VSS) capacitor c=8.93314e-17
C116 (\8\:RNb VSS) capacitor c=2.16771e-16
C117 (\3\:net521 VSS) capacitor c=9.78222e-17
C118 (\11\:mout VSS) capacitor c=6.42177e-17
C119 (\12\:CKNbb VSS) capacitor c=4.64986e-17
C120 (\7\:n20 VSS) capacitor c=9.84671e-17
C121 (\18\:CKNb VSS) capacitor c=1.02813e-16
C122 (\7\:Db VSS) capacitor c=1.16748e-16
C123 (\6\:SEb VSS) capacitor c=6.88981e-17
C124 (\6\:CKNb VSS) capacitor c=1.08972e-17
C125 (\8\:CKNb VSS) capacitor c=1.79124e-17
C126 (\4\:SI VSS) capacitor c=4.00693e-17
C127 (\4\:SEb VSS) capacitor c=5.58488e-17
C128 (\5\:SEb VSS) capacitor c=7.74855e-17
C129 (\8\:SE VSS) capacitor c=1.35824e-16
C130 (\9\:SE VSS) capacitor c=4.69934e-17
C131 (\10\:SE VSS) capacitor c=4.93628e-17
C132 (\11\:SE VSS) capacitor c=3.70699e-17
C133 (\4\:D VSS) capacitor c=6.98215e-17
C134 (\4\:CKN VSS) capacitor c=5.91308e-17
C135 (\15\:CKNb VSS) capacitor c=4.78038e-17
C136 (\16\:CKNb VSS) capacitor c=8.34531e-17
C137 (\17\:CKNb VSS) capacitor c=1.16214e-16
C138 (\20\:CKNb VSS) capacitor c=7.87267e-17
C139 (\4\:n20 VSS) capacitor c=1.86823e-16
C140 (\6\:SN VSS) capacitor c=6.69779e-17
C141 (\4\:RN VSS) capacitor c=5.32951e-17
C142 (\10\:mout VSS) capacitor c=1.41901e-16
C143 (\13\:mout VSS) capacitor c=1.01291e-16
C144 (\7\:CKNbb VSS) capacitor c=2.65851e-16
C145 (\10\:CKNbb VSS) capacitor c=6.7937e-17
C146 (\11\:CKNbb VSS) capacitor c=6.92929e-17
C147 (\23\:CKNb VSS) capacitor c=8.28708e-17
C148 (\24\:CKNb VSS) capacitor c=3.21511e-16
C149 (\25\:CKNb VSS) capacitor c=2.54781e-16
C150 (\26\:CKNb VSS) capacitor c=6.07637e-17
C151 (\7\:RNb VSS) capacitor c=1.99056e-16
C152 (\10\:RNb VSS) capacitor c=8.12504e-17
C153 (\8\:n35 VSS) capacitor c=1.43078e-16
C154 (\9\:n35 VSS) capacitor c=1.71532e-16
C155 (\6\:Q VSS) capacitor c=1.69627e-16
C156 (\5\:QN VSS) capacitor c=1.50759e-16
C157 (\20\:qbint VSS) capacitor c=2.64519e-16
C158 (\21\:qbint VSS) capacitor c=2.00179e-16
C159 (\22\:qbint VSS) capacitor c=3.78077e-17
C160 (\23\:qbint VSS) capacitor c=5.88604e-17
C161 (\24\:qbint VSS) capacitor c=2.36708e-17
C162 (\29\:qbint VSS) capacitor c=1.69173e-17
C163 (\18\:qint VSS) capacitor c=5.40428e-17
C164 (\19\:qint VSS) capacitor c=3.37088e-17
C165 (\21\:VDD VSS) capacitor c=5.10466e-17
C166 (\24\:VDD VSS) capacitor c=6.41638e-17
C167 (\28\:VDD VSS) capacitor c=2.2392e-17
C168 (\31\:VDD VSS) capacitor c=3.67832e-17
C169 (\34\:VDD VSS) capacitor c=2.99091e-17
C170 (\38\:VDD VSS) capacitor c=2.61329e-17
Rk9 (D \4\:D) resistor r=0.2014 c=0
Rk23 (\4\:RN RN) resistor r=0.2629 c=0
Rk47 (\1\:Q Q) resistor r=0.218 c=0
Rk48 (Q \6\:Q) resistor r=0.03303 c=0
Rk22 (SN \6\:SN) resistor r=0.1163 c=0
Rk52 (\1\:QN QN) resistor r=0.2356 c=0
Rk53 (QN \5\:QN) resistor r=0.0584 c=0
Rk99 (\1\:VDD \20\:VDD) resistor r=0.2206 c=0
Rk100 (\20\:VDD \21\:VDD) resistor r=0.05249 c=0
Rk101 (\21\:VDD \23\:VDD) resistor r=0.2872 c=0
Rk102 (\21\:VDD \24\:VDD) resistor r=0.9705 c=0
Rk103 (\24\:VDD \26\:VDD) resistor r=0.1029 c=0
Rk104 (\24\:VDD \27\:VDD) resistor r=0.1804 c=0
Rk105 (\27\:VDD \28\:VDD) resistor r=0.2723 c=0
Rk106 (\28\:VDD \30\:VDD) resistor r=0.04333 c=0
Rk107 (\28\:VDD \31\:VDD) resistor r=0.2144 c=0
Rk108 (\31\:VDD \33\:VDD) resistor r=0.1029 c=0
Rk109 (\31\:VDD \34\:VDD) resistor r=0.6167 c=0
Rk110 (\34\:VDD \36\:VDD) resistor r=0.07416 c=0
Rk111 (\34\:VDD \37\:VDD) resistor r=0.09764 c=0
Rk114 (\38\:VDD VDD) resistor r=0.2329 c=0
Rk112 (\37\:VDD \38\:VDD) resistor r=0.3184 c=0
Rk113 (\38\:VDD \40\:VDD) resistor r=0.1914 c=0
Rk5 (\8\:SE SE) resistor r=0.8605 c=0
Rk6 (SE \9\:SE) resistor r=0.03995 c=0
Rk7 (\9\:SE \10\:SE) resistor r=0.2597 c=0
Rk8 (\9\:SE \11\:SE) resistor r=0.1343 c=0
Rk1 (\4\:SI SI) resistor r=0.04057 c=0
Rk10 (CKN \4\:CKN) resistor r=0.1714 c=0
Rk71 (\1\:VSS \9\:VSS) resistor r=0.2206 c=0
Rk72 (\9\:VSS \10\:VSS) resistor r=0.7449 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.4589 c=0
Rk74 (\11\:VSS \12\:VSS) resistor r=0.4404 c=0
Rk75 (\12\:VSS \13\:VSS) resistor r=0.6961 c=0
Rk76 (\13\:VSS \14\:VSS) resistor r=0.06503 c=0
Rk78 (\15\:VSS VSS) resistor r=0.1526 c=0
Rk77 (\14\:VSS \15\:VSS) resistor r=0.3987 c=0
Rk84 (\10\:VSS \27\:VSS) resistor r=0.228 c=0
Rk85 (\12\:VSS \29\:VSS) resistor r=0.04333 c=0
Rk86 (\13\:VSS \31\:VSS) resistor r=0.3246 c=0
Rk87 (\15\:VSS \33\:VSS) resistor r=0.2463 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.3683 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.6748 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04813 c=0
Rk11 (\2\:Db \4\:Db) resistor r=0.488 c=0
Rk12 (\4\:Db \6\:Db) resistor r=0.7845 c=0
Rk13 (\6\:Db \8\:Db) resistor r=0.5667 c=0
Rk14 (\15\:CKNb \16\:CKNb) resistor r=0.2499 c=0
Rk15 (\16\:CKNb \17\:CKNb) resistor r=0.481 c=0
Rk16 (\17\:CKNb \19\:CKNb) resistor r=0.3538 c=0
Rk17 (\17\:CKNb \20\:CKNb) resistor r=0.3732 c=0
Rk18 (\19\:CKNb \22\:CKNb) resistor r=0.5788 c=0
Rk33 (\23\:CKNb \24\:CKNb) resistor r=0.3685 c=0
Rk34 (\24\:CKNb \25\:CKNb) resistor r=1.7794 c=0
Rk35 (\24\:CKNb \26\:CKNb) resistor r=0.422 c=0
Rk19 (\4\:n20 \6\:n20) resistor r=1.3129 c=0
Rk20 (\6\:n20 \8\:n20) resistor r=0.4705 c=0
Rk29 (\7\:CKNbb \9\:CKNbb) resistor r=1.9431 c=0
Rk30 (\9\:CKNbb \10\:CKNbb) resistor r=0.1391 c=0
Rk31 (\10\:CKNbb \11\:CKNbb) resistor r=0.3859 c=0
Rk32 (\10\:CKNbb \13\:CKNbb) resistor r=0.2541 c=0
Rk24 (\5\:mout \7\:mout) resistor r=0.4434 c=0
Rk25 (\7\:mout \9\:mout) resistor r=0.8606 c=0
Rk26 (\9\:mout \10\:mout) resistor r=0.4776 c=0
Rk27 (\10\:mout \12\:mout) resistor r=0.2253 c=0
Rk28 (\10\:mout \13\:mout) resistor r=0.8518 c=0
Rk36 (\7\:RNb \9\:RNb) resistor r=1.2189 c=0
Rk37 (\9\:RNb \10\:RNb) resistor r=0.7067 c=0
Rk38 (\9\:RNb \12\:RNb) resistor r=0.3508 c=0
Rk21 (\2\:net521 \4\:net521) resistor r=0.4636 c=0
Rk42 (\8\:n35 \9\:n35) resistor r=1.0156 c=0
Rk43 (\9\:n35 \11\:n35) resistor r=0.25 c=0
Rk44 (\9\:n35 \13\:n35) resistor r=0.1305 c=0
Rk39 (\2\:net0363 \4\:net0363) resistor r=0.3236 c=0
Rk40 (\2\:net498 \4\:net498) resistor r=0.4095 c=0
Rk56 (\20\:qbint \21\:qbint) resistor r=2.0416 c=0
Rk57 (\21\:qbint \22\:qbint) resistor r=0.08306 c=0
Rk58 (\22\:qbint \23\:qbint) resistor r=0.3426 c=0
Rk59 (\21\:qbint \24\:qbint) resistor r=0.09617 c=0
Rk60 (\24\:qbint \26\:qbint) resistor r=0.2737 c=0
Rk61 (\22\:qbint \28\:qbint) resistor r=0.05853 c=0
Rk62 (\24\:qbint \29\:qbint) resistor r=0.2041 c=0
Rk63 (\17\:qint \18\:qint) resistor r=0.3995 c=0
Rk64 (\18\:qint \19\:qint) resistor r=0.2082 c=0
Rk65 (\18\:qint \21\:qint) resistor r=0.1833 c=0
Rk41 (\2\:net566 \4\:net566) resistor r=0.679 c=0
Rl9 (\1\:D \2\:D) resistor r=186.333 c=0
Rl10 (\2\:D \3\:D) resistor r=43.7671 c=0
Rl29 (\2\:RN \3\:RN) resistor r=60.7713 c=0
Rl28 (\1\:RN \2\:RN) resistor r=45.708 c=0
Rl38 (\1\:SN \2\:SN) resistor r=223.077 c=0
Rl39 (\2\:SN \3\:SN) resistor r=928.412 c=0
Rl41 (\4\:SN \5\:SN) resistor r=60.7713 c=0
Rl40 (\3\:SN \4\:SN) resistor r=189.939 c=0
Rl8 (\6\:SE \7\:SE) resistor r=79.5379 c=0
Rl5 (\4\:SE \5\:SE) resistor r=47.3097 c=0
Rl1 (\1\:SE \2\:SE) resistor r=251.489 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl3 (\1\:SI \2\:SI) resistor r=144.923 c=0
Rl4 (\2\:SI \3\:SI) resistor r=85.3072 c=0
Rl11 (\1\:CKN \2\:CKN) resistor r=109.615 c=0
Rl12 (\2\:CKN \3\:CKN) resistor r=59.0659 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl6 (SEb \2\:SEb) resistor r=263.567 c=0
Rl33 (\13\:CKNb \14\:CKNb) resistor r=120.667 c=0
Rl30 (\11\:CKNb \12\:CKNb) resistor r=37.6944 c=0
Rl16 (\3\:CKNb \4\:CKNb) resistor r=29.5379 c=0
Rl13 (CKNb \2\:CKNb) resistor r=64.1533 c=0
Rl19 (\5\:CKNb \6\:CKNb) resistor r=49.7141 c=0
Rl20 (\6\:CKNb \7\:CKNb) resistor r=1.2666 c=0
Rl22 (\8\:CKNb \9\:CKNb) resistor r=35.7866 c=0
Rl23 (\8\:CKNb \10\:CKNb) resistor r=92.8494 c=0
Rl21 (\6\:CKNb \8\:CKNb) resistor r=44.8859 c=0
Rl25 (n20 \3\:n20) resistor r=123.077 c=0
Rl24 (n20 \2\:n20) resistor r=139.617 c=0
Rl31 (\4\:CKNbb \5\:CKNbb) resistor r=176.054 c=0
Rl32 (\5\:CKNbb \6\:CKNbb) resistor r=64.1533 c=0
Rl14 (CKNbb \2\:CKNbb) resistor r=24.7951 c=0
Rl15 (\2\:CKNbb \3\:CKNbb) resistor r=172.62 c=0
Rl17 (mout \2\:mout) resistor r=169.231 c=0
Rl18 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl26 (RNb \2\:RNb) resistor r=143.796 c=0
Rl34 (\4\:RNb \5\:RNb) resistor r=138.439 c=0
Rl35 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl27 (\2\:RNb \3\:RNb) resistor r=249.513 c=0
Rl75 (\18\:qbint \19\:qbint) resistor r=110.555 c=0
Rl74 (\18\:qbint \17\:qbint) resistor r=34.6284 c=0
Rl36 (\2\:qbint qbint) resistor r=164.153 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=33.3841 c=0
Rz33 (\1\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz34 (\20\:VDD \3\:VDD) resistor r=6.25 c=0
Rz35 (\27\:VDD \3\:VDD) resistor r=6.25 c=0
Rz36 (\37\:VDD \3\:VDD) resistor r=6.25 c=0
Rz29 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz30 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz31 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz32 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz4 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz5 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (\12\:CKNbb \13\:CKNbb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz6 (net521 \2\:net521) resistor r=75 c=0
Rz7 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz16 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz12 (net0363 \2\:net0363) resistor r=75 c=0
Rz13 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz14 (net498 \2\:net498) resistor r=75 c=0
Rz15 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz21 (\28\:qbint \27\:qbint) resistor r=75 c=0
Rz22 (\17\:qint \16\:qint) resistor r=75 c=0
Ry30 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry31 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry32 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry33 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry34 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry35 (\40\:VDD \39\:VDD) resistor r=62 c=0
Ry19 (\1\:VSS \3\:VSS) resistor r=5.6364 c=0
Ry20 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry21 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\14\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\5\:Db \6\:Db) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry8 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry12 (\13\:n35 \12\:n35) resistor r=62 c=0
Ry17 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry18 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Ry10 (net566 \2\:net566) resistor r=62 c=0
Ry11 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx13 (\2\:RN \4\:RN) resistor r=45 c=0
Rx12 (\4\:SN \6\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\7\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\4\:CKNb \16\:CKNb) resistor r=45 c=0
Rx10 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx17 (\12\:CKNb \23\:CKNb) resistor r=45 c=0
Rx18 (\10\:CKNb \25\:CKNb) resistor r=45 c=0
Rx19 (\13\:CKNb \26\:CKNb) resistor r=45 c=0
Rx11 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx15 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx16 (\2\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx14 (\3\:mout \13\:mout) resistor r=45 c=0
Rx20 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx21 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx22 (\8\:n35 n35) resistor r=45 c=0
Rx23 (\20\:qbint \18\:qbint) resistor r=45 c=0
Rx24 (\23\:qbint \2\:qbint) resistor r=45 c=0
Rx25 (\29\:qbint \4\:qbint) resistor r=45 c=0
Rx26 (\19\:qint qint) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.88e-14 ad=2.465e-14 ps=1.12e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.43448e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn13 (net538 \3\:SI \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.88e-14 ad=8.7e-15 ps=1.12e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=9.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn14 (\7\:Db \4\:SE net538 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=8.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn12 (\7\:Db SEb net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=3.698e-14 ps=5.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net546 \3\:D \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=1.595e-14 ps=6.9e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=3.85e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn20 (\18\:CKNb \3\:CKN \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (Db \3\:CKNbb \7\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=8.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKNb net582 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=3.045e-14 ps=5.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net582 \2\:mout \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.877e-14 ad=1.667e-14 ps=1.85e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=4.1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\12\:CKNbb \5\:CKNb \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.877e-14 ad=2.03e-14 ps=1.85e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn31 (\11\:mout \2\:RNb net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.32e-14 ps=7.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.24e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn32 (\11\:mout \3\:n20 \3\:net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.482e-14 ad=2.32e-14 ps=1.46e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.035e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\3\:net521 \3\:SN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.75e-14 ad=8.482e-14 ps=9.9e-07 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=4.05e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn22 (\8\:RNb \1\:RN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\4\:mout \11\:CKNb \10\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn53 (\10\:n35 \4\:CKNbb net0363 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\3\:net0363 \6\:RNb \3\:net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.392e-14 ps=6.9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn52 (\3\:net0363 \3\:qbint net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn50 (net498 \2\:SN \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn45_1__rcx (\27\:qbint n35 \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.861e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.09268e-07 sb=2e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(2)
mn56 (\16\:qint \17\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn55_1__rcx (\1\:Q \4\:qbint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.061e-14 ad=4.16e-14 ps=1.3475e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.39135e-07 sb=2e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.342e-14 ad=4.16e-14 ps=1.3475e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70346e-06 sb=1.165e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
mp45_1__rcx (\25\:qbint n35 \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.776e-14 ad=4.96e-14 ps=1.165e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.64677e-07 sb=2e-06 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(2)
mp56 (\20\:qint \19\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96308e-06 sb=1.4e-07 sd=160n sca=27.1678 \
        scb=0.0200607 scc=0.00278 m=(1)
mp55_1__rcx (\6\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.353e-14 ad=7.312e-14 ps=1.115e-06 pd=1.155e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.19103e-07 sb=1.86e-06 sd=160n \
        sca=25.6993 scb=0.0190507 scc=0.00277827 m=(4)
mp57_1__rcx (\5\:QN qint \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.727e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64724e-06 sb=9.85e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
ends SDFFNSRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:32 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFNSRXL
// View name: extracted

simulator lang=spectre

subckt SDFFNSRXL CKN D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:qint \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
mp56 (\5\:qint \7\:qbint \30\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp22 (\9\:RNb \1\:RN \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp45 (\16\:qbint n35 \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.01e-14 ps=1.73e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp50 (\3\:net566 \1\:SN \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.89e-14 ad=4.515e-14 ps=1.73e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp52 (\3\:net566 \8\:qbint net414 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.902e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.7e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp51 (net414 \2\:RNb \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=2.902e-14 ps=1.67e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.9e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp53 (\8\:n35 \2\:CKNb net566 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=5.375e-14 ps=9e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\8\:n35 CKNbb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.375e-14 ps=7.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (net478 \4\:RNb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.805e-14 ad=4.408e-14 ps=2.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.01767e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp32 (\10\:mout n20 net478 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.763e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.67674e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp30 (\10\:mout \5\:SN \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.763e-14 ps=1.81e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=5.47674e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp35 (net486 mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=2.15e-14 ps=1.81e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.14535e-07 sb=6.65e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp36 (\4\:n20 \8\:CKNbb net486 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=6.45e-14 ps=6.3e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.59535e-07 sb=5.2e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp25 (\4\:n20 \11\:CKNb \8\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=6.45e-14 ps=7.8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10453e-06 sb=1.75e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp21 (\11\:CKNbb \3\:CKNb \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp20 (\14\:CKNb \1\:CKN \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.395e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp11 (net461 \1\:D \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.688e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.19e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp12 (\6\:Db \2\:SE net461 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.688e-14 ad=6.45e-14 ps=6.8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.02e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp14 (\6\:Db SEb net453 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=6.45e-14 ps=7.2e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=6.75e-07 sd=160n sca=12.7214 \
        scb=0.0110237 scc=0.000332196 m=(1)
mp13 (net453 \1\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=3.118e-14 ps=1.19e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=4.85e-07 sd=160n sca=13.8366 \
        scb=0.012107 scc=0.000335122 m=(1)
mp10 (\6\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=4.73e-14 ps=1.19e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=2.2e-07 sd=160n sca=19.4835 \
        scb=0.0215572 scc=0.000673289 m=(1)
C1 (CKN VSS) capacitor c=5.73297e-17
C2 (QN VSS) capacitor c=2.29654e-17
C3 (SN VSS) capacitor c=2.69945e-16
C4 (SI VSS) capacitor c=7.71195e-17
C5 (VDD VSS) capacitor c=5.14473e-16
C6 (RN VSS) capacitor c=9.91187e-17
C7 (D VSS) capacitor c=6.59313e-17
C8 (Q VSS) capacitor c=2.72249e-17
C9 (qint VSS) capacitor c=2.2096e-17
C10 (qbint VSS) capacitor c=4.21215e-17
C11 (RNb VSS) capacitor c=6.34628e-17
C12 (n35 VSS) capacitor c=4.33108e-17
C13 (net498 VSS) capacitor c=7.65386e-17
C14 (net0363 VSS) capacitor c=1.09657e-16
C15 (CKNbb VSS) capacitor c=2.68744e-17
C16 (mout VSS) capacitor c=5.68864e-17
C17 (CKNb VSS) capacitor c=3.83074e-17
C18 (net521 VSS) capacitor c=7.28116e-17
C19 (n20 VSS) capacitor c=5.42891e-17
C20 (Db VSS) capacitor c=4.25194e-17
C21 (net546 VSS) capacitor c=5.39102e-18
C22 (SEb VSS) capacitor c=2.81075e-17
C23 (net566 VSS) capacitor c=1.03595e-16
C24 (net414 VSS) capacitor c=4.45039e-18
C25 (net478 VSS) capacitor c=3.50425e-18
C26 (net486 VSS) capacitor c=1.12332e-18
C27 (net453 VSS) capacitor c=4.7683e-18
C28 (\5\:SE VSS) capacitor c=5.03188e-17
C29 (\1\:SI VSS) capacitor c=4.73241e-17
C30 (\2\:SE VSS) capacitor c=5.16821e-17
C31 (\1\:D VSS) capacitor c=4.68944e-17
C32 (\1\:CKN VSS) capacitor c=5.31603e-17
C33 (\3\:CKNb VSS) capacitor c=1.72835e-17
C34 (\11\:CKNb VSS) capacitor c=3.46091e-17
C35 (\8\:CKNbb VSS) capacitor c=5.44493e-17
C36 (\5\:SN VSS) capacitor c=5.74178e-17
C37 (\4\:RNb VSS) capacitor c=5.70539e-17
C38 (\2\:CKNb VSS) capacitor c=4.61055e-17
C39 (\2\:RNb VSS) capacitor c=4.61039e-17
C40 (\8\:qbint VSS) capacitor c=6.08167e-17
C41 (\1\:SN VSS) capacitor c=3.38024e-17
C42 (\1\:RN VSS) capacitor c=3.84519e-17
C43 (\7\:qbint VSS) capacitor c=2.82168e-17
C44 (\4\:qint VSS) capacitor c=3.11966e-17
C45 (\7\:SE VSS) capacitor c=2.70425e-17
C46 (\3\:SI VSS) capacitor c=7.5854e-17
C47 (\3\:SE VSS) capacitor c=6.71769e-17
C48 (\3\:SEb VSS) capacitor c=5.34492e-17
C49 (\3\:D VSS) capacitor c=2.6998e-17
C50 (\3\:CKN VSS) capacitor c=3.18467e-17
C51 (\10\:CKNb VSS) capacitor c=2.84141e-17
C52 (\5\:CKNbb VSS) capacitor c=4.61753e-17
C53 (\6\:CKNb VSS) capacitor c=1.54765e-16
C54 (\3\:mout VSS) capacitor c=6.98781e-17
C55 (\7\:SN VSS) capacitor c=6.66809e-17
C56 (\3\:n20 VSS) capacitor c=3.76428e-17
C57 (\6\:RNb VSS) capacitor c=5.30499e-17
C58 (\8\:CKNb VSS) capacitor c=2.78959e-17
C59 (\3\:CKNbb VSS) capacitor c=5.02167e-17
C60 (\9\:qbint VSS) capacitor c=5.79521e-17
C61 (\4\:SN VSS) capacitor c=4.95273e-17
C62 (\3\:n35 VSS) capacitor c=3.62926e-17
C63 (\3\:RN VSS) capacitor c=4.28742e-17
C64 (\6\:qbint VSS) capacitor c=2.38535e-17
C65 (\4\:qbint VSS) capacitor c=2.07847e-17
C66 (\3\:qint VSS) capacitor c=2.7181e-17
C67 (\6\:SE VSS) capacitor c=4.12509e-17
C68 (\2\:SI VSS) capacitor c=4.47846e-17
C69 (\2\:SEb VSS) capacitor c=8.03608e-17
C70 (\4\:SE VSS) capacitor c=5.02239e-17
C71 (\1\:SE VSS) capacitor c=4.19924e-17
C72 (\2\:D VSS) capacitor c=3.8229e-17
C73 (\2\:CKN VSS) capacitor c=3.74895e-17
C74 (\9\:CKNb VSS) capacitor c=1.27537e-17
C75 (\7\:CKNbb VSS) capacitor c=4.37289e-17
C76 (\6\:CKNbb VSS) capacitor c=3.26084e-17
C77 (\2\:mout VSS) capacitor c=5.62741e-17
C78 (\6\:SN VSS) capacitor c=3.60551e-17
C79 (\2\:n20 VSS) capacitor c=3.54406e-17
C80 (\4\:CKNbb VSS) capacitor c=4.53886e-17
C81 (\5\:RNb VSS) capacitor c=2.83961e-17
C82 (\7\:CKNb VSS) capacitor c=7.08571e-17
C83 (\3\:RNb VSS) capacitor c=2.25936e-17
C84 (\10\:qbint VSS) capacitor c=2.86315e-17
C85 (\3\:SN VSS) capacitor c=2.68438e-17
C86 (\2\:n35 VSS) capacitor c=3.67618e-17
C87 (\2\:RN VSS) capacitor c=4.08156e-17
C88 (\5\:qbint VSS) capacitor c=1.75616e-17
C89 (\6\:SEb VSS) capacitor c=1.07387e-16
C90 (\1\:VDD VSS) capacitor c=2.36721e-17
C91 (\6\:Db VSS) capacitor c=7.05087e-17
C92 (\6\:VDD VSS) capacitor c=3.96988e-17
C93 (\14\:CKNb VSS) capacitor c=9.0315e-17
C94 (\9\:VDD VSS) capacitor c=9.96601e-18
C95 (\11\:CKNbb VSS) capacitor c=1.10114e-16
C96 (\8\:Db VSS) capacitor c=1.12843e-16
C97 (\4\:n20 VSS) capacitor c=6.4746e-17
C98 (\13\:VDD VSS) capacitor c=1.26503e-17
C99 (\10\:mout VSS) capacitor c=3.59038e-17
C100 (\16\:VDD VSS) capacitor c=2.14913e-17
C101 (\8\:mout VSS) capacitor c=6.62443e-17
C102 (\8\:n35 VSS) capacitor c=4.56562e-17
C103 (\20\:VDD VSS) capacitor c=3.19485e-17
C104 (\3\:net566 VSS) capacitor c=1.03852e-16
C105 (\23\:VDD VSS) capacitor c=2.7592e-17
C106 (\16\:qbint VSS) capacitor c=6.86266e-17
C107 (\9\:RNb VSS) capacitor c=1.50433e-16
C108 (\26\:VDD VSS) capacitor c=3.88831e-17
C109 (\5\:qint VSS) capacitor c=2.54137e-17
C110 (\30\:VDD VSS) capacitor c=3.82726e-17
C111 (\1\:QN VSS) capacitor c=1.97577e-17
C112 (\3\:VDD VSS) capacitor c=1.08737e-16
C113 (\4\:SEb VSS) capacitor c=7.86725e-17
C114 (\18\:CKNb VSS) capacitor c=5.02557e-17
C115 (\9\:CKNbb VSS) capacitor c=7.47055e-17
C116 (\4\:Db VSS) capacitor c=1.96888e-16
C117 (\7\:n20 VSS) capacitor c=3.4718e-17
C118 (\12\:mout VSS) capacitor c=2.82065e-17
C119 (\3\:net521 VSS) capacitor c=8.27919e-17
C120 (\14\:mout VSS) capacitor c=4.14339e-17
C121 (\4\:n35 VSS) capacitor c=9.10524e-17
C122 (\3\:net0363 VSS) capacitor c=1.15886e-16
C123 (\3\:net498 VSS) capacitor c=6.73179e-17
C124 (\14\:qbint VSS) capacitor c=4.49483e-17
C125 (\11\:RNb VSS) capacitor c=1.09604e-16
C126 (\4\:Q VSS) capacitor c=8.29098e-17
C127 (\9\:qint VSS) capacitor c=2.9431e-17
C128 (\3\:QN VSS) capacitor c=4.27257e-17
C129 (\2\:qint VSS) capacitor c=1.33267e-17
C130 (\2\:qbint VSS) capacitor c=3.55733e-17
C131 (\3\:qbint VSS) capacitor c=4.52496e-17
C132 (\2\:SN VSS) capacitor c=2.43536e-17
C133 (\2\:CKNbb VSS) capacitor c=4.40445e-17
C134 (\7\:qint VSS) capacitor c=2.25757e-17
C135 (\8\:qint VSS) capacitor c=3.57583e-17
C136 (\3\:Q VSS) capacitor c=6.39461e-17
C137 (\4\:CKNb VSS) capacitor c=1.93208e-17
C138 (\5\:CKNb VSS) capacitor c=6.92071e-17
C139 (\11\:qbint VSS) capacitor c=5.09211e-17
C140 (\12\:qbint VSS) capacitor c=1.19332e-16
C141 (\13\:qbint VSS) capacitor c=1.17712e-16
C142 (\6\:n35 VSS) capacitor c=1.93698e-16
C143 (\7\:n35 VSS) capacitor c=1.30154e-16
C144 (\12\:CKNb VSS) capacitor c=9.64988e-17
C145 (\13\:CKNb VSS) capacitor c=1.13116e-16
C146 (\7\:RNb VSS) capacitor c=1.55427e-16
C147 (\8\:RNb VSS) capacitor c=2.32954e-16
C148 (\8\:SN VSS) capacitor c=2.68185e-16
C149 (\9\:SN VSS) capacitor c=3.13286e-17
C150 (\4\:mout VSS) capacitor c=5.1091e-17
C151 (\5\:mout VSS) capacitor c=5.49996e-17
C152 (\6\:mout VSS) capacitor c=6.01698e-17
C153 (\7\:mout VSS) capacitor c=6.83169e-17
C154 (\6\:n20 VSS) capacitor c=8.83829e-17
C155 (\9\:n20 VSS) capacitor c=8.01587e-17
C156 (\13\:CKNbb VSS) capacitor c=1.48667e-16
C157 (\14\:CKNbb VSS) capacitor c=6.32091e-17
C158 (\15\:CKNbb VSS) capacitor c=5.45105e-17
C159 (\16\:CKNbb VSS) capacitor c=1.69515e-16
C160 (\4\:CKN VSS) capacitor c=4.17202e-17
C161 (\16\:CKNb VSS) capacitor c=9.72188e-17
C162 (\17\:CKNb VSS) capacitor c=2.45643e-17
C163 (\4\:D VSS) capacitor c=3.81649e-17
C164 (\3\:Db VSS) capacitor c=2.19111e-16
C165 (\8\:SE VSS) capacitor c=5.57541e-17
C166 (\9\:SE VSS) capacitor c=7.77036e-17
C167 (\10\:SE VSS) capacitor c=7.84055e-17
C168 (\4\:SI VSS) capacitor c=4.33155e-17
C169 (\8\:SEb VSS) capacitor c=7.6843e-17
C170 (\5\:VDD VSS) capacitor c=3.04827e-17
C171 (\8\:VDD VSS) capacitor c=8.64668e-18
C172 (\12\:VDD VSS) capacitor c=4.26071e-17
C173 (\15\:VDD VSS) capacitor c=2.88321e-17
C174 (\19\:VDD VSS) capacitor c=3.62928e-17
C175 (\22\:VDD VSS) capacitor c=4.15942e-17
C176 (\25\:VDD VSS) capacitor c=2.3446e-17
C177 (\29\:VDD VSS) capacitor c=1.06947e-17
Rk42 (\4\:CKN CKN) resistor r=0.1665 c=0
Rk2 (\4\:QN QN) resistor r=0.09288 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk51 (\8\:SE \9\:SE) resistor r=0.2657 c=0
Rk53 (\10\:SE SE) resistor r=0.01279 c=0
Rk52 (\9\:SE \10\:SE) resistor r=0.2765 c=0
Rk25 (\8\:SN SN) resistor r=2.0735 c=0
Rk26 (SN \9\:SN) resistor r=0.1035 c=0
Rk54 (SI \4\:SI) resistor r=0.1871 c=0
Rk57 (\2\:VDD \4\:VDD) resistor r=0.2305 c=0
Rk58 (\4\:VDD \5\:VDD) resistor r=0.4818 c=0
Rk59 (\5\:VDD \7\:VDD) resistor r=0.2911 c=0
Rk60 (\5\:VDD \8\:VDD) resistor r=0.283 c=0
Rk61 (\8\:VDD \10\:VDD) resistor r=0.07393 c=0
Rk62 (\8\:VDD \11\:VDD) resistor r=0.03742 c=0
Rk63 (\11\:VDD \12\:VDD) resistor r=0.5481 c=0
Rk64 (\12\:VDD \14\:VDD) resistor r=0.04331 c=0
Rk65 (\12\:VDD \15\:VDD) resistor r=0.4416 c=0
Rk66 (\15\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk67 (\15\:VDD \18\:VDD) resistor r=0.2095 c=0
Rk68 (\18\:VDD \19\:VDD) resistor r=0.2998 c=0
Rk69 (\19\:VDD \21\:VDD) resistor r=0.04331 c=0
Rk70 (\19\:VDD \22\:VDD) resistor r=0.3588 c=0
Rk71 (\22\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk72 (\22\:VDD \25\:VDD) resistor r=0.4651 c=0
Rk73 (\25\:VDD \27\:VDD) resistor r=0.2815 c=0
Rk74 (\25\:VDD \28\:VDD) resistor r=0.07504 c=0
Rk77 (\29\:VDD VDD) resistor r=0.2127 c=0
Rk75 (\28\:VDD \29\:VDD) resistor r=0.3384 c=0
Rk76 (\29\:VDD \31\:VDD) resistor r=0.4181 c=0
Rk9 (\4\:RN RN) resistor r=0.004839 c=0
Rk46 (\4\:D D) resistor r=0.08852 c=0
Rk7 (\3\:Q Q) resistor r=0.07888 c=0
Rk6 (\2\:Q \3\:Q) resistor r=0.03859 c=0
Rk8 (\3\:Q \5\:Q) resistor r=0.502 c=0
Rk78 (\2\:VSS \3\:VSS) resistor r=0.03742 c=0
Rk79 (\3\:VSS \4\:VSS) resistor r=0.4435 c=0
Rk80 (\4\:VSS \5\:VSS) resistor r=0.2745 c=0
Rk81 (\5\:VSS \6\:VSS) resistor r=0.044 c=0
Rk82 (\6\:VSS \7\:VSS) resistor r=0.534 c=0
Rk83 (\7\:VSS \8\:VSS) resistor r=0.6694 c=0
Rk84 (\8\:VSS \9\:VSS) resistor r=0.691 c=0
Rk85 (\9\:VSS \10\:VSS) resistor r=0.435 c=0
Rk86 (\10\:VSS \11\:VSS) resistor r=0.07504 c=0
Rk88 (\12\:VSS VSS) resistor r=0.2127 c=0
Rk87 (\11\:VSS \12\:VSS) resistor r=0.3384 c=0
Rk89 (\3\:VSS \14\:VSS) resistor r=0.3134 c=0
Rk90 (\4\:VSS \16\:VSS) resistor r=0.3234 c=0
Rk91 (\5\:VSS \18\:VSS) resistor r=0.04331 c=0
Rk92 (\7\:VSS \20\:VSS) resistor r=0.3223 c=0
Rk93 (\9\:VSS \22\:VSS) resistor r=0.04331 c=0
Rk94 (\10\:VSS \24\:VSS) resistor r=0.2878 c=0
Rk95 (\12\:VSS \26\:VSS) resistor r=0.3692 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1148 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1194 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1088 c=0
Rk10 (\11\:qbint \12\:qbint) resistor r=0.3772 c=0
Rk11 (\12\:qbint \13\:qbint) resistor r=0.8163 c=0
Rk12 (\12\:qbint \15\:qbint) resistor r=0.1081 c=0
Rk13 (\15\:qbint \17\:qbint) resistor r=0.4093 c=0
Rk21 (\7\:RNb \8\:RNb) resistor r=1.0765 c=0
Rk22 (\8\:RNb \10\:RNb) resistor r=0.9729 c=0
Rk23 (\10\:RNb \12\:RNb) resistor r=0.6681 c=0
Rk17 (\5\:n35 \6\:n35) resistor r=0.4954 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=1.0387 c=0
Rk19 (\6\:n35 \9\:n35) resistor r=0.1739 c=0
Rk14 (\2\:net498 \4\:net498) resistor r=0.4348 c=0
Rk16 (\2\:net0363 \4\:net0363) resistor r=0.7318 c=0
Rk37 (\10\:CKNbb \12\:CKNbb) resistor r=0.3745 c=0
Rk38 (\12\:CKNbb \13\:CKNbb) resistor r=0.531 c=0
Rk39 (\13\:CKNbb \14\:CKNbb) resistor r=0.2842 c=0
Rk40 (\14\:CKNbb \15\:CKNbb) resistor r=0.1332 c=0
Rk41 (\13\:CKNbb \16\:CKNbb) resistor r=1.1535 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2406 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.3342 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.2689 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.395 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.09337 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1022 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1469 c=0
Rk20 (\12\:CKNb \13\:CKNb) resistor r=0.5141 c=0
Rk43 (\15\:CKNb \16\:CKNb) resistor r=0.6458 c=0
Rk44 (\16\:CKNb \17\:CKNb) resistor r=0.04241 c=0
Rk45 (\16\:CKNb \19\:CKNb) resistor r=0.288 c=0
Rk24 (\2\:net521 \4\:net521) resistor r=0.5131 c=0
Rk34 (\5\:n20 \6\:n20) resistor r=0.3746 c=0
Rk35 (\6\:n20 \8\:n20) resistor r=0.1396 c=0
Rk36 (\6\:n20 \9\:n20) resistor r=0.398 c=0
Rk47 (\2\:Db \3\:Db) resistor r=0.3037 c=0
Rk48 (\3\:Db \5\:Db) resistor r=1.3668 c=0
Rk49 (\3\:Db \7\:Db) resistor r=0.4492 c=0
Rk50 (\5\:Db \9\:Db) resistor r=0.5648 c=0
Rk55 (\5\:SEb \7\:SEb) resistor r=0.633 c=0
Rk56 (\7\:SEb \8\:SEb) resistor r=0.5733 c=0
Rk15 (\2\:net566 \4\:net566) resistor r=0.3873 c=0
Rl43 (\1\:CKN \2\:CKN) resistor r=114.183 c=0
Rl44 (\2\:CKN \3\:CKN) resistor r=91.5405 c=0
Rl53 (\5\:SE \6\:SE) resistor r=144.231 c=0
Rl54 (\6\:SE \7\:SE) resistor r=28.2967 c=0
Rl50 (\3\:SE \4\:SE) resistor r=41.5405 c=0
Rl47 (\1\:SE \2\:SE) resistor r=63.2246 c=0
Rl30 (\5\:SN \7\:SN) resistor r=146.154 c=0
Rl29 (\5\:SN \6\:SN) resistor r=59.5926 c=0
Rl14 (\1\:SN \2\:SN) resistor r=36.5533 c=0
Rl16 (\2\:SN \4\:SN) resistor r=89.5925 c=0
Rl15 (\2\:SN \3\:SN) resistor r=5.4946 c=0
Rl51 (\1\:SI \2\:SI) resistor r=66.0764 c=0
Rl52 (\2\:SI \3\:SI) resistor r=109.94 c=0
Rl10 (\1\:RN \2\:RN) resistor r=119.922 c=0
Rl11 (\2\:RN \3\:RN) resistor r=89.1533 c=0
Rl45 (\1\:D \2\:D) resistor r=80.0021 c=0
Rl46 (\2\:D \3\:D) resistor r=87.6944 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl1 (qint \2\:qint) resistor r=2.0213 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=153.412 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=111.052 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=29.5379 c=0
Rl4 (qbint \2\:qbint) resistor r=147.31 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=28.7715 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=224.363 c=0
Rl26 (\4\:RNb \6\:RNb) resistor r=146.154 c=0
Rl19 (RNb \2\:RNb) resistor r=163.027 c=0
Rl25 (\4\:RNb \5\:RNb) resistor r=109.128 c=0
Rl20 (\2\:RNb \3\:RNb) resistor r=78.079 c=0
Rl12 (n35 \2\:n35) resistor r=88.4615 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=29.9451 c=0
Rl34 (\7\:CKNbb \8\:CKNbb) resistor r=63.2246 c=0
Rl33 (\5\:CKNbb \6\:CKNbb) resistor r=26.1559 c=0
Rl22 (CKNbb \2\:CKNbb) resistor r=28.0797 c=0
Rl23 (\2\:CKNbb \3\:CKNbb) resistor r=137.261 c=0
Rl24 (\2\:CKNbb \4\:CKNbb) resistor r=179.219 c=0
Rl31 (mout \2\:mout) resistor r=60.7134 c=0
Rl32 (\2\:mout \3\:mout) resistor r=87.6365 c=0
Rl41 (\9\:CKNb \10\:CKNb) resistor r=39.1533 c=0
Rl38 (\6\:CKNb \7\:CKNb) resistor r=505.975 c=0
Rl39 (\7\:CKNb \8\:CKNb) resistor r=32.0175 c=0
Rl21 (CKNb \2\:CKNb) resistor r=55.1375 c=0
Rl35 (\3\:CKNb \4\:CKNb) resistor r=38.0255 c=0
Rl40 (\4\:CKNb \9\:CKNb) resistor r=11.3405 c=0
Rl42 (\5\:CKNb \11\:CKNb) resistor r=82.3738 c=0
Rl37 (\5\:CKNb \6\:CKNb) resistor r=228.824 c=0
Rl36 (\4\:CKNb \5\:CKNb) resistor r=159.512 c=0
Rl27 (n20 \2\:n20) resistor r=91.0764 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl48 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=179.104 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz21 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz22 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz23 (\3\:VDD \18\:VDD) resistor r=6.25 c=0
Rz24 (\3\:VDD \28\:VDD) resistor r=6.25 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz25 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz26 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz27 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz28 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz30 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz31 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (net498 \2\:net498) resistor r=75 c=0
Rz6 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz7 (net0363 \2\:net0363) resistor r=75 c=0
Rz8 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz16 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz17 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz11 (net521 \2\:net521) resistor r=75 c=0
Rz12 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz15 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry17 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry18 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry19 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry20 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry21 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry22 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry23 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry24 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry25 (\30\:VDD \31\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry27 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry28 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\1\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\11\:CKNbb \12\:CKNbb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry13 (\14\:CKNb \15\:CKNb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\6\:SEb \7\:SEb) resistor r=62 c=0
Ry5 (net566 \2\:net566) resistor r=62 c=0
Ry6 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx17 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\6\:SN \8\:SN) resistor r=45 c=0
Rx11 (\3\:SN \9\:SN) resistor r=45 c=0
Rx23 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\5\:qbint \13\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx14 (\7\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx15 (\6\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx16 (\4\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx6 (\7\:CKNb \12\:CKNb) resistor r=45 c=0
Rx7 (CKNb \13\:CKNb) resistor r=45 c=0
Rx18 (\9\:CKNb \17\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\4\:Q \6\:qbint \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn22 (\11\:RNb \3\:RN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=3.48e-14 ps=6.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn45 (\14\:qbint \3\:n35 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.87e-14 ad=2.392e-14 ps=1.51e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=1e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn50 (\3\:net498 \4\:SN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.87e-14 ad=5.002e-14 ps=1.51e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=7.35e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn52 (\3\:net0363 \9\:qbint \3\:net498 VSS) g45n1hvt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=5.002e-14 ad=2.32e-14 ps=9.8e-07 pd=6.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=8.2e-07 sb=3.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn51 (\3\:net0363 RNb net498 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn53 (\4\:n35 \3\:CKNbb net0363 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.277e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn40 (\14\:mout \8\:CKNb \4\:n35 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.277e-14 ad=2.03e-14 ps=8.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn31 (\12\:mout \6\:RNb \3\:net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.125e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn32 (\12\:mout \3\:n20 net521 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.972e-14 ps=6.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=8.75e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (net521 \7\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn35 (net582 \3\:mout \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn36 (\7\:n20 \6\:CKNb net582 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (\4\:Db \5\:CKNbb \7\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\9\:CKNbb \10\:CKNb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.725e-14 ad=3.335e-14 ps=1.34e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.3e-07 sb=1.7e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn20 (\18\:CKNb \3\:CKN \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn11 (net546 \3\:D \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=4.713e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.035e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn12 (Db \3\:SEb net546 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=6.65e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn14 (Db \3\:SE net538 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=4.6e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn13 (net538 \3\:SI \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=3.55e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\4\:SEb \7\:SE \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
ends SDFFNSRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:33 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFQX1
// View name: extracted

simulator lang=spectre

subckt SDFFQX1 CK D Q SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=31.6283 \
        scb=0.0342226 scc=0.00291148 m=(1)
C1 (D VSS) capacitor c=4.3067e-17
C2 (VDD VSS) capacitor c=3.31884e-16
C3 (CK VSS) capacitor c=5.90759e-17
C4 (SE VSS) capacitor c=3.08013e-17
C5 (SI VSS) capacitor c=1.32611e-16
C6 (qbint VSS) capacitor c=2.27149e-17
C7 (CKb VSS) capacitor c=4.4339e-17
C8 (n30 VSS) capacitor c=5.33233e-17
C9 (mout VSS) capacitor c=7.97432e-17
C10 (CKbb VSS) capacitor c=2.02515e-17
C11 (n20 VSS) capacitor c=4.09305e-17
C12 (Db VSS) capacitor c=9.49768e-17
C13 (n1 VSS) capacitor c=5.34612e-18
C14 (SEb VSS) capacitor c=7.17568e-17
C15 (n8 VSS) capacitor c=4.67726e-18
C16 (n6 VSS) capacitor c=7.53389e-20
C17 (n2 VSS) capacitor c=5.98587e-18
C18 (\5\:SE VSS) capacitor c=5.31411e-17
C19 (\1\:SI VSS) capacitor c=7.69307e-17
C20 (\1\:SE VSS) capacitor c=4.0696e-17
C21 (\1\:D VSS) capacitor c=6.87584e-17
C22 (\5\:CKb VSS) capacitor c=5.38282e-17
C23 (\6\:CKbb VSS) capacitor c=4.47157e-17
C24 (\8\:CKb VSS) capacitor c=7.1457e-17
C25 (\3\:n20 VSS) capacitor c=4.10905e-17
C26 (\3\:CKb VSS) capacitor c=5.9405e-17
C27 (\3\:CKbb VSS) capacitor c=4.97296e-17
C28 (\5\:qbint VSS) capacitor c=5.06633e-17
C29 (\1\:CK VSS) capacitor c=3.09963e-17
C30 (\4\:qbint VSS) capacitor c=4.76205e-17
C31 (\7\:SE VSS) capacitor c=2.97817e-17
C32 (\3\:SI VSS) capacitor c=7.18951e-17
C33 (\3\:SE VSS) capacitor c=6.70128e-17
C34 (\3\:SEb VSS) capacitor c=5.65183e-17
C35 (\3\:D VSS) capacitor c=4.12888e-17
C36 (\9\:CKb VSS) capacitor c=4.243e-17
C37 (\10\:CKb VSS) capacitor c=2.82446e-17
C38 (\4\:CKbb VSS) capacitor c=8.46074e-17
C39 (\3\:mout VSS) capacitor c=5.4077e-17
C40 (\8\:qbint VSS) capacitor c=4.09269e-17
C41 (\2\:n30 VSS) capacitor c=4.47301e-17
C42 (\3\:CK VSS) capacitor c=4.25627e-17
C43 (\3\:qbint VSS) capacitor c=2.93131e-17
C44 (\6\:SE VSS) capacitor c=5.18592e-17
C45 (\2\:SI VSS) capacitor c=8.32905e-17
C46 (\4\:SE VSS) capacitor c=5.04202e-17
C47 (\2\:SEb VSS) capacitor c=9.63878e-17
C48 (\2\:SE VSS) capacitor c=4.28289e-17
C49 (\2\:D VSS) capacitor c=7.41421e-17
C50 (\7\:CKbb VSS) capacitor c=4.71616e-17
C51 (\11\:CKb VSS) capacitor c=3.10076e-17
C52 (\5\:CKbb VSS) capacitor c=2.73565e-17
C53 (\2\:mout VSS) capacitor c=5.48523e-17
C54 (\2\:n20 VSS) capacitor c=4.64309e-17
C55 (\4\:CKb VSS) capacitor c=2.65635e-17
C56 (\2\:CKbb VSS) capacitor c=5.28768e-17
C57 (\2\:CKb VSS) capacitor c=3.38524e-17
C58 (\7\:qbint VSS) capacitor c=4.69798e-17
C59 (\3\:n30 VSS) capacitor c=2.17608e-17
C60 (\2\:CK VSS) capacitor c=2.7812e-17
C61 (\4\:SEb VSS) capacitor c=1.24536e-17
C62 (\1\:VDD VSS) capacitor c=5.35086e-17
C63 (\8\:Db VSS) capacitor c=4.498e-17
C64 (\10\:VDD VSS) capacitor c=4.27543e-17
C65 (\8\:CKbb VSS) capacitor c=7.95722e-17
C66 (\4\:Db VSS) capacitor c=1.01784e-16
C67 (\4\:n20 VSS) capacitor c=3.48671e-17
C68 (\12\:VDD VSS) capacitor c=1.4421e-17
C69 (\6\:mout VSS) capacitor c=4.03868e-17
C70 (\4\:n30 VSS) capacitor c=7.53643e-17
C71 (\14\:VDD VSS) capacitor c=1.40891e-17
C72 (\13\:qbint VSS) capacitor c=4.52892e-17
C73 (\15\:CKb VSS) capacitor c=9.84307e-17
C74 (\16\:VDD VSS) capacitor c=4.43344e-17
C75 (\1\:Q VSS) capacitor c=5.55795e-17
C76 (\3\:VDD VSS) capacitor c=5.49465e-17
C77 (\8\:SEb VSS) capacitor c=7.8405e-17
C78 (\14\:CKbb VSS) capacitor c=4.23607e-17
C79 (\6\:Db VSS) capacitor c=7.09639e-17
C80 (\8\:n20 VSS) capacitor c=4.73779e-17
C81 (\8\:mout VSS) capacitor c=3.2959e-17
C82 (\6\:n30 VSS) capacitor c=1.07637e-16
C83 (\11\:qbint VSS) capacitor c=8.125e-17
C84 (\17\:CKb VSS) capacitor c=6.68854e-17
C85 (\3\:Q VSS) capacitor c=5.16402e-17
C86 (\2\:qbint VSS) capacitor c=1.56914e-17
C87 (\6\:CKb VSS) capacitor c=7.18416e-17
C88 (\7\:CKb VSS) capacitor c=6.54101e-17
C89 (\4\:CK VSS) capacitor c=5.65784e-17
C90 (\9\:qbint VSS) capacitor c=3.05027e-17
C91 (\10\:qbint VSS) capacitor c=3.3011e-17
C92 (\15\:qbint VSS) capacitor c=1.37711e-16
C93 (\8\:n30 VSS) capacitor c=6.60874e-17
C94 (\4\:mout VSS) capacitor c=5.07211e-17
C95 (\5\:mout VSS) capacitor c=4.60666e-17
C96 (\12\:CKb VSS) capacitor c=5.58299e-17
C97 (\13\:CKb VSS) capacitor c=8.17717e-17
C98 (\14\:CKb VSS) capacitor c=1.00261e-16
C99 (\20\:CKb VSS) capacitor c=5.20221e-17
C100 (\6\:n20 VSS) capacitor c=5.5125e-17
C101 (\7\:n20 VSS) capacitor c=5.34583e-17
C102 (\10\:CKbb VSS) capacitor c=1.36948e-16
C103 (\11\:CKbb VSS) capacitor c=5.29749e-17
C104 (\12\:CKbb VSS) capacitor c=8.52368e-17
C105 (\13\:CKbb VSS) capacitor c=1.11785e-16
C106 (\16\:CKbb VSS) capacitor c=1.81274e-17
C107 (\4\:D VSS) capacitor c=6.3317e-17
C108 (\3\:Db VSS) capacitor c=1.56626e-16
C109 (\8\:SE VSS) capacitor c=3.76099e-17
C110 (\9\:SE VSS) capacitor c=7.96144e-17
C111 (\10\:SE VSS) capacitor c=6.20285e-17
C112 (\6\:SEb VSS) capacitor c=1.00294e-16
C113 (\7\:SEb VSS) capacitor c=8.75154e-17
C114 (\5\:VDD VSS) capacitor c=2.51039e-17
C115 (\6\:VDD VSS) capacitor c=5.5946e-17
C116 (\8\:VDD VSS) capacitor c=1.47947e-17
C117 (\9\:VDD VSS) capacitor c=1.41803e-17
Rk28 (\4\:D D) resistor r=0.09047 c=0
Rk1 (\2\:Q Q) resistor r=0.3595 c=0
Rk2 (Q \4\:Q) resistor r=0.0595 c=0
Rk40 (\2\:VDD \4\:VDD) resistor r=0.5204 c=0
Rk41 (\4\:VDD \5\:VDD) resistor r=0.08755 c=0
Rk42 (\5\:VDD \6\:VDD) resistor r=0.5486 c=0
Rk43 (\6\:VDD \7\:VDD) resistor r=0.4661 c=0
Rk44 (\7\:VDD \8\:VDD) resistor r=0.04242 c=0
Rk46 (\9\:VDD VDD) resistor r=0.1074 c=0
Rk45 (\8\:VDD \9\:VDD) resistor r=0.4007 c=0
Rk47 (\5\:VDD \11\:VDD) resistor r=0.2336 c=0
Rk48 (\6\:VDD \13\:VDD) resistor r=0.07369 c=0
Rk49 (\8\:VDD \15\:VDD) resistor r=0.1024 c=0
Rk50 (\9\:VDD \17\:VDD) resistor r=0.2714 c=0
Rk3 (\4\:CK CK) resistor r=0.194 c=0
Rk33 (SE \8\:SE) resistor r=0.03328 c=0
Rk34 (\8\:SE \9\:SE) resistor r=0.1953 c=0
Rk35 (\9\:SE \10\:SE) resistor r=0.3246 c=0
Rk36 (\4\:SI SI) resistor r=0.001381 c=0
Rk51 (\2\:VSS \4\:VSS) resistor r=0.5536 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.08755 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.5577 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.4551 c=0
Rk55 (\5\:VSS \9\:VSS) resistor r=0.268 c=0
Rk56 (\6\:VSS \11\:VSS) resistor r=0.04329 c=0
Rk58 (\12\:VSS VSS) resistor r=0.1074 c=0
Rk57 (\7\:VSS \12\:VSS) resistor r=0.4447 c=0
Rk59 (\7\:VSS \14\:VSS) resistor r=0.07145 c=0
Rk60 (\12\:VSS \16\:VSS) resistor r=0.2929 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1677 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1221 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.2355 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.7734 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.4684 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.3626 c=0
Rk15 (\14\:CKb \16\:CKb) resistor r=0.6335 c=0
Rk16 (\16\:CKb \18\:CKb) resistor r=0.2774 c=0
Rk17 (\13\:CKb \19\:CKb) resistor r=0.0153 c=0
Rk18 (\14\:CKb \20\:CKb) resistor r=0.3252 c=0
Rk8 (\5\:n30 \7\:n30) resistor r=0.4351 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.51 c=0
Rk10 (\4\:mout \5\:mout) resistor r=0.2384 c=0
Rk11 (\5\:mout \7\:mout) resistor r=0.2366 c=0
Rk12 (\5\:mout \9\:mout) resistor r=0.1276 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.5614 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3571 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2134 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.7606 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.2505 c=0
Rk27 (\12\:CKbb \16\:CKbb) resistor r=0.03035 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1344 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.264 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2513 c=0
Rk29 (\2\:Db \3\:Db) resistor r=0.7183 c=0
Rk30 (\3\:Db \5\:Db) resistor r=0.4026 c=0
Rk31 (\5\:Db \7\:Db) resistor r=0.3935 c=0
Rk32 (\3\:Db \9\:Db) resistor r=0.2962 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.04776 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.5307 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.6657 c=0
Rl27 (\1\:D \2\:D) resistor r=171.411 c=0
Rl28 (\2\:D \3\:D) resistor r=100.257 c=0
Rl4 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl5 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl35 (\5\:SE \6\:SE) resistor r=187.23 c=0
Rl36 (\6\:SE \7\:SE) resistor r=42.9995 c=0
Rl32 (\3\:SE \4\:SE) resistor r=37.6944 c=0
Rl29 (\1\:SE \2\:SE) resistor r=74.2328 c=0
Rl33 (\1\:SI \2\:SI) resistor r=116.54 c=0
Rl34 (\2\:SI \3\:SI) resistor r=110.771 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=68.9449 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=112.741 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=34.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=0.5166 c=0
Rl26 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=47.3097 c=0
Rl11 (CKb \2\:CKb) resistor r=43.4636 c=0
Rl21 (\5\:CKb \6\:CKb) resistor r=162.261 c=0
Rl24 (\6\:CKb \9\:CKb) resistor r=96.8761 c=0
Rl23 (\7\:CKb \8\:CKb) resistor r=159.159 c=0
Rl25 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=181.607 c=0
Rl6 (n30 \2\:n30) resistor r=146.154 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl17 (mout \2\:mout) resistor r=91.0764 c=0
Rl18 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl20 (\6\:CKbb \7\:CKbb) resistor r=43.4636 c=0
Rl19 (\4\:CKbb \5\:CKbb) resistor r=67.9995 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=114.381 c=0
Rl12 (CKbb \2\:CKbb) resistor r=25.0391 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=33.5406 c=0
Rl15 (n20 \2\:n20) resistor r=86.3335 c=0
Rl30 (SEb \2\:SEb) resistor r=107.398 c=0
Rl31 (\2\:SEb \3\:SEb) resistor r=153.955 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz12 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz15 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\6\:Db \7\:Db) resistor r=75 c=0
Rz10 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry17 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\8\:Db \9\:Db) resistor r=62 c=0
Ry10 (\4\:SEb \5\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\6\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\17\:CKb \3\:CK \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\11\:qbint \2\:n30 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.845e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n7 \8\:qbint \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.65e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\6\:n30 CKb n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.445e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout CKbb \6\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=4.568e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.17e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=4.568e-14 ps=1.64e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=8.1e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=8.7e-15 ps=1.64e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=5.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \4\:CKbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\6\:Db \10\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (n1 \3\:D \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.683e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.85e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.8e-07 sb=4.5e-07 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn13 (n3 \3\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\8\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp20 (\15\:CKb \1\:CK \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.366 scb=0.0254155 \
        scc=0.00302764 m=(1)
mp45 (\13\:qbint n30 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.845e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (n8 \5\:qbint \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=5.482e-14 ps=1.62e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.58e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\4\:n30 \3\:CKbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.28e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\4\:n30 \3\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.075e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\6\:mout \3\:n20 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.23e-14 ad=3.655e-14 ps=1.62e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=8.6e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (n6 mout \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.29e-14 ps=1.62e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=5.95e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=4.9e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=2.65e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp21 (\8\:CKbb \5\:CKb \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp11 (n2 \1\:D \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.978e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.85e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.44e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=10.5972 \
        scb=0.00776431 scc=9.29552e-05 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.8e-07 sb=4.5e-07 sd=160n sca=11.4263 scb=0.00831104 \
        scc=9.35693e-05 m=(1)
mp13 (n4 \1\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=12.2213 \
        scb=0.00924687 scc=9.7291e-05 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=16.0509 \
        scb=0.0157301 scc=0.000264062 m=(1)
ends SDFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:34 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFQX2
// View name: extracted

simulator lang=spectre

subckt SDFFQX2 CK D Q SE SI VDD VSS
mp55 (\1\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.131e-14 ad=6.24e-14 ps=1.155e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.03462e-07 sd=160n sca=41.3017 \
        scb=0.035902 scc=0.00422214 m=(2)
C1 (D VSS) capacitor c=8.23404e-17
C2 (Q VSS) capacitor c=9.95983e-18
C3 (VDD VSS) capacitor c=4.15132e-16
C4 (CK VSS) capacitor c=6.14053e-17
C5 (SE VSS) capacitor c=7.29167e-17
C6 (SI VSS) capacitor c=9.16053e-17
C7 (qbint VSS) capacitor c=1.56826e-16
C8 (CKb VSS) capacitor c=4.46433e-17
C9 (n30 VSS) capacitor c=3.13291e-17
C10 (n7 VSS) capacitor c=4.3707e-18
C11 (mout VSS) capacitor c=7.98878e-17
C12 (CKbb VSS) capacitor c=2.24207e-17
C13 (n20 VSS) capacitor c=3.98344e-17
C14 (Db VSS) capacitor c=9.89004e-17
C15 (n1 VSS) capacitor c=8.18964e-18
C16 (SEb VSS) capacitor c=4.61206e-17
C17 (n8 VSS) capacitor c=7.52667e-18
C18 (\7\:SE VSS) capacitor c=5.30738e-17
C19 (\3\:SI VSS) capacitor c=6.70719e-17
C20 (\1\:SE VSS) capacitor c=4.09547e-17
C21 (\1\:D VSS) capacitor c=4.77043e-17
C22 (\5\:CKb VSS) capacitor c=6.60561e-17
C23 (\6\:CKbb VSS) capacitor c=3.80815e-17
C24 (\8\:CKb VSS) capacitor c=7.29569e-17
C25 (\3\:CKb VSS) capacitor c=5.08638e-17
C26 (\3\:CKbb VSS) capacitor c=5.04766e-17
C27 (\8\:qbint VSS) capacitor c=3.17411e-17
C28 (\3\:n30 VSS) capacitor c=5.20787e-17
C29 (\1\:CK VSS) capacitor c=4.31994e-17
C30 (\5\:SE VSS) capacitor c=2.69637e-17
C31 (\1\:SI VSS) capacitor c=6.6106e-17
C32 (\3\:SE VSS) capacitor c=6.90755e-17
C33 (\3\:SEb VSS) capacitor c=5.72057e-17
C34 (\3\:D VSS) capacitor c=3.73797e-17
C35 (\9\:CKb VSS) capacitor c=2.89953e-17
C36 (\10\:CKb VSS) capacitor c=3.97685e-17
C37 (\5\:CKbb VSS) capacitor c=7.69291e-17
C38 (\3\:mout VSS) capacitor c=5.41802e-17
C39 (\3\:n20 VSS) capacitor c=4.07163e-17
C40 (\10\:qbint VSS) capacitor c=4.90569e-17
C41 (\3\:CK VSS) capacitor c=4.14367e-17
C42 (\6\:SE VSS) capacitor c=5.32148e-17
C43 (\2\:SI VSS) capacitor c=6.47576e-17
C44 (\4\:SE VSS) capacitor c=4.58003e-17
C45 (\2\:SEb VSS) capacitor c=5.36606e-17
C46 (\2\:SE VSS) capacitor c=4.05473e-17
C47 (\2\:D VSS) capacitor c=7.93409e-17
C48 (\7\:CKbb VSS) capacitor c=3.86547e-17
C49 (\4\:CKbb VSS) capacitor c=4.01971e-17
C50 (\11\:CKb VSS) capacitor c=2.95247e-17
C51 (\2\:mout VSS) capacitor c=5.45636e-17
C52 (\2\:n20 VSS) capacitor c=3.95852e-17
C53 (\4\:CKb VSS) capacitor c=2.58449e-17
C54 (\2\:CKbb VSS) capacitor c=4.86643e-17
C55 (\2\:CKb VSS) capacitor c=3.65034e-17
C56 (\9\:qbint VSS) capacitor c=4.13417e-17
C57 (\2\:CK VSS) capacitor c=3.99274e-17
C58 (\6\:qbint VSS) capacitor c=1.92255e-17
C59 (\8\:SEb VSS) capacitor c=1.32792e-17
C60 (\1\:VDD VSS) capacitor c=5.43488e-17
C61 (\6\:Db VSS) capacitor c=4.63818e-17
C62 (\12\:VDD VSS) capacitor c=4.2214e-17
C63 (\8\:CKbb VSS) capacitor c=7.26385e-17
C64 (\4\:Db VSS) capacitor c=1.08193e-16
C65 (\4\:n20 VSS) capacitor c=3.5093e-17
C66 (\14\:VDD VSS) capacitor c=1.69382e-17
C67 (\6\:mout VSS) capacitor c=3.98309e-17
C68 (\9\:n30 VSS) capacitor c=6.94064e-17
C69 (\16\:VDD VSS) capacitor c=3.6134e-17
C70 (\12\:qbint VSS) capacitor c=6.66254e-17
C71 (\15\:CKb VSS) capacitor c=1.12457e-16
C72 (\1\:Q VSS) capacitor c=7.81297e-17
C73 (\3\:VDD VSS) capacitor c=3.84875e-17
C74 (\4\:SEb VSS) capacitor c=7.0487e-17
C75 (\14\:CKbb VSS) capacitor c=5.45417e-17
C76 (\8\:Db VSS) capacitor c=8.16808e-17
C77 (\8\:n20 VSS) capacitor c=5.54677e-17
C78 (\8\:mout VSS) capacitor c=3.61048e-17
C79 (\5\:n30 VSS) capacitor c=2.30163e-17
C80 (\14\:qbint VSS) capacitor c=1.29402e-16
C81 (\18\:CKb VSS) capacitor c=1.10546e-16
C82 (\4\:Q VSS) capacitor c=2.52576e-17
C83 (\2\:n30 VSS) capacitor c=3.00211e-17
C84 (\6\:CKb VSS) capacitor c=6.61939e-17
C85 (\7\:CKb VSS) capacitor c=6.23714e-17
C86 (\3\:Q VSS) capacitor c=3.77131e-17
C87 (\4\:CK VSS) capacitor c=4.44514e-17
C88 (\11\:qbint VSS) capacitor c=4.14683e-17
C89 (\16\:qbint VSS) capacitor c=1.35297e-16
C90 (\7\:n30 VSS) capacitor c=7.37072e-17
C91 (\8\:n30 VSS) capacitor c=8.17195e-17
C92 (\4\:mout VSS) capacitor c=4.96698e-17
C93 (\5\:mout VSS) capacitor c=4.73387e-17
C94 (\12\:CKb VSS) capacitor c=6.03114e-17
C95 (\13\:CKb VSS) capacitor c=8.62768e-17
C96 (\14\:CKb VSS) capacitor c=9.42376e-17
C97 (\17\:CKb VSS) capacitor c=5.5349e-17
C98 (\6\:n20 VSS) capacitor c=6.03379e-17
C99 (\7\:n20 VSS) capacitor c=5.10599e-17
C100 (\10\:CKbb VSS) capacitor c=1.24229e-16
C101 (\11\:CKbb VSS) capacitor c=6.76084e-17
C102 (\12\:CKbb VSS) capacitor c=7.6037e-17
C103 (\13\:CKbb VSS) capacitor c=1.08485e-16
C104 (\4\:D VSS) capacitor c=3.43108e-17
C105 (\3\:Db VSS) capacitor c=1.30711e-16
C106 (\8\:SE VSS) capacitor c=4.6792e-17
C107 (\10\:SE VSS) capacitor c=7.73041e-17
C108 (\4\:SI VSS) capacitor c=4.35436e-17
C109 (\6\:SEb VSS) capacitor c=1.06983e-16
C110 (\7\:SEb VSS) capacitor c=6.16172e-17
C111 (\5\:VDD VSS) capacitor c=2.2975e-17
C112 (\6\:VDD VSS) capacitor c=5.86569e-17
C113 (\7\:VDD VSS) capacitor c=2.5896e-17
Rk27 (\4\:D D) resistor r=0.06529 c=0
Rk2 (\3\:Q Q) resistor r=0.002419 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.3231 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1898 c=0
Rk51 (\2\:VDD \4\:VDD) resistor r=0.6041 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.05746 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.5486 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.5637 c=0
Rk56 (\8\:VDD VDD) resistor r=0.3307 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.03239 c=0
Rk59 (\5\:VDD \13\:VDD) resistor r=0.2584 c=0
Rk60 (\6\:VDD \15\:VDD) resistor r=0.07369 c=0
Rk61 (\7\:VDD \17\:VDD) resistor r=0.209 c=0
Rk4 (CK \4\:CK) resistor r=0.1109 c=0
Rk32 (\8\:SE SE) resistor r=0.2343 c=0
Rk34 (SE \10\:SE) resistor r=0.3782 c=0
Rk35 (\4\:SI SI) resistor r=0.1351 c=0
Rk39 (\2\:VSS \4\:VSS) resistor r=0.6634 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.05746 c=0
Rk41 (\5\:VSS \6\:VSS) resistor r=0.5477 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.5961 c=0
Rk43 (\5\:VSS \9\:VSS) resistor r=0.2966 c=0
Rk44 (\6\:VSS \11\:VSS) resistor r=0.04329 c=0
Rk47 (\12\:VSS VSS) resistor r=0.0151 c=0
Rk45 (\7\:VSS \12\:VSS) resistor r=0.3307 c=0
Rk48 (\7\:VSS \15\:VSS) resistor r=0.3674 c=0
Rk5 (\11\:qbint \13\:qbint) resistor r=0.2244 c=0
Rk6 (\13\:qbint \15\:qbint) resistor r=0.3633 c=0
Rk7 (\15\:qbint \16\:qbint) resistor r=0.835 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.464 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.3948 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4697 c=0
Rk17 (\14\:CKb \17\:CKb) resistor r=0.2686 c=0
Rk18 (\16\:CKb \19\:CKb) resistor r=0.6422 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.06409 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.432 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.3852 c=0
Rk11 (\4\:mout \5\:mout) resistor r=0.2532 c=0
Rk12 (\5\:mout \7\:mout) resistor r=0.2422 c=0
Rk13 (\5\:mout \9\:mout) resistor r=0.1387 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.5321 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3682 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.1381 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.78 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.2499 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1397 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.2722 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.1974 c=0
Rk28 (\2\:Db \3\:Db) resistor r=0.6893 c=0
Rk29 (\3\:Db \5\:Db) resistor r=0.4325 c=0
Rk30 (\3\:Db \7\:Db) resistor r=0.271 c=0
Rk31 (\5\:Db \9\:Db) resistor r=0.48 c=0
Rk36 (\5\:SEb \6\:SEb) resistor r=0.7076 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.4859 c=0
Rk38 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rl30 (\1\:D \2\:D) resistor r=119.488 c=0
Rl31 (\2\:D \3\:D) resistor r=123.334 c=0
Rl7 (\1\:CK \2\:CK) resistor r=139.56 c=0
Rl8 (\2\:CK \3\:CK) resistor r=53.0211 c=0
Rl39 (\6\:SE \7\:SE) resistor r=166.483 c=0
Rl38 (\5\:SE \6\:SE) resistor r=36.5385 c=0
Rl35 (\3\:SE \4\:SE) resistor r=35.3072 c=0
Rl32 (\1\:SE \2\:SE) resistor r=79.5379 c=0
Rl37 (\2\:SI \3\:SI) resistor r=104.104 c=0
Rl36 (\1\:SI \2\:SI) resistor r=96.8456 c=0
Rl12 (\9\:qbint \8\:qbint) resistor r=30.1196 c=0
Rl13 (\9\:qbint \10\:qbint) resistor r=94.0258 c=0
Rl5 (qbint \6\:qbint) resistor r=4.8851 c=0
Rl29 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=37.6944 c=0
Rl14 (CKb \2\:CKb) resistor r=53.079 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=148.799 c=0
Rl27 (\6\:CKb \9\:CKb) resistor r=81.4915 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=186.082 c=0
Rl28 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=164.3 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=52.8616 c=0
Rl9 (n30 \2\:n30) resistor r=37.477 c=0
Rl11 (\2\:n30 \4\:n30) resistor r=6.1589 c=0
Rl20 (mout \2\:mout) resistor r=93.4636 c=0
Rl21 (\2\:mout \3\:mout) resistor r=33.8482 c=0
Rl23 (\6\:CKbb \7\:CKbb) resistor r=41.5405 c=0
Rl22 (\4\:CKbb \5\:CKbb) resistor r=40.8563 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=138.016 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl18 (n20 \2\:n20) resistor r=31.9251 c=0
Rl19 (\2\:n20 \3\:n20) resistor r=95.3867 c=0
Rl33 (SEb \2\:SEb) resistor r=76.9231 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=127.421 c=0
Rz1 (\5\:Q \4\:Q) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz2 (\15\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry11 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry12 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\4\:SE SE) resistor r=45 c=0
Rx14 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55_1__rcx (\4\:Q qbint \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.29038e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn20 (\18\:CKb \3\:CK \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.407e-14 ps=9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.35e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn50 (n7 \10\:qbint \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.682e-14 ps=7.9e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.705e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 CKb n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.335e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout CKbb \5\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=4.277e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=4.278e-14 ps=1.6e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \5\:CKbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.973e-14 ps=4.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:Db \10\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=3.48e-14 ps=7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=2.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \3\:D \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.205e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=6.65e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.85e-07 sb=4.6e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \1\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.55e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn45 (\14\:qbint n30 \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.87e-14 ps=7.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41317e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp20 (\15\:CKb \1\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.802e-14 ad=3.87e-14 ps=1.25e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.8e-07 sd=160n sca=13.4091 \
        scb=0.0119825 scc=0.00042533 m=(1)
mp50 (n8 \8\:qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.71e-14 ad=7.202e-14 ps=1.48e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.28488e-07 sb=1.69e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\9\:n30 \3\:CKbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.202e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.08488e-07 sb=1.31e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\9\:n30 \3\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13488e-07 sb=1.105e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\6\:mout n20 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=4.3e-14 ps=1.57e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15849e-06 sb=8.6e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (n6 mout \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=1.29e-14 ps=1.57e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42349e-06 sb=5.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52849e-06 sb=4.9e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=4.515e-14 ps=9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78349e-06 sb=2.35e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp21 (\8\:CKbb \5\:CKb \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp11 (n2 \1\:D \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp12 (\6\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.87e-14 ps=7.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.25e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp14 (\6\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.87e-14 ps=6.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5e-07 sd=160n sca=11.3106 scb=0.00875354 \
        scc=0.000148925 m=(1)
mp13 (n4 \3\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.365e-14 ps=7.5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=12.0628 \
        scb=0.00935347 scc=0.000149867 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=14.4353 \
        scb=0.0129221 scc=0.000190612 m=(1)
mp45 (\12\:qbint \3\:n30 \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.71e-14 ad=4.34e-14 ps=1.48e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.67661e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends SDFFQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:35 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFQX4
// View name: extracted

simulator lang=spectre

subckt SDFFQX4 CK D Q SE SI VDD VSS
mp20 (\17\:CKb \4\:CK \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.39721e-06 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
mp50 (n8 \17\:qbint \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=2.687e-14 ps=1.08e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53012e-06 sb=1.705e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\12\:n30 \2\:CKbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.3e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70012e-06 sb=1.535e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\12\:n30 CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=4.3e-14 ps=1.07e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91442e-06 sb=1.29e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.205e-14 ad=6.88e-14 ps=1.6e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.25e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp35 (n6 \4\:mout \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.205e-14 ad=2.473e-14 ps=1.6e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.5e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp36 (\6\:n20 \4\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.44e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp25 (\6\:n20 \8\:CKbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp21 (\9\:CKbb \6\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp11 (n2 \1\:D \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.15e-14 ps=7.5e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.15e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp12 (\9\:Db \2\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=7.7e-07 sd=160n sca=10.6461 \
        scb=0.00827274 scc=0.000128406 m=(1)
mp14 (\9\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.87e-14 ps=7.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.45e-07 sd=160n sca=11.2732 \
        scb=0.00852207 scc=0.000128512 m=(1)
mp13 (n4 \3\:SI \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.332e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=3.45e-07 sd=160n sca=12.5323 \
        scb=0.0098256 scc=0.000132754 m=(1)
mp10 (\9\:SEb \7\:SE \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.4e-07 sd=160n sca=16.3619 \
        scb=0.0163088 scc=0.000299525 m=(1)
C1 (D VSS) capacitor c=7.22142e-17
C2 (Q VSS) capacitor c=2.95087e-16
C3 (VDD VSS) capacitor c=3.35906e-16
C4 (CK VSS) capacitor c=5.45052e-17
C5 (SE VSS) capacitor c=6.40837e-17
C6 (SI VSS) capacitor c=4.18643e-17
C7 (CKb VSS) capacitor c=5.63332e-17
C8 (qbint VSS) capacitor c=2.67116e-16
C9 (n30 VSS) capacitor c=1.96267e-16
C10 (n7 VSS) capacitor c=6.57007e-19
C11 (mout VSS) capacitor c=3.86828e-17
C12 (CKbb VSS) capacitor c=4.51463e-17
C13 (n20 VSS) capacitor c=5.40511e-17
C14 (n5 VSS) capacitor c=1.91161e-18
C15 (Db VSS) capacitor c=9.93103e-17
C16 (n1 VSS) capacitor c=5.99035e-18
C17 (SEb VSS) capacitor c=3.35707e-17
C18 (n8 VSS) capacitor c=2.04398e-18
C19 (n6 VSS) capacitor c=2.92314e-18
C20 (n2 VSS) capacitor c=1.93991e-19
C21 (n4 VSS) capacitor c=3.42778e-18
C22 (\7\:SE VSS) capacitor c=5.11035e-17
C23 (\3\:SI VSS) capacitor c=5.25808e-17
C24 (\2\:SE VSS) capacitor c=4.80126e-17
C25 (\1\:D VSS) capacitor c=6.1397e-17
C26 (\6\:CKb VSS) capacitor c=5.08584e-17
C27 (\8\:CKbb VSS) capacitor c=2.62962e-17
C28 (\4\:CKb VSS) capacitor c=5.35072e-17
C29 (\4\:mout VSS) capacitor c=6.84535e-17
C30 (\3\:n20 VSS) capacitor c=3.20737e-17
C31 (\2\:CKbb VSS) capacitor c=4.00846e-17
C32 (\17\:qbint VSS) capacitor c=5.0243e-17
C33 (\4\:CK VSS) capacitor c=3.25153e-17
C34 (\5\:SE VSS) capacitor c=2.73127e-17
C35 (\1\:SI VSS) capacitor c=6.59098e-17
C36 (\3\:SE VSS) capacitor c=6.87159e-17
C37 (\3\:SEb VSS) capacitor c=7.09519e-17
C38 (\3\:D VSS) capacitor c=3.72345e-17
C39 (\10\:CKb VSS) capacitor c=3.13326e-17
C40 (\9\:CKb VSS) capacitor c=1.43821e-17
C41 (\7\:CKbb VSS) capacitor c=4.91803e-17
C42 (\3\:CKbb VSS) capacitor c=4.54233e-17
C43 (\2\:CKb VSS) capacitor c=5.24805e-17
C44 (\14\:qbint VSS) capacitor c=3.55301e-17
C45 (\3\:CK VSS) capacitor c=2.99639e-17
C46 (\6\:SE VSS) capacitor c=5.45831e-17
C47 (\2\:SI VSS) capacitor c=7.56769e-17
C48 (\4\:SE VSS) capacitor c=5.00463e-17
C49 (\1\:SE VSS) capacitor c=5.19143e-17
C50 (\2\:D VSS) capacitor c=5.29429e-17
C51 (\8\:CKb VSS) capacitor c=4.66155e-17
C52 (\5\:CKbb VSS) capacitor c=1.94378e-17
C53 (\5\:CKb VSS) capacitor c=4.46656e-17
C54 (\3\:mout VSS) capacitor c=5.64634e-17
C55 (\2\:n20 VSS) capacitor c=4.64643e-17
C56 (\4\:CKbb VSS) capacitor c=3.6587e-17
C57 (\3\:CKb VSS) capacitor c=2.26386e-17
C58 (\16\:qbint VSS) capacitor c=4.81255e-17
C59 (\1\:CK VSS) capacitor c=1.90257e-17
C60 (\9\:SEb VSS) capacitor c=7.71233e-18
C61 (\9\:VDD VSS) capacitor c=3.37211e-17
C62 (\9\:Db VSS) capacitor c=7.13289e-17
C63 (\11\:VDD VSS) capacitor c=4.16472e-17
C64 (\9\:CKbb VSS) capacitor c=6.91516e-17
C65 (\5\:Db VSS) capacitor c=7.40895e-17
C66 (\6\:n20 VSS) capacitor c=9.47997e-17
C67 (\13\:VDD VSS) capacitor c=1.34334e-17
C68 (\8\:mout VSS) capacitor c=6.24632e-17
C69 (\12\:n30 VSS) capacitor c=2.7253e-17
C70 (\24\:qbint VSS) capacitor c=7.0822e-17
C71 (\17\:CKb VSS) capacitor c=4.01869e-17
C72 (\1\:VDD VSS) capacitor c=6.65845e-17
C73 (\5\:SEb VSS) capacitor c=6.97504e-17
C74 (\15\:CKbb VSS) capacitor c=8.81979e-17
C75 (\7\:Db VSS) capacitor c=1.00188e-16
C76 (\4\:n20 VSS) capacitor c=8.81582e-17
C77 (\5\:mout VSS) capacitor c=2.93154e-17
C78 (\8\:n30 VSS) capacitor c=8.24464e-17
C79 (\22\:qbint VSS) capacitor c=3.38858e-17
C80 (\14\:CKb VSS) capacitor c=1.75548e-16
C81 (\2\:CK VSS) capacitor c=1.28072e-17
C82 (\6\:CKbb VSS) capacitor c=3.30305e-17
C83 (\7\:CKb VSS) capacitor c=6.10014e-17
C84 (\2\:SEb VSS) capacitor c=6.6704e-17
C85 (\5\:CK VSS) capacitor c=6.28384e-17
C86 (\18\:qbint VSS) capacitor c=5.42841e-17
C87 (\19\:qbint VSS) capacitor c=2.06832e-17
C88 (\20\:qbint VSS) capacitor c=2.67239e-17
C89 (\21\:qbint VSS) capacitor c=3.43538e-17
C90 (\10\:n30 VSS) capacitor c=8.29554e-17
C91 (\11\:n30 VSS) capacitor c=5.847e-17
C92 (\7\:mout VSS) capacitor c=4.13851e-17
C93 (\10\:mout VSS) capacitor c=4.71296e-17
C94 (\8\:n20 VSS) capacitor c=7.15946e-17
C95 (\11\:CKb VSS) capacitor c=9.35291e-17
C96 (\12\:CKb VSS) capacitor c=1.25552e-16
C97 (\13\:CKb VSS) capacitor c=2.29721e-16
C98 (\16\:CKb VSS) capacitor c=7.41308e-17
C99 (\11\:CKbb VSS) capacitor c=1.82488e-16
C100 (\12\:CKbb VSS) capacitor c=1.05641e-16
C101 (\14\:CKbb VSS) capacitor c=4.22202e-17
C102 (\17\:CKbb VSS) capacitor c=1.26991e-16
C103 (\4\:D VSS) capacitor c=4.43982e-17
C104 (\3\:Db VSS) capacitor c=1.56078e-16
C105 (\4\:Db VSS) capacitor c=1.1231e-16
C106 (\8\:SE VSS) capacitor c=4.90699e-17
C107 (\9\:SE VSS) capacitor c=7.30497e-17
C108 (\4\:SI VSS) capacitor c=8.58576e-17
C109 (\7\:SEb VSS) capacitor c=8.32088e-17
C110 (\8\:SEb VSS) capacitor c=6.8817e-17
C111 (\3\:VDD VSS) capacitor c=1.25517e-17
C112 (\4\:VDD VSS) capacitor c=2.71728e-17
C113 (\6\:VDD VSS) capacitor c=3.9381e-17
C114 (\7\:VDD VSS) capacitor c=2.93601e-16
Rk31 (\4\:D D) resistor r=0.08242 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.08004 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.3732 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.2982 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.4602 c=0
Rk75 (\7\:VDD VDD) resistor r=0.1174 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.5428 c=0
Rk66 (\3\:VDD \10\:VDD) resistor r=0.246 c=0
Rk67 (\4\:VDD \12\:VDD) resistor r=0.2529 c=0
Rk68 (\6\:VDD \14\:VDD) resistor r=0.0433 c=0
Rk1 (CK \5\:CK) resistor r=0.0703 c=0
Rk38 (\9\:SE SE) resistor r=0.2325 c=0
Rk37 (\8\:SE \9\:SE) resistor r=0.3512 c=0
Rk40 (SI \4\:SI) resistor r=0.0119 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.04243 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.3958 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.3132 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.4035 c=0
Rk56 (\7\:VSS VSS) resistor r=0.1024 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.5387 c=0
Rk50 (\3\:VSS \10\:VSS) resistor r=0.2951 c=0
Rk51 (\4\:VSS \12\:VSS) resistor r=0.286 c=0
Rk52 (\6\:VSS \14\:VSS) resistor r=0.07381 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.5815 c=0
Rk21 (\12\:CKb \13\:CKb) resistor r=0.6021 c=0
Rk22 (\13\:CKb \15\:CKb) resistor r=1.5784 c=0
Rk23 (\12\:CKb \16\:CKb) resistor r=0.3493 c=0
Rk24 (\15\:CKb \18\:CKb) resistor r=0.2855 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.2925 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.0683 c=0
Rk9 (\20\:qbint \21\:qbint) resistor r=0.1858 c=0
Rk10 (\19\:qbint \23\:qbint) resistor r=0.188 c=0
Rk11 (\20\:qbint \25\:qbint) resistor r=0.2839 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.516 c=0
Rk13 (\10\:n30 \11\:n30) resistor r=0.2866 c=0
Rk14 (\10\:n30 \13\:n30) resistor r=0.2095 c=0
Rk15 (\6\:mout \7\:mout) resistor r=0.09754 c=0
Rk16 (\7\:mout \9\:mout) resistor r=0.2708 c=0
Rk17 (\7\:mout \10\:mout) resistor r=0.1967 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.6188 c=0
Rk26 (\11\:CKbb \12\:CKbb) resistor r=0.2783 c=0
Rk27 (\11\:CKbb \13\:CKbb) resistor r=0.9614 c=0
Rk28 (\13\:CKbb \14\:CKbb) resistor r=0.1478 c=0
Rk29 (\12\:CKbb \16\:CKbb) resistor r=0.5819 c=0
Rk30 (\13\:CKbb \17\:CKbb) resistor r=0.04616 c=0
Rk18 (\5\:n20 \7\:n20) resistor r=0.416 c=0
Rk19 (\7\:n20 \8\:n20) resistor r=0.4113 c=0
Rk32 (\2\:Db \3\:Db) resistor r=0.6544 c=0
Rk33 (\3\:Db \4\:Db) resistor r=0.36 c=0
Rk34 (\4\:Db \6\:Db) resistor r=0.3483 c=0
Rk35 (\3\:Db \8\:Db) resistor r=0.6392 c=0
Rk36 (\4\:Db \10\:Db) resistor r=0.5483 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.6289 c=0
Rk42 (\7\:SEb \8\:SEb) resistor r=0.4055 c=0
Rk43 (\7\:SEb \10\:SEb) resistor r=0.02784 c=0
Rl42 (\1\:D \2\:D) resistor r=116.076 c=0
Rl43 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl3 (\2\:CK \4\:CK) resistor r=40.0987 c=0
Rl2 (\2\:CK \3\:CK) resistor r=43.9449 c=0
Rl1 (\1\:CK \2\:CK) resistor r=1.2713 c=0
Rl52 (\6\:SE \7\:SE) resistor r=170.33 c=0
Rl51 (\5\:SE \6\:SE) resistor r=36.5385 c=0
Rl48 (\3\:SE \4\:SE) resistor r=35.3072 c=0
Rl44 (\1\:SE \2\:SE) resistor r=66.565 c=0
Rl50 (\2\:SI \3\:SI) resistor r=111.516 c=0
Rl49 (\1\:SI \2\:SI) resistor r=92.1028 c=0
Rl26 (CKb \2\:CKb) resistor r=153.412 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=48.7687 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=26.1559 c=0
Rl38 (\6\:CKb \7\:CKb) resistor r=156.926 c=0
Rl41 (\7\:CKb \10\:CKb) resistor r=70.3874 c=0
Rl39 (\7\:CKb \8\:CKb) resistor r=241.784 c=0
Rl24 (\15\:qbint \17\:qbint) resistor r=104.785 c=0
Rl22 (\15\:qbint \14\:qbint) resistor r=47.0924 c=0
Rl23 (\15\:qbint \16\:qbint) resistor r=2.9709 c=0
Rl33 (\2\:mout \4\:mout) resistor r=114.4 c=0
Rl31 (mout \2\:mout) resistor r=37.477 c=0
Rl32 (\2\:mout \3\:mout) resistor r=2.7461 c=0
Rl28 (\3\:CKbb \4\:CKbb) resistor r=66.0764 c=0
Rl25 (CKbb \2\:CKbb) resistor r=57.6695 c=0
Rl37 (\6\:CKbb \8\:CKbb) resistor r=39.7465 c=0
Rl36 (\6\:CKbb \7\:CKbb) resistor r=156.166 c=0
Rl35 (\5\:CKbb \6\:CKbb) resistor r=27.7015 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=63.8117 c=0
Rl29 (n20 \2\:n20) resistor r=94.3522 c=0
Rl45 (SEb \2\:SEb) resistor r=40.1031 c=0
Rl46 (\2\:SEb \3\:SEb) resistor r=193.515 c=0
Rl47 (\2\:SEb \4\:SEb) resistor r=3.3229 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz20 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz3 (\23\:qbint \22\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\5\:mout \6\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\7\:Db \8\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry15 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry16 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry3 (\25\:qbint \24\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry9 (\5\:Db \6\:Db) resistor r=62 c=0
Ry10 (\9\:Db \10\:Db) resistor r=62 c=0
Ry11 (\9\:SEb \10\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx16 (\6\:SE SE) resistor r=45 c=0
Rx14 (\1\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\8\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (\3\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \10\:mout) resistor r=45 c=0
Rx10 (\5\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \17\:CKbb) resistor r=45 c=0
Rx6 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn20 (\14\:CKb \3\:CK \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.345e-14 ad=2.03e-14 ps=1.68e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (n7 \14\:qbint \7\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=4.495e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.72e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\8\:n30 \2\:CKb n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.32e-14 ps=9.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:mout \3\:CKbb \8\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.697e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.16e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\5\:mout n20 \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.43e-14 ad=3.697e-14 ps=1.64e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (n5 mout \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.43e-14 ad=1.885e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.65e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (\4\:n20 \7\:CKbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=4.422e-14 ps=5.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (\7\:Db \9\:CKb \4\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=6.452e-14 ps=6.1e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.175e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \3\:D \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.77e-14 ps=6.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=9.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=3.77e-14 \
        ad=2.32e-14 ps=8.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.55e-07 sb=6.65e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.16e-06 sb=4.6e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \1\:SI \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=3.55e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\5\:SEb \5\:SE \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.688e-14 ad=4.16e-14 ps=1.62e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=1.5826e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45_1__rcx (\22\:qbint n30 \7\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.387e-14 ad=3.383e-14 ps=1.6e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23451e-06 sb=1.50537e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mp55_1__rcx (Q qbint \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.506e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.53878e-06 sd=160n sca=33.5925 \
        scb=0.0236177 scc=0.00338536 m=(4)
mp45 (\24\:qbint n30 \7\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.452e-14 ad=4.96e-14 ps=1.12e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09234e-06 sb=1.48056e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
ends SDFFQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:36 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFQXL
// View name: extracted

simulator lang=spectre

subckt SDFFQXL CK D Q SE SI VDD VSS
mp55 (\3\:Q \4\:qbint \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=22.7477 \
        scb=0.0252121 scc=0.00126954 m=(1)
mp20 (\15\:CKb \4\:CK \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=13.584 \
        scb=0.0113598 scc=0.000108591 m=(1)
mp45 (\13\:qbint n30 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.875e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp50 (n8 \5\:qbint \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=4.837e-14 ps=1.51e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.61e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp51 (\4\:n30 \3\:CKbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=3.44e-14 ps=8.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.34e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.44e-14 ps=8.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.135e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp30 (\4\:mout n20 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=4.945e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=8.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp35 (n6 mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=1.935e-14 ps=1.51e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=5.95e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=3.87e-14 ps=6.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=4.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp25 (\4\:n20 \6\:CKbb \6\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.87e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=2.35e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp21 (\8\:CKbb \5\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.185e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp11 (n2 \1\:D \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.547e-14 ps=7.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=9.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp12 (\4\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=7.55e-07 sd=160n sca=10.5693 \
        scb=0.00783293 scc=9.84607e-05 m=(1)
mp14 (\4\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.762e-14 ps=7.2e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5.35e-07 sd=160n sca=11.3905 \
        scb=0.00832609 scc=9.89279e-05 m=(1)
mp13 (n4 \1\:SI \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.117e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.45e-07 sd=160n sca=13.0884 \
        scb=0.0105751 scc=0.000113994 m=(1)
mp10 (\8\:SEb \5\:SE \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.4e-07 sd=160n sca=19.3888 \
        scb=0.0210602 scc=0.000665938 m=(1)
C1 (D VSS) capacitor c=6.05613e-17
C2 (VDD VSS) capacitor c=3.8495e-16
C3 (CK VSS) capacitor c=7.94923e-17
C4 (SE VSS) capacitor c=5.17346e-17
C5 (Q VSS) capacitor c=6.44916e-17
C6 (SI VSS) capacitor c=3.82353e-17
C7 (qbint VSS) capacitor c=2.81436e-17
C8 (CKb VSS) capacitor c=5.40878e-17
C9 (n30 VSS) capacitor c=4.86362e-17
C10 (mout VSS) capacitor c=6.53272e-17
C11 (CKbb VSS) capacitor c=1.83192e-17
C12 (n20 VSS) capacitor c=3.83015e-17
C13 (Db VSS) capacitor c=8.26932e-17
C14 (n1 VSS) capacitor c=5.70493e-18
C15 (SEb VSS) capacitor c=3.4871e-17
C16 (n8 VSS) capacitor c=2.80538e-18
C17 (n2 VSS) capacitor c=6.53665e-20
C18 (\5\:SE VSS) capacitor c=5.44498e-17
C19 (\1\:SI VSS) capacitor c=5.26282e-17
C20 (\1\:SE VSS) capacitor c=4.1898e-17
C21 (\1\:D VSS) capacitor c=5.46909e-17
C22 (\5\:CKb VSS) capacitor c=5.47877e-17
C23 (\6\:CKbb VSS) capacitor c=4.53084e-17
C24 (\8\:CKb VSS) capacitor c=4.64708e-17
C25 (\3\:CKb VSS) capacitor c=5.29567e-17
C26 (\3\:CKbb VSS) capacitor c=4.57805e-17
C27 (\5\:qbint VSS) capacitor c=4.76656e-17
C28 (\4\:CK VSS) capacitor c=4.14179e-17
C29 (\4\:qbint VSS) capacitor c=5.73053e-17
C30 (\7\:SE VSS) capacitor c=2.80076e-17
C31 (\3\:SI VSS) capacitor c=7.51641e-17
C32 (\3\:SE VSS) capacitor c=6.86121e-17
C33 (\3\:SEb VSS) capacitor c=7.24169e-17
C34 (\4\:D VSS) capacitor c=3.34036e-17
C35 (\9\:CKb VSS) capacitor c=2.5578e-17
C36 (\10\:CKb VSS) capacitor c=2.90699e-17
C37 (\4\:CKbb VSS) capacitor c=7.60163e-17
C38 (\3\:mout VSS) capacitor c=5.22783e-17
C39 (\3\:n20 VSS) capacitor c=3.72854e-17
C40 (\8\:qbint VSS) capacitor c=4.96066e-17
C41 (\2\:n30 VSS) capacitor c=4.10821e-17
C42 (\1\:CK VSS) capacitor c=4.54399e-17
C43 (\3\:qbint VSS) capacitor c=2.70643e-17
C44 (\6\:SE VSS) capacitor c=5.37605e-17
C45 (\2\:SI VSS) capacitor c=6.44654e-17
C46 (\4\:SE VSS) capacitor c=4.39672e-17
C47 (\2\:SEb VSS) capacitor c=7.01382e-17
C48 (\2\:SE VSS) capacitor c=4.11907e-17
C49 (\3\:D VSS) capacitor c=3.1118e-17
C50 (\7\:CKbb VSS) capacitor c=4.26534e-17
C51 (\11\:CKb VSS) capacitor c=2.89881e-17
C52 (\5\:CKbb VSS) capacitor c=2.68119e-17
C53 (\2\:mout VSS) capacitor c=4.55585e-17
C54 (\2\:n20 VSS) capacitor c=3.80383e-17
C55 (\2\:CKbb VSS) capacitor c=5.4162e-17
C56 (\4\:CKb VSS) capacitor c=2.31422e-17
C57 (\2\:CKb VSS) capacitor c=3.15483e-17
C58 (\7\:qbint VSS) capacitor c=4.93385e-17
C59 (\3\:n30 VSS) capacitor c=2.21159e-17
C60 (\3\:CK VSS) capacitor c=5.2016e-17
C61 (\8\:SEb VSS) capacitor c=2.00361e-17
C62 (\16\:VDD VSS) capacitor c=4.3207e-17
C63 (\4\:Db VSS) capacitor c=5.31203e-17
C64 (\13\:VDD VSS) capacitor c=2.91009e-17
C65 (\8\:CKbb VSS) capacitor c=9.02551e-17
C66 (\6\:Db VSS) capacitor c=1.20672e-16
C67 (\4\:n20 VSS) capacitor c=3.00605e-17
C68 (\10\:VDD VSS) capacitor c=2.67871e-17
C69 (\4\:mout VSS) capacitor c=5.02916e-17
C70 (\4\:n30 VSS) capacitor c=7.70972e-17
C71 (\5\:VDD VSS) capacitor c=2.70169e-17
C72 (\13\:qbint VSS) capacitor c=3.50259e-17
C73 (\15\:CKb VSS) capacitor c=1.08462e-16
C74 (\1\:VDD VSS) capacitor c=3.13549e-17
C75 (\3\:Q VSS) capacitor c=7.23031e-17
C76 (\7\:VDD VSS) capacitor c=5.0753e-17
C77 (\4\:SEb VSS) capacitor c=4.2908e-17
C78 (\14\:CKbb VSS) capacitor c=6.1389e-17
C79 (\8\:Db VSS) capacitor c=6.08573e-17
C80 (\8\:n20 VSS) capacitor c=5.62832e-17
C81 (\7\:mout VSS) capacitor c=3.88399e-17
C82 (\6\:n30 VSS) capacitor c=9.93368e-17
C83 (\11\:qbint VSS) capacitor c=9.3593e-17
C84 (\19\:CKb VSS) capacitor c=1.06178e-16
C85 (\2\:qbint VSS) capacitor c=3.31913e-17
C86 (\6\:CKb VSS) capacitor c=6.686e-17
C87 (\7\:CKb VSS) capacitor c=7.8711e-17
C88 (\2\:D VSS) capacitor c=3.39548e-17
C89 (\5\:CK VSS) capacitor c=4.25936e-17
C90 (\9\:qbint VSS) capacitor c=3.15519e-17
C91 (\10\:qbint VSS) capacitor c=2.93585e-17
C92 (\15\:qbint VSS) capacitor c=1.04043e-16
C93 (\8\:n30 VSS) capacitor c=6.22715e-17
C94 (\6\:mout VSS) capacitor c=4.87914e-17
C95 (\9\:mout VSS) capacitor c=5.44356e-17
C96 (\12\:CKb VSS) capacitor c=6.69464e-17
C97 (\13\:CKb VSS) capacitor c=6.7767e-17
C98 (\14\:CKb VSS) capacitor c=8.47596e-17
C99 (\17\:CKb VSS) capacitor c=1.52887e-17
C100 (\18\:CKb VSS) capacitor c=6.08603e-17
C101 (\6\:n20 VSS) capacitor c=5.26596e-17
C102 (\7\:n20 VSS) capacitor c=6.50612e-17
C103 (\10\:CKbb VSS) capacitor c=1.19885e-16
C104 (\11\:CKbb VSS) capacitor c=6.55535e-17
C105 (\12\:CKbb VSS) capacitor c=8.36085e-17
C106 (\13\:CKbb VSS) capacitor c=1.19117e-16
C107 (\16\:CKbb VSS) capacitor c=1.73289e-17
C108 (\5\:D VSS) capacitor c=3.59585e-17
C109 (\3\:Db VSS) capacitor c=1.34204e-16
C110 (\8\:SE VSS) capacitor c=6.57447e-17
C111 (\9\:SE VSS) capacitor c=7.15e-17
C112 (\4\:SI VSS) capacitor c=1.0021e-16
C113 (\6\:SEb VSS) capacitor c=7.5654e-17
C114 (\7\:SEb VSS) capacitor c=5.83759e-17
C115 (\3\:VDD VSS) capacitor c=1.85221e-17
C116 (\4\:VDD VSS) capacitor c=1.61635e-17
C117 (\9\:VDD VSS) capacitor c=5.12075e-17
C118 (\12\:VDD VSS) capacitor c=2.50575e-17
Rk28 (\5\:D D) resistor r=0.1705 c=0
Rk52 (\3\:VDD VDD) resistor r=0.1073 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.1967 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.3831 c=0
Rk54 (\4\:VDD \6\:VDD) resistor r=0.1288 c=0
Rk55 (\4\:VDD \8\:VDD) resistor r=0.05996 c=0
Rk56 (\8\:VDD \9\:VDD) resistor r=0.4485 c=0
Rk57 (\9\:VDD \11\:VDD) resistor r=0.1288 c=0
Rk58 (\9\:VDD \12\:VDD) resistor r=0.6463 c=0
Rk59 (\12\:VDD \14\:VDD) resistor r=0.232 c=0
Rk60 (\12\:VDD \15\:VDD) resistor r=0.05746 c=0
Rk61 (\15\:VDD \17\:VDD) resistor r=0.603 c=0
Rk3 (\5\:CK CK) resistor r=0.1244 c=0
Rk34 (\9\:SE SE) resistor r=0.2199 c=0
Rk33 (\8\:SE \9\:SE) resistor r=0.3442 c=0
Rk35 (SE \10\:SE) resistor r=0.002697 c=0
Rk1 (\2\:Q Q) resistor r=0.002997 c=0
Rk2 (Q \4\:Q) resistor r=0.4885 c=0
Rk36 (SI \4\:SI) resistor r=0.009246 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.6617 c=0
Rk41 (\4\:VSS \5\:VSS) resistor r=0.07249 c=0
Rk42 (\5\:VSS \6\:VSS) resistor r=0.6504 c=0
Rk43 (\6\:VSS \7\:VSS) resistor r=0.4275 c=0
Rk44 (\7\:VSS \8\:VSS) resistor r=0.04397 c=0
Rk46 (\9\:VSS VSS) resistor r=0.08728 c=0
Rk45 (\8\:VSS \9\:VSS) resistor r=0.4173 c=0
Rk47 (\5\:VSS \11\:VSS) resistor r=0.2938 c=0
Rk48 (\6\:VSS \13\:VSS) resistor r=0.04328 c=0
Rk49 (\8\:VSS \15\:VSS) resistor r=0.04328 c=0
Rk50 (\9\:VSS \17\:VSS) resistor r=0.07358 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1674 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1206 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.2091 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.7664 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.5284 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.2795 c=0
Rk15 (\14\:CKb \16\:CKb) resistor r=0.537 c=0
Rk16 (\13\:CKb \17\:CKb) resistor r=0.03285 c=0
Rk17 (\14\:CKb \18\:CKb) resistor r=0.3554 c=0
Rk18 (\16\:CKb \20\:CKb) resistor r=0.5296 c=0
Rk8 (\5\:n30 \7\:n30) resistor r=0.4132 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.5086 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.239 c=0
Rk11 (\6\:mout \8\:mout) resistor r=0.12 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.2517 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.6491 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3242 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2057 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.7737 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.3653 c=0
Rk27 (\12\:CKbb \16\:CKbb) resistor r=0.0529 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1253 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3025 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2416 c=0
Rk29 (\2\:Db \3\:Db) resistor r=0.6437 c=0
Rk30 (\3\:Db \5\:Db) resistor r=0.2692 c=0
Rk31 (\3\:Db \7\:Db) resistor r=0.5881 c=0
Rk32 (\7\:Db \9\:Db) resistor r=0.3444 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.3961 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3301 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.08492 c=0
Rl28 (\1\:D \2\:D) resistor r=137.695 c=0
Rl30 (\2\:D \4\:D) resistor r=97.3105 c=0
Rl29 (\2\:D \3\:D) resistor r=29.6836 c=0
Rl6 (\2\:CK \4\:CK) resistor r=142.76 c=0
Rl4 (\1\:CK \2\:CK) resistor r=113.913 c=0
Rl5 (\2\:CK \3\:CK) resistor r=2.733 c=0
Rl37 (\5\:SE \6\:SE) resistor r=183.848 c=0
Rl38 (\6\:SE \7\:SE) resistor r=26.1559 c=0
Rl34 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl31 (\1\:SE \2\:SE) resistor r=76.1559 c=0
Rl35 (\1\:SI \2\:SI) resistor r=93.4636 c=0
Rl36 (\2\:SI \3\:SI) resistor r=116.54 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=212.341 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=37.3411 c=0
Rl1 (qbint \2\:qbint) resistor r=5.0163 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=99.2798 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=34.3295 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=0.5166 c=0
Rl27 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=60.7713 c=0
Rl12 (CKb \2\:CKb) resistor r=30.0021 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=156.492 c=0
Rl25 (\6\:CKb \9\:CKb) resistor r=78.0797 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl26 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=254.684 c=0
Rl7 (n30 \2\:n30) resistor r=132.692 c=0
Rl8 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl18 (mout \2\:mout) resistor r=77.6148 c=0
Rl19 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl21 (\6\:CKbb \7\:CKbb) resistor r=30.0021 c=0
Rl20 (\4\:CKbb \5\:CKbb) resistor r=76.1559 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=110.587 c=0
Rl14 (CKbb \2\:CKbb) resistor r=24.5191 c=0
Rl16 (n20 \2\:n20) resistor r=26.098 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=74.1749 c=0
Rl32 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl33 (\2\:SEb \3\:SEb) resistor r=214.183 c=0
Rz16 (\7\:VDD \8\:VDD) resistor r=6.25 c=0
Rz17 (\7\:VDD \15\:VDD) resistor r=6.8182 c=0
Rz1 (\1\:Q \2\:Q) resistor r=75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry14 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry1 (\3\:Q \4\:Q) resistor r=62 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry12 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx14 (\2\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx16 (\6\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\1\:Q \3\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.028e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.95e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\19\:CKb \1\:CK \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.028e-14 ad=2.538e-14 ps=1.44e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn45 (\11\:qbint \2\:n30 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.905e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n7 \8\:qbint \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.233e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.71e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\6\:n30 CKb n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=4.423e-14 ps=4.6e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.58e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\7\:mout CKbb \6\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.423e-14 ad=4.278e-14 ps=9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.23e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\7\:mout \3\:n20 \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.205e-14 ad=4.278e-14 ps=1.74e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=8.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=8.7e-15 ps=1.74e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=6.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \4\:CKbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=5.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:Db \10\:CKb \8\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.568e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.285e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \4\:D \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.842e-14 ps=7.3e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.02e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=7.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.2e-07 sb=5.05e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \3\:SI \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.827e-14 ps=6.1e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.95e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
ends SDFFQXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:37 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX1 CK D Q RN SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.72308e-07 sd=160n sca=23.0036 \
        scb=0.0261368 scc=0.00127103 m=(1)
mp11 (net381 \1\:D \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.98e-14 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.20897e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp12 (\3\:Db \2\:SE net381 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.15897e-07 sd=160n sca=12.2524 \
        scb=0.0106415 scc=0.00038358 m=(1)
mp14 (\3\:Db SEb net373 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.90897e-07 sd=160n sca=12.9125 \
        scb=0.0109255 scc=0.000383719 m=(1)
mp13 (net373 \3\:SI \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=5.265e-14 ps=1.31e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45064e-07 sb=3.10897e-07 sd=160n sca=14.0619 \
        scb=0.0121239 scc=0.000387547 m=(1)
C1 (D VSS) capacitor c=4.02028e-17
C2 (Q VSS) capacitor c=1.32008e-17
C3 (RN VSS) capacitor c=4.92285e-17
C4 (VDD VSS) capacitor c=3.31669e-16
C5 (SE VSS) capacitor c=7.29724e-17
C6 (SI VSS) capacitor c=4.95859e-17
C7 (qbint VSS) capacitor c=1.87077e-17
C8 (CKb VSS) capacitor c=5.79398e-17
C9 (net337 VSS) capacitor c=4.46366e-18
C10 (n30 VSS) capacitor c=5.62737e-17
C11 (net405 VSS) capacitor c=2.68183e-18
C12 (mout VSS) capacitor c=5.89201e-17
C13 (CKbb VSS) capacitor c=2.15079e-17
C14 (n20 VSS) capacitor c=5.10107e-17
C15 (Db VSS) capacitor c=1.25246e-16
C16 (net450 VSS) capacitor c=6.64026e-18
C17 (SEb VSS) capacitor c=4.56599e-17
C18 (net326 VSS) capacitor c=3.58673e-18
C19 (net349 VSS) capacitor c=5.66685e-17
C20 (net381 VSS) capacitor c=1.5388e-18
C21 (net373 VSS) capacitor c=3.87756e-18
C22 (\5\:SE VSS) capacitor c=4.34616e-17
C23 (\3\:SI VSS) capacitor c=6.71766e-17
C24 (\2\:SE VSS) capacitor c=7.2781e-17
C25 (\1\:D VSS) capacitor c=1.08477e-16
C26 (\8\:CKb VSS) capacitor c=5.09535e-17
C27 (\7\:CKbb VSS) capacitor c=5.28701e-17
C28 (\5\:CKb VSS) capacitor c=5.37722e-17
C29 (\2\:RN VSS) capacitor c=1.36567e-16
C30 (\3\:n20 VSS) capacitor c=5.76825e-17
C31 (\3\:CKb VSS) capacitor c=4.47561e-17
C32 (\3\:CKbb VSS) capacitor c=8.9782e-17
C33 (\5\:qbint VSS) capacitor c=6.9645e-17
C34 (\3\:RN VSS) capacitor c=1.05852e-16
C35 (\1\:CK VSS) capacitor c=4.15702e-17
C36 (\4\:qbint VSS) capacitor c=5.81951e-17
C37 (\7\:SE VSS) capacitor c=3.38833e-17
C38 (\1\:SI VSS) capacitor c=8.0021e-17
C39 (\3\:SE VSS) capacitor c=5.85988e-17
C40 (\3\:SEb VSS) capacitor c=6.55313e-17
C41 (\4\:D VSS) capacitor c=3.86458e-17
C42 (\10\:CKb VSS) capacitor c=6.32977e-17
C43 (\7\:CKb VSS) capacitor c=4.90036e-17
C44 (\4\:CKbb VSS) capacitor c=4.60951e-17
C45 (\3\:mout VSS) capacitor c=6.5346e-17
C46 (\1\:RN VSS) capacitor c=8.98021e-17
C47 (\7\:qbint VSS) capacitor c=5.63759e-17
C48 (\5\:RN VSS) capacitor c=5.13029e-17
C49 (\3\:n30 VSS) capacitor c=2.92865e-17
C50 (\3\:CK VSS) capacitor c=4.94278e-17
C51 (\3\:qbint VSS) capacitor c=3.43207e-17
C52 (\6\:SE VSS) capacitor c=4.00113e-17
C53 (\2\:SI VSS) capacitor c=6.47187e-17
C54 (\4\:SE VSS) capacitor c=4.35427e-17
C55 (\2\:SEb VSS) capacitor c=5.76262e-17
C56 (\1\:SE VSS) capacitor c=5.21226e-17
C57 (\3\:D VSS) capacitor c=2.56249e-17
C58 (\9\:CKb VSS) capacitor c=2.77675e-17
C59 (\6\:CKbb VSS) capacitor c=3.78216e-17
C60 (\6\:CKb VSS) capacitor c=2.06381e-17
C61 (\5\:CKbb VSS) capacitor c=4.02057e-17
C62 (\2\:mout VSS) capacitor c=5.94538e-17
C63 (\2\:n20 VSS) capacitor c=4.95181e-17
C64 (\4\:CKb VSS) capacitor c=3.20777e-17
C65 (\2\:CKbb VSS) capacitor c=5.81745e-17
C66 (\2\:CKb VSS) capacitor c=5.73752e-17
C67 (\6\:qbint VSS) capacitor c=6.90841e-17
C68 (\6\:RN VSS) capacitor c=2.54602e-17
C69 (\2\:n30 VSS) capacitor c=3.94228e-17
C70 (\2\:CK VSS) capacitor c=4.49341e-17
C71 (\5\:SEb VSS) capacitor c=9.49591e-17
C72 (\1\:VDD VSS) capacitor c=6.00638e-17
C73 (\3\:Db VSS) capacitor c=1.44401e-16
C74 (\5\:VDD VSS) capacitor c=1.58364e-17
C75 (\8\:CKbb VSS) capacitor c=6.70995e-17
C76 (\6\:Db VSS) capacitor c=1.70823e-16
C77 (\4\:n20 VSS) capacitor c=5.7e-17
C78 (\8\:VDD VSS) capacitor c=3.43276e-17
C79 (\3\:net349 VSS) capacitor c=6.80599e-17
C80 (\11\:VDD VSS) capacitor c=4.56672e-17
C81 (\8\:mout VSS) capacitor c=8.76327e-17
C82 (\4\:n30 VSS) capacitor c=1.20594e-16
C83 (\14\:VDD VSS) capacitor c=4.95149e-17
C84 (\12\:qbint VSS) capacitor c=5.57533e-17
C85 (\18\:VDD VSS) capacitor c=3.75173e-17
C86 (\15\:CKb VSS) capacitor c=1.39541e-16
C87 (\21\:VDD VSS) capacitor c=6.69337e-17
C88 (\1\:Q VSS) capacitor c=6.65291e-17
C89 (\3\:VDD VSS) capacitor c=6.82542e-17
C90 (\7\:SEb VSS) capacitor c=7.51405e-17
C91 (\14\:CKbb VSS) capacitor c=1.91864e-17
C92 (\8\:Db VSS) capacitor c=1.05964e-16
C93 (\8\:n20 VSS) capacitor c=9.32742e-17
C94 (\6\:mout VSS) capacitor c=6.53465e-17
C95 (\6\:n30 VSS) capacitor c=1.5523e-16
C96 (\10\:qbint VSS) capacitor c=1.45716e-16
C97 (\19\:CKb VSS) capacitor c=1.12488e-16
C98 (\4\:Q VSS) capacitor c=3.18057e-17
C99 (\2\:qbint VSS) capacitor c=2.41639e-17
C100 (\4\:RN VSS) capacitor c=3.35345e-17
C101 (\2\:D VSS) capacitor c=2.57214e-17
C102 (\3\:Q VSS) capacitor c=5.2911e-17
C103 (\4\:CK VSS) capacitor c=5.9995e-17
C104 (\5\:CK VSS) capacitor c=4.32737e-17
C105 (\8\:RN VSS) capacitor c=4.94178e-17
C106 (\8\:qbint VSS) capacitor c=6.41541e-17
C107 (\9\:qbint VSS) capacitor c=1.04086e-16
C108 (\14\:qbint VSS) capacitor c=1.2535e-16
C109 (\8\:n30 VSS) capacitor c=1.20216e-16
C110 (\4\:mout VSS) capacitor c=8.78146e-17
C111 (\5\:mout VSS) capacitor c=1.06079e-16
C112 (\6\:n20 VSS) capacitor c=9.96866e-17
C113 (\7\:n20 VSS) capacitor c=8.07361e-17
C114 (\10\:CKbb VSS) capacitor c=3.8112e-17
C115 (\11\:CKbb VSS) capacitor c=9.89327e-17
C116 (\12\:CKbb VSS) capacitor c=2.22983e-16
C117 (\13\:CKbb VSS) capacitor c=1.89909e-16
C118 (\16\:CKbb VSS) capacitor c=3.84947e-17
C119 (\11\:CKb VSS) capacitor c=8.07945e-17
C120 (\12\:CKb VSS) capacitor c=1.48916e-16
C121 (\13\:CKb VSS) capacitor c=1.35084e-16
C122 (\14\:CKb VSS) capacitor c=1.65703e-16
C123 (\17\:CKb VSS) capacitor c=8.29889e-17
C124 (\18\:CKb VSS) capacitor c=5.22664e-17
C125 (\6\:D VSS) capacitor c=3.78147e-17
C126 (\5\:Db VSS) capacitor c=5.07665e-17
C127 (\4\:SI VSS) capacitor c=5.5802e-17
C128 (\8\:SE VSS) capacitor c=6.22354e-17
C129 (\9\:SE VSS) capacitor c=4.45e-17
C130 (\10\:SE VSS) capacitor c=5.99161e-17
C131 (\4\:SEb VSS) capacitor c=8.13389e-17
C132 (\7\:VDD VSS) capacitor c=3.28424e-17
C133 (\10\:VDD VSS) capacitor c=3.63379e-17
C134 (\13\:VDD VSS) capacitor c=3.0829e-17
C135 (\17\:VDD VSS) capacitor c=1.41645e-17
C136 (\20\:VDD VSS) capacitor c=1.01631e-17
Rk36 (\5\:D \6\:D) resistor r=0.002289 c=0
Rk37 (\7\:D D) resistor r=0.002403 c=0
Rk38 (\6\:D \7\:D) resistor r=0.09354 c=0
Rk2 (\3\:Q Q) resistor r=0.007258 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.4303 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1825 c=0
Rk7 (\7\:RN \8\:RN) resistor r=0.008733 c=0
Rk8 (\9\:RN RN) resistor r=0.008733 c=0
Rk9 (\8\:RN \9\:RN) resistor r=0.01996 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.5885 c=0
Rk60 (\4\:VDD \6\:VDD) resistor r=0.1215 c=0
Rk61 (\4\:VDD \7\:VDD) resistor r=0.4558 c=0
Rk62 (\7\:VDD \9\:VDD) resistor r=0.04338 c=0
Rk63 (\7\:VDD \10\:VDD) resistor r=0.2196 c=0
Rk64 (\10\:VDD \12\:VDD) resistor r=0.1543 c=0
Rk65 (\10\:VDD \13\:VDD) resistor r=0.4741 c=0
Rk66 (\13\:VDD \15\:VDD) resistor r=0.247 c=0
Rk67 (\13\:VDD \16\:VDD) resistor r=0.05253 c=0
Rk68 (\16\:VDD \17\:VDD) resistor r=0.2132 c=0
Rk69 (\17\:VDD \19\:VDD) resistor r=0.1543 c=0
Rk72 (\20\:VDD VDD) resistor r=0.1251 c=0
Rk70 (\17\:VDD \20\:VDD) resistor r=0.213 c=0
Rk71 (\20\:VDD \22\:VDD) resistor r=0.3203 c=0
Rk45 (\8\:SE SE) resistor r=0.3149 c=0
Rk46 (SE \9\:SE) resistor r=0.0751 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.2249 c=0
Rk44 (SI \4\:SI) resistor r=0.02621 c=0
Rk50 (\2\:VSS \4\:VSS) resistor r=0.7354 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.6777 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.5277 c=0
Rk54 (\7\:VSS VSS) resistor r=0.1251 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.4266 c=0
Rk55 (\4\:VSS \9\:VSS) resistor r=0.3693 c=0
Rk56 (\5\:VSS \11\:VSS) resistor r=0.2545 c=0
Rk57 (\6\:VSS \13\:VSS) resistor r=0.1976 c=0
Rk58 (\7\:VSS \15\:VSS) resistor r=0.3086 c=0
Rk4 (CK \4\:CK) resistor r=0.004227 c=0
Rk6 (\4\:CK \5\:CK) resistor r=0.07064 c=0
Rk5 (\5\:CK \6\:CK) resistor r=0.004227 c=0
Rk10 (\8\:qbint \9\:qbint) resistor r=0.3799 c=0
Rk11 (\9\:qbint \11\:qbint) resistor r=0.5415 c=0
Rk12 (\9\:qbint \13\:qbint) resistor r=0.2374 c=0
Rk13 (\11\:qbint \14\:qbint) resistor r=0.6457 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.3924 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8429 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3488 c=0
Rk32 (\14\:CKb \16\:CKb) resistor r=0.781 c=0
Rk33 (\13\:CKb \17\:CKb) resistor r=0.2949 c=0
Rk34 (\14\:CKb \18\:CKb) resistor r=0.326 c=0
Rk35 (\16\:CKb \20\:CKb) resistor r=0.5326 c=0
Rk14 (\5\:n30 \7\:n30) resistor r=0.588 c=0
