Rk64 (\11\:VSS \20\:VSS) resistor r=0.2184 c=0
Rk65 (\13\:VSS \22\:VSS) resistor r=0.2184 c=0
Rk66 (\14\:VSS \24\:VSS) resistor r=0.223 c=0
Rk67 (\2\:VDD \3\:VDD) resistor r=0.802 c=0
Rk74 (\4\:VDD VDD) resistor r=0.03213 c=0
Rk68 (\3\:VDD \4\:VDD) resistor r=0.9146 c=0
Rk11 (net130 \9\:net130) resistor r=0.501 c=0
Rl60 (C0 \12\:C0) resistor r=101.421 c=0
Rl51 (C0 \8\:C0) resistor r=28.5806 c=0
Rl52 (C0 \9\:C0) resistor r=84.3341 c=0
Rl42 (C0 \3\:C0) resistor r=29.9442 c=0
Rl24 (\3\:B1 B1) resistor r=48.1957 c=0
Rl27 (\3\:B1 \6\:B1) resistor r=34.9276 c=0
Rl25 (\3\:B1 \4\:B1) resistor r=97.2646 c=0
Rl36 (\11\:B1 B1) resistor r=55.6945 c=0
Rl38 (\11\:B1 \13\:B1) resistor r=100.426 c=0
Rl37 (\11\:B1 \12\:B1) resistor r=35.772 c=0
Rl20 (A0 \12\:A0) resistor r=33.7912 c=0
Rl9 (A0 \4\:A0) resistor r=82.4994 c=0
Rl12 (A0 \8\:A0) resistor r=33.1976 c=0
Rl1 (A0 \1\:A0) resistor r=67.0977 c=0
Rl44 (\3\:C1 C1) resistor r=6.3032 c=0
Rl45 (\3\:C1 \4\:C1) resistor r=76.9865 c=0
Rl47 (\3\:C1 \6\:C1) resistor r=126.408 c=0
Rl55 (\10\:C1 C1) resistor r=24.9043 c=0
Rl58 (\10\:C1 \13\:C1) resistor r=32.7557 c=0
Rl56 (\10\:C1 \11\:C1) resistor r=82.1768 c=0
Rl40 (\1\:B0 \12\:B0) resistor r=33.3841 c=0
Rl31 (\1\:B0 \8\:B0) resistor r=28.5806 c=0
Rl32 (\1\:B0 \9\:B0) resistor r=84.3341 c=0
Rl22 (\1\:B0 \3\:B0) resistor r=33.3841 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.6542 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=126.408 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=76.9865 c=0
Rl15 (\9\:A1 \3\:A1) resistor r=6.3032 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\6\:Y \5\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\11\:Y \10\:Y) resistor r=75 c=0
Rz6 (\13\:Y \12\:Y) resistor r=75 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz8 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz9 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz10 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz11 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz12 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz13 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz16 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry23 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \12\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (12 \1\:A0 \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (\10\:Y \4\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_2__rcx (\10\:Y \1\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0_2__rcx (13 \8\:A0 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (14 \4\:A0 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_3__rcx (\8\:Y \11\:A1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (\8\:Y \8\:A1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.07e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0 (15 \12\:A0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.17e-13 ad=1.56e-14 ps=1.42e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (16 \3\:B0 \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.17e-13 ad=2.99e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (\5\:Y \4\:B1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_2__rcx (\5\:Y \6\:B1 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_2__rcx (17 \9\:B0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_3__rcx (18 \8\:B0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=7.93e-14 ps=8.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn3_3__rcx (\3\:Y \12\:B1 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.84e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3 (\3\:Y \13\:B1 19 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.635e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (19 \12\:B0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.43e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4_1__rcx (20 \3\:C0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.86e-14 ps=8.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.225e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_1__rcx (\1\:Y \6\:C1 20 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=4.16e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.07e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_2__rcx (\1\:Y \4\:C1 21 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4_2__rcx (21 \9\:C0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn4_3__rcx (22 \8\:C0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_3__rcx (\12\:Y \11\:C1 22 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn5 (\12\:Y \13\:C1 23 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4 (23 \12\:C0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
ends AOI222X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:50 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI222XL
// View name: extracted

simulator lang=spectre

subckt AOI222XL A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (\3\:net134 \3\:A0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.44e-14 ad=3.977e-14 ps=1.75e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.3e-07 sd=160n sca=43.6839 scb=0.0409846 \
        scc=0.00506402 m=(1)
mp1 (\3\:net134 \1\:A1 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.44e-14 ad=3.977e-14 ps=1.75e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1e-07 sd=160n sca=35.9206 scb=0.0284699 \
        scc=0.00428553 m=(1)
mp3 (\6\:net122 \1\:B1 net134 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp2 (net122 \1\:B0 net134 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=13.1974 \
        scb=0.0118569 scc=0.000425239 m=(1)
mp4 (\1\:Y \1\:C0 net122 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=4.085e-14 ps=8.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=3.75e-07 sd=160n sca=14.7565 scb=0.0134564 \
        scc=0.00043091 m=(1)
mp5 (\1\:Y \1\:C1 \4\:net122 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=20.3151 \
        scb=0.022841 scc=0.000796775 m=(1)
C1 (C1 VSS) capacitor c=6.92568e-17
C2 (B1 VSS) capacitor c=6.47526e-17
C3 (C0 VSS) capacitor c=8.88402e-17
C4 (A1 VSS) capacitor c=6.00824e-17
C5 (VDD VSS) capacitor c=1.52734e-16
C6 (B0 VSS) capacitor c=3.50694e-17
C7 (A0 VSS) capacitor c=3.96531e-17
C8 (Y VSS) capacitor c=9.19029e-17
C9 (net147 VSS) capacitor c=5.70603e-18
C10 (net155 VSS) capacitor c=3.97139e-18
C11 (net134 VSS) capacitor c=1.0982e-16
C12 (net122 VSS) capacitor c=1.90284e-17
C13 (\1\:C1 VSS) capacitor c=3.2969e-17
C14 (\1\:C0 VSS) capacitor c=6.05328e-17
C15 (\1\:B0 VSS) capacitor c=4.4556e-17
C16 (\1\:B1 VSS) capacitor c=5.32307e-17
C17 (\1\:A1 VSS) capacitor c=4.7029e-17
C18 (\3\:A0 VSS) capacitor c=3.34518e-17
C19 (\3\:C1 VSS) capacitor c=6.13721e-17
C20 (\3\:C0 VSS) capacitor c=3.80588e-17
C21 (\3\:B0 VSS) capacitor c=5.23791e-17
C22 (\3\:B1 VSS) capacitor c=3.415e-17
C23 (\3\:A1 VSS) capacitor c=2.94979e-17
C24 (\1\:A0 VSS) capacitor c=4.11024e-17
C25 (\2\:C1 VSS) capacitor c=4.99567e-17
C26 (\2\:C0 VSS) capacitor c=6.42399e-17
C27 (\2\:B0 VSS) capacitor c=5.32894e-17
C28 (\2\:B1 VSS) capacitor c=4.36694e-17
C29 (\2\:A1 VSS) capacitor c=3.94947e-17
C30 (\2\:A0 VSS) capacitor c=4.17712e-17
C31 (\4\:net122 VSS) capacitor c=5.98756e-17
C32 (\1\:Y VSS) capacitor c=9.62416e-17
C33 (\6\:net122 VSS) capacitor c=6.05483e-17
C34 (\5\:VDD VSS) capacitor c=7.11971e-18
C35 (\3\:net134 VSS) capacitor c=5.04603e-17
C36 (\7\:VDD VSS) capacitor c=3.27059e-18
C37 (\3\:Y VSS) capacitor c=8.3737e-17
C38 (\5\:Y VSS) capacitor c=7.28602e-17
C39 (\4\:A0 VSS) capacitor c=3.71337e-17
C40 (\4\:A1 VSS) capacitor c=3.60708e-17
C41 (\4\:B1 VSS) capacitor c=3.91303e-17
C42 (\4\:B0 VSS) capacitor c=8.7929e-17
C43 (\4\:C0 VSS) capacitor c=4.40468e-17
C44 (\4\:C1 VSS) capacitor c=5.99864e-17
C45 (\3\:net122 VSS) capacitor c=4.81816e-17
C46 (\3\:VDD VSS) capacitor c=6.68923e-17
C47 (\4\:VDD VSS) capacitor c=7.42043e-18
Rk7 (C1 \4\:C1) resistor r=0.112 c=0
Rk3 (\4\:B1 B1) resistor r=0.07088 c=0
Rk6 (C0 \4\:C0) resistor r=0.09829 c=0
Rk2 (\4\:A1 A1) resistor r=0.1778 c=0
Rk20 (\4\:VDD VDD) resistor r=0.03715 c=0
Rk19 (\3\:VDD \4\:VDD) resistor r=0.2126 c=0
Rk21 (\3\:VDD \6\:VDD) resistor r=0.07346 c=0
Rk22 (\4\:VDD \8\:VDD) resistor r=0.07346 c=0
Rk5 (B0 \4\:B0) resistor r=0.06743 c=0
Rk1 (\4\:A0 A0) resistor r=0.191 c=0
Rk11 (\2\:Y Y) resistor r=0.6536 c=0
Rk12 (Y \4\:Y) resistor r=0.2087 c=0
Rk13 (\4\:Y \6\:Y) resistor r=0.5987 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.222 c=0
Rk16 (\5\:VSS VSS) resistor r=0.05469 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.3958 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.1798 c=0
Rk4 (\2\:net134 \4\:net134) resistor r=0.4783 c=0
Rk8 (\2\:net122 \3\:net122) resistor r=0.04758 c=0
Rk9 (\3\:net122 \5\:net122) resistor r=0.3715 c=0
Rk10 (\3\:net122 \7\:net122) resistor r=0.3269 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=71.1538 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=170.604 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=156.461 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=83.3841 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=210.307 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=29.5379 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=152.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=97.872 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=134.603 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=95.6044 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=88.4615 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\5\:Y \6\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry8 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\1\:Y \2\:Y) resistor r=62 c=0
Ry1 (net134 \2\:net134) resistor r=62 c=0
Ry2 (\3\:net134 \4\:net134) resistor r=62 c=0
Ry3 (net122 \2\:net122) resistor r=62 c=0
Ry4 (\4\:net122 \5\:net122) resistor r=62 c=0
Ry5 (\6\:net122 \7\:net122) resistor r=62 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net139 \1\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.595e-14 ps=5.7e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (\5\:Y \3\:A1 net139 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=7.395e-14 ps=5.1e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=1.315e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn3 (\5\:Y \3\:B1 net147 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=7.395e-14 ps=5.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=7.6e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn2 (net147 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.175e-14 ps=1.05e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=5.65e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn4 (net155 \3\:C0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.668e-14 ps=1.05e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=3e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn5 (\3\:Y \3\:C1 net155 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
ends AOI222XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:51 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI22X1
// View name: extracted

simulator lang=spectre

subckt AOI22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=5.46e-14 ps=1.44e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=25.383 \
        scb=0.0290112 scc=0.00169816 m=(1)
mp1 (\3\:net89 \1\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=6.435e-14 ps=1.44e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.6e-07 sd=160n sca=15.7692 \
        scb=0.0144715 scc=0.000333573 m=(1)
mp3 (\1\:Y \1\:B1 \3\:net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.435e-14 ps=1.11e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.5e-07 sd=160n sca=14.4126 \
        scb=0.011746 scc=0.00029444 m=(1)
mp2 (\1\:Y \1\:B0 net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.4e-07 sd=160n sca=16.4371 \
        scb=0.0157949 scc=0.000369535 m=(1)
C1 (Y VSS) capacitor c=7.85579e-17
C2 (B1 VSS) capacitor c=2.4454e-17
C3 (VDD VSS) capacitor c=9.30093e-17
C4 (B0 VSS) capacitor c=3.48214e-17
C5 (A0 VSS) capacitor c=6.84418e-17
C6 (net102 VSS) capacitor c=2.43791e-18
C7 (net89 VSS) capacitor c=5.34431e-17
C8 (\1\:B0 VSS) capacitor c=5.46304e-17
C9 (\1\:B1 VSS) capacitor c=5.70413e-17
C10 (\1\:A1 VSS) capacitor c=8.26747e-17
C11 (\1\:A0 VSS) capacitor c=6.8793e-17
C12 (\3\:B0 VSS) capacitor c=4.189e-17
C13 (\3\:B1 VSS) capacitor c=5.40722e-17
C14 (\3\:A1 VSS) capacitor c=4.00494e-17
C15 (\4\:A0 VSS) capacitor c=4.32286e-17
C16 (\2\:B0 VSS) capacitor c=5.1167e-17
C17 (\2\:B1 VSS) capacitor c=5.52593e-17
C18 (\2\:A1 VSS) capacitor c=6.21341e-17
C19 (\3\:A0 VSS) capacitor c=1.69153e-17
C20 (\1\:Y VSS) capacitor c=8.61894e-17
C21 (\3\:net89 VSS) capacitor c=9.51955e-17
C22 (\4\:VDD VSS) capacitor c=4.59442e-17
C23 (\5\:net89 VSS) capacitor c=4.30316e-17
C24 (\3\:Y VSS) capacitor c=1.06063e-16
C25 (\2\:A0 VSS) capacitor c=3.87455e-17
C26 (\4\:A1 VSS) capacitor c=4.08679e-17
C27 (\5\:A1 VSS) capacitor c=4.4388e-17
C28 (\4\:B1 VSS) capacitor c=7.16434e-17
C29 (\4\:B0 VSS) capacitor c=3.53817e-17
C30 (\3\:VDD VSS) capacitor c=4.5621e-17
Rk6 (\2\:Y Y) resistor r=0.2428 c=0
Rk7 (Y \4\:Y) resistor r=0.5393 c=0
Rk5 (B1 \4\:B1) resistor r=0.03079 c=0
Rk2 (A1 \4\:A1) resistor r=0.004076 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.06597 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.004196 c=0
Rk12 (\4\:VSS VSS) resistor r=0.2507 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.3583 c=0
Rk13 (VSS \6\:VSS) resistor r=0.2284 c=0
Rk15 (\3\:VDD VDD) resistor r=0.1014 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.1285 c=0
Rk10 (\4\:B0 B0) resistor r=0.03383 c=0
Rk1 (A0 \5\:A0) resistor r=0.00426 c=0
Rk8 (\2\:net89 \4\:net89) resistor r=0.4624 c=0
Rk9 (\4\:net89 \6\:net89) resistor r=0.4119 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=98.0568 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=94.2107 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=171.131 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=144.231 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=54.9451 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=152.726 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=60.4181 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.013 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=20.6667 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=31 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=31 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (net102 \4\:A0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.99e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:Y \3\:A1 net102 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=5.46e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=5.5e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
mn3 (\3\:Y \3\:B1 net98 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=5.46e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net98 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.86e-14 ps=8e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
ends AOI22X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:53 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI22X2
// View name: extracted

simulator lang=spectre

subckt AOI22X2 A0 A1 B0 B1 VDD VSS Y
mp1_1__rcx (\10\:net89 \3\:A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.635e-06 sd=160n \
        sca=25.8099 scb=0.0207374 scc=0.00244421 m=(2)
mp0 (net89 \2\:A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=9.262e-14 ps=1.19e-06 pd=1.255e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.84e-06 sd=160n sca=31.4293 \
        scb=0.0302361 scc=0.00287283 m=(2)
mp3_1__rcx (\1\:Y \1\:B1 \3\:net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.5e-07 sd=160n sca=24.4001 \
        scb=0.0188912 scc=0.00243299 m=(2)
mp2 (\1\:Y \1\:B0 net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.262e-14 ad=6.24e-14 ps=1.255e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=7.55e-07 sd=160n sca=23.571 \
        scb=0.0183444 scc=0.00243237 m=(2)
C1 (Y VSS) capacitor c=3.79012e-17
C2 (B1 VSS) capacitor c=5.73436e-17
C3 (A0 VSS) capacitor c=2.38427e-17
C4 (VDD VSS) capacitor c=8.40968e-17
C5 (B0 VSS) capacitor c=3.77173e-17
C6 (10 VSS) capacitor c=1.596e-18
C7 (11 VSS) capacitor c=3.31755e-18
C8 (net89 VSS) capacitor c=2.40714e-16
C9 (\1\:B1 VSS) capacitor c=9.70409e-17
C10 (\1\:B0 VSS) capacitor c=3.13574e-16
C11 (\6\:B0 VSS) capacitor c=3.72191e-17
C12 (\6\:B1 VSS) capacitor c=3.4551e-17
C13 (\4\:B1 VSS) capacitor c=4.76982e-17
C14 (\3\:B0 VSS) capacitor c=4.10391e-17
C15 (\6\:A0 VSS) capacitor c=5.79125e-17
C16 (\1\:A1 VSS) capacitor c=5.63712e-17
C17 (\4\:A1 VSS) capacitor c=5.13876e-17
C18 (\1\:A0 VSS) capacitor c=5.02193e-17
C19 (\3\:A1 VSS) capacitor c=9.86217e-17
C20 (\2\:A0 VSS) capacitor c=3.18573e-16
C21 (\1\:Y VSS) capacitor c=1.97644e-16
C22 (\3\:net89 VSS) capacitor c=1.1181e-16
C23 (\10\:net89 VSS) capacitor c=3.4712e-17
C24 (\9\:Y VSS) capacitor c=5.0633e-17
C25 (\7\:Y VSS) capacitor c=5.36694e-17
C26 (\2\:A1 VSS) capacitor c=3.68702e-17
C27 (\3\:B1 VSS) capacitor c=1.87409e-17
C28 (\7\:A1 VSS) capacitor c=2.88107e-17
C29 (\9\:A1 VSS) capacitor c=3.70623e-17
C30 (\8\:B1 VSS) capacitor c=2.79725e-17
C31 (\5\:Y VSS) capacitor c=4.39301e-17
C32 (\6\:Y VSS) capacitor c=7.17132e-17
C33 (\3\:VDD VSS) capacitor c=1.55937e-16
Rk13 (\5\:Y Y) resistor r=0.06149 c=0
Rk10 (\1\:Y \5\:Y) resistor r=0.2738 c=0
Rk11 (\5\:Y \6\:Y) resistor r=0.2504 c=0
Rk12 (\6\:Y \8\:Y) resistor r=0.3232 c=0
Rk14 (\6\:Y \10\:Y) resistor r=0.3095 c=0
Rk6 (\7\:B1 \8\:B1) resistor r=0.001097 c=0
Rk7 (\9\:B1 B1) resistor r=0.001206 c=0
Rk8 (\8\:B1 \9\:B1) resistor r=0.03292 c=0
Rk5 (\2\:A0 A0) resistor r=0.1194 c=0
Rk22 (\2\:VSS \4\:VSS) resistor r=0.6683 c=0
Rk24 (\5\:VSS VSS) resistor r=0.18 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.3211 c=0
Rk25 (\4\:VSS \7\:VSS) resistor r=0.2111 c=0
Rk26 (\5\:VSS \9\:VSS) resistor r=0.2293 c=0
Rk29 (\3\:VDD VDD) resistor r=0.1374 c=0
Rk20 (B0 \1\:B0) resistor r=0.1831 c=0
Rk1 (\7\:A1 \8\:A1) resistor r=0.001293 c=0
Rk2 (A1 \9\:A1) resistor r=0.001164 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.0225 c=0
Rk19 (net89 \11\:net89) resistor r=0.06242 c=0
Rl13 (\3\:B1 \1\:B1) resistor r=13.5863 c=0
Rl16 (\3\:B1 \6\:B1) resistor r=32.2187 c=0
Rl14 (\3\:B1 \4\:B1) resistor r=75.2063 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.9849 c=0
Rl18 (\1\:B0 \6\:B0) resistor r=24.7951 c=0
Rl11 (\1\:B0 \3\:B0) resistor r=29.5379 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=95.9194 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=51.7685 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=10.4 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Rz2 (\10\:Y \9\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Ry4 (net89 \3\:net89) resistor r=62 c=0
Ry7 (\11\:net89 \10\:net89) resistor r=31 c=0
Rx4 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
mn0_1__rcx (9 \1\:A0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\7\:Y \4\:A1 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.345e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1 (\7\:Y \1\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.14e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (10 \6\:A0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=1.56e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.035e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_1__rcx (11 \3\:B0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=3.12e-14 ps=1.37e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=6.55e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3_1__rcx (\9\:Y \4\:B1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=4.9e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3 (\9\:Y \6\:B1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.6e-14 \
        ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.305e-06 sb=2.85e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (12 \6\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.6e-14 ps=8e-07 pd=7.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.45e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
ends AOI22X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:54 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI22X4
// View name: extracted

simulator lang=spectre

subckt AOI22X4 A0 A1 B0 B1 VDD VSS Y
mp0_1__rcx (net89 \2\:A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=28.0553 scb=0.030197 \
        scc=0.00226721 m=(4)
mp1 (net89 A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=21.2373 scb=0.019015 \
        scc=0.00161477 m=(4)
mp2_1__rcx (\10\:Y B0 net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3_1__rcx (\10\:Y B1 net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.37e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
C1 (Y VSS) capacitor c=6.42597e-17
C2 (B1 VSS) capacitor c=3.99413e-16
C3 (A0 VSS) capacitor c=3.54318e-17
C4 (VDD VSS) capacitor c=1.36246e-16
C5 (B0 VSS) capacitor c=6.07684e-16
C6 (A1 VSS) capacitor c=3.83383e-16
C7 (10 VSS) capacitor c=1.77435e-18
C8 (11 VSS) capacitor c=1.76875e-18
C9 (12 VSS) capacitor c=4.21738e-18
C10 (13 VSS) capacitor c=4.18161e-18
C11 (14 VSS) capacitor c=1.75671e-18
C12 (15 VSS) capacitor c=2.07872e-18
C13 (net89 VSS) capacitor c=5.99504e-16
C14 (\13\:B0 VSS) capacitor c=7.33347e-17
C15 (\12\:B1 VSS) capacitor c=4.7138e-17
C16 (\10\:B1 VSS) capacitor c=6.74335e-17
C17 (\10\:B0 VSS) capacitor c=4.88594e-17
C18 (\9\:B0 VSS) capacitor c=5.11682e-17
C19 (\4\:B1 VSS) capacitor c=5.37334e-17
C20 (\6\:B1 VSS) capacitor c=4.06327e-17
C21 (\3\:B0 VSS) capacitor c=4.09926e-17
C22 (\14\:A0 VSS) capacitor c=4.07889e-17
C23 (\12\:A1 VSS) capacitor c=3.90291e-17
C24 (\10\:A1 VSS) capacitor c=5.40902e-17
C25 (\4\:A0 VSS) capacitor c=6.65438e-17
C26 (\9\:A0 VSS) capacitor c=4.80871e-17
C27 (\1\:A1 VSS) capacitor c=6.709e-17
C28 (\4\:A1 VSS) capacitor c=4.71301e-17
C29 (\1\:A0 VSS) capacitor c=7.49357e-17
C30 (\2\:A0 VSS) capacitor c=5.62441e-16
C31 (\10\:Y VSS) capacitor c=2.77951e-16
C32 (\1\:VDD VSS) capacitor c=8.89833e-17
C33 (\8\:Y VSS) capacitor c=6.40772e-17
C34 (\1\:Y VSS) capacitor c=9.51269e-17
C35 (\4\:Y VSS) capacitor c=8.49395e-17
C36 (\6\:Y VSS) capacitor c=6.80517e-17
C37 (\2\:A1 VSS) capacitor c=2.7788e-17
C38 (\5\:A0 VSS) capacitor c=2.04e-17
C39 (\9\:A1 VSS) capacitor c=3.72581e-17
C40 (\3\:B1 VSS) capacitor c=3.61156e-17
C41 (\9\:B1 VSS) capacitor c=1.93489e-17
C42 (\3\:Y VSS) capacitor c=7.58978e-17
C43 (\3\:VDD VSS) capacitor c=2.19377e-16
Rk14 (Y \10\:Y) resistor r=0.1778 c=0
Rk13 (\3\:Y Y) resistor r=0.2982 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.3131 c=0
Rk10 (\3\:Y \5\:Y) resistor r=0.2888 c=0
Rk11 (\5\:Y \7\:Y) resistor r=0.4656 c=0
Rk12 (\2\:Y \9\:Y) resistor r=0.4593 c=0
Rk3 (A0 \2\:A0) resistor r=0.06806 c=0
Rk32 (\2\:VSS \4\:VSS) resistor r=0.2663 c=0
Rk33 (\4\:VSS \5\:VSS) resistor r=0.2628 c=0
Rk34 (\5\:VSS \6\:VSS) resistor r=0.3603 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.2778 c=0
Rk36 (\7\:VSS \8\:VSS) resistor r=0.08245 c=0
Rk38 (\9\:VSS VSS) resistor r=0.1724 c=0
Rk37 (\8\:VSS \9\:VSS) resistor r=0.2951 c=0
Rk39 (\5\:VSS \11\:VSS) resistor r=0.1979 c=0
Rk40 (\6\:VSS \13\:VSS) resistor r=0.1979 c=0
Rk41 (\8\:VSS \15\:VSS) resistor r=0.1979 c=0
Rk42 (\9\:VSS \17\:VSS) resistor r=0.2024 c=0
Rk51 (\3\:VDD VDD) resistor r=0.1248 c=0
Rk43 (\2\:VDD \3\:VDD) resistor r=0.7111 c=0
Rl26 (\3\:B1 B1) resistor r=10.2925 c=0
Rl27 (\3\:B1 \4\:B1) resistor r=78.9095 c=0
Rl29 (\3\:B1 \6\:B1) resistor r=128.331 c=0
Rl36 (\9\:B1 B1) resistor r=27.337 c=0
Rl39 (\9\:B1 \12\:B1) resistor r=32.6005 c=0
Rl37 (\9\:B1 \10\:B1) resistor r=80.4523 c=0
Rl21 (\2\:A0 \14\:A0) resistor r=52.7257 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=124.977 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=82.1768 c=0
Rl12 (\5\:A0 \9\:A0) resistor r=32.7557 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=3.9095 c=0
Rl41 (B0 \13\:B0) resistor r=121.131 c=0
Rl34 (B0 \10\:B0) resistor r=45.9329 c=0
Rl33 (B0 \9\:B0) resistor r=67.3652 c=0
Rl23 (B0 \3\:B0) resistor r=48.8796 c=0
Rl4 (\2\:A1 A1) resistor r=28.05 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=80.4523 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.6005 c=0
Rl15 (\9\:A1 A1) resistor r=10.2925 c=0
Rl18 (\9\:A1 \12\:A1) resistor r=128.331 c=0
Rl16 (\9\:A1 \10\:A1) resistor r=78.9095 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz7 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz8 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz9 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=12.5 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry15 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (9 \1\:A0 \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\6\:Y \4\:A1 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\6\:Y \1\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (10 \9\:A0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (11 \4\:A0 \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.995e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\4\:Y \10\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.89e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\4\:Y \12\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.685e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (12 \14\:A0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.48e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (13 \3\:B0 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.275e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\1\:Y \6\:B1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=1.07e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\1\:Y \4\:B1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=8.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (14 \9\:B0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=7.6e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (15 \10\:B0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (\8\:Y \10\:B1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (\8\:Y \12\:B1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (16 \13\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
ends AOI22X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:55 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI22XL
// View name: extracted

simulator lang=spectre

subckt AOI22XL A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
mp1 (\3\:net89 \1\:A1 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=15.407 scb=0.01402 \
        scc=0.000262427 m=(1)
mp3 (\3\:Y \1\:B1 \3\:net89 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=14.2109 \
        scb=0.0116139 scc=0.000225742 m=(1)
mp2 (\3\:Y \4\:B0 net89 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=17.4411 \
        scb=0.0179282 scc=0.000407312 m=(1)
C1 (B1 VSS) capacitor c=6.71939e-17
C2 (A1 VSS) capacitor c=3.17609e-17
C3 (VDD VSS) capacitor c=1.10875e-16
C4 (A0 VSS) capacitor c=2.30335e-17
C5 (Y VSS) capacitor c=8.10857e-17
C6 (net98 VSS) capacitor c=3.11587e-18
C7 (net89 VSS) capacitor c=5.47668e-17
C8 (\4\:B0 VSS) capacitor c=4.41431e-17
C9 (\1\:B1 VSS) capacitor c=5.02801e-17
C10 (\1\:A1 VSS) capacitor c=6.66393e-17
C11 (\1\:A0 VSS) capacitor c=4.01281e-17
C12 (\3\:B0 VSS) capacitor c=4.3498e-17
C13 (\3\:B1 VSS) capacitor c=3.61879e-17
C14 (\3\:A1 VSS) capacitor c=2.93615e-17
C15 (\4\:A0 VSS) capacitor c=5.43834e-17
C16 (\1\:B0 VSS) capacitor c=1.16561e-17
C17 (\2\:B1 VSS) capacitor c=5.80377e-17
C18 (\2\:A1 VSS) capacitor c=5.69719e-17
C19 (\3\:A0 VSS) capacitor c=5.35425e-17
C20 (\3\:Y VSS) capacitor c=3.54126e-17
C21 (\3\:net89 VSS) capacitor c=8.85623e-17
C22 (\4\:VDD VSS) capacitor c=4.52886e-17
C23 (\5\:net89 VSS) capacitor c=5.09175e-17
C24 (\1\:Y VSS) capacitor c=1.0863e-16
C25 (\2\:B0 VSS) capacitor c=4.43804e-17
C26 (\5\:A0 VSS) capacitor c=3.00335e-17
C27 (\4\:A1 VSS) capacitor c=4.00488e-17
C28 (\4\:B1 VSS) capacitor c=5.12971e-17
C29 (\5\:B0 VSS) capacitor c=2.99341e-17
C30 (\7\:B0 VSS) capacitor c=2.04304e-17
C31 (\3\:VDD VSS) capacitor c=4.0131e-17
Rk3 (B1 \4\:B1) resistor r=0.1085 c=0
Rk2 (A1 \4\:A1) resistor r=0.08406 c=0
Rk12 (\4\:VSS VSS) resistor r=0.2506 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.3638 c=0
Rk13 (VSS \6\:VSS) resistor r=0.1816 c=0
Rk15 (\3\:VDD VDD) resistor r=0.1023 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.2816 c=0
Rk6 (\5\:B0 \6\:B0) resistor r=0.004213 c=0
Rk7 (B0 \7\:B0) resistor r=0.004073 c=0
Rk8 (\5\:B0 \7\:B0) resistor r=0.04761 c=0
Rk1 (A0 \5\:A0) resistor r=0.0139 c=0
Rk4 (\2\:Y Y) resistor r=0.572 c=0
Rk5 (Y \4\:Y) resistor r=0.07986 c=0
Rk9 (\2\:net89 \4\:net89) resistor r=0.5175 c=0
Rk10 (\4\:net89 \6\:net89) resistor r=0.2845 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=160.771 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=95.3867 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=231.925 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.2328 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=132.406 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=143.945 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=0.5213 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=96.9565 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=177.726 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=0.6051 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=62 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=62 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=62 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\1\:B0 \6\:B0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (net106 \4\:A0 \5\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\1\:Y \3\:A1 net106 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \3\:B1 net98 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (net98 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
ends AOI22XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:56 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB1X1
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y n0 n2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.40705e-07 sd=160n sca=15.9621 scb=0.0150202 \
        scc=0.000309344 m=(1)
mp2 (n2 \3\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=2.34e-14 ps=1.19e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.35705e-07 sd=160n sca=14.5611 \
        scb=0.0122104 scc=0.000254242 m=(1)
C1 (B0 VSS) capacitor c=5.2013e-17
C2 (Y VSS) capacitor c=9.45555e-17
C3 (VDD VSS) capacitor c=8.7346e-17
C4 (A1N VSS) capacitor c=2.50032e-17
C5 (A0N VSS) capacitor c=6.26058e-17
C6 (n0 VSS) capacitor c=9.47488e-17
C7 (n2 VSS) capacitor c=1.75431e-18
C8 (\3\:A1N VSS) capacitor c=7.75483e-17
C9 (\1\:A0N VSS) capacitor c=6.95665e-17
C10 (\3\:B0 VSS) capacitor c=8.93613e-17
C11 (\1\:A1N VSS) capacitor c=3.15495e-17
C12 (\3\:A0N VSS) capacitor c=4.78308e-17
C13 (\1\:B0 VSS) capacitor c=6.02227e-17
C14 (\3\:n0 VSS) capacitor c=3.00092e-17
C15 (\4\:A1N VSS) capacitor c=1.2298e-17
C16 (\2\:A0N VSS) capacitor c=6.3588e-17
C17 (\2\:B0 VSS) capacitor c=6.53018e-17
C18 (\2\:n0 VSS) capacitor c=5.64846e-17
C19 (\4\:n0 VSS) capacitor c=5.53762e-17
C20 (\1\:VDD VSS) capacitor c=3.69078e-17
C21 (\1\:Y VSS) capacitor c=8.04677e-17
C22 (\8\:n0 VSS) capacitor c=3.11138e-17
C23 (\3\:Y VSS) capacitor c=4.46312e-17
C24 (\2\:A1N VSS) capacitor c=4.27096e-17
C25 (\4\:B0 VSS) capacitor c=6.57804e-17
C26 (\4\:A0N VSS) capacitor c=4.60989e-17
C27 (\6\:n0 VSS) capacitor c=1.065e-16
C28 (\7\:n0 VSS) capacitor c=8.58094e-17
C29 (\5\:A1N VSS) capacitor c=4.34232e-17
C30 (\4\:VDD VSS) capacitor c=3.22639e-17
Rk3 (B0 \4\:B0) resistor r=0.09846 c=0
Rk1 (\2\:Y Y) resistor r=0.6666 c=0
Rk2 (Y \4\:Y) resistor r=0.08156 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.5016 c=0
Rk15 (\5\:VSS VSS) resistor r=0.03965 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.2103 c=0
Rk16 (\4\:VSS \7\:VSS) resistor r=0.3073 c=0
Rk17 (\5\:VSS \9\:VSS) resistor r=0.1785 c=0
Rk19 (\4\:VDD VDD) resistor r=0.2508 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.2674 c=0
Rk10 (\5\:A1N \6\:A1N) resistor r=0.01391 c=0
Rk11 (A1N \7\:A1N) resistor r=0.01391 c=0
Rk12 (\5\:A1N \7\:A1N) resistor r=0.02119 c=0
Rk6 (\4\:A0N A0N) resistor r=0.02396 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.4796 c=0
Rk8 (\6\:n0 \7\:n0) resistor r=0.3662 c=0
Rk9 (\6\:n0 \9\:n0) resistor r=0.1404 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.6365 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=103.021 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=167.616 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=71.8171 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=5.1011 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=106.461 c=0
Rl1 (n0 \2\:n0) resistor r=165.385 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=33.7912 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y \3\:n0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=5.72692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn2 (\3\:Y \1\:B0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.67692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn0 (\8\:n0 \3\:A0N \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.755e-14 ps=8.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.75e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn1 (\8\:n0 \1\:A1N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.4e-07 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mp0 (n1 \1\:A0N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=1.29e-14 ps=1.19e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2.45e-07 sd=160n sca=15.6375 \
        scb=0.0141102 scc=0.000376252 m=(1)
mp1 (\4\:n0 \3\:A1N n1 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.4e-07 sd=160n sca=17.3765 scb=0.017565 \
        scc=0.000461873 m=(1)
ends AOI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:57 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB1X2
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X2 A0N A1N B0 VDD VSS Y
mp2_1__rcx (2 \1\:B0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.56218e-07 sd=160n sca=15.3142 \
        scb=0.0139264 scc=0.00046091 m=(1)
mp3_1__rcx (\5\:Y \5\:net104 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.51218e-07 sd=160n sca=14.157 \
        scb=0.0122233 scc=0.000446408 m=(1)
mp3 (\5\:Y net104 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=4.46218e-07 sd=160n sca=13.0345 scb=0.0111963 scc=0.000443955 \
        m=(1)
mp2 (3 \6\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=2.34e-14 ps=1.21e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.41218e-07 sd=160n sca=12.7928 \
        scb=0.0110816 scc=0.000443908 m=(1)
C1 (A0N VSS) capacitor c=4.6595e-17
C2 (B0 VSS) capacitor c=2.13308e-17
C3 (Y VSS) capacitor c=8.3799e-17
C4 (VDD VSS) capacitor c=1.06558e-16
C5 (A1N VSS) capacitor c=5.79162e-17
C6 (net104 VSS) capacitor c=5.88782e-17
C7 (2 VSS) capacitor c=1.82166e-18
C8 (net87 VSS) capacitor c=1.42137e-18
C9 (\3\:A1N VSS) capacitor c=7.03466e-17
C10 (\3\:A0N VSS) capacitor c=7.63289e-17
C11 (\6\:B0 VSS) capacitor c=9.16005e-17
C12 (\5\:net104 VSS) capacitor c=7.41357e-17
C13 (\1\:B0 VSS) capacitor c=8.00549e-17
C14 (\1\:A1N VSS) capacitor c=3.43302e-17
C15 (\1\:A0N VSS) capacitor c=3.2795e-17
C16 (\2\:A1N VSS) capacitor c=3.34695e-17
C17 (\2\:A0N VSS) capacitor c=4.48847e-17
C18 (\2\:net104 VSS) capacitor c=2.27051e-17
C19 (\2\:B0 VSS) capacitor c=3.30068e-16
C20 (\11\:net104 VSS) capacitor c=1.61603e-17
C21 (\1\:VDD VSS) capacitor c=4.62956e-17
C22 (\5\:Y VSS) capacitor c=9.77387e-17
C23 (\6\:VDD VSS) capacitor c=2.44652e-17
C24 (\7\:net104 VSS) capacitor c=8.01181e-17
C25 (\1\:Y VSS) capacitor c=1.11679e-16
C26 (\3\:net104 VSS) capacitor c=1.46255e-16
C27 (\4\:A0N VSS) capacitor c=6.4642e-17
C28 (\9\:net104 VSS) capacitor c=1.00686e-16
C29 (\10\:net104 VSS) capacitor c=8.39063e-17
C30 (\5\:A1N VSS) capacitor c=3.81459e-17
C31 (\4\:VDD VSS) capacitor c=3.78813e-17
C32 (\5\:VDD VSS) capacitor c=1.29221e-17
Rk7 (\4\:A0N A0N) resistor r=0.02184 c=0
Rk6 (\2\:B0 B0) resistor r=0.04405 c=0
Rk2 (\1\:Y Y) resistor r=0.3463 c=0
Rk3 (Y \6\:Y) resistor r=0.7463 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.2975 c=0
Rk24 (\5\:VDD VDD) resistor r=0.1271 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.2723 c=0
Rk25 (\5\:VDD \7\:VDD) resistor r=0.2051 c=0
Rk18 (\3\:VSS VSS) resistor r=0.07706 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.5258 c=0
Rk20 (\3\:VSS \11\:VSS) resistor r=0.1721 c=0
Rk13 (A1N \5\:A1N) resistor r=0.03585 c=0
Rk8 (\8\:net104 \9\:net104) resistor r=0.4788 c=0
Rk9 (\9\:net104 \10\:net104) resistor r=0.4618 c=0
Rk10 (\9\:net104 \12\:net104) resistor r=0.1068 c=0
Rl11 (\2\:A0N \3\:A0N) resistor r=134.066 c=0
Rl10 (\1\:A0N \2\:A0N) resistor r=53.8462 c=0
Rl9 (\2\:B0 \6\:B0) resistor r=99.7951 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=103.079 c=0
Rl13 (\2\:A1N \3\:A1N) resistor r=108.232 c=0
Rl12 (\1\:A1N \2\:A1N) resistor r=149.233 c=0
Rl3 (\2\:net104 net104) resistor r=38.4089 c=0
Rl6 (\2\:net104 \5\:net104) resistor r=79.9751 c=0
Rl4 (\3\:net104 \2\:net104) resistor r=6.662 c=0
Rz4 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz3 (\8\:net104 \7\:net104) resistor r=75 c=0
Ry1 (\6\:Y \5\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\12\:net104 \11\:net104) resistor r=62 c=0
Rx3 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx5 (\2\:A1N \5\:A1N) resistor r=45 c=0
Rx4 (\10\:net104 \2\:net104) resistor r=45 c=0
mn2 (\1\:Y \2\:B0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06452e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (\1\:Y \3\:net104 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.59519e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn0 (\7\:net104 \1\:A0N \3\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.988e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=4.6e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn1 (\7\:net104 \1\:A1N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=3.988e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mp0 (net87 \3\:A0N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=1.29e-14 ps=1.21e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2.45e-07 sd=160n sca=15.4989 \
        scb=0.01467 scc=0.00075392 m=(1)
mp1 (\11\:net104 \3\:A1N net87 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.4e-07 sd=160n sca=16.1917 \
        scb=0.0154022 scc=0.000756069 m=(1)
ends AOI2BB1X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:58 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB1X4
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X4 A0N A1N B0 VDD VSS Y
mp2_1__rcx (1 \1\:B0 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=2.34e-14 ps=1.12e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.685e-06 sd=160n sca=14.6306 \
        scb=0.0131928 scc=0.00027089 m=(1)
mp3_1__rcx (\10\:Y \5\:net104 1 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.58e-06 sd=160n sca=13.3043 \
        scb=0.011125 scc=0.000248176 m=(1)
mp3_2__rcx (\10\:Y net104 3 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.375e-06 sd=160n sca=12.0532 \
        scb=0.00986215 scc=0.000244296 m=(1)
mp2_2__rcx (3 \8\:B0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.27e-06 sd=160n sca=11.7142 \
        scb=0.00970251 scc=0.00024422 m=(1)
mp2_3__rcx (2 \9\:B0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.065e-06 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp3_3__rcx (\12\:Y \11\:net104 2 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=9.6e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp3 (\12\:Y \12\:net104 7 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.014e-13 ad=6.24e-14 ps=1.3e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=7.55e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp2 (7 \12\:B0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.014e-13 ps=1.1e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=4.5e-07 sd=160n sca=12.0927 \
        scb=0.00988629 scc=0.000244314 m=(1)
mp0 (net87 \3\:A0N \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61e-06 sb=2.45e-07 sd=160n sca=13.4007 \
        scb=0.0112573 scc=0.000248973 m=(1)
mp1 (\13\:net104 \3\:A1N net87 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=1.4e-07 sd=160n sca=14.804 \
        scb=0.0134899 scc=0.000276131 m=(1)
C1 (B0 VSS) capacitor c=1.61255e-17
C2 (Y VSS) capacitor c=9.73985e-17
C3 (A1N VSS) capacitor c=5.93942e-17
C4 (VDD VSS) capacitor c=1.71889e-16
C5 (A0N VSS) capacitor c=2.3695e-17
C6 (net104 VSS) capacitor c=5.9521e-17
C7 (1 VSS) capacitor c=1.93443e-18
C8 (3 VSS) capacitor c=1.95976e-18
C9 (2 VSS) capacitor c=2.1037e-18
C10 (7 VSS) capacitor c=5.84337e-18
C11 (net87 VSS) capacitor c=1.35348e-18
C12 (\3\:A1N VSS) capacitor c=9.267e-17
C13 (\3\:A0N VSS) capacitor c=8.78752e-17
C14 (\12\:B0 VSS) capacitor c=5.11438e-17
C15 (\12\:net104 VSS) capacitor c=2.19824e-17
C16 (\11\:net104 VSS) capacitor c=7.35988e-17
C17 (\9\:B0 VSS) capacitor c=6.86436e-17
C18 (\8\:B0 VSS) capacitor c=7.57378e-17
C19 (\5\:net104 VSS) capacitor c=7.51115e-17
C20 (\1\:B0 VSS) capacitor c=7.65714e-17
C21 (\1\:A1N VSS) capacitor c=4.65749e-17
C22 (\1\:A0N VSS) capacitor c=5.53653e-17
C23 (\4\:A1N VSS) capacitor c=1.1237e-17
C24 (\2\:A0N VSS) capacitor c=6.68141e-17
C25 (\2\:net104 VSS) capacitor c=5.1164e-16
C26 (\2\:B0 VSS) capacitor c=5.59504e-16
C27 (\13\:net104 VSS) capacitor c=2.84966e-17
C28 (\1\:VDD VSS) capacitor c=8.1052e-17
C29 (\12\:Y VSS) capacitor c=8.44584e-17
C30 (\7\:VDD VSS) capacitor c=3.36247e-17
C31 (\10\:Y VSS) capacitor c=2.66724e-17
C32 (\9\:VDD VSS) capacitor c=3.686e-17
C33 (\18\:net104 VSS) capacitor c=7.56548e-17
C34 (\1\:Y VSS) capacitor c=2.54815e-16
C35 (\7\:B0 VSS) capacitor c=3.39322e-17
C36 (\2\:A1N VSS) capacitor c=3.06834e-17
C37 (\9\:Y VSS) capacitor c=5.72413e-17
C38 (\4\:A0N VSS) capacitor c=9.65623e-17
C39 (\15\:net104 VSS) capacitor c=9.41623e-17
C40 (\6\:A1N VSS) capacitor c=1.39016e-17
C41 (\4\:VDD VSS) capacitor c=2.69296e-17
C42 (\5\:VDD VSS) capacitor c=2.44381e-17
C43 (\6\:VDD VSS) capacitor c=1.57317e-17
Rk11 (\2\:B0 B0) resistor r=0.006364 c=0
Rk4 (\1\:Y Y) resistor r=0.6989 c=0
Rk5 (Y \9\:Y) resistor r=0.236 c=0
Rk6 (\9\:Y \11\:Y) resistor r=0.05755 c=0
Rk7 (\9\:Y \13\:Y) resistor r=0.5091 c=0
Rk22 (A1N \6\:A1N) resistor r=0.05091 c=0
Rk29 (\3\:VSS VSS) resistor r=0.06471 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.3877 c=0
Rk35 (\2\:VDD \4\:VDD) resistor r=0.5168 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.1251 c=0
Rk38 (\6\:VDD VDD) resistor r=0.08476 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.3404 c=0
Rk39 (\5\:VDD \8\:VDD) resistor r=0.1765 c=0
Rk40 (\6\:VDD \10\:VDD) resistor r=0.1719 c=0
Rk14 (\4\:A0N A0N) resistor r=0.005989 c=0
Rk16 (\15\:net104 \2\:net104) resistor r=0.5356 c=0
Rk15 (\14\:net104 \15\:net104) resistor r=0.1408 c=0
Rk18 (\15\:net104 \19\:net104) resistor r=0.5113 c=0
Rl19 (\2\:B0 \12\:B0) resistor r=86.3335 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=89.6174 c=0
Rl12 (\7\:B0 \9\:B0) resistor r=78.4102 c=0
Rl11 (\7\:B0 \8\:B0) resistor r=122.561 c=0
Rl10 (\7\:B0 \2\:B0) resistor r=6.3032 c=0
Rl23 (\2\:A1N \3\:A1N) resistor r=111.048 c=0
Rl22 (\1\:A1N \2\:A1N) resistor r=149.462 c=0
Rl24 (\2\:A1N \4\:A1N) resistor r=11.6126 c=0
Rl21 (\2\:A0N \3\:A0N) resistor r=78.079 c=0
Rl20 (\1\:A0N \2\:A0N) resistor r=134.331 c=0
Rl17 (\2\:net104 \12\:net104) resistor r=21.8511 c=0
Rl16 (\2\:net104 \11\:net104) resistor r=76.7238 c=0
Rl3 (\2\:net104 net104) resistor r=25.3355 c=0
Rl6 (\2\:net104 \5\:net104) resistor r=84.3341 c=0
Rz6 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz5 (\19\:net104 \18\:net104) resistor r=75 c=0
Ry1 (\11\:Y \10\:Y) resistor r=31 c=0
Ry2 (\13\:Y \12\:Y) resistor r=31 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry3 (\14\:net104 \13\:net104) resistor r=20.6667 c=0
Rx7 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx4 (\2\:A0N \4\:A0N) resistor r=45 c=0
mn0 (\18\:net104 \1\:A0N \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=3.45e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn1 (\18\:net104 \1\:A1N \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn2_1__rcx (\1\:Y \2\:B0 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
mn3_1__rcx (\1\:Y \2\:net104 \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.78e-06 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
ends AOI2BB1X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:12:59 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB1XL
// View name: extracted

simulator lang=spectre

subckt AOI2BB1XL A0N A1N B0 VDD VSS Y
mp3 (\1\:Y net100 net79 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=14.7825 \
        scb=0.0129755 scc=0.000158065 m=(1)
mp2 (net79 \1\:B0 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.29e-14 ps=7.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.6e-07 sd=160n sca=13.4422 \
        scb=0.0102845 scc=0.000107644 m=(1)
mp0 (net87 \1\:A0N \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.29e-14 ps=7.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.45e-07 sd=160n sca=13.4422 \
        scb=0.0102845 scc=0.000107644 m=(1)
mp1 (\8\:net100 \3\:A1N net87 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.4e-07 sd=160n sca=14.7825 \
        scb=0.0129755 scc=0.000158065 m=(1)
C1 (B0 VSS) capacitor c=7.37786e-17
C2 (Y VSS) capacitor c=7.22728e-17
C3 (A1N VSS) capacitor c=3.60118e-17
C4 (VDD VSS) capacitor c=1.25239e-16
C5 (A0N VSS) capacitor c=1.41886e-16
C6 (net100 VSS) capacitor c=9.11987e-17
C7 (\3\:A1N VSS) capacitor c=1.03686e-16
C8 (\1\:A0N VSS) capacitor c=6.25993e-17
C9 (\1\:B0 VSS) capacitor c=8.09462e-17
C10 (\1\:A1N VSS) capacitor c=2.5167e-17
C11 (\3\:A0N VSS) capacitor c=7.8198e-17
C12 (\3\:B0 VSS) capacitor c=5.47912e-17
C13 (\3\:net100 VSS) capacitor c=3.33369e-17
C14 (\4\:A1N VSS) capacitor c=1.04531e-17
C15 (\2\:A0N VSS) capacitor c=9.15373e-17
C16 (\2\:B0 VSS) capacitor c=9.66736e-17
C17 (\2\:net100 VSS) capacitor c=7.91785e-17
C18 (\8\:net100 VSS) capacitor c=6.69133e-17
C19 (\1\:VDD VSS) capacitor c=1.49829e-17
C20 (\1\:Y VSS) capacitor c=4.77842e-17
C21 (\6\:net100 VSS) capacitor c=4.87352e-17
C22 (\3\:Y VSS) capacitor c=8.8004e-17
C23 (\2\:A1N VSS) capacitor c=7.34906e-17
C24 (\4\:B0 VSS) capacitor c=4.71145e-17
C25 (\4\:net100 VSS) capacitor c=5.33354e-17
C26 (\5\:net100 VSS) capacitor c=1.16603e-16
C27 (\5\:A1N VSS) capacitor c=6.51984e-17
C28 (\4\:VDD VSS) capacitor c=4.10938e-17
Rk3 (B0 \4\:B0) resistor r=0.1274 c=0
Rk9 (\2\:VSS \4\:VSS) resistor r=0.3924 c=0
Rk11 (\5\:VSS VSS) resistor r=0.04217 c=0
Rk10 (\4\:VSS \5\:VSS) resistor r=0.2082 c=0
Rk12 (\4\:VSS \7\:VSS) resistor r=0.2216 c=0
Rk13 (\5\:VSS \9\:VSS) resistor r=0.1738 c=0
Rk1 (\2\:Y Y) resistor r=0.4506 c=0
Rk2 (Y \4\:Y) resistor r=0.5182 c=0
Rk8 (A1N \5\:A1N) resistor r=0.1513 c=0
Rk15 (\4\:VDD VDD) resistor r=0.2508 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.2196 c=0
Rk4 (A0N \4\:A0N) resistor r=0.002507 c=0
Rk5 (\4\:net100 \5\:net100) resistor r=0.3475 c=0
Rk6 (\5\:net100 \7\:net100) resistor r=0.2478 c=0
Rk7 (\5\:net100 \9\:net100) resistor r=0.473 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=154.538 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=162.23 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=316.817 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=30.2311 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=6.4284 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=73.7687 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=243 c=0
Rl1 (net100 \2\:net100) resistor r=226.156 c=0
Rl2 (\2\:net100 \3\:net100) resistor r=111.954 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\6\:net100 \7\:net100) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\8\:net100 \9\:net100) resistor r=62 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \5\:A1N) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx3 (\2\:net100 \4\:net100) resistor r=45 c=0
mn3 (\3\:Y \3\:net100 \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\3\:Y \3\:B0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\6\:net100 \3\:A0N \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.465e-14 ad=2.537e-14 ps=6.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.6e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\6\:net100 \1\:A1N \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
ends AOI2BB1XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:00 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB2X1
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X1 A0N A1N B0 B1 VDD VSS Y
mp1 (\4\:n1 \1\:A1N \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.5e-07 sd=160n sca=20.0627 \
        scb=0.0223685 scc=0.000742304 m=(1)
mp0 (\6\:n0 \3\:A0N \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=13.9338 \
        scb=0.0121124 scc=0.00023362 m=(1)
C1 (A0N VSS) capacitor c=5.83417e-17
C2 (B0 VSS) capacitor c=1.87804e-17
C3 (A1N VSS) capacitor c=5.43238e-17
C4 (Y VSS) capacitor c=2.81816e-17
C5 (VDD VSS) capacitor c=1.07891e-16
C6 (B1 VSS) capacitor c=2.99196e-17
C7 (n1 VSS) capacitor c=5.79347e-17
C8 (n0 VSS) capacitor c=3.89407e-17
C9 (n2 VSS) capacitor c=2.72591e-18
C10 (n3 VSS) capacitor c=9.12392e-18
C11 (n4 VSS) capacitor c=4.21968e-17
C12 (\1\:B0 VSS) capacitor c=4.42745e-17
C13 (\1\:B1 VSS) capacitor c=4.10917e-17
C14 (\3\:n0 VSS) capacitor c=4.62718e-17
C15 (\3\:A0N VSS) capacitor c=3.26023e-17
C16 (\1\:A1N VSS) capacitor c=4.32831e-17
C17 (\3\:B0 VSS) capacitor c=3.90126e-17
C18 (\4\:B1 VSS) capacitor c=5.35834e-17
C19 (\3\:n1 VSS) capacitor c=3.63051e-17
C20 (\1\:A0N VSS) capacitor c=3.6942e-17
C21 (\3\:A1N VSS) capacitor c=2.63198e-17
C22 (\4\:B0 VSS) capacitor c=1.23836e-17
C23 (\3\:B1 VSS) capacitor c=1.70874e-17
C24 (\2\:n1 VSS) capacitor c=4.02976e-17
C25 (\2\:n0 VSS) capacitor c=3.38295e-17
C26 (\2\:A0N VSS) capacitor c=3.5824e-17
C27 (\2\:A1N VSS) capacitor c=3.3674e-17
C28 (\1\:Y VSS) capacitor c=1.13617e-16
C29 (\3\:n4 VSS) capacitor c=7.33026e-17
C30 (\1\:VDD VSS) capacitor c=4.55816e-17
C31 (\5\:n4 VSS) capacitor c=6.0098e-17
C32 (\6\:n0 VSS) capacitor c=6.40296e-17
C33 (\6\:VDD VSS) capacitor c=3.1262e-17
C34 (\4\:n1 VSS) capacitor c=5.42105e-17
C35 (\3\:Y VSS) capacitor c=9.94278e-17
C36 (\8\:n0 VSS) capacitor c=2.57684e-17
C37 (\6\:n1 VSS) capacitor c=1.26933e-16
C38 (\2\:B1 VSS) capacitor c=2.71219e-17
C39 (\2\:B0 VSS) capacitor c=2.41282e-17
C40 (\4\:A1N VSS) capacitor c=5.33688e-17
C41 (\4\:A0N VSS) capacitor c=5.67496e-17
C42 (\4\:n0 VSS) capacitor c=5.22824e-17
C43 (\5\:n0 VSS) capacitor c=5.40022e-17
C44 (\8\:n1 VSS) capacitor c=1.68242e-16
C45 (\5\:B1 VSS) capacitor c=1.0009e-16
C46 (\5\:B0 VSS) capacitor c=8.02673e-17
C47 (\4\:VDD VSS) capacitor c=4.64987e-17
C48 (\5\:VDD VSS) capacitor c=1.36195e-17
Rk2 (\4\:A0N A0N) resistor r=0.1907 c=0
Rk15 (B0 \5\:B0) resistor r=0.02177 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.6122 c=0
Rk18 (\5\:VSS VSS) resistor r=0.1474 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.303 c=0
Rk19 (\4\:VSS \7\:VSS) resistor r=0.2392 c=0
Rk20 (\5\:VSS \9\:VSS) resistor r=0.07346 c=0
Rk1 (\4\:A1N A1N) resistor r=0.1524 c=0
Rk12 (\4\:Y Y) resistor r=0.01611 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.6902 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.3864 c=0
Rk23 (\5\:VDD VDD) resistor r=0.1324 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.3181 c=0
Rk24 (\5\:VDD \7\:VDD) resistor r=0.2728 c=0
Rk10 (\5\:B1 B1) resistor r=0.01497 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4253 c=0
Rk7 (\7\:n1 \8\:n1) resistor r=1.0427 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.248 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.4196 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.06021 c=0
Rk13 (\2\:n4 \4\:n4) resistor r=0.4736 c=0
Rk14 (\4\:n4 \6\:n4) resistor r=0.4226 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=74.1758 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=76.9231 c=0
Rl12 (\1\:B0 \2\:B0) resistor r=92.9709 c=0
Rl13 (\2\:B0 \3\:B0) resistor r=52.2314 c=0
Rl14 (\2\:B0 \4\:B0) resistor r=5.1011 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=119.922 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=29.5379 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=37.3411 c=0
Rl11 (\2\:B1 \4\:B1) resistor r=114.264 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=1.2301 c=0
Rl7 (n1 \2\:n1) resistor r=106.461 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=29.5379 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=87.6365 c=0
Rl5 (n0 \2\:n0) resistor r=46.6893 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry9 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (n4 \2\:n4) resistor r=31 c=0
Ry5 (\3\:n4 \4\:n4) resistor r=31 c=0
Ry6 (\5\:n4 \6\:n4) resistor r=31 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx5 (\3\:B1 \5\:B1) resistor r=45 c=0
Rx4 (\2\:n1 \8\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\6\:n1 \3\:A1N \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\8\:n0 \1\:A0N \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=3.263e-14 ps=1.6e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=2.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n2 n0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=3.12e-14 ps=8e-07 pd=7.6e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=7.3e-07 sd=160n sca=8.65991 scb=0.00681295 scc=0.000165238 \
        m=(1)
mn3 (\3\:Y \3\:n1 n2 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.12e-14 \
        ad=5.72e-14 ps=7.6e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.05e-07 sb=5.65e-07 sd=160n sca=8.65991 scb=0.00681295 \
        scc=0.000165238 m=(1)
mn5 (n3 \4\:B1 \3\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=2.99e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.7e-07 sb=3e-07 sd=160n sca=8.65991 scb=0.00681295 \
        scc=0.000165238 m=(1)
mn4 (\1\:VSS \3\:B0 n3 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.64e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mp2 (\5\:n4 \3\:n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=20.624 \
        scb=0.0171402 scc=0.00197772 m=(1)
mp3 (\3\:n4 n1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=21.2883 \
        scb=0.0174673 scc=0.00197792 m=(1)
mp5 (\1\:Y \1\:B1 \3\:n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=23.6754 \
        scb=0.020671 scc=0.0020044 m=(1)
mp4 (\1\:Y \1\:B0 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.46e-14 \
        ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.15e-07 sb=1.4e-07 sd=160n sca=31.7169 scb=0.0333373 \
        scc=0.002913 m=(1)
ends AOI2BB2X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:01 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB2X2
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X2 A0N A1N B0 B1 VDD VSS Y
mp1 (\10\:n1 \1\:A1N \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.3686e-07 sd=160n sca=35.2997 \
        scb=0.0321645 scc=0.00387088 m=(1)
mp0 (\12\:n0 \1\:A0N \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.05e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4186e-07 sd=160n sca=31.8032 \
        scb=0.0262603 scc=0.00373148 m=(1)
C1 (Y VSS) capacitor c=7.22931e-17
C2 (A0N VSS) capacitor c=3.65399e-17
C3 (B0 VSS) capacitor c=3.63831e-16
C4 (VDD VSS) capacitor c=1.51169e-16
C5 (A1N VSS) capacitor c=4.6479e-17
C6 (B1 VSS) capacitor c=5.4178e-17
C7 (n1 VSS) capacitor c=1.69895e-16
C8 (n0 VSS) capacitor c=6.75798e-17
C9 (12 VSS) capacitor c=4.23054e-18
C10 (13 VSS) capacitor c=4.42702e-18
C11 (n4 VSS) capacitor c=1.85264e-16
C12 (\1\:B1 VSS) capacitor c=1.32189e-16
C13 (\1\:A0N VSS) capacitor c=3.67485e-17
C14 (\1\:A1N VSS) capacitor c=3.79866e-17
C15 (\7\:B0 VSS) capacitor c=5.29824e-17
C16 (\4\:B1 VSS) capacitor c=5.96644e-17
C17 (\5\:B1 VSS) capacitor c=3.75188e-17
C18 (\3\:B0 VSS) capacitor c=3.37977e-17
C19 (\6\:n0 VSS) capacitor c=4.91235e-17
C20 (\5\:n1 VSS) capacitor c=3.0984e-17
C21 (\4\:n1 VSS) capacitor c=4.57651e-17
C22 (\3\:A0N VSS) capacitor c=2.92602e-17
C23 (\3\:A1N VSS) capacitor c=2.80356e-17
C24 (\2\:n0 VSS) capacitor c=3.34596e-16
C25 (\2\:A0N VSS) capacitor c=2.99411e-17
C26 (\2\:A1N VSS) capacitor c=3.45002e-17
C27 (\1\:Y VSS) capacitor c=1.65342e-16
C28 (\3\:n4 VSS) capacitor c=7.42284e-17
C29 (\10\:n4 VSS) capacitor c=3.59422e-17
C30 (\12\:n0 VSS) capacitor c=2.54179e-17
C31 (\11\:VDD VSS) capacitor c=1.1668e-17
C32 (\10\:n1 VSS) capacitor c=5.68129e-17
C33 (\1\:VDD VSS) capacitor c=5.4787e-17
C34 (\8\:Y VSS) capacitor c=5.67961e-17
C35 (\6\:Y VSS) capacitor c=4.69284e-17
C36 (\10\:n0 VSS) capacitor c=4.57642e-17
C37 (\8\:n1 VSS) capacitor c=1.67746e-16
C38 (\4\:A1N VSS) capacitor c=8.70658e-17
C39 (\4\:A0N VSS) capacitor c=9.16437e-17
C40 (\7\:n1 VSS) capacitor c=1.75763e-16
C41 (\9\:n0 VSS) capacitor c=5.45359e-17
C42 (\7\:B1 VSS) capacitor c=9.13023e-17
C43 (\5\:Y VSS) capacitor c=7.13953e-17
C44 (\3\:VDD VSS) capacitor c=1.04092e-16
C45 (\6\:VDD VSS) capacitor c=1.07532e-17
Rk13 (\1\:Y Y) resistor r=0.2512 c=0
Rk14 (Y \5\:Y) resistor r=0.2241 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.3113 c=0
Rk16 (\5\:Y \9\:Y) resistor r=0.3209 c=0
Rk4 (A0N \4\:A0N) resistor r=0.07164 c=0
Rk24 (\2\:VSS \4\:VSS) resistor r=0.2474 c=0
Rk25 (\4\:VSS \5\:VSS) resistor r=0.4501 c=0
Rk26 (\5\:VSS \6\:VSS) resistor r=0.2996 c=0
Rk28 (\7\:VSS VSS) resistor r=0.122 c=0
Rk27 (\6\:VSS \7\:VSS) resistor r=0.4276 c=0
Rk29 (\5\:VSS \9\:VSS) resistor r=0.197 c=0
Rk30 (\6\:VSS \11\:VSS) resistor r=0.2474 c=0
Rk31 (\7\:VSS \13\:VSS) resistor r=0.07288 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.5294 c=0
Rk34 (\3\:VDD \5\:VDD) resistor r=0.02978 c=0
Rk36 (\6\:VDD VDD) resistor r=0.1844 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.3645 c=0
Rk39 (\6\:VDD \12\:VDD) resistor r=0.1982 c=0
Rk3 (\4\:A1N A1N) resistor r=0.05075 c=0
Rk11 (B1 \7\:B1) resistor r=0.129 c=0
Rk5 (\7\:n1 \9\:n1) resistor r=1.2698 c=0
Rk6 (\9\:n1 \11\:n1) resistor r=0.4365 c=0
Rk8 (\2\:n0 \9\:n0) resistor r=0.3855 c=0
Rk9 (\9\:n0 \11\:n0) resistor r=0.1739 c=0
Rk10 (\9\:n0 \13\:n0) resistor r=0.1404 c=0
Rk23 (n4 \11\:n4) resistor r=0.05922 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=43.4636 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=33.8482 c=0
Rl23 (B0 \7\:B0) resistor r=28.6412 c=0
Rl15 (B0 \3\:B0) resistor r=41.1873 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=51.9231 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=29.9451 c=0
Rl19 (\1\:B1 \4\:B1) resistor r=111.253 c=0
Rl20 (\1\:B1 \5\:B1) resistor r=103.297 c=0
Rl10 (n1 \5\:n1) resistor r=30.0028 c=0
Rl9 (n1 \4\:n1) resistor r=29.579 c=0
Rl13 (\2\:n0 \6\:n0) resistor r=90.1797 c=0
Rl5 (\2\:n0 n0) resistor r=90.1797 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz8 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz9 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz10 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\9\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry10 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry11 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry14 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry6 (n4 \3\:n4) resistor r=62 c=0
Ry9 (\11\:n4 \10\:n4) resistor r=31 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx3 (\7\:n1 n1) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.988e-14 ad=2.755e-14 ps=1.71e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (\10\:n0 \3\:A0N \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.988e-14 ad=2.538e-14 ps=1.71e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2_1__rcx (11 n0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.425e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\6\:Y \4\:n1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.32e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\6\:Y \5\:n1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.115e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (12 \6\:n0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=2.99e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=9.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\8\:VSS \3\:B0 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=6.63e-14 ps=8.4e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=6.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_1__rcx (13 \5\:B1 \8\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=4.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (14 \4\:B1 \8\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.32e-06 sb=2.45e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4 (\1\:VSS \7\:B0 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp3_1__rcx (\10\:n4 n1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.33718e-07 sb=1.42e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\1\:Y B0 n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.98718e-07 sb=7.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(2)
mp2 (n4 \2\:n0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.605e-14 ps=1.1e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28718e-07 sb=1.625e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp5_1__rcx (\1\:Y \1\:B1 \3\:n4 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20372e-06 sb=5.5e-07 sd=160n sca=14.0716 \
        scb=0.0123579 scc=0.000647567 m=(2)
ends AOI2BB2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:02 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB2X4
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X4 A0N A1N B0 B1 VDD VSS Y
mp1 (\17\:net144 \1\:A1N \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.26538e-07 sd=160n sca=18.6612 \
        scb=0.0194292 scc=0.000712894 m=(1)
mp0 (\18\:net148 \1\:A0N \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=4.74e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.21538e-07 sd=160n sca=14.9537 \
        scb=0.0131754 scc=0.000560012 m=(1)
mp2_1__rcx (net127 \2\:net148 \3\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=5.775e-14 ps=1.1e-06 pd=1.09e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.12308e-07 sb=2e-06 sd=160n \
        sca=18.3986 scb=0.0159927 scc=0.00159615 m=(4)
mp3_1__rcx (net127 \2\:net144 \3\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.17308e-07 sb=2e-06 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(4)
mp4_1__rcx (Y B0 net127 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.75231e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp5_1__rcx (Y B1 net127 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95731e-06 sb=1.37e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
C1 (VDD VSS) capacitor c=1.97722e-16
C2 (A0N VSS) capacitor c=7.39503e-17
C3 (B0 VSS) capacitor c=6.83964e-16
C4 (Y VSS) capacitor c=3.49669e-16
C5 (A1N VSS) capacitor c=9.15244e-17
C6 (B1 VSS) capacitor c=4.00604e-16
C7 (net144 VSS) capacitor c=6.23334e-17
C8 (net148 VSS) capacitor c=7.65965e-17
C9 (12 VSS) capacitor c=1.73025e-18
C10 (13 VSS) capacitor c=1.73025e-18
C11 (14 VSS) capacitor c=4.73764e-18
C12 (15 VSS) capacitor c=5.31477e-18
C13 (17 VSS) capacitor c=2.03972e-18
C14 (18 VSS) capacitor c=1.0071e-17
C15 (net127 VSS) capacitor c=7.30163e-16
C16 (\1\:A0N VSS) capacitor c=4.95136e-17
C17 (\1\:A1N VSS) capacitor c=4.59431e-17
C18 (\13\:B0 VSS) capacitor c=3.46204e-17
C19 (\11\:B1 VSS) capacitor c=4.36049e-17
C20 (\13\:B1 VSS) capacitor c=5.28059e-17
C21 (\9\:B0 VSS) capacitor c=3.8692e-17
C22 (\8\:B0 VSS) capacitor c=2.92518e-17
C23 (\1\:B1 VSS) capacitor c=2.85054e-17
C24 (\5\:B1 VSS) capacitor c=4.09723e-17
C25 (\3\:B0 VSS) capacitor c=3.79237e-17
C26 (\13\:net148 VSS) capacitor c=4.92037e-17
C27 (\11\:net144 VSS) capacitor c=2.48074e-17
C28 (\10\:net144 VSS) capacitor c=4.49716e-17
C29 (\4\:net148 VSS) capacitor c=6.23097e-17
C30 (\8\:net148 VSS) capacitor c=5.81158e-17
C31 (\5\:net144 VSS) capacitor c=4.66247e-17
C32 (\3\:A0N VSS) capacitor c=3.51623e-17
C33 (\3\:A1N VSS) capacitor c=3.11849e-17
C34 (\2\:net144 VSS) capacitor c=6.04821e-16
C35 (\2\:net148 VSS) capacitor c=6.5043e-16
C36 (\2\:A0N VSS) capacitor c=3.43033e-17
C37 (\2\:A1N VSS) capacitor c=3.91387e-17
C38 (\18\:net148 VSS) capacitor c=5.75355e-17
C39 (\17\:VDD VSS) capacitor c=3.42623e-17
C40 (\17\:net144 VSS) capacitor c=8.46235e-17
C41 (\1\:VDD VSS) capacitor c=1.03696e-16
C42 (\1\:Y VSS) capacitor c=8.88579e-17
C43 (\17\:Y VSS) capacitor c=4.735e-17
C44 (\13\:Y VSS) capacitor c=8.89051e-17
C45 (\15\:Y VSS) capacitor c=7.92491e-17
C46 (\20\:net148 VSS) capacitor c=4.73461e-17
C47 (\15\:net144 VSS) capacitor c=1.99631e-16
C48 (\2\:B1 VSS) capacitor c=2.23355e-17
C49 (\4\:A1N VSS) capacitor c=4.15896e-17
C50 (\4\:A0N VSS) capacitor c=5.80516e-17
C51 (\17\:net148 VSS) capacitor c=4.312e-17
C52 (\12\:Y VSS) capacitor c=8.95114e-17
C53 (\3\:VDD VSS) capacitor c=2.68353e-16
C54 (\8\:VDD VSS) capacitor c=1.2811e-17
Rk37 (\2\:VSS \4\:VSS) resistor r=0.5474 c=0
Rk38 (\4\:VSS \5\:VSS) resistor r=0.04494 c=0
Rk39 (\5\:VSS \6\:VSS) resistor r=0.4259 c=0
Rk40 (\6\:VSS \7\:VSS) resistor r=0.3607 c=0
Rk41 (\7\:VSS \8\:VSS) resistor r=0.2706 c=0
Rk42 (\5\:VSS \10\:VSS) resistor r=0.2076 c=0
Rk43 (\6\:VSS \12\:VSS) resistor r=0.1993 c=0
Rk44 (\7\:VSS \14\:VSS) resistor r=0.1993 c=0
Rk46 (\15\:VSS VSS) resistor r=0.1299 c=0
Rk45 (\8\:VSS \15\:VSS) resistor r=0.4217 c=0
Rk47 (\8\:VSS \17\:VSS) resistor r=0.2532 c=0
Rk48 (\15\:VSS \19\:VSS) resistor r=0.2366 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.574 c=0
Rk55 (\8\:VDD VDD) resistor r=0.1675 c=0
Rk54 (\3\:VDD \8\:VDD) resistor r=0.3105 c=0
Rk60 (\8\:VDD \18\:VDD) resistor r=0.2217 c=0
Rk2 (A0N \4\:A0N) resistor r=0.174 c=0
Rk13 (\2\:Y Y) resistor r=0.3821 c=0
Rk19 (Y \12\:Y) resistor r=0.4902 c=0
Rk20 (\12\:Y \14\:Y) resistor r=0.2977 c=0
Rk21 (\14\:Y \16\:Y) resistor r=0.4686 c=0
Rk22 (\12\:Y \18\:Y) resistor r=0.3133 c=0
Rk1 (A1N \4\:A1N) resistor r=0.06001 c=0
Rk4 (\2\:net144 \16\:net144) resistor r=1.2504 c=0
Rk5 (\16\:net144 \18\:net144) resistor r=0.6517 c=0
Rk8 (\2\:net148 \17\:net148) resistor r=0.2067 c=0
Rk9 (\17\:net148 \19\:net148) resistor r=0.2172 c=0
Rk10 (\17\:net148 \21\:net148) resistor r=0.2177 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=56.461 c=0
Rl45 (B0 \13\:B0) resistor r=39.5604 c=0
Rl36 (B0 \9\:B0) resistor r=41.5412 c=0
Rl35 (B0 \8\:B0) resistor r=39.6174 c=0
Rl26 (B0 \3\:B0) resistor r=41.1873 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=92.3077 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=57.1429 c=0
Rl41 (B1 \11\:B1) resistor r=103.08 c=0
Rl43 (B1 \13\:B1) resistor r=106.868 c=0
Rl29 (\2\:B1 B1) resistor r=38.2679 c=0
Rl28 (\2\:B1 \1\:B1) resistor r=33.7068 c=0
Rl31 (\2\:B1 \5\:B1) resistor r=90.7134 c=0
Rl20 (\2\:net144 \11\:net144) resistor r=30.0028 c=0
Rl19 (\2\:net144 \10\:net144) resistor r=29.579 c=0
Rl7 (\2\:net144 net144) resistor r=82.6695 c=0
Rl10 (\2\:net144 \5\:net144) resistor r=28.9526 c=0
Rl24 (\2\:net148 \13\:net148) resistor r=102.726 c=0
Rl12 (\2\:net148 \4\:net148) resistor r=124.51 c=0
Rl15 (\2\:net148 \8\:net148) resistor r=94.6154 c=0
Rl5 (\2\:net148 net148) resistor r=165.08 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz11 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\2\:Y \1\:Y) resistor r=75 c=0
Rz4 (\14\:Y \13\:Y) resistor r=75 c=0
Rz5 (\16\:Y \15\:Y) resistor r=75 c=0
Rz6 (\18\:Y \17\:Y) resistor r=75 c=0
Rz1 (\16\:net144 \15\:net144) resistor r=75 c=0
Rz2 (\21\:net148 \20\:net148) resistor r=75 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry17 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry22 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry1 (\18\:net144 \17\:net144) resistor r=62 c=0
Ry2 (\19\:net148 \18\:net148) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
mn1 (\15\:net144 \3\:A1N \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (\20\:net148 \3\:A0N \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (11 net148 \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_1__rcx (\15\:Y \5\:net144 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\15\:Y net144 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_2__rcx (12 \8\:net148 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (13 \4\:net148 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_3__rcx (\13\:Y \10\:net144 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\13\:Y \11\:net144 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.93e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (14 \13\:net148 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.725e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\11\:VSS \3\:B0 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.52e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_1__rcx (15 \5\:B1 \17\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.94e-14 ps=8.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_2__rcx (16 \1\:B1 \17\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.38e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.08e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (\9\:VSS \8\:B0 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.38e-14 ad=4.16e-14 ps=7.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.05e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_3__rcx (\9\:VSS \9\:B0 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.16e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_3__rcx (17 \13\:B1 \1\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.08e-14 ps=1e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (18 \11\:B1 \1\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.73e-14 ps=1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.9e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4 (\1\:VSS \13\:B0 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=3.64e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
ends AOI2BB2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:03 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI2BB2XL
// View name: extracted

simulator lang=spectre

subckt AOI2BB2XL A0N A1N B0 B1 VDD VSS Y
mp1 (\7\:net164 \1\:A1N \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.38488e-07 sd=160n sca=16.1102 \
        scb=0.0158781 scc=0.000281876 m=(1)
mp0 (\7\:net146 \1\:A0N \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.87e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.33488e-07 sd=160n sca=12.5196 \
        scb=0.0098468 scc=0.00014175 m=(1)
mp2 (net124 \4\:net146 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.63e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=8.2e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp3 (\3\:net124 net164 \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=6.15e-07 sd=160n sca=18.3739 \
        scb=0.0179115 scc=0.00142386 m=(1)
mp5 (\1\:Y \1\:B1 \3\:net124 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.32326e-07 sb=4.1e-07 sd=160n sca=19.4061 \
        scb=0.0187808 scc=0.00142556 m=(1)
mp4 (\1\:Y \1\:B0 \5\:net124 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=4.515e-14 ps=7.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.87326e-07 sb=1.55e-07 sd=160n sca=23.6629 \
        scb=0.0258087 scc=0.00159495 m=(1)
C1 (Y VSS) capacitor c=8.93816e-17
C2 (A0N VSS) capacitor c=4.47465e-17
C3 (B0 VSS) capacitor c=3.0724e-17
C4 (VDD VSS) capacitor c=1.49446e-16
C5 (A1N VSS) capacitor c=2.85989e-17
C6 (B1 VSS) capacitor c=9.21474e-17
C7 (net164 VSS) capacitor c=6.05568e-17
C8 (net146 VSS) capacitor c=5.6084e-17
C9 (net144 VSS) capacitor c=8.767e-19
C10 (net156 VSS) capacitor c=6.87186e-18
C11 (net124 VSS) capacitor c=4.71473e-17
C12 (\1\:B0 VSS) capacitor c=3.42639e-17
C13 (\1\:B1 VSS) capacitor c=3.91066e-17
C14 (\4\:net146 VSS) capacitor c=3.79558e-17
C15 (\1\:A0N VSS) capacitor c=4.80577e-17
C16 (\1\:A1N VSS) capacitor c=3.22676e-17
C17 (\3\:B0 VSS) capacitor c=2.49485e-17
C18 (\3\:B1 VSS) capacitor c=3.94297e-17
C19 (\2\:net164 VSS) capacitor c=6.41566e-17
C20 (\3\:A0N VSS) capacitor c=3.43883e-17
C21 (\3\:A1N VSS) capacitor c=5.22658e-17
C22 (\2\:B0 VSS) capacitor c=2.85248e-17
C23 (\2\:B1 VSS) capacitor c=4.05935e-17
C24 (\3\:net164 VSS) capacitor c=3.33401e-17
C25 (\3\:net146 VSS) capacitor c=2.44014e-17
C26 (\2\:A0N VSS) capacitor c=4.04839e-17
C27 (\2\:A1N VSS) capacitor c=4.05086e-17
C28 (\5\:net124 VSS) capacitor c=5.81668e-17
C29 (\1\:Y VSS) capacitor c=9.66073e-17
C30 (\3\:net124 VSS) capacitor c=8.61163e-17
C31 (\1\:VDD VSS) capacitor c=4.27182e-17
C32 (\7\:net146 VSS) capacitor c=5.80864e-17
C33 (\6\:VDD VSS) capacitor c=3.40765e-17
C34 (\7\:net164 VSS) capacitor c=8.62171e-17
C35 (\3\:Y VSS) capacitor c=1.2163e-16
C36 (\9\:net146 VSS) capacitor c=3.80805e-17
C37 (\5\:net164 VSS) capacitor c=1.79766e-16
C38 (\2\:net146 VSS) capacitor c=3.91405e-17
C39 (\4\:A1N VSS) capacitor c=9.51932e-17
C40 (\4\:A0N VSS) capacitor c=7.41851e-17
C41 (\5\:net146 VSS) capacitor c=3.37736e-17
C42 (\6\:net146 VSS) capacitor c=5.33167e-17
C43 (\4\:net164 VSS) capacitor c=1.3016e-16
C44 (\4\:B1 VSS) capacitor c=2.88611e-17
C45 (\4\:B0 VSS) capacitor c=6.2776e-17
C46 (\4\:VDD VSS) capacitor c=4.40163e-17
C47 (\5\:VDD VSS) capacitor c=1.63785e-17
Rk12 (\4\:Y Y) resistor r=0.4266 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5505 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.7496 c=0
Rk18 (\5\:VSS VSS) resistor r=0.1498 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.3504 c=0
Rk19 (\4\:VSS \7\:VSS) resistor r=0.07138 c=0
Rk20 (\5\:VSS \9\:VSS) resistor r=0.07323 c=0
Rk4 (\4\:A0N A0N) resistor r=0.1036 c=0
Rk15 (B0 \4\:B0) resistor r=0.1854 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4592 c=0
Rk23 (\5\:VDD VDD) resistor r=0.1699 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.3304 c=0
Rk24 (\5\:VDD \7\:VDD) resistor r=0.2584 c=0
Rk3 (\4\:A1N A1N) resistor r=0.005982 c=0
Rk10 (\4\:B1 B1) resistor r=0.09348 c=0
Rk8 (\4\:net164 \6\:net164) resistor r=0.9559 c=0
Rk9 (\6\:net164 \8\:net164) resistor r=0.6795 c=0
Rk5 (\5\:net146 \6\:net146) resistor r=0.14 c=0
Rk6 (\6\:net146 \8\:net146) resistor r=0.4649 c=0
Rk7 (\6\:net146 \10\:net146) resistor r=0.1195 c=0
Rk13 (\2\:net124 \4\:net124) resistor r=0.385 c=0
Rk14 (\4\:net124 \6\:net124) resistor r=0.4406 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=160.771 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=33.8482 c=0
Rl12 (\1\:B0 \2\:B0) resistor r=95.3867 c=0
Rl13 (\2\:B0 \3\:B0) resistor r=37.6944 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=29.5379 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=168 c=0
Rl10 (\1\:B1 \2\:B1) resistor r=72.3097 c=0
Rl11 (\2\:B1 \3\:B1) resistor r=60.7713 c=0
Rl8 (net164 \2\:net164) resistor r=161.538 c=0
Rl9 (\2\:net164 \3\:net164) resistor r=29.5379 c=0
Rl7 (\2\:net146 \4\:net146) resistor r=99.6815 c=0
Rl5 (net146 \2\:net146) resistor r=82.6702 c=0
Rl6 (\2\:net146 \3\:net146) resistor r=92.233 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz2 (\5\:net164 \6\:net164) resistor r=75 c=0
Rz1 (\9\:net146 \10\:net146) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry9 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\7\:net164 \8\:net164) resistor r=62 c=0
Ry1 (\7\:net146 \8\:net146) resistor r=62 c=0
Ry4 (net124 \2\:net124) resistor r=62 c=0
Ry5 (\3\:net124 \4\:net124) resistor r=62 c=0
Ry6 (\5\:net124 \6\:net124) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx4 (\3\:net164 \4\:net164) resistor r=45 c=0
Rx3 (\3\:net146 \5\:net146) resistor r=45 c=0
mn1 (\5\:net164 \3\:A1N \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.86e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn0 (\9\:net146 \3\:A0N \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.86e-14 ad=3.19e-14 ps=1.43e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.2e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (net144 net146 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.725e-14 ad=8.7e-15 ps=1.34e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.05e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\3\:Y \2\:net164 net144 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn5 (net156 \3\:B1 \3\:Y VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=3.95e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (\1\:VSS \3\:B0 net156 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
ends AOI2BB2XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:04 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI31X1
// View name: extracted

simulator lang=spectre

subckt AOI31X1 A0 A1 A2 B0 VDD VSS Y
mp0 (net81 \3\:A0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=18.8466 \
        scb=0.0203197 scc=0.000573038 m=(1)
mp1 (net81 \1\:A1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=14.4531 \
        scb=0.0120361 scc=0.000241045 m=(1)
mp2 (\3\:net81 \1\:A2 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.825e-14 ps=1.1e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.6e-07 sd=160n sca=14.3825 \
        scb=0.0118943 scc=0.000239579 m=(1)
mp3 (\4\:Y \1\:B0 \3\:net81 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=5.46e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=19.0814 \
        scb=0.0207066 scc=0.000603442 m=(1)
C1 (Y VSS) capacitor c=1.85752e-17
C2 (A2 VSS) capacitor c=7.84495e-17
C3 (A1 VSS) capacitor c=7.77391e-17
C4 (B0 VSS) capacitor c=6.56184e-17
C5 (A0 VSS) capacitor c=5.05588e-17
C6 (VDD VSS) capacitor c=9.2694e-17
C7 (net81 VSS) capacitor c=9.94807e-17
C8 (\1\:B0 VSS) capacitor c=4.57017e-17
C9 (\1\:A2 VSS) capacitor c=5.74672e-17
C10 (\1\:A1 VSS) capacitor c=7.23964e-17
C11 (\3\:A0 VSS) capacitor c=4.62223e-17
C12 (\3\:B0 VSS) capacitor c=3.91103e-17
C13 (\3\:A2 VSS) capacitor c=6.05989e-17
C14 (\3\:A1 VSS) capacitor c=6.47379e-17
C15 (\1\:A0 VSS) capacitor c=7.37786e-17
C16 (\2\:B0 VSS) capacitor c=4.40211e-17
C17 (\2\:A2 VSS) capacitor c=6.30883e-17
C18 (\2\:A1 VSS) capacitor c=7.81046e-17
C19 (\2\:A0 VSS) capacitor c=5.77313e-17
C20 (\4\:Y VSS) capacitor c=2.23629e-17
C21 (\3\:net81 VSS) capacitor c=1.0217e-16
C22 (\1\:VDD VSS) capacitor c=7.01632e-17
C23 (\6\:VDD VSS) capacitor c=4.03388e-17
C24 (\1\:Y VSS) capacitor c=1.21208e-16
C25 (\4\:A0 VSS) capacitor c=2.20668e-17
C26 (\4\:A1 VSS) capacitor c=4.72232e-17
C27 (\4\:A2 VSS) capacitor c=3.7989e-17
C28 (\4\:B0 VSS) capacitor c=5.32533e-17
C29 (\3\:Y VSS) capacitor c=9.12615e-17
C30 (\4\:VDD VSS) capacitor c=4.32883e-17
C31 (\5\:VDD VSS) capacitor c=1.11042e-17
Rk10 (\3\:Y Y) resistor r=0.01805 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.9703 c=0
Rk9 (\3\:Y \5\:Y) resistor r=0.2458 c=0
Rk4 (\6\:A2 A2) resistor r=0.001036 c=0
Rk5 (\4\:A2 \6\:A2) resistor r=0.05079 c=0
Rk2 (\4\:A1 A1) resistor r=0.1517 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.4073 c=0
Rk13 (\5\:VSS VSS) resistor r=0.09234 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.1578 c=0
Rk14 (\5\:VSS \7\:VSS) resistor r=0.2143 c=0
Rk7 (\4\:B0 B0) resistor r=0.1654 c=0
Rk1 (A0 \4\:A0) resistor r=0.1111 c=0
Rk15 (\2\:VDD \4\:VDD) resistor r=0.2807 c=0
Rk18 (\5\:VDD VDD) resistor r=0.04219 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.2083 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2789 c=0
Rk6 (\2\:net81 \4\:net81) resistor r=0.5322 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=110.771 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=91.5405 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=175.692 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=113.462 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=93.4066 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=78.079 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=138.261 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Ry3 (\4\:Y \5\:Y) resistor r=31 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=20.6667 c=0
Ry1 (net81 \2\:net81) resistor r=31 c=0
Ry2 (\3\:net81 \4\:net81) resistor r=31 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net93 \1\:A0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (net97 \3\:A1 net93 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=2.99e-14 ps=6.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \3\:A2 net97 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.29e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.29e-14 ps=8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
ends AOI31X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:05 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI31X2
// View name: extracted

simulator lang=spectre

subckt AOI31X2 A0 A1 A2 B0 VDD VSS Y
mp3 (\5\:Y \1\:B0 net81 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.45e-07 sd=160n sca=21.3165 \
        scb=0.0178846 scc=0.00184501 m=(2)
mp2_1__rcx (net81 \3\:A2 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.165e-06 sd=160n sca=20.9872 \
        scb=0.0175085 scc=0.00184372 m=(2)
mp0 (net81 \2\:A0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=33.3935 \
        scb=0.0357498 scc=0.00324908 m=(2)
mp1_1__rcx (net81 \1\:A1 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=23.3597 \
        scb=0.0210771 scc=0.00188446 m=(2)
C1 (A0 VSS) capacitor c=3.37202e-17
C2 (A1 VSS) capacitor c=3.30782e-17
C3 (Y VSS) capacitor c=4.29667e-17
C4 (B0 VSS) capacitor c=5.55367e-17
C5 (VDD VSS) capacitor c=9.44289e-17
C6 (A2 VSS) capacitor c=5.93743e-17
C7 (9 VSS) capacitor c=1.36221e-18
C8 (10 VSS) capacitor c=4.97519e-18
C9 (11 VSS) capacitor c=4.22545e-18
C10 (12 VSS) capacitor c=2.8113e-18
C11 (net81 VSS) capacitor c=3.3184e-16
C12 (\1\:B0 VSS) capacitor c=7.32269e-17
C13 (\1\:A1 VSS) capacitor c=3.77954e-16
C14 (\6\:A0 VSS) capacitor c=5.87534e-17
C15 (\6\:A1 VSS) capacitor c=6.29224e-17
C16 (\1\:A2 VSS) capacitor c=3.83475e-17
C17 (\4\:A2 VSS) capacitor c=2.92276e-17
C18 (\3\:A1 VSS) capacitor c=6.02888e-17
C19 (\1\:A0 VSS) capacitor c=4.96065e-17
C20 (\7\:B0 VSS) capacitor c=1.72795e-17
C21 (\3\:A2 VSS) capacitor c=9.04953e-17
C22 (\2\:A0 VSS) capacitor c=4.43388e-16
C23 (\5\:Y VSS) capacitor c=4.98958e-17
C24 (\1\:VDD VSS) capacitor c=1.53187e-16
C25 (\7\:VDD VSS) capacitor c=4.24747e-17
C26 (\3\:Y VSS) capacitor c=8.42549e-17
C27 (\1\:Y VSS) capacitor c=8.73611e-17
C28 (\2\:A2 VSS) capacitor c=4.41225e-17
C29 (\4\:B0 VSS) capacitor c=7.95093e-17
C30 (\7\:A2 VSS) capacitor c=4.34159e-17
Rk4 (A0 \2\:A0) resistor r=0.05589 c=0
Rk3 (\1\:A1 A1) resistor r=0.09536 c=0
Rk7 (\4\:Y Y) resistor r=0.2324 c=0
Rk6 (\2\:Y \4\:Y) resistor r=0.5358 c=0
Rk8 (Y \6\:Y) resistor r=0.2206 c=0
Rk17 (\1\:VSS \5\:VSS) resistor r=0.1367 c=0
Rk19 (\6\:VSS VSS) resistor r=0.03465 c=0
Rk18 (\5\:VSS \6\:VSS) resistor r=0.4159 c=0
Rk21 (\6\:VSS \10\:VSS) resistor r=0.1987 c=0
Rk15 (B0 \9\:B0) resistor r=0.002997 c=0
Rk25 (\1\:VDD VDD) resistor r=0.1023 c=0
Rk26 (\1\:VDD \8\:VDD) resistor r=0.2799 c=0
Rk1 (A2 \7\:A2) resistor r=0.06041 c=0
Rl13 (\2\:A0 \6\:A0) resistor r=31.4665 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=29.8412 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=44.9225 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=44.9225 c=0
Rl15 (\3\:B0 \1\:B0) resistor r=48.6954 c=0
Rl19 (\3\:B0 \7\:B0) resistor r=30.0336 c=0
Rl16 (\4\:B0 \3\:B0) resistor r=7.3053 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=97.7009 c=0
Rl7 (\2\:A2 \4\:A2) resistor r=113.085 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=6.6414 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz5 (\10\:VSS \9\:VSS) resistor r=75 c=0
Ry1 (\6\:Y \5\:Y) resistor r=62 c=0
Ry9 (\8\:VDD \7\:VDD) resistor r=62 c=0
Rx6 (\9\:B0 \7\:B0) resistor r=45 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
mn0_1__rcx (9 \1\:A0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (9 \3\:A1 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=1.56e-14 ps=9.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.345e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\1\:Y \4\:A2 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.095e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\1\:Y \1\:A2 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=7e-07 \
        sb=8.9e-07 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn1 (11 \6\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.95e-14 \
        ad=2.99e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.6e-07 sb=7.3e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (12 \6\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.95e-14 ps=1.35e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=6.1e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\3\:Y \4\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=4.16e-14 ps=1.075e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.245e-06 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
ends AOI31X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:06 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI31X4
// View name: extracted

simulator lang=spectre

subckt AOI31X4 A0 A1 A2 B0 VDD VSS Y
mp3_1__rcx (\4\:Y B0 net89 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.361e-14 ad=6.24e-14 ps=1.1575e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.35e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
mp0_1__rcx (net89 A0 \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.912 scb=0.0201637 \
        scc=0.00163433 m=(4)
mp1_1__rcx (net89 A1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(4)
mp2_1__rcx (net89 \1\:A2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.655e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
C1 (A2 VSS) capacitor c=2.86435e-17
C2 (A1 VSS) capacitor c=3.82844e-16
C3 (VDD VSS) capacitor c=1.48357e-16
C4 (B0 VSS) capacitor c=3.52432e-16
C5 (A0 VSS) capacitor c=3.59729e-16
C6 (net97 VSS) capacitor c=3.07341e-16
C7 (net101 VSS) capacitor c=1.48489e-16
C8 (net89 VSS) capacitor c=6.91208e-16
C9 (\1\:A2 VSS) capacitor c=3.28835e-16
C10 (\4\:Y VSS) capacitor c=1.57115e-16
C11 (\1\:VDD VSS) capacitor c=5.63056e-17
C12 (\1\:Y VSS) capacitor c=3.12354e-16
C13 (\4\:net101 VSS) capacitor c=1.53786e-16
C14 (\3\:VDD VSS) capacitor c=1.11929e-16
C15 (\5\:VDD VSS) capacitor c=1.00836e-16
C16 (\8\:VDD VSS) capacitor c=1.04501e-16
Rk21 (Y \4\:Y) resistor r=0.01331 c=0
Rk20 (\1\:Y Y) resistor r=0.2519 c=0
Rk12 (\1\:A2 A2) resistor r=0.0566 c=0
Rk44 (\1\:VSS \6\:VSS) resistor r=0.8845 c=0
Rk47 (\7\:VSS VSS) resistor r=0.1023 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.2429 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.268 c=0
Rk53 (\3\:VDD \5\:VDD) resistor r=0.2051 c=0
Rk55 (\5\:VDD \7\:VDD) resistor r=0.06747 c=0
Rk58 (\8\:VDD VDD) resistor r=0.2076 c=0
Rk56 (\7\:VDD \8\:VDD) resistor r=0.1376 c=0
Rk14 (net101 \4\:net101) resistor r=0.4187 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz20 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Ry19 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry20 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
mn2_1__rcx (\1\:Y \1\:A2 net101 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn3_1__rcx (\1\:Y B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn1_1__rcx (\4\:net101 A1 net97 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn0_1__rcx (net97 A0 \7\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
ends AOI31X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:07 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI31XL
// View name: extracted

simulator lang=spectre

subckt AOI31XL A0 A1 A2 B0 VDD VSS Y
mp0 (net89 \1\:A0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=9.95e-07 sd=160n sca=17.5166 scb=0.0182556 \
        scc=0.000475856 m=(1)
mp1 (net89 \1\:A1 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=7.9e-07 sd=160n sca=13.9261 \
        scb=0.0122243 scc=0.000335729 m=(1)
mp2 (\3\:net89 \1\:A2 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.87e-14 ps=1.52e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=5.25e-07 sd=160n sca=12.9171 \
        scb=0.0110416 scc=0.000332167 m=(1)
mp3 (\1\:Y \1\:B0 \3\:net89 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=6.45e-14 ps=7.9e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=3e-07 sd=160n sca=13.7104 scb=0.0119478 \
        scc=0.000334396 m=(1)
C1 (A2 VSS) capacitor c=4.41141e-17
C2 (A1 VSS) capacitor c=9.6013e-17
C3 (Y VSS) capacitor c=2.38123e-17
C4 (VDD VSS) capacitor c=1.20794e-16
C5 (B0 VSS) capacitor c=7.12943e-17
C6 (A0 VSS) capacitor c=5.11081e-17
C7 (net97 VSS) capacitor c=1.59504e-18
C8 (net101 VSS) capacitor c=4.09452e-18
C9 (net89 VSS) capacitor c=3.01141e-17
C10 (\1\:B0 VSS) capacitor c=2.33522e-17
C11 (\1\:A2 VSS) capacitor c=5.16248e-17
C12 (\1\:A1 VSS) capacitor c=4.76408e-17
C13 (\1\:A0 VSS) capacitor c=2.83328e-17
C14 (\3\:B0 VSS) capacitor c=3.58858e-17
C15 (\3\:A2 VSS) capacitor c=2.68456e-17
C16 (\3\:A1 VSS) capacitor c=3.0964e-17
C17 (\3\:A0 VSS) capacitor c=3.66227e-17
C18 (\2\:B0 VSS) capacitor c=3.35159e-17
C19 (\2\:A2 VSS) capacitor c=3.55571e-17
C20 (\2\:A1 VSS) capacitor c=3.95756e-17
C21 (\2\:A0 VSS) capacitor c=3.35384e-17
C22 (\1\:Y VSS) capacitor c=4.14753e-17
C23 (\3\:net89 VSS) capacitor c=5.82191e-17
C24 (\5\:VDD VSS) capacitor c=1.2933e-17
C25 (\7\:VDD VSS) capacitor c=3.15995e-18
C26 (\4\:Y VSS) capacitor c=6.30346e-17
C27 (\4\:A0 VSS) capacitor c=1.51577e-17
C28 (\4\:A2 VSS) capacitor c=6.36291e-17
C29 (\4\:B0 VSS) capacitor c=3.33962e-17
C30 (\3\:Y VSS) capacitor c=6.09642e-17
C31 (\3\:VDD VSS) capacitor c=4.08884e-17
C32 (\4\:VDD VSS) capacitor c=8.90098e-18
Rk9 (\2\:VSS \4\:VSS) resistor r=0.5292 c=0
Rk11 (\5\:VSS VSS) resistor r=0.06678 c=0
Rk10 (\4\:VSS \5\:VSS) resistor r=0.2812 c=0
Rk12 (\5\:VSS \7\:VSS) resistor r=0.3578 c=0
Rk3 (A2 \4\:A2) resistor r=0.01337 c=0
Rk2 (\4\:A1 A1) resistor r=0.002876 c=0
Rk8 (\3\:Y Y) resistor r=0.08474 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.2153 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4511 c=0
Rk15 (\4\:VDD VDD) resistor r=0.05185 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.2337 c=0
Rk16 (\3\:VDD \6\:VDD) resistor r=0.07243 c=0
Rk17 (\4\:VDD \8\:VDD) resistor r=0.07243 c=0
Rk5 (\4\:B0 B0) resistor r=0.02648 c=0
Rk1 (\4\:A0 A0) resistor r=0.073 c=0
Rk4 (\2\:net89 \4\:net89) resistor r=0.2755 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=112.694 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=79.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=60.3072 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=24.2328 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=112.694 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=110.307 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (net89 \2\:net89) resistor r=62 c=0
Ry2 (\3\:net89 \4\:net89) resistor r=62 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net97 \3\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (net101 \3\:A1 net97 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (\4\:Y \3\:A2 net101 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\4\:Y \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
ends AOI31XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:08 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI32X1
// View name: extracted

simulator lang=spectre

subckt AOI32X1 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (\5\:net114 \1\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=25.2855 \
        scb=0.0288799 scc=0.00168046 m=(1)
mp1 (\5\:net114 \1\:A1 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.23e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=15.2518 \
        scb=0.0142072 scc=0.000315834 m=(1)
mp2 (\3\:net114 \1\:A2 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.23e-14 ad=7.02e-14 ps=1.43e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.7e-07 sd=160n sca=13.3156 \
        scb=0.0107792 scc=0.000275125 m=(1)
mp4 (\1\:Y \1\:B1 \3\:net114 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=6.24e-14 ps=1.14e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=13.5349 \
        scb=0.0111426 scc=0.000276613 m=(1)
mp3 (\1\:Y \1\:B0 net114 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=16.4194 \
        scb=0.0162738 scc=0.000375337 m=(1)
C1 (A0 VSS) capacitor c=3.57474e-17
C2 (Y VSS) capacitor c=6.78777e-17
C3 (B1 VSS) capacitor c=4.64774e-17
C4 (VDD VSS) capacitor c=1.0562e-16
C5 (A2 VSS) capacitor c=4.82748e-17
C6 (B0 VSS) capacitor c=2.90827e-17
C7 (net122 VSS) capacitor c=3.28987e-18
C8 (net126 VSS) capacitor c=2.41572e-18
C9 (net118 VSS) capacitor c=2.72112e-18
C10 (net114 VSS) capacitor c=5.75361e-17
C11 (\1\:B0 VSS) capacitor c=5.07625e-17
C12 (\1\:B1 VSS) capacitor c=5.48957e-17
C13 (\1\:A2 VSS) capacitor c=7.38681e-17
C14 (\1\:A1 VSS) capacitor c=7.29936e-17
C15 (\1\:A0 VSS) capacitor c=4.70618e-17
C16 (\3\:B0 VSS) capacitor c=3.56094e-17
C17 (\3\:B1 VSS) capacitor c=3.78726e-17
C18 (\3\:A2 VSS) capacitor c=3.26621e-17
C19 (\3\:A1 VSS) capacitor c=4.25188e-17
C20 (\4\:A0 VSS) capacitor c=3.70368e-17
C21 (\2\:B0 VSS) capacitor c=4.41034e-17
C22 (\2\:B1 VSS) capacitor c=4.83542e-17
C23 (\2\:A2 VSS) capacitor c=4.84159e-17
C24 (\2\:A1 VSS) capacitor c=6.47108e-17
C25 (\3\:A0 VSS) capacitor c=1.48462e-17
C26 (\1\:Y VSS) capacitor c=7.45183e-17
C27 (\3\:net114 VSS) capacitor c=9.33773e-17
C28 (\6\:VDD VSS) capacitor c=4.04638e-17
C29 (\5\:net114 VSS) capacitor c=7.0252e-17
C30 (\4\:VDD VSS) capacitor c=4.55768e-17
C31 (\3\:Y VSS) capacitor c=9.30802e-17
C32 (\2\:A0 VSS) capacitor c=3.4943e-17
C33 (\5\:A0 VSS) capacitor c=5.26303e-17
C34 (\4\:A1 VSS) capacitor c=6.32231e-17
C35 (\6\:A1 VSS) capacitor c=4.29539e-17
C36 (\5\:A2 VSS) capacitor c=5.75819e-17
C37 (\4\:B1 VSS) capacitor c=6.4271e-17
C38 (\5\:B0 VSS) capacitor c=2.84134e-17
C39 (\3\:VDD VSS) capacitor c=5.46139e-17
Rk1 (A0 \5\:A0) resistor r=0.1767 c=0
Rk9 (\2\:Y Y) resistor r=0.249 c=0
Rk10 (Y \4\:Y) resistor r=0.4035 c=0
Rk8 (B1 \4\:B1) resistor r=0.1163 c=0
Rk17 (\4\:VSS VSS) resistor r=0.3008 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.5158 c=0
Rk18 (VSS \6\:VSS) resistor r=0.3131 c=0
Rk20 (\3\:VDD VDD) resistor r=0.2054 c=0
Rk21 (VDD \5\:VDD) resistor r=0.2553 c=0
Rk22 (\3\:VDD \7\:VDD) resistor r=0.1931 c=0
Rk7 (A2 \5\:A2) resistor r=0.005989 c=0
Rk11 (\4\:B0 \5\:B0) resistor r=0.001269 c=0
Rk12 (\6\:B0 B0) resistor r=0.001396 c=0
Rk13 (\5\:B0 \6\:B0) resistor r=0.01797 c=0
Rk2 (\4\:A1 \5\:A1) resistor r=0.002562 c=0
Rk3 (A1 \6\:A1) resistor r=0.002476 c=0
Rk4 (\4\:A1 \6\:A1) resistor r=0.07567 c=0
Rk14 (\2\:net114 \4\:net114) resistor r=0.4828 c=0
Rk15 (\4\:net114 \6\:net114) resistor r=0.4341 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=125.803 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=37.3411 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.013 c=0
Rl8 (\1\:B1 \2\:B1) resistor r=91.5405 c=0
Rl9 (\2\:B1 \3\:B1) resistor r=53.079 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=132.246 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl10 (\1\:B0 \2\:B0) resistor r=110.771 c=0
Rl11 (\2\:B0 \3\:B0) resistor r=50.3716 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=117.565 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=31 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (net114 \2\:net114) resistor r=20.6667 c=0
Ry3 (\3\:net114 \4\:net114) resistor r=31 c=0
Ry4 (\5\:net114 \6\:net114) resistor r=31 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx3 (\2\:A2 \5\:A2) resistor r=45 c=0
Rx5 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
mn0 (net122 \4\:A0 \5\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.99e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.55e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn1 (net126 \3\:A1 net122 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.03e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=7.95e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn2 (\3\:Y \3\:A2 net126 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=5.98e-14 ps=8.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=5.95e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn4 (\3\:Y \3\:B1 net118 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.98e-14 ps=7.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.2e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn3 (net118 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.51e-14 ps=8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
ends AOI32X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:09 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI32X2
// View name: extracted

simulator lang=spectre

subckt AOI32X2 A0 A1 A2 B0 B1 VDD VSS Y
mp2 (net47 \3\:A2 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.75e-06 sd=160n sca=12.9062 \
        scb=0.0110166 scc=0.000412479 m=(2)
mp4_1__rcx (\7\:Y \1\:B1 \4\:net47 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=8.093e-14 ps=1.1e-06 pd=1.195e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=6.45e-07 sd=160n sca=12.9823 \
        scb=0.0110609 scc=0.000412509 m=(2)
mp3 (\7\:Y B0 net47 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=7.41e-14 \
        ad=8.093e-14 ps=1.16e-06 pd=1.195e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.45e-06 sb=8.5e-07 sd=160n sca=12.4042 scb=0.0108296 \
        scc=0.000412414 m=(2)
mp0 (net47 A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.4492 scb=0.017739 \
        scc=0.000533089 m=(2)
mp1 (net47 \1\:A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.955e-06 sd=160n sca=14.0779 \
        scb=0.0121323 scc=0.000415426 m=(2)
C1 (A2 VSS) capacitor c=7.42894e-17
C2 (B1 VSS) capacitor c=5.17925e-17
C3 (A0 VSS) capacitor c=4.40845e-16
C4 (Y VSS) capacitor c=2.17495e-17
C5 (B0 VSS) capacitor c=3.39875e-16
C6 (A1 VSS) capacitor c=1.9487e-17
C7 (VDD VSS) capacitor c=1.44105e-16
C8 (10 VSS) capacitor c=1.92813e-18
C9 (11 VSS) capacitor c=5.2414e-18
C10 (12 VSS) capacitor c=2.77956e-18
C11 (13 VSS) capacitor c=9.73428e-18
C12 (14 VSS) capacitor c=4.63479e-18
C13 (15 VSS) capacitor c=6.32374e-18
C14 (net47 VSS) capacitor c=3.55114e-16
C15 (\1\:B1 VSS) capacitor c=8.47748e-17
C16 (\1\:A1 VSS) capacitor c=3.63517e-16
C17 (\6\:B0 VSS) capacitor c=2.24976e-17
C18 (\4\:B1 VSS) capacitor c=2.12797e-17
C19 (\6\:B1 VSS) capacitor c=4.59199e-17
C20 (\1\:B0 VSS) capacitor c=4.1148e-17
C21 (\6\:A0 VSS) capacitor c=3.27122e-17
C22 (\6\:A1 VSS) capacitor c=5.82842e-17
C23 (\1\:A2 VSS) capacitor c=6.40117e-17
C24 (\5\:A2 VSS) capacitor c=2.40383e-17
C25 (\3\:A1 VSS) capacitor c=5.85565e-17
C26 (\1\:A0 VSS) capacitor c=4.88998e-17
C27 (\3\:A2 VSS) capacitor c=9.53118e-17
C28 (\4\:net47 VSS) capacitor c=8.99343e-17
C29 (\7\:Y VSS) capacitor c=1.46556e-16
C30 (\7\:VDD VSS) capacitor c=3.9067e-17
C31 (\1\:VDD VSS) capacitor c=8.01097e-17
C32 (\1\:Y VSS) capacitor c=5.07591e-17
C33 (\4\:Y VSS) capacitor c=7.84232e-17
C34 (\2\:A2 VSS) capacitor c=1.86707e-17
C35 (\3\:B1 VSS) capacitor c=2.04803e-17
C36 (\7\:A2 VSS) capacitor c=3.83596e-17
C37 (\3\:Y VSS) capacitor c=9.88597e-17
C38 (\6\:Y VSS) capacitor c=4.88214e-17
C39 (\7\:B1 VSS) capacitor c=5.03619e-17
C40 (\3\:VDD VSS) capacitor c=1.11375e-16
Rk1 (\7\:A2 A2) resistor r=0.2025 c=0
Rk12 (B1 \7\:B1) resistor r=0.02928 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3186 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4836 c=0
Rk9 (\6\:Y Y) resistor r=0.02559 c=0
Rk10 (\6\:Y \7\:Y) resistor r=0.2431 c=0
Rk8 (\3\:Y \6\:Y) resistor r=0.3845 c=0
Rk21 (\2\:VSS \4\:VSS) resistor r=0.288 c=0
Rk22 (\4\:VSS \5\:VSS) resistor r=0.5261 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.1251 c=0
Rk25 (\7\:VSS VSS) resistor r=0.1073 c=0
Rk24 (\6\:VSS \7\:VSS) resistor r=0.4434 c=0
Rk26 (\5\:VSS \9\:VSS) resistor r=0.1021 c=0
Rk27 (\7\:VSS \11\:VSS) resistor r=0.2815 c=0
Rk2 (A1 \1\:A1) resistor r=0.02396 c=0
Rk34 (\3\:VDD VDD) resistor r=0.1599 c=0
Rk28 (\2\:VDD \3\:VDD) resistor r=0.6522 c=0
Rk31 (\3\:VDD \8\:VDD) resistor r=0.1995 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=82.6702 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=49.9779 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=49.0067 c=0
Rl17 (\3\:B1 \1\:B1) resistor r=23.8563 c=0
Rl18 (\3\:B1 \4\:B1) resistor r=32.7557 c=0
Rl20 (\3\:B1 \6\:B1) resistor r=82.1768 c=0
Rl13 (A0 \6\:A0) resistor r=28.1859 c=0
Rl1 (A0 \1\:A0) resistor r=29.8412 c=0
Rl22 (B0 \6\:B0) resistor r=37.3411 c=0
Rl14 (B0 \1\:B0) resistor r=24.7951 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=47.2527 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=35.3072 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz5 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry10 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry11 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry13 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry5 (net47 \4\:net47) resistor r=62 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
mn0_1__rcx (10 \1\:A0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1_1__rcx (10 \3\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=1.56e-14 ps=8.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.955e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_1__rcx (\4\:Y \5\:A2 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.735e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\4\:Y \1\:A2 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.7e-07 sb=1.53e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (12 \6\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.75e-07 sb=1.425e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn0 (13 \6\:A0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.177e-13 ad=5.72e-14 ps=1.77e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.16e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_1__rcx (14 \1\:B0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.177e-13 ad=3.12e-14 ps=1.77e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=8.1e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4_1__rcx (\1\:Y \6\:B1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=6.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4 (\1\:Y \4\:B1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=6.63e-14 \
        ad=4.16e-14 ps=1.03e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.76e-06 sb=4.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn3 (15 \6\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=6.63e-14 ps=8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
ends AOI32X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:10 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI32X4
// View name: extracted

simulator lang=spectre

subckt AOI32X4 A0 A1 A2 B0 B1 VDD VSS Y
mp3_1__rcx (\10\:Y B0 net106 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
mp4_1__rcx (\10\:Y B1 net106 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp0_1__rcx (net106 A0 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=24.9718 scb=0.0274046 \
        scc=0.00171026 m=(4)
mp1_1__rcx (net106 \2\:A1 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=18.9104 \
        scb=0.0172562 scc=0.00120281 m=(4)
mp2 (net106 A2 \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=17.1755 scb=0.0150279 \
        scc=0.00118894 m=(4)
C1 (A2 VSS) capacitor c=4.90394e-16
C2 (B1 VSS) capacitor c=3.92484e-16
C3 (A0 VSS) capacitor c=8.71623e-16
C4 (Y VSS) capacitor c=7.59207e-17
C5 (B0 VSS) capacitor c=5.60995e-16
C6 (A1 VSS) capacitor c=2.55925e-17
C7 (VDD VSS) capacitor c=1.85362e-16
C8 (10 VSS) capacitor c=1.36221e-18
C9 (11 VSS) capacitor c=4.06732e-18
C10 (12 VSS) capacitor c=2.24904e-18
C11 (13 VSS) capacitor c=4.22545e-18
C12 (14 VSS) capacitor c=3.93582e-18
C13 (15 VSS) capacitor c=8.5743e-18
C14 (16 VSS) capacitor c=7.51963e-18
C15 (17 VSS) capacitor c=4.16847e-18
C16 (18 VSS) capacitor c=3.58574e-18
C17 (19 VSS) capacitor c=1.90394e-18
C18 (20 VSS) capacitor c=2.01768e-18
C19 (net106 VSS) capacitor c=8.00903e-16
C20 (\12\:B0 VSS) capacitor c=7.29675e-17
C21 (\12\:B1 VSS) capacitor c=4.7925e-17
C22 (\10\:B1 VSS) capacitor c=4.94859e-17
C23 (\8\:B0 VSS) capacitor c=5.1585e-17
C24 (\9\:B0 VSS) capacitor c=7.13526e-17
C25 (\4\:B1 VSS) capacitor c=5.56322e-17
C26 (\6\:B1 VSS) capacitor c=4.56328e-17
C27 (\1\:B0 VSS) capacitor c=4.30159e-17
C28 (\12\:A0 VSS) capacitor c=4.59808e-17
C29 (\13\:A1 VSS) capacitor c=4.59144e-17
C30 (\12\:A2 VSS) capacitor c=4.29392e-17
C31 (\10\:A2 VSS) capacitor c=2.35545e-17
C32 (\9\:A1 VSS) capacitor c=4.72943e-17
C33 (\9\:A0 VSS) capacitor c=3.42244e-17
C34 (\7\:A0 VSS) capacitor c=5.39412e-17
C35 (\6\:A1 VSS) capacitor c=6.91757e-17
C36 (\1\:A2 VSS) capacitor c=5.23548e-17
C37 (\5\:A2 VSS) capacitor c=2.56701e-17
C38 (\1\:A1 VSS) capacitor c=6.12597e-17
C39 (\1\:A0 VSS) capacitor c=5.01673e-17
C40 (\2\:A1 VSS) capacitor c=8.43744e-16
C41 (\10\:Y VSS) capacitor c=2.73187e-16
C42 (\1\:VDD VSS) capacitor c=9.1846e-17
C43 (\1\:Y VSS) capacitor c=6.15147e-17
C44 (\3\:Y VSS) capacitor c=6.98175e-17
C45 (\6\:Y VSS) capacitor c=1.56419e-16
C46 (\8\:Y VSS) capacitor c=1.28996e-16
C47 (\2\:A2 VSS) capacitor c=3.922e-17
C48 (\9\:A2 VSS) capacitor c=2.27657e-17
C49 (\3\:B1 VSS) capacitor c=3.514e-17
C50 (\9\:B1 VSS) capacitor c=4.38527e-17
C51 (\5\:Y VSS) capacitor c=1.09702e-16
C52 (\3\:VDD VSS) capacitor c=3.47366e-16
Rk19 (Y \10\:Y) resistor r=0.1127 c=0
Rk14 (\2\:Y \4\:Y) resistor r=0.4599 c=0
Rk18 (\5\:Y Y) resistor r=0.4494 c=0
Rk15 (\4\:Y \5\:Y) resistor r=0.3002 c=0
Rk16 (\5\:Y \7\:Y) resistor r=0.4803 c=0
Rk17 (\7\:Y \9\:Y) resistor r=0.8447 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.5028 c=0
Rk41 (\4\:VSS \5\:VSS) resistor r=0.4312 c=0
Rk42 (\5\:VSS \6\:VSS) resistor r=0.6218 c=0
Rk43 (\6\:VSS \7\:VSS) resistor r=0.09661 c=0
Rk45 (\8\:VSS VSS) resistor r=0.1149 c=0
Rk44 (\7\:VSS \8\:VSS) resistor r=0.4359 c=0
Rk46 (\4\:VSS \10\:VSS) resistor r=0.07144 c=0
Rk47 (\5\:VSS \12\:VSS) resistor r=0.04328 c=0
Rk48 (\6\:VSS \14\:VSS) resistor r=0.04328 c=0
Rk49 (\8\:VSS \16\:VSS) resistor r=0.1987 c=0
Rk7 (\2\:A1 A1) resistor r=0.08428 c=0
Rk62 (\3\:VDD VDD) resistor r=0.1324 c=0
Rk50 (\2\:VDD \3\:VDD) resistor r=0.5262 c=0
Rl6 (\2\:A2 A2) resistor r=62.3759 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=73.0548 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=59.5933 c=0
Rl20 (\9\:A2 A2) resistor r=77.3125 c=0
Rl23 (\9\:A2 \12\:A2) resistor r=100.426 c=0
Rl21 (\9\:A2 \10\:A2) resistor r=35.772 c=0
Rl32 (\3\:B1 B1) resistor r=7.101 c=0
Rl33 (\3\:B1 \4\:B1) resistor r=86.6019 c=0
Rl35 (\3\:B1 \6\:B1) resistor r=136.023 c=0
Rl42 (\9\:B1 B1) resistor r=25.8618 c=0
Rl45 (\9\:B1 \12\:B1) resistor r=60.0739 c=0
Rl43 (\9\:B1 \10\:B1) resistor r=67.7662 c=0
Rl28 (A0 \12\:A0) resistor r=40.1797 c=0
Rl16 (A0 \9\:A0) resistor r=24.2328 c=0
Rl14 (A0 \7\:A0) resistor r=98.3529 c=0
Rl1 (A0 \1\:A0) resistor r=30.2349 c=0
Rl47 (B0 \12\:B0) resistor r=98.0541 c=0
Rl39 (B0 \8\:B0) resistor r=40.6783 c=0
Rl40 (B0 \9\:B0) resistor r=109.334 c=0
Rl29 (B0 \1\:B0) resistor r=31.9251 c=0
Rl26 (\2\:A1 \13\:A1) resistor r=52.7257 c=0
Rl18 (\2\:A1 \9\:A1) resistor r=56.8681 c=0
Rl11 (\2\:A1 \6\:A1) resistor r=44.9225 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=44.9225 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz9 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry17 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry18 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (10 \1\:A0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \1\:A1 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=1.56e-14 ps=8.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\8\:Y \5\:A2 11 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_2__rcx (\8\:Y \1\:A2 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (12 \6\:A1 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (13 \7\:A0 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_3__rcx (14 \9\:A0 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.73e-14 ps=1.35e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (14 \9\:A1 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.73e-14 ps=9.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (\6\:Y \10\:A2 15 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.16e-14 ps=9.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (\6\:Y \12\:A2 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (16 \13\:A1 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.55e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=1.785e-06 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn0 (17 \12\:A0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=2.99e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.625e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (18 \1\:B0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=3.51e-14 ps=1.45e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.31e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\3\:Y \6\:B1 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.13e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (\3\:Y \4\:B1 19 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.25e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (19 \9\:B0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.35e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.2e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_3__rcx (20 \8\:B0 \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.35e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_3__rcx (\1\:Y \10\:B1 20 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4 (\1\:Y \12\:B1 21 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (21 \12\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
ends AOI32X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:12 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI32XL
// View name: extracted

simulator lang=spectre

subckt AOI32XL A0 A1 A2 B0 B1 VDD VSS Y
mp0 (net114 \1\:A0 \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.12e-06 sd=160n sca=16.0514 scb=0.0157827 \
        scc=0.00029851 m=(1)
mp1 (net114 \1\:A1 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.15e-07 sd=160n sca=12.7829 \
        scb=0.0103785 scc=0.000190716 m=(1)
mp2 (\3\:net114 \1\:A2 \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=7.095e-14 ps=1.45e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=7.2e-07 sd=160n sca=11.9309 scb=0.00939564 \
        scc=0.00018805 m=(1)
mp4 (\1\:Y \1\:B1 \3\:net114 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.095e-14 ad=3.44e-14 ps=1.09e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=3.45e-07 sd=160n sca=13.6898 \
        scb=0.0116924 scc=0.000200935 m=(1)
mp3 (\1\:Y \1\:B0 \5\:net114 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=1.4e-07 sd=160n sca=19.5246 \
        scb=0.021512 scc=0.000667372 m=(1)
C1 (A0 VSS) capacitor c=3.50665e-17
C2 (Y VSS) capacitor c=5.69032e-17
C3 (B1 VSS) capacitor c=1.04934e-16
C4 (VDD VSS) capacitor c=1.31878e-16
C5 (A2 VSS) capacitor c=5.04441e-17
C6 (B0 VSS) capacitor c=3.95058e-17
C7 (A1 VSS) capacitor c=4.30914e-17
C8 (net126 VSS) capacitor c=6.03317e-18
C9 (net130 VSS) capacitor c=5.90245e-19
C10 (net114 VSS) capacitor c=2.33902e-17
C11 (\1\:B0 VSS) capacitor c=3.41688e-17
C12 (\1\:B1 VSS) capacitor c=4.68534e-17
C13 (\1\:A2 VSS) capacitor c=6.01143e-17
C14 (\1\:A1 VSS) capacitor c=6.91271e-17
C15 (\1\:A0 VSS) capacitor c=4.45632e-17
C16 (\3\:B0 VSS) capacitor c=6.79433e-17
C17 (\3\:B1 VSS) capacitor c=4.12914e-17
C18 (\3\:A2 VSS) capacitor c=2.38309e-17
C19 (\3\:A1 VSS) capacitor c=2.92105e-17
C20 (\3\:A0 VSS) capacitor c=2.6319e-17
C21 (\4\:B0 VSS) capacitor c=1.21347e-17
C22 (\2\:B1 VSS) capacitor c=6.274e-17
C23 (\2\:A2 VSS) capacitor c=4.88898e-17
C24 (\2\:A1 VSS) capacitor c=5.93714e-17
C25 (\2\:A0 VSS) capacitor c=4.21652e-17
C26 (\5\:net114 VSS) capacitor c=6.87783e-17
C27 (\1\:Y VSS) capacitor c=5.59941e-17
C28 (\3\:net114 VSS) capacitor c=7.23043e-17
C29 (\5\:VDD VSS) capacitor c=1.14444e-17
C30 (\7\:VDD VSS) capacitor c=1.64308e-19
C31 (\3\:Y VSS) capacitor c=8.28505e-17
C32 (\2\:B0 VSS) capacitor c=4.84892e-17
C33 (\4\:A0 VSS) capacitor c=3.1562e-17
C34 (\4\:A1 VSS) capacitor c=7.00457e-17
C35 (\4\:A2 VSS) capacitor c=6.48052e-17
C36 (\5\:B0 VSS) capacitor c=4.61324e-17
C37 (\3\:VDD VSS) capacitor c=5.42918e-17
C38 (\4\:VDD VSS) capacitor c=9.84158e-18
Rk1 (A0 \4\:A0) resistor r=0.1043 c=0
Rk5 (\2\:Y Y) resistor r=0.2993 c=0
Rk6 (Y \4\:Y) resistor r=0.4062 c=0
Rk4 (\4\:B1 B1) resistor r=0.00298 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.5648 c=0
Rk12 (\5\:VSS VSS) resistor r=0.07432 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.2739 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.284 c=0
Rk16 (\4\:VDD VDD) resistor r=0.05936 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.2339 c=0
Rk17 (\3\:VDD \6\:VDD) resistor r=0.07254 c=0
Rk18 (\4\:VDD \8\:VDD) resistor r=0.07254 c=0
Rk3 (A2 \4\:A2) resistor r=0.2135 c=0
Rk7 (\5\:B0 B0) resistor r=0.0535 c=0
Rk2 (\4\:A1 A1) resistor r=0.1068 c=0
Rk8 (\2\:net114 \4\:net114) resistor r=0.2677 c=0
Rk9 (\4\:net114 \6\:net114) resistor r=0.4787 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.944 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=35.7134 c=0
Rl7 (\1\:B1 \2\:B1) resistor r=164.617 c=0
Rl8 (\2\:B1 \3\:B1) resistor r=30.0021 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=170.387 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl9 (\1\:B0 \2\:B0) resistor r=71.8171 c=0
Rl10 (\2\:B0 \3\:B0) resistor r=156.078 c=0
Rl11 (\2\:B0 \4\:B0) resistor r=5.1011 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=168 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (net114 \2\:net114) resistor r=62 c=0
Ry3 (\3\:net114 \4\:net114) resistor r=62 c=0
Ry4 (\5\:net114 \6\:net114) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx5 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (net126 \3\:A0 \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn1 (net130 \3\:A1 net126 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.175e-14 ps=6.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.15e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\3\:Y \3\:A2 net130 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.785e-14 ps=5.9e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.2e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (\3\:Y \3\:B1 net118 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.785e-14 ps=4.1e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (net118 \3\:B0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
ends AOI32XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:13 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI33X1
// View name: extracted

simulator lang=spectre

subckt AOI33X1 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (\5\:net059 \3\:A0 \7\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=19.248 \
        scb=0.0210891 scc=0.000636466 m=(1)
mp1 (\5\:net059 \1\:A1 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.045e-06 sd=160n sca=13.8333 \
        scb=0.0119033 scc=0.000242673 m=(1)
mp2 (\3\:net059 \1\:A2 \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.605e-14 ps=1.1e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=8.4e-07 sd=160n sca=12.3219 \
        scb=0.00994851 scc=0.000232104 m=(1)
mp5 (\5\:Y \1\:B2 \3\:net059 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.605e-14 ad=6.24e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6e-07 sd=160n sca=12.3642 scb=0.0100002 \
        scc=0.000232183 m=(1)
mp4 (\5\:Y \1\:B1 net059 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.95e-07 sd=160n sca=14.03 \
        scb=0.0122147 scc=0.000246052 m=(1)
mp3 (\1\:Y \1\:B0 net059 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.9e-07 sd=160n sca=20.0914 \
        scb=0.0223631 scc=0.000753507 m=(1)
C1 (A1 VSS) capacitor c=4.84831e-17
C2 (Y VSS) capacitor c=1.03405e-16
C3 (B1 VSS) capacitor c=6.37624e-17
C4 (A0 VSS) capacitor c=3.00918e-17
C5 (B2 VSS) capacitor c=5.73949e-17
C6 (B0 VSS) capacitor c=5.15129e-17
C7 (VDD VSS) capacitor c=9.24562e-17
C8 (A2 VSS) capacitor c=6.42905e-17
C9 (net157 VSS) capacitor c=1.51532e-18
C10 (net141 VSS) capacitor c=6.36837e-18
C11 (net137 VSS) capacitor c=7.6705e-19
C12 (net059 VSS) capacitor c=8.2491e-17
C13 (\1\:B0 VSS) capacitor c=5.12663e-17
C14 (\1\:B1 VSS) capacitor c=6.25956e-17
C15 (\1\:B2 VSS) capacitor c=6.11916e-17
C16 (\1\:A2 VSS) capacitor c=6.56933e-17
C17 (\1\:A1 VSS) capacitor c=6.94339e-17
C18 (\3\:A0 VSS) capacitor c=5.45329e-17
C19 (\3\:B0 VSS) capacitor c=6.16648e-17
C20 (\3\:B1 VSS) capacitor c=6.96217e-17
C21 (\3\:B2 VSS) capacitor c=3.74001e-17
C22 (\3\:A2 VSS) capacitor c=3.81316e-17
C23 (\3\:A1 VSS) capacitor c=6.40795e-17
C24 (\1\:A0 VSS) capacitor c=5.57532e-17
C25 (\2\:B0 VSS) capacitor c=5.7802e-17
C26 (\2\:B1 VSS) capacitor c=6.2457e-17
C27 (\2\:B2 VSS) capacitor c=5.29092e-17
C28 (\2\:A2 VSS) capacitor c=5.27385e-17
C29 (\2\:A1 VSS) capacitor c=5.77971e-17
C30 (\2\:A0 VSS) capacitor c=5.07258e-17
C31 (\1\:Y VSS) capacitor c=2.68815e-17
C32 (\5\:Y VSS) capacitor c=8.25222e-17
C33 (\3\:net059 VSS) capacitor c=8.92485e-17
C34 (\5\:VDD VSS) capacitor c=6.48235e-17
C35 (\5\:net059 VSS) capacitor c=9.08854e-17
C36 (\7\:VDD VSS) capacitor c=3.64727e-17
C37 (\3\:Y VSS) capacitor c=1.86404e-16
C38 (\4\:A0 VSS) capacitor c=4.78916e-17
C39 (\4\:A1 VSS) capacitor c=7.79015e-17
C40 (\4\:A2 VSS) capacitor c=7.4995e-17
C41 (\4\:B2 VSS) capacitor c=2.70989e-17
C42 (\4\:B1 VSS) capacitor c=3.88029e-17
C43 (\4\:B0 VSS) capacitor c=6.54422e-17
C44 (\3\:VDD VSS) capacitor c=7.65905e-17
C45 (\4\:VDD VSS) capacitor c=1.11776e-17
Rk2 (A1 \4\:A1) resistor r=0.1264 c=0
Rk11 (\2\:Y Y) resistor r=0.08352 c=0
Rk12 (Y \4\:Y) resistor r=1.0424 c=0
Rk13 (Y \6\:Y) resistor r=0.4076 c=0
Rk7 (B1 \4\:B1) resistor r=0.08064 c=0
Rk1 (A0 \4\:A0) resistor r=0.03311 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4324 c=0
Rk16 (\5\:VSS VSS) resistor r=0.08739 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2633 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2308 c=0
Rk6 (\4\:B2 B2) resistor r=0.04214 c=0
Rk10 (B0 \4\:B0) resistor r=0.1686 c=0
Rk20 (\4\:VDD VDD) resistor r=0.0372 c=0
Rk19 (\3\:VDD \4\:VDD) resistor r=0.2054 c=0
Rk21 (\3\:VDD \6\:VDD) resistor r=0.2357 c=0
Rk22 (\4\:VDD \8\:VDD) resistor r=0.2805 c=0
Rk3 (A2 \4\:A2) resistor r=0.2167 c=0
Rk8 (\2\:net059 \4\:net059) resistor r=0.4629 c=0
Rk9 (\4\:net059 \6\:net059) resistor r=0.5223 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=152.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=44.9225 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=125.692 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=71.8456 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=153.641 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=151.156 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=43.4636 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=126.923 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=77.6561 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=149.98 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=44.9225 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\5\:Y \6\:Y) resistor r=31 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry1 (net059 \2\:net059) resistor r=31 c=0
Ry2 (\3\:net059 \4\:net059) resistor r=31 c=0
Ry3 (\5\:net059 \6\:net059) resistor r=20.6667 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
mn0 (net149 \1\:A0 \6\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mn1 (net157 \3\:A1 net149 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.51e-14 ps=6.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.95e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\3\:Y \3\:A2 net157 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.72e-14 ps=7.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=7.15e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn5 (\3\:Y \3\:B2 net141 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=4.5e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn4 (net141 \3\:B1 net137 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=2.45e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn3 (net137 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.4e-07 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
ends AOI33X1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:14 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI33X2
// View name: extracted

simulator lang=spectre

subckt AOI33X2 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp3 (\7\:Y B0 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=6.338e-14 ps=1.22e-06 pd=1.105e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.555e-06 sb=1.2e-06 sd=160n sca=12.3656 scb=0.0108222 \
        scc=0.000412413 m=(2)
mp4_1__rcx (\7\:Y \1\:B1 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.338e-14 ps=1.13e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=9.9e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(2)
mp0 (net124 A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.117e-14 ad=8.58e-14 ps=1.145e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.0413 scb=0.02503 \
        scc=0.00108348 m=(2)
mp1 (net124 \1\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.117e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=15.2233 scb=0.013848 \
        scc=0.000431029 m=(2)
mp5_1__rcx (\9\:Y \1\:B2 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=7.75e-07 sd=160n sca=12.4666 \
        scb=0.0108434 scc=0.000412415 m=(2)
mp2 (net124 \3\:A2 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=13.3531 scb=0.0113375 \
        scc=0.000412845 m=(2)
C1 (A1 VSS) capacitor c=2.4193e-17
C2 (B1 VSS) capacitor c=3.18617e-17
C3 (Y VSS) capacitor c=7.05497e-17
C4 (A2 VSS) capacitor c=6.83954e-17
C5 (B2 VSS) capacitor c=7.38366e-17
C6 (B0 VSS) capacitor c=4.59137e-16
C7 (A0 VSS) capacitor c=4.43097e-16
C8 (VDD VSS) capacitor c=1.67163e-16
C9 (11 VSS) capacitor c=2.6935e-18
C10 (12 VSS) capacitor c=6.8412e-18
C11 (13 VSS) capacitor c=2.64226e-18
C12 (14 VSS) capacitor c=1.19232e-17
C13 (15 VSS) capacitor c=7.18522e-18
C14 (16 VSS) capacitor c=4.78439e-18
C15 (17 VSS) capacitor c=7.31257e-18
C16 (18 VSS) capacitor c=3.44348e-18
C17 (net124 VSS) capacitor c=4.91436e-16
C18 (\1\:B2 VSS) capacitor c=1.12102e-16
C19 (\1\:B1 VSS) capacitor c=4.0687e-16
C20 (\1\:A1 VSS) capacitor c=3.86595e-16
C21 (\6\:B0 VSS) capacitor c=4.08944e-17
C22 (\6\:B1 VSS) capacitor c=4.9799e-17
C23 (\6\:B2 VSS) capacitor c=3.0376e-17
C24 (\4\:B2 VSS) capacitor c=3.12555e-17
C25 (\3\:B1 VSS) capacitor c=4.42022e-17
C26 (\3\:B0 VSS) capacitor c=3.6312e-17
C27 (\6\:A0 VSS) capacitor c=3.05001e-17
C28 (\6\:A1 VSS) capacitor c=5.45001e-17
C29 (\1\:A2 VSS) capacitor c=4.74494e-17
C30 (\4\:A2 VSS) capacitor c=3.12455e-17
C31 (\3\:A1 VSS) capacitor c=5.69811e-17
C32 (\1\:A0 VSS) capacitor c=4.9292e-17
C33 (\3\:A2 VSS) capacitor c=1.22086e-16
C34 (\9\:Y VSS) capacitor c=9.54817e-17
C35 (\7\:Y VSS) capacitor c=1.34629e-16
C36 (\9\:VDD VSS) capacitor c=4.75609e-17
C37 (\1\:VDD VSS) capacitor c=7.91028e-17
C38 (\1\:Y VSS) capacitor c=7.44635e-17
C39 (\4\:Y VSS) capacitor c=8.28809e-17
C40 (\2\:A2 VSS) capacitor c=2.44836e-17
C41 (\3\:B2 VSS) capacitor c=2.58196e-17
C42 (\7\:A2 VSS) capacitor c=4.9309e-17
C43 (\7\:B2 VSS) capacitor c=6.00427e-17
C44 (\3\:Y VSS) capacitor c=1.31257e-16
C45 (\4\:VDD VSS) capacitor c=1.25083e-16
Rk2 (\1\:A1 A1) resistor r=0.09952 c=0
Rk9 (B1 \1\:B1) resistor r=0.08385 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.4463 c=0
Rk12 (\3\:Y \5\:Y) resistor r=0.5299 c=0
Rk14 (\6\:Y Y) resistor r=0.02126 c=0
Rk15 (\6\:Y \7\:Y) resistor r=0.1544 c=0
Rk13 (\3\:Y \6\:Y) resistor r=0.4542 c=0
Rk26 (\2\:VSS \3\:VSS) resistor r=0.04327 c=0
Rk27 (\3\:VSS \5\:VSS) resistor r=0.6254 c=0
Rk28 (\3\:VSS \6\:VSS) resistor r=0.1242 c=0
Rk30 (\7\:VSS VSS) resistor r=0.0572 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.4935 c=0
Rk31 (\5\:VSS \9\:VSS) resistor r=0.2623 c=0
Rk32 (\7\:VSS \11\:VSS) resistor r=0.2184 c=0
Rk5 (\7\:A2 A2) resistor r=0.005542 c=0
Rk8 (\7\:B2 B2) resistor r=0.02105 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.7518 c=0
Rk37 (\4\:VDD VDD) resistor r=0.1098 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.02988 c=0
Rk39 (\4\:VDD \10\:VDD) resistor r=0.202 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=29.9442 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=33.3841 c=0
Rl24 (\1\:B1 \6\:B1) resistor r=44.9225 c=0
Rl17 (\1\:B1 \3\:B1) resistor r=33.3841 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=32.7557 c=0
Rl7 (\2\:A2 \4\:A2) resistor r=82.1768 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.6542 c=0
Rl19 (\3\:B2 \1\:B2) resistor r=24.6542 c=0
Rl22 (\3\:B2 \6\:B2) resistor r=82.1768 c=0
Rl20 (\3\:B2 \4\:B2) resistor r=32.7557 c=0
Rl26 (B0 \6\:B0) resistor r=24.7951 c=0
Rl15 (B0 \3\:B0) resistor r=29.5379 c=0
Rl13 (A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (A0 \1\:A0) resistor r=29.8412 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz5 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry2 (\7\:Y \9\:Y) resistor r=62 c=0
Ry11 (\4\:VSS \5\:VSS) resistor r=20.6667 c=0
Ry12 (\4\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry14 (\10\:VDD \9\:VDD) resistor r=62 c=0
Rx3 (\7\:A2 \3\:A2) resistor r=45 c=0
Rx6 (\7\:B2 \1\:B2) resistor r=45 c=0
mn0_1__rcx (11 \1\:A0 \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (11 \3\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=1.56e-14 ps=9.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\4\:Y \4\:A2 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (\4\:Y \1\:A2 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.1e-07 sb=1.865e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (13 \6\:A1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=6.5e-14 \
        ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.15e-07 sb=1.76e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0 (14 \6\:A0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.05e-13 ad=6.5e-14 ps=1.57e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.11e-06 sb=1.465e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (15 \3\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.05e-13 ad=4.29e-14 ps=1.57e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=1.12e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4_1__rcx (15 \3\:B1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.29e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.665e-06 sb=9.1e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_1__rcx (\1\:Y \4\:B2 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.825e-06 sb=7.5e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5 (\1\:Y \6\:B2 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=6.11e-14 \
        ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=5.45e-07 sd=160n sca=10.3222 scb=0.00938145 scc=0.000353946 \
        m=(1)
mn4 (17 \6\:B1 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=2.08e-14 \
        ad=6.11e-14 ps=6.8e-07 pd=9.9e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.65e-07 sd=160n sca=10.3222 scb=0.00938145 scc=0.000353946 \
        m=(1)
mn3 (18 \6\:B0 \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.08e-14 ps=8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
ends AOI33X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:15 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI33X4
// View name: extracted

simulator lang=spectre

subckt AOI33X4 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0_1__rcx (net124 \2\:A0 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4303 scb=0.0198654 \
        scc=0.00125373 m=(4)
mp1_1__rcx (net124 \2\:A1 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.6981 \
        scb=0.0155463 scc=0.00119019 m=(4)
mp2 (net124 \3\:A2 \4\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=16.6869 scb=0.0147126 \
        scc=0.00118865 m=(4)
mp3_1__rcx (\10\:Y B0 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp4_1__rcx (\10\:Y B1 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp5_1__rcx (\10\:Y \1\:B2 net124 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.985e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
C1 (A1 VSS) capacitor c=2.30892e-17
C2 (B1 VSS) capacitor c=8.30224e-16
C3 (Y VSS) capacitor c=8.67823e-17
C4 (B2 VSS) capacitor c=2.85609e-17
C5 (B0 VSS) capacitor c=8.383e-16
C6 (A0 VSS) capacitor c=1.4332e-16
C7 (VDD VSS) capacitor c=2.24541e-16
C8 (11 VSS) capacitor c=1.36221e-18
C9 (12 VSS) capacitor c=5.31602e-18
C10 (13 VSS) capacitor c=2.24904e-18
C11 (14 VSS) capacitor c=4.21276e-18
C12 (15 VSS) capacitor c=4.07685e-18
C13 (16 VSS) capacitor c=4.08884e-18
C14 (17 VSS) capacitor c=6.90979e-18
C15 (18 VSS) capacitor c=4.75885e-18
C16 (19 VSS) capacitor c=5.88913e-18
C17 (20 VSS) capacitor c=6.93724e-18
C18 (21 VSS) capacitor c=6.57774e-18
C19 (22 VSS) capacitor c=6.94548e-18
C20 (23 VSS) capacitor c=4.22752e-18
C21 (24 VSS) capacitor c=2.24904e-18
C22 (25 VSS) capacitor c=5.90293e-18
C23 (26 VSS) capacitor c=1.36221e-18
C24 (net124 VSS) capacitor c=9.96178e-16
C25 (\1\:B2 VSS) capacitor c=4.60492e-16
C26 (\12\:B0 VSS) capacitor c=5.00748e-17
C27 (\12\:B1 VSS) capacitor c=7.18668e-17
C28 (\12\:B2 VSS) capacitor c=2.79434e-17
C29 (\10\:B2 VSS) capacitor c=5.65528e-17
C30 (\9\:B1 VSS) capacitor c=7.11445e-17
C31 (\4\:B0 VSS) capacitor c=5.23511e-17
C32 (\6\:B0 VSS) capacitor c=2.69448e-17
C33 (\6\:B1 VSS) capacitor c=4.38265e-17
C34 (\6\:B2 VSS) capacitor c=2.7506e-17
C35 (\4\:B2 VSS) capacitor c=4.0815e-17
C36 (\3\:B1 VSS) capacitor c=4.08911e-17
C37 (\3\:B0 VSS) capacitor c=3.72782e-17
C38 (\13\:A0 VSS) capacitor c=3.88589e-17
C39 (\13\:A1 VSS) capacitor c=4.03927e-17
C40 (\12\:A2 VSS) capacitor c=2.5655e-17
C41 (\10\:A2 VSS) capacitor c=4.65951e-17
C42 (\9\:A1 VSS) capacitor c=6.29216e-17
C43 (\9\:A0 VSS) capacitor c=3.41201e-17
C44 (\7\:A0 VSS) capacitor c=4.89975e-17
C45 (\6\:A1 VSS) capacitor c=7.21389e-17
C46 (\1\:A2 VSS) capacitor c=5.24522e-17
C47 (\5\:A2 VSS) capacitor c=2.35643e-17
C48 (\1\:A1 VSS) capacitor c=7.10513e-17
C49 (\1\:A0 VSS) capacitor c=5.00983e-17
C50 (\3\:A2 VSS) capacitor c=5.17161e-16
C51 (\2\:A1 VSS) capacitor c=8.09452e-16
C52 (\2\:A0 VSS) capacitor c=7.0128e-16
C53 (\10\:Y VSS) capacitor c=5.05965e-16
C54 (\1\:VDD VSS) capacitor c=1.29151e-16
C55 (\1\:Y VSS) capacitor c=1.27656e-16
C56 (\3\:Y VSS) capacitor c=1.64155e-16
C57 (\6\:Y VSS) capacitor c=1.47371e-16
C58 (\8\:Y VSS) capacitor c=1.17464e-16
C59 (\2\:A2 VSS) capacitor c=3.74763e-17
C60 (\9\:A2 VSS) capacitor c=3.37687e-17
C61 (\3\:B2 VSS) capacitor c=2.20978e-17
C62 (\9\:B2 VSS) capacitor c=4.53673e-17
C63 (\5\:Y VSS) capacitor c=1.23161e-16
C64 (\4\:VDD VSS) capacitor c=3.57908e-16
Rk6 (\2\:A1 A1) resistor r=0.01617 c=0
Rk22 (Y \10\:Y) resistor r=0.3024 c=0
Rk17 (\2\:Y \4\:Y) resistor r=0.8483 c=0
Rk21 (\5\:Y Y) resistor r=0.3287 c=0
Rk18 (\4\:Y \5\:Y) resistor r=0.5468 c=0
Rk19 (\5\:Y \7\:Y) resistor r=0.4541 c=0
Rk20 (\7\:Y \9\:Y) resistor r=0.7852 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.04331 c=0
Rk50 (\3\:VSS \5\:VSS) resistor r=0.5305 c=0
Rk51 (\3\:VSS \6\:VSS) resistor r=0.2195 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.4478 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.5946 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.1568 c=0
Rk56 (\10\:VSS VSS) resistor r=0.1475 c=0
Rk55 (\9\:VSS \10\:VSS) resistor r=0.4036 c=0
Rk57 (\5\:VSS \12\:VSS) resistor r=0.2426 c=0
Rk58 (\7\:VSS \14\:VSS) resistor r=0.04331 c=0
Rk59 (\8\:VSS \16\:VSS) resistor r=0.04331 c=0
Rk60 (\10\:VSS \18\:VSS) resistor r=0.1995 c=0
Rk2 (\3\:A2 A2) resistor r=0.009678 c=0
Rk12 (\1\:B2 B2) resistor r=0.02372 c=0
Rk7 (A0 \2\:A0) resistor r=0.01801 c=0
Rk61 (\2\:VDD \3\:VDD) resistor r=0.7524 c=0
Rk69 (\4\:VDD VDD) resistor r=0.1927 c=0
Rk62 (\3\:VDD \4\:VDD) resistor r=0.5164 c=0
Rl26 (\2\:A1 \13\:A1) resistor r=52.7257 c=0
Rl18 (\2\:A1 \9\:A1) resistor r=87.6374 c=0
Rl11 (\2\:A1 \6\:A1) resistor r=56.461 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=92.1028 c=0
Rl54 (B1 \12\:B1) resistor r=102.615 c=0
Rl47 (B1 \9\:B1) resistor r=52.6149 c=0
Rl40 (B1 \6\:B1) resistor r=53.0211 c=0
Rl33 (B1 \3\:B1) resistor r=44.9225 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=73.0548 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=59.5933 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=71.9912 c=0
Rl23 (\9\:A2 \12\:A2) resistor r=47.4088 c=0
Rl21 (\9\:A2 \10\:A2) resistor r=94.2087 c=0
Rl20 (\9\:A2 \3\:A2) resistor r=69.6756 c=0
Rl35 (\3\:B2 \1\:B2) resistor r=70.1824 c=0
Rl38 (\3\:B2 \6\:B2) resistor r=35.772 c=0
Rl36 (\3\:B2 \4\:B2) resistor r=100.426 c=0
Rl49 (\9\:B2 \1\:B2) resistor r=6.7128 c=0
Rl52 (\9\:B2 \12\:B2) resistor r=129.305 c=0
Rl50 (\9\:B2 \10\:B2) resistor r=106.228 c=0
Rl56 (B0 \12\:B0) resistor r=24.7951 c=0
Rl41 (B0 \4\:B0) resistor r=96.595 c=0
Rl42 (B0 \6\:B0) resistor r=21.8676 c=0
Rl31 (B0 \3\:B0) resistor r=24.2328 c=0
Rl29 (\2\:A0 \13\:A0) resistor r=23.7402 c=0
Rl16 (\2\:A0 \9\:A0) resistor r=24.2328 c=0
Rl14 (\2\:A0 \7\:A0) resistor r=98.3529 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.2349 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz9 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Ry22 (\4\:VSS \5\:VSS) resistor r=20.6667 c=0
Ry23 (\4\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry24 (\4\:VSS \9\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (11 \1\:A0 \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (11 \1\:A1 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=1.56e-14 ps=9.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\8\:Y \5\:A2 12 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (\8\:Y \1\:A2 13 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_2__rcx (13 \6\:A1 14 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (14 \7\:A0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (15 \9\:A0 \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.73e-14 ps=1.35e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (15 \9\:A1 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=2.73e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (\6\:Y \10\:A2 16 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\6\:Y \12\:A2 17 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (17 \13\:A1 18 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (18 \13\:A0 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_1__rcx (19 \3\:B0 \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4_1__rcx (19 \3\:B1 20 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_1__rcx (\3\:Y \4\:B2 20 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.885e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_2__rcx (\3\:Y \6\:B2 21 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=4.16e-14 ps=8.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (21 \6\:B1 22 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.77e-14 ps=8.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.49e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (22 \6\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.16e-14 ps=1.35e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (23 \4\:B0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.02e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_3__rcx (23 \9\:B1 24 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=2.99e-14 ps=6.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_3__rcx (\1\:Y \10\:B2 24 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (\1\:Y \12\:B2 25 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4 (25 \12\:B1 26 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=6.76e-14 ps=6.4e-07 pd=1.04e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (26 \12\:B0 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
ends AOI33X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:16 2013 )
// Library name: gsclib045_hvt
// Cell name: AOI33XL
// View name: extracted

simulator lang=spectre

subckt AOI33XL A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (net124 \3\:A0 \4\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=3.655e-14 ps=1.33e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.165e-06 sd=160n sca=30.1692 \
        scb=0.0324471 scc=0.00278498 m=(1)
mp1 (net124 \1\:A1 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.655e-14 ps=1.41e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=9.5e-07 sd=160n sca=14.9994 \
        scb=0.0139145 scc=0.000209273 m=(1)
mp2 (\3\:net124 \1\:A2 \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.55e-07 sd=160n sca=12.5773 \
        scb=0.00960893 scc=0.000140232 m=(1)
mp5 (\1\:Y \1\:B2 \3\:net124 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.5e-07 sd=160n sca=12.38 \
        scb=0.00928483 scc=0.000139001 m=(1)
mp4 (\1\:Y \1\:B1 \5\:net124 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=14.1566 \
        scb=0.012431 scc=0.000173041 m=(1)
mp3 (\6\:Y \1\:B0 \5\:net124 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=23.3203 \
        scb=0.0262833 scc=0.00133399 m=(1)
C1 (A1 VSS) capacitor c=2.44331e-17
C2 (Y VSS) capacitor c=1.52511e-17
C3 (B1 VSS) capacitor c=6.50267e-17
C4 (A0 VSS) capacitor c=2.32528e-17
C5 (VDD VSS) capacitor c=1.46605e-16
C6 (B2 VSS) capacitor c=2.38322e-17
C7 (A2 VSS) capacitor c=3.24808e-17
C8 (net149 VSS) capacitor c=8.56837e-22
C9 (net141 VSS) capacitor c=4.74221e-18
C10 (net137 VSS) capacitor c=2.34552e-18
C11 (net124 VSS) capacitor c=4.4457e-17
C12 (\1\:B0 VSS) capacitor c=3.94003e-17
C13 (\1\:B1 VSS) capacitor c=6.66627e-17
C14 (\1\:B2 VSS) capacitor c=3.36522e-17
C15 (\1\:A2 VSS) capacitor c=7.07933e-17
C16 (\1\:A1 VSS) capacitor c=5.54484e-17
C17 (\3\:A0 VSS) capacitor c=2.34929e-17
C18 (\3\:B0 VSS) capacitor c=6.07505e-17
C19 (\3\:B1 VSS) capacitor c=4.69085e-17
C20 (\3\:B2 VSS) capacitor c=6.97696e-17
C21 (\3\:A2 VSS) capacitor c=3.78072e-17
C22 (\3\:A1 VSS) capacitor c=5.95908e-17
C23 (\1\:A0 VSS) capacitor c=6.75054e-17
C24 (\2\:B0 VSS) capacitor c=6.64075e-17
C25 (\2\:B1 VSS) capacitor c=7.88943e-17
C26 (\2\:B2 VSS) capacitor c=6.06366e-17
C27 (\2\:A2 VSS) capacitor c=6.34458e-17
C28 (\2\:A1 VSS) capacitor c=6.77665e-17
C29 (\2\:A0 VSS) capacitor c=6.21201e-17
C30 (\5\:net124 VSS) capacitor c=6.94605e-17
C31 (\1\:Y VSS) capacitor c=6.08877e-17
C32 (\3\:net124 VSS) capacitor c=6.31978e-17
C33 (\6\:VDD VSS) capacitor c=1.16442e-17
C34 (\4\:VDD VSS) capacitor c=4.6552e-18
C35 (\4\:Y VSS) capacitor c=1.28763e-16
C36 (\4\:A0 VSS) capacitor c=1.95604e-17
C37 (\4\:A1 VSS) capacitor c=2.75884e-17
C38 (\4\:A2 VSS) capacitor c=2.9357e-17
C39 (\6\:B2 VSS) capacitor c=2.60102e-17
C40 (\4\:B1 VSS) capacitor c=6.57859e-17
C41 (\4\:B0 VSS) capacitor c=7.55684e-17
C42 (\5\:B0 VSS) capacitor c=7.17587e-17
C43 (\3\:Y VSS) capacitor c=1.18168e-16
C44 (\3\:VDD VSS) capacitor c=5.94233e-17
Rk2 (\4\:A1 A1) resistor r=0.04585 c=0
Rk13 (\2\:Y \3\:Y) resistor r=0.3216 c=0
Rk14 (\3\:Y \5\:Y) resistor r=0.9777 c=0
Rk16 (\7\:Y Y) resistor r=0.002814 c=0
Rk15 (\3\:Y \7\:Y) resistor r=0.07134 c=0
Rk7 (B1 \4\:B1) resistor r=0.1592 c=0
Rk1 (\4\:A0 A0) resistor r=0.04463 c=0
Rk18 (\3\:VSS VSS) resistor r=0.0171 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.213 c=0
Rk19 (\3\:VSS \5\:VSS) resistor r=0.283 c=0
Rk20 (\5\:VSS \7\:VSS) resistor r=0.3742 c=0
Rk22 (\3\:VDD VDD) resistor r=0.1704 c=0
Rk23 (VDD \5\:VDD) resistor r=0.07947 c=0
Rk24 (\3\:VDD \7\:VDD) resistor r=0.07346 c=0
Rk4 (\4\:B2 B2) resistor r=0.005012 c=0
Rk6 (\4\:B2 \6\:B2) resistor r=0.01641 c=0
Rk5 (\5\:B2 \6\:B2) resistor r=0.005012 c=0
Rk10 (B0 \4\:B0) resistor r=0.001228 c=0
Rk12 (\4\:B0 \5\:B0) resistor r=0.1041 c=0
Rk11 (\5\:B0 \6\:B0) resistor r=0.001293 c=0
Rk3 (A2 \4\:A2) resistor r=0.0404 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.2726 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.3667 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=106.461 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=141.076 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=204.944 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=35.7134 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.3736 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=223.077 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=33.3841 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=214.153 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=102.978 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=147.253 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=175.692 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=71.8456 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry5 (\6\:Y \7\:Y) resistor r=62 c=0
Ry7 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (net124 \2\:net124) resistor r=62 c=0
Ry2 (\3\:net124 \4\:net124) resistor r=62 c=0
Ry3 (\5\:net124 \6\:net124) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B2 \5\:B2) resistor r=45 c=0
Rx6 (\2\:B0 \6\:B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
mn0 (net149 \1\:A0 \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.378e-14 ps=5.7e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.025e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn1 (net153 \3\:A1 net149 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.378e-14 ad=2.175e-14 ps=4.8e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=8.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn2 (\4\:Y \3\:A2 net153 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=2.32e-14 ps=5.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=6.9e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn5 (\4\:Y \3\:B2 net141 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=4.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn4 (net137 \3\:B1 net141 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.43e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2.8e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (\6\:VSS \3\:B0 net137 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=4.025e-14 ps=4.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=1.7e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
ends AOI33XL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:17 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX12
// View name: extracted

simulator lang=spectre

subckt BUFX12 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.378e-14 ad=7.52e-14 ps=1.256e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99064e-06 sd=160n sca=28.0481 \
        scb=0.031636 scc=0.00223037 m=(10)
C1 (VDD VSS) capacitor c=6.97543e-16
C2 (A VSS) capacitor c=4.04101e-17
C3 (Y VSS) capacitor c=1.56108e-17
C4 (n0 VSS) capacitor c=9.05357e-16
C5 (\1\:A VSS) capacitor c=2.43946e-16
C6 (\31\:n0 VSS) capacitor c=1.6768e-16
C7 (\1\:Y VSS) capacitor c=5.38197e-16
C8 (\1\:VDD VSS) capacitor c=2.25488e-17
C9 (\15\:Y VSS) capacitor c=6.38119e-16
C10 (\10\:A VSS) capacitor c=4.06222e-17
C11 (\34\:n0 VSS) capacitor c=4.23734e-17
C12 (\42\:n0 VSS) capacitor c=1.64777e-16
Rk46 (\2\:VSS VSS) resistor r=0.06759 c=0
Rk31 (\2\:VDD VDD) resistor r=0.06759 c=0
Rk19 (A \10\:A) resistor r=0.09983 c=0
Rk5 (\1\:Y Y) resistor r=0.1468 c=0
Rk10 (Y \15\:Y) resistor r=0.1717 c=0
Rk22 (\34\:n0 n0) resistor r=0.3289 c=0
Rk21 (\31\:n0 \34\:n0) resistor r=0.2235 c=0
Rk28 (\34\:n0 \42\:n0) resistor r=0.08258 c=0
Rz9 (VDD \1\:VDD) resistor r=6.25 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=25 c=0
Ry16 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Rx1 (\10\:A \1\:A) resistor r=45 c=0
mn1_1__rcx (VSS n0 \15\:Y VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.868e-14 ps=9.4e-07 pd=9.36e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99113e-06 sd=160n sca=9.61806 \
        scb=0.00827687 scc=0.000298696 m=(10)
mn0_1__rcx (VSS \1\:A \42\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.327e-14 ps=8.2667e-07 pd=8.7333e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(3)
mp0_1__rcx (\31\:n0 \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.507e-14 ad=5.98e-14 ps=1.15333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=12.5423 scb=0.0105189 \
        scc=0.000333341 m=(3)
ends BUFX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:19 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX16
// View name: extracted

simulator lang=spectre

subckt BUFX16 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.033e-14 ad=7.12e-14 ps=1.20714e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (Y VSS) capacitor c=1.66686e-17
C2 (VDD VSS) capacitor c=9.26302e-16
C3 (A VSS) capacitor c=3.66861e-17
C4 (n0 VSS) capacitor c=1.25991e-15
C5 (\1\:A VSS) capacitor c=2.4184e-16
C6 (\43\:n0 VSS) capacitor c=2.27689e-16
C7 (\1\:Y VSS) capacitor c=8.64062e-16
C8 (\9\:Y VSS) capacitor c=7.48896e-16
C9 (\46\:n0 VSS) capacitor c=2.68931e-17
C10 (\56\:n0 VSS) capacitor c=1.71644e-16
C11 (\13\:A VSS) capacitor c=6.76903e-17
C12 (\14\:A VSS) capacitor c=5.9438e-17
Rk7 (\1\:Y Y) resistor r=0.08238 c=0
Rk8 (Y \9\:Y) resistor r=0.0911 c=0
Rk40 (A \13\:A) resistor r=0.1621 c=0
Rk41 (\13\:A \14\:A) resistor r=0.138 c=0
Rk29 (\46\:n0 n0) resistor r=0.203 c=0
Rk28 (\43\:n0 \46\:n0) resistor r=0.09951 c=0
Rk37 (\46\:n0 \56\:n0) resistor r=0.1042 c=0
Rx8 (\13\:A \1\:A) resistor r=45 c=0
Rx9 (\14\:A \1\:A) resistor r=45 c=0
mn1_1__rcx (VSS n0 \9\:Y VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=6.251e-14 ps=9.1e-07 pd=1.43643e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
mn0_1__rcx (VSS \1\:A \56\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.558e-14 ps=8.4e-07 pd=1.3275e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mp0_1__rcx (\43\:n0 \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.182e-14 ad=6.24e-14 ps=1.1175e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
ends BUFX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:20 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX2
// View name: extracted

simulator lang=spectre

subckt BUFX2 A VDD VSS Y
mp1 (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.325e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.40064e-07 sd=160n sca=36.3413 scb=0.0370255 \
        scc=0.00367875 m=(2)
C1 (VDD VSS) capacitor c=1.60063e-16
C2 (A VSS) capacitor c=2.06836e-17
C3 (Y VSS) capacitor c=1.4482e-17
C4 (n0 VSS) capacitor c=1.681e-16
C5 (\1\:A VSS) capacitor c=4.49998e-17
C6 (\3\:A VSS) capacitor c=4.16705e-17
C7 (\2\:A VSS) capacitor c=4.68219e-17
C8 (\7\:n0 VSS) capacitor c=6.00385e-17
C9 (\1\:Y VSS) capacitor c=8.11096e-17
C10 (\10\:n0 VSS) capacitor c=4.58216e-17
C11 (\4\:Y VSS) capacitor c=6.31466e-17
C12 (\3\:Y VSS) capacitor c=3.64325e-17
C13 (\9\:n0 VSS) capacitor c=1.13401e-16
C14 (\4\:A VSS) capacitor c=6.32956e-17
Rk6 (A \4\:A) resistor r=0.03418 c=0
Rk2 (\3\:Y Y) resistor r=0.02506 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.2469 c=0
Rk3 (\3\:Y \5\:Y) resistor r=0.2478 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.5054 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.3851 c=0
Rl6 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl7 (\2\:A \3\:A) resistor r=100.692 c=0
Rz1 (\5\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\9\:n0 n0) resistor r=45 c=0
mn1 (VSS n0 \4\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.555e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.41635e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(2)
mn0 (VSS \3\:A \10\:n0 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.47e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp0 (\7\:n0 \1\:A VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=16.9419 \
        scb=0.0158681 scc=0.000320204 m=(1)
ends BUFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:21 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX20
// View name: extracted

simulator lang=spectre

subckt BUFX20 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.335e-14 ad=7.306e-14 ps=1.24e-06 pd=1.23765e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=39.4883 scb=0.0368308 \
        scc=0.00409097 m=(17)
C1 (VDD VSS) capacitor c=1.61539e-16
C2 (A VSS) capacitor c=4.25709e-17
C3 (Y VSS) capacitor c=1.50751e-17
C4 (n0 VSS) capacitor c=1.65938e-15
C5 (\1\:A VSS) capacitor c=3.79179e-16
C6 (\52\:n0 VSS) capacitor c=2.5437e-16
C7 (\1\:VDD VSS) capacitor c=9.39772e-16
C8 (\1\:Y VSS) capacitor c=1.11865e-15
C9 (\11\:Y VSS) capacitor c=1.11365e-15
C10 (\56\:n0 VSS) capacitor c=2.00956e-17
C11 (\69\:n0 VSS) capacitor c=2.32805e-16
Rk89 (\1\:VSS VSS) resistor r=0.1026 c=0
Rk76 (\1\:VDD VDD) resistor r=0.1026 c=0
Rk35 (A \1\:A) resistor r=0.1211 c=0
Rk9 (\1\:Y Y) resistor r=0.09454 c=0
Rk10 (Y \11\:Y) resistor r=0.0734 c=0
Rk40 (\56\:n0 n0) resistor r=0.1469 c=0
Rk39 (\52\:n0 \56\:n0) resistor r=0.2067 c=0
Rk50 (\56\:n0 \69\:n0) resistor r=0.1315 c=0
mn1_1__rcx (\1\:VSS n0 \11\:Y VSS) g45n1hvt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.864e-14 ps=9.2765e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
mn0_1__rcx (\1\:VSS \1\:A \69\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.056e-14 ad=4.25e-14 ps=8.32e-07 pd=8.58e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(5)
mp0_1__rcx (\52\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.38e-14 ad=6.084e-14 ps=1.128e-06 pd=1.092e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(5)
ends BUFX20
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:22 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX3
// View name: extracted

simulator lang=spectre

subckt BUFX3 A VDD VSS Y
mp0 (\11\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=16.7198 \
        scb=0.0160191 scc=0.000448714 m=(1)
mp1 (Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.98e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.8768 scb=0.0296503 \
        scc=0.00178994 m=(3)
C1 (Y VSS) capacitor c=3.28319e-16
C2 (A VSS) capacitor c=2.74963e-17
C3 (VDD VSS) capacitor c=9.06324e-17
C4 (n0 VSS) capacitor c=1.85921e-16
C5 (\1\:A VSS) capacitor c=4.73835e-17
C6 (\3\:A VSS) capacitor c=3.77496e-17
C7 (\2\:A VSS) capacitor c=4.34867e-17
C8 (\7\:n0 VSS) capacitor c=3.84965e-17
C9 (\11\:n0 VSS) capacitor c=7.82295e-17
C10 (\1\:VDD VSS) capacitor c=1.94936e-16
C11 (\14\:n0 VSS) capacitor c=6.83747e-17
C12 (\4\:A VSS) capacitor c=6.37282e-17
C13 (\13\:n0 VSS) capacitor c=1.12712e-16
Rk16 (\1\:VSS VSS) resistor r=0.1023 c=0
Rk7 (\4\:A A) resistor r=0.02444 c=0
Rk12 (\1\:VDD VDD) resistor r=0.1023 c=0
Rk8 (\12\:n0 \13\:n0) resistor r=0.5178 c=0
Rk9 (\13\:n0 \15\:n0) resistor r=0.4356 c=0
Rl10 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl11 (\2\:A \3\:A) resistor r=55.0021 c=0
Rl6 (n0 \7\:n0) resistor r=3.8801 c=0
Rz3 (\15\:n0 \14\:n0) resistor r=37.5 c=0
Ry3 (\12\:n0 \11\:n0) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\13\:n0 \7\:n0) resistor r=45 c=0
mn0 (\1\:VSS \3\:A \14\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn1 (\1\:VSS n0 Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.987e-14 \
        ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(3)
ends BUFX3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:23 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX4
// View name: extracted

simulator lang=spectre

subckt BUFX4 A VDD VSS Y
mp0 (\14\:n0 \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=20.4961 \
        scb=0.0204164 scc=0.00119548 m=(1)
mp1 (\1\:Y n0 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.337e-14 \
        ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.75e-07 sd=160n sca=29.498 scb=0.0332632 \
        scc=0.00250913 m=(4)
C1 (Y VSS) capacitor c=2.49766e-17
C2 (A VSS) capacitor c=3.07099e-17
C3 (VDD VSS) capacitor c=3.03618e-16
C4 (n0 VSS) capacitor c=2.43364e-16
C5 (\1\:A VSS) capacitor c=4.25632e-17
C6 (\3\:A VSS) capacitor c=4.83298e-17
C7 (\2\:A VSS) capacitor c=4.04491e-17
C8 (\8\:n0 VSS) capacitor c=3.80955e-17
C9 (\14\:n0 VSS) capacitor c=8.79633e-17
C10 (\1\:Y VSS) capacitor c=3.66161e-16
C11 (\17\:n0 VSS) capacitor c=5.70209e-17
C12 (\4\:A VSS) capacitor c=6.13338e-17
C13 (\16\:n0 VSS) capacitor c=9.48239e-17
Rk3 (\1\:Y Y) resistor r=0.1185 c=0
Rk7 (\4\:A A) resistor r=0.01672 c=0
Rk8 (\15\:n0 \16\:n0) resistor r=0.5815 c=0
Rk9 (\16\:n0 \18\:n0) resistor r=0.3907 c=0
Rl13 (\1\:A \2\:A) resistor r=55.0021 c=0
Rl14 (\2\:A \3\:A) resistor r=105.002 c=0
Rl7 (n0 \8\:n0) resistor r=3.8088 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=37.5 c=0
Ry3 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\16\:n0 \8\:n0) resistor r=45 c=0
mn0 (VSS \3\:A \17\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (VSS n0 \1\:Y VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.75e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
ends BUFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:24 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX6
// View name: extracted

simulator lang=spectre

subckt BUFX6 A VDD VSS Y
mp1 (Y n0 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=7.424e-14 \
        ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.2934e-06 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(5)
C1 (VDD VSS) capacitor c=6.51276e-17
C2 (A VSS) capacitor c=3.54023e-17
C3 (Y VSS) capacitor c=4.7327e-16
C4 (n0 VSS) capacitor c=3.00269e-16
C5 (\1\:A VSS) capacitor c=1.55664e-16
C6 (\6\:A VSS) capacitor c=1.06276e-17
C7 (\1\:VDD VSS) capacitor c=3.6274e-16
C8 (\17\:n0 VSS) capacitor c=7.78215e-17
C9 (\21\:n0 VSS) capacitor c=5.79466e-17
C10 (\19\:n0 VSS) capacitor c=4.30942e-17
C11 (\20\:n0 VSS) capacitor c=3.38048e-17
C12 (\8\:A VSS) capacitor c=2.90062e-17
Rk28 (\1\:VSS VSS) resistor r=0.1024 c=0
Rk20 (\1\:VDD VDD) resistor r=0.1024 c=0
Rk13 (\8\:A \9\:A) resistor r=0.006005 c=0
Rk14 (\10\:A A) resistor r=0.006353 c=0
Rk15 (\9\:A \10\:A) resistor r=0.03706 c=0
Rk10 (\18\:n0 \19\:n0) resistor r=0.2612 c=0
Rk11 (\19\:n0 \20\:n0) resistor r=0.1652 c=0
Rk12 (\19\:n0 \22\:n0) resistor r=0.2473 c=0
Rl20 (\1\:A \6\:A) resistor r=4.8851 c=0
Rl8 (n0 \9\:n0) resistor r=3.8088 c=0
Rz4 (\22\:n0 \21\:n0) resistor r=37.5 c=0
Ry4 (\18\:n0 \17\:n0) resistor r=20.6667 c=0
Rx2 (\8\:A \6\:A) resistor r=45 c=0
Rx1 (\20\:n0 \9\:n0) resistor r=45 c=0
mn1 (\1\:VSS n0 Y VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=4.9e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.29742e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn0 (\1\:VSS \1\:A \21\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.15e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mp0 (\17\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=32.0467 \
        scb=0.0213026 scc=0.00336306 m=(2)
ends BUFX6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:25 2013 )
// Library name: gsclib045_hvt
// Cell name: BUFX8
// View name: extracted

simulator lang=spectre

subckt BUFX8 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72438e-06 sd=160n sca=25.5327 \
        scb=0.0229112 scc=0.00209852 m=(7)
C1 (VDD VSS) capacitor c=7.91191e-17
C2 (Y VSS) capacitor c=1.72777e-17
C3 (n0 VSS) capacitor c=6.71249e-16
C4 (\1\:A VSS) capacitor c=1.55357e-16
C5 (\6\:A VSS) capacitor c=1.74337e-17
C6 (\1\:VDD VSS) capacitor c=4.26537e-16
C7 (\22\:n0 VSS) capacitor c=7.77746e-17
C8 (\1\:Y VSS) capacitor c=4.08713e-16
C9 (\28\:n0 VSS) capacitor c=2.17215e-17
C10 (\6\:Y VSS) capacitor c=4.30288e-16
C11 (\24\:n0 VSS) capacitor c=4.16116e-17
C12 (\8\:A VSS) capacitor c=7.61977e-17
Rk36 (\1\:VSS VSS) resistor r=0.1802 c=0
Rk26 (\1\:VDD VDD) resistor r=0.1802 c=0
Rk20 (A \8\:A) resistor r=0.01092 c=0
Rk4 (\1\:Y Y) resistor r=0.1156 c=0
Rk5 (Y \6\:Y) resistor r=0.09208 c=0
Rk16 (\24\:n0 n0) resistor r=0.1704 c=0
Rk15 (\23\:n0 \24\:n0) resistor r=0.2673 c=0
Rk19 (\24\:n0 \29\:n0) resistor r=0.164 c=0
Rl23 (\1\:A \6\:A) resistor r=10.1271 c=0
Rz5 (\29\:n0 \28\:n0) resistor r=75 c=0
Ry5 (\23\:n0 \22\:n0) resistor r=20.6667 c=0
Rx4 (\8\:A \6\:A) resistor r=45 c=0
mn1_1__rcx (\1\:VSS n0 \6\:Y VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.69e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72661e-06 sd=160n sca=14.382 \
        scb=0.0140935 scc=0.0010585 m=(7)
mn0_1__rcx (\1\:VSS \1\:A \28\:n0 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.075e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mp0 (\22\:n0 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(2)
ends BUFX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:26 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX1
// View name: extracted

simulator lang=spectre

subckt TBUFX1 A OE VDD VSS Y
mp4 (\4\:pon \3\:OE \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=6.1e-07 sd=160n sca=20.0544 \
        scb=0.0221539 scc=0.000755314 m=(1)
mp3 (\4\:pon \1\:A \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=4.05e-07 sd=160n sca=13.5021 \
        scb=0.0113243 scc=0.000155139 m=(1)
mp0 (\6\:OEb \4\:OE \7\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.4e-07 sd=160n sca=11.3955 \
        scb=0.00869667 scc=0.000138257 m=(1)
mp2 (\5\:non OEb net127 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=40.6729 \
        scb=0.0277136 scc=0.00519699 m=(1)
mp1 (net127 \4\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.652e-14 ad=1.29e-14 ps=1.45e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.3e-07 sd=160n sca=41.2802 \
        scb=0.0282849 scc=0.00519823 m=(1)
C1 (OE VSS) capacitor c=3.19083e-17
C2 (Y VSS) capacitor c=2.90149e-17
C3 (VDD VSS) capacitor c=1.58063e-16
C4 (A VSS) capacitor c=1.80935e-16
C5 (pon VSS) capacitor c=3.17892e-17
C6 (OEb VSS) capacitor c=6.27973e-17
C7 (non VSS) capacitor c=4.07077e-17
C8 (\4\:A VSS) capacitor c=7.88736e-17
C9 (\4\:OE VSS) capacitor c=4.71427e-17
C10 (\1\:A VSS) capacitor c=3.82211e-17
C11 (\3\:OE VSS) capacitor c=3.72557e-17
C12 (\5\:A VSS) capacitor c=5.47959e-17
C13 (\3\:OEb VSS) capacitor c=3.03392e-17
C14 (\7\:OE VSS) capacitor c=4.03986e-17
C15 (\3\:A VSS) capacitor c=5.96017e-17
C16 (\1\:OE VSS) capacitor c=3.94766e-17
C17 (\2\:pon VSS) capacitor c=2.31867e-17
C18 (\2\:non VSS) capacitor c=3.77232e-17
C19 (\6\:A VSS) capacitor c=2.56851e-17
C20 (\2\:OEb VSS) capacitor c=3.93687e-17
C21 (\6\:OE VSS) capacitor c=1.64668e-17
C22 (\2\:A VSS) capacitor c=5.57983e-17
C23 (\2\:OE VSS) capacitor c=4.13914e-17
C24 (\3\:Y VSS) capacitor c=8.17094e-17
C25 (\1\:VDD VSS) capacitor c=1.10928e-16
C26 (\5\:non VSS) capacitor c=5.16376e-17
C27 (\6\:OEb VSS) capacitor c=8.13831e-17
C28 (\7\:VDD VSS) capacitor c=1.94662e-17
C29 (\4\:pon VSS) capacitor c=2.25349e-16
C30 (\9\:VDD VSS) capacitor c=3.40791e-17
C31 (\1\:Y VSS) capacitor c=2.532e-17
C32 (\7\:non VSS) capacitor c=3.71587e-17
C33 (\8\:OEb VSS) capacitor c=3.74256e-17
C34 (\6\:pon VSS) capacitor c=6.02899e-17
C35 (\5\:OE VSS) capacitor c=2.36132e-17
C36 (\8\:OE VSS) capacitor c=3.31319e-17
C37 (\9\:OE VSS) capacitor c=3.59562e-17
C38 (\10\:OE VSS) capacitor c=3.35569e-17
C39 (\4\:OEb VSS) capacitor c=2.95043e-17
C40 (\5\:OEb VSS) capacitor c=7.42675e-17
C41 (\7\:A VSS) capacitor c=3.57166e-17
C42 (\8\:A VSS) capacitor c=1.33564e-16
C43 (\3\:non VSS) capacitor c=3.17615e-17
C44 (\4\:non VSS) capacitor c=4.0434e-17
C45 (\3\:pon VSS) capacitor c=1.88162e-16
C46 (\4\:VDD VSS) capacitor c=4.15517e-17
C47 (\5\:VDD VSS) capacitor c=1.77685e-17
C48 (\6\:VDD VSS) capacitor c=7.52525e-18
Rk3 (\9\:OE OE) resistor r=0.09855 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.09991 c=0
Rk2 (\9\:OE \10\:OE) resistor r=0.1315 c=0
Rk14 (Y \2\:Y) resistor r=0.06799 c=0
Rk15 (Y \4\:Y) resistor r=0.4085 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.7449 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.2046 c=0
Rk19 (\6\:VDD VDD) resistor r=0.01962 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.2244 c=0
Rk20 (\5\:VDD \8\:VDD) resistor r=0.04333 c=0
Rk21 (\6\:VDD \10\:VDD) resistor r=0.2629 c=0
Rk7 (\7\:A A) resistor r=0.1512 c=0
Rk8 (A \8\:A) resistor r=1.1058 c=0
Rk22 (\2\:VSS \4\:VSS) resistor r=0.5098 c=0
Rk24 (\5\:VSS VSS) resistor r=0.2454 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.2055 c=0
Rk25 (\4\:VSS \7\:VSS) resistor r=0.0715 c=0
Rk26 (\5\:VSS \9\:VSS) resistor r=0.2849 c=0
Rk12 (\3\:pon \5\:pon) resistor r=1.4482 c=0
Rk13 (\5\:pon \7\:pon) resistor r=0.6071 c=0
Rk4 (\4\:OEb \5\:OEb) resistor r=0.09504 c=0
Rk5 (\5\:OEb \7\:OEb) resistor r=0.5608 c=0
Rk6 (\5\:OEb \9\:OEb) resistor r=0.1516 c=0
Rk9 (\3\:non \4\:non) resistor r=0.1125 c=0
Rk10 (\4\:non \6\:non) resistor r=0.2942 c=0
Rk11 (\4\:non \8\:non) resistor r=0.1776 c=0
Rl2 (\2\:OE \3\:OE) resistor r=87.6374 c=0
Rl1 (\1\:OE \2\:OE) resistor r=90.3846 c=0
Rl5 (\4\:OE \5\:OE) resistor r=107.406 c=0
Rl7 (\5\:OE \7\:OE) resistor r=86.2526 c=0
Rl6 (\5\:OE \6\:OE) resistor r=2.0166 c=0
Rl10 (\4\:A \5\:A) resistor r=134.615 c=0
Rl11 (\5\:A \6\:A) resistor r=24.2328 c=0
Rl3 (\1\:A \2\:A) resistor r=26.098 c=0
Rl4 (\2\:A \3\:A) resistor r=143.406 c=0
Rl13 (pon \2\:pon) resistor r=26.098 c=0
Rl8 (OEb \2\:OEb) resistor r=103.823 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=24.7951 c=0
Rl12 (non \2\:non) resistor r=59.1284 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz8 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\6\:pon \7\:pon) resistor r=75 c=0
Rz1 (\8\:OEb \9\:OEb) resistor r=75 c=0
Rz2 (\7\:non \8\:non) resistor r=75 c=0
Ry4 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry3 (\4\:pon \5\:pon) resistor r=62 c=0
Ry1 (\6\:OEb \7\:OEb) resistor r=62 c=0
Ry2 (\5\:non \6\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \10\:OE) resistor r=45 c=0
Rx4 (\2\:A \7\:A) resistor r=45 c=0
Rx5 (\6\:A \8\:A) resistor r=45 c=0
Rx7 (\2\:pon \3\:pon) resistor r=45 c=0
Rx3 (\2\:OEb \4\:OEb) resistor r=45 c=0
Rx6 (\2\:non \3\:non) resistor r=45 c=0
mn4 (\6\:pon \1\:OE net144 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.03e-14 ps=5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn3 (net144 \3\:A \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.33e-14 ad=1.522e-14 ps=9.2e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=5.2e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn0 (\8\:OEb \7\:OE \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.33e-14 ad=3.698e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.55e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn2 (\7\:non \3\:OEb \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=2.32e-14 ps=1.3e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6e-07 sd=160n sca=12.2839 scb=0.0124725 \
        scc=0.000542081 m=(1)
mn1 (\7\:non \5\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.95e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn5 (\1\:Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.74231e-07 sb=1.4e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mp5 (\3\:Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.652e-14 ad=5.85e-14 ps=1.45e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.07372e-07 sb=1.5e-07 sd=160n sca=39.7153 \
        scb=0.0373018 scc=0.00416002 m=(1)
ends TBUFX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:27 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX12
// View name: extracted

simulator lang=spectre

subckt TBUFX12 A OE VDD VSS Y
mp0 (\14\:OEb \1\:OE \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.945e-14 ad=6.63e-14 ps=1.36e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.50135e-06 sd=160n sca=24.3916 \
        scb=0.0229031 scc=0.00193544 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.403e-14 ad=6.24e-14 ps=1.11583e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.53333e-07 sb=2e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(12)
C1 (OE VSS) capacitor c=3.20491e-17
C2 (Y VSS) capacitor c=8.82295e-16
C3 (VDD VSS) capacitor c=3.68835e-16
C4 (A VSS) capacitor c=1.48672e-15
C5 (OEb VSS) capacitor c=6.79285e-17
C6 (pon VSS) capacitor c=4.27619e-16
C7 (14 VSS) capacitor c=1.84769e-18
C8 (15 VSS) capacitor c=5.60508e-20
C9 (16 VSS) capacitor c=1.82655e-18
C10 (non VSS) capacitor c=3.65999e-16
C11 (5 VSS) capacitor c=4.32879e-18
C12 (6 VSS) capacitor c=2.85578e-18
C13 (7 VSS) capacitor c=2.83609e-18
C14 (8 VSS) capacitor c=2.12885e-18
C15 (\23\:A VSS) capacitor c=8.05921e-17
C16 (\8\:OEb VSS) capacitor c=8.89549e-17
C17 (\13\:OEb VSS) capacitor c=6.6494e-17
C18 (\16\:A VSS) capacitor c=6.15335e-17
C19 (\21\:A VSS) capacitor c=5.32364e-17
C20 (\5\:OEb VSS) capacitor c=2.24603e-17
C21 (\10\:A VSS) capacitor c=4.02802e-17
C22 (\1\:OE VSS) capacitor c=5.32749e-17
C23 (\15\:A VSS) capacitor c=3.35594e-17
C24 (\16\:OE VSS) capacitor c=3.14062e-17
C25 (\18\:OE VSS) capacitor c=5.09329e-17
C26 (\7\:A VSS) capacitor c=3.80259e-17
C27 (\8\:A VSS) capacitor c=2.34238e-17
C28 (\4\:OE VSS) capacitor c=3.76037e-17
C29 (\11\:OE VSS) capacitor c=2.28311e-17
C30 (\3\:A VSS) capacitor c=5.39025e-17
C31 (\3\:OE VSS) capacitor c=3.53238e-17
C32 (\13\:non VSS) capacitor c=3.80551e-17
C33 (\6\:OEb VSS) capacitor c=1.71462e-17
C34 (\2\:OEb VSS) capacitor c=4.72265e-16
C35 (\5\:OE VSS) capacitor c=4.15794e-16
C36 (\8\:OE VSS) capacitor c=2.516e-17
C37 (\2\:OE VSS) capacitor c=2.58483e-17
C38 (\1\:VDD VSS) capacitor c=6.01909e-16
C39 (\40\:non VSS) capacitor c=4.5017e-17
C40 (\24\:VDD VSS) capacitor c=4.96067e-17
C41 (\34\:non VSS) capacitor c=1.23511e-16
C42 (\4\:VDD VSS) capacitor c=5.73287e-17
C43 (\25\:non VSS) capacitor c=3.2328e-16
C44 (\24\:pon VSS) capacitor c=7.89243e-17
C45 (\34\:pon VSS) capacitor c=8.21445e-17
C46 (\16\:OEb VSS) capacitor c=4.95678e-17
C47 (\7\:OE VSS) capacitor c=1.03551e-17
C48 (\19\:OE VSS) capacitor c=5.05983e-17
C49 (\20\:OE VSS) capacitor c=3.68865e-17
C50 (\15\:OEb VSS) capacitor c=2.07688e-16
C51 (\18\:OEb VSS) capacitor c=2.31185e-16
C52 (\32\:non VSS) capacitor c=7.3576e-17
C53 (\33\:non VSS) capacitor c=1.45693e-16
C54 (\26\:pon VSS) capacitor c=5.25467e-16
C55 (\36\:pon VSS) capacitor c=2.63591e-16
C56 (\23\:VDD VSS) capacitor c=2.18118e-17
C57 (\26\:VDD VSS) capacitor c=1.83454e-16
Rk1 (\19\:OE OE) resistor r=0.1575 c=0
Rk2 (OE \20\:OE) resistor r=0.06326 c=0
Rk88 (\1\:VSS \16\:VSS) resistor r=0.3934 c=0
Rk89 (\16\:VSS \17\:VSS) resistor r=0.1653 c=0
Rk91 (\18\:VSS VSS) resistor r=0.1827 c=0
Rk90 (\17\:VSS \18\:VSS) resistor r=0.3685 c=0
Rk102 (\16\:VSS \40\:VSS) resistor r=0.2646 c=0
Rk103 (\18\:VSS \42\:VSS) resistor r=0.2547 c=0
Rk61 (\1\:VDD \22\:VDD) resistor r=0.1679 c=0
Rk62 (\22\:VDD \23\:VDD) resistor r=0.223 c=0
Rk63 (\23\:VDD \25\:VDD) resistor r=0.24 c=0
Rk75 (\26\:VDD VDD) resistor r=0.1827 c=0
Rk64 (\23\:VDD \26\:VDD) resistor r=0.3809 c=0
Rk4 (\15\:OEb \17\:OEb) resistor r=0.4064 c=0
Rk5 (\15\:OEb \18\:OEb) resistor r=1.8402 c=0
Rk22 (\25\:pon \26\:pon) resistor r=0.3642 c=0
Rk27 (\26\:pon \35\:pon) resistor r=0.3926 c=0
Rk28 (\26\:pon \36\:pon) resistor r=1.9434 c=0
Rk16 (\25\:non \32\:non) resistor r=0.2383 c=0
Rk17 (\32\:non \33\:non) resistor r=0.4675 c=0
Rk18 (\33\:non \35\:non) resistor r=0.6406 c=0
Rk21 (\33\:non \41\:non) resistor r=0.1133 c=0
Rl20 (\5\:OE \16\:OE) resistor r=84.2969 c=0
Rl22 (\5\:OE \18\:OE) resistor r=89.8352 c=0
Rl5 (\5\:OE \4\:OE) resistor r=97.3098 c=0
Rl1 (\2\:OE \1\:OE) resistor r=73.7687 c=0
Rl2 (\2\:OE \3\:OE) resistor r=29.5379 c=0
Rl11 (\7\:OE \11\:OE) resistor r=34.3295 c=0
Rl7 (\7\:OE \5\:OE) resistor r=56.64 c=0
Rl8 (\7\:OE \8\:OE) resistor r=2.0166 c=0
Rl45 (A \23\:A) resistor r=114.264 c=0
Rl34 (A \16\:A) resistor r=84.5933 c=0
Rl38 (A \21\:A) resistor r=24.2328 c=0
Rl23 (A \10\:A) resistor r=78.3307 c=0
Rl27 (A \15\:A) resistor r=84.3341 c=0
Rl14 (A \7\:A) resistor r=28.0797 c=0
Rl15 (A \8\:A) resistor r=30.2861 c=0
Rl4 (A \3\:A) resistor r=98.7687 c=0
Rl32 (\6\:OEb \5\:OEb) resistor r=29.5379 c=0
Rl40 (\2\:OEb \8\:OEb) resistor r=210.338 c=0
Rl44 (\2\:OEb \13\:OEb) resistor r=94.0258 c=0
Rl28 (\2\:OEb OEb) resistor r=133.437 c=0
Rl31 (\2\:OEb \5\:OEb) resistor r=86.8321 c=0
Rl59 (non \13\:non) resistor r=9.5799 c=0
Rz28 (\40\:VSS \39\:VSS) resistor r=75 c=0
Rz29 (\42\:VSS \41\:VSS) resistor r=75 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz15 (\22\:VDD \4\:VDD) resistor r=6.25 c=0
Rz16 (\26\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\17\:OEb \16\:OEb) resistor r=75 c=0
Rz6 (\25\:pon \24\:pon) resistor r=75 c=0
Rz7 (\35\:pon \34\:pon) resistor r=75 c=0
Ry27 (\1\:VSS \4\:VSS) resistor r=2.9524 c=0
Ry29 (\17\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry21 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry1 (\15\:OEb \14\:OEb) resistor r=20.6667 c=0
Ry2 (\35\:non \34\:non) resistor r=62 c=0
Ry3 (\41\:non \40\:non) resistor r=62 c=0
Rx1 (\19\:OE \8\:OE) resistor r=45 c=0
Rx2 (\20\:OE \2\:OE) resistor r=45 c=0
Rx5 (\18\:OEb \6\:OEb) resistor r=45 c=0
Rx14 (\36\:pon pon) resistor r=45 c=0
Rx13 (\32\:non \13\:non) resistor r=45 c=0
mn0 (\16\:OEb \3\:OE \41\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.42e-14 ps=9.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.50837e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.082e-14 ad=4.16e-14 ps=8.3667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35827e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(12)
mn3_1__rcx (13 \3\:A \41\:VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.12e-14 ps=9.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.92077e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn4_1__rcx (\34\:pon \11\:OE 13 VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=6.728e-14 ps=7.1e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.84192e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn4_2__rcx (\34\:pon \4\:OE 14 VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=2.535e-14 ad=6.728e-14 ps=6.5e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.68885e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn3_2__rcx (14 \8\:A \39\:VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=2.535e-14 ps=7.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.61705e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn1_1__rcx (\25\:non A \1\:VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=3.26e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95128e-06 sb=1.285e-06 sd=160n sca=10.2695 \
        scb=0.00939499 scc=0.000302823 m=(2)
mn2 (\25\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=3.26e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27449e-06 sb=1.96179e-06 sd=160n sca=7.99316 \
        scb=0.0056435 scc=9.07136e-05 m=(2)
mn3_3__rcx (15 \7\:A \39\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=1.14e-14 ps=7.1e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.57605e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn4_3__rcx (\24\:pon \18\:OE 15 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.14e-14 ad=4.37e-14 ps=5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1.53461e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn4 (\24\:pon \16\:OE 16 VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=2.945e-14 ad=4.37e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.42605e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn3 (16 \15\:A \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=2.945e-14 ps=7.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99e-06 sb=1.34711e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn1 (\25\:non A \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.415e-14 ad=3.04e-14 ps=7.75e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49816e-06 sb=2e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(2)
mn2_2__rcx (\25\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(1.9e-07) l=4.5e-08 \
        nf=1 as=3.04e-14 ad=3.04e-14 ps=7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57908e-06 sb=2e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(2)
mp1_1__rcx (5 \10\:A \26\:VDD VDD) g45p1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=5.015e-14 ps=1.83e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96085e-06 sb=1.37424e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp2_1__rcx (\34\:non \5\:OEb 5 VDD) g45p1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=4.72e-14 ps=9.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97144e-06 sb=1.24305e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp2_2__rcx (\34\:non OEb 6 VDD) g45p1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97492e-06 sb=1.11797e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp1_2__rcx (6 \21\:A \24\:VDD VDD) g45p1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=1.77e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97669e-06 sb=1.0539e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp3_1__rcx (\26\:pon A \26\:VDD VDD) g45p1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=8.093e-14 ad=4.74e-14 ps=1.595e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.91661e-06 sd=160n sca=24.0377 \
        scb=0.0205536 scc=0.00241838 m=(2)
mp4_1__rcx (\26\:pon \5\:OE \26\:VDD VDD) g45p1hvt w=(2.95e-07) \
        l=4.5e-08 nf=1 as=1.2427e-13 ad=4.74e-14 ps=2.18e-06 pd=9.2e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.21695e-07 sb=1.97754e-06 sd=160n \
        sca=25.2842 scb=0.0209131 scc=0.00278313 m=(2)
mp1_3__rcx (7 \16\:A \24\:VDD VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=1.74e-14 ps=1.32e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94931e-06 sb=9.47759e-07 sd=160n sca=23.09 \
        scb=0.0200797 scc=0.00245753 m=(1)
mp2_3__rcx (\40\:non \13\:OEb 7 VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=6.4e-14 ps=7e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95293e-06 sb=8.86207e-07 sd=160n sca=23.09 \
        scb=0.0200797 scc=0.00245753 m=(1)
mp2 (\40\:non \8\:OEb 8 VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=6.4e-14 ps=7e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4931e-07 sb=2e-06 sd=160n sca=10.9993 \
        scb=0.00888516 scc=0.000178627 m=(1)
mp1 (8 \23\:A \1\:VDD VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=8.975e-14 ad=1.74e-14 ps=1.33e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.14483e-07 sb=2e-06 sd=160n sca=10.9993 \
        scb=0.00888516 scc=0.000178627 m=(1)
mp3 (\26\:pon A \26\:VDD VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=5.438e-14 ps=1.83e-06 pd=9.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39138e-06 sb=1.93759e-06 sd=160n sca=25.2314 \
        scb=0.0210442 scc=0.00282901 m=(2)
mp4_2__rcx (\26\:pon \5\:OE \26\:VDD VDD) g45p1hvt w=(2.9e-07) l=4.5e-08 \
        nf=1 as=1.124e-13 ad=5.437e-14 ps=1.83e-06 pd=9.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59638e-06 sb=1.81034e-06 sd=160n sca=25.2314 \
        scb=0.0210442 scc=0.00282901 m=(2)
ends TBUFX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:28 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX16
// View name: extracted

simulator lang=spectre

subckt TBUFX16 A OE VDD VSS Y
mp2_1__rcx (\44\:non OEb 7 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.34e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_1__rcx (7 \21\:A \42\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=3.1e-14 ps=9.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_2__rcx (6 \16\:A \42\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=3.1e-14 ps=9.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2_2__rcx (\54\:non \6\:OEb 6 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.96e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2_3__rcx (\54\:non \4\:OEb 9 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_3__rcx (9 \28\:A \40\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=1.86e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_4__rcx (8 \23\:A \40\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=1.86e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2_4__rcx (\52\:non \12\:OEb 8 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.2e-14 ps=7.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.295e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp2 (\52\:non \13\:OEb 10 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.2e-14 ps=7.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1 (10 \31\:A \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2115e-13 ad=1.86e-14 ps=1.51e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp4_1__rcx (\34\:pon \1\:OE \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.836e-14 ad=5.834e-14 ps=9.32e-07 pd=1.026e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.99726e-06 sd=160n \
        sca=16.3045 scb=0.0159017 scc=0.000427021 m=(5)
mp3_1__rcx (\34\:pon \1\:A \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.056e-14 ad=5.834e-14 ps=1.476e-06 pd=1.026e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.94105e-06 sd=160n \
        sca=13.5722 scb=0.0115826 scc=0.000363488 m=(5)
C1 (A VSS) capacitor c=2.02651e-17
C2 (OE VSS) capacitor c=3.44183e-17
C3 (VDD VSS) capacitor c=4.8705e-16
C4 (Y VSS) capacitor c=1.02194e-15
C5 (pon VSS) capacitor c=5.28942e-16
C6 (16 VSS) capacitor c=1.86268e-18
C7 (17 VSS) capacitor c=1.38687e-18
C8 (18 VSS) capacitor c=2.31144e-18
C9 (OEb VSS) capacitor c=5.13299e-17
C10 (non VSS) capacitor c=5.03265e-16
C11 (7 VSS) capacitor c=3.46041e-18
C12 (6 VSS) capacitor c=3.35142e-18
C13 (9 VSS) capacitor c=1.93954e-18
C14 (8 VSS) capacitor c=1.92628e-18
C15 (10 VSS) capacitor c=1.87512e-18
C16 (\31\:A VSS) capacitor c=8.57071e-17
C17 (\13\:OEb VSS) capacitor c=5.93512e-17
C18 (\12\:OEb VSS) capacitor c=5.87735e-17
C19 (\23\:A VSS) capacitor c=7.13621e-17
C20 (\28\:A VSS) capacitor c=7.21447e-17
C21 (\4\:OEb VSS) capacitor c=6.56905e-17
C22 (\6\:OEb VSS) capacitor c=4.27089e-17
C23 (\16\:A VSS) capacitor c=5.79105e-17
C24 (\21\:A VSS) capacitor c=3.77173e-17
C25 (\14\:OE VSS) capacitor c=7.68714e-17
C26 (\1\:A VSS) capacitor c=1.30428e-15
C27 (\1\:OE VSS) capacitor c=6.90195e-16
C28 (\20\:OE VSS) capacitor c=4.02348e-17
C29 (\15\:A VSS) capacitor c=2.82682e-17
C30 (\22\:OE VSS) capacitor c=2.78857e-17
C31 (\19\:OE VSS) capacitor c=4.48504e-17
C32 (\10\:A VSS) capacitor c=4.14348e-17
C33 (\12\:A VSS) capacitor c=2.57555e-17
C34 (\11\:OE VSS) capacitor c=2.99134e-17
C35 (\13\:OE VSS) capacitor c=2.40599e-17
C36 (\6\:A VSS) capacitor c=3.01097e-17
C37 (\3\:A VSS) capacitor c=3.29594e-17
C38 (\3\:OE VSS) capacitor c=3.36744e-17
C39 (\17\:non VSS) capacitor c=2.45771e-17
C40 (\18\:A VSS) capacitor c=6.35186e-16
C41 (\2\:OEb VSS) capacitor c=8.08835e-16
C42 (\1\:VDD VSS) capacitor c=7.18317e-16
C43 (\52\:non VSS) capacitor c=3.56732e-17
C44 (\40\:VDD VSS) capacitor c=4.62596e-17
C45 (\54\:non VSS) capacitor c=3.46368e-17
C46 (\42\:VDD VSS) capacitor c=4.80844e-17
C47 (\44\:non VSS) capacitor c=1.12305e-16
C48 (\21\:OEb VSS) capacitor c=2.97567e-17
C49 (\33\:non VSS) capacitor c=4.35118e-16
C50 (\19\:OEb VSS) capacitor c=6.92146e-17
C51 (\32\:pon VSS) capacitor c=8.22826e-17
C52 (\42\:pon VSS) capacitor c=8.35506e-17
C53 (\49\:pon VSS) capacitor c=8.35175e-17
C54 (\17\:A VSS) capacitor c=3.07866e-17
C55 (\18\:OEb VSS) capacitor c=4.98755e-17
C56 (\41\:non VSS) capacitor c=1.05209e-16
C57 (\42\:non VSS) capacitor c=1.25123e-16
C58 (\43\:non VSS) capacitor c=1.54977e-16
C59 (\34\:pon VSS) capacitor c=7.37879e-16
C60 (\37\:pon VSS) capacitor c=3.94173e-16
C61 (\14\:VDD VSS) capacitor c=2.82878e-17
C62 (\15\:VDD VSS) capacitor c=1.55741e-17
C63 (\17\:VDD VSS) capacitor c=2.64921e-16
Rk18 (\1\:A A) resistor r=0.003673 c=0
Rk14 (\1\:A \18\:A) resistor r=1.3948 c=0
Rk135 (\1\:VSS \41\:VSS) resistor r=0.3882 c=0
Rk136 (\41\:VSS \42\:VSS) resistor r=0.4108 c=0
Rk137 (\42\:VSS \43\:VSS) resistor r=0.2079 c=0
Rk139 (\44\:VSS VSS) resistor r=0.2753 c=0
Rk138 (\43\:VSS \44\:VSS) resistor r=0.2756 c=0
Rk142 (\41\:VSS \50\:VSS) resistor r=0.3411 c=0
Rk143 (\42\:VSS \52\:VSS) resistor r=0.3314 c=0
Rk144 (\44\:VSS \54\:VSS) resistor r=0.3236 c=0
Rk1 (OE \1\:OE) resistor r=0.03115 c=0
Rk82 (\1\:VDD \14\:VDD) resistor r=0.3506 c=0
Rk83 (\14\:VDD \15\:VDD) resistor r=0.3506 c=0
Rk84 (\15\:VDD \16\:VDD) resistor r=0.09758 c=0
Rk92 (\17\:VDD VDD) resistor r=0.08981 c=0
Rk85 (\16\:VDD \17\:VDD) resistor r=0.4962 c=0
Rk101 (\14\:VDD \41\:VDD) resistor r=0.2623 c=0
Rk102 (\15\:VDD \43\:VDD) resistor r=0.2623 c=0
Rk33 (\33\:pon \34\:pon) resistor r=0.4161 c=0
Rk35 (\34\:pon \37\:pon) resistor r=3.0493 c=0
Rk39 (\34\:pon \43\:pon) resistor r=0.362 c=0
Rk43 (\34\:pon \50\:pon) resistor r=0.7273 c=0
Rk6 (\2\:OEb \18\:OEb) resistor r=0.4155 c=0
Rk7 (\18\:OEb \20\:OEb) resistor r=0.2001 c=0
Rk8 (\18\:OEb \22\:OEb) resistor r=0.08288 c=0
Rk24 (\33\:non \41\:non) resistor r=0.2767 c=0
Rk25 (\41\:non \42\:non) resistor r=0.5185 c=0
Rk26 (\42\:non \43\:non) resistor r=0.5743 c=0
Rk27 (\43\:non \45\:non) resistor r=0.6502 c=0
Rk31 (\42\:non \53\:non) resistor r=0.07109 c=0
Rk32 (\43\:non \55\:non) resistor r=0.07109 c=0
Rl22 (\1\:A \15\:A) resistor r=35.989 c=0
Rl18 (\1\:A \10\:A) resistor r=55.0028 c=0
Rl20 (\1\:A \12\:A) resistor r=35.3463 c=0
Rl6 (\1\:A \6\:A) resistor r=86.3335 c=0
Rl4 (\1\:A \3\:A) resistor r=76.098 c=0
Rl54 (\18\:A \31\:A) resistor r=128.297 c=0
Rl43 (\18\:A \23\:A) resistor r=148.385 c=0
Rl47 (\18\:A \28\:A) resistor r=135.771 c=0
Rl33 (\17\:A \16\:A) resistor r=100.426 c=0
Rl37 (\17\:A \21\:A) resistor r=35.772 c=0
Rl34 (\17\:A \18\:A) resistor r=98.0022 c=0
Rl23 (\1\:OE \14\:OE) resistor r=263.027 c=0
Rl28 (\20\:OE \14\:OE) resistor r=92.3077 c=0
Rl30 (\1\:OE \22\:OE) resistor r=72.9851 c=0
Rl27 (\1\:OE \19\:OE) resistor r=53.079 c=0
Rl13 (\1\:OE \11\:OE) resistor r=30.0028 c=0
Rl15 (\1\:OE \13\:OE) resistor r=24.6815 c=0
Rl2 (\1\:OE \3\:OE) resistor r=29.5379 c=0
Rl51 (\2\:OEb \13\:OEb) resistor r=72.3105 c=0
Rl50 (\2\:OEb \12\:OEb) resistor r=71.8867 c=0
Rl39 (\2\:OEb \4\:OEb) resistor r=121.898 c=0
Rl40 (\2\:OEb \6\:OEb) resistor r=75.5053 c=0
Rl31 (\2\:OEb OEb) resistor r=70.9489 c=0
Rl70 (non \17\:non) resistor r=24.2107 c=0
Rz36 (\50\:VSS \49\:VSS) resistor r=75 c=0
Rz37 (\52\:VSS \51\:VSS) resistor r=75 c=0
Rz38 (\54\:VSS \53\:VSS) resistor r=75 c=0
Rz20 (\16\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\17\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\33\:pon \32\:pon) resistor r=75 c=0
Rz8 (\43\:pon \42\:pon) resistor r=75 c=0
Rz9 (\50\:pon \49\:pon) resistor r=75 c=0
Rz1 (\20\:OEb \19\:OEb) resistor r=75 c=0
Ry39 (\43\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry28 (\41\:VDD \40\:VDD) resistor r=62 c=0
Ry29 (\43\:VDD \42\:VDD) resistor r=62 c=0
Ry1 (\22\:OEb \21\:OEb) resistor r=62 c=0
Ry2 (\45\:non \44\:non) resistor r=62 c=0
Ry3 (\53\:non \52\:non) resistor r=62 c=0
Ry4 (\55\:non \54\:non) resistor r=62 c=0
Rx16 (\37\:pon pon) resistor r=45 c=0
Rx15 (\41\:non \17\:non) resistor r=45 c=0
mn4_1__rcx (\49\:pon \3\:OE 14 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=2.87e-14 ps=6.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3_1__rcx (14 \3\:A \53\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=2.46e-14 ps=7.5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3_2__rcx (15 \6\:A \53\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=4.92e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn4_2__rcx (\42\:pon \13\:OE 15 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.15e-14 ps=8.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.775e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4_3__rcx (\42\:pon \11\:OE 16 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.153e-14 ad=6.15e-14 ps=6.2e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.43e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3_3__rcx (16 \12\:A \51\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.998e-14 ad=2.153e-14 ps=8e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.28e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3_4__rcx (17 \10\:A \51\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.998e-14 ad=1.23e-14 ps=8e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.04e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4_4__rcx (\32\:pon \19\:OE 17 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.998e-14 ps=5.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=9.35e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\32\:pon \22\:OE 18 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.998e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.885e-06 sb=6.95e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3 (18 \15\:A \49\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=3.28e-14 ps=1.13e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn2 (\33\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.198e-14 ad=3.444e-14 ps=7.22e-07 pd=7.46e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.14613 scb=0.0042077 \
        scc=4.68757e-05 m=(5)
mn1_1__rcx (\33\:non \18\:A \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.493e-14 ad=3.444e-14 ps=7.62e-07 pd=7.46e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.14613 scb=0.0042077 \
        scc=4.68757e-05 m=(5)
mn0 (\19\:OEb \20\:OE \49\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.139e-14 ad=4.16e-14 ps=8.4063e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=2e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(16)
mp0 (\21\:OEb \14\:OE \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=1.2285e-13 ps=1.1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24083e-06 sb=3.15e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=6.484e-14 ps=1.12313e-06 pd=1.1125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61026e-06 sb=2e-06 sd=160n sca=12.8992 \
        scb=0.0114532 scc=0.000515529 m=(16)
ends TBUFX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:29 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX2
// View name: extracted

simulator lang=spectre

subckt TBUFX2 A OE VDD VSS Y
mp4 (\6\:pon \3\:OE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.837e-14 ps=7.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=33.0431 \
        scb=0.0334326 scc=0.00333002 m=(1)
mp3 (\6\:pon \1\:A \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=4.838e-14 ps=1.8e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=4e-07 sd=160n sca=27.5463 scb=0.0242522 \
        scc=0.00301933 m=(1)
mp0 (\9\:OEb \4\:OE \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=4.408e-14 ps=1.8e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=2.05e-07 sd=160n sca=26.4598 \
        scb=0.0232447 scc=0.00301689 m=(1)
mp2 (\8\:non OEb net127 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.01e-14 ps=6.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=26.1509 \
        scb=0.0231087 scc=0.00301684 m=(1)
mp1 (net127 \5\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.208e-13 ad=2.365e-14 ps=1.96e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=6.4e-07 sd=160n sca=26.6838 \
        scb=0.0233875 scc=0.00301701 m=(1)
C1 (Y VSS) capacitor c=1.99375e-17
C2 (VDD VSS) capacitor c=1.46202e-16
C3 (A VSS) capacitor c=1.26649e-16
C4 (pon VSS) capacitor c=9.89633e-17
C5 (OEb VSS) capacitor c=6.27169e-17
C6 (non VSS) capacitor c=8.10462e-17
C7 (net127 VSS) capacitor c=1.93634e-18
C8 (\5\:A VSS) capacitor c=5.36401e-17
C9 (\4\:OE VSS) capacitor c=5.79083e-17
C10 (\1\:A VSS) capacitor c=3.64499e-17
C11 (\3\:OE VSS) capacitor c=3.34052e-17
C12 (\7\:A VSS) capacitor c=4.62448e-17
C13 (\4\:OEb VSS) capacitor c=3.07988e-17
C14 (\7\:OE VSS) capacitor c=2.33988e-17
C15 (\3\:A VSS) capacitor c=4.83728e-17
C16 (\1\:OE VSS) capacitor c=2.76418e-17
C17 (\3\:non VSS) capacitor c=2.70907e-17
C18 (\6\:A VSS) capacitor c=5.47823e-17
C19 (\3\:OEb VSS) capacitor c=1.85833e-17
C20 (\6\:OE VSS) capacitor c=4.26227e-17
C21 (\2\:OE VSS) capacitor c=3.15231e-17
C22 (\1\:VDD VSS) capacitor c=1.14756e-16
C23 (\3\:Y VSS) capacitor c=7.29007e-17
C24 (\8\:non VSS) capacitor c=7.18589e-17
C25 (\9\:OEb VSS) capacitor c=5.69676e-17
C26 (\10\:VDD VSS) capacitor c=2.31593e-17
C27 (\6\:pon VSS) capacitor c=2.03413e-16
C28 (\12\:VDD VSS) capacitor c=4.40941e-17
C29 (\1\:Y VSS) capacitor c=4.45837e-17
C30 (\5\:non VSS) capacitor c=3.59809e-17
C31 (\7\:OEb VSS) capacitor c=2.17299e-17
C32 (\4\:pon VSS) capacitor c=6.56797e-17
C33 (\2\:A VSS) capacitor c=5.04055e-17
C34 (\2\:OEb VSS) capacitor c=3.57727e-17
C35 (\8\:OE VSS) capacitor c=6.04919e-17
C36 (\9\:OE VSS) capacitor c=5.26302e-17
C37 (\5\:OEb VSS) capacitor c=1.60273e-17
C38 (\6\:OEb VSS) capacitor c=3.77947e-17
C39 (\8\:A VSS) capacitor c=1.31029e-16
C40 (\9\:A VSS) capacitor c=2.77299e-17
C41 (\7\:non VSS) capacitor c=5.95749e-17
C42 (\10\:non VSS) capacitor c=3.73037e-17
C43 (\8\:pon VSS) capacitor c=1.49732e-16
C44 (\5\:VDD VSS) capacitor c=3.1445e-17
C45 (\6\:VDD VSS) capacitor c=1.9295e-17
C46 (\7\:VDD VSS) capacitor c=1.15627e-17
Rk2 (\9\:OE OE) resistor r=0.009977 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.2301 c=0
Rk24 (\1\:VSS \4\:VSS) resistor r=0.1901 c=0
Rk25 (\4\:VSS \6\:VSS) resistor r=0.04493 c=0
Rk27 (\7\:VSS VSS) resistor r=0.2778 c=0
Rk26 (\6\:VSS \7\:VSS) resistor r=0.2229 c=0
Rk29 (\4\:VSS \11\:VSS) resistor r=0.2295 c=0
Rk30 (\7\:VSS \13\:VSS) resistor r=0.2911 c=0
Rk13 (Y \2\:Y) resistor r=0.2524 c=0
Rk14 (Y \4\:Y) resistor r=0.1409 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.2796 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.237 c=0
Rk19 (\7\:VDD VDD) resistor r=0.04468 c=0
Rk18 (\6\:VDD \7\:VDD) resistor r=0.2168 c=0
Rk21 (\6\:VDD \11\:VDD) resistor r=0.04329 c=0
Rk22 (\7\:VDD \13\:VDD) resistor r=0.4084 c=0
Rk6 (\8\:A A) resistor r=1.0464 c=0
Rk7 (A \9\:A) resistor r=0.051 c=0
Rk11 (\5\:pon \7\:pon) resistor r=0.6441 c=0
Rk12 (\7\:pon \8\:pon) resistor r=1.3156 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.1077 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.1174 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.246 c=0
Rk8 (\6\:non \7\:non) resistor r=0.09746 c=0
Rk9 (\7\:non \9\:non) resistor r=0.4111 c=0
Rk10 (\7\:non \10\:non) resistor r=0.189 c=0
Rl2 (\2\:OE \3\:OE) resistor r=89.5604 c=0
Rl1 (\1\:OE \2\:OE) resistor r=40.3846 c=0
Rl6 (\4\:OE \5\:OE) resistor r=109.329 c=0
Rl8 (\5\:OE \7\:OE) resistor r=36.2526 c=0
Rl7 (\5\:OE \6\:OE) resistor r=0.5166 c=0
Rl12 (\5\:A \6\:A) resistor r=74.2328 c=0
Rl13 (\6\:A \7\:A) resistor r=87.6944 c=0
Rl3 (\1\:A \2\:A) resistor r=41.4601 c=0
Rl4 (\2\:A \3\:A) resistor r=106.845 c=0
Rl5 (\2\:A \4\:A) resistor r=4.959 c=0
Rl9 (OEb \2\:OEb) resistor r=112.741 c=0
Rl11 (\2\:OEb \4\:OEb) resistor r=70.868 c=0
Rl10 (\2\:OEb \3\:OEb) resistor r=25.857 c=0
Rl15 (non \3\:non) resistor r=18.7325 c=0
Rz8 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz3 (\5\:pon \4\:pon) resistor r=75 c=0
Rz1 (\7\:OEb \8\:OEb) resistor r=75 c=0
Rz2 (\6\:non \5\:non) resistor r=75 c=0
Ry4 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry7 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry3 (\7\:pon \6\:pon) resistor r=62 c=0
Ry1 (\9\:OEb \10\:OEb) resistor r=62 c=0
Ry2 (\9\:non \8\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\6\:A \8\:A) resistor r=45 c=0
Rx5 (\4\:A \9\:A) resistor r=45 c=0
Rx7 (\8\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\10\:non \3\:non) resistor r=45 c=0
mn4 (\4\:pon \1\:OE net144 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (net144 \3\:A \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.8e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\7\:OEb \7\:OE \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\5\:non \4\:OEb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (\5\:non \7\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn5 (\1\:Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.99e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84423e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp5 (\3\:Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.77e-14 ad=6.24e-14 ps=1.51e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.92564e-07 sb=3.45e-07 sd=160n sca=34.13 \
        scb=0.0245441 scc=0.00340271 m=(2)
ends TBUFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:30 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX20
// View name: extracted

simulator lang=spectre

subckt TBUFX20 A OE VDD VSS Y
mp1_1__rcx (8 \19\:A VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=1.2318e-13 ad=6.012e-14 ps=1.66e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.69262e-06 sb=1.79077e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp2_1__rcx (\55\:non \6\:OEb 8 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=6.012e-14 ad=5.2e-14 ps=1.02e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74569e-06 sb=1.75538e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp2_2__rcx (\55\:non OEb 11 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.2e-14 ps=7.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.793e-06 sb=1.72385e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp1_2__rcx (11 \27\:A \52\:VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=1.95e-14 ps=1.32e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81723e-06 sb=1.70769e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp1_3__rcx (9 \22\:A \52\:VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=3.25e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59685e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2_3__rcx (\53\:non \12\:OEb 9 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=3.25e-14 ad=5.2e-14 ps=8.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65262e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2_4__rcx (\53\:non \7\:OEb 10 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=3.25e-14 ad=5.2e-14 ps=8.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73146e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1_4__rcx (10 \31\:A \50\:VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.89e-14 ad=3.25e-14 ps=1.38e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78123e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1_5__rcx (5 \28\:A \50\:VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.89e-14 ad=5.2e-14 ps=1.38e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83015e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2_5__rcx (\51\:non \19\:OEb 5 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=5.2e-14 ps=9.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86692e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2 (\51\:non \13\:OEb 6 VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=5.2e-14 ps=9.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89846e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1 (6 \34\:A \1\:VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=9.035e-14 ad=5.2e-14 ps=1.28e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.93e-06 sb=2e-06 sd=160n sca=13.7057 scb=0.0125682 \
        scc=0.000653447 m=(1)
mp3_1__rcx (\40\:pon \2\:A VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=7.425e-14 ad=5.2e-14 ps=1.76667e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=49.4087 scb=0.0429485 \
        scc=0.0056687 m=(6)
mp4_1__rcx (\40\:pon OE VDD VDD) g45p1hvt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.877e-14 ad=5.2e-14 ps=1.97e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=38.3877 scb=0.0274361 \
        scc=0.00406713 m=(6)
C1 (Y VSS) capacitor c=1.22443e-15
C2 (A VSS) capacitor c=2.35318e-17
C3 (VDD VSS) capacitor c=7.07774e-16
C4 (OE VSS) capacitor c=7.23676e-16
C5 (15 VSS) capacitor c=6.35687e-18
C6 (pon VSS) capacitor c=7.02371e-16
C7 (16 VSS) capacitor c=2.50553e-18
C8 (17 VSS) capacitor c=2.83825e-18
C9 (18 VSS) capacitor c=3.00585e-18
C10 (19 VSS) capacitor c=9.24291e-19
C11 (20 VSS) capacitor c=1.88768e-18
C12 (OEb VSS) capacitor c=5.84456e-17
C13 (non VSS) capacitor c=6.55186e-16
C14 (8 VSS) capacitor c=7.32462e-18
C15 (11 VSS) capacitor c=2.86247e-18
C16 (9 VSS) capacitor c=7.06791e-18
C17 (10 VSS) capacitor c=5.29684e-18
C18 (5 VSS) capacitor c=8.74805e-18
C19 (6 VSS) capacitor c=9.61153e-18
C20 (\34\:A VSS) capacitor c=5.68028e-17
C21 (\13\:OEb VSS) capacitor c=4.19726e-17
C22 (\19\:OEb VSS) capacitor c=3.15016e-17
C23 (\28\:A VSS) capacitor c=4.4897e-17
C24 (\31\:A VSS) capacitor c=5.49278e-17
C25 (\7\:OEb VSS) capacitor c=4.13583e-17
C26 (\12\:OEb VSS) capacitor c=4.08678e-17
C27 (\22\:A VSS) capacitor c=6.14257e-17
C28 (\27\:A VSS) capacitor c=6.77205e-17
C29 (\6\:OEb VSS) capacitor c=2.59973e-17
C30 (\19\:A VSS) capacitor c=5.45588e-17
C31 (\14\:OE VSS) capacitor c=1.93662e-16
C32 (\18\:A VSS) capacitor c=3.47092e-17
C33 (\24\:OE VSS) capacitor c=3.521e-17
C34 (\26\:OE VSS) capacitor c=5.27237e-17
C35 (\13\:A VSS) capacitor c=3.87096e-17
C36 (\14\:A VSS) capacitor c=1.66462e-17
C37 (\11\:OE VSS) capacitor c=2.68633e-17
C38 (\12\:OE VSS) capacitor c=3.25709e-17
C39 (\9\:A VSS) capacitor c=1.98515e-17
C40 (\6\:A VSS) capacitor c=2.16888e-17
C41 (\1\:OE VSS) capacitor c=2.56784e-17
C42 (\4\:OE VSS) capacitor c=3.1062e-17
C43 (\1\:A VSS) capacitor c=3.15073e-17
C44 (\21\:non VSS) capacitor c=2.35483e-17
C45 (\20\:A VSS) capacitor c=1.05092e-15
C46 (\2\:A VSS) capacitor c=1.13849e-15
C47 (\1\:VDD VSS) capacitor c=8.55169e-16
C48 (\51\:non VSS) capacitor c=1.4339e-16
C49 (\50\:VDD VSS) capacitor c=3.77392e-17
C50 (\53\:non VSS) capacitor c=1.7947e-16
C51 (\52\:VDD VSS) capacitor c=3.88465e-17
C52 (\55\:non VSS) capacitor c=1.18598e-16
C53 (\26\:OEb VSS) capacitor c=3.44081e-17
C54 (\40\:pon VSS) capacitor c=6.99395e-16
C55 (\41\:non VSS) capacitor c=4.76129e-16
C56 (\24\:OEb VSS) capacitor c=8.51532e-17
C57 (\45\:pon VSS) capacitor c=8.10816e-17
C58 (\52\:pon VSS) capacitor c=6.97608e-17
C59 (\59\:pon VSS) capacitor c=8.1502e-17
C60 (\2\:OEb VSS) capacitor c=8.2841e-16
C61 (\23\:OEb VSS) capacitor c=5.51057e-17
C62 (\50\:non VSS) capacitor c=1.15372e-16
C63 (\43\:pon VSS) capacitor c=4.01115e-16
C64 (\17\:VDD VSS) capacitor c=3.44518e-17
C65 (\18\:VDD VSS) capacitor c=2.22052e-17
Rk17 (\2\:A A) resistor r=0.07968 c=0
Rk12 (\20\:A \2\:A) resistor r=1.0099 c=0
Rk93 (\1\:VDD \17\:VDD) resistor r=0.471 c=0
Rk94 (\17\:VDD \18\:VDD) resistor r=0.3807 c=0
Rk96 (\19\:VDD VDD) resistor r=0.2355 c=0
Rk95 (\18\:VDD \19\:VDD) resistor r=0.2154 c=0
Rk116 (\17\:VDD \51\:VDD) resistor r=0.1592 c=0
Rk117 (\18\:VDD \53\:VDD) resistor r=0.2126 c=0
Rk145 (\1\:VSS \24\:VSS) resistor r=0.3582 c=0
Rk146 (\24\:VSS \25\:VSS) resistor r=0.2982 c=0
Rk147 (\25\:VSS \26\:VSS) resistor r=0.1578 c=0
Rk149 (\27\:VSS VSS) resistor r=0.02212 c=0
Rk148 (\26\:VSS \27\:VSS) resistor r=0.3707 c=0
Rk167 (\24\:VSS \63\:VSS) resistor r=0.2598 c=0
Rk168 (\26\:VSS \65\:VSS) resistor r=0.2598 c=0
Rk169 (\27\:VSS \67\:VSS) resistor r=0.251 c=0
Rk35 (\40\:pon \43\:pon) resistor r=2.9728 c=0
Rk37 (\40\:pon \46\:pon) resistor r=0.3461 c=0
Rk41 (\40\:pon \53\:pon) resistor r=0.3509 c=0
Rk45 (\40\:pon \60\:pon) resistor r=0.3642 c=0
Rk6 (\2\:OEb \23\:OEb) resistor r=0.5161 c=0
Rk7 (\23\:OEb \25\:OEb) resistor r=0.1344 c=0
Rk8 (\23\:OEb \27\:OEb) resistor r=0.06751 c=0
Rk26 (\41\:non \50\:non) resistor r=0.261 c=0
Rk27 (\50\:non \52\:non) resistor r=0.5173 c=0
Rk28 (\52\:non \54\:non) resistor r=0.6086 c=0
Rk29 (\54\:non \56\:non) resistor r=0.5824 c=0
Rl65 (\20\:A \34\:A) resistor r=114.264 c=0
Rl54 (\20\:A \28\:A) resistor r=103.08 c=0
Rl56 (\20\:A \31\:A) resistor r=115.362 c=0
Rl44 (\20\:A \22\:A) resistor r=112.261 c=0
Rl48 (\20\:A \27\:A) resistor r=85.7713 c=0
Rl37 (\20\:A \19\:A) resistor r=88.4615 c=0
Rl24 (\2\:A \18\:A) resistor r=43.6813 c=0
Rl20 (\2\:A \13\:A) resistor r=28.0797 c=0
Rl21 (\2\:A \14\:A) resistor r=32.2092 c=0
Rl12 (\2\:A \9\:A) resistor r=26.098 c=0
Rl10 (\2\:A \6\:A) resistor r=26.098 c=0
Rl1 (\2\:A \1\:A) resistor r=36.5385 c=0
Rl28 (OE \14\:OE) resistor r=289.95 c=0
Rl34 (OE \24\:OE) resistor r=78.5277 c=0
Rl36 (OE \26\:OE) resistor r=79.9451 c=0
Rl15 (OE \11\:OE) resistor r=74.7951 c=0
Rl16 (OE \12\:OE) resistor r=81.9251 c=0
Rl3 (OE \1\:OE) resistor r=27.2353 c=0
Rl5 (OE \4\:OE) resistor r=28.0797 c=0
Rl59 (\2\:OEb \13\:OEb) resistor r=151.157 c=0
Rl64 (\2\:OEb \19\:OEb) resistor r=43.4636 c=0
Rl49 (\2\:OEb \7\:OEb) resistor r=45.3874 c=0
Rl53 (\2\:OEb \12\:OEb) resistor r=43.4636 c=0
Rl39 (\2\:OEb OEb) resistor r=74.6625 c=0
Rl43 (\2\:OEb \6\:OEb) resistor r=24.2328 c=0
Rl87 (non \21\:non) resistor r=11.3141 c=0
Rz25 (VDD \1\:VDD) resistor r=6.25 c=0
Rz24 (\19\:VDD \1\:VDD) resistor r=6.25 c=0
Rz44 (\63\:VSS \62\:VSS) resistor r=75 c=0
Rz45 (\65\:VSS \64\:VSS) resistor r=75 c=0
Rz46 (\67\:VSS \66\:VSS) resistor r=75 c=0
Rz8 (\46\:pon \45\:pon) resistor r=75 c=0
Rz9 (\53\:pon \52\:pon) resistor r=75 c=0
Rz10 (\60\:pon \59\:pon) resistor r=75 c=0
Rz1 (\25\:OEb \24\:OEb) resistor r=75 c=0
Ry33 (\51\:VDD \50\:VDD) resistor r=62 c=0
Ry34 (\53\:VDD \52\:VDD) resistor r=62 c=0
Ry46 (\25\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\27\:OEb \26\:OEb) resistor r=62 c=0
Ry2 (\52\:non \51\:non) resistor r=62 c=0
Ry3 (\54\:non \53\:non) resistor r=62 c=0
Ry4 (\56\:non \55\:non) resistor r=62 c=0
Rx18 (\43\:pon pon) resistor r=45 c=0
Rx17 (\50\:non \21\:non) resistor r=45 c=0
mn3_1__rcx (15 \1\:A \66\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.258e-14 ps=7.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn4_1__rcx (\59\:pon \4\:OE 15 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=3.44e-14 ps=6.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn4_2__rcx (\59\:pon \1\:OE 16 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_2__rcx (16 \6\:A \64\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_3__rcx (17 \9\:A \64\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.333e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn4_3__rcx (\52\:pon \12\:OE 17 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=4.515e-14 ps=7.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4_4__rcx (\52\:pon \11\:OE 18 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_4__rcx (18 \14\:A \62\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_5__rcx (19 \13\:A \62\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4_5__rcx (\45\:pon \26\:OE 19 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4 (\45\:pon \24\:OE 20 VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.3e-14 ps=6.6e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn3 (20 \18\:A \1\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.007e-14 ad=2.472e-14 ps=1.13e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn1_1__rcx (\41\:non \20\:A \1\:VSS VSS) g45n1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.253e-14 ad=3.44e-14 ps=8.4167e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(6)
mn2_1__rcx (\41\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(6)
mn0_1__rcx (\24\:OEb \14\:OE \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.007e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67115e-06 sb=1.70663e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.163e-14 ad=4.16e-14 ps=8.42e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67115e-06 sb=2e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(20)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.341e-14 ad=6.396e-14 ps=1.107e-06 pd=1.108e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66949e-06 sb=2e-06 sd=160n sca=13.1056 \
        scb=0.0116857 scc=0.000556045 m=(20)
mp0_1__rcx (\26\:OEb \14\:OE VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.896e-14 ad=8.775e-14 ps=1.43e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.68333e-06 sb=1.59295e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
ends TBUFX20
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:31 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX3
// View name: extracted

simulator lang=spectre

subckt TBUFX3 A OE VDD VSS Y
mp4 (\6\:pon \3\:OE \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.04551e-07 sd=160n sca=24.3383 \
        scb=0.0260706 scc=0.00165215 m=(1)
mp3 (\6\:pon \1\:A \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.99551e-07 sd=160n sca=19.1183 \
        scb=0.0171898 scc=0.00129044 m=(1)
mp2 (\9\:non OEb net127 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.35e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp1 (net127 \4\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.3e-07 sd=160n sca=30.5804 \
        scb=0.0202168 scc=0.00336097 m=(1)
mp5_1__rcx (\4\:Y pon \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.795e-14 ad=5.98e-14 ps=1.32333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=6.1e-07 sd=160n sca=31.2654 \
        scb=0.0205378 scc=0.00336116 m=(3)
C1 (OE VSS) capacitor c=6.21399e-17
C2 (Y VSS) capacitor c=2.44631e-17
C3 (VDD VSS) capacitor c=1.13393e-16
C4 (A VSS) capacitor c=2.50623e-17
C5 (pon VSS) capacitor c=1.44979e-16
C6 (OEb VSS) capacitor c=8.94277e-17
C7 (non VSS) capacitor c=1.16202e-16
C8 (net127 VSS) capacitor c=3.8178e-18
C9 (\4\:A VSS) capacitor c=8.82175e-17
C10 (\4\:OE VSS) capacitor c=3.5817e-17
C11 (\1\:A VSS) capacitor c=4.35692e-17
C12 (\3\:OE VSS) capacitor c=4.46822e-17
C13 (\6\:A VSS) capacitor c=2.76e-17
C14 (\4\:OEb VSS) capacitor c=2.88849e-17
C15 (\7\:OE VSS) capacitor c=2.46644e-17
C16 (\3\:A VSS) capacitor c=6.18229e-17
C17 (\1\:OE VSS) capacitor c=4.1049e-17
C18 (\4\:non VSS) capacitor c=2.31324e-17
C19 (\5\:A VSS) capacitor c=4.92731e-17
C20 (\3\:OEb VSS) capacitor c=1.25091e-17
C21 (\6\:OE VSS) capacitor c=1.90335e-17
C22 (\2\:A VSS) capacitor c=4.12156e-17
C23 (\2\:OE VSS) capacitor c=3.67514e-17
C24 (\9\:non VSS) capacitor c=3.24912e-17
C25 (\7\:OEb VSS) capacitor c=9.327e-17
C26 (\12\:VDD VSS) capacitor c=3.50294e-17
C27 (\6\:pon VSS) capacitor c=2.17575e-16
C28 (\14\:VDD VSS) capacitor c=2.80602e-17
C29 (\1\:VDD VSS) capacitor c=2.75601e-17
C30 (\1\:Y VSS) capacitor c=7.64518e-17
C31 (\11\:non VSS) capacitor c=6.24995e-17
C32 (\9\:OEb VSS) capacitor c=3.07581e-17
C33 (\8\:pon VSS) capacitor c=7.92024e-17
C34 (\5\:OE VSS) capacitor c=1.44661e-17
C35 (\2\:OEb VSS) capacitor c=3.39372e-17
C36 (\8\:OE VSS) capacitor c=5.58462e-17
C37 (\5\:OEb VSS) capacitor c=2.00046e-17
C38 (\6\:OEb VSS) capacitor c=5.02989e-17
C39 (\7\:A VSS) capacitor c=1.63369e-16
C40 (\8\:A VSS) capacitor c=1.52476e-16
C41 (\9\:A VSS) capacitor c=5.44811e-17
C42 (\7\:non VSS) capacitor c=7.41149e-17
C43 (\8\:non VSS) capacitor c=5.99983e-17
C44 (\5\:pon VSS) capacitor c=1.96635e-16
C45 (\4\:Y VSS) capacitor c=9.95621e-17
C46 (\3\:VDD VSS) capacitor c=9.17733e-17
C47 (\6\:VDD VSS) capacitor c=1.61499e-17
C48 (\7\:VDD VSS) capacitor c=7.57484e-18
Rk2 (\9\:OE OE) resistor r=0.003271 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.2153 c=0
Rk15 (\1\:Y Y) resistor r=0.2199 c=0
Rk16 (Y \4\:Y) resistor r=0.04988 c=0
Rk29 (\2\:VDD \3\:VDD) resistor r=0.1327 c=0
Rk31 (\3\:VDD \5\:VDD) resistor r=0.2981 c=0
Rk32 (\5\:VDD \6\:VDD) resistor r=0.3056 c=0
Rk34 (\7\:VDD VDD) resistor r=0.03966 c=0
Rk33 (\6\:VDD \7\:VDD) resistor r=0.2051 c=0
Rk37 (\6\:VDD \13\:VDD) resistor r=0.2154 c=0
Rk38 (\7\:VDD \15\:VDD) resistor r=0.2577 c=0
Rk8 (\8\:A A) resistor r=0.0262 c=0
Rk6 (\7\:A \8\:A) resistor r=1.1854 c=0
Rk7 (\8\:A \9\:A) resistor r=0.2681 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.1126 c=0
Rk22 (\3\:VSS \5\:VSS) resistor r=0.3344 c=0
Rk26 (\10\:VSS VSS) resistor r=0.2377 c=0
Rk25 (\5\:VSS \10\:VSS) resistor r=0.3131 c=0
Rk27 (\5\:VSS \12\:VSS) resistor r=0.07144 c=0
Rk28 (\10\:VSS \14\:VSS) resistor r=0.2466 c=0
Rk12 (\5\:pon \7\:pon) resistor r=1.5174 c=0
Rk13 (\7\:pon \9\:pon) resistor r=0.7166 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.1109 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.4762 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.05947 c=0
Rk9 (\7\:non \8\:non) resistor r=0.4473 c=0
Rk10 (\8\:non \10\:non) resistor r=0.1057 c=0
Rk11 (\8\:non \12\:non) resistor r=0.2549 c=0
Rl2 (\2\:OE \3\:OE) resistor r=87.6374 c=0
Rl1 (\1\:OE \2\:OE) resistor r=30.7692 c=0
Rl5 (\4\:OE \5\:OE) resistor r=99.7141 c=0
Rl7 (\5\:OE \7\:OE) resistor r=34.3295 c=0
Rl6 (\5\:OE \6\:OE) resistor r=4.3144 c=0
Rl11 (\4\:A \5\:A) resistor r=91.0764 c=0
Rl12 (\5\:A \6\:A) resistor r=29.5379 c=0
Rl3 (\1\:A \2\:A) resistor r=26.098 c=0
Rl4 (\2\:A \3\:A) resistor r=83.7903 c=0
Rl8 (OEb \2\:OEb) resistor r=150.308 c=0
Rl10 (\2\:OEb \4\:OEb) resistor r=23.7402 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=16.1277 c=0
Rl18 (non \4\:non) resistor r=3.203 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz11 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz3 (\9\:pon \8\:pon) resistor r=75 c=0
Rz1 (\9\:OEb \10\:OEb) resistor r=75 c=0
Rz2 (\12\:non \11\:non) resistor r=75 c=0
Ry10 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry7 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry3 (\7\:pon \6\:pon) resistor r=20.6667 c=0
Ry1 (\7\:OEb \8\:OEb) resistor r=62 c=0
Ry2 (\10\:non \9\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\5\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \9\:A) resistor r=45 c=0
Rx7 (\5\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\7\:non \4\:non) resistor r=45 c=0
mn4 (\8\:pon \1\:OE net144 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=3.64e-14 ps=7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.42692e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mn3 (net144 \3\:A \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.017e-14 ad=2.34e-14 ps=9.9e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.07692e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn2 (\11\:non \4\:OEb \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.58e-14 ad=5.72e-14 ps=1.22e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.105e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn1 (\11\:non \6\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.37e-14 ad=5.72e-14 ps=1.01e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=8.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn5_1__rcx (\1\:Y non \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.897e-14 ad=3.987e-14 ps=8.9667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=5.5e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(3)
mn0 (\9\:OEb \7\:OE \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.017e-14 ad=4.93e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mp0 (\7\:OEb \4\:OE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=22.5405 \
        scb=0.0210689 scc=0.00225095 m=(1)
ends TBUFX3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:32 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX4
// View name: extracted

simulator lang=spectre

subckt TBUFX4 A OE VDD VSS Y
mp4 (\9\:pon \1\:OE \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.07308e-07 sd=160n sca=21.9686 \
        scb=0.0221039 scc=0.00141228 m=(1)
mp3 (\9\:pon \1\:A \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.02308e-07 sd=160n sca=18.49 \
        scb=0.0162883 scc=0.00128386 m=(1)
mp2 (\11\:non OEb net127 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp1 (net127 \4\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.014e-13 ad=2.34e-14 ps=1.3e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.13e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp5_1__rcx (\1\:Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.605e-14 ps=1.14e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=8.25e-07 sd=160n sca=20.6353 \
        scb=0.0171431 scc=0.00197772 m=(4)
C1 (OE VSS) capacitor c=4.31668e-17
C2 (Y VSS) capacitor c=3.27362e-17
C3 (VDD VSS) capacitor c=1.35175e-16
C4 (A VSS) capacitor c=2.01907e-17
C5 (pon VSS) capacitor c=1.60181e-16
C6 (OEb VSS) capacitor c=8.70002e-17
C7 (non VSS) capacitor c=1.40894e-16
C8 (net127 VSS) capacitor c=3.89141e-18
C9 (\4\:A VSS) capacitor c=8.34227e-17
C10 (\4\:OE VSS) capacitor c=5.17027e-17
C11 (\1\:A VSS) capacitor c=5.40719e-17
C12 (\1\:OE VSS) capacitor c=4.6791e-17
C13 (\6\:A VSS) capacitor c=2.79496e-17
C14 (\4\:OEb VSS) capacitor c=3.65203e-17
C15 (\7\:OE VSS) capacitor c=3.41722e-17
C16 (\3\:A VSS) capacitor c=6.24173e-17
C17 (\3\:OE VSS) capacitor c=4.28931e-17
C18 (\5\:non VSS) capacitor c=2.67676e-17
C19 (\5\:A VSS) capacitor c=5.04083e-17
C20 (\3\:OEb VSS) capacitor c=1.38888e-17
C21 (\6\:OE VSS) capacitor c=2.18283e-17
C22 (\2\:A VSS) capacitor c=4.54516e-17
C23 (\2\:OE VSS) capacitor c=3.4116e-17
C24 (\1\:VDD VSS) capacitor c=1.69111e-16
C25 (\1\:Y VSS) capacitor c=1.374e-16
C26 (\11\:non VSS) capacitor c=4.52813e-17
C27 (\7\:OEb VSS) capacitor c=6.80612e-17
C28 (\14\:VDD VSS) capacitor c=3.63584e-17
C29 (\9\:pon VSS) capacitor c=2.094e-16
C30 (\16\:VDD VSS) capacitor c=2.81659e-17
C31 (\3\:VDD VSS) capacitor c=2.90347e-17
C32 (\13\:non VSS) capacitor c=6.3602e-17
C33 (\9\:OEb VSS) capacitor c=4.71348e-17
C34 (\11\:pon VSS) capacitor c=7.49417e-17
C35 (\5\:OE VSS) capacitor c=1.88729e-17
C36 (\2\:OEb VSS) capacitor c=3.31956e-17
C37 (\8\:OE VSS) capacitor c=3.24715e-17
C38 (\9\:OE VSS) capacitor c=3.27217e-17
C39 (\5\:OEb VSS) capacitor c=1.52632e-17
C40 (\6\:OEb VSS) capacitor c=4.4537e-17
C41 (\7\:A VSS) capacitor c=1.48533e-16
C42 (\8\:A VSS) capacitor c=1.57673e-16
C43 (\9\:A VSS) capacitor c=7.27974e-17
C44 (\9\:non VSS) capacitor c=7.18427e-17
C45 (\10\:non VSS) capacitor c=5.97279e-17
C46 (\8\:pon VSS) capacitor c=1.99117e-16
C47 (\4\:Y VSS) capacitor c=7.90216e-17
C48 (\8\:VDD VSS) capacitor c=1.5406e-17
C49 (\9\:VDD VSS) capacitor c=7.43772e-18
Rk1 (\8\:OE OE) resistor r=0.09997 c=0
Rk2 (OE \9\:OE) resistor r=0.1038 c=0
Rk15 (\1\:Y Y) resistor r=0.0738 c=0
Rk16 (Y \4\:Y) resistor r=0.21 c=0
Rk23 (\1\:VDD \7\:VDD) resistor r=0.2554 c=0
Rk24 (\7\:VDD \8\:VDD) resistor r=0.2755 c=0
Rk26 (\9\:VDD VDD) resistor r=0.06973 c=0
Rk25 (\8\:VDD \9\:VDD) resistor r=0.2051 c=0
Rk29 (\8\:VDD \15\:VDD) resistor r=0.2151 c=0
Rk30 (\9\:VDD \17\:VDD) resistor r=0.2573 c=0
Rk8 (\8\:A A) resistor r=0.003669 c=0
Rk6 (\7\:A \8\:A) resistor r=1.01 c=0
Rk7 (\8\:A \9\:A) resistor r=0.4051 c=0
Rk34 (\1\:VSS \7\:VSS) resistor r=0.286 c=0
Rk36 (\8\:VSS VSS) resistor r=0.2401 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.3113 c=0
Rk39 (\7\:VSS \14\:VSS) resistor r=0.07143 c=0
Rk40 (\8\:VSS \16\:VSS) resistor r=0.2329 c=0
Rk12 (\8\:pon \10\:pon) resistor r=1.3384 c=0
Rk13 (\10\:pon \12\:pon) resistor r=0.7152 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.05422 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.3249 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.179 c=0
Rk9 (\9\:non \10\:non) resistor r=0.3628 c=0
Rk10 (\10\:non \12\:non) resistor r=0.1488 c=0
Rk11 (\10\:non \14\:non) resistor r=0.238 c=0
Rl1 (\1\:OE \2\:OE) resistor r=87.2302 c=0
Rl2 (\2\:OE \3\:OE) resistor r=37.2302 c=0
Rl5 (\4\:OE \5\:OE) resistor r=118.464 c=0
Rl7 (\5\:OE \7\:OE) resistor r=28.0797 c=0
Rl6 (\5\:OE \6\:OE) resistor r=31.5487 c=0
Rl11 (\4\:A \5\:A) resistor r=99.1749 c=0
Rl12 (\5\:A \6\:A) resistor r=26.098 c=0
Rl3 (\1\:A \2\:A) resistor r=28.1965 c=0
Rl4 (\2\:A \3\:A) resistor r=90.1797 c=0
Rl8 (OEb \2\:OEb) resistor r=119.539 c=0
Rl10 (\2\:OEb \4\:OEb) resistor r=71.8171 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=14.532 c=0
Rl16 (non \5\:non) resistor r=24.9253 c=0
Rz6 (\1\:VDD \3\:VDD) resistor r=37.5 c=0
Rz7 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz3 (\12\:pon \11\:pon) resistor r=75 c=0
Rz1 (\9\:OEb \10\:OEb) resistor r=75 c=0
Rz2 (\14\:non \13\:non) resistor r=75 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry10 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry11 (\1\:VSS \3\:VSS) resistor r=31 c=0
Ry12 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry3 (\10\:pon \9\:pon) resistor r=20.6667 c=0
Ry1 (\7\:OEb \8\:OEb) resistor r=62 c=0
Ry2 (\12\:non \11\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\5\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \9\:A) resistor r=45 c=0
Rx7 (\8\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\9\:non \5\:non) resistor r=45 c=0
mn4 (\11\:pon \3\:OE net144 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=3.64e-14 ps=7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.39904e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn3 (net144 \3\:A \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=2.34e-14 ps=1.11e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.04904e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn2 (\13\:non \4\:OEb \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=4.94e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.31e-06 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1 (\13\:non \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.94e-14 ps=1.07e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.075e-06 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn5_1__rcx (\4\:Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.777e-14 ad=4.16e-14 ps=8.875e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\9\:OEb \7\:OE \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=3.987e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2.75e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp0 (\7\:OEb \4\:OE \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=22.3241 \
        scb=0.0209633 scc=0.0022509 m=(1)
ends TBUFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:33 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX6
// View name: extracted

simulator lang=spectre

subckt TBUFX6 A OE VDD VSS Y
mp2_1__rcx (\16\:non OEb 7 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_1__rcx (7 \10\:A \14\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_2__rcx (6 \13\:A \14\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=4.81e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.98e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp2_2__rcx (\13\:non \9\:OEb 6 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.29e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.75e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp2 (\13\:non \4\:OEb 8 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.47e-14 ad=4.29e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.54e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp1 (8 \18\:A \1\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.47e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=1.4e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp4_1__rcx (\13\:pon OE \16\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.29e-14 ps=8.2667e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40433e-06 sd=160n sca=23.1083 \
        scb=0.0266933 scc=0.00125052 m=(3)
mp3_1__rcx (\13\:pon \1\:A \16\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.925e-14 ad=4.29e-14 ps=1.1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18433e-06 sd=160n sca=16.3479 \
        scb=0.0155274 scc=0.000646302 m=(3)
C1 (Y VSS) capacitor c=3.79811e-16
C2 (A VSS) capacitor c=2.34996e-17
C3 (VDD VSS) capacitor c=2.29852e-16
C4 (OE VSS) capacitor c=4.17904e-16
C5 (12 VSS) capacitor c=1.62221e-18
C6 (pon VSS) capacitor c=2.79784e-16
C7 (13 VSS) capacitor c=2.34057e-18
C8 (OEb VSS) capacitor c=9.05948e-17
C9 (non VSS) capacitor c=2.23172e-16
C10 (7 VSS) capacitor c=2.23816e-18
C11 (6 VSS) capacitor c=6.89697e-18
C12 (8 VSS) capacitor c=2.90695e-18
C13 (\18\:A VSS) capacitor c=7.94912e-17
C14 (\4\:OEb VSS) capacitor c=4.87488e-17
C15 (\9\:OEb VSS) capacitor c=3.3048e-17
C16 (\13\:A VSS) capacitor c=4.75988e-17
C17 (\10\:A VSS) capacitor c=7.20938e-17
C18 (\10\:OE VSS) capacitor c=6.28533e-17
C19 (\1\:A VSS) capacitor c=4.50722e-16
C20 (\11\:A VSS) capacitor c=5.22262e-16
C21 (\13\:OE VSS) capacitor c=3.41186e-17
C22 (\9\:A VSS) capacitor c=8.48195e-17
C23 (\8\:OE VSS) capacitor c=4.03479e-17
C24 (\9\:OE VSS) capacitor c=5.05528e-17
C25 (\6\:A VSS) capacitor c=3.56188e-17
C26 (\4\:A VSS) capacitor c=6.46405e-17
C27 (\3\:OE VSS) capacitor c=6.11797e-17
C28 (\7\:non VSS) capacitor c=5.86071e-17
C29 (\2\:OEb VSS) capacitor c=3.69877e-16
C30 (\12\:OE VSS) capacitor c=4.10042e-17
C31 (\1\:VDD VSS) capacitor c=2.61222e-16
C32 (\13\:non VSS) capacitor c=4.84623e-17
C33 (\14\:VDD VSS) capacitor c=5.2671e-17
C34 (\16\:non VSS) capacitor c=1.28419e-16
C35 (\15\:OEb VSS) capacitor c=6.03981e-17
C36 (\13\:pon VSS) capacitor c=4.45566e-16
C37 (\4\:VDD VSS) capacitor c=2.28573e-17
C38 (\19\:non VSS) capacitor c=1.3963e-16
C39 (\13\:OEb VSS) capacitor c=4.27663e-17
C40 (\21\:pon VSS) capacitor c=9.1024e-17
C41 (\19\:pon VSS) capacitor c=1.08753e-16
C42 (\3\:A VSS) capacitor c=2.52945e-17
C43 (\11\:OE VSS) capacitor c=3.01544e-17
C44 (\16\:OE VSS) capacitor c=5.21264e-17
C45 (\12\:OEb VSS) capacitor c=2.81379e-17
C46 (\15\:non VSS) capacitor c=1.01411e-16
C47 (\18\:non VSS) capacitor c=8.42277e-17
C48 (\25\:non VSS) capacitor c=4.63025e-17
C49 (\12\:pon VSS) capacitor c=2.75582e-16
C50 (\13\:VDD VSS) capacitor c=2.89653e-17
C51 (\16\:VDD VSS) capacitor c=1.35609e-16
Rk8 (A \1\:A) resistor r=0.01324 c=0
Rk10 (\1\:A \11\:A) resistor r=0.8981 c=0
Rk58 (\1\:VDD \13\:VDD) resistor r=0.4234 c=0
Rk59 (\13\:VDD \15\:VDD) resistor r=0.2987 c=0
Rk69 (\16\:VDD VDD) resistor r=0.02463 c=0
Rk60 (\13\:VDD \16\:VDD) resistor r=0.4024 c=0
Rk3 (OE \16\:OE) resistor r=0.1909 c=0
Rk42 (\1\:VSS \12\:VSS) resistor r=0.2396 c=0
Rk44 (\13\:VSS VSS) resistor r=0.1801 c=0
Rk43 (\12\:VSS \13\:VSS) resistor r=0.3716 c=0
Rk50 (\12\:VSS \25\:VSS) resistor r=0.3631 c=0
Rk51 (\13\:VSS \27\:VSS) resistor r=0.2196 c=0
Rk20 (\12\:pon \13\:pon) resistor r=2.1909 c=0
Rk23 (\13\:pon \20\:pon) resistor r=0.5868 c=0
Rk24 (\20\:pon \22\:pon) resistor r=0.518 c=0
Rk5 (\2\:OEb \12\:OEb) resistor r=0.09138 c=0
Rk6 (\12\:OEb \14\:OEb) resistor r=0.2222 c=0
Rk7 (\12\:OEb \16\:OEb) resistor r=0.2842 c=0
Rk13 (\14\:non \15\:non) resistor r=0.1328 c=0
Rk14 (\15\:non \17\:non) resistor r=0.7773 c=0
Rk16 (\18\:non \19\:non) resistor r=0.0254 c=0
Rk15 (\15\:non \18\:non) resistor r=0.2504 c=0
Rk19 (\18\:non \25\:non) resistor r=0.1562 c=0
Rl30 (\11\:A \18\:A) resistor r=184.181 c=0
Rl22 (\11\:A \13\:A) resistor r=178.693 c=0
Rl20 (\11\:A \10\:A) resistor r=176.489 c=0
Rl14 (\1\:A \9\:A) resistor r=156.093 c=0
Rl4 (\3\:A \1\:A) resistor r=58.644 c=0
Rl7 (\3\:A \6\:A) resistor r=35.772 c=0
Rl5 (\3\:A \4\:A) resistor r=123.503 c=0
Rl11 (OE \8\:OE) resistor r=37.4796 c=0
Rl12 (OE \9\:OE) resistor r=83.5649 c=0
Rl2 (OE \3\:OE) resistor r=102.615 c=0
Rl15 (\11\:OE \10\:OE) resistor r=205.747 c=0
Rl17 (\11\:OE \13\:OE) resistor r=30.4507 c=0
Rl16 (\11\:OE \12\:OE) resistor r=36.87 c=0
Rl24 (\2\:OEb \4\:OEb) resistor r=137.695 c=0
Rl28 (\2\:OEb \9\:OEb) resistor r=107.487 c=0
Rl18 (\2\:OEb OEb) resistor r=132.258 c=0
Rl46 (non \7\:non) resistor r=11.1519 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz20 (\16\:VDD \4\:VDD) resistor r=6.25 c=0
Rz17 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz18 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz5 (\20\:pon \19\:pon) resistor r=75 c=0
Rz6 (\22\:pon \21\:pon) resistor r=75 c=0
Rz1 (\14\:OEb \13\:OEb) resistor r=75 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry10 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry11 (\12\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry1 (\16\:OEb \15\:OEb) resistor r=62 c=0
Ry2 (\14\:non \13\:non) resistor r=62 c=0
Ry3 (\17\:non \16\:non) resistor r=62 c=0
Rx3 (\16\:OE \12\:OE) resistor r=45 c=0
Rx12 (\12\:pon pon) resistor r=45 c=0
Rx11 (\25\:non \7\:non) resistor r=45 c=0
mn4_1__rcx (\19\:pon \3\:OE 12 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.02e-14 ad=2.38e-14 ps=4.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26618e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_1__rcx (12 \4\:A \26\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.02e-14 ps=1.01e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.16118e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_2__rcx (13 \6\:A \26\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.36e-14 ps=1.01e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.96176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4_2__rcx (\21\:pon \9\:OE 13 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.36e-14 ad=2.77e-14 ps=5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=7.71176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn2 (\19\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.872e-14 ad=2.933e-14 ps=1.37e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn1 (\19\:non \11\:A \1\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=8.005e-14 ad=2.932e-14 ps=1.47e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn4 (\21\:pon \8\:OE 14 VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=1.05e-14 ad=2.77e-14 ps=4.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18857e-07 sb=5.68143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn3 (14 \9\:A \24\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=1.05e-14 ps=8.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.23857e-07 sb=4.63143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn2_2__rcx (\19\:non \2\:OEb \1\:VSS VSS) g45n1hvt w=(1.75e-07) \
        l=4.5e-08 nf=1 as=7.605e-14 ad=2.8e-14 ps=1.42e-06 pd=6.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.06371e-06 sb=1.59e-06 sd=160n \
        sca=12.1767 scb=0.0122352 scc=0.000549928 m=(1)
mn1_2__rcx (\19\:non \11\:A \1\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 \
        nf=1 as=3.912e-14 ad=2.8e-14 ps=8.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26871e-06 sb=1.385e-06 sd=160n sca=12.1767 \
        scb=0.0122352 scc=0.000549928 m=(1)
mn0 (\13\:OEb \13\:OE \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=3.553e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20448e-06 sb=2.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.032e-14 ad=4.16e-14 ps=8.3833e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03471e-06 sb=1.165e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(6)
mp0 (\15\:OEb \10\:OE \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=6.24e-14 ps=1.10333e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.23333e-07 sb=1.165e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(6)
ends TBUFX6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:34 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFX8
// View name: extracted

simulator lang=spectre

subckt TBUFX8 A OE VDD VSS Y
mp2_1__rcx (\20\:non OEb 6 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_1__rcx (6 \10\:A \25\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_2__rcx (7 \13\:A \25\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=3.38e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp2_2__rcx (\17\:non \9\:OEb 7 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.38e-14 ad=5.72e-14 ps=7.8e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp2 (\17\:non \4\:OEb 8 VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.47e-14 ad=5.72e-14 ps=7.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.95e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp1 (8 \18\:A \3\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.47e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=1.81e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp4 (\17\:pon OE \10\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.29e-14 ps=8.2667e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40433e-06 sd=160n sca=23.1083 \
        scb=0.0266933 scc=0.00125052 m=(3)
mp3_1__rcx (\17\:pon \1\:A \10\:VDD VDD) g45p1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.925e-14 ad=4.29e-14 ps=1.1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18433e-06 sd=160n sca=16.3479 \
        scb=0.0155274 scc=0.000646302 m=(3)
C1 (Y VSS) capacitor c=5.01676e-16
C2 (A VSS) capacitor c=2.34996e-17
C3 (VDD VSS) capacitor c=2.4049e-16
C4 (OE VSS) capacitor c=4.17962e-16
C5 (12 VSS) capacitor c=1.62221e-18
C6 (pon VSS) capacitor c=3.59e-16
C7 (13 VSS) capacitor c=2.34057e-18
C8 (OEb VSS) capacitor c=9.20571e-17
C9 (non VSS) capacitor c=3.02782e-16
C10 (6 VSS) capacitor c=2.23816e-18
C11 (7 VSS) capacitor c=4.58974e-18
C12 (8 VSS) capacitor c=2.90695e-18
C13 (\18\:A VSS) capacitor c=7.94912e-17
C14 (\4\:OEb VSS) capacitor c=5.0416e-17
C15 (\9\:OEb VSS) capacitor c=3.93408e-17
C16 (\13\:A VSS) capacitor c=4.66713e-17
C17 (\10\:A VSS) capacitor c=7.25011e-17
C18 (\10\:OE VSS) capacitor c=6.29561e-17
C19 (\1\:A VSS) capacitor c=4.54671e-16
C20 (\11\:A VSS) capacitor c=5.31024e-16
C21 (\13\:OE VSS) capacitor c=3.40843e-17
C22 (\9\:A VSS) capacitor c=8.48325e-17
C23 (\8\:OE VSS) capacitor c=4.03325e-17
C24 (\9\:OE VSS) capacitor c=5.05435e-17
C25 (\6\:A VSS) capacitor c=3.56188e-17
C26 (\4\:A VSS) capacitor c=6.46405e-17
C27 (\3\:OE VSS) capacitor c=6.11723e-17
C28 (\9\:non VSS) capacitor c=5.99545e-17
C29 (\2\:OEb VSS) capacitor c=3.73982e-16
C30 (\12\:OE VSS) capacitor c=4.09826e-17
C31 (\17\:non VSS) capacitor c=5.01049e-17
C32 (\25\:VDD VSS) capacitor c=5.29358e-17
C33 (\20\:non VSS) capacitor c=1.27721e-16
C34 (\15\:OEb VSS) capacitor c=5.79011e-17
C35 (\17\:pon VSS) capacitor c=4.45781e-16
C36 (\1\:VDD VSS) capacitor c=1.90618e-17
C37 (\23\:non VSS) capacitor c=1.39944e-16
C38 (\13\:OEb VSS) capacitor c=4.14604e-17
C39 (\25\:pon VSS) capacitor c=9.1024e-17
C40 (\23\:pon VSS) capacitor c=1.08753e-16
C41 (\3\:A VSS) capacitor c=2.52964e-17
C42 (\11\:OE VSS) capacitor c=2.97719e-17
C43 (\16\:OE VSS) capacitor c=5.21285e-17
C44 (\12\:OEb VSS) capacitor c=3.16241e-17
C45 (\19\:non VSS) capacitor c=1.00043e-16
C46 (\22\:non VSS) capacitor c=8.46472e-17
C47 (\29\:non VSS) capacitor c=4.62829e-17
C48 (\16\:pon VSS) capacitor c=2.74092e-16
C49 (\3\:VDD VSS) capacitor c=3.39047e-16
C50 (\9\:VDD VSS) capacitor c=2.87657e-17
C51 (\10\:VDD VSS) capacitor c=1.35609e-16
Rk8 (A \1\:A) resistor r=0.01324 c=0
Rk10 (\1\:A \11\:A) resistor r=0.8955 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.09259 c=0
Rk66 (\3\:VDD \9\:VDD) resistor r=0.4234 c=0
Rk72 (\10\:VDD VDD) resistor r=0.02463 c=0
Rk67 (\9\:VDD \10\:VDD) resistor r=0.4024 c=0
Rk78 (\9\:VDD \26\:VDD) resistor r=0.2987 c=0
Rk3 (OE \16\:OE) resistor r=0.1909 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.06752 c=0
Rk47 (\3\:VSS \12\:VSS) resistor r=0.2396 c=0
Rk57 (\29\:VSS VSS) resistor r=0.1801 c=0
Rk56 (\12\:VSS \29\:VSS) resistor r=0.3716 c=0
Rk58 (\12\:VSS \31\:VSS) resistor r=0.3631 c=0
Rk59 (\29\:VSS \33\:VSS) resistor r=0.2196 c=0
Rk20 (\16\:pon \17\:pon) resistor r=2.1909 c=0
Rk23 (\17\:pon \24\:pon) resistor r=0.5868 c=0
Rk24 (\24\:pon \26\:pon) resistor r=0.518 c=0
Rk5 (\2\:OEb \12\:OEb) resistor r=0.1315 c=0
Rk6 (\12\:OEb \14\:OEb) resistor r=0.18 c=0
Rk7 (\12\:OEb \16\:OEb) resistor r=0.2708 c=0
Rk13 (\18\:non \19\:non) resistor r=0.1328 c=0
Rk14 (\19\:non \21\:non) resistor r=0.768 c=0
Rk16 (\22\:non \23\:non) resistor r=0.0254 c=0
Rk15 (\19\:non \22\:non) resistor r=0.2504 c=0
Rk19 (\22\:non \29\:non) resistor r=0.1562 c=0
Rl30 (\11\:A \18\:A) resistor r=184.181 c=0
Rl22 (\11\:A \13\:A) resistor r=178.693 c=0
Rl20 (\11\:A \10\:A) resistor r=176.489 c=0
Rl14 (\1\:A \9\:A) resistor r=156.093 c=0
Rl4 (\3\:A \1\:A) resistor r=58.644 c=0
Rl7 (\3\:A \6\:A) resistor r=35.772 c=0
Rl5 (\3\:A \4\:A) resistor r=123.503 c=0
Rl11 (OE \8\:OE) resistor r=37.4796 c=0
Rl12 (OE \9\:OE) resistor r=83.5649 c=0
Rl2 (OE \3\:OE) resistor r=102.615 c=0
Rl15 (\11\:OE \10\:OE) resistor r=205.747 c=0
Rl17 (\11\:OE \13\:OE) resistor r=30.4507 c=0
Rl16 (\11\:OE \12\:OE) resistor r=36.87 c=0
Rl24 (\2\:OEb \4\:OEb) resistor r=137.695 c=0
Rl28 (\2\:OEb \9\:OEb) resistor r=107.487 c=0
Rl18 (\2\:OEb OEb) resistor r=132.258 c=0
Rl52 (non \9\:non) resistor r=11.1519 c=0
Rz21 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz22 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz20 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz5 (\24\:pon \23\:pon) resistor r=75 c=0
Rz6 (\26\:pon \25\:pon) resistor r=75 c=0
Rz1 (\14\:OEb \13\:OEb) resistor r=75 c=0
Ry19 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\16\:OEb \15\:OEb) resistor r=62 c=0
Ry2 (\18\:non \17\:non) resistor r=62 c=0
Ry3 (\21\:non \20\:non) resistor r=62 c=0
Rx3 (\16\:OE \12\:OE) resistor r=45 c=0
Rx12 (\16\:pon pon) resistor r=45 c=0
Rx11 (\29\:non \9\:non) resistor r=45 c=0
mn4_1__rcx (\23\:pon \3\:OE 12 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.02e-14 ad=2.38e-14 ps=4.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26618e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_1__rcx (12 \4\:A \32\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.02e-14 ps=1.01e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.16118e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_2__rcx (13 \6\:A \32\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.36e-14 ps=1.01e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.96176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4_2__rcx (\25\:pon \9\:OE 13 VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.36e-14 ad=2.77e-14 ps=5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=7.71176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn2 (\23\:non \2\:OEb \3\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.872e-14 ad=2.933e-14 ps=1.37e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn1 (\23\:non \11\:A \3\:VSS VSS) g45n1hvt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=8.005e-14 ad=2.932e-14 ps=1.47e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn4 (\25\:pon \8\:OE 14 VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=1.05e-14 ad=2.77e-14 ps=4.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18857e-07 sb=5.68143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn3 (14 \9\:A \30\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=1.05e-14 ps=8.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.23857e-07 sb=4.63143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn2_2__rcx (\23\:non \2\:OEb \3\:VSS VSS) g45n1hvt w=(1.75e-07) \
        l=4.5e-08 nf=1 as=7.605e-14 ad=2.8e-14 ps=1.42e-06 pd=6.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.06371e-06 sb=2e-06 sd=160n \
        sca=12.1767 scb=0.0122352 scc=0.000549928 m=(1)
mn1_2__rcx (\23\:non \11\:A \3\:VSS VSS) g45n1hvt w=(1.75e-07) l=4.5e-08 \
        nf=1 as=3.912e-14 ad=2.8e-14 ps=8.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26871e-06 sb=1.795e-06 sd=160n sca=12.1767 \
        scb=0.0122352 scc=0.000549928 m=(1)
mn0 (\13\:OEb \13\:OE \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=3.553e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20448e-06 sb=2.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn5_1__rcx (Y non \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.064e-14 ad=4.16e-14 ps=8.3875e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03471e-06 sb=1.575e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(8)
mp0 (\15\:OEb \10\:OE \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp5_1__rcx (Y pon \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.142e-14 ad=6.24e-14 ps=1.1025e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.23333e-07 sb=1.575e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(8)
ends TBUFX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:35 2013 )
// Library name: gsclib045_hvt
// Cell name: TBUFXL
// View name: extracted

simulator lang=spectre

subckt TBUFXL A OE VDD VSS Y
mp4 (\5\:pon \3\:OE \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=23.8733 \
        scb=0.0264891 scc=0.00148688 m=(1)
mp3 (\5\:pon \1\:A \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.44e-14 ps=1.32e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.05e-07 sd=160n sca=13.8395 \
        scb=0.0118164 scc=0.000122256 m=(1)
mp0 (\6\:OEb \4\:OE \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.1189 \
        scb=0.00792127 scc=8.08408e-05 m=(1)
mp2 (\5\:non OEb net127 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=28.9946 \
        scb=0.0243497 scc=0.00347661 m=(1)
mp1 (net127 \4\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.043e-13 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=29.4689 \
        scb=0.0246948 scc=0.00347702 m=(1)
mp5 (\1\:Y pon \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.043e-13 ad=3.01e-14 ps=1.82e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=32.5034 \
        scb=0.0292389 scc=0.00353613 m=(1)
C1 (OE VSS) capacitor c=2.21604e-17
C2 (VDD VSS) capacitor c=1.8931e-16
C3 (A VSS) capacitor c=1.83678e-17
C4 (pon VSS) capacitor c=4.86582e-17
C5 (OEb VSS) capacitor c=6.25111e-17
C6 (non VSS) capacitor c=4.63215e-17
C7 (\4\:A VSS) capacitor c=8.07172e-17
C8 (\4\:OE VSS) capacitor c=5.01905e-17
C9 (\1\:A VSS) capacitor c=4.53026e-17
C10 (\3\:OE VSS) capacitor c=4.41271e-17
C11 (\5\:A VSS) capacitor c=5.74211e-17
C12 (\3\:OEb VSS) capacitor c=3.0725e-17
C13 (\6\:OE VSS) capacitor c=4.25186e-17
C14 (\3\:A VSS) capacitor c=6.5642e-17
C15 (\1\:OE VSS) capacitor c=4.81758e-17
C16 (\2\:pon VSS) capacitor c=2.08242e-17
C17 (\2\:non VSS) capacitor c=4.01256e-17
C18 (\6\:A VSS) capacitor c=2.66037e-17
C19 (\2\:OEb VSS) capacitor c=4.3534e-17
C20 (\5\:OE VSS) capacitor c=4.22448e-17
C21 (\2\:A VSS) capacitor c=6.86384e-17
C22 (\2\:OE VSS) capacitor c=5.56721e-17
C23 (\1\:Y VSS) capacitor c=3.31083e-17
C24 (\1\:VDD VSS) capacitor c=3.82263e-17
C25 (\5\:non VSS) capacitor c=6.10096e-17
C26 (\6\:OEb VSS) capacitor c=8.15421e-17
C27 (\8\:VDD VSS) capacitor c=2.45385e-17
C28 (\5\:pon VSS) capacitor c=1.83542e-16
C29 (\6\:VDD VSS) capacitor c=3.12628e-17
C30 (\3\:Y VSS) capacitor c=4.52945e-17
C31 (\7\:non VSS) capacitor c=3.91306e-17
C32 (\8\:OEb VSS) capacitor c=5.90211e-17
C33 (\3\:pon VSS) capacitor c=7.40779e-17
C34 (\7\:OE VSS) capacitor c=5.249e-17
C35 (\9\:OE VSS) capacitor c=5.56997e-17
C36 (\4\:OEb VSS) capacitor c=3.06565e-17
C37 (\5\:OEb VSS) capacitor c=8.77883e-17
C38 (\7\:A VSS) capacitor c=1.59929e-16
C39 (\8\:A VSS) capacitor c=1.86645e-16
C40 (\3\:non VSS) capacitor c=3.16143e-17
C41 (\4\:non VSS) capacitor c=3.97846e-17
C42 (\7\:pon VSS) capacitor c=1.21116e-16
C43 (\4\:VDD VSS) capacitor c=3.05783e-17
C44 (\5\:VDD VSS) capacitor c=2.17526e-17
Rk3 (\8\:OE OE) resistor r=0.05673 c=0
Rk1 (\7\:OE \8\:OE) resistor r=0.1998 c=0
Rk2 (\8\:OE \9\:OE) resistor r=0.037 c=0
Rk14 (Y \2\:Y) resistor r=0.002901 c=0
Rk15 (\2\:Y \4\:Y) resistor r=0.3392 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.3155 c=0
Rk23 (\5\:VDD VDD) resistor r=0.2195 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2295 c=0
Rk24 (VDD \7\:VDD) resistor r=0.239 c=0
Rk25 (\5\:VDD \9\:VDD) resistor r=0.04328 c=0
Rk8 (\8\:A A) resistor r=0.02018 c=0
Rk7 (\7\:A \8\:A) resistor r=1.3617 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.07144 c=0
Rk18 (\5\:VSS VSS) resistor r=0.1976 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.253 c=0
Rk19 (\4\:VSS \7\:VSS) resistor r=0.6425 c=0
Rk20 (\5\:VSS \9\:VSS) resistor r=0.2832 c=0
Rk12 (\4\:pon \6\:pon) resistor r=0.671 c=0
Rk13 (\6\:pon \7\:pon) resistor r=1.0729 c=0
Rk4 (\4\:OEb \5\:OEb) resistor r=0.09647 c=0
Rk5 (\5\:OEb \7\:OEb) resistor r=0.5589 c=0
Rk6 (\5\:OEb \9\:OEb) resistor r=0.2473 c=0
Rk9 (\3\:non \4\:non) resistor r=0.1183 c=0
Rk10 (\4\:non \6\:non) resistor r=0.3397 c=0
Rk11 (\4\:non \8\:non) resistor r=0.1145 c=0
Rl5 (\4\:OE \5\:OE) resistor r=131.02 c=0
Rl6 (\5\:OE \6\:OE) resistor r=76.1559 c=0
Rl2 (\2\:OE \3\:OE) resistor r=135.714 c=0
Rl1 (\1\:OE \2\:OE) resistor r=75 c=0
Rl9 (\4\:A \5\:A) resistor r=129.43 c=0
Rl10 (\5\:A \6\:A) resistor r=35.3072 c=0
Rl3 (\1\:A \2\:A) resistor r=60.7713 c=0
Rl4 (\2\:A \3\:A) resistor r=155.323 c=0
Rl12 (pon \2\:pon) resistor r=71.8456 c=0
Rl7 (OEb \2\:OEb) resistor r=93.7849 c=0
Rl8 (\2\:OEb \3\:OEb) resistor r=24.2328 c=0
Rl11 (non \2\:non) resistor r=35.2058 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\3\:pon \4\:pon) resistor r=75 c=0
Rz1 (\8\:OEb \9\:OEb) resistor r=75 c=0
Rz2 (\7\:non \8\:non) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry3 (\5\:pon \6\:pon) resistor r=62 c=0
Ry1 (\6\:OEb \7\:OEb) resistor r=62 c=0
Ry2 (\5\:non \6\:non) resistor r=62 c=0
Rx1 (\5\:OE \7\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\6\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \8\:A) resistor r=45 c=0
Rx7 (\2\:pon \7\:pon) resistor r=45 c=0
Rx3 (\2\:OEb \4\:OEb) resistor r=45 c=0
Rx6 (\2\:non \3\:non) resistor r=45 c=0
mn4 (\3\:pon \1\:OE net144 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=6.25e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (net144 \3\:A \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.358e-14 ad=8.7e-15 ps=9.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=5.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn0 (\8\:OEb \6\:OE \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.358e-14 ad=3.19e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn2 (\7\:non \3\:OEb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.025e-14 ad=2.32e-14 ps=1.39e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.65e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (\7\:non \5\:A \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.6e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn5 (\3\:Y non \6\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
ends TBUFXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:36 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X12
// View name: extracted

simulator lang=spectre

subckt CLKAND2X12 A B VDD VSS Y
mp1_1__rcx (\44\:net61 \2\:B \1\:VDD VDD) g45p1hvt w=(2.35e-07) \
        l=4.5e-08 nf=1 as=5.53e-14 ad=3.76e-14 ps=1.43e-06 pd=7.9e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.9528 \
        scb=0.026615 scc=0.00120831 m=(5)
mp0_1__rcx (\44\:net61 A \1\:VDD VDD) g45p1hvt w=(2.35e-07) l=4.5e-08 \
        nf=1 as=7.119e-14 ad=3.76e-14 ps=1.66e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.4006 scb=0.0157854 \
        scc=0.000608134 m=(5)
C1 (Y VSS) capacitor c=1.66749e-17
C2 (B VSS) capacitor c=1.3991e-17
C3 (VDD VSS) capacitor c=2.14813e-16
C4 (A VSS) capacitor c=6.63702e-16
C5 (7 VSS) capacitor c=2.60375e-18
C6 (net61 VSS) capacitor c=8.40858e-16
C7 (8 VSS) capacitor c=1.81486e-18
C8 (9 VSS) capacitor c=4.09274e-18
C9 (10 VSS) capacitor c=7.05118e-18
C10 (11 VSS) capacitor c=1.93492e-18
C11 (\16\:A VSS) capacitor c=6.73325e-17
C12 (\13\:B VSS) capacitor c=5.64157e-17
C13 (\14\:B VSS) capacitor c=2.50956e-17
C14 (\12\:A VSS) capacitor c=3.284e-17
C15 (\11\:A VSS) capacitor c=4.13281e-17
C16 (\8\:B VSS) capacitor c=2.91402e-17
C17 (\7\:B VSS) capacitor c=5.56445e-17
C18 (\1\:A VSS) capacitor c=5.22635e-17
C19 (\7\:A VSS) capacitor c=4.18917e-17
C20 (\1\:B VSS) capacitor c=5.08407e-17
C21 (\2\:B VSS) capacitor c=6.25694e-16
C22 (\1\:VDD VSS) capacitor c=5.53928e-16
C23 (\44\:net61 VSS) capacitor c=2.9277e-16
C24 (\1\:Y VSS) capacitor c=4.89206e-16
C25 (\54\:net61 VSS) capacitor c=2.45105e-17
C26 (\40\:net61 VSS) capacitor c=1.52289e-16
C27 (\42\:net61 VSS) capacitor c=5.68426e-17
C28 (\38\:net61 VSS) capacitor c=7.24476e-17
C29 (\39\:net61 VSS) capacitor c=8.83729e-17
C30 (\9\:Y VSS) capacitor c=6.15551e-16
Rk27 (\1\:Y Y) resistor r=0.2439 c=0
Rk28 (Y \9\:Y) resistor r=0.05423 c=0
Rk2 (\2\:B B) resistor r=0.02594 c=0
Rk68 (\1\:VSS \11\:VSS) resistor r=0.3883 c=0
Rk69 (\11\:VSS \12\:VSS) resistor r=0.04243 c=0
Rk71 (\13\:VSS VSS) resistor r=0.2428 c=0
Rk70 (\12\:VSS \13\:VSS) resistor r=0.3082 c=0
Rk76 (\11\:VSS \23\:VSS) resistor r=0.254 c=0
Rk77 (\13\:VSS \25\:VSS) resistor r=0.254 c=0
Rk61 (\1\:VDD VDD) resistor r=0.02463 c=0
Rk12 (net61 \38\:net61) resistor r=0.112 c=0
Rk16 (\38\:net61 \44\:net61) resistor r=0.3956 c=0
Rk13 (\38\:net61 \39\:net61) resistor r=0.4363 c=0
Rk14 (\39\:net61 \41\:net61) resistor r=0.6352 c=0
Rk15 (\41\:net61 \43\:net61) resistor r=0.5463 c=0
Rk21 (\39\:net61 \55\:net61) resistor r=0.05786 c=0
Rl21 (\2\:B \13\:B) resistor r=58.8489 c=0
Rl22 (\2\:B \14\:B) resistor r=35.7713 c=0
Rl12 (\2\:B \8\:B) resistor r=24.7951 c=0
Rl11 (\2\:B \7\:B) resistor r=71.1317 c=0
Rl1 (\2\:B \1\:B) resistor r=44.0258 c=0
Rl25 (A \16\:A) resistor r=53.6412 c=0
Rl17 (A \12\:A) resistor r=93.9123 c=0
Rl16 (A \11\:A) resistor r=97.9249 c=0
Rl3 (A \1\:A) resistor r=33.5003 c=0
Rl8 (A \7\:A) resistor r=35.9003 c=0
Rz17 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz18 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz1 (\41\:net61 \40\:net61) resistor r=75 c=0
Rz2 (\43\:net61 \42\:net61) resistor r=37.5 c=0
Rz3 (\55\:net61 \54\:net61) resistor r=37.5 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry23 (\12\:VSS \4\:VSS) resistor r=5.1667 c=0
mn1_1__rcx (\42\:net61 \1\:B 7 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.635e-14 ad=4.34e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_1__rcx (7 \7\:A \24\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=2.635e-14 ps=9.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_2__rcx (8 \1\:A \24\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.86e-14 ps=9.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn1_2__rcx (\40\:net61 \7\:B 8 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn1_3__rcx (\40\:net61 \8\:B 9 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_3__rcx (9 \11\:A \22\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_4__rcx (10 \12\:A \22\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.665e-14 ps=9.4e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn1_4__rcx (\54\:net61 \14\:B 10 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=4.96e-14 ps=1.05e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.435e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn1 (\54\:net61 \13\:B 11 VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0 (11 \16\:A \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=1.86e-14 ps=1.08e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.745e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn2_1__rcx (\1\:Y net61 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.332e-14 ad=4.96e-14 ps=9.64e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(10)
mp2_1__rcx (\9\:Y net61 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.798e-14 ad=7.52e-14 ps=1.32e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06266e-06 sb=1.985e-06 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(10)
ends CLKAND2X12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:37 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X2
// View name: extracted

simulator lang=spectre

subckt CLKAND2X2 A B VDD VSS Y
mp1 (\10\:net61 \4\:B \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.46e-14 ad=4.623e-14 ps=1.36e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=8.6e-07 sd=160n sca=29.6691 scb=0.0324961 \
        scc=0.00263757 m=(1)
mp0 (\10\:net61 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.623e-14 ps=1.1e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6e-07 sd=160n sca=14.8606 scb=0.0129927 \
        scc=0.000217202 m=(1)
C1 (B VSS) capacitor c=9.3438e-17
C2 (Y VSS) capacitor c=1.5463e-17
C3 (VDD VSS) capacitor c=7.66115e-17
C4 (A VSS) capacitor c=6.36475e-17
C5 (net69 VSS) capacitor c=2.52116e-18
C6 (net61 VSS) capacitor c=1.69671e-16
C7 (\1\:A VSS) capacitor c=5.1647e-17
C8 (\4\:B VSS) capacitor c=3.00104e-17
C9 (\3\:A VSS) capacitor c=7.59408e-17
C10 (\1\:B VSS) capacitor c=7.29507e-17
C11 (\2\:A VSS) capacitor c=5.9408e-17
C12 (\3\:B VSS) capacitor c=1.11362e-17
C13 (\1\:VDD VSS) capacitor c=9.67013e-17
C14 (\4\:Y VSS) capacitor c=8.48814e-17
C15 (\10\:net61 VSS) capacitor c=9.47423e-17
C16 (\6\:VDD VSS) capacitor c=1.55956e-17
C17 (\2\:Y VSS) capacitor c=4.97875e-17
C18 (\8\:net61 VSS) capacitor c=7.68918e-17
C19 (\2\:B VSS) capacitor c=3.62486e-17
C20 (\4\:A VSS) capacitor c=5.33542e-17
C21 (\7\:net61 VSS) capacitor c=6.74277e-17
C22 (\1\:Y VSS) capacitor c=5.55137e-17
Rk15 (\1\:VSS VSS) resistor r=0.2149 c=0
Rk1 (B \5\:B) resistor r=0.002991 c=0
Rk5 (Y \1\:Y) resistor r=0.01983 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.2677 c=0
Rk7 (\1\:Y \5\:Y) resistor r=0.4037 c=0
Rk10 (\1\:VDD VDD) resistor r=0.2153 c=0
Rk11 (VDD \7\:VDD) resistor r=0.0793 c=0
Rk2 (A \4\:A) resistor r=0.1841 c=0
Rk3 (\7\:net61 \9\:net61) resistor r=0.3931 c=0
Rk4 (\9\:net61 \11\:net61) resistor r=0.4633 c=0
Rl3 (\2\:B \4\:B) resistor r=87.2017 c=0
Rl1 (\1\:B \2\:B) resistor r=144.539 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl4 (\1\:A \2\:A) resistor r=135.307 c=0
Rl5 (\2\:A \3\:A) resistor r=44.9225 c=0
Rz2 (\3\:Y \2\:Y) resistor r=75 c=0
Rz1 (\9\:net61 \8\:net61) resistor r=75 c=0
Ry2 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\11\:net61 \10\:net61) resistor r=62 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:net61 net61) resistor r=45 c=0
mn1 (\8\:net61 \1\:B net69 VSS) g45n1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=4.06e-14 ps=7e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.53276e-07 sd=160n sca=11.0503 \
        scb=0.01032 scc=0.000482273 m=(1)
mn0 (net69 \3\:A \1\:VSS VSS) g45n1hvt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=4.46e-14 ad=1.74e-14 ps=9e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.48276e-07 sd=160n sca=11.0503 scb=0.01032 \
        scc=0.000482273 m=(1)
mn2 (\2\:Y net61 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.7e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=3.95e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(2)
mp2 (\4\:Y net61 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.3e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.56346e-07 sb=3.95e-07 sd=160n sca=21.7424 \
        scb=0.0181571 scc=0.00171859 m=(2)
ends CLKAND2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:38 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X3
// View name: extracted

simulator lang=spectre

subckt CLKAND2X3 A B VDD VSS Y
mp0 (\13\:net61 A VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=3.12e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43e-06 sd=160n sca=42.2144 \
        scb=0.0437053 scc=0.00493222 m=(2)
mp1 (\13\:net61 \1\:B \8\:VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=3.12e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.225e-06 sd=160n sca=32.1806 \
        scb=0.0290326 scc=0.0035676 m=(2)
C1 (Y VSS) capacitor c=1.8614e-17
C2 (VDD VSS) capacitor c=2.20101e-16
C3 (A VSS) capacitor c=3.25775e-16
C4 (7 VSS) capacitor c=5.24972e-20
C5 (net61 VSS) capacitor c=2.0115e-16
C6 (8 VSS) capacitor c=1.71309e-18
C7 (\1\:B VSS) capacitor c=1.07402e-16
C8 (\6\:A VSS) capacitor c=5.49003e-17
C9 (\5\:B VSS) capacitor c=5.72848e-17
C10 (\4\:B VSS) capacitor c=5.91741e-17
C11 (\1\:A VSS) capacitor c=5.27627e-17
C12 (\1\:Y VSS) capacitor c=1.25808e-16
C13 (\13\:net61 VSS) capacitor c=1.1073e-16
C14 (\8\:VDD VSS) capacitor c=6.45403e-18
C15 (\4\:Y VSS) capacitor c=8.06264e-17
C16 (\17\:net61 VSS) capacitor c=7.47939e-17
C17 (\8\:B VSS) capacitor c=6.69963e-17
C18 (\9\:B VSS) capacitor c=3.93431e-17
C19 (\11\:net61 VSS) capacitor c=2.84853e-17
C20 (\12\:net61 VSS) capacitor c=7.84754e-17
Rk24 (\6\:VSS VSS) resistor r=0.04948 c=0
Rk23 (\1\:VSS \6\:VSS) resistor r=0.2942 c=0
Rk26 (\6\:VSS \10\:VSS) resistor r=0.2012 c=0
Rk1 (\7\:B \8\:B) resistor r=0.001871 c=0
Rk2 (\9\:B B) resistor r=0.001871 c=0
Rk3 (\8\:B \9\:B) resistor r=0.0327 c=0
Rk11 (\1\:Y Y) resistor r=0.1674 c=0
Rk12 (Y \4\:Y) resistor r=0.1131 c=0
Rk18 (VDD \9\:VDD) resistor r=0.07277 c=0
Rk7 (\12\:net61 \13\:net61) resistor r=0.3997 c=0
Rk6 (\11\:net61 \12\:net61) resistor r=0.1104 c=0
Rk9 (\12\:net61 \18\:net61) resistor r=0.4532 c=0
Rl6 (\1\:B \5\:B) resistor r=99.2335 c=0
Rl5 (\1\:B \4\:B) resistor r=98.8098 c=0
Rl9 (A \6\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=28.6412 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\18\:net61 \17\:net61) resistor r=75 c=0
Ry7 (\9\:VDD \8\:VDD) resistor r=62 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
Rx4 (\11\:net61 net61) resistor r=45 c=0
mn0_1__rcx (7 \1\:A \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.27e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (\17\:net61 \4\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.165e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\17\:net61 \5\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.6e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (8 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=8.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\4\:Y net61 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.027e-14 ad=3.987e-14 ps=9.0667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(3)
mp2 (\1\:Y net61 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.012e-14 ad=5.98e-14 ps=1.38333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=5.5e-07 sd=160n sca=20.4293 \
        scb=0.0170251 scc=0.00184286 m=(3)
ends CLKAND2X3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:39 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X4
// View name: extracted

simulator lang=spectre

subckt CLKAND2X4 A B VDD VSS Y
mp0_1__rcx (\17\:net61 A \1\:VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=6.995e-14 ad=3.12e-14 ps=1.84e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.645e-06 sd=160n sca=36.6813 \
        scb=0.0366529 scc=0.00396633 m=(2)
mp1 (\17\:net61 \1\:B \11\:VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=3.12e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.44e-06 sd=160n sca=31.0619 \
        scb=0.0271542 scc=0.0035377 m=(2)
C1 (Y VSS) capacitor c=2.00271e-17
C2 (B VSS) capacitor c=4.79274e-17
C3 (VDD VSS) capacitor c=8.37522e-17
C4 (A VSS) capacitor c=3.27292e-16
C5 (7 VSS) capacitor c=1.16406e-19
C6 (net61 VSS) capacitor c=3.22513e-16
C7 (8 VSS) capacitor c=2.0482e-18
C8 (\1\:B VSS) capacitor c=9.95825e-17
C9 (\6\:A VSS) capacitor c=5.61783e-17
C10 (\4\:B VSS) capacitor c=5.90794e-17
C11 (\5\:B VSS) capacitor c=5.96836e-17
C12 (\1\:A VSS) capacitor c=5.27618e-17
C13 (\1\:VDD VSS) capacitor c=1.81505e-16
C14 (\17\:net61 VSS) capacitor c=1.11281e-16
C15 (\11\:VDD VSS) capacitor c=7.4509e-18
C16 (\1\:Y VSS) capacitor c=1.33269e-16
C17 (\21\:net61 VSS) capacitor c=6.77163e-17
C18 (\7\:B VSS) capacitor c=9.09079e-17
C19 (\16\:net61 VSS) capacitor c=8.37631e-17
C20 (\5\:Y VSS) capacitor c=1.81907e-16
Rk10 (\1\:Y Y) resistor r=0.2801 c=0
Rk11 (Y \5\:Y) resistor r=0.07296 c=0
Rk1 (B \7\:B) resistor r=0.1107 c=0
Rk27 (\7\:VSS VSS) resistor r=0.08442 c=0
Rk26 (\1\:VSS \7\:VSS) resistor r=0.2942 c=0
Rk30 (\7\:VSS \13\:VSS) resistor r=0.2078 c=0
Rk22 (\1\:VDD VDD) resistor r=0.05447 c=0
Rk19 (\1\:VDD \12\:VDD) resistor r=0.07277 c=0
Rk5 (net61 \16\:net61) resistor r=0.1872 c=0
Rk6 (\16\:net61 \17\:net61) resistor r=0.3734 c=0
Rk8 (\16\:net61 \22\:net61) resistor r=0.4469 c=0
Rl5 (\1\:B \4\:B) resistor r=111.253 c=0
Rl6 (\1\:B \5\:B) resistor r=103.297 c=0
Rl9 (A \6\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=28.6412 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\22\:net61 \21\:net61) resistor r=75 c=0
Ry8 (\12\:VDD \11\:VDD) resistor r=62 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
mn0_1__rcx (7 \1\:A \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.445e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn1_1__rcx (\21\:net61 \5\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.34e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn1 (\21\:net61 \4\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.135e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn0 (8 \6\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.03e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn2_1__rcx (\1\:Y net61 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=7.55e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(4)
mp2_1__rcx (\5\:Y net61 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.673e-14 ad=6.24e-14 ps=1.3075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=7.55e-07 sd=160n sca=20.0159 \
        scb=0.0168107 scc=0.00184273 m=(4)
ends CLKAND2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:40 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X6
// View name: extracted

simulator lang=spectre

subckt CLKAND2X6 A B VDD VSS Y
mp0_1__rcx (\20\:net61 A VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=3.12e-14 ps=1.4e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=59.1807 scb=0.0520305 \
        scc=0.00794391 m=(4)
mp1_1__rcx (\20\:net61 B VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.215e-14 ad=3.12e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=44.2595 scb=0.0339396 \
        scc=0.00538195 m=(4)
C1 (Y VSS) capacitor c=1.17275e-17
C2 (B VSS) capacitor c=4.01514e-16
C3 (VDD VSS) capacitor c=3.98867e-16
C4 (A VSS) capacitor c=5.61429e-16
C5 (net61 VSS) capacitor c=3.97481e-16
C6 (8 VSS) capacitor c=1.73025e-18
C7 (9 VSS) capacitor c=5.1205e-18
C8 (10 VSS) capacitor c=1.71135e-18
C9 (\12\:A VSS) capacitor c=6.62363e-17
C10 (\11\:B VSS) capacitor c=4.47814e-17
C11 (\12\:B VSS) capacitor c=2.50951e-17
C12 (\8\:A VSS) capacitor c=3.0283e-17
C13 (\7\:A VSS) capacitor c=4.77649e-17
C14 (\1\:B VSS) capacitor c=5.60844e-17
C15 (\4\:B VSS) capacitor c=3.50653e-17
C16 (\1\:A VSS) capacitor c=3.31594e-17
C17 (\1\:Y VSS) capacitor c=2.93627e-16
C18 (\20\:net61 VSS) capacitor c=2.04e-16
C19 (\1\:VDD VSS) capacitor c=1.99227e-17
C20 (\28\:net61 VSS) capacitor c=1.21163e-16
C21 (\30\:net61 VSS) capacitor c=8.22868e-17
C22 (\19\:net61 VSS) capacitor c=7.97432e-17
C23 (\4\:Y VSS) capacitor c=2.14622e-16
Rk15 (\1\:Y Y) resistor r=0.003371 c=0
Rk16 (Y \4\:Y) resistor r=0.1832 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.08001 c=0
Rk43 (\3\:VSS \6\:VSS) resistor r=0.1703 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.1853 c=0
Rk46 (\8\:VSS VSS) resistor r=0.02963 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.3355 c=0
Rk50 (\7\:VSS \16\:VSS) resistor r=0.1987 c=0
Rk51 (\8\:VSS \18\:VSS) resistor r=0.2033 c=0
Rk24 (\2\:VDD VDD) resistor r=0.05244 c=0
Rk7 (net61 \19\:net61) resistor r=0.199 c=0
Rk8 (\19\:net61 \20\:net61) resistor r=0.3493 c=0
Rk12 (\19\:net61 \29\:net61) resistor r=0.4711 c=0
Rk13 (\29\:net61 \31\:net61) resistor r=0.534 c=0
Rl16 (B \11\:B) resistor r=28.0797 c=0
Rl17 (B \12\:B) resistor r=27.2353 c=0
Rl3 (B \1\:B) resistor r=100.478 c=0
Rl5 (B \4\:B) resistor r=90.0661 c=0
Rl20 (A \12\:A) resistor r=43.4636 c=0
Rl11 (A \8\:A) resistor r=58.8489 c=0
Rl10 (A \7\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=36.3335 c=0
Rz11 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz12 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz7 (VDD \1\:VDD) resistor r=6.25 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\29\:net61 \28\:net61) resistor r=75 c=0
Rz2 (\31\:net61 \30\:net61) resistor r=75 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry18 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (7 \1\:A \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\30\:net61 \4\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\30\:net61 \1\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (8 \7\:A \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.925e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (9 \8\:A \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.72e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\28\:net61 \12\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.525e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\28\:net61 \11\:B 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.32e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (10 \12\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.96e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.215e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\4\:Y net61 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.836e-14 ps=9.6e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35806e-06 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp2_1__rcx (\1\:Y net61 VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.407e-14 ad=7.332e-14 ps=1.302e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.83457e-07 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends CLKAND2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:42 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKAND2X8
// View name: extracted

simulator lang=spectre

subckt CLKAND2X8 A B VDD VSS Y
mp0_1__rcx (\27\:net61 \2\:A \1\:VDD VDD) g45p1hvt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=6.552e-14 ad=3.12e-14 ps=1.8125e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=39.3523 \
        scb=0.0403906 scc=0.00438703 m=(4)
mp1 (\27\:net61 \2\:B \1\:VDD VDD) g45p1hvt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.215e-14 ad=3.12e-14 ps=1.81e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=31.6431 scb=0.0281062 \
        scc=0.00355025 m=(4)
C1 (Y VSS) capacitor c=1.45434e-17
C2 (B VSS) capacitor c=4.26228e-17
C3 (VDD VSS) capacitor c=1.36274e-16
C4 (A VSS) capacitor c=5.32031e-17
C5 (net61 VSS) capacitor c=5.1909e-16
C6 (8 VSS) capacitor c=1.75543e-18
C7 (9 VSS) capacitor c=5.29864e-18
C8 (10 VSS) capacitor c=1.75543e-18
C9 (\12\:A VSS) capacitor c=6.5079e-17
C10 (\11\:B VSS) capacitor c=4.45746e-17
C11 (\12\:B VSS) capacitor c=2.49127e-17
C12 (\8\:A VSS) capacitor c=2.98784e-17
C13 (\7\:A VSS) capacitor c=4.74211e-17
C14 (\1\:B VSS) capacitor c=5.74758e-17
C15 (\6\:B VSS) capacitor c=3.36626e-17
C16 (\1\:A VSS) capacitor c=3.0846e-17
C17 (\2\:B VSS) capacitor c=3.97153e-16
C18 (\2\:A VSS) capacitor c=5.31684e-16
C19 (\1\:Y VSS) capacitor c=3.51539e-16
C20 (\1\:VDD VSS) capacitor c=3.45921e-16
C21 (\27\:net61 VSS) capacitor c=2.07991e-16
C22 (\35\:net61 VSS) capacitor c=1.15092e-16
C23 (\37\:net61 VSS) capacitor c=8.54433e-17
C24 (\26\:net61 VSS) capacitor c=7.0237e-17
C25 (\4\:Y VSS) capacitor c=2.27182e-16
Rk16 (\1\:Y Y) resistor r=0.05411 c=0
Rk17 (Y \4\:Y) resistor r=0.1785 c=0
Rk1 (B \2\:B) resistor r=0.05403 c=0
Rk48 (\1\:VSS \8\:VSS) resistor r=0.2097 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.1447 c=0
Rk51 (\10\:VSS VSS) resistor r=0.06451 c=0
Rk50 (\9\:VSS \10\:VSS) resistor r=0.3394 c=0
Rk55 (\9\:VSS \18\:VSS) resistor r=0.2168 c=0
Rk56 (\10\:VSS \20\:VSS) resistor r=0.2213 c=0
Rk36 (\1\:VDD VDD) resistor r=0.03453 c=0
Rk5 (\2\:A A) resistor r=0.002519 c=0
Rk8 (net61 \26\:net61) resistor r=0.2095 c=0
Rk9 (\26\:net61 \27\:net61) resistor r=0.3425 c=0
Rk13 (\26\:net61 \36\:net61) resistor r=0.4242 c=0
Rk14 (\36\:net61 \38\:net61) resistor r=0.5298 c=0
Rl16 (\2\:B \11\:B) resistor r=28.0797 c=0
Rl17 (\2\:B \12\:B) resistor r=27.2353 c=0
Rl3 (\2\:B \1\:B) resistor r=111.254 c=0
Rl7 (\2\:B \6\:B) resistor r=90.0661 c=0
Rl20 (\2\:A \12\:A) resistor r=40.1797 c=0
Rl11 (\2\:A \8\:A) resistor r=55.0028 c=0
Rl10 (\2\:A \7\:A) resistor r=31.9251 c=0
Rl1 (\2\:A \1\:A) resistor r=28.6412 c=0
Rz13 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz14 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\36\:net61 \35\:net61) resistor r=75 c=0
Rz2 (\38\:net61 \37\:net61) resistor r=75 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry18 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (7 \1\:A \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.9e-14 ps=8e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (\37\:net61 \6\:B 7 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_2__rcx (\37\:net61 \1\:B 8 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0_2__rcx (8 \7\:A \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (9 \8\:A \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_3__rcx (\35\:net61 \12\:B 9 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.955e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (\35\:net61 \11\:B 10 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=1.75e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0 (10 \12\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=1.645e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\4\:Y net61 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=4.95e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44847e-06 sb=1.37e-06 sd=160n sca=11.5122 \
        scb=0.0109007 scc=0.000558627 m=(7)
mp2_1__rcx (\1\:Y net61 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.267e-14 ad=6.993e-14 ps=1.30571e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.20843e-07 sb=1.37e-06 sd=160n \
        sca=18.517 scb=0.0155152 scc=0.00162155 m=(7)
ends CLKAND2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:43 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX12
// View name: extracted

simulator lang=spectre

subckt CLKBUFX12 A VDD VSS Y
mp1_1__rcx (Y net44 VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.573e-14 ad=7.52e-14 ps=1.266e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99064e-06 sd=160n sca=28.0481 \
        scb=0.031636 scc=0.00223037 m=(10)
C1 (VDD VSS) capacitor c=6.81006e-16
C2 (A VSS) capacitor c=5.11987e-17
C3 (Y VSS) capacitor c=5.25716e-16
C4 (net44 VSS) capacitor c=8.1871e-16
C5 (\1\:A VSS) capacitor c=2.32714e-16
C6 (\31\:net44 VSS) capacitor c=1.39051e-16
C7 (\7\:Y VSS) capacitor c=4.7554e-16
C8 (\10\:A VSS) capacitor c=4.44273e-17
C9 (\34\:net44 VSS) capacitor c=1.08506e-16
Rk19 (A \10\:A) resistor r=0.1302 c=0
Rk5 (Y \7\:Y) resistor r=0.4369 c=0
Rk23 (\34\:net44 net44) resistor r=0.4423 c=0
Rk21 (\31\:net44 \34\:net44) resistor r=0.276 c=0
Rx1 (\10\:A \1\:A) resistor r=45 c=0
mn1_1__rcx (\7\:Y net44 VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.998e-14 ad=4.96e-14 ps=9.46e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99113e-06 sd=160n sca=9.61806 \
        scb=0.00827687 scc=0.000298696 m=(10)
mn0_1__rcx (\34\:net44 \1\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.76e-14 ad=5.373e-14 ps=9.0667e-07 pd=9.3333e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=6.3e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(3)
mp0_1__rcx (\31\:net44 \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.157e-14 ad=8.06e-14 ps=1.18667e-06 pd=1.19333e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=6.3e-07 sd=160n sca=12.7559 \
        scb=0.0106631 scc=0.000333478 m=(3)
ends CLKBUFX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:43 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX16
// View name: extracted

simulator lang=spectre

subckt CLKBUFX16 A VDD VSS Y
mp1_1__rcx (Y net44 VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.033e-14 ad=7.12e-14 ps=1.20714e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (VDD VSS) capacitor c=8.77678e-16
C2 (A VSS) capacitor c=3.33126e-16
C3 (Y VSS) capacitor c=8.74536e-16
C4 (net44 VSS) capacitor c=1.16014e-15
C5 (\43\:net44 VSS) capacitor c=1.71744e-16
C6 (\49\:net44 VSS) capacitor c=8.49727e-17
C7 (\9\:Y VSS) capacitor c=4.80757e-16
C8 (\48\:net44 VSS) capacitor c=2.37164e-17
Rk7 (Y \9\:Y) resistor r=0.2351 c=0
Rk26 (\48\:net44 net44) resistor r=0.1464 c=0
Rk23 (\43\:net44 \48\:net44) resistor r=0.2122 c=0
Rk24 (\48\:net44 \49\:net44) resistor r=0.1301 c=0
mn1_1__rcx (\9\:Y net44 VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.663e-14 ad=4.72e-14 ps=9.0714e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
mn0_1__rcx (\49\:net44 A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.118e-14 ad=4.16e-14 ps=8.475e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mp0_1__rcx (\43\:net44 A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.158e-14 ad=6.24e-14 ps=1.1675e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.55e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
ends CLKBUFX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:44 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX2
// View name: extracted

simulator lang=spectre

subckt CLKBUFX2 A VDD VSS Y
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.97949e-07 sd=160n sca=30.8133 \
        scb=0.0297121 scc=0.00267709 m=(2)
C1 (VDD VSS) capacitor c=5.86893e-17
C2 (A VSS) capacitor c=6.74307e-17
C3 (Y VSS) capacitor c=1.04148e-17
C4 (net44 VSS) capacitor c=1.64579e-16
C5 (\1\:A VSS) capacitor c=4.4972e-17
C6 (\3\:A VSS) capacitor c=4.26788e-17
C7 (\2\:A VSS) capacitor c=4.6052e-17
C8 (\7\:net44 VSS) capacitor c=4.73799e-17
C9 (\1\:VDD VSS) capacitor c=1.06067e-16
C10 (\1\:Y VSS) capacitor c=7.47009e-17
C11 (\11\:net44 VSS) capacitor c=1.5353e-17
C12 (\4\:Y VSS) capacitor c=2.18041e-17
C13 (\3\:Y VSS) capacitor c=4.8699e-17
C14 (\4\:A VSS) capacitor c=4.14314e-17
C15 (\9\:net44 VSS) capacitor c=5.17197e-17
C16 (\10\:net44 VSS) capacitor c=4.92894e-17
Rk14 (\1\:VSS VSS) resistor r=0.03712 c=0
Rk10 (\1\:VDD VDD) resistor r=0.03712 c=0
Rk4 (\4\:A A) resistor r=0.1206 c=0
Rk3 (\3\:Y Y) resistor r=0.002419 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.421 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.1064 c=0
Rk5 (\8\:net44 \9\:net44) resistor r=0.3792 c=0
Rk6 (\9\:net44 \10\:net44) resistor r=0.2891 c=0
Rk7 (\9\:net44 \12\:net44) resistor r=0.12 c=0
Rl6 (\1\:A \2\:A) resistor r=91.0764 c=0
Rl7 (\2\:A \3\:A) resistor r=100.692 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\12\:net44 \11\:net44) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\8\:net44 \7\:net44) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\10\:net44 net44) resistor r=45 c=0
mn1 (\4\:Y net44 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.00192e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mn0 (\11\:net44 \3\:A \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.553e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp0 (\7\:net44 \1\:A \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.267e-14 ps=1.1e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.45e-07 sd=160n sca=19.2351 \
        scb=0.0201659 scc=0.000554323 m=(1)
ends CLKBUFX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:45 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX20
// View name: extracted

simulator lang=spectre

subckt CLKBUFX20 A VDD VSS Y
mp1_1__rcx (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(4.55e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=6.37e-14 ps=1.24e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=39.6635 scb=0.0369516 \
        scc=0.00411991 m=(1)
C1 (VDD VSS) capacitor c=1.58849e-16
C2 (A VSS) capacitor c=4.0659e-16
C3 (Y VSS) capacitor c=1.32273e-17
C4 (net44 VSS) capacitor c=1.45439e-15
C5 (\52\:net44 VSS) capacitor c=2.26735e-16
C6 (\1\:VDD VSS) capacitor c=8.8794e-16
C7 (\1\:Y VSS) capacitor c=1.06716e-15
C8 (\57\:net44 VSS) capacitor c=1.32282e-16
C9 (\11\:Y VSS) capacitor c=8.15041e-16
C10 (\56\:net44 VSS) capacitor c=2.24545e-17
Rk87 (\1\:VSS VSS) resistor r=0.1025 c=0
Rk74 (\1\:VDD VDD) resistor r=0.1025 c=0
Rk9 (\1\:Y Y) resistor r=0.1726 c=0
Rk10 (Y \11\:Y) resistor r=0.02804 c=0
Rk43 (\56\:net44 net44) resistor r=0.1404 c=0
Rk39 (\52\:net44 \56\:net44) resistor r=0.2212 c=0
Rk40 (\56\:net44 \57\:net44) resistor r=0.1372 c=0
mn1_1__rcx (\11\:Y net44 \1\:VSS VSS) g45n1hvt w=(3.05e-07) l=4.5e-08 \
        nf=1 as=4.864e-14 ad=4.844e-14 ps=9.3e-07 pd=9.2765e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 \
        scb=0.0155296 scc=0.00139557 m=(17)
mn0_1__rcx (\57\:net44 A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.25e-14 ad=4.056e-14 ps=8.58e-07 pd=8.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(5)
mp1_2__rcx (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.36e-14 ps=1.24e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.42337e-07 sb=2e-06 sd=160n sca=30.979 \
        scb=0.0224787 scc=0.002898 m=(16)
mp0_1__rcx (\52\:net44 A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.38e-14 ad=6.084e-14 ps=1.128e-06 pd=1.092e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(5)
ends CLKBUFX20
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:46 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX3
// View name: extracted

simulator lang=spectre

subckt CLKBUFX3 A VDD VSS Y
mp0 (\11\:net44 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.655e-14 ps=1.1e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.45e-07 sd=160n sca=22.6205 \
        scb=0.0258254 scc=0.00117627 m=(1)
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.98e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=17.5421 \
        scb=0.0176137 scc=0.000504265 m=(3)
C1 (VDD VSS) capacitor c=7.30358e-17
C2 (A VSS) capacitor c=8.48472e-17
C3 (Y VSS) capacitor c=1.80029e-17
C4 (net44 VSS) capacitor c=1.04334e-16
C5 (\1\:A VSS) capacitor c=4.69352e-17
C6 (\3\:A VSS) capacitor c=3.63993e-17
C7 (\2\:A VSS) capacitor c=4.47454e-17
C8 (\3\:net44 VSS) capacitor c=1.09634e-16
C9 (\11\:net44 VSS) capacitor c=8.18577e-17
C10 (\1\:VDD VSS) capacitor c=1.36103e-16
C11 (\1\:Y VSS) capacitor c=1.17762e-16
C12 (\13\:net44 VSS) capacitor c=5.53229e-17
C13 (\4\:Y VSS) capacitor c=1.14265e-16
C14 (\4\:A VSS) capacitor c=3.69802e-17
C15 (\15\:net44 VSS) capacitor c=5.38296e-17
Rk18 (\1\:VSS VSS) resistor r=0.1548 c=0
Rk14 (\1\:VDD VDD) resistor r=0.1749 c=0
Rk9 (\4\:A A) resistor r=0.04486 c=0
Rk2 (\1\:Y Y) resistor r=0.003365 c=0
Rk3 (Y \4\:Y) resistor r=0.2851 c=0
Rk10 (\12\:net44 \14\:net44) resistor r=0.5066 c=0
Rk11 (\14\:net44 \15\:net44) resistor r=0.3154 c=0
Rl10 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl11 (\2\:A \3\:A) resistor r=47.3281 c=0
Rl2 (net44 \3\:net44) resistor r=34.2287 c=0
Rz3 (\14\:net44 \13\:net44) resistor r=75 c=0
Ry3 (\12\:net44 \11\:net44) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\15\:net44 \3\:net44) resistor r=45 c=0
mn0 (\13\:net44 \3\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn1 (\4\:Y \3\:net44 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.377e-14 ad=3.987e-14 ps=8.5667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(3)
ends CLKBUFX3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:47 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX4
// View name: extracted

simulator lang=spectre

subckt CLKBUFX4 A VDD VSS Y
mp0 (\13\:net44 \1\:A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=20.4961 \
        scb=0.0204164 scc=0.00119548 m=(1)
mp1 (\1\:Y net44 VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.337e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=29.498 \
        scb=0.0332632 scc=0.00250913 m=(4)
C1 (Y VSS) capacitor c=2.32191e-17
C2 (A VSS) capacitor c=5.05654e-17
C3 (VDD VSS) capacitor c=2.79226e-16
C4 (net44 VSS) capacitor c=3.62223e-16
C5 (\1\:A VSS) capacitor c=4.31658e-17
C6 (\3\:A VSS) capacitor c=4.52905e-17
C7 (\2\:A VSS) capacitor c=3.92039e-17
C8 (\13\:net44 VSS) capacitor c=6.50883e-17
C9 (\1\:Y VSS) capacitor c=2.01059e-16
C10 (\18\:net44 VSS) capacitor c=3.27427e-17
C11 (\6\:Y VSS) capacitor c=1.79263e-16
C12 (\4\:A VSS) capacitor c=3.46916e-17
C13 (\15\:net44 VSS) capacitor c=5.94674e-17
Rk2 (\1\:Y Y) resistor r=0.09251 c=0
Rk4 (Y \6\:Y) resistor r=0.2245 c=0
Rk7 (\4\:A A) resistor r=0.04123 c=0
Rk9 (\15\:net44 net44) resistor r=0.3253 c=0
Rk8 (\14\:net44 \15\:net44) resistor r=0.3896 c=0
Rk11 (\15\:net44 \19\:net44) resistor r=0.1771 c=0
Rl11 (\1\:A \2\:A) resistor r=55.0021 c=0
Rl12 (\2\:A \3\:A) resistor r=105.002 c=0
Rz3 (\19\:net44 \18\:net44) resistor r=37.5 c=0
Ry3 (\14\:net44 \13\:net44) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (\18\:net44 \3\:A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\6\:Y net44 VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
ends CLKBUFX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:48 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX6
// View name: extracted

simulator lang=spectre

subckt CLKBUFX6 A VDD VSS Y
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2934e-06 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(5)
C1 (VDD VSS) capacitor c=6.13466e-17
C2 (A VSS) capacitor c=3.86308e-17
C3 (Y VSS) capacitor c=1.29606e-17
C4 (net44 VSS) capacitor c=4.3084e-16
C5 (\1\:A VSS) capacitor c=1.43029e-16
C6 (\6\:A VSS) capacitor c=1.1125e-17
C7 (\1\:VDD VSS) capacitor c=3.24051e-16
C8 (\16\:net44 VSS) capacitor c=8.18986e-17
C9 (\1\:Y VSS) capacitor c=2.97765e-16
C10 (\21\:net44 VSS) capacitor c=3.06689e-17
C11 (\5\:Y VSS) capacitor c=2.31824e-16
C12 (\18\:net44 VSS) capacitor c=6.10909e-17
C13 (\9\:A VSS) capacitor c=7.38283e-17
Rk30 (\1\:VSS VSS) resistor r=0.1024 c=0
Rk22 (\1\:VDD VDD) resistor r=0.1024 c=0
Rk17 (A \9\:A) resistor r=0.03004 c=0
Rk3 (\1\:Y Y) resistor r=0.05801 c=0
Rk4 (Y \5\:Y) resistor r=0.1508 c=0
Rk12 (\18\:net44 net44) resistor r=0.5569 c=0
Rk11 (\17\:net44 \18\:net44) resistor r=0.2535 c=0
Rk14 (\18\:net44 \22\:net44) resistor r=0.1818 c=0
Rl18 (\1\:A \6\:A) resistor r=4.8851 c=0
Rz4 (\22\:net44 \21\:net44) resistor r=75 c=0
Ry4 (\17\:net44 \16\:net44) resistor r=20.6667 c=0
Rx3 (\9\:A \6\:A) resistor r=45 c=0
mn1 (\5\:Y net44 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.9e-14 ad=4.836e-14 ps=9.4e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29742e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mn0 (\21\:net44 \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.15e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mp0 (\16\:net44 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=32.0467 \
        scb=0.0213026 scc=0.00336306 m=(2)
ends CLKBUFX6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:49 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKBUFX8
// View name: extracted

simulator lang=spectre

subckt CLKBUFX8 A VDD VSS Y
mp1_1__rcx (\1\:Y net44 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.72438e-06 sd=160n \
        sca=25.5327 scb=0.0229112 scc=0.00209852 m=(7)
C1 (VDD VSS) capacitor c=7.84521e-17
C2 (A VSS) capacitor c=3.25002e-17
C3 (Y VSS) capacitor c=1.07143e-17
C4 (net44 VSS) capacitor c=6.67495e-16
C5 (\1\:A VSS) capacitor c=1.63954e-16
C6 (\1\:VDD VSS) capacitor c=4.02563e-16
C7 (\22\:net44 VSS) capacitor c=6.83667e-17
C8 (\1\:Y VSS) capacitor c=4.10605e-16
C9 (\28\:net44 VSS) capacitor c=6.32244e-17
C10 (\6\:Y VSS) capacitor c=4.35035e-16
C11 (\24\:net44 VSS) capacitor c=4.54191e-17
C12 (\9\:A VSS) capacitor c=3.67848e-17
Rk38 (\1\:VSS VSS) resistor r=0.1803 c=0
Rk28 (\1\:VDD VDD) resistor r=0.1803 c=0
Rk20 (\8\:A \9\:A) resistor r=0.008317 c=0
Rk21 (\10\:A A) resistor r=0.008468 c=0
Rk22 (\9\:A \10\:A) resistor r=0.03387 c=0
Rk4 (\1\:Y Y) resistor r=0.09531 c=0
Rk5 (Y \6\:Y) resistor r=0.08628 c=0
Rk16 (\24\:net44 net44) resistor r=0.183 c=0
Rk15 (\23\:net44 \24\:net44) resistor r=0.2599 c=0
Rk19 (\24\:net44 \29\:net44) resistor r=0.2347 c=0
Rz5 (\29\:net44 \28\:net44) resistor r=37.5 c=0
Ry5 (\23\:net44 \22\:net44) resistor r=20.6667 c=0
Rx4 (\8\:A \1\:A) resistor r=45 c=0
mn1_1__rcx (\6\:Y net44 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72661e-06 sd=160n sca=14.382 \
        scb=0.0140935 scc=0.0010585 m=(7)
mn0_1__rcx (\28\:net44 \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.075e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mp0 (\22\:net44 \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(2)
ends CLKBUFX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:50 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX1
// View name: extracted

simulator lang=spectre

subckt CLKINVX1 A VDD VSS Y
mp0 (\1\:Y \1\:A \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.86e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24615e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=4.98396e-17
C2 (VDD VSS) capacitor c=2.75467e-17
C3 (\1\:A VSS) capacitor c=2.93388e-17
C4 (\4\:A VSS) capacitor c=2.40696e-17
C5 (\3\:A VSS) capacitor c=1.55142e-17
C6 (\1\:Y VSS) capacitor c=4.02946e-17
C7 (\3\:VDD VSS) capacitor c=4.72871e-17
C8 (\2\:A VSS) capacitor c=9.53353e-18
C9 (\5\:A VSS) capacitor c=3.69186e-17
C10 (\7\:A VSS) capacitor c=3.88107e-17
Rk9 (VSS \4\:VSS) resistor r=0.3102 c=0
Rk1 (\5\:A \6\:A) resistor r=0.004811 c=0
Rk2 (A \7\:A) resistor r=0.004651 c=0
Rk3 (\5\:A \7\:A) resistor r=0.04303 c=0
Rk4 (\2\:Y Y) resistor r=0.2477 c=0
Rk5 (Y \4\:Y) resistor r=0.06047 c=0
Rk7 (VDD \4\:VDD) resistor r=0.3843 c=0
Rl1 (\1\:A \2\:A) resistor r=61.2526 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=4.3144 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\3\:VDD \4\:VDD) resistor r=20.6667 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
mn0 (\3\:Y \4\:A \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.08e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.18462e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
ends CLKINVX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:51 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX12
// View name: extracted

simulator lang=spectre

subckt CLKINVX12 A VDD VSS Y
mp0 (Y A VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=8.554e-14 \
        ad=7.661e-14 ps=1.304e-06 pd=1.266e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(10)
C1 (A VSS) capacitor c=7.83048e-16
C2 (Y VSS) capacitor c=4.76208e-16
C3 (VDD VSS) capacitor c=4.26972e-16
C4 (\9\:Y VSS) capacitor c=4.81282e-16
Rk12 (Y \9\:Y) resistor r=0.4398 c=0
mn0 (\9\:Y A VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=5.859e-14 ps=9.32e-07 pd=9.98e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=8.7305 scb=0.00693421 \
        scc=0.00019605 m=(10)
ends CLKINVX12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:52 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX16
// View name: extracted

simulator lang=spectre

subckt CLKINVX16 A VDD VSS Y
mp0 (Y \1\:A \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=33.496 scb=0.0262642 \
        scc=0.00310781 m=(14)
C1 (A VSS) capacitor c=2.1506e-17
C2 (Y VSS) capacitor c=6.76068e-16
C3 (VDD VSS) capacitor c=8.85565e-17
C4 (\1\:A VSS) capacitor c=9.4543e-16
C5 (\1\:VDD VSS) capacitor c=4.60088e-16
C6 (\17\:Y VSS) capacitor c=4.05981e-16
Rk56 (\1\:VSS VSS) resistor r=0.06474 c=0
Rk8 (\1\:A A) resistor r=0.01234 c=0
Rk19 (Y \17\:Y) resistor r=0.2528 c=0
Rk39 (\1\:VDD VDD) resistor r=0.06474 c=0
mn0 (\17\:Y \1\:A \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
ends CLKINVX16
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:53 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX2
// View name: extracted

simulator lang=spectre

subckt CLKINVX2 A VDD VSS Y
mp0 (\3\:Y \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.0826 \
        scb=0.0294587 scc=0.00345874 m=(2)
C1 (Y VSS) capacitor c=2.66915e-17
C2 (A VSS) capacitor c=2.50484e-17
C3 (VDD VSS) capacitor c=2.28279e-17
C4 (\1\:A VSS) capacitor c=1.06683e-16
C5 (\4\:A VSS) capacitor c=1.17735e-17
C6 (\1\:VDD VSS) capacitor c=1.23627e-16
C7 (\3\:Y VSS) capacitor c=9.61784e-17
C8 (\1\:Y VSS) capacitor c=1.63529e-17
C9 (\8\:A VSS) capacitor c=6.61726e-17
Rk2 (Y \2\:Y) resistor r=0.05085 c=0
Rk3 (Y \4\:Y) resistor r=0.2572 c=0
Rk1 (A \8\:A) resistor r=0.1424 c=0
Rk6 (\1\:VDD VDD) resistor r=0.09222 c=0
Rk10 (\1\:VSS VSS) resistor r=0.09222 c=0
Rl3 (\1\:A \4\:A) resistor r=4.8851 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Ry1 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Rx1 (\8\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
ends CLKINVX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:55 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX20
// View name: extracted

simulator lang=spectre

subckt CLKINVX20 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.301e-14 ad=7.36e-14 ps=1.2375e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.0128 scb=0.0371513 \
        scc=0.00426262 m=(16)
C1 (A VSS) capacitor c=1.65572e-17
C2 (VDD VSS) capacitor c=6.46714e-16
C3 (Y VSS) capacitor c=1.05716e-17
C4 (\1\:A VSS) capacitor c=1.27635e-15
C5 (\1\:Y VSS) capacitor c=8.29827e-16
C6 (\12\:Y VSS) capacitor c=7.94553e-16
Rk9 (\1\:A A) resistor r=0.01718 c=0
Rk18 (\1\:Y Y) resistor r=0.03951 c=0
Rk19 (\1\:Y \12\:Y) resistor r=0.1937 c=0
mn0 (\12\:Y \1\:A VSS VSS) g45n1hvt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.844e-14 ps=9.2765e-07 pd=9.2765e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
mp0_16__rcx (\1\:Y \1\:A VDD VDD) g45p1hvt w=(4.55e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=1.0238e-13 ps=1.24e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=32.0859 scb=0.0265913 \
        scc=0.00291711 m=(1)
ends CLKINVX20
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:56 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX3
// View name: extracted

simulator lang=spectre

subckt CLKINVX3 A VDD VSS Y
mp0 (\1\:Y \1\:A \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=5.98e-14 ps=1.08667e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=36.7233 \
        scb=0.0278991 scc=0.00349312 m=(3)
C1 (A VSS) capacitor c=2.33216e-17
C2 (VDD VSS) capacitor c=4.0693e-17
C3 (Y VSS) capacitor c=1.25926e-17
C4 (\1\:A VSS) capacitor c=1.47152e-16
C5 (\6\:A VSS) capacitor c=1.12727e-17
C6 (\1\:Y VSS) capacitor c=1.20601e-16
C7 (\1\:VDD VSS) capacitor c=1.28561e-16
C8 (\4\:Y VSS) capacitor c=6.77057e-17
C9 (\12\:A VSS) capacitor c=8.0783e-17
Rk13 (\1\:VSS VSS) resistor r=0.06971 c=0
Rk1 (A \12\:A) resistor r=0.05007 c=0
Rk9 (\1\:VDD VDD) resistor r=0.06971 c=0
Rk3 (\1\:Y Y) resistor r=0.02731 c=0
Rk4 (Y \4\:Y) resistor r=0.1524 c=0
Rl5 (\1\:A \6\:A) resistor r=4.3693 c=0
Rx1 (\12\:A \6\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=3.987e-14 ps=8.2667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
ends CLKINVX3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:57 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX4
// View name: extracted

simulator lang=spectre

subckt CLKINVX4 A VDD VSS Y
mp0 (Y A VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=6.054e-14 \
        ad=6.24e-14 ps=1.245e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.15e-07 sd=160n sca=33.7975 scb=0.0358754 \
        scc=0.00324911 m=(4)
C1 (Y VSS) capacitor c=1.99055e-16
C2 (A VSS) capacitor c=3.37398e-16
C3 (VDD VSS) capacitor c=1.87879e-16
C4 (\4\:Y VSS) capacitor c=1.92325e-16
Rk4 (Y \4\:Y) resistor r=0.2069 c=0
mn0 (\4\:Y A VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.306e-14 \
        ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.15e-07 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
ends CLKINVX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:58 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX6
// View name: extracted

simulator lang=spectre

subckt CLKINVX6 A VDD VSS Y
mp0 (\1\:Y A VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 as=7.52e-14 \
        ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.7e-07 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(5)
C1 (A VSS) capacitor c=3.59417e-16
C2 (Y VSS) capacitor c=1.65583e-17
C3 (VDD VSS) capacitor c=2.16501e-16
C4 (\1\:Y VSS) capacitor c=2.03369e-16
C5 (\6\:Y VSS) capacitor c=2.07227e-16
Rk5 (\1\:Y Y) resistor r=0.02733 c=0
Rk6 (Y \6\:Y) resistor r=0.2233 c=0
mn0 (\6\:Y A VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=4.96e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.7e-07 sd=160n sca=9.23999 scb=0.00771541 \
        scc=0.000252587 m=(5)
ends CLKINVX6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:13:59 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKINVX8
// View name: extracted

simulator lang=spectre

subckt CLKINVX8 A VDD VSS Y
mp0 (\1\:Y \1\:A \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.993e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=37.2769 \
        scb=0.0322553 scc=0.00356814 m=(7)
C1 (A VSS) capacitor c=2.08287e-17
C2 (Y VSS) capacitor c=1.4391e-17
C3 (VDD VSS) capacitor c=5.07893e-17
C4 (\1\:A VSS) capacitor c=3.97175e-16
C5 (\1\:Y VSS) capacitor c=2.79443e-16
C6 (\1\:VDD VSS) capacitor c=2.18315e-16
C7 (\4\:Y VSS) capacitor c=1.62689e-16
Rk29 (\1\:VSS VSS) resistor r=0.02458 c=0
Rk3 (\1\:A A) resistor r=0.02659 c=0
Rk5 (\1\:Y Y) resistor r=0.1992 c=0
Rk6 (Y \4\:Y) resistor r=0.01233 c=0
Rk21 (\1\:VDD VDD) resistor r=0.02458 c=0
mn0 (\4\:Y \1\:A \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.636e-14 ps=9.0429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
ends CLKINVX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:00 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X12
// View name: extracted

simulator lang=spectre

subckt CLKMX2X12 A B S0 VDD VSS Y
mp0 (\9\:S0b \1\:S0 \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.61026e-06 sd=160n sca=16.3241 \
        scb=0.0161972 scc=0.000342398 m=(1)
C1 (S0 VSS) capacitor c=6.40684e-17
C2 (Y VSS) capacitor c=9.54744e-16
C3 (VDD VSS) capacitor c=2.30037e-16
C4 (B VSS) capacitor c=3.89468e-17
C5 (S0b VSS) capacitor c=5.08717e-17
C6 (n0 VSS) capacitor c=5.93648e-16
C7 (net140 VSS) capacitor c=8.56299e-18
C8 (net123 VSS) capacitor c=3.58658e-18
C9 (net115 VSS) capacitor c=4.99478e-18
C10 (\1\:B VSS) capacitor c=3.81655e-17
C11 (\3\:S0b VSS) capacitor c=3.53861e-17
C12 (\6\:S0 VSS) capacitor c=4.38578e-17
C13 (\1\:A VSS) capacitor c=7.04353e-17
C14 (\1\:S0 VSS) capacitor c=4.91618e-17
C15 (\3\:B VSS) capacitor c=5.56467e-17
C16 (\4\:S0 VSS) capacitor c=6.24672e-17
C17 (\2\:S0b VSS) capacitor c=6.76963e-17
C18 (\3\:A VSS) capacitor c=9.4772e-17
C19 (\3\:S0 VSS) capacitor c=5.62627e-17
C20 (\2\:B VSS) capacitor c=4.04353e-17
C21 (\4\:S0b VSS) capacitor c=3.52485e-17
C22 (\5\:S0 VSS) capacitor c=7.37328e-17
C23 (\2\:A VSS) capacitor c=5.48734e-17
C24 (\2\:S0 VSS) capacitor c=4.3818e-17
C25 (\1\:VDD VSS) capacitor c=5.06731e-16
C26 (\44\:n0 VSS) capacitor c=9.88033e-17
C27 (\21\:VDD VSS) capacitor c=3.64071e-17
C28 (\9\:S0b VSS) capacitor c=9.79343e-17
C29 (\3\:VDD VSS) capacitor c=4.79606e-17
C30 (\42\:n0 VSS) capacitor c=5.73585e-17
C31 (\7\:S0b VSS) capacitor c=8.8816e-17
C32 (\4\:A VSS) capacitor c=4.18614e-17
C33 (\5\:A VSS) capacitor c=5.20564e-17
C34 (\7\:S0 VSS) capacitor c=3.3773e-17
C35 (\8\:S0 VSS) capacitor c=8.38783e-17
C36 (\5\:S0b VSS) capacitor c=7.96224e-17
C37 (\6\:S0b VSS) capacitor c=9.01861e-17
C38 (\4\:B VSS) capacitor c=6.11711e-17
C39 (\40\:n0 VSS) capacitor c=5.63321e-17
C40 (\41\:n0 VSS) capacitor c=1.17885e-16
C41 (\10\:VDD VSS) capacitor c=2.74404e-17
Rk4 (S0 \7\:S0) resistor r=0.03903 c=0
Rk5 (S0 \8\:S0) resistor r=0.4084 c=0
Rk1 (A \4\:A) resistor r=0.002332 c=0
Rk3 (\4\:A \5\:A) resistor r=0.03791 c=0
Rk2 (\5\:A \6\:A) resistor r=0.002413 c=0
Rk50 (\1\:VSS \9\:VSS) resistor r=0.06501 c=0
Rk52 (\10\:VSS VSS) resistor r=0.1776 c=0
Rk51 (\9\:VSS \10\:VSS) resistor r=0.3735 c=0
Rk58 (\10\:VSS \22\:VSS) resistor r=0.2209 c=0
Rk36 (\1\:VDD \9\:VDD) resistor r=0.1302 c=0
Rk38 (\10\:VDD VDD) resistor r=0.1776 c=0
Rk37 (\9\:VDD \10\:VDD) resistor r=0.3735 c=0
Rk44 (\10\:VDD \22\:VDD) resistor r=0.1786 c=0
Rk9 (\4\:B B) resistor r=0.01175 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.4236 c=0
Rk7 (\6\:S0b \8\:S0b) resistor r=0.3474 c=0
Rk8 (\8\:S0b \10\:S0b) resistor r=0.735 c=0
Rk10 (\40\:n0 \41\:n0) resistor r=0.3134 c=0
Rk11 (\41\:n0 \43\:n0) resistor r=0.4108 c=0
Rk12 (\41\:n0 \45\:n0) resistor r=0.5789 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=28.2967 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=218.796 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=26.098 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=145.329 c=0
Rl3 (\1\:A \2\:A) resistor r=81.461 c=0
Rl4 (\2\:A \3\:A) resistor r=148.769 c=0
Rl9 (\1\:B \2\:B) resistor r=33.3841 c=0
Rl10 (\2\:B \3\:B) resistor r=196.846 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=30.0021 c=0
Rl5 (S0b \2\:S0b) resistor r=42.6366 c=0
Rz16 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz9 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\7\:S0b \8\:S0b) resistor r=75 c=0
Rz2 (\43\:n0 \42\:n0) resistor r=75 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry16 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry14 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry1 (\9\:S0b \10\:S0b) resistor r=62 c=0
Ry2 (\45\:n0 \44\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \6\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\40\:n0 n0) resistor r=45 c=0
mn0 (\7\:S0b \3\:S0 \21\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59808e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (net148 \3\:A \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=1.23e-14 ps=8.4e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn2 (\42\:n0 \2\:S0b net148 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn4 (\42\:n0 \4\:S0 net140 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=3.28e-14 ps=1.04e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.048e-14 ad=6.458e-14 ps=1.01e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=2e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn5_1__rcx (Y n0 \1\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.217e-14 ad=4.96e-14 ps=9.63e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6379e-07 sb=2e-06 sd=160n sca=11.8347 \
        scb=0.0112322 scc=0.000626052 m=(10)
mp1 (net123 \1\:A \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=3.255e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=12.241 scb=0.00942952 \
        scc=0.00011999 m=(1)
mp2 (\44\:n0 \6\:S0 net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.255e-14 ad=6.82e-14 ps=8.3e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=11.314 scb=0.00849585 \
        scc=0.00011741 m=(1)
mp4 (\44\:n0 \3\:S0b net115 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=6.82e-14 ps=1.04e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp3 (net115 \1\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.059e-13 ad=6.51e-14 ps=1.52e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=2e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5_1__rcx (Y n0 \1\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.733e-14 ad=7.52e-14 ps=1.282e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.24468e-07 sb=1.985e-06 sd=160n sca=13.3727 \
        scb=0.0119208 scc=0.000609828 m=(10)
ends CLKMX2X12
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:00 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X2
// View name: extracted

simulator lang=spectre

subckt CLKMX2X2 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=15.5214 \
        scb=0.0147757 scc=0.000215748 m=(1)
mp1 (net123 \1\:A \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.977e-14 ps=7.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=11.7983 \
        scb=0.00857189 scc=7.47494e-05 m=(1)
mp2 (\12\:n0 \6\:S0 net123 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=9.5e-07 sd=160n sca=10.5655 \
        scb=0.0074576 scc=7.20375e-05 m=(1)
mp4 (\12\:n0 \3\:S0b net115 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.73e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.85e-07 sd=160n sca=10.707 \
        scb=0.00753257 scc=7.20801e-05 m=(1)
mp3 (net115 \4\:B \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.935e-14 ps=1.1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=11.3858 \
        scb=0.0080918 scc=7.29969e-05 m=(1)
C1 (S0 VSS) capacitor c=2.90938e-17
C2 (A VSS) capacitor c=5.58589e-17
C3 (Y VSS) capacitor c=2.80318e-17
C4 (VDD VSS) capacitor c=1.70637e-16
C5 (S0b VSS) capacitor c=6.79703e-17
C6 (n0 VSS) capacitor c=1.69293e-16
C7 (net140 VSS) capacitor c=5.94741e-18
C8 (net115 VSS) capacitor c=1.61012e-18
C9 (\4\:B VSS) capacitor c=6.951e-17
C10 (\3\:S0b VSS) capacitor c=4.76678e-17
C11 (\6\:S0 VSS) capacitor c=4.00511e-17
C12 (\1\:A VSS) capacitor c=4.19649e-17
C13 (\1\:S0 VSS) capacitor c=3.16105e-17
C14 (\3\:B VSS) capacitor c=5.60282e-17
C15 (\4\:S0 VSS) capacitor c=6.09393e-17
C16 (\3\:A VSS) capacitor c=9.14968e-17
C17 (\3\:S0 VSS) capacitor c=5.66864e-17
C18 (\4\:n0 VSS) capacitor c=4.35991e-17
C19 (\1\:B VSS) capacitor c=2.36277e-17
C20 (\4\:S0b VSS) capacitor c=4.56261e-17
C21 (\5\:S0 VSS) capacitor c=8.07146e-17
C22 (\2\:S0b VSS) capacitor c=5.59097e-17
C23 (\2\:A VSS) capacitor c=7.1716e-17
C24 (\2\:S0 VSS) capacitor c=5.50439e-17
C25 (\1\:VDD VSS) capacitor c=1.135e-16
C26 (\4\:Y VSS) capacitor c=1.01047e-16
C27 (\12\:n0 VSS) capacitor c=9.43155e-17
C28 (\9\:VDD VSS) capacitor c=3.71143e-17
C29 (\10\:S0b VSS) capacitor c=9.35684e-17
C30 (\2\:Y VSS) capacitor c=3.0196e-17
C31 (\10\:n0 VSS) capacitor c=5.572e-17
C32 (\8\:S0b VSS) capacitor c=2.07457e-17
C33 (\2\:B VSS) capacitor c=5.15356e-17
C34 (\4\:A VSS) capacitor c=6.08691e-17
C35 (\7\:S0 VSS) capacitor c=8.22889e-17
C36 (\8\:S0 VSS) capacitor c=7.28826e-17
C37 (\5\:S0b VSS) capacitor c=7.67003e-17
C38 (\6\:S0b VSS) capacitor c=1.21534e-16
C39 (\7\:S0b VSS) capacitor c=8.12973e-17
C40 (\5\:B VSS) capacitor c=1.23449e-16
C41 (\8\:n0 VSS) capacitor c=3.24213e-17
C42 (\9\:n0 VSS) capacitor c=1.11192e-16
C43 (\1\:Y VSS) capacitor c=4.75549e-17
C44 (\5\:VDD VSS) capacitor c=2.3638e-17
C45 (\6\:VDD VSS) capacitor c=1.60853e-17
Rk3 (\8\:S0 S0) resistor r=0.02104 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.417 c=0
Rk22 (\1\:VSS \5\:VSS) resistor r=0.1955 c=0
Rk24 (\6\:VSS VSS) resistor r=0.1701 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.2306 c=0
Rk26 (\6\:VSS \10\:VSS) resistor r=0.194 c=0
Rk1 (A \4\:A) resistor r=0.07467 c=0
Rk12 (Y \1\:Y) resistor r=0.111 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.1478 c=0
Rk14 (\1\:Y \5\:Y) resistor r=0.502 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.1955 c=0
Rk18 (\6\:VDD VDD) resistor r=0.1701 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.2306 c=0
Rk20 (\6\:VDD \10\:VDD) resistor r=0.2093 c=0
Rk8 (B \5\:B) resistor r=0.006762 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4511 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3941 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09765 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7268 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.1576 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.4052 c=0
Rk11 (\9\:n0 \13\:n0) resistor r=0.5968 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=236.093 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=41.0764 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=248.769 c=0
Rl3 (\1\:A \2\:A) resistor r=76.1559 c=0
Rl4 (\2\:A \3\:A) resistor r=210.771 c=0
Rl11 (\2\:B \4\:B) resistor r=128.56 c=0
Rl10 (\2\:B \3\:B) resistor r=178.56 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=62.9746 c=0
Rl5 (S0b \2\:S0b) resistor r=83.8482 c=0
Rl14 (n0 \4\:n0) resistor r=4.1351 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\3\:Y \2\:Y) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\8\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn1 (net148 \3\:A \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn2 (\10\:n0 S0b net148 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.075e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn4 (\10\:n0 \4\:S0 net140 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.7e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn5 (\2\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.10673e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp5 (\4\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.03654e-07 sb=3.45e-07 sd=160n sca=15.9948 \
        scb=0.0151656 scc=0.000454155 m=(2)
ends CLKMX2X2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:01 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X3
// View name: extracted

simulator lang=spectre

subckt CLKMX2X3 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=4.837e-14 ps=1.64e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.9e-06 sd=160n sca=26.5704 \
        scb=0.0277882 scc=0.00223218 m=(1)
C1 (A VSS) capacitor c=1.27158e-16
C2 (Y VSS) capacitor c=2.0593e-17
C3 (VDD VSS) capacitor c=1.26258e-16
C4 (S0b VSS) capacitor c=6.98721e-17
C5 (n0 VSS) capacitor c=2.27031e-16
C6 (net140 VSS) capacitor c=9.82845e-18
C7 (net123 VSS) capacitor c=4.6781e-18
C8 (net115 VSS) capacitor c=4.39319e-18
C9 (\4\:B VSS) capacitor c=4.6208e-17
C10 (\3\:S0b VSS) capacitor c=5.02267e-17
C11 (\7\:S0 VSS) capacitor c=4.69184e-17
C12 (\1\:A VSS) capacitor c=5.73292e-17
C13 (\1\:S0 VSS) capacitor c=2.41403e-17
C14 (\3\:B VSS) capacitor c=4.66115e-17
C15 (\4\:S0 VSS) capacitor c=5.90533e-17
C16 (\3\:A VSS) capacitor c=7.25038e-17
C17 (\3\:S0 VSS) capacitor c=3.27893e-17
C18 (\1\:B VSS) capacitor c=2.45845e-17
C19 (\4\:S0b VSS) capacitor c=3.64091e-17
C20 (\6\:S0 VSS) capacitor c=5.52903e-17
C21 (\2\:S0b VSS) capacitor c=4.3976e-17
C22 (\2\:A VSS) capacitor c=4.96406e-17
C23 (\2\:S0 VSS) capacitor c=2.73216e-17
C24 (\1\:Y VSS) capacitor c=1.52576e-16
C25 (\1\:VDD VSS) capacitor c=1.56739e-16
C26 (\14\:n0 VSS) capacitor c=9.89126e-17
C27 (\10\:VDD VSS) capacitor c=5.00951e-17
C28 (\8\:S0b VSS) capacitor c=5.56441e-17
C29 (\12\:n0 VSS) capacitor c=5.77752e-17
C30 (\10\:S0b VSS) capacitor c=1.83759e-17
C31 (\2\:B VSS) capacitor c=2.74855e-17
C32 (\8\:S0 VSS) capacitor c=1.31401e-16
C33 (\9\:S0 VSS) capacitor c=1.13866e-16
C34 (\5\:S0b VSS) capacitor c=7.42628e-17
C35 (\6\:S0b VSS) capacitor c=9.31933e-17
C36 (\7\:S0b VSS) capacitor c=8.27887e-17
C37 (\5\:B VSS) capacitor c=1.22253e-16
C38 (\10\:n0 VSS) capacitor c=4.07464e-17
C39 (\11\:n0 VSS) capacitor c=9.68201e-17
C40 (\4\:Y VSS) capacitor c=6.43327e-17
C41 (\5\:VDD VSS) capacitor c=1.75903e-17
C42 (\6\:VDD VSS) capacitor c=1.22762e-17
Rk2 (\8\:S0 S0) resistor r=0.8194 c=0
Rk3 (S0 \9\:S0) resistor r=0.002989 c=0
Rk26 (\1\:VSS \5\:VSS) resistor r=0.1525 c=0
Rk28 (\6\:VSS VSS) resistor r=0.1422 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.4077 c=0
Rk30 (\6\:VSS \10\:VSS) resistor r=0.294 c=0
Rk13 (\1\:Y Y) resistor r=0.01846 c=0
Rk14 (Y \4\:Y) resistor r=0.2044 c=0
Rk19 (\1\:VDD \5\:VDD) resistor r=0.1525 c=0
Rk21 (\6\:VDD VDD) resistor r=0.2898 c=0
Rk20 (\5\:VDD \6\:VDD) resistor r=0.2601 c=0
Rk24 (\6\:VDD \11\:VDD) resistor r=0.2439 c=0
Rk8 (B \5\:B) resistor r=0.004698 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.34 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5036 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.3484 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.0962 c=0
Rk9 (\10\:n0 \11\:n0) resistor r=0.2249 c=0
Rk10 (\11\:n0 \13\:n0) resistor r=0.3794 c=0
Rk11 (\11\:n0 \15\:n0) resistor r=0.5369 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=36.5385 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=101.099 c=0
Rl8 (\5\:S0 \7\:S0) resistor r=69.3988 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=143.857 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=1.2666 c=0
Rl3 (\1\:A \2\:A) resistor r=65.3618 c=0
Rl4 (\2\:A \3\:A) resistor r=82.4874 c=0
Rl12 (\2\:B \4\:B) resistor r=34.3295 c=0
Rl11 (\2\:B \3\:B) resistor r=117.022 c=0
Rl10 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl9 (\3\:S0b \4\:S0b) resistor r=51.3412 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rz8 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\13\:n0 \12\:n0) resistor r=75 c=0
Ry8 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx2 (\6\:S0 \8\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \9\:S0) resistor r=45 c=0
Rx1 (\2\:A A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\10\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \3\:S0 \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=2.03e-14 ps=1.32e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.955e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (net148 \3\:A \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=1.56e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.70481e-07 sb=1.51e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (\12\:n0 S0b net148 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75481e-07 sb=1.405e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\12\:n0 \4\:S0 net140 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.32e-14 ad=4.16e-14 ps=1.16e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.80481e-07 sb=1.2e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=8.32e-14 ps=8.4e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04548e-06 sb=8.35e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn5_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.373e-14 ps=8.4e-07 pd=9.3333e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25048e-06 sb=6.3e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(3)
mp1 (net123 \1\:A \10\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=5.265e-14 ps=1.64e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.48718e-07 sb=1.425e-06 sd=160n sca=16.6245 \
        scb=0.014685 scc=0.00118863 m=(1)
mp2 (\14\:n0 \7\:S0 net123 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=6.24e-14 ps=1.05e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.28718e-07 sb=1.245e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp4 (\14\:n0 \3\:S0b net115 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.33718e-07 sb=1.04e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3 (net115 \4\:B \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03872e-06 sb=8.35e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.06e-14 ps=1.1e-06 pd=1.19333e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24372e-06 sb=6.3e-07 sd=160n sca=16.6869 \
        scb=0.0147126 scc=0.00118865 m=(3)
ends CLKMX2X3
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:02 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X4
// View name: extracted

simulator lang=spectre

subckt CLKMX2X4 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=3.01e-14 ps=9.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
C1 (S0 VSS) capacitor c=1.13994e-16
C2 (Y VSS) capacitor c=4.10688e-17
C3 (VDD VSS) capacitor c=2.03626e-16
C4 (B VSS) capacitor c=6.49146e-17
C5 (S0b VSS) capacitor c=4.66755e-17
C6 (n0 VSS) capacitor c=3.24935e-16
C7 (net140 VSS) capacitor c=2.39347e-18
C8 (net123 VSS) capacitor c=3.94347e-18
C9 (net115 VSS) capacitor c=3.57588e-18
C10 (\3\:B VSS) capacitor c=5.27198e-17
C11 (\3\:S0b VSS) capacitor c=4.52502e-17
C12 (\6\:S0 VSS) capacitor c=5.23534e-17
C13 (\3\:A VSS) capacitor c=7.27047e-17
C14 (\1\:S0 VSS) capacitor c=4.28813e-17
C15 (\1\:B VSS) capacitor c=7.31339e-17
C16 (\4\:S0 VSS) capacitor c=9.0366e-17
C17 (\2\:S0b VSS) capacitor c=4.41485e-17
C18 (\1\:A VSS) capacitor c=5.83532e-17
C19 (\3\:S0 VSS) capacitor c=5.62444e-17
C20 (\4\:B VSS) capacitor c=2.82171e-17
C21 (\4\:S0b VSS) capacitor c=4.74711e-17
C22 (\5\:S0 VSS) capacitor c=9.1697e-17
C23 (\2\:A VSS) capacitor c=6.0245e-17
C24 (\2\:S0 VSS) capacitor c=5.65806e-17
C25 (\1\:VDD VSS) capacitor c=1.88934e-16
C26 (\1\:Y VSS) capacitor c=1.56525e-16
C27 (\16\:n0 VSS) capacitor c=8.96735e-17
C28 (\12\:VDD VSS) capacitor c=3.77329e-17
C29 (\10\:S0b VSS) capacitor c=1.03783e-16
C30 (\18\:n0 VSS) capacitor c=5.96136e-17
C31 (\8\:S0b VSS) capacitor c=1.32478e-17
C32 (\2\:B VSS) capacitor c=4.769e-17
C33 (\4\:A VSS) capacitor c=1.17239e-16
C34 (\8\:S0 VSS) capacitor c=9.3998e-17
C35 (\5\:S0b VSS) capacitor c=6.51227e-17
C36 (\6\:S0b VSS) capacitor c=9.60327e-17
C37 (\7\:S0b VSS) capacitor c=9.91324e-17
C38 (\5\:B VSS) capacitor c=5.31854e-17
C39 (\14\:n0 VSS) capacitor c=4.45405e-17
C40 (\15\:n0 VSS) capacitor c=1.09431e-16
C41 (\4\:Y VSS) capacitor c=7.8567e-17
C42 (\6\:VDD VSS) capacitor c=2.07995e-17
C43 (\7\:VDD VSS) capacitor c=2.44378e-17
Rk2 (\7\:S0 S0) resistor r=0.002995 c=0
Rk3 (S0 \8\:S0) resistor r=0.6145 c=0
Rk13 (\1\:Y Y) resistor r=0.001906 c=0
Rk14 (Y \4\:Y) resistor r=0.3586 c=0
Rk1 (\4\:A A) resistor r=0.002995 c=0
Rk30 (\8\:VSS VSS) resistor r=0.185 c=0
Rk29 (\1\:VSS \8\:VSS) resistor r=0.3657 c=0
Rk32 (\8\:VSS \12\:VSS) resistor r=0.1864 c=0
Rk20 (\1\:VDD \6\:VDD) resistor r=0.03489 c=0
Rk22 (\7\:VDD VDD) resistor r=0.1765 c=0
Rk21 (\6\:VDD \7\:VDD) resistor r=0.3723 c=0
Rk25 (\7\:VDD \13\:VDD) resistor r=0.1185 c=0
Rk8 (\5\:B B) resistor r=0.06791 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.3117 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4883 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.05422 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7841 c=0
Rk9 (\14\:n0 \15\:n0) resistor r=0.2366 c=0
Rk10 (\15\:n0 \17\:n0) resistor r=0.5687 c=0
Rk11 (\15\:n0 \19\:n0) resistor r=0.348 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=266.862 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=73.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=212.23 c=0
Rl4 (\2\:A \3\:A) resistor r=118.644 c=0
Rl3 (\1\:A \2\:A) resistor r=134.226 c=0
Rl10 (\2\:B \3\:B) resistor r=78.3537 c=0
Rl9 (\1\:B \2\:B) resistor r=187.375 c=0
Rl11 (\2\:B \4\:B) resistor r=5.7469 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=41.3047 c=0
Rl5 (S0b \2\:S0b) resistor r=60.6943 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\17\:n0 \16\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\4\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\14\:n0 n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (net148 \1\:A \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.69e-14 ps=7.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.635e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn2 (\18\:n0 \2\:S0b net148 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.28e-14 ps=7.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3122e-07 sb=1.41e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn4 (\18\:n0 \4\:S0 net140 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=3.28e-14 ps=6.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3622e-07 sb=1.205e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn3 (net140 \1\:B \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.46e-14 ps=8.4e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0122e-07 sb=1.04e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn5_1__rcx (\4\:Y n0 \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.948e-14 ad=5.2e-14 ps=8.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93365e-07 sb=8.35e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
mp1 (net123 \3\:A \12\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=4.185e-14 ps=9.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80323e-07 sb=1.65e-06 sd=160n sca=12.241 \
        scb=0.00942952 scc=0.00011999 m=(1)
mp2 (\16\:n0 \6\:S0 net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60323e-07 sb=1.47e-06 sd=160n sca=11.1885 \
        scb=0.00841332 scc=0.000117337 m=(1)
mp4 (\16\:n0 \3\:S0b net115 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65323e-07 sb=1.265e-06 sd=160n sca=10.6105 \
        scb=0.00818197 scc=0.000117242 m=(1)
mp3 (net115 \3\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.65e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.60323e-07 sb=1.07e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.238e-14 ad=7.8e-14 ps=1.105e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99359e-07 sb=8.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
ends CLKMX2X4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:03 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X6
// View name: extracted

simulator lang=spectre

subckt CLKMX2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \3\:S0 \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=4.085e-14 ps=1.24e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=16.964 scb=0.0172681 \
        scc=0.000351906 m=(1)
C1 (S0 VSS) capacitor c=6.12246e-17
C2 (Y VSS) capacitor c=5.29618e-16
C3 (A VSS) capacitor c=4.14989e-17
C4 (VDD VSS) capacitor c=1.51052e-16
C5 (B VSS) capacitor c=1.0741e-16
C6 (S0b VSS) capacitor c=6.86241e-17
C7 (n0 VSS) capacitor c=3.26515e-16
C8 (net140 VSS) capacitor c=4.74361e-18
C9 (net123 VSS) capacitor c=4.30967e-18
C10 (net115 VSS) capacitor c=2.50176e-18
C11 (\1\:B VSS) capacitor c=5.01493e-17
C12 (\3\:S0b VSS) capacitor c=4.34362e-17
C13 (\6\:S0 VSS) capacitor c=4.14711e-17
C14 (\1\:A VSS) capacitor c=5.68635e-17
C15 (\3\:S0 VSS) capacitor c=3.2369e-17
C16 (\3\:B VSS) capacitor c=5.37035e-17
C17 (\4\:S0 VSS) capacitor c=6.39571e-17
C18 (\3\:A VSS) capacitor c=8.39622e-17
C19 (\1\:S0 VSS) capacitor c=4.62822e-17
C20 (\2\:B VSS) capacitor c=4.33859e-17
C21 (\4\:S0b VSS) capacitor c=4.2688e-17
C22 (\5\:S0 VSS) capacitor c=9.06271e-17
C23 (\2\:S0b VSS) capacitor c=5.61979e-17
C24 (\2\:A VSS) capacitor c=6.14321e-17
C25 (\2\:S0 VSS) capacitor c=4.43725e-17
C26 (\23\:n0 VSS) capacitor c=9.80213e-17
C27 (\14\:VDD VSS) capacitor c=2.90837e-17
C28 (\8\:S0b VSS) capacitor c=7.33764e-17
C29 (\1\:VDD VSS) capacitor c=3.09951e-17
C30 (\21\:n0 VSS) capacitor c=4.265e-17
C31 (\10\:S0b VSS) capacitor c=1.20888e-17
C32 (\4\:A VSS) capacitor c=7.65191e-17
C33 (\7\:S0 VSS) capacitor c=8.74935e-17
C34 (\8\:S0 VSS) capacitor c=3.64404e-17
C35 (\5\:S0b VSS) capacitor c=7.20062e-17
C36 (\6\:S0b VSS) capacitor c=8.60604e-17
C37 (\7\:S0b VSS) capacitor c=7.73479e-17
C38 (\19\:n0 VSS) capacitor c=6.13884e-17
C39 (\20\:n0 VSS) capacitor c=1.10144e-16
C40 (\3\:VDD VSS) capacitor c=2.71829e-16
C41 (\7\:VDD VSS) capacitor c=1.86157e-17
Rk2 (\7\:S0 S0) resistor r=0.424 c=0
Rk3 (S0 \8\:S0) resistor r=0.03791 c=0
Rk1 (A \4\:A) resistor r=0.03583 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.1227 c=0
Rk34 (\3\:VSS \6\:VSS) resistor r=0.08256 c=0
Rk36 (\7\:VSS VSS) resistor r=0.2278 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.3233 c=0
Rk40 (\7\:VSS \15\:VSS) resistor r=0.1775 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk24 (\3\:VDD \6\:VDD) resistor r=0.1302 c=0
Rk26 (\7\:VDD VDD) resistor r=0.1525 c=0
Rk25 (\6\:VDD \7\:VDD) resistor r=0.3985 c=0
Rk30 (\7\:VDD \15\:VDD) resistor r=0.231 c=0
Rk8 (B \4\:B) resistor r=0.003002 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.337 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5013 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.6219 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.05463 c=0
Rk9 (\19\:n0 \20\:n0) resistor r=0.3487 c=0
Rk10 (\20\:n0 \22\:n0) resistor r=0.3306 c=0
Rk11 (\20\:n0 \24\:n0) resistor r=0.5496 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=29.5379 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=229.104 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=66.4835 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=194.231 c=0
Rl3 (\1\:A \2\:A) resistor r=77.6148 c=0
Rl4 (\2\:A \3\:A) resistor r=144.923 c=0
Rl9 (\1\:B \2\:B) resistor r=73.7687 c=0
Rl10 (\2\:B \3\:B) resistor r=148.769 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=55.2823 c=0
Rl5 (S0b \2\:S0b) resistor r=68.4636 c=0
Rz11 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz7 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=75 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\24\:n0 \23\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\19\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \1\:S0 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.79977 scb=0.00524357 \
        scc=6.87485e-05 m=(1)
mn1 (net148 \3\:A \14\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52195e-07 sb=1.84e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (\21\:n0 S0b net148 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.57195e-07 sb=1.735e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn4 (\21\:n0 \4\:S0 net140 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.28e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.62195e-07 sb=1.53e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn3 (net140 \3\:B \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.74e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57195e-07 sb=1.235e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn5_1__rcx (Y n0 \3\:VSS VSS) g45n1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.916e-14 ad=5.456e-14 ps=9.48e-07 pd=9.72e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15645e-07 sb=1.01e-06 sd=160n sca=8.89324 \
        scb=0.00718666 scc=0.00021338 m=(5)
mp1 (net123 \1\:A \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=3.875e-14 ps=1.24e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08629e-07 sb=1.865e-06 sd=160n sca=12.5498 \
        scb=0.0102845 scc=0.000266006 m=(1)
mp2 (\23\:n0 \6\:S0 net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=6.2e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78629e-07 sb=1.695e-06 sd=160n sca=11.8758 \
        scb=0.0098568 scc=0.000265591 m=(1)
mp4 (\23\:n0 \3\:S0b net115 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=6.2e-14 ps=9.1e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=1.45e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp3 (net115 \1\:B \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01363e-06 sb=1.26e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp5_1__rcx (Y n0 \3\:VDD VDD) g45p1hvt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.917e-14 ad=7.332e-14 ps=1.298e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.00479e-07 sb=9.6e-07 sd=160n sca=21.0172 \
        scb=0.0163249 scc=0.00202715 m=(5)
ends CLKMX2X6
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:04 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKMX2X8
// View name: extracted

simulator lang=spectre

subckt CLKMX2X8 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.837e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.0095 scb=0.0106782 \
        scc=0.000192315 m=(1)
C1 (S0 VSS) capacitor c=5.04117e-17
C2 (Y VSS) capacitor c=4.70565e-16
C3 (VDD VSS) capacitor c=2.0849e-16
C4 (B VSS) capacitor c=3.45246e-17
C5 (S0b VSS) capacitor c=3.61488e-17
C6 (n0 VSS) capacitor c=3.59768e-16
C7 (net140 VSS) capacitor c=3.99956e-18
C8 (net123 VSS) capacitor c=5.90288e-18
C9 (net115 VSS) capacitor c=4.68461e-18
C10 (\1\:B VSS) capacitor c=3.85855e-17
C11 (\6\:S0 VSS) capacitor c=4.38874e-17
C12 (\1\:A VSS) capacitor c=6.24986e-17
C13 (\1\:S0 VSS) capacitor c=3.55211e-17
C14 (\3\:B VSS) capacitor c=4.52189e-17
C15 (\4\:S0 VSS) capacitor c=7.09373e-17
C16 (\3\:S0b VSS) capacitor c=3.01833e-17
C17 (\3\:A VSS) capacitor c=4.20689e-17
C18 (\3\:S0 VSS) capacitor c=5.14822e-17
C19 (\2\:B VSS) capacitor c=4.06175e-17
C20 (\2\:S0b VSS) capacitor c=3.90523e-17
C21 (\4\:S0b VSS) capacitor c=4.42922e-17
C22 (\5\:S0 VSS) capacitor c=8.43306e-17
C23 (\2\:A VSS) capacitor c=4.88704e-17
C24 (\2\:S0 VSS) capacitor c=3.87788e-17
C25 (\1\:VDD VSS) capacitor c=2.88853e-16
C26 (\26\:n0 VSS) capacitor c=8.34007e-17
C27 (\16\:VDD VSS) capacitor c=3.92118e-17
C28 (\8\:S0b VSS) capacitor c=9.63085e-17
C29 (\3\:VDD VSS) capacitor c=5.38824e-17
C30 (\23\:n0 VSS) capacitor c=4.39629e-17
C31 (\5\:S0b VSS) capacitor c=1.19429e-17
C32 (\4\:A VSS) capacitor c=4.6387e-17
C33 (\6\:A VSS) capacitor c=6.82336e-17
C34 (\7\:S0 VSS) capacitor c=9.99281e-17
C35 (\8\:S0 VSS) capacitor c=8.61653e-17
C36 (\7\:S0b VSS) capacitor c=1.06624e-16
C37 (\10\:S0b VSS) capacitor c=7.6679e-17
C38 (\11\:S0b VSS) capacitor c=5.4737e-17
C39 (\4\:B VSS) capacitor c=5.89686e-17
C40 (\25\:n0 VSS) capacitor c=1.13995e-16
C41 (\28\:n0 VSS) capacitor c=6.10018e-17
C42 (\9\:VDD VSS) capacitor c=1.83406e-17
Rk4 (S0 \7\:S0) resistor r=0.07534 c=0
Rk5 (\7\:S0 \8\:S0) resistor r=0.6924 c=0
Rk1 (\4\:A \5\:A) resistor r=0.003456 c=0
Rk2 (A \6\:A) resistor r=0.003369 c=0
Rk3 (\4\:A \6\:A) resistor r=0.1037 c=0
Rk40 (\1\:VSS \8\:VSS) resistor r=0.2027 c=0
Rk42 (\9\:VSS VSS) resistor r=0.2826 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.2678 c=0
Rk46 (\9\:VSS \17\:VSS) resistor r=0.2422 c=0
Rk29 (\1\:VDD \8\:VDD) resistor r=0.2953 c=0
Rk31 (\9\:VDD VDD) resistor r=0.2675 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.2828 c=0
Rk35 (\9\:VDD \17\:VDD) resistor r=0.1979 c=0
Rk10 (B \4\:B) resistor r=0.1626 c=0
Rk6 (\6\:S0b \7\:S0b) resistor r=0.05402 c=0
Rk7 (\7\:S0b \9\:S0b) resistor r=0.7964 c=0
Rk8 (\7\:S0b \10\:S0b) resistor r=0.5536 c=0
Rk9 (\10\:S0b \11\:S0b) resistor r=0.2331 c=0
Rk11 (\24\:n0 \25\:n0) resistor r=0.3054 c=0
Rk12 (\25\:n0 \27\:n0) resistor r=0.5835 c=0
Rk13 (\25\:n0 \28\:n0) resistor r=0.3686 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=169.923 c=0
Rl3 (\1\:A \2\:A) resistor r=133.384 c=0
Rl4 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl9 (\1\:B \2\:B) resistor r=81.461 c=0
Rl10 (\2\:B \3\:B) resistor r=117.999 c=0
Rl5 (S0b \2\:S0b) resistor r=33.8482 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=66.8207 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz8 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\5\:S0b \6\:S0b) resistor r=75 c=0
Rz2 (\24\:n0 \23\:n0) resistor r=75 c=0
Ry12 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry13 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\27\:n0 \26\:n0) resistor r=31 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \10\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \11\:S0b) resistor r=45 c=0
Rx7 (\28\:n0 n0) resistor r=45 c=0
mn0 (\5\:S0b \3\:S0 \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.1906 scb=0.0108717 \
        scc=0.000387468 m=(1)
mn1 (net148 \3\:A \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=4.817e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn2 (\23\:n0 \3\:S0b net148 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.715e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn4 (\23\:n0 \4\:S0 net140 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.715e-14 ps=7.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6122e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.357e-14 ad=3.382e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07122e-06 sb=1.8e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn5_1__rcx (Y n0 \1\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.097e-14 ad=5.226e-14 ps=9.5429e-07 pd=9.4429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02508e-06 sb=1.44e-06 sd=160n sca=13.5379 \
        scb=0.0132414 scc=0.000904444 m=(7)
mp1 (net123 \1\:A \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=5.735e-14 ps=1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61935e-07 sb=2e-06 sd=160n sca=11.3406 \
        scb=0.00879396 scc=0.000154509 m=(1)
mp2 (\26\:n0 \6\:S0 net123 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.425e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp4 (\26\:n0 S0b net115 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.37e-14 ad=5.425e-14 ps=1.16e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.11935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp3 (net115 \1\:B \1\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=8.37e-14 ps=1.52e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12694e-06 sb=1.8e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp5_1__rcx (Y n0 \1\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.691e-14 ad=7.883e-14 ps=1.25429e-06 pd=1.24429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.06618e-06 sb=1.44e-06 sd=160n \
        sca=14.4925 scb=0.0129103 scc=0.000843152 m=(7)
ends CLKMX2X8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:14:06 2013 )
// Library name: gsclib045_hvt
// Cell name: CLKXOR2X1
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X1 A B VDD VSS Y
mp5 (\1\:Y \4\:n0 \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.03654e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (A VSS) capacitor c=8.00352e-17
C2 (VDD VSS) capacitor c=1.19006e-16
C3 (Y VSS) capacitor c=4.65105e-17
C4 (B VSS) capacitor c=5.62197e-17
C5 (n0 VSS) capacitor c=2.29814e-17
C6 (n1 VSS) capacitor c=5.80448e-17
C7 (n2 VSS) capacitor c=5.50553e-17
C8 (net130 VSS) capacitor c=2.04336e-18
C9 (\7\:B VSS) capacitor c=3.79895e-17
C10 (\3\:n1 VSS) capacitor c=8.30989e-17
C11 (\2\:n2 VSS) capacitor c=8.60769e-17
C12 (\1\:B VSS) capacitor c=3.51366e-17
C13 (\1\:A VSS) capacitor c=4.37537e-17
C14 (\4\:n0 VSS) capacitor c=3.65769e-17
C15 (\5\:B VSS) capacitor c=4.27677e-17
C16 (\3\:B VSS) capacitor c=7.68548e-17
C17 (\3\:A VSS) capacitor c=4.29484e-17
C18 (\3\:n0 VSS) capacitor c=4.11985e-17
C19 (\6\:B VSS) capacitor c=5.54707e-17
C20 (\2\:n1 VSS) capacitor c=8.08103e-17
C21 (\4\:B VSS) capacitor c=7.41743e-17
C22 (\3\:n2 VSS) capacitor c=3.34761e-17
C23 (\2\:B VSS) capacitor c=4.08312e-17
C24 (\2\:A VSS) capacitor c=5.64589e-17
C25 (\4\:n2 VSS) capacitor c=1.29986e-17
C26 (\1\:VDD VSS) capacitor c=5.51736e-17
C27 (\8\:n0 VSS) capacitor c=1.22919e-16
C28 (\8\:n1 VSS) capacitor c=6.65199e-17
C29 (\6\:VDD VSS) capacitor c=2.75197e-17
C30 (\1\:Y VSS) capacitor c=7.93514e-17
C31 (\8\:n2 VSS) capacitor c=5.37854e-17
C32 (\5\:n0 VSS) capacitor c=1.2593e-16
C33 (\6\:n1 VSS) capacitor c=6.54697e-17
C34 (\3\:Y VSS) capacitor c=2.57457e-17
C35 (\2\:n0 VSS) capacitor c=1.92799e-17
C36 (\4\:A VSS) capacitor c=4.53432e-17
C37 (\7\:n0 VSS) capacitor c=2.38338e-16
C38 (\4\:n1 VSS) capacitor c=5.83893e-17
C39 (\5\:n1 VSS) capacitor c=1.27502e-16
C40 (\8\:B VSS) capacitor c=3.74039e-17
C41 (\9\:B VSS) capacitor c=4.42946e-17
C42 (\10\:B VSS) capacitor c=6.72349e-17
C43 (\6\:n2 VSS) capacitor c=1.1549e-16
C44 (\7\:n2 VSS) capacitor c=7.93283e-17
C45 (\4\:VDD VSS) capacitor c=4.20782e-17
C46 (\5\:VDD VSS) capacitor c=1.34955e-17
Rk3 (A \4\:A) resistor r=0.111 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.4317 c=0
Rk17 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.2483 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.2349 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.4973 c=0
Rk21 (\5\:VDD VDD) resistor r=0.1166 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.2323 c=0
Rk22 (\5\:VDD \7\:VDD) resistor r=0.06846 c=0
Rk1 (\2\:Y Y) resistor r=0.4562 c=0
Rk2 (Y \4\:Y) resistor r=0.04518 c=0
Rk9 (\8\:B B) resistor r=0.1323 c=0
