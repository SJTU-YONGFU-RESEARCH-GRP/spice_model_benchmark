Rk15 (\7\:n30 \8\:n30) resistor r=0.7398 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.473 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2059 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3244 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.3799 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1571 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.8393 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.0921 c=0
Rk27 (\10\:CKbb \15\:CKbb) resistor r=0.0921 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.07888 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2171 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5467 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3571 c=0
Rk39 (\2\:Db \4\:Db) resistor r=0.7348 c=0
Rk40 (\4\:Db \5\:Db) resistor r=0.0391 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.583 c=0
Rk42 (\7\:Db \9\:Db) resistor r=0.6106 c=0
Rk43 (\5\:Db \10\:Db) resistor r=0.0987 c=0
Rk48 (\4\:SEb \6\:SEb) resistor r=0.5531 c=0
Rk49 (\6\:SEb \8\:SEb) resistor r=0.5391 c=0
Rk19 (\2\:net349 \4\:net349) resistor r=0.3075 c=0
Rl29 (\1\:D \2\:D) resistor r=127.726 c=0
Rl31 (\2\:D \4\:D) resistor r=45.0334 c=0
Rl30 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl17 (\2\:RN \3\:RN) resistor r=603.412 c=0
Rl16 (\1\:RN \2\:RN) resistor r=215.232 c=0
Rl18 (\3\:RN \4\:RN) resistor r=96.9565 c=0
Rl19 (\4\:RN \5\:RN) resistor r=106.572 c=0
Rl20 (\4\:RN \6\:RN) resistor r=5.013 c=0
Rl38 (\5\:SE \6\:SE) resistor r=119.922 c=0
Rl39 (\6\:SE \7\:SE) resistor r=46.8456 c=0
Rl35 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl32 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl37 (\2\:SI \3\:SI) resistor r=101.477 c=0
Rl36 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl4 (\1\:CK \2\:CK) resistor r=104.538 c=0
Rl5 (\2\:CK \3\:CK) resistor r=110.307 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=160.771 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=24.2328 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=121.957 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=41.1873 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl28 (\8\:CKb \10\:CKb) resistor r=182.692 c=0
Rl25 (\5\:CKb \7\:CKb) resistor r=150 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=52.1862 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=64.1533 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl10 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl6 (n30 \2\:n30) resistor r=158.384 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl21 (mout \2\:mout) resistor r=108.79 c=0
Rl22 (\2\:mout \3\:mout) resistor r=72.2519 c=0
Rl26 (\6\:CKbb \7\:CKbb) resistor r=99.2573 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=41.5405 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=214.504 c=0
Rl12 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=51.0989 c=0
Rl14 (n20 \2\:n20) resistor r=138.462 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.404 c=0
Rz1 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz16 (\3\:VDD \4\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \16\:VDD) resistor r=6.25 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry17 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry18 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry19 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry20 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry21 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\21\:VDD \22\:VDD) resistor r=20.6667 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry9 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\3\:Db \10\:Db) resistor r=62 c=0
Ry13 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\6\:RN \7\:RN) resistor r=45 c=0
Rx17 (\1\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\6\:SE \10\:SE) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx3 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx4 (qbint \14\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn55 (\4\:Q \3\:qbint \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.73846e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn11 (net450 \4\:D \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=6.76e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=8.51635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41635e-07 sb=5.46635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46635e-07 sb=3.41635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51635e-07 sb=2.36635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn20 (\19\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.103e-14 ps=9e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn21 (\14\:CKbb \10\:CKb \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12276e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\7\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12276e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn46 (\10\:qbint \3\:n30 net337 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.793e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn45 (net337 \5\:RN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.28e-14 ps=1.06e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.95e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (net405 \7\:qbint \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=1.23e-14 ps=1.06e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.685e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.58e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.945e-14 ad=5.228e-14 ps=9.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.28e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (\6\:mout n20 \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=5.945e-14 ps=1.24e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=9.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net426 \1\:RN \10\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=2.665e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=7.1e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=1.333e-14 ps=6.7e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.35e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.333e-14 ad=4.613e-14 ps=5.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.915e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=4.613e-14 ps=7.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mp20 (\15\:CKb \1\:CK \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.118e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.6299 \
        scb=0.00978612 scc=8.84613e-05 m=(1)
mp21 (\8\:CKbb \8\:CKb \5\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.98e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp10 (\5\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=3.01e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=25.1693 \
        scb=0.0296469 scc=0.00157586 m=(1)
mp46 (\12\:qbint n30 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=12.1897 \
        scb=0.0106254 scc=0.000361908 m=(1)
mp45 (\14\:VDD \3\:RN \12\:qbint VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=6.82e-14 ps=9.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp50 (net326 \5\:qbint \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=4.805e-14 ps=1.06e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.265e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.065e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=8.6e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp30 (\8\:mout \3\:n20 \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=5.85e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp35 (\3\:net349 \2\:RN \11\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=4.96e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.2e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp36 (\3\:net349 mout \8\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.883e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.15e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
ends SDFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:38 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX2 CK D Q RN SE SI VDD VSS
mp11 (net381 \1\:D \6\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=4.29e-14 ps=1.85e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.51603e-07 sb=8.29551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\4\:Db \2\:SE net381 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.02e-14 ps=1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.06603e-07 sb=6.74551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\4\:Db SEb net373 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.31603e-07 sb=4.49551e-07 sd=160n sca=17.5519 \
        scb=0.0153572 scc=0.00137894 m=(1)
mp13 (net373 \3\:SI \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.11603e-07 sb=2.69551e-07 sd=160n sca=18.2813 \
        scb=0.0158345 scc=0.00137945 m=(1)
mp55 (\3\:Q qbint VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=36.4171 \
        scb=0.0367067 scc=0.00372944 m=(2)
C1 (D VSS) capacitor c=4.11697e-17
C2 (Q VSS) capacitor c=4.33011e-17
C3 (RN VSS) capacitor c=6.24142e-17
C4 (VDD VSS) capacitor c=4.81946e-16
C5 (SE VSS) capacitor c=5.36417e-17
C6 (SI VSS) capacitor c=6.94639e-17
C7 (CK VSS) capacitor c=7.04354e-17
C8 (qbint VSS) capacitor c=1.81195e-16
C9 (CKb VSS) capacitor c=4.40417e-17
C10 (net337 VSS) capacitor c=9.20655e-18
C11 (n30 VSS) capacitor c=5.93833e-17
C12 (net405 VSS) capacitor c=3.70463e-18
C13 (mout VSS) capacitor c=5.56644e-17
C14 (CKbb VSS) capacitor c=2.22947e-17
C15 (n20 VSS) capacitor c=3.73225e-17
C16 (net426 VSS) capacitor c=6.64024e-19
C17 (net422 VSS) capacitor c=1.2838e-18
C18 (Db VSS) capacitor c=8.41882e-17
C19 (net450 VSS) capacitor c=5.79847e-18
C20 (SEb VSS) capacitor c=4.54992e-17
C21 (net326 VSS) capacitor c=5.02997e-18
C22 (net349 VSS) capacitor c=6.8402e-17
C23 (net381 VSS) capacitor c=3.83547e-18
C24 (net373 VSS) capacitor c=4.02889e-18
C25 (\7\:SE VSS) capacitor c=4.98971e-17
C26 (\3\:SI VSS) capacitor c=5.83597e-17
C27 (\2\:SE VSS) capacitor c=5.18514e-17
C28 (\1\:D VSS) capacitor c=7.79173e-17
C29 (\8\:CKb VSS) capacitor c=3.88657e-17
C30 (\8\:CKbb VSS) capacitor c=5.29726e-17
C31 (\6\:CKb VSS) capacitor c=4.9626e-17
C32 (\3\:mout VSS) capacitor c=6.16002e-17
C33 (\2\:RN VSS) capacitor c=1.53488e-16
C34 (\3\:n20 VSS) capacitor c=5.5486e-17
C35 (\3\:CKb VSS) capacitor c=3.22663e-17
C36 (\3\:CKbb VSS) capacitor c=9.12358e-17
C37 (\8\:qbint VSS) capacitor c=8.61351e-17
C38 (\3\:RN VSS) capacitor c=1.17724e-16
C39 (\3\:CK VSS) capacitor c=4.66436e-17
C40 (\5\:SE VSS) capacitor c=3.13918e-17
C41 (\1\:SI VSS) capacitor c=8.0051e-17
C42 (\3\:SE VSS) capacitor c=6.48669e-17
C43 (\3\:SEb VSS) capacitor c=5.416e-17
C44 (\4\:D VSS) capacitor c=3.91057e-17
C45 (\10\:CKb VSS) capacitor c=5.61482e-17
C46 (\5\:CKb VSS) capacitor c=5.44067e-17
C47 (\5\:CKbb VSS) capacitor c=4.19581e-17
C48 (\1\:RN VSS) capacitor c=1.02315e-16
C49 (\10\:qbint VSS) capacitor c=4.09787e-17
C50 (\5\:RN VSS) capacitor c=4.50769e-17
C51 (\3\:n30 VSS) capacitor c=2.06857e-17
C52 (\1\:CK VSS) capacitor c=3.89989e-17
C53 (\6\:SE VSS) capacitor c=3.89025e-17
C54 (\2\:SI VSS) capacitor c=6.56237e-17
C55 (\4\:SE VSS) capacitor c=4.20373e-17
C56 (\2\:SEb VSS) capacitor c=7.0983e-17
C57 (\1\:SE VSS) capacitor c=4.38754e-17
C58 (\3\:D VSS) capacitor c=2.87942e-17
C59 (\9\:CKb VSS) capacitor c=2.66716e-17
C60 (\7\:CKbb VSS) capacitor c=3.65191e-17
C61 (\7\:CKb VSS) capacitor c=1.89302e-17
C62 (\6\:CKbb VSS) capacitor c=4.7307e-17
C63 (\2\:mout VSS) capacitor c=7.879e-17
C64 (\2\:n20 VSS) capacitor c=3.75988e-17
C65 (\4\:CKbb VSS) capacitor c=1.57815e-17
C66 (\4\:CKb VSS) capacitor c=3.53034e-17
C67 (\2\:CKb VSS) capacitor c=5.32255e-17
C68 (\9\:qbint VSS) capacitor c=5.07465e-17
C69 (\4\:RN VSS) capacitor c=5.13973e-17
C70 (\2\:n30 VSS) capacitor c=4.48712e-17
C71 (\2\:CK VSS) capacitor c=4.69294e-17
C72 (\6\:SEb VSS) capacitor c=1.13647e-16
C73 (\1\:VDD VSS) capacitor c=3.05594e-17
C74 (\4\:Db VSS) capacitor c=5.35961e-17
C75 (\6\:VDD VSS) capacitor c=1.18366e-17
C76 (\9\:CKbb VSS) capacitor c=6.97422e-17
C77 (\6\:Db VSS) capacitor c=1.63365e-16
C78 (\4\:n20 VSS) capacitor c=5.74091e-17
C79 (\10\:VDD VSS) capacitor c=2.15828e-17
C80 (\3\:net349 VSS) capacitor c=6.51443e-17
C81 (\13\:VDD VSS) capacitor c=3.08651e-17
C82 (\4\:mout VSS) capacitor c=4.38529e-17
C83 (\4\:n30 VSS) capacitor c=1.09629e-16
C84 (\16\:VDD VSS) capacitor c=3.63313e-17
C85 (\16\:qbint VSS) capacitor c=7.67069e-17
C86 (\19\:VDD VSS) capacitor c=2.51884e-17
C87 (\16\:CKb VSS) capacitor c=3.33823e-17
C88 (\3\:Q VSS) capacitor c=5.56089e-17
C89 (\3\:VDD VSS) capacitor c=7.40263e-17
C90 (\4\:SEb VSS) capacitor c=6.62522e-17
C91 (\12\:CKbb VSS) capacitor c=6.3899e-17
C92 (\8\:Db VSS) capacitor c=8.6661e-17
C93 (\8\:n20 VSS) capacitor c=7.1249e-17
C94 (\7\:mout VSS) capacitor c=4.05092e-17
C95 (\6\:n30 VSS) capacitor c=1.28978e-16
C96 (\13\:qbint VSS) capacitor c=1.47497e-16
C97 (\20\:CKb VSS) capacitor c=1.19781e-16
C98 (\1\:Q VSS) capacitor c=5.46167e-17
C99 (\2\:CKbb VSS) capacitor c=4.54147e-17
C100 (\2\:D VSS) capacitor c=2.26865e-17
C101 (\4\:CK VSS) capacitor c=5.46688e-17
C102 (\11\:qbint VSS) capacitor c=7.81964e-17
C103 (\12\:qbint VSS) capacitor c=1.30111e-16
C104 (\15\:qbint VSS) capacitor c=1.15183e-16
C105 (\6\:RN VSS) capacitor c=7.56612e-17
C106 (\8\:n30 VSS) capacitor c=1.09476e-16
C107 (\6\:mout VSS) capacitor c=8.148e-17
C108 (\9\:mout VSS) capacitor c=7.7883e-17
C109 (\6\:n20 VSS) capacitor c=9.87486e-17
C110 (\7\:n20 VSS) capacitor c=1.02595e-16
C111 (\11\:CKbb VSS) capacitor c=4.41232e-17
C112 (\14\:CKbb VSS) capacitor c=1.63936e-16
C113 (\15\:CKbb VSS) capacitor c=1.18199e-16
C114 (\16\:CKbb VSS) capacitor c=1.68146e-17
C115 (\17\:CKbb VSS) capacitor c=6.18652e-17
C116 (\11\:CKb VSS) capacitor c=7.16366e-17
C117 (\12\:CKb VSS) capacitor c=1.82066e-16
C118 (\13\:CKb VSS) capacitor c=1.04456e-16
C119 (\14\:CKb VSS) capacitor c=1.33516e-16
C120 (\15\:CKb VSS) capacitor c=1.2496e-16
C121 (\18\:CKb VSS) capacitor c=5.41669e-17
C122 (\19\:CKb VSS) capacitor c=7.93886e-17
C123 (\5\:D VSS) capacitor c=6.89115e-17
C124 (\3\:Db VSS) capacitor c=1.28991e-16
C125 (\8\:SE VSS) capacitor c=7.18533e-17
C126 (\10\:SE VSS) capacitor c=4.97078e-17
C127 (\4\:SI VSS) capacitor c=7.18659e-17
C128 (\8\:SEb VSS) capacitor c=7.73214e-17
C129 (\5\:VDD VSS) capacitor c=3.19384e-17
C130 (\9\:VDD VSS) capacitor c=9.78922e-18
C131 (\12\:VDD VSS) capacitor c=4.0042e-17
C132 (\15\:VDD VSS) capacitor c=4.5291e-17
C133 (\18\:VDD VSS) capacitor c=1.04229e-17
Rk32 (\5\:D D) resistor r=0.1125 c=0
Rk1 (\2\:Q Q) resistor r=0.3383 c=0
Rk2 (Q \4\:Q) resistor r=0.04504 c=0
Rk8 (RN \6\:RN) resistor r=0.0315 c=0
Rk57 (\2\:VDD \4\:VDD) resistor r=0.3041 c=0
Rk58 (\4\:VDD \5\:VDD) resistor r=0.4208 c=0
Rk59 (\5\:VDD \7\:VDD) resistor r=0.04331 c=0
Rk60 (\5\:VDD \8\:VDD) resistor r=0.4302 c=0
Rk61 (\8\:VDD \9\:VDD) resistor r=0.1192 c=0
Rk62 (\9\:VDD \11\:VDD) resistor r=0.04331 c=0
Rk63 (\9\:VDD \12\:VDD) resistor r=0.2193 c=0
Rk64 (\12\:VDD \14\:VDD) resistor r=0.1528 c=0
Rk65 (\12\:VDD \15\:VDD) resistor r=0.5639 c=0
Rk66 (\15\:VDD \17\:VDD) resistor r=0.1528 c=0
Rk67 (\15\:VDD \18\:VDD) resistor r=0.2504 c=0
Rk68 (\18\:VDD \20\:VDD) resistor r=0.1374 c=0
Rk70 (\21\:VDD VDD) resistor r=0.3434 c=0
Rk69 (\18\:VDD \21\:VDD) resistor r=0.04745 c=0
Rk39 (\9\:SE SE) resistor r=0.009307 c=0
Rk38 (\8\:SE \9\:SE) resistor r=0.3319 c=0
Rk40 (SE \10\:SE) resistor r=0.2305 c=0
Rk41 (\4\:SI SI) resistor r=0.1334 c=0
Rk44 (\2\:VSS \4\:VSS) resistor r=0.3672 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.4061 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.4462 c=0
Rk47 (\6\:VSS \7\:VSS) resistor r=0.2822 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.6783 c=0
Rk50 (\9\:VSS VSS) resistor r=0.3459 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.2406 c=0
Rk52 (\5\:VSS \12\:VSS) resistor r=0.231 c=0
Rk53 (\7\:VSS \14\:VSS) resistor r=0.04331 c=0
Rk54 (\8\:VSS \16\:VSS) resistor r=0.1628 c=0
Rk3 (\4\:CK CK) resistor r=0.05672 c=0
Rk4 (\11\:qbint \12\:qbint) resistor r=0.4802 c=0
Rk5 (\12\:qbint \14\:qbint) resistor r=0.5459 c=0
Rk6 (\14\:qbint \15\:qbint) resistor r=0.7093 c=0
Rk7 (\12\:qbint \17\:qbint) resistor r=0.3532 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.4756 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.9859 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2399 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.797 c=0
Rk28 (\15\:CKb \17\:CKb) resistor r=0.0824 c=0
Rk29 (\13\:CKb \18\:CKb) resistor r=0.2755 c=0
Rk30 (\14\:CKb \19\:CKb) resistor r=0.3888 c=0
Rk31 (\15\:CKb \21\:CKb) resistor r=0.6116 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.4983 c=0
Rk10 (\7\:n30 \8\:n30) resistor r=0.8286 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3143 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.09076 c=0
Rk13 (\6\:mout \9\:mout) resistor r=0.4237 c=0
Rk18 (\10\:CKbb \11\:CKbb) resistor r=0.3423 c=0
Rk19 (\11\:CKbb \13\:CKbb) resistor r=0.1285 c=0
Rk20 (\13\:CKbb \14\:CKbb) resistor r=0.6103 c=0
Rk21 (\14\:CKbb \15\:CKbb) resistor r=0.9205 c=0
Rk22 (\11\:CKbb \16\:CKbb) resistor r=0.04461 c=0
Rk23 (\14\:CKbb \17\:CKbb) resistor r=0.2339 c=0
Rk15 (\5\:n20 \6\:n20) resistor r=0.2275 c=0
Rk16 (\6\:n20 \7\:n20) resistor r=0.6229 c=0
Rk17 (\6\:n20 \9\:n20) resistor r=0.3042 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.5529 c=0
Rk34 (\3\:Db \5\:Db) resistor r=0.1548 c=0
Rk35 (\3\:Db \7\:Db) resistor r=0.6961 c=0
Rk36 (\7\:Db \9\:Db) resistor r=0.5164 c=0
Rk37 (\5\:Db \10\:Db) resistor r=0.1478 c=0
Rk42 (\5\:SEb \7\:SEb) resistor r=0.6566 c=0
Rk43 (\7\:SEb \8\:SEb) resistor r=0.4758 c=0
Rk14 (\2\:net349 \4\:net349) resistor r=0.2443 c=0
Rl32 (\1\:D \2\:D) resistor r=102.726 c=0
Rl34 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl33 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl21 (\2\:RN \3\:RN) resistor r=738.027 c=0
Rl20 (\1\:RN \2\:RN) resistor r=193.362 c=0
Rl22 (\3\:RN \4\:RN) resistor r=50 c=0
Rl23 (\4\:RN \5\:RN) resistor r=99.1758 c=0
Rl42 (\6\:SE \7\:SE) resistor r=95.3297 c=0
Rl41 (\5\:SE \6\:SE) resistor r=32.6923 c=0
Rl38 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl35 (\1\:SE \2\:SE) resistor r=32.6096 c=0
Rl40 (\2\:SI \3\:SI) resistor r=44.4497 c=0
Rl39 (\1\:SI \2\:SI) resistor r=86.3335 c=0
Rl8 (\2\:CK \3\:CK) resistor r=129.944 c=0
Rl7 (\1\:CK \2\:CK) resistor r=53.0211 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=123.799 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=24.2328 c=0
Rl5 (qbint \6\:qbint) resistor r=3.5051 c=0
Rl31 (\8\:CKb \10\:CKb) resistor r=150 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=164.95 c=0
Rl30 (\8\:CKb \9\:CKb) resistor r=61.0982 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=37.2302 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl9 (n30 \2\:n30) resistor r=184.593 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=24.7951 c=0
Rl25 (\2\:mout \3\:mout) resistor r=119.952 c=0
Rl24 (mout \2\:mout) resistor r=24.2328 c=0
Rl29 (\7\:CKbb \8\:CKbb) resistor r=113.439 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=35.7713 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=176.797 c=0
Rl15 (CKbb \2\:CKbb) resistor r=23.7402 c=0
Rl17 (\2\:CKbb \4\:CKbb) resistor r=35.2766 c=0
Rl19 (\2\:n20 \3\:n20) resistor r=97.631 c=0
Rl18 (n20 \2\:n20) resistor r=70.3867 c=0
Rl36 (SEb \2\:SEb) resistor r=25.0391 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=122.356 c=0
Rz1 (\2\:Q \1\:Q) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=15 c=0
Rz18 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz19 (\21\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz7 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz6 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry19 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry20 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry21 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry22 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry14 (\4\:VSS \3\:VSS) resistor r=12.4 c=0
Ry15 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry2 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry9 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\4\:Db \10\:Db) resistor r=62 c=0
Ry13 (\6\:SEb \7\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\4\:RN \6\:RN) resistor r=45 c=0
Rx16 (\1\:SE \8\:SE) resistor r=45 c=0
Rx17 (\4\:SE \9\:SE) resistor r=45 c=0
Rx18 (\6\:SE \10\:SE) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\15\:qbint \6\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \9\:mout) resistor r=45 c=0
Rx8 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\7\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn11 (net450 \4\:D \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=5.07e-14 ps=9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.40769e-07 sb=8.77212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=6.37e-14 ps=9.1e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.80769e-07 sb=6.37212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.37e-14 ps=6.4e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.70769e-07 sb=3.47212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75769e-07 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn55_1__rcx (\1\:Q qbint VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.23462e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
mn20 (\20\:CKb \1\:CK VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.25e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn21 (\12\:CKbb \10\:CKb \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.843e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.21621e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33759e-06 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn46 (\13\:qbint \3\:n30 net337 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn45 (net337 \5\:RN \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=6.458e-14 ps=1.06e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn50 (net405 \10\:qbint \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=2.768e-14 ps=1.06e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=3.69e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.895e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn40 (\6\:n30 CKbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.1173e-13 ad=3.69e-14 ps=1.5e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1.67e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn30 (\7\:mout n20 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.783e-14 ad=1.1173e-13 ps=1.47e-06 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.08e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (net426 \1\:RN \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.783e-14 ad=1.23e-14 ps=1.47e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.5e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn36 (net422 mout net426 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.768e-14 ps=5.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.45e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn37 (\8\:n20 \5\:CKbb net422 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.65e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn25 (\8\:n20 \5\:CKb \8\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=5.432e-14 ps=7.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mp20 (\16\:CKb \3\:CK VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=13.0129 \
        scb=0.0110013 scc=0.000282677 m=(1)
mp21 (\9\:CKbb \8\:CKb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.17e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp10 (\6\:SEb \7\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=1.4e-07 sd=160n sca=26.3819 \
        scb=0.0255791 scc=0.00246259 m=(1)
mp46 (\16\:qbint n30 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=4.96e-14 ps=1.45e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.9e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp45 (\16\:VDD \3\:RN \16\:qbint VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=9.4e-14 ps=9.4e-07 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.695e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp50 (net326 \8\:qbint \16\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=3.1e-14 ps=1.49e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.43e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=7.905e-14 ps=8.2e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.285e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.147e-13 ad=7.905e-14 ps=1.36e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=9.85e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp30 (\4\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=1.147e-13 ps=1.49e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=5.7e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp35 (\3\:net349 \2\:RN \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.4e-14 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=3.05e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp36 (\3\:net349 \3\:mout \10\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.64e-14 ad=4.96e-14 ps=1.64e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=1e-07 sd=160n sca=17.3904 scb=0.0162056 \
        scc=0.00137566 m=(1)
mp37 (\4\:n20 \6\:CKb net349 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.45e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp25 (\4\:n20 \8\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
ends SDFFRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:40 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX4 CK D Q RN SE SI VDD VSS
mp20 (\13\:CKb \3\:CK \9\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1192e-13 ad=4.085e-14 ps=1.88e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.4457e-06 sd=160n sca=18.4108 \
        scb=0.0197286 scc=0.000520456 m=(1)
mp21 (\9\:CKbb \7\:CKb \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.34e-14 ad=2.73e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26977e-07 sb=1.11279e-06 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp10 (\7\:SEb \4\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14442e-06 sb=1.4e-07 sd=160n sca=31.4748 \
        scb=0.0307939 scc=0.00317368 m=(1)
C1 (D VSS) capacitor c=5.73444e-17
C2 (RN VSS) capacitor c=5.49784e-16
C3 (Q VSS) capacitor c=1.63654e-16
C4 (VDD VSS) capacitor c=4.695e-16
C5 (CK VSS) capacitor c=4.25812e-17
C6 (CKb VSS) capacitor c=6.06448e-17
C7 (qbint VSS) capacitor c=2.75719e-16
C8 (21 VSS) capacitor c=2.881e-18
C9 (n30 VSS) capacitor c=1.27077e-16
C10 (22 VSS) capacitor c=2.92145e-18
C11 (net405 VSS) capacitor c=5.16852e-18
C12 (mout VSS) capacitor c=3.82818e-17
C13 (CKbb VSS) capacitor c=4.09969e-17
C14 (n20 VSS) capacitor c=2.14663e-17
C15 (net422 VSS) capacitor c=3.2421e-19
C16 (Db VSS) capacitor c=1.07754e-16
C17 (net450 VSS) capacitor c=1.78551e-18
C18 (SEb VSS) capacitor c=6.59871e-17
C19 (net442 VSS) capacitor c=4.47651e-18
C20 (net326 VSS) capacitor c=2.84457e-18
C21 (net349 VSS) capacitor c=7.61268e-17
C22 (net381 VSS) capacitor c=1.88088e-18
C23 (net373 VSS) capacitor c=4.93146e-18
C24 (\4\:SE VSS) capacitor c=3.67092e-17
C25 (\1\:SI VSS) capacitor c=5.15078e-17
C26 (\3\:SEb VSS) capacitor c=4.81378e-17
C27 (\3\:SE VSS) capacitor c=1.13277e-16
C28 (\1\:D VSS) capacitor c=1.00477e-16
C29 (\7\:CKb VSS) capacitor c=4.40659e-17
C30 (\7\:CKbb VSS) capacitor c=3.37813e-17
C31 (\4\:CKb VSS) capacitor c=4.68809e-17
C32 (\8\:RN VSS) capacitor c=4.13293e-17
C33 (\4\:n20 VSS) capacitor c=5.15114e-17
C34 (\2\:CKb VSS) capacitor c=4.41979e-17
C35 (\2\:CKbb VSS) capacitor c=4.42099e-17
C36 (\16\:qbint VSS) capacitor c=3.97612e-17
C37 (\3\:CK VSS) capacitor c=3.50539e-17
C38 (\6\:SE VSS) capacitor c=2.46577e-17
C39 (\3\:SI VSS) capacitor c=4.8893e-17
C40 (\1\:SE VSS) capacitor c=3.54646e-17
C41 (\3\:D VSS) capacitor c=6.92661e-17
C42 (\9\:CKb VSS) capacitor c=5.58843e-17
C43 (\6\:CKb VSS) capacitor c=4.29424e-17
C44 (\5\:CKbb VSS) capacitor c=4.1419e-17
C45 (\3\:mout VSS) capacitor c=3.58675e-17
C46 (\10\:RN VSS) capacitor c=3.59801e-17
C47 (\3\:n20 VSS) capacitor c=2.49917e-17
C48 (\3\:CKbb VSS) capacitor c=4.33424e-17
C49 (\18\:qbint VSS) capacitor c=3.89382e-17
C50 (\7\:RN VSS) capacitor c=3.12334e-17
C51 (\5\:n30 VSS) capacitor c=2.79566e-17
C52 (\4\:n30 VSS) capacitor c=3.5262e-17
C53 (\1\:RN VSS) capacitor c=4.18946e-17
C54 (\1\:CK VSS) capacitor c=3.59943e-17
C55 (\5\:SE VSS) capacitor c=2.31659e-17
C56 (\2\:SI VSS) capacitor c=4.49385e-17
C57 (\4\:SEb VSS) capacitor c=4.69337e-17
C58 (\2\:SE VSS) capacitor c=5.62216e-17
C59 (\2\:SEb VSS) capacitor c=5.96916e-17
C60 (\2\:D VSS) capacitor c=5.25715e-17
C61 (\8\:CKb VSS) capacitor c=2.28781e-17
C62 (\8\:CKbb VSS) capacitor c=1.69935e-17
C63 (\5\:CKb VSS) capacitor c=2.70746e-17
C64 (\6\:CKbb VSS) capacitor c=4.15418e-17
C65 (\2\:mout VSS) capacitor c=3.1834e-17
C66 (\9\:RN VSS) capacitor c=3.30536e-17
C67 (\4\:CKbb VSS) capacitor c=2.88887e-17
C68 (\3\:CKb VSS) capacitor c=2.54963e-17
C69 (\17\:qbint VSS) capacitor c=3.01948e-17
C70 (\2\:CK VSS) capacitor c=3.71928e-17
C71 (\7\:SEb VSS) capacitor c=8.94002e-17
C72 (\1\:VDD VSS) capacitor c=5.85228e-17
C73 (\15\:VDD VSS) capacitor c=4.92591e-17
C74 (\9\:CKbb VSS) capacitor c=6.14186e-17
C75 (\7\:Db VSS) capacitor c=2.49777e-17
C76 (\5\:n20 VSS) capacitor c=1.02503e-16
C77 (\17\:VDD VSS) capacitor c=2.07029e-17
C78 (\3\:net349 VSS) capacitor c=7.93243e-17
C79 (\19\:VDD VSS) capacitor c=2.56926e-17
C80 (\5\:mout VSS) capacitor c=1.68762e-16
C81 (\11\:n30 VSS) capacitor c=8.67987e-17
C82 (\23\:VDD VSS) capacitor c=2.02192e-17
C83 (\20\:qbint VSS) capacitor c=1.50326e-16
C84 (\13\:CKb VSS) capacitor c=2.52689e-16
C85 (\3\:VDD VSS) capacitor c=7.52528e-17
C86 (\5\:SEb VSS) capacitor c=6.83214e-17
C87 (\9\:Db VSS) capacitor c=7.90035e-17
C88 (\16\:CKbb VSS) capacitor c=6.58906e-17
C89 (\5\:Db VSS) capacitor c=7.18943e-17
C90 (\9\:n20 VSS) capacitor c=1.7657e-17
C91 (\7\:mout VSS) capacitor c=8.86754e-17
C92 (\7\:n30 VSS) capacitor c=7.7001e-17
C93 (\23\:qbint VSS) capacitor c=7.50706e-17
C94 (\15\:CKb VSS) capacitor c=7.76983e-17
C95 (\2\:n20 VSS) capacitor c=1.82171e-17
C96 (\4\:CK VSS) capacitor c=6.19142e-17
C97 (\19\:qbint VSS) capacitor c=4.37096e-17
C98 (\27\:qbint VSS) capacitor c=6.66058e-17
C99 (\9\:n30 VSS) capacitor c=1.27463e-16
C100 (\10\:n30 VSS) capacitor c=1.11501e-16
C101 (\11\:RN VSS) capacitor c=2.44392e-16
C102 (\4\:mout VSS) capacitor c=1.23355e-16
C103 (\7\:n20 VSS) capacitor c=1.14799e-16
C104 (\8\:n20 VSS) capacitor c=1.02171e-16
C105 (\11\:CKbb VSS) capacitor c=5.91695e-17
C106 (\12\:CKbb VSS) capacitor c=2.75361e-16
C107 (\13\:CKbb VSS) capacitor c=2.19179e-16
C108 (\14\:CKbb VSS) capacitor c=4.87076e-17
C109 (\15\:CKbb VSS) capacitor c=7.24203e-17
C110 (\18\:CKbb VSS) capacitor c=7.98683e-17
C111 (\19\:CKbb VSS) capacitor c=3.39523e-17
C112 (\10\:CKb VSS) capacitor c=1.00015e-16
C113 (\11\:CKb VSS) capacitor c=2.38279e-16
C114 (\12\:CKb VSS) capacitor c=3.63035e-16
C115 (\4\:D VSS) capacitor c=6.90663e-17
C116 (\3\:Db VSS) capacitor c=9.18643e-17
C117 (\4\:Db VSS) capacitor c=1.45257e-16
C118 (\4\:SI VSS) capacitor c=1.17488e-16
C119 (\7\:SE VSS) capacitor c=9.21511e-17
C120 (\8\:SE VSS) capacitor c=8.13725e-17
C121 (\9\:SEb VSS) capacitor c=1.1325e-16
C122 (\10\:SEb VSS) capacitor c=6.39036e-17
C123 (\5\:VDD VSS) capacitor c=3.96763e-17
C124 (\6\:VDD VSS) capacitor c=5.35703e-17
C125 (\7\:VDD VSS) capacitor c=1.5646e-17
C126 (\9\:VDD VSS) capacitor c=2.17073e-16
Rk36 (D \4\:D) resistor r=0.102 c=0
Rk14 (\11\:RN RN) resistor r=1.5556 c=0
Rk48 (\2\:VDD \4\:VDD) resistor r=0.5417 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.09006 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.668 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.3437 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.09663 c=0
Rk59 (\9\:VDD VDD) resistor r=0.1951 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.5764 c=0
Rk60 (\5\:VDD \16\:VDD) resistor r=0.308 c=0
Rk61 (\6\:VDD \18\:VDD) resistor r=0.04329 c=0
Rk62 (\7\:VDD \20\:VDD) resistor r=0.04329 c=0
Rk64 (\9\:VDD \24\:VDD) resistor r=0.07369 c=0
Rk43 (SE \7\:SE) resistor r=0.004839 c=0
Rk44 (\7\:SE \8\:SE) resistor r=0.5605 c=0
Rk42 (\4\:SI SI) resistor r=0.003618 c=0
Rk68 (\2\:VSS \4\:VSS) resistor r=0.4784 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.1201 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.9999 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.08253 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.5755 c=0
Rk77 (\9\:VSS VSS) resistor r=0.2929 c=0
Rk73 (\8\:VSS \9\:VSS) resistor r=0.4324 c=0
Rk78 (\5\:VSS \14\:VSS) resistor r=0.199 c=0
Rk79 (\6\:VSS \16\:VSS) resistor r=0.2814 c=0
Rk80 (\8\:VSS \18\:VSS) resistor r=0.04329 c=0
Rk1 (CK \4\:CK) resistor r=0.08996 c=0
Rk32 (\10\:CKb \11\:CKb) resistor r=0.7047 c=0
Rk33 (\11\:CKb \12\:CKb) resistor r=1.2182 c=0
Rk34 (\12\:CKb \14\:CKb) resistor r=2.0634 c=0
Rk35 (\14\:CKb \16\:CKb) resistor r=0.6752 c=0
Rk6 (\19\:qbint \20\:qbint) resistor r=0.3218 c=0
Rk8 (\20\:qbint \24\:qbint) resistor r=0.3459 c=0
Rk10 (\20\:qbint \27\:qbint) resistor r=0.3813 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.3531 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.7375 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.4576 c=0
Rk18 (\4\:mout \6\:mout) resistor r=0.8868 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.3841 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.3139 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.2854 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.5948 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.1614 c=0
Rk28 (\11\:CKbb \15\:CKbb) resistor r=0.2688 c=0
Rk29 (\15\:CKbb \17\:CKbb) resistor r=0.2917 c=0
Rk30 (\12\:CKbb \18\:CKbb) resistor r=0.457 c=0
Rk31 (\13\:CKbb \19\:CKbb) resistor r=0.1053 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5272 c=0
Rk22 (\7\:n20 \8\:n20) resistor r=0.6739 c=0
Rk23 (\7\:n20 \10\:n20) resistor r=0.05443 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.6307 c=0
Rk38 (\3\:Db \4\:Db) resistor r=0.3363 c=0
Rk39 (\4\:Db \6\:Db) resistor r=0.6008 c=0
Rk40 (\3\:Db \8\:Db) resistor r=0.07452 c=0
Rk41 (\4\:Db \10\:Db) resistor r=0.5425 c=0
Rk45 (\6\:SEb \8\:SEb) resistor r=0.5319 c=0
Rk46 (\8\:SEb \9\:SEb) resistor r=0.631 c=0
Rk47 (\9\:SEb \10\:SEb) resistor r=0.3029 c=0
Rk20 (\2\:net349 \4\:net349) resistor r=0.2505 c=0
Rl46 (\1\:D \2\:D) resistor r=98.3343 c=0
Rl47 (\2\:D \3\:D) resistor r=44.9225 c=0
Rl26 (RN \7\:RN) resistor r=34.3295 c=0
Rl17 (RN \1\:RN) resistor r=24.7951 c=0
Rl36 (\9\:RN \8\:RN) resistor r=29.5379 c=0
Rl37 (\9\:RN \10\:RN) resistor r=77.6149 c=0
Rl54 (\4\:SE \5\:SE) resistor r=100.692 c=0
Rl55 (\5\:SE \6\:SE) resistor r=33.3841 c=0
Rl50 (\2\:SE \3\:SE) resistor r=133.735 c=0
Rl49 (\1\:SE \2\:SE) resistor r=24.2328 c=0
Rl52 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl53 (\2\:SI \3\:SI) resistor r=106.925 c=0
Rl2 (\2\:CK \3\:CK) resistor r=76.7181 c=0
Rl1 (\1\:CK \2\:CK) resistor r=111.516 c=0
Rl45 (\7\:CKb \9\:CKb) resistor r=205.769 c=0
Rl42 (\4\:CKb \6\:CKb) resistor r=134.615 c=0
Rl30 (CKb \2\:CKb) resistor r=133.771 c=0
Rl44 (\7\:CKb \8\:CKb) resistor r=37.2302 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=61.0515 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=30.0021 c=0
Rl27 (\17\:qbint \16\:qbint) resistor r=24.2328 c=0
Rl28 (\17\:qbint \18\:qbint) resistor r=80.0021 c=0
Rl22 (n30 \5\:n30) resistor r=64.5595 c=0
Rl21 (n30 \4\:n30) resistor r=64.6181 c=0
Rl38 (mout \2\:mout) resistor r=24.2328 c=0
Rl39 (\2\:mout \3\:mout) resistor r=80.0021 c=0
Rl43 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl40 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl32 (\3\:CKbb \4\:CKbb) resistor r=37.6944 c=0
Rl29 (CKbb \2\:CKbb) resistor r=30.3481 c=0
Rl35 (\2\:n20 \4\:n20) resistor r=90.0987 c=0
Rl34 (\2\:n20 \3\:n20) resistor r=34.3295 c=0
Rl33 (n20 \2\:n20) resistor r=2.7713 c=0
Rl51 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl48 (SEb \2\:SEb) resistor r=54.5379 c=0
Rz12 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz13 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz14 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz8 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz9 (\5\:Db \6\:Db) resistor r=75 c=0
Rz10 (\9\:Db \10\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry11 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry10 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=20.6667 c=0
Ry13 (\7\:Db \8\:Db) resistor r=62 c=0
Ry14 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry7 (net349 \2\:net349) resistor r=62 c=0
Ry8 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx17 (\2\:D \4\:D) resistor r=45 c=0
Rx5 (\11\:RN \9\:RN) resistor r=45 c=0
Rx19 (\5\:SE \7\:SE) resistor r=45 c=0
Rx20 (\2\:SE \8\:SE) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\8\:CKb \10\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\3\:CKb \12\:CKb) resistor r=45 c=0
Rx2 (\19\:qbint qbint) resistor r=45 c=0
Rx3 (\27\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \18\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx9 (n20 \8\:n20) resistor r=45 c=0
Rx21 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn20 (\15\:CKb \1\:CK \9\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.96e-14 ad=2.03e-14 ps=1.12e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67379e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\16\:CKbb \9\:CKb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=6.453e-14 ps=9e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.405e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.827e-14 ps=1.28e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (net450 \3\:D \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41154e-07 sb=9.57692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (\9\:Db SEb net450 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.46154e-07 sb=8.52692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn14 (\9\:Db \1\:SE net442 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.51154e-07 sb=6.47692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net442 \3\:SI \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=5.07e-14 ps=1.28e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.91154e-07 sb=4.07692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.528e-14 ad=5.2e-14 ps=9.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32404e-07 sb=1.7451e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn45_1__rcx (21 \1\:RN \9\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.357e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19146e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn46_1__rcx (\23\:qbint \4\:n30 21 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.358e-14 ad=4.1e-14 ps=6.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35146e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn46 (\23\:qbint \5\:n30 22 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=4.1e-14 ps=7.7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59646e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn45 (22 \7\:RN \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=3.69e-14 ps=1.53e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81488e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn50 (net405 \18\:qbint \17\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.93e-14 ad=7.892e-14 ps=1.53e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98598e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn51 (\7\:n30 CKb net405 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.892e-14 ad=3.28e-14 ps=1.18e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.865e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn40 (\7\:n30 \3\:CKbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.38e-14 ad=3.28e-14 ps=1.13e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.66e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn30 (\7\:mout \3\:n20 \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.51e-14 ad=7.38e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.255e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn35 (net426 \10\:RN \15\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=7.79e-14 ps=8.5e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.9e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=3.588e-14 ps=1.17e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.65e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn37 (\9\:n20 \5\:CKbb net422 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=3.28e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn25 (\9\:n20 \6\:CKb \5\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mp11 (net381 \1\:D \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.34e-14 ad=2.34e-14 ps=1.3e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.83013e-07 sb=8.54295e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp12 (Db \3\:SE net381 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.88013e-07 sb=7.49295e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp14 (Db \3\:SEb net373 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.93013e-07 sb=5.44295e-07 sd=160n sca=19.095 \
        scb=0.0163725 scc=0.00171562 m=(1)
mp13 (net373 \1\:SI \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=4.875e-14 ps=1.54e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.63013e-07 sb=3.74295e-07 sd=160n sca=19.5664 \
        scb=0.0165531 scc=0.00171569 m=(1)
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1158e-13 ad=7.215e-14 ps=1.7225e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.12308e-07 sb=1.77333e-06 sd=160n sca=23.2892 \
        scb=0.0184233 scc=0.00227283 m=(4)
mp50 (net326 \16\:qbint \9\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.274e-13 ad=6.665e-14 ps=1.92e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.83e-06 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp51 (\11\:n30 \2\:CKbb net326 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=4.96e-14 ps=1.05e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.57e-06 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp40 (\11\:n30 \2\:CKb \5\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.643e-13 ad=4.96e-14 ps=1.68e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(1)
mp30 (\5\:mout \4\:n20 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.15e-13 ad=1.643e-13 ps=1.84e-06 pd=1.68e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.9e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp35 (\3\:net349 \8\:RN \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.15e-13 ad=1.178e-13 ps=1.84e-06 pd=1.38e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.25e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp36 (\3\:net349 mout \17\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.178e-13 ps=1.74e-06 pd=1.38e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp37 (\5\:n20 \4\:CKb net349 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=1.116e-13 ps=9e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=5.4371e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\5\:n20 \7\:CKbb \7\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=1.116e-13 ps=1.02e-06 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.20484e-07 sb=1.3871e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp45 (\9\:VDD RN \20\:qbint VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.181e-13 ps=9.4e-07 pd=1.795e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23839e-06 sb=2e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(2)
mp46_1__rcx (\20\:qbint n30 \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.15e-13 ad=4.96e-14 ps=1.84e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44339e-06 sb=2e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(2)
ends SDFFRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:41 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX8 CK D Q RN SE SI VDD VSS
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=7.374e-14 ps=1.21e-06 pd=1.22143e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.9209e-06 sd=160n sca=32.089 \
        scb=0.0262252 scc=0.00294457 m=(7)
C1 (D VSS) capacitor c=4.36773e-17
C2 (Q VSS) capacitor c=4.97233e-16
C3 (RN VSS) capacitor c=4.4247e-16
C4 (VDD VSS) capacitor c=3.92067e-16
C5 (SE VSS) capacitor c=3.12021e-17
C6 (SI VSS) capacitor c=9.64978e-17
C7 (CK VSS) capacitor c=7.19697e-17
C8 (qbint VSS) capacitor c=4.03294e-16
C9 (21 VSS) capacitor c=2.98312e-18
C10 (n30 VSS) capacitor c=4.97908e-16
C11 (22 VSS) capacitor c=2.09613e-18
C12 (23 VSS) capacitor c=3.531e-18
C13 (CKb VSS) capacitor c=4.61756e-17
C14 (net405 VSS) capacitor c=2.24031e-18
C15 (mout VSS) capacitor c=4.71584e-17
C16 (CKbb VSS) capacitor c=2.12639e-17
C17 (n20 VSS) capacitor c=4.09041e-17
C18 (net426 VSS) capacitor c=4.90915e-18
C19 (net422 VSS) capacitor c=3.3758e-18
C20 (Db VSS) capacitor c=8.81705e-17
C21 (net450 VSS) capacitor c=8.07784e-18
C22 (SEb VSS) capacitor c=4.58521e-17
C23 (net326 VSS) capacitor c=3.00682e-18
C24 (net349 VSS) capacitor c=7.65193e-17
C25 (net381 VSS) capacitor c=3.36268e-18
C26 (net373 VSS) capacitor c=4.08851e-18
C27 (\7\:SE VSS) capacitor c=4.56586e-17
C28 (\3\:SI VSS) capacitor c=5.67191e-17
C29 (\2\:SE VSS) capacitor c=5.47842e-17
C30 (\1\:D VSS) capacitor c=7.85863e-17
C31 (\8\:CKb VSS) capacitor c=3.78528e-17
C32 (\7\:CKbb VSS) capacitor c=5.1021e-17
C33 (\5\:CKb VSS) capacitor c=4.25566e-17
C34 (\12\:RN VSS) capacitor c=6.94955e-17
C35 (\3\:n20 VSS) capacitor c=4.53714e-17
C36 (\3\:CKb VSS) capacitor c=3.56591e-17
C37 (\3\:CKbb VSS) capacitor c=6.81975e-17
C38 (\28\:qbint VSS) capacitor c=5.17802e-17
C39 (\1\:CK VSS) capacitor c=4.36878e-17
C40 (\5\:SE VSS) capacitor c=3.3226e-17
C41 (\1\:SI VSS) capacitor c=8.60912e-17
C42 (\3\:SE VSS) capacitor c=7.03736e-17
C43 (\3\:SEb VSS) capacitor c=6.08609e-17
C44 (\4\:D VSS) capacitor c=3.43218e-17
C45 (\10\:CKb VSS) capacitor c=4.7833e-17
C46 (\7\:CKb VSS) capacitor c=4.43595e-17
C47 (\4\:CKbb VSS) capacitor c=4.13568e-17
C48 (\3\:mout VSS) capacitor c=4.20499e-17
C49 (\11\:RN VSS) capacitor c=7.17693e-17
C50 (\30\:qbint VSS) capacitor c=6.08039e-17
C51 (\3\:CK VSS) capacitor c=3.67995e-17
C52 (\10\:n30 VSS) capacitor c=3.99652e-17
C53 (\4\:RN VSS) capacitor c=3.55453e-17
C54 (\7\:RN VSS) capacitor c=1.98741e-17
C55 (\6\:n30 VSS) capacitor c=2.33622e-17
C56 (\5\:n30 VSS) capacitor c=3.24358e-17
C57 (\1\:RN VSS) capacitor c=4.96245e-17
C58 (\6\:SE VSS) capacitor c=3.84633e-17
C59 (\2\:SI VSS) capacitor c=5.98069e-17
C60 (\4\:SE VSS) capacitor c=4.54904e-17
C61 (\1\:SE VSS) capacitor c=4.0634e-17
C62 (\3\:D VSS) capacitor c=2.10891e-17
C63 (\9\:CKb VSS) capacitor c=2.49427e-17
C64 (\6\:CKbb VSS) capacitor c=3.3942e-17
C65 (\6\:CKb VSS) capacitor c=2.05505e-17
C66 (\5\:CKbb VSS) capacitor c=3.87167e-17
C67 (\2\:mout VSS) capacitor c=4.33721e-17
C68 (\2\:n20 VSS) capacitor c=3.72525e-17
C69 (\13\:RN VSS) capacitor c=3.48257e-17
C70 (\2\:CKbb VSS) capacitor c=5.8278e-17
C71 (\4\:CKb VSS) capacitor c=3.7717e-17
C72 (\2\:CKb VSS) capacitor c=3.96691e-17
C73 (\29\:qbint VSS) capacitor c=4.20483e-17
C74 (\2\:CK VSS) capacitor c=3.23058e-17
C75 (\9\:RN VSS) capacitor c=1.93488e-17
C76 (\7\:SEb VSS) capacitor c=9.91714e-17
C77 (\14\:VDD VSS) capacitor c=2.95803e-17
C78 (\4\:Db VSS) capacitor c=5.25251e-17
C79 (\16\:VDD VSS) capacitor c=1.16602e-17
C80 (\8\:CKbb VSS) capacitor c=7.14549e-17
C81 (\6\:Db VSS) capacitor c=1.52551e-16
C82 (\4\:n20 VSS) capacitor c=7.00472e-17
C83 (\18\:VDD VSS) capacitor c=2.04699e-17
C84 (\3\:net349 VSS) capacitor c=7.59069e-17
C85 (\20\:VDD VSS) capacitor c=7.13111e-17
C86 (\7\:mout VSS) capacitor c=6.17622e-17
C87 (\11\:n30 VSS) capacitor c=1.02517e-16
C88 (\22\:VDD VSS) capacitor c=2.39328e-17
C89 (\18\:CKb VSS) capacitor c=1.02484e-16
C90 (\33\:qbint VSS) capacitor c=2.41102e-16
C91 (\1\:VDD VSS) capacitor c=1.08069e-16
C92 (\5\:SEb VSS) capacitor c=6.10183e-17
C93 (\14\:CKbb VSS) capacitor c=9.55737e-18
C94 (\8\:Db VSS) capacitor c=1.06404e-16
C95 (\8\:n20 VSS) capacitor c=7.12402e-17
C96 (\4\:mout VSS) capacitor c=4.18506e-17
C97 (\13\:n30 VSS) capacitor c=2.4268e-16
C98 (\15\:CKb VSS) capacitor c=1.31753e-16
C99 (\39\:qbint VSS) capacitor c=7.16567e-17
C100 (\43\:qbint VSS) capacitor c=7.36372e-17
C101 (\2\:D VSS) capacitor c=2.13344e-17
C102 (\2\:SEb VSS) capacitor c=5.49094e-17
C103 (\4\:CK VSS) capacitor c=4.51965e-17
C104 (\31\:qbint VSS) capacitor c=1.38912e-16
C105 (\32\:qbint VSS) capacitor c=1.40202e-16
C106 (\45\:qbint VSS) capacitor c=4.25067e-17
C107 (\16\:RN VSS) capacitor c=1.66011e-16
C108 (\17\:RN VSS) capacitor c=1.59834e-16
C109 (\6\:mout VSS) capacitor c=1.09463e-16
C110 (\9\:mout VSS) capacitor c=1.022e-16
C111 (\6\:n20 VSS) capacitor c=1.12053e-16
C112 (\7\:n20 VSS) capacitor c=1.1437e-16
C113 (\10\:CKbb VSS) capacitor c=4.6592e-17
C114 (\11\:CKbb VSS) capacitor c=9.0122e-17
C115 (\12\:CKbb VSS) capacitor c=2.16509e-16
C116 (\13\:CKbb VSS) capacitor c=1.48812e-16
C117 (\16\:CKbb VSS) capacitor c=4.44908e-17
C118 (\11\:CKb VSS) capacitor c=7.55993e-17
C119 (\12\:CKb VSS) capacitor c=2.14287e-16
C120 (\13\:CKb VSS) capacitor c=2.39954e-16
C121 (\14\:CKb VSS) capacitor c=1.63248e-16
C122 (\17\:CKb VSS) capacitor c=6.84037e-17
C123 (\5\:D VSS) capacitor c=6.51236e-17
C124 (\3\:Db VSS) capacitor c=1.41037e-16
C125 (\8\:SE VSS) capacitor c=7.16275e-17
C126 (\9\:SE VSS) capacitor c=5.97961e-17
C127 (\10\:SE VSS) capacitor c=4.84842e-17
C128 (\4\:SI VSS) capacitor c=4.28177e-17
C129 (\9\:SEb VSS) capacitor c=7.65754e-17
C130 (\3\:VDD VSS) capacitor c=1.4584e-17
C131 (\4\:VDD VSS) capacitor c=2.47288e-17
C132 (\6\:VDD VSS) capacitor c=2.5074e-17
C133 (\7\:VDD VSS) capacitor c=4.86963e-17
C134 (\9\:VDD VSS) capacitor c=5.38265e-16
Rk51 (\5\:D D) resistor r=0.1126 c=0
Rk31 (\16\:RN \17\:RN) resistor r=1.2883 c=0
Rk84 (\2\:VDD \3\:VDD) resistor r=0.1277 c=0
Rk85 (\3\:VDD \4\:VDD) resistor r=0.3925 c=0
Rk86 (\4\:VDD \5\:VDD) resistor r=0.2297 c=0
Rk87 (\5\:VDD \6\:VDD) resistor r=0.3501 c=0
Rk88 (\6\:VDD \7\:VDD) resistor r=0.2771 c=0
Rk89 (\7\:VDD \8\:VDD) resistor r=0.5749 c=0
Rk109 (\9\:VDD VDD) resistor r=0.1651 c=0
Rk90 (\8\:VDD \9\:VDD) resistor r=0.2905 c=0
Rk95 (\3\:VDD \15\:VDD) resistor r=0.2585 c=0
Rk96 (\4\:VDD \17\:VDD) resistor r=0.04333 c=0
Rk97 (\6\:VDD \19\:VDD) resistor r=0.04333 c=0
Rk98 (\7\:VDD \21\:VDD) resistor r=0.3469 c=0
Rk99 (\8\:VDD \23\:VDD) resistor r=0.0715 c=0
Rk57 (\8\:SE \9\:SE) resistor r=0.3402 c=0
Rk59 (\10\:SE SE) resistor r=0.05396 c=0
Rk58 (\9\:SE \10\:SE) resistor r=0.2318 c=0
Rk60 (\4\:SI SI) resistor r=0.06227 c=0
Rk63 (\2\:VSS \3\:VSS) resistor r=0.0851 c=0
Rk64 (\3\:VSS \4\:VSS) resistor r=0.4211 c=0
Rk65 (\4\:VSS \5\:VSS) resistor r=0.2457 c=0
Rk66 (\5\:VSS \6\:VSS) resistor r=0.5693 c=0
Rk67 (\6\:VSS \7\:VSS) resistor r=0.6357 c=0
Rk68 (\3\:VSS \9\:VSS) resistor r=0.292 c=0
Rk69 (\4\:VSS \11\:VSS) resistor r=0.2317 c=0
Rk70 (\6\:VSS \13\:VSS) resistor r=0.18 c=0
Rk71 (\7\:VSS \14\:VSS) resistor r=0.5116 c=0
Rk77 (\15\:VSS VSS) resistor r=0.2078 c=0
Rk72 (\14\:VSS \15\:VSS) resistor r=0.4186 c=0
Rk78 (\7\:VSS \21\:VSS) resistor r=0.0715 c=0
Rk79 (\14\:VSS \23\:VSS) resistor r=0.2841 c=0
Rk17 (\4\:CK CK) resistor r=0.1298 c=0
Rk19 (\32\:qbint \33\:qbint) resistor r=0.1506 c=0
Rk18 (\31\:qbint \32\:qbint) resistor r=0.9963 c=0
Rk23 (\32\:qbint \40\:qbint) resistor r=0.4295 c=0
Rk25 (\33\:qbint \44\:qbint) resistor r=0.3434 c=0
Rk26 (\33\:qbint \45\:qbint) resistor r=0.3623 c=0
Rk28 (\14\:n30 n30) resistor r=1.3505 c=0
Rk27 (\12\:n30 \14\:n30) resistor r=0.4947 c=0
Rk45 (\11\:CKb \12\:CKb) resistor r=0.4769 c=0
Rk46 (\12\:CKb \13\:CKb) resistor r=1.4046 c=0
Rk47 (\13\:CKb \14\:CKb) resistor r=0.6599 c=0
Rk48 (\14\:CKb \16\:CKb) resistor r=0.6379 c=0
Rk49 (\13\:CKb \17\:CKb) resistor r=0.2643 c=0
Rk50 (\16\:CKb \19\:CKb) resistor r=0.5821 c=0
Rk32 (\5\:mout \6\:mout) resistor r=0.1059 c=0
Rk33 (\6\:mout \8\:mout) resistor r=0.3215 c=0
Rk34 (\6\:mout \9\:mout) resistor r=0.5477 c=0
Rk39 (\9\:CKbb \10\:CKbb) resistor r=0.3455 c=0
Rk40 (\10\:CKbb \11\:CKbb) resistor r=0.1402 c=0
Rk41 (\11\:CKbb \12\:CKbb) resistor r=0.7931 c=0
Rk42 (\12\:CKbb \13\:CKbb) resistor r=1.1085 c=0
Rk43 (\10\:CKbb \15\:CKbb) resistor r=0.1152 c=0
Rk44 (\12\:CKbb \16\:CKbb) resistor r=0.1529 c=0
Rk36 (\5\:n20 \6\:n20) resistor r=0.3056 c=0
Rk37 (\6\:n20 \7\:n20) resistor r=0.712 c=0
Rk38 (\6\:n20 \9\:n20) resistor r=0.3051 c=0
Rk52 (\2\:Db \3\:Db) resistor r=0.6178 c=0
Rk53 (\3\:Db \5\:Db) resistor r=0.149 c=0
Rk54 (\3\:Db \7\:Db) resistor r=0.6938 c=0
Rk55 (\7\:Db \9\:Db) resistor r=0.6083 c=0
Rk56 (\5\:Db \10\:Db) resistor r=0.1474 c=0
Rk61 (\6\:SEb \8\:SEb) resistor r=0.6167 c=0
Rk62 (\8\:SEb \9\:SEb) resistor r=0.4689 c=0
Rk35 (\2\:net349 \4\:net349) resistor r=0.2887 c=0
Rl63 (\1\:D \2\:D) resistor r=102.726 c=0
Rl65 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl64 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl53 (\11\:RN \12\:RN) resistor r=182.258 c=0
Rl35 (RN \4\:RN) resistor r=28.0797 c=0
Rl37 (RN \7\:RN) resistor r=24.2328 c=0
Rl27 (RN \1\:RN) resistor r=24.5316 c=0
Rl54 (\13\:RN \12\:RN) resistor r=189.898 c=0
Rl39 (\9\:RN RN) resistor r=24.2328 c=0
Rl74 (\6\:SE \7\:SE) resistor r=95.3297 c=0
Rl73 (\5\:SE \6\:SE) resistor r=40.3846 c=0
Rl70 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl66 (\1\:SE \2\:SE) resistor r=33.8727 c=0
Rl72 (\2\:SI \3\:SI) resistor r=30.0268 c=0
Rl71 (\1\:SI \2\:SI) resistor r=91.6329 c=0
Rl43 (\1\:CK \2\:CK) resistor r=90.3846 c=0
Rl44 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl45 (\29\:qbint \28\:qbint) resistor r=39.1533 c=0
Rl46 (\29\:qbint \30\:qbint) resistor r=89.1533 c=0
Rl42 (n30 \10\:n30) resistor r=26.3736 c=0
Rl33 (n30 \6\:n30) resistor r=28.0797 c=0
Rl32 (n30 \5\:n30) resistor r=28.0797 c=0
Rl62 (\8\:CKb \10\:CKb) resistor r=150 c=0
Rl59 (\5\:CKb \7\:CKb) resistor r=142.308 c=0
Rl61 (\8\:CKb \9\:CKb) resistor r=54.5379 c=0
Rl58 (\5\:CKb \6\:CKb) resistor r=37.2302 c=0
Rl48 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl47 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl55 (mout \2\:mout) resistor r=98.7687 c=0
Rl56 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl60 (\6\:CKbb \7\:CKbb) resistor r=89.6769 c=0
Rl57 (\4\:CKbb \5\:CKbb) resistor r=28.079 c=0
Rl50 (\2\:CKbb \3\:CKbb) resistor r=174.12 c=0
Rl49 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl52 (\2\:n20 \3\:n20) resistor r=35.7065 c=0
Rl51 (n20 \2\:n20) resistor r=84.4104 c=0
Rl67 (SEb \2\:SEb) resistor r=67.4757 c=0
Rl68 (\2\:SEb \3\:SEb) resistor r=138.049 c=0
Rl69 (\2\:SEb \4\:SEb) resistor r=1.2666 c=0
Rz24 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz25 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz26 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz27 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz15 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz16 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz18 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz19 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz5 (\40\:qbint \39\:qbint) resistor r=75 c=0
Rz6 (\44\:qbint \43\:qbint) resistor r=75 c=0
Rz7 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz11 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz10 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz9 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\8\:Db \9\:Db) resistor r=75 c=0
Rz14 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry23 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry24 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry25 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry26 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry27 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry20 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\15\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry8 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry14 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\7\:mout \8\:mout) resistor r=62 c=0
Ry13 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry12 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry15 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (\6\:Db \7\:Db) resistor r=31 c=0
Ry17 (\4\:Db \10\:Db) resistor r=62 c=0
Ry18 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry10 (net349 \2\:net349) resistor r=62 c=0
Ry11 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx19 (\3\:D \5\:D) resistor r=45 c=0
Rx8 (\16\:RN \13\:RN) resistor r=45 c=0
Rx9 (\17\:RN \9\:RN) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\6\:SE \10\:SE) resistor r=45 c=0
Rx23 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx4 (\31\:qbint \29\:qbint) resistor r=45 c=0
Rx5 (\45\:qbint qbint) resistor r=45 c=0
Rx15 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx18 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx10 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx14 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx24 (\4\:SEb \9\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \15\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (21 \1\:RN \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=2.73e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=1.12e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_1__rcx (\43\:qbint \5\:n30 21 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.73e-14 ad=4.94e-14 ps=7.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=9.7e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_2__rcx (\43\:qbint \6\:n30 22 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.42e-14 ad=4.94e-14 ps=8.6e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=7.35e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn45_2__rcx (22 \7\:RN \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.42e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.2e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn45 (23 \4\:RN \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.21e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn46 (\39\:qbint \10\:n30 23 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.03e-14 ps=6.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn11 (net450 \4\:D \10\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=7.28e-14 ps=9.6e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40769e-07 sb=9.32981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.28e-14 ad=4.16e-14 ps=1.08e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65769e-07 sb=6.07981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70769e-07 sb=4.02981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75769e-07 sb=2.97981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn20 (\15\:CKb \3\:CK \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn21 (\14\:CKbb \10\:CKb \10\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=3.407e-14 ps=9.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.29379e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\5\:SEb \5\:SE \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.625e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27793e-06 sb=2.5e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (net405 \30\:qbint \20\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.99e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\13\:n30 CKb net405 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=4.92e-14 ps=6.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.83e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\13\:n30 CKbb \4\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=4.92e-14 ps=1.1e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8378e-07 sb=1.545e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\4\:mout n20 \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.778e-14 ad=7.073e-14 ps=1.15e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27378e-06 sb=1.155e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (net426 \11\:RN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.778e-14 ad=3.178e-14 ps=1.15e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59378e-06 sb=8.35e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=2.358e-14 ps=7.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79378e-06 sb=6.35e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=5.945e-14 ps=6.4e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9078e-06 sb=4.75e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=5.945e-14 ps=6.9e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3195 scb=0.00946099 \
        scc=0.0003152 m=(1)
mp11 (net381 \1\:D \16\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.695e-14 ad=3.9e-14 ps=1.91e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=8.19551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\4\:Db \2\:SE net381 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=7.02e-14 ps=9.8e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.13141e-07 sb=6.74551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\4\:Db SEb net373 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.38141e-07 sb=4.49551e-07 sd=160n sca=17.5238 \
        scb=0.0153466 scc=0.00137894 m=(1)
mp13 (net373 \3\:SI \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.18141e-07 sb=2.69551e-07 sd=160n sca=18.2259 \
        scb=0.0157849 scc=0.00137936 m=(1)
mp45_1__rcx (\9\:VDD RN \33\:qbint VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.37e-14 ad=7.203e-14 ps=1.10667e-06 pd=1.17667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=1.265e-06 sd=160n \
        sca=28.7024 scb=0.0198217 scc=0.00315848 m=(3)
mp46 (\33\:qbint n30 \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.49e-14 ad=6.37e-14 ps=1.37e-06 pd=1.10667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=1.06e-06 sd=160n sca=28.7024 \
        scb=0.0198217 scc=0.00315848 m=(3)
mp20 (\18\:CKb \1\:CK \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.195e-14 ad=3.01e-14 ps=1.98e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.735e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp21 (\8\:CKbb \8\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.695e-14 ad=3.01e-14 ps=1.91e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp10 (\7\:SEb \7\:SE \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.4e-07 sd=160n sca=26.1974 \
        scb=0.0252592 scc=0.00245634 m=(1)
mp50 (net326 \28\:qbint \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.195e-14 ad=4.495e-14 ps=1.98e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.77984e-07 sb=1.525e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp51 (\11\:n30 \3\:CKbb net326 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=7.595e-14 ps=9.1e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.67984e-07 sb=1.335e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp40 (\11\:n30 \3\:CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=7.595e-14 ps=1.23e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.57984e-07 sb=1.045e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp30 (\7\:mout \3\:n20 \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=9.455e-14 ps=9.4e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10798e-06 sb=6.95e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp35 (\3\:net349 \12\:RN \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=8.525e-14 ps=9.4e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.31298e-06 sb=4.9e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp36 (\3\:net349 mout \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=8.525e-14 ps=1.71e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63298e-06 sb=1.7e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
ends SDFFRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:42 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRX1
// View name: extracted

simulator lang=spectre

subckt SDFFRX1 CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:qint \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.49744e-07 sd=160n sca=35.1619 \
        scb=0.02637 scc=0.00345369 m=(1)
mp55 (\1\:Q qbint \24\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=5.46e-14 ps=1.2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.02628e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
C1 (RN VSS) capacitor c=8.7932e-17
C2 (QN VSS) capacitor c=2.14017e-17
C3 (SE VSS) capacitor c=4.24894e-17
C4 (SI VSS) capacitor c=7.82079e-17
C5 (VDD VSS) capacitor c=3.82149e-16
C6 (CK VSS) capacitor c=6.8427e-17
C7 (D VSS) capacitor c=5.71422e-17
C8 (qint VSS) capacitor c=2.13771e-17
C9 (qbint VSS) capacitor c=4.04991e-17
C10 (CKb VSS) capacitor c=4.52719e-17
C11 (n9 VSS) capacitor c=2.50111e-18
C12 (n30 VSS) capacitor c=2.09631e-17
C13 (n11 VSS) capacitor c=4.35612e-18
C14 (mout VSS) capacitor c=5.76693e-17
C15 (Ckbb VSS) capacitor c=2.27596e-17
C16 (n20 VSS) capacitor c=3.91598e-17
C17 (n7 VSS) capacitor c=7.275e-19
C18 (Db VSS) capacitor c=1.01741e-16
C19 (n1 VSS) capacitor c=8.34339e-18
C20 (SEb VSS) capacitor c=3.76651e-17
C21 (n8 VSS) capacitor c=3.12581e-18
C22 (n6 VSS) capacitor c=6.32439e-17
C23 (n2 VSS) capacitor c=7.58328e-18
C24 (\5\:SE VSS) capacitor c=3.55088e-17
C25 (\1\:SI VSS) capacitor c=4.19887e-17
C26 (\1\:SE VSS) capacitor c=3.96346e-17
C27 (\1\:D VSS) capacitor c=6.14583e-17
C28 (\9\:CKb VSS) capacitor c=5.54127e-17
C29 (\7\:Ckbb VSS) capacitor c=4.6094e-17
C30 (\6\:CKb VSS) capacitor c=4.99369e-17
C31 (\6\:RN VSS) capacitor c=6.76711e-17
C32 (\3\:n20 VSS) capacitor c=4.44199e-17
C33 (\3\:CKb VSS) capacitor c=3.64461e-17
C34 (\3\:Ckbb VSS) capacitor c=6.68967e-17
C35 (\8\:qbint VSS) capacitor c=5.52638e-17
C36 (\3\:RN VSS) capacitor c=3.90527e-17
C37 (\3\:n30 VSS) capacitor c=5.01678e-17
C38 (\1\:CK VSS) capacitor c=3.12235e-17
C39 (\7\:qbint VSS) capacitor c=3.10212e-17
C40 (\4\:qint VSS) capacitor c=4.47874e-17
C41 (\7\:SE VSS) capacitor c=1.98052e-17
C42 (\3\:SI VSS) capacitor c=5.63681e-17
C43 (\3\:SE VSS) capacitor c=6.7387e-17
C44 (\3\:SEb VSS) capacitor c=5.9398e-17
C45 (\3\:D VSS) capacitor c=2.70336e-17
C46 (\8\:CKb VSS) capacitor c=5.64822e-17
C47 (\5\:CKb VSS) capacitor c=4.81988e-17
C48 (\4\:Ckbb VSS) capacitor c=7.34209e-17
C49 (\3\:mout VSS) capacitor c=5.78248e-17
C50 (\5\:RN VSS) capacitor c=8.99042e-17
C51 (\10\:qbint VSS) capacitor c=3.91271e-17
C52 (\1\:RN VSS) capacitor c=5.13212e-17
C53 (\2\:n30 VSS) capacitor c=4.65525e-17
C54 (\3\:CK VSS) capacitor c=3.43976e-17
C55 (\5\:qbint VSS) capacitor c=3.02208e-17
C56 (\4\:qbint VSS) capacitor c=3.14393e-17
C57 (\3\:qint VSS) capacitor c=3.66959e-17
C58 (\6\:SE VSS) capacitor c=2.63734e-17
C59 (\2\:SI VSS) capacitor c=5.40428e-17
C60 (\4\:SE VSS) capacitor c=6.03027e-17
C61 (\2\:SEb VSS) capacitor c=7.28919e-17
C62 (\2\:SE VSS) capacitor c=4.35397e-17
C63 (\2\:D VSS) capacitor c=3.86703e-17
C64 (\10\:CKb VSS) capacitor c=2.3022e-17
C65 (\6\:Ckbb VSS) capacitor c=3.194e-17
C66 (\7\:CKb VSS) capacitor c=2.02439e-17
C67 (\5\:Ckbb VSS) capacitor c=3.37815e-17
C68 (\2\:mout VSS) capacitor c=6.09843e-17
C69 (\7\:RN VSS) capacitor c=2.82343e-17
C70 (\2\:n20 VSS) capacitor c=4.5627e-17
C71 (\4\:CKb VSS) capacitor c=3.1916e-17
C72 (\2\:Ckbb VSS) capacitor c=5.26665e-17
C73 (\2\:CKb VSS) capacitor c=5.54134e-17
C74 (\9\:qbint VSS) capacitor c=4.869e-17
C75 (\2\:RN VSS) capacitor c=4.27332e-17
C76 (\4\:RN VSS) capacitor c=2.59851e-17
C77 (\2\:CK VSS) capacitor c=2.90765e-17
C78 (\4\:SEb VSS) capacitor c=7.28406e-18
C79 (\1\:VDD VSS) capacitor c=3.33844e-17
C80 (\8\:Db VSS) capacitor c=3.05518e-17
C81 (\14\:VDD VSS) capacitor c=7.45943e-18
C82 (\13\:Ckbb VSS) capacitor c=7.65835e-17
C83 (\4\:Db VSS) capacitor c=1.57893e-16
C84 (\7\:n20 VSS) capacitor c=5.2632e-17
C85 (\16\:VDD VSS) capacitor c=4.06071e-17
C86 (\3\:n6 VSS) capacitor c=6.77072e-17
C87 (\18\:VDD VSS) capacitor c=2.57615e-17
C88 (\8\:mout VSS) capacitor c=6.04974e-17
C89 (\7\:n30 VSS) capacitor c=8.44612e-17
C90 (\20\:VDD VSS) capacitor c=2.56005e-17
C91 (\11\:qbint VSS) capacitor c=9.77771e-17
C92 (\22\:VDD VSS) capacitor c=1.02615e-17
C93 (\15\:CKb VSS) capacitor c=1.33131e-16
C94 (\24\:VDD VSS) capacitor c=4.3568e-17
C95 (\1\:Q VSS) capacitor c=7.33879e-17
C96 (\5\:qint VSS) capacitor c=2.45112e-17
C97 (\26\:VDD VSS) capacitor c=1.85875e-17
C98 (\1\:QN VSS) capacitor c=3.52654e-17
C99 (\3\:VDD VSS) capacitor c=5.80316e-17
C100 (\8\:SEb VSS) capacitor c=5.7483e-17
C101 (\9\:Ckbb VSS) capacitor c=1.14983e-16
C102 (\6\:Db VSS) capacitor c=7.64813e-17
C103 (\4\:n20 VSS) capacitor c=5.11719e-17
C104 (\6\:mout VSS) capacitor c=3.12386e-17
C105 (\4\:n30 VSS) capacitor c=1.22854e-16
C106 (\14\:qbint VSS) capacitor c=7.42396e-17
C107 (\19\:CKb VSS) capacitor c=6.36781e-17
C108 (\3\:Q VSS) capacitor c=7.46376e-17
C109 (\9\:qint VSS) capacitor c=2.36187e-17
C110 (\3\:QN VSS) capacitor c=2.63059e-17
C111 (\2\:qint VSS) capacitor c=7.32123e-18
C112 (\2\:qbint VSS) capacitor c=3.87893e-17
C113 (\3\:qbint VSS) capacitor c=3.05606e-17
C114 (\7\:qint VSS) capacitor c=2.71099e-17
C115 (\8\:qint VSS) capacitor c=1.98745e-17
C116 (\4\:CK VSS) capacitor c=4.1319e-17
C117 (\8\:RN VSS) capacitor c=4.02292e-17
C118 (\13\:qbint VSS) capacitor c=1.11882e-16
C119 (\16\:qbint VSS) capacitor c=8.54339e-17
C120 (\17\:qbint VSS) capacitor c=1.11139e-16
C121 (\6\:n30 VSS) capacitor c=9.69982e-17
C122 (\9\:RN VSS) capacitor c=1.68008e-16
C123 (\10\:RN VSS) capacitor c=1.65826e-16
C124 (\4\:mout VSS) capacitor c=6.49029e-17
C125 (\5\:mout VSS) capacitor c=7.40697e-17
C126 (\6\:n20 VSS) capacitor c=1.09794e-16
C127 (\9\:n20 VSS) capacitor c=8.59357e-17
C128 (\8\:Ckbb VSS) capacitor c=3.41045e-17
C129 (\11\:Ckbb VSS) capacitor c=1.8757e-16
C130 (\12\:Ckbb VSS) capacitor c=1.29738e-16
C131 (\11\:CKb VSS) capacitor c=7.98327e-17
C132 (\12\:CKb VSS) capacitor c=1.64649e-16
C133 (\13\:CKb VSS) capacitor c=1.2796e-16
C134 (\14\:CKb VSS) capacitor c=1.58451e-16
C135 (\17\:CKb VSS) capacitor c=6.84331e-17
C136 (\18\:CKb VSS) capacitor c=7.01807e-17
C137 (\4\:D VSS) capacitor c=4.83274e-17
C138 (\3\:Db VSS) capacitor c=1.52558e-16
C139 (\4\:SI VSS) capacitor c=4.64261e-17
C140 (\8\:SE VSS) capacitor c=7.85651e-17
C141 (\9\:SE VSS) capacitor c=1.02287e-16
C142 (\10\:SE VSS) capacitor c=4.23401e-17
C143 (\6\:SEb VSS) capacitor c=7.92635e-17
C144 (\7\:SEb VSS) capacitor c=9.48785e-17
C145 (\5\:VDD VSS) capacitor c=3.94931e-17
C146 (\6\:VDD VSS) capacitor c=2.45265e-17
C147 (\8\:VDD VSS) capacitor c=3.54967e-17
C148 (\9\:VDD VSS) capacitor c=3.95558e-17
C149 (\10\:VDD VSS) capacitor c=1.58492e-17
C150 (\12\:VDD VSS) capacitor c=1.01303e-17
C151 (\13\:VDD VSS) capacitor c=1.16239e-17
Rk9 (\8\:RN RN) resistor r=0.1221 c=0
Rk16 (\9\:RN \10\:RN) resistor r=1.0603 c=0
Rk2 (\4\:QN QN) resistor r=0.07593 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3057 c=0
Rk41 (SE \8\:SE) resistor r=0.09091 c=0
Rk42 (\8\:SE \9\:SE) resistor r=0.5972 c=0
Rk43 (\9\:SE \10\:SE) resistor r=0.1875 c=0
Rk6 (\2\:Q Q) resistor r=0.3602 c=0
Rk7 (Q \4\:Q) resistor r=0.04708 c=0
Rk40 (SI \4\:SI) resistor r=0.04461 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.4042 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.3885 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.5638 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.04995 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.1694 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.5393 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.1993 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.2907 c=0
Rk55 (\11\:VDD \12\:VDD) resistor r=0.04243 c=0
Rk57 (\13\:VDD VDD) resistor r=0.1976 c=0
Rk56 (\12\:VDD \13\:VDD) resistor r=0.3105 c=0
Rk58 (\5\:VDD \15\:VDD) resistor r=0.07381 c=0
Rk59 (\6\:VDD \17\:VDD) resistor r=0.1759 c=0
Rk60 (\8\:VDD \19\:VDD) resistor r=0.0433 c=0
Rk61 (\9\:VDD \21\:VDD) resistor r=0.0433 c=0
Rk62 (\10\:VDD \23\:VDD) resistor r=0.07381 c=0
Rk63 (\12\:VDD \25\:VDD) resistor r=0.2785 c=0
Rk64 (\13\:VDD \27\:VDD) resistor r=0.224 c=0
Rk8 (\4\:CK CK) resistor r=0.1844 c=0
Rk35 (\4\:D D) resistor r=0.1361 c=0
Rk65 (\2\:VSS \3\:VSS) resistor r=0.2039 c=0
Rk66 (\3\:VSS \5\:VSS) resistor r=0.4236 c=0
Rk67 (\3\:VSS \6\:VSS) resistor r=0.579 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.1051 c=0
Rk69 (\7\:VSS \8\:VSS) resistor r=0.6064 c=0
Rk70 (\8\:VSS \9\:VSS) resistor r=0.4913 c=0
Rk71 (\9\:VSS \10\:VSS) resistor r=0.065 c=0
Rk73 (\11\:VSS VSS) resistor r=0.1976 c=0
Rk72 (\10\:VSS \11\:VSS) resistor r=0.288 c=0
Rk74 (\5\:VSS \13\:VSS) resistor r=0.2757 c=0
Rk75 (\7\:VSS \15\:VSS) resistor r=0.1225 c=0
Rk76 (\8\:VSS \17\:VSS) resistor r=0.1506 c=0
Rk77 (\10\:VSS \19\:VSS) resistor r=0.2864 c=0
Rk78 (\11\:VSS \21\:VSS) resistor r=0.07381 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1177 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1193 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1057 c=0
Rk10 (\12\:qbint \13\:qbint) resistor r=0.5616 c=0
Rk11 (\13\:qbint \15\:qbint) resistor r=0.1131 c=0
Rk12 (\13\:qbint \16\:qbint) resistor r=0.4471 c=0
Rk13 (\15\:qbint \17\:qbint) resistor r=0.677 c=0
Rk28 (\11\:CKb \12\:CKb) resistor r=0.5573 c=0
Rk29 (\12\:CKb \13\:CKb) resistor r=0.8047 c=0
Rk30 (\13\:CKb \14\:CKb) resistor r=0.2989 c=0
Rk31 (\14\:CKb \16\:CKb) resistor r=0.9156 c=0
Rk32 (\13\:CKb \17\:CKb) resistor r=0.2834 c=0
Rk33 (\14\:CKb \18\:CKb) resistor r=0.3719 c=0
Rk34 (\16\:CKb \20\:CKb) resistor r=0.3553 c=0
Rk14 (\5\:n30 \6\:n30) resistor r=0.6434 c=0
Rk15 (\5\:n30 \8\:n30) resistor r=0.4521 c=0
Rk17 (\4\:mout \5\:mout) resistor r=0.4543 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.1108 c=0
Rk19 (\5\:mout \9\:mout) resistor r=0.2121 c=0
Rk24 (\8\:Ckbb \10\:Ckbb) resistor r=0.2636 c=0
Rk25 (\10\:Ckbb \11\:Ckbb) resistor r=0.5614 c=0
Rk26 (\11\:Ckbb \12\:Ckbb) resistor r=1.129 c=0
Rk27 (\10\:Ckbb \14\:Ckbb) resistor r=0.5596 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.2469 c=0
Rk22 (\6\:n20 \8\:n20) resistor r=0.2957 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.5202 c=0
Rk36 (\2\:Db \3\:Db) resistor r=0.7641 c=0
Rk37 (\3\:Db \5\:Db) resistor r=0.7638 c=0
Rk38 (\5\:Db \7\:Db) resistor r=0.4683 c=0
Rk39 (\3\:Db \9\:Db) resistor r=0.178 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.04786 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.5956 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.4871 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.219 c=0
Rl25 (\5\:RN \6\:RN) resistor r=188.027 c=0
Rl26 (\6\:RN \7\:RN) resistor r=87.2302 c=0
Rl15 (\2\:RN \3\:RN) resistor r=51.1559 c=0
Rl14 (\1\:RN \2\:RN) resistor r=87.6944 c=0
Rl16 (\3\:RN \4\:RN) resistor r=87.2302 c=0
Rl43 (\5\:SE \6\:SE) resistor r=158.384 c=0
Rl44 (\6\:SE \7\:SE) resistor r=29.5379 c=0
Rl40 (\3\:SE \4\:SE) resistor r=81.461 c=0
Rl37 (\1\:SE \2\:SE) resistor r=79.5379 c=0
Rl41 (\1\:SI \2\:SI) resistor r=98.7687 c=0
Rl42 (\2\:SI \3\:SI) resistor r=89.1533 c=0
Rl10 (\1\:CK \2\:CK) resistor r=37.2302 c=0
Rl11 (\2\:CK \3\:CK) resistor r=44.9225 c=0
Rl35 (\1\:D \2\:D) resistor r=160.618 c=0
Rl36 (\2\:D \3\:D) resistor r=26.1559 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=102.615 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=39.1533 c=0
Rl4 (qbint \2\:qbint) resistor r=68.2462 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=37.477 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.6723 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=41.5412 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=47.3105 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=145.337 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=211.022 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=150.368 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=50.6918 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=47.2519 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl19 (CKb \2\:CKb) resistor r=64.6174 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=170.72 c=0
Rl12 (n30 \2\:n30) resistor r=26.1559 c=0
Rl27 (mout \2\:mout) resistor r=114.617 c=0
Rl28 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl32 (\6\:Ckbb \7\:Ckbb) resistor r=118.744 c=0
Rl29 (\4\:Ckbb \5\:Ckbb) resistor r=26.1559 c=0
Rl21 (\2\:Ckbb \3\:Ckbb) resistor r=164.504 c=0
Rl20 (Ckbb \2\:Ckbb) resistor r=24.2328 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=53.4003 c=0
Rl23 (n20 \2\:n20) resistor r=97.3098 c=0
Rl38 (SEb \2\:SEb) resistor r=26.9231 c=0
Rl39 (\2\:SEb \3\:SEb) resistor r=167.606 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz14 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz15 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz17 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz9 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz7 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry21 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry22 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry23 (\4\:VSS \5\:VSS) resistor r=7.75 c=0
Ry24 (\4\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry25 (\4\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry11 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry9 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx3 (\2\:RN \8\:RN) resistor r=45 c=0
Rx7 (\7\:RN \9\:RN) resistor r=45 c=0
Rx8 (\4\:RN \10\:RN) resistor r=45 c=0
Rx20 (\6\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\2\:SE \10\:SE) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx4 (\9\:qbint \16\:qbint) resistor r=45 c=0
Rx5 (\6\:qbint \17\:qbint) resistor r=45 c=0
Rx14 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx6 (n30 \6\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\6\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx12 (\5\:Ckbb \11\:Ckbb) resistor r=45 c=0
Rx13 (\2\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx10 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q \5\:qbint \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.51923e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\19\:CKb \3\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.625e-14 ps=9.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=2.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn46 (\14\:qbint \2\:n30 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.523e-14 ad=3.698e-14 ps=5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=2e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn45 (n9 \1\:RN \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.523e-14 ps=1.05e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn50 (n11 \10\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.957e-14 ps=1.05e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.81e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn51 (\4\:n30 CKb n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.9e-14 ps=5.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.63e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn40 (\6\:mout Ckbb \4\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=5.728e-14 ps=6.9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=1.385e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn30 (\6\:mout n20 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=5.728e-14 ps=1.22e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=9.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn35 (n7 \5\:RN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-06 sb=6.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=1.958e-14 ps=4.1e-07 pd=5.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.955e-06 sb=5.25e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn37 (\4\:n20 \4\:Ckbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn25 (\6\:Db \5\:CKb \4\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn21 (\9\:Ckbb \8\:CKb \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.64e-14 ps=6.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=1.635e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn11 (n1 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.148e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.43e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.03e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.13e-06 sb=8.25e-07 sd=160n sca=7.37439 scb=0.00450456 \
        scc=4.82709e-05 m=(1)
mn13 (n3 \3\:SI \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=8.7e-15 ps=1.19e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=7.2e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn10 (\8\:SEb \7\:SE \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=3.263e-14 ps=1.19e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.25e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp56 (\5\:qint \7\:qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.1852 \
        scb=0.0292558 scc=0.00588561 m=(1)
mp20 (\15\:CKb \1\:CK \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=3.87e-14 ps=1.2e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.8e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp46 (\11\:qbint \3\:n30 \22\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.39e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.855e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp45 (\11\:qbint \3\:RN \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.65e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n8 \8\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.978e-14 ps=1.83e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.385e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp51 (\7\:n30 \3\:Ckbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=5.483e-14 ps=8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.155e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n30 \3\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=5.483e-14 ps=9.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=8.55e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\8\:mout \3\:n20 \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=5.16e-14 ps=1.83e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=5.7e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (\3\:n6 \6\:RN \18\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=3.05e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\3\:n6 mout \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.59e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp37 (\7\:n20 \6\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\7\:n20 \7\:Ckbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\13\:Ckbb \9\:CKb \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.91e-14 ad=3.01e-14 ps=1.81e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp11 (n2 \1\:D \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=5.697e-14 ps=1.81e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.315e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.44e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.005e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=2.58e-14 \
        ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.8e-07 sb=8e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp13 (n4 \1\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=2.58e-14 ps=1.33e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=6.35e-07 sd=160n sca=21.4774 \
        scb=0.0204117 scc=0.00208844 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=26.5704 \
        scb=0.0277882 scc=0.00223218 m=(1)
ends SDFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:43 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRX2
// View name: extracted

simulator lang=spectre

subckt SDFFRX2 CK D Q QN RN SE SI VDD VSS
mp56 (\11\:qint \3\:qbint \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.305e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45721e-06 sd=160n sca=57.0065 \
        scb=0.0445545 scc=0.00681945 m=(1)
mp20 (\17\:CKb \3\:CK \20\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.572e-14 ad=4.67e-14 ps=1.56e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2.17209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (n8 \12\:qbint \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.303e-14 ad=4.3e-14 ps=1.81e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.435e-06 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp51 (\4\:n30 Ckbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.482e-14 ps=8.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.19e-06 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=5.483e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=8.9e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp30 (\4\:mout \4\:n20 \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.29e-14 ad=5.913e-14 ps=1.76e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=5.7e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp35 (\3\:n6 \5\:RN \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.75e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp36 (\3\:n6 mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.075e-14 ad=3.44e-14 ps=1.34e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.7e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp37 (\8\:n20 \6\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp25 (\8\:n20 \7\:Ckbb \5\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp21 (\14\:Ckbb \8\:CKb \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.042e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp13 (n4 \1\:SI \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.042e-14 ad=1.29e-14 ps=1.92e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=9.9e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp14 (\3\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=5.698e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=8.85e-07 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp12 (\3\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=5.698e-14 ps=7.8e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.75e-07 sd=160n sca=35.7281 \
        scb=0.0264923 scc=0.00456533 m=(1)
mp11 (n2 \1\:D \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.763e-14 ps=1.9e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=3.55e-07 sd=160n sca=36.9533 \
        scb=0.0276367 scc=0.0045683 m=(1)
mp10 (\5\:SEb \6\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=40.6333 \
        scb=0.0337853 scc=0.00470903 m=(1)
C1 (RN VSS) capacitor c=1.54732e-16
C2 (QN VSS) capacitor c=4.95e-17
C3 (D VSS) capacitor c=5.67399e-17
C4 (Q VSS) capacitor c=4.41528e-17
C5 (VDD VSS) capacitor c=3.53572e-16
C6 (CK VSS) capacitor c=1.1017e-16
C7 (SI VSS) capacitor c=8.05007e-17
C8 (qbint VSS) capacitor c=3.20039e-17
C9 (qint VSS) capacitor c=1.65439e-16
C10 (CKb VSS) capacitor c=5.73565e-17
C11 (n30 VSS) capacitor c=5.17651e-17
C12 (mout VSS) capacitor c=4.77573e-17
C13 (Ckbb VSS) capacitor c=7.9265e-17
C14 (n20 VSS) capacitor c=2.57669e-17
C15 (n5 VSS) capacitor c=2.08302e-19
C16 (Db VSS) capacitor c=1.07702e-16
C17 (n3 VSS) capacitor c=2.93728e-18
C18 (SEb VSS) capacitor c=6.51553e-17
C19 (n8 VSS) capacitor c=3.9157e-18
C20 (n6 VSS) capacitor c=8.54235e-17
C21 (n4 VSS) capacitor c=1.17072e-18
C22 (n2 VSS) capacitor c=5.77736e-18
C23 (\6\:SE VSS) capacitor c=4.0133e-17
C24 (\1\:D VSS) capacitor c=3.58651e-17
C25 (\1\:SE VSS) capacitor c=3.06742e-17
C26 (\1\:SI VSS) capacitor c=7.62428e-17
C27 (\8\:CKb VSS) capacitor c=4.39624e-17
C28 (\7\:Ckbb VSS) capacitor c=5.05322e-17
C29 (\6\:CKb VSS) capacitor c=3.98066e-17
C30 (\5\:RN VSS) capacitor c=6.79302e-17
C31 (\4\:n20 VSS) capacitor c=4.43633e-17
C32 (\3\:CKb VSS) capacitor c=3.65943e-17
C33 (\12\:qbint VSS) capacitor c=4.33275e-17
C34 (\1\:RN VSS) capacitor c=4.64919e-17
C35 (\3\:n30 VSS) capacitor c=3.86229e-17
C36 (\3\:CK VSS) capacitor c=4.17518e-17
C37 (\4\:qbint VSS) capacitor c=4.56851e-16
C38 (\3\:qbint VSS) capacitor c=1.8311e-17
C39 (\4\:SE VSS) capacitor c=2.79368e-17
C40 (\3\:D VSS) capacitor c=6.78313e-17
C41 (\3\:SEb VSS) capacitor c=7.58337e-17
C42 (\3\:SE VSS) capacitor c=5.02815e-17
C43 (\3\:SI VSS) capacitor c=2.81345e-17
C44 (\10\:CKb VSS) capacitor c=5.24808e-17
C45 (\5\:CKb VSS) capacitor c=4.55779e-17
C46 (\4\:Ckbb VSS) capacitor c=5.81278e-17
C47 (\3\:mout VSS) capacitor c=4.72287e-17
C48 (\4\:RN VSS) capacitor c=8.68045e-17
C49 (\3\:n20 VSS) capacitor c=4.1549e-17
C50 (\2\:Ckbb VSS) capacitor c=4.61938e-17
C51 (\13\:qbint VSS) capacitor c=7.86107e-17
C52 (\3\:RN VSS) capacitor c=6.69554e-17
C53 (\1\:CK VSS) capacitor c=2.42917e-17
C54 (\5\:SE VSS) capacitor c=3.48063e-17
C55 (\2\:D VSS) capacitor c=4.79009e-17
C56 (\4\:SEb VSS) capacitor c=3.24254e-17
C57 (\2\:SE VSS) capacitor c=4.02778e-17
C58 (\2\:SEb VSS) capacitor c=3.63486e-17
C59 (\2\:SI VSS) capacitor c=4.60945e-17
C60 (\9\:CKb VSS) capacitor c=2.32286e-17
C61 (\6\:Ckbb VSS) capacitor c=3.57689e-17
C62 (\7\:CKb VSS) capacitor c=1.94546e-17
C63 (\5\:Ckbb VSS) capacitor c=2.43371e-17
C64 (\2\:mout VSS) capacitor c=4.42658e-17
C65 (\6\:RN VSS) capacitor c=2.90731e-17
C66 (\3\:Ckbb VSS) capacitor c=1.97342e-17
C67 (\4\:CKb VSS) capacitor c=4.38315e-17
C68 (\2\:CKb VSS) capacitor c=2.4687e-17
C69 (\14\:qbint VSS) capacitor c=2.48061e-17
C70 (\2\:RN VSS) capacitor c=5.07775e-17
C71 (\2\:n30 VSS) capacitor c=3.63112e-17
C72 (\2\:CK VSS) capacitor c=2.87764e-17
C73 (\2\:qbint VSS) capacitor c=3.22956e-17
C74 (\5\:SEb VSS) capacitor c=4.74892e-17
C75 (\1\:VDD VSS) capacitor c=1.96932e-17
C76 (\3\:Db VSS) capacitor c=1.25718e-16
C77 (\8\:VDD VSS) capacitor c=1.07438e-17
C78 (\14\:Ckbb VSS) capacitor c=5.65337e-17
C79 (\5\:Db VSS) capacitor c=1.62075e-16
C80 (\8\:n20 VSS) capacitor c=5.64975e-17
C81 (\10\:VDD VSS) capacitor c=3.63875e-17
C82 (\3\:n6 VSS) capacitor c=8.55685e-17
C83 (\12\:VDD VSS) capacitor c=2.36571e-17
C84 (\4\:mout VSS) capacitor c=4.96943e-17
C85 (\4\:n30 VSS) capacitor c=7.47582e-17
C86 (\15\:VDD VSS) capacitor c=1.06411e-17
C87 (\21\:qbint VSS) capacitor c=5.58274e-17
C88 (\18\:VDD VSS) capacitor c=3.11369e-17
C89 (\17\:CKb VSS) capacitor c=6.18117e-17
C90 (\3\:Q VSS) capacitor c=6.57105e-17
C91 (\3\:QN VSS) capacitor c=5.60056e-17
C92 (\11\:qint VSS) capacitor c=4.11335e-17
C93 (\3\:VDD VSS) capacitor c=6.75779e-17
C94 (\7\:SEb VSS) capacitor c=8.31076e-17
C95 (\8\:Ckbb VSS) capacitor c=2.12363e-17
C96 (\7\:Db VSS) capacitor c=6.85489e-17
C97 (\5\:n20 VSS) capacitor c=4.12944e-17
C98 (\7\:mout VSS) capacitor c=2.72524e-17
C99 (\8\:n30 VSS) capacitor c=3.17713e-17
C100 (\15\:qbint VSS) capacitor c=6.87022e-17
C101 (\15\:CKb VSS) capacitor c=1.20984e-16
C102 (\1\:Q VSS) capacitor c=1.57682e-17
C103 (\1\:QN VSS) capacitor c=1.84319e-17
C104 (\9\:qint VSS) capacitor c=4.9684e-17
C105 (\2\:n20 VSS) capacitor c=1.95403e-17
C106 (\8\:qint VSS) capacitor c=6.43432e-17
C107 (\17\:qbint VSS) capacitor c=7.93395e-17
C108 (\20\:qbint VSS) capacitor c=1.0094e-16
C109 (\23\:qbint VSS) capacitor c=6.16674e-17
C110 (\6\:n30 VSS) capacitor c=5.07184e-17
C111 (\7\:n30 VSS) capacitor c=8.31714e-17
C112 (\7\:RN VSS) capacitor c=1.63976e-16
C113 (\8\:RN VSS) capacitor c=4.05891e-17
C114 (\6\:mout VSS) capacitor c=5.9034e-17
C115 (\9\:mout VSS) capacitor c=6.87998e-17
C116 (\7\:n20 VSS) capacitor c=8.79092e-17
C117 (\10\:n20 VSS) capacitor c=9.77046e-17
C118 (\10\:Ckbb VSS) capacitor c=2.85133e-17
C119 (\11\:Ckbb VSS) capacitor c=6.47126e-17
C120 (\12\:Ckbb VSS) capacitor c=1.11356e-16
C121 (\13\:Ckbb VSS) capacitor c=8.37625e-17
C122 (\11\:CKb VSS) capacitor c=7.40409e-17
C123 (\12\:CKb VSS) capacitor c=2.09217e-16
C124 (\13\:CKb VSS) capacitor c=2.18615e-16
C125 (\14\:CKb VSS) capacitor c=1.50524e-16
C126 (\4\:SI VSS) capacitor c=3.89008e-17
C127 (\4\:D VSS) capacitor c=5.37892e-17
C128 (\7\:SE VSS) capacitor c=8.72676e-17
C129 (\8\:SE VSS) capacitor c=6.48903e-17
C130 (\9\:SEb VSS) capacitor c=1.08554e-16
C131 (\10\:SEb VSS) capacitor c=2.64404e-17
C132 (\11\:SEb VSS) capacitor c=1.01341e-16
C133 (\5\:VDD VSS) capacitor c=3.11171e-17
C134 (\6\:VDD VSS) capacitor c=2.9874e-17
C135 (\14\:VDD VSS) capacitor c=3.60573e-17
C136 (\17\:VDD VSS) capacitor c=1.35573e-17
C137 (\20\:VDD VSS) capacitor c=1.24458e-16
Rk19 (\7\:RN RN) resistor r=1.1013 c=0
Rk20 (RN \8\:RN) resistor r=0.1094 c=0
Rk3 (\2\:QN QN) resistor r=0.06657 c=0
Rk4 (QN \4\:QN) resistor r=0.1965 c=0
Rk49 (\2\:VSS \4\:VSS) resistor r=0.2366 c=0
Rk50 (\4\:VSS \5\:VSS) resistor r=0.248 c=0
Rk51 (\5\:VSS \6\:VSS) resistor r=0.7551 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.5416 c=0
Rk57 (\8\:VSS VSS) resistor r=0.1875 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.6012 c=0
Rk58 (\5\:VSS \13\:VSS) resistor r=0.28 c=0
Rk59 (\6\:VSS \15\:VSS) resistor r=0.07144 c=0
Rk60 (\7\:VSS \17\:VSS) resistor r=0.1288 c=0
Rk44 (\8\:SE SE) resistor r=0.005081 c=0
Rk43 (\7\:SE \8\:SE) resistor r=0.3449 c=0
Rk42 (D \4\:D) resistor r=0.2151 c=0
Rk5 (\2\:Q Q) resistor r=0.06768 c=0
Rk6 (Q \4\:Q) resistor r=0.1712 c=0
Rk64 (\2\:VDD \4\:VDD) resistor r=0.2302 c=0
Rk65 (\4\:VDD \5\:VDD) resistor r=0.2179 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=0.5887 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.1953 c=0
Rk68 (\5\:VDD \9\:VDD) resistor r=0.07358 c=0
Rk69 (\6\:VDD \11\:VDD) resistor r=0.1754 c=0
Rk70 (\7\:VDD \13\:VDD) resistor r=0.07144 c=0
Rk71 (\7\:VDD \14\:VDD) resistor r=0.5699 c=0
Rk72 (\14\:VDD \16\:VDD) resistor r=0.07358 c=0
Rk73 (\14\:VDD \17\:VDD) resistor r=0.2001 c=0
Rk74 (\17\:VDD \19\:VDD) resistor r=0.2466 c=0
Rk82 (\20\:VDD VDD) resistor r=0.1149 c=0
Rk75 (\17\:VDD \20\:VDD) resistor r=0.358 c=0
Rk7 (\4\:CK CK) resistor r=0.002516 c=0
Rk38 (\4\:SI SI) resistor r=0.1283 c=0
Rk9 (\17\:qbint \4\:qbint) resistor r=0.589 c=0
Rk8 (\16\:qbint \17\:qbint) resistor r=0.3283 c=0
Rk11 (\4\:qbint \20\:qbint) resistor r=0.6832 c=0
Rk12 (\17\:qbint \22\:qbint) resistor r=0.2401 c=0
Rk13 (\22\:qbint \23\:qbint) resistor r=0.3138 c=0
Rk1 (\8\:qint \10\:qint) resistor r=0.3054 c=0
Rk2 (\10\:qint \12\:qint) resistor r=0.3041 c=0
Rk33 (\11\:CKb \12\:CKb) resistor r=0.5151 c=0
Rk34 (\12\:CKb \13\:CKb) resistor r=1.1438 c=0
Rk35 (\13\:CKb \14\:CKb) resistor r=0.698 c=0
Rk36 (\14\:CKb \16\:CKb) resistor r=0.8379 c=0
Rk37 (\16\:CKb \18\:CKb) resistor r=0.3148 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.3183 c=0
Rk17 (\6\:n30 \7\:n30) resistor r=0.4182 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.09782 c=0
Rk21 (\5\:mout \6\:mout) resistor r=0.2475 c=0
Rk22 (\6\:mout \8\:mout) resistor r=0.09265 c=0
Rk23 (\6\:mout \9\:mout) resistor r=0.3876 c=0
Rk28 (\9\:Ckbb \10\:Ckbb) resistor r=0.1486 c=0
Rk29 (\10\:Ckbb \11\:Ckbb) resistor r=0.09296 c=0
Rk30 (\11\:Ckbb \12\:Ckbb) resistor r=0.6378 c=0
Rk31 (\12\:Ckbb \13\:Ckbb) resistor r=0.5953 c=0
Rk32 (\10\:Ckbb \15\:Ckbb) resistor r=0.2417 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.2085 c=0
Rk26 (\7\:n20 \9\:n20) resistor r=0.265 c=0
Rk27 (\7\:n20 \10\:n20) resistor r=0.5262 c=0
Rk39 (\2\:Db \4\:Db) resistor r=0.5576 c=0
Rk40 (\4\:Db \6\:Db) resistor r=0.7767 c=0
Rk41 (\6\:Db \8\:Db) resistor r=0.3995 c=0
Rk45 (\6\:SEb \8\:SEb) resistor r=0.4707 c=0
Rk46 (\8\:SEb \9\:SEb) resistor r=0.4755 c=0
Rk47 (\9\:SEb \10\:SEb) resistor r=0.04287 c=0
Rk48 (\9\:SEb \11\:SEb) resistor r=0.5881 c=0
Rk24 (\2\:n6 \4\:n6) resistor r=0.2607 c=0
Rl30 (\4\:RN \5\:RN) resistor r=136.104 c=0
Rl31 (\5\:RN \6\:RN) resistor r=73.7687 c=0
Rl19 (\1\:RN \2\:RN) resistor r=24.2328 c=0
Rl20 (\2\:RN \3\:RN) resistor r=84.9195 c=0
Rl49 (\5\:SE \6\:SE) resistor r=87.6374 c=0
Rl48 (\4\:SE \5\:SE) resistor r=39.3036 c=0
Rl43 (\1\:SE \2\:SE) resistor r=24.2328 c=0
Rl44 (\2\:SE \3\:SE) resistor r=116.106 c=0
Rl46 (\1\:D \2\:D) resistor r=29.5379 c=0
Rl47 (\2\:D \3\:D) resistor r=96.8456 c=0
Rl16 (\2\:CK \3\:CK) resistor r=74.1758 c=0
Rl15 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl40 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl41 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl21 (\13\:qbint \12\:qbint) resistor r=126.923 c=0
Rl22 (\14\:qbint \12\:qbint) resistor r=29.5379 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=31.4748 c=0
Rl1 (\2\:qbint qbint) resistor r=57.6923 c=0
Rl39 (\8\:CKb \10\:CKb) resistor r=151.923 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=102.735 c=0
Rl38 (\8\:CKb \9\:CKb) resistor r=56.461 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=44.9225 c=0
Rl24 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl23 (CKb \2\:CKb) resistor r=81.9251 c=0
Rl18 (\2\:n30 \3\:n30) resistor r=64.5604 c=0
Rl17 (n30 \2\:n30) resistor r=38.4615 c=0
Rl32 (mout \2\:mout) resistor r=69.2107 c=0
Rl33 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (Ckbb \2\:Ckbb) resistor r=224.131 c=0
Rl37 (\6\:Ckbb \7\:Ckbb) resistor r=136.052 c=0
Rl34 (\4\:Ckbb \5\:Ckbb) resistor r=31.9251 c=0
Rl26 (\2\:Ckbb \3\:Ckbb) resistor r=31.9251 c=0
Rl29 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=84.3295 c=0
Rl27 (n20 \2\:n20) resistor r=0.5213 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=65.6003 c=0
Rl42 (SEb \2\:SEb) resistor r=46.8456 c=0
Rz2 (\2\:QN \1\:QN) resistor r=75 c=0
Rz13 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz3 (\2\:Q \1\:Q) resistor r=75 c=0
Rz20 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz21 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz22 (\20\:VDD \3\:VDD) resistor r=6.25 c=0
Rz4 (\16\:qbint \15\:qbint) resistor r=75 c=0
Rz1 (\10\:qint \9\:qint) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\8\:Ckbb \9\:Ckbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry2 (\4\:QN \3\:QN) resistor r=62 c=0
Ry15 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry16 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry3 (\4\:Q \3\:Q) resistor r=62 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry19 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry20 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry21 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry23 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry4 (\22\:qbint \21\:qbint) resistor r=31 c=0
Ry1 (\12\:qint \11\:qint) resistor r=62 c=0
Ry11 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\4\:mout \5\:mout) resistor r=62 c=0
Ry10 (\14\:Ckbb \15\:Ckbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry12 (\3\:Db \4\:Db) resistor r=62 c=0
Ry13 (\5\:Db \6\:Db) resistor r=62 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx8 (\6\:RN \7\:RN) resistor r=45 c=0
Rx9 (\2\:RN \8\:RN) resistor r=45 c=0
Rx21 (\2\:SE \7\:SE) resistor r=45 c=0
Rx22 (\5\:SE \8\:SE) resistor r=45 c=0
Rx20 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\20\:qbint \2\:qbint) resistor r=45 c=0
Rx4 (\23\:qbint \14\:qbint) resistor r=45 c=0
Rx1 (\8\:qint qint) resistor r=45 c=0
Rx15 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx18 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\6\:Ckbb \11\:Ckbb) resistor r=45 c=0
Rx13 (\5\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx14 (\3\:Ckbb \13\:Ckbb) resistor r=45 c=0
Rx11 (n20 \10\:n20) resistor r=45 c=0
Rx23 (\4\:SEb \10\:SEb) resistor r=45 c=0
Rx24 (\2\:SEb \11\:SEb) resistor r=45 c=0
mn56 (\9\:qint qbint \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34293e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn20 (\15\:CKb \1\:CK \8\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.133e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26776e-06 sb=2.85e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n11 \13\:qbint \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.825e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn51 (\8\:n30 CKb n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.38e-14 ps=4.1e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.72e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\7\:mout \2\:Ckbb \8\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.38e-14 ad=3.335e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.235e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\7\:mout \3\:n20 \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.17e-14 ad=3.335e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=9.6e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n7 \4\:RN \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.17e-14 ad=8.7e-15 ps=1.56e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=6.95e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.682e-14 ps=4.1e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.8e-06 sb=5.9e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn37 (\5\:n20 \4\:Ckbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.537e-14 ps=6.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.6e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn25 (\7\:Db \5\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn21 (\8\:Ckbb \10\:CKb \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn13 (n3 \3\:SI \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=4.06e-14 ps=6.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.04e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=4.06e-14 \
        ad=2.32e-14 ps=8.5e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.75e-07 sb=7.15e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.8e-07 sb=5.1e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn11 (n1 \3\:D \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.79e-14 ad=8.7e-15 ps=1.33e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=4.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn10 (\7\:SEb \4\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.79e-14 ad=2.03e-14 ps=1.33e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn57 (\1\:QN qint \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.48e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.87788e-07 sb=1.02404e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn55_1__rcx (\1\:Q \4\:qbint \8\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.68e-14 ad=4.81e-14 ps=9.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.97788e-07 sb=6.14038e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn46 (\15\:qbint n30 n9 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.998e-14 ps=5.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=1.49512e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn45 (n9 \3\:RN \16\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=1.23e-14 ps=1.38e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.46439e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mp57_1__rcx (\3\:QN qint \20\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.742e-14 ad=7.215e-14 ps=1.32e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=1.02833e-06 sd=160n sca=32.8253 \
        scb=0.0223774 scc=0.00336999 m=(2)
mp55_1__rcx (\3\:Q \4\:qbint \20\:VDD VDD) g45p1hvt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=8.376e-14 ad=7.215e-14 ps=1.44e-06 pd=1.15e-06 \
        nrd=1.16667 nrs=1.16667 sa=7.94551e-07 sb=5.33333e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(2)
mp46 (\21\:qbint \3\:n30 \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=4.96e-14 ps=1.14e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06774e-07 sb=1.38347e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp45 (\21\:qbint \1\:RN \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.303e-14 ad=4.96e-14 ps=1.81e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.11774e-07 sb=1.17847e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
ends SDFFRX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:44 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRX4
// View name: extracted

simulator lang=spectre

subckt SDFFRX4 CK D Q QN RN SE SI VDD VSS
mp10 (\8\:SEb \1\:SE \39\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=14.1047 \
        scb=0.0123052 scc=0.000144089 m=(1)
mp13 (n4 \1\:SI \39\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=11.6656 \
        scb=0.00859665 scc=9.9547e-05 m=(1)
mp14 (\8\:Db \3\:SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=5.697e-14 ps=8.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=8.75e-07 sd=160n sca=10.6337 \
        scb=0.00785382 scc=9.84653e-05 m=(1)
mp12 (\8\:Db \6\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.697e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=5.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp11 (n2 \1\:D \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=4.6e-07 sd=160n sca=10.3756 scb=0.00778655 \
        scc=9.84544e-05 m=(1)
mp20 (\17\:CKb \1\:CK \37\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=2.55e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\13\:Ckbb \4\:CKb \35\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.98e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp25 (\7\:n20 Ckbb \3\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp37 (\7\:n20 \6\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\3\:n6 \3\:mout \33\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.795e-14 ad=3.44e-14 ps=1.81e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (\3\:n6 \1\:RN \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1823e-13 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\8\:mout n20 \31\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1823e-13 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.32674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\13\:n30 \9\:CKb \8\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.37674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\13\:n30 \5\:Ckbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15767e-06 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (n8 \3\:qbint \3\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.548e-14 ps=1.18e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36767e-06 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
C1 (RN VSS) capacitor c=9.62889e-18
C2 (Q VSS) capacitor c=2.33672e-17
C3 (SI VSS) capacitor c=5.25256e-17
C4 (QN VSS) capacitor c=2.09398e-17
C5 (VDD VSS) capacitor c=4.95253e-16
C6 (CK VSS) capacitor c=7.83984e-17
C7 (D VSS) capacitor c=3.90105e-17
C8 (SEb VSS) capacitor c=6.3957e-17
C9 (n3 VSS) capacitor c=8.64555e-20
C10 (Db VSS) capacitor c=6.93067e-17
C11 (n1 VSS) capacitor c=4.33203e-18
C12 (CKb VSS) capacitor c=1.92188e-17
C13 (Ckbb VSS) capacitor c=5.08643e-17
C14 (n20 VSS) capacitor c=5.9691e-17
C15 (mout VSS) capacitor c=9.47725e-17
C16 (n30 VSS) capacitor c=9.63666e-17
C17 (n11 VSS) capacitor c=9.10397e-19
C18 (qbint VSS) capacitor c=6.18603e-17
C19 (29 VSS) capacitor c=1.18163e-18
C20 (qint VSS) capacitor c=2.90109e-16
C21 (n6 VSS) capacitor c=6.99202e-17
C22 (n8 VSS) capacitor c=2.23881e-18
C23 (\23\:qbint VSS) capacitor c=4.74243e-17
C24 (\4\:qbint VSS) capacitor c=2.69036e-16
C25 (\3\:qbint VSS) capacitor c=3.35992e-17
C26 (\5\:Ckbb VSS) capacitor c=7.83871e-17
C27 (\9\:CKb VSS) capacitor c=5.2352e-17
C28 (\1\:RN VSS) capacitor c=4.56797e-17
C29 (\3\:mout VSS) capacitor c=3.75241e-17
C30 (\6\:CKb VSS) capacitor c=3.68071e-17
C31 (\4\:CKb VSS) capacitor c=2.5472e-17
C32 (\1\:CK VSS) capacitor c=5.50201e-17
C33 (\1\:D VSS) capacitor c=9.13212e-17
C34 (\6\:SE VSS) capacitor c=5.89738e-17
C35 (\3\:SEb VSS) capacitor c=2.82319e-17
C36 (\1\:SI VSS) capacitor c=5.67418e-17
C37 (\1\:SE VSS) capacitor c=5.80475e-17
C38 (\21\:qbint VSS) capacitor c=3.1405e-17
C39 (\9\:RN VSS) capacitor c=4.8411e-17
C40 (\6\:n30 VSS) capacitor c=3.23425e-17
C41 (\5\:n30 VSS) capacitor c=4.29652e-17
C42 (\4\:RN VSS) capacitor c=5.00516e-17
C43 (\11\:CKb VSS) capacitor c=5.85869e-17
C44 (\6\:Ckbb VSS) capacitor c=8.10412e-17
C45 (\4\:n20 VSS) capacitor c=3.4686e-17
C46 (\3\:RN VSS) capacitor c=5.60653e-17
C47 (\3\:Ckbb VSS) capacitor c=6.76545e-17
C48 (\8\:CKb VSS) capacitor c=3.955e-17
C49 (\3\:CK VSS) capacitor c=2.71903e-17
C50 (\3\:D VSS) capacitor c=3.85963e-17
C51 (\4\:SE VSS) capacitor c=6.56828e-17
C52 (\3\:SI VSS) capacitor c=6.49516e-17
C53 (\3\:SE VSS) capacitor c=2.31382e-17
C54 (\22\:qbint VSS) capacitor c=3.13027e-17
C55 (\13\:qbint VSS) capacitor c=2.53607e-17
C56 (\7\:n30 VSS) capacitor c=1.38362e-17
C57 (\5\:RN VSS) capacitor c=4.48713e-16
C58 (\2\:qbint VSS) capacitor c=4.58507e-17
C59 (\12\:CKb VSS) capacitor c=4.56623e-17
C60 (\10\:CKb VSS) capacitor c=2.31925e-17
C61 (\3\:n20 VSS) capacitor c=2.97867e-17
C62 (\7\:Ckbb VSS) capacitor c=4.76758e-17
C63 (\2\:RN VSS) capacitor c=5.69972e-17
C64 (\2\:mout VSS) capacitor c=5.78251e-17
C65 (\4\:Ckbb VSS) capacitor c=2.56227e-17
C66 (\7\:CKb VSS) capacitor c=2.54371e-17
C67 (\2\:Ckbb VSS) capacitor c=3.8198e-17
C68 (\5\:CKb VSS) capacitor c=2.52076e-17
C69 (\3\:CKb VSS) capacitor c=7.16119e-18
C70 (\2\:CK VSS) capacitor c=5.16093e-17
C71 (\2\:D VSS) capacitor c=5.46689e-17
C72 (\7\:SE VSS) capacitor c=4.25082e-17
C73 (\2\:SEb VSS) capacitor c=5.39758e-17
C74 (\5\:SE VSS) capacitor c=4.98961e-17
C75 (\2\:SI VSS) capacitor c=6.79805e-17
C76 (\2\:SE VSS) capacitor c=5.92793e-17
C77 (\19\:qint VSS) capacitor c=3.68277e-17
C78 (\1\:QN VSS) capacitor c=1.70351e-16
C79 (\1\:Q VSS) capacitor c=1.74601e-16
C80 (\27\:VDD VSS) capacitor c=3.48328e-17
C81 (\13\:n30 VSS) capacitor c=8.93465e-17
C82 (\8\:mout VSS) capacitor c=2.18363e-17
C83 (\31\:VDD VSS) capacitor c=2.10592e-17
C84 (\3\:n6 VSS) capacitor c=7.23359e-17
C85 (\33\:VDD VSS) capacitor c=1.772e-17
C86 (\7\:n20 VSS) capacitor c=7.36972e-17
C87 (\3\:Db VSS) capacitor c=2.59973e-16
C88 (\13\:Ckbb VSS) capacitor c=5.03475e-17
C89 (\35\:VDD VSS) capacitor c=4.77777e-17
C90 (\17\:CKb VSS) capacitor c=8.97718e-17
C91 (\37\:VDD VSS) capacitor c=4.27953e-17
C92 (\8\:Db VSS) capacitor c=1.59927e-17
C93 (\39\:VDD VSS) capacitor c=2.75493e-17
C94 (\8\:SEb VSS) capacitor c=1.46218e-17
C95 (\1\:VDD VSS) capacitor c=8.25368e-17
C96 (\15\:qint VSS) capacitor c=4.19575e-17
C97 (\4\:QN VSS) capacitor c=1.15915e-16
C98 (\35\:qbint VSS) capacitor c=1.08437e-16
C99 (\15\:n30 VSS) capacitor c=2.6998e-17
C100 (\4\:mout VSS) capacitor c=8.26425e-17
C101 (\9\:n20 VSS) capacitor c=2.60468e-17
C102 (\11\:Ckbb VSS) capacitor c=3.29697e-17
C103 (\15\:CKb VSS) capacitor c=5.67052e-17
C104 (\6\:Db VSS) capacitor c=1.20789e-16
C105 (\6\:SEb VSS) capacitor c=7.09073e-17
C106 (\2\:CKb VSS) capacitor c=8.34758e-18
C107 (\2\:n20 VSS) capacitor c=2.83943e-17
C108 (\3\:n30 VSS) capacitor c=2.79452e-17
C109 (\4\:n30 VSS) capacitor c=2.87694e-17
C110 (\4\:SI VSS) capacitor c=5.83986e-17
C111 (\4\:SEb VSS) capacitor c=6.60744e-17
C112 (\5\:SEb VSS) capacitor c=8.55173e-17
C113 (\8\:SE VSS) capacitor c=1.87915e-16
C114 (\9\:SE VSS) capacitor c=1.40931e-16
C115 (\10\:SE VSS) capacitor c=3.22764e-17
C116 (\11\:SE VSS) capacitor c=4.43552e-17
C117 (\5\:D VSS) capacitor c=9.38002e-17
C118 (\4\:CK VSS) capacitor c=4.18721e-17
C119 (\13\:CKb VSS) capacitor c=3.36184e-17
C120 (\14\:CKb VSS) capacitor c=8.00513e-17
C121 (\5\:Db VSS) capacitor c=2.70943e-16
C122 (\8\:Ckbb VSS) capacitor c=4.48944e-17
C123 (\9\:Ckbb VSS) capacitor c=9.74916e-17
C124 (\10\:Ckbb VSS) capacitor c=7.73493e-17
C125 (\5\:n20 VSS) capacitor c=7.56036e-17
C126 (\6\:n20 VSS) capacitor c=7.05498e-17
C127 (\6\:mout VSS) capacitor c=1.14255e-16
C128 (\7\:mout VSS) capacitor c=9.55609e-17
C129 (\19\:CKb VSS) capacitor c=1.61657e-16
C130 (\20\:CKb VSS) capacitor c=6.47176e-17
C131 (\21\:CKb VSS) capacitor c=1.60179e-16
C132 (\22\:CKb VSS) capacitor c=1.10725e-16
C133 (\11\:n30 VSS) capacitor c=1.26963e-16
C134 (\12\:n30 VSS) capacitor c=1.4253e-16
C135 (\11\:RN VSS) capacitor c=1.98727e-16
C136 (\12\:RN VSS) capacitor c=8.83666e-17
C137 (\24\:qbint VSS) capacitor c=3.886e-17
C138 (\25\:qbint VSS) capacitor c=1.84855e-16
C139 (\27\:qbint VSS) capacitor c=6.48917e-17
C140 (\4\:Q VSS) capacitor c=1.24664e-16
C141 (\32\:qbint VSS) capacitor c=1.27561e-16
C142 (\33\:qbint VSS) capacitor c=2.28337e-16
C143 (\34\:qbint VSS) capacitor c=4.06073e-17
C144 (\17\:qint VSS) capacitor c=3.43684e-17
C145 (\18\:qint VSS) capacitor c=2.96141e-17
C146 (\3\:VDD VSS) capacitor c=5.33452e-16
C147 (\12\:VDD VSS) capacitor c=3.54341e-17
C148 (\13\:VDD VSS) capacitor c=4.3771e-17
C149 (\14\:VDD VSS) capacitor c=2.7627e-17
C150 (\16\:VDD VSS) capacitor c=2.67309e-17
Rk40 (\11\:RN RN) resistor r=0.003081 c=0
Rk37 (\5\:RN \11\:RN) resistor r=1.2016 c=0
Rk38 (\11\:RN \12\:RN) resistor r=0.4973 c=0
Rk47 (\1\:Q Q) resistor r=0.07816 c=0
Rk48 (Q \4\:Q) resistor r=0.2117 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.2212 c=0
Rk6 (\9\:SE \10\:SE) resistor r=0.0935 c=0
Rk8 (\11\:SE SE) resistor r=0.003679 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.1995 c=0
Rk1 (\4\:SI SI) resistor r=0.01562 c=0
Rk53 (\1\:QN QN) resistor r=0.07599 c=0
Rk54 (QN \4\:QN) resistor r=0.2228 c=0
Rk85 (\2\:VDD \3\:VDD) resistor r=0.06252 c=0
Rk93 (\3\:VDD \11\:VDD) resistor r=0.4216 c=0
Rk94 (\11\:VDD \12\:VDD) resistor r=0.3755 c=0
Rk95 (\12\:VDD \13\:VDD) resistor r=0.4226 c=0
Rk96 (\13\:VDD \14\:VDD) resistor r=0.3207 c=0
Rk97 (\14\:VDD \15\:VDD) resistor r=0.08259 c=0
Rk99 (\16\:VDD VDD) resistor r=0.2028 c=0
Rk98 (\15\:VDD \16\:VDD) resistor r=0.3485 c=0
Rk105 (\3\:VDD \28\:VDD) resistor r=0.273 c=0
Rk107 (\11\:VDD \32\:VDD) resistor r=0.1494 c=0
Rk108 (\12\:VDD \34\:VDD) resistor r=0.04333 c=0
Rk109 (\13\:VDD \36\:VDD) resistor r=0.2398 c=0
Rk110 (\14\:VDD \38\:VDD) resistor r=0.184 c=0
Rk111 (\16\:VDD \40\:VDD) resistor r=0.1747 c=0
Rk12 (CK \4\:CK) resistor r=0.1172 c=0
Rk11 (D \5\:D) resistor r=0.06012 c=0
Rk63 (\2\:VSS \3\:VSS) resistor r=0.06659 c=0
Rk71 (\3\:VSS \14\:VSS) resistor r=0.4427 c=0
Rk72 (\14\:VSS \15\:VSS) resistor r=0.5015 c=0
Rk73 (\15\:VSS \16\:VSS) resistor r=0.8759 c=0
Rk74 (\16\:VSS \17\:VSS) resistor r=0.263 c=0
Rk75 (\17\:VSS \18\:VSS) resistor r=0.06503 c=0
Rk77 (\19\:VSS VSS) resistor r=0.1425 c=0
Rk76 (\18\:VSS \19\:VSS) resistor r=0.4087 c=0
Rk80 (\14\:VSS \25\:VSS) resistor r=0.1029 c=0
Rk81 (\15\:VSS \27\:VSS) resistor r=0.3735 c=0
Rk82 (\16\:VSS \29\:VSS) resistor r=0.3759 c=0
Rk83 (\17\:VSS \31\:VSS) resistor r=0.2753 c=0
Rk84 (\19\:VSS \33\:VSS) resistor r=0.2756 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.42 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.669 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04813 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.4418 c=0
Rk17 (\4\:Db \5\:Db) resistor r=1.6409 c=0
Rk18 (\5\:Db \7\:Db) resistor r=0.7439 c=0
Rk19 (\5\:Db \9\:Db) resistor r=0.0745 c=0
Rk13 (\13\:CKb \14\:CKb) resistor r=0.1766 c=0
Rk14 (\14\:CKb \16\:CKb) resistor r=0.2999 c=0
Rk15 (\14\:CKb \18\:CKb) resistor r=0.4265 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.3441 c=0
Rk32 (\19\:CKb \21\:CKb) resistor r=1.0203 c=0
Rk33 (\21\:CKb \22\:CKb) resistor r=0.6479 c=0
Rk21 (\8\:Ckbb \9\:Ckbb) resistor r=0.2893 c=0
Rk22 (\9\:Ckbb \10\:Ckbb) resistor r=0.7846 c=0
Rk23 (\10\:Ckbb \12\:Ckbb) resistor r=0.1632 c=0
Rk24 (\12\:Ckbb \14\:Ckbb) resistor r=0.2407 c=0
Rk25 (\5\:n20 \6\:n20) resistor r=0.4458 c=0
Rk26 (\6\:n20 \8\:n20) resistor r=0.346 c=0
Rk27 (\6\:n20 \10\:n20) resistor r=0.1277 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.4669 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.5867 c=0
Rk30 (\6\:mout \9\:mout) resistor r=0.03287 c=0
Rk34 (\11\:n30 \12\:n30) resistor r=0.7801 c=0
Rk35 (\12\:n30 \14\:n30) resistor r=0.5019 c=0
Rk36 (\12\:n30 \16\:n30) resistor r=0.03063 c=0
Rk41 (\24\:qbint \25\:qbint) resistor r=0.2725 c=0
Rk43 (\25\:qbint \27\:qbint) resistor r=0.3392 c=0
Rk57 (\32\:qbint \33\:qbint) resistor r=1.0529 c=0
Rk58 (\33\:qbint \34\:qbint) resistor r=0.2134 c=0
Rk59 (\33\:qbint \36\:qbint) resistor r=0.9778 c=0
Rk60 (\16\:qint \17\:qint) resistor r=0.2712 c=0
Rk61 (\17\:qint \18\:qint) resistor r=0.1876 c=0
Rk62 (\17\:qint \20\:qint) resistor r=0.1489 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.2612 c=0
Rl47 (\5\:RN \9\:RN) resistor r=30.5643 c=0
Rl34 (\5\:RN \4\:RN) resistor r=26.9231 c=0
Rl23 (\2\:RN \1\:RN) resistor r=63.4615 c=0
Rl24 (\2\:RN \3\:RN) resistor r=87.9121 c=0
Rl8 (\6\:SE \7\:SE) resistor r=73.7687 c=0
Rl5 (\4\:SE \5\:SE) resistor r=43.4636 c=0
Rl1 (\1\:SE \2\:SE) resistor r=236.104 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl3 (\1\:SI \2\:SI) resistor r=148.077 c=0
Rl4 (\2\:SI \3\:SI) resistor r=120.33 c=0
Rl11 (\1\:CK \2\:CK) resistor r=219.923 c=0
Rl12 (\2\:CK \3\:CK) resistor r=46.8456 c=0
Rl9 (\1\:D \2\:D) resistor r=179.538 c=0
Rl10 (\2\:D \3\:D) resistor r=88.2781 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl6 (SEb \2\:SEb) resistor r=236.583 c=0
Rl19 (\6\:CKb \8\:CKb) resistor r=125 c=0
Rl31 (\11\:CKb \12\:CKb) resistor r=49.2328 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl18 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=84.9359 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=47.791 c=0
Rl13 (CKb \2\:CKb) resistor r=36.2526 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=1.2666 c=0
Rl29 (\5\:Ckbb \6\:Ckbb) resistor r=201.161 c=0
Rl30 (\6\:Ckbb \7\:Ckbb) resistor r=291.821 c=0
Rl20 (\3\:Ckbb \4\:Ckbb) resistor r=53.079 c=0
Rl17 (Ckbb \2\:Ckbb) resistor r=121.131 c=0
Rl25 (n20 \2\:n20) resistor r=143.464 c=0
Rl27 (\2\:n20 \4\:n20) resistor r=28.0797 c=0
Rl26 (\2\:n20 \3\:n20) resistor r=64.2411 c=0
Rl22 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl21 (mout \2\:mout) resistor r=122.31 c=0
Rl42 (n30 \7\:n30) resistor r=11.572 c=0
Rl37 (\3\:n30 n30) resistor r=95.1951 c=0
Rl40 (\3\:n30 \6\:n30) resistor r=37.6951 c=0
Rl39 (\4\:n30 \5\:n30) resistor r=34.6788 c=0
Rl41 (\4\:n30 \7\:n30) resistor r=20.9149 c=0
Rl38 (\4\:n30 \3\:n30) resistor r=98.4217 c=0
Rl78 (\22\:qbint \23\:qbint) resistor r=78.6412 c=0
Rl77 (\22\:qbint \21\:qbint) resistor r=32.6802 c=0
Rl56 (\4\:qbint \13\:qbint) resistor r=7.553 c=0
Rl33 (\2\:qbint \3\:qbint) resistor r=26.3736 c=0
Rl32 (\2\:qbint qbint) resistor r=125 c=0
Rz25 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz26 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz27 (\11\:VDD \1\:VDD) resistor r=6.25 c=0
Rz28 (\15\:VDD \1\:VDD) resistor r=6.25 c=0
Rz20 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz21 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz22 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz23 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz24 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\11\:Ckbb \12\:Ckbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz7 (\4\:mout \5\:mout) resistor r=75 c=0
Rz8 (\16\:n30 \15\:n30) resistor r=75 c=0
Rz13 (\36\:qbint \35\:qbint) resistor r=75 c=0
Rz14 (\16\:qint \15\:qint) resistor r=75 c=0
Ry27 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry30 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry31 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry32 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry33 (\40\:VDD \39\:VDD) resistor r=62 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry19 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\15\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\18\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry3 (\3\:Db \4\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry7 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry8 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\14\:n30 \13\:n30) resistor r=62 c=0
Ry17 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Ry5 (n6 \2\:n6) resistor r=62 c=0
Ry6 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx20 (\12\:RN \2\:RN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SE \11\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:D \5\:D) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\3\:CKb \13\:CKb) resistor r=45 c=0
Rx14 (\7\:CKb \19\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \20\:CKb) resistor r=45 c=0
Rx16 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx17 (\12\:CKb \22\:CKb) resistor r=45 c=0
Rx9 (\7\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx10 (\4\:Ckbb \9\:Ckbb) resistor r=45 c=0
Rx11 (\2\:Ckbb \10\:Ckbb) resistor r=45 c=0
Rx12 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx13 (\2\:mout \7\:mout) resistor r=45 c=0
Rx18 (\11\:n30 \7\:n30) resistor r=45 c=0
Rx22 (\24\:qbint \13\:qbint) resistor r=45 c=0
Rx23 (\27\:qbint \2\:qbint) resistor r=45 c=0
Rx24 (\32\:qbint \22\:qbint) resistor r=45 c=0
Rx25 (\34\:qbint \4\:qbint) resistor r=45 c=0
Rx26 (\18\:qint qint) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.465e-14 ps=7.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.325e-06 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn13 (n3 \3\:SI \32\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=8.7e-15 ps=7.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.055e-06 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn14 (\6\:Db \4\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=9.5e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn12 (\6\:Db SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=4.64e-14 \
        ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.5e-07 sb=7.45e-07 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mn11 (n1 \3\:D \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=4.64e-14 ps=6.8e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=3.8e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn20 (\15\:CKb \3\:CK \30\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=1.4e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn21 (\11\:Ckbb CKb \28\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.03e-14 ps=7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (Db \8\:CKb \9\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn37 (\9\:n20 \3\:Ckbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.843e-14 ps=4.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (n5 mout n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=9.43e-15 \
        ad=8.7e-15 ps=4.2e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.55e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n7 \3\:RN \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.018e-14 ad=9.43e-15 ps=1.12e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\4\:mout \4\:n20 \26\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.018e-14 ad=3.625e-14 ps=1.12e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\4\:mout \6\:Ckbb \15\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=3.625e-14 ps=7.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\15\:n30 \11\:CKb n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.232e-14 ad=3.48e-14 ps=4.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (n11 qbint \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.923e-14 ad=1.233e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (28 \4\:RN \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.923e-14 ad=1.23e-14 ps=1.6e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46439e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn46_1__rcx (\35\:qbint \5\:n30 28 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.23e-14 ad=6.048e-14 ps=5.3e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49512e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn46 (\35\:qbint \6\:n30 29 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=6.048e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.59463e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn45 (29 \9\:RN \3\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.265e-14 ad=2.05e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63707e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn56 (\15\:qint \21\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38788e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn57_1__rcx (\4\:QN qint \3\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80365e-06 sb=1.1e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mp46_1__rcx (\25\:qbint n30 \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.145e-14 ad=4.96e-14 ps=1.21e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.40073e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp45 (\25\:qbint \5\:RN \3\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.47e-14 ad=4.96e-14 ps=1.33e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2046e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp56 (\19\:qint \23\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.63e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96308e-06 sb=1.4e-07 sd=160n sca=25.3022 \
        scb=0.0253386 scc=0.00193759 m=(1)
mp55 (\1\:Q \4\:qbint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.673e-14 ad=6.24e-14 ps=1.195e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43455e-06 sb=1.82e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(4)
mp57_1__rcx (\1\:QN qint \3\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.337e-14 ad=6.825e-14 ps=1.105e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.78667e-06 sb=1e-06 sd=160n \
        sca=19.0259 scb=0.0163587 scc=0.00171562 m=(4)
ends SDFFRX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:45 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFRXL
// View name: extracted

simulator lang=spectre

subckt SDFFRXL CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:qint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=50.5874 \
        scb=0.0347407 scc=0.00598541 m=(1)
mp56 (\9\:qint \7\:qbint \26\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.9828 \
        scb=0.0290392 scc=0.00588499 m=(1)
mp55 (\3\:Q qbint \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\20\:CKb \1\:CK \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp46 (\11\:qbint n30 \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\11\:qbint \2\:RN \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp50 (n8 \8\:qbint \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.655e-14 ps=1.8e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.335e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp51 (\7\:n30 \3\:Ckbb n8 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.483e-14 ps=7.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.12e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp40 (\7\:n30 \3\:CKb \6\:mout VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=5.483e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=8.2e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp30 (\6\:mout \3\:n20 \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=5.913e-14 ps=1.8e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=5e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp35 (\3\:n6 \6\:RN \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=3.05e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp36 (\3\:n6 mout \10\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.315e-14 ad=3.44e-14 ps=1.7e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=1e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp37 (\8\:n20 \6\:CKb n6 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\8\:n20 \8\:Ckbb \4\:Db VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\13\:Ckbb \9\:CKb \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.815e-14 ad=3.01e-14 ps=1.57e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp11 (n2 \1\:D \6\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.655e-14 ps=1.57e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.19e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=9.75e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 as=4.3e-14 \
        ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.55e-07 sb=7.7e-07 sd=160n sca=13.1637 scb=0.0123476 \
        scc=0.000501177 m=(1)
mp13 (n4 \1\:SI \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=4.3e-14 ps=1.11e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=5.25e-07 sd=160n sca=13.7416 scb=0.0125632 \
        scc=0.000501256 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=3.01e-14 ps=1.11e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=17.8247 \
        scb=0.018517 scc=0.000593893 m=(1)
C1 (RN VSS) capacitor c=6.22135e-17
C2 (QN VSS) capacitor c=2.11739e-17
C3 (SE VSS) capacitor c=3.88711e-17
C4 (Q VSS) capacitor c=6.8287e-17
C5 (SI VSS) capacitor c=1.1134e-16
C6 (VDD VSS) capacitor c=3.94343e-16
C7 (CK VSS) capacitor c=8.0611e-17
C8 (D VSS) capacitor c=7.04419e-17
C9 (qint VSS) capacitor c=2.16961e-17
C10 (qbint VSS) capacitor c=5.31828e-17
C11 (CKb VSS) capacitor c=6.44791e-17
C12 (n9 VSS) capacitor c=1.2869e-18
C13 (n30 VSS) capacitor c=5.25895e-17
C14 (n11 VSS) capacitor c=2.18491e-18
C15 (mout VSS) capacitor c=5.1578e-17
C16 (Ckbb VSS) capacitor c=2.02301e-17
C17 (n20 VSS) capacitor c=3.03185e-17
C18 (n7 VSS) capacitor c=1.5963e-19
C19 (Db VSS) capacitor c=1.26653e-16
C20 (n1 VSS) capacitor c=7.95439e-18
C21 (SEb VSS) capacitor c=3.20012e-17
C22 (n8 VSS) capacitor c=2.31739e-18
C23 (n6 VSS) capacitor c=6.89818e-17
C24 (n2 VSS) capacitor c=4.29239e-18
C25 (\5\:SE VSS) capacitor c=4.21262e-17
C26 (\1\:SI VSS) capacitor c=4.54474e-17
C27 (\1\:SE VSS) capacitor c=4.10888e-17
C28 (\1\:D VSS) capacitor c=6.89254e-17
C29 (\9\:CKb VSS) capacitor c=5.86838e-17
C30 (\8\:Ckbb VSS) capacitor c=5.15091e-17
C31 (\6\:CKb VSS) capacitor c=3.97177e-17
C32 (\6\:RN VSS) capacitor c=7.47834e-17
C33 (\3\:n20 VSS) capacitor c=5.00033e-17
C34 (\3\:CKb VSS) capacitor c=3.58178e-17
C35 (\3\:Ckbb VSS) capacitor c=5.00348e-17
C36 (\8\:qbint VSS) capacitor c=5.7097e-17
C37 (\2\:RN VSS) capacitor c=3.6388e-17
C38 (\1\:CK VSS) capacitor c=4.43383e-17
C39 (\7\:qbint VSS) capacitor c=2.28989e-17
C40 (\4\:qint VSS) capacitor c=2.73223e-17
C41 (\7\:SE VSS) capacitor c=2.30862e-17
C42 (\3\:SI VSS) capacitor c=4.75845e-17
C43 (\3\:SE VSS) capacitor c=6.10033e-17
C44 (\3\:SEb VSS) capacitor c=5.31917e-17
C45 (\4\:D VSS) capacitor c=3.0365e-17
C46 (\8\:CKb VSS) capacitor c=7.05142e-17
C47 (\5\:CKb VSS) capacitor c=4.65419e-17
C48 (\5\:Ckbb VSS) capacitor c=6.92929e-17
C49 (\3\:mout VSS) capacitor c=5.10086e-17
C50 (\5\:RN VSS) capacitor c=8.4029e-17
C51 (\4\:n20 VSS) capacitor c=2.95436e-17
C52 (\10\:qbint VSS) capacitor c=4.98993e-17
C53 (\4\:RN VSS) capacitor c=6.62054e-17
C54 (\2\:n30 VSS) capacitor c=5.01917e-17
C55 (\3\:CK VSS) capacitor c=4.6974e-17
C56 (\5\:qbint VSS) capacitor c=2.50078e-17
C57 (\4\:qbint VSS) capacitor c=2.48459e-17
C58 (\3\:qint VSS) capacitor c=2.98509e-17
C59 (\6\:SE VSS) capacitor c=3.26014e-17
C60 (\2\:SI VSS) capacitor c=5.38875e-17
C61 (\4\:SE VSS) capacitor c=5.54202e-17
C62 (\2\:SEb VSS) capacitor c=8.66333e-17
C63 (\2\:SE VSS) capacitor c=4.42388e-17
C64 (\3\:D VSS) capacitor c=2.42876e-17
C65 (\10\:CKb VSS) capacitor c=2.57469e-17
C66 (\7\:Ckbb VSS) capacitor c=3.88477e-17
C67 (\7\:CKb VSS) capacitor c=2.24125e-17
C68 (\6\:Ckbb VSS) capacitor c=3.1037e-17
C69 (\2\:mout VSS) capacitor c=6.09499e-17
C70 (\7\:RN VSS) capacitor c=2.40922e-17
C71 (\4\:Ckbb VSS) capacitor c=3.27409e-17
C72 (\4\:CKb VSS) capacitor c=3.8386e-17
C73 (\2\:CKb VSS) capacitor c=4.03104e-17
C74 (\9\:qbint VSS) capacitor c=5.1522e-17
C75 (\1\:RN VSS) capacitor c=2.3317e-17
C76 (\3\:RN VSS) capacitor c=4.86529e-17
C77 (\3\:n30 VSS) capacitor c=2.88071e-17
C78 (\2\:CK VSS) capacitor c=5.19311e-17
C79 (\6\:qbint VSS) capacitor c=2.34924e-17
C80 (\4\:SEb VSS) capacitor c=1.05479e-17
C81 (\1\:VDD VSS) capacitor c=3.27322e-17
C82 (\8\:Db VSS) capacitor c=2.24582e-17
C83 (\6\:VDD VSS) capacitor c=1.03898e-17
C84 (\13\:Ckbb VSS) capacitor c=8.27509e-17
C85 (\4\:Db VSS) capacitor c=1.40326e-16
C86 (\8\:n20 VSS) capacitor c=4.91538e-17
C87 (\10\:VDD VSS) capacitor c=9.88276e-18
C88 (\3\:n6 VSS) capacitor c=6.74509e-17
C89 (\13\:VDD VSS) capacitor c=1.95464e-17
C90 (\6\:mout VSS) capacitor c=6.27959e-17
C91 (\7\:n30 VSS) capacitor c=8.29601e-17
C92 (\16\:VDD VSS) capacitor c=2.01571e-17
C93 (\11\:qbint VSS) capacitor c=1.01338e-16
C94 (\19\:VDD VSS) capacitor c=3.19999e-17
C95 (\20\:CKb VSS) capacitor c=2.30334e-17
C96 (\23\:VDD VSS) capacitor c=2.61499e-17
C97 (\3\:Q VSS) capacitor c=4.2845e-17
C98 (\9\:qint VSS) capacitor c=3.87116e-17
C99 (\26\:VDD VSS) capacitor c=4.45117e-17
C100 (\1\:QN VSS) capacitor c=2.09195e-17
C101 (\3\:VDD VSS) capacitor c=7.91112e-17
C102 (\8\:SEb VSS) capacitor c=7.64033e-17
C103 (\9\:Ckbb VSS) capacitor c=5.11075e-17
C104 (\6\:Db VSS) capacitor c=5.87654e-17
C105 (\5\:n20 VSS) capacitor c=4.02172e-17
C106 (\8\:mout VSS) capacitor c=2.6488e-17
C107 (\4\:n30 VSS) capacitor c=9.12923e-17
C108 (\14\:qbint VSS) capacitor c=8.75402e-17
C109 (\16\:CKb VSS) capacitor c=1.06667e-16
C110 (\1\:Q VSS) capacitor c=6.28915e-17
C111 (\7\:qint VSS) capacitor c=2.56235e-17
C112 (\3\:QN VSS) capacitor c=2.50856e-17
C113 (\2\:qint VSS) capacitor c=7.61862e-18
C114 (\2\:qbint VSS) capacitor c=3.77253e-17
C115 (\3\:qbint VSS) capacitor c=3.51e-17
C116 (\2\:Ckbb VSS) capacitor c=4.99235e-17
C117 (\2\:n20 VSS) capacitor c=3.41332e-17
C118 (\2\:D VSS) capacitor c=3.29022e-17
C119 (\5\:qint VSS) capacitor c=2.5666e-17
C120 (\6\:qint VSS) capacitor c=3.4066e-17
C121 (\4\:CK VSS) capacitor c=3.76495e-17
C122 (\13\:qbint VSS) capacitor c=1.0578e-16
C123 (\16\:qbint VSS) capacitor c=8.61944e-17
C124 (\17\:qbint VSS) capacitor c=8.65998e-17
C125 (\8\:RN VSS) capacitor c=7.67781e-17
C126 (\6\:n30 VSS) capacitor c=1.10756e-16
C127 (\9\:RN VSS) capacitor c=1.47977e-16
C128 (\10\:RN VSS) capacitor c=1.49566e-16
C129 (\4\:mout VSS) capacitor c=7.83737e-17
C130 (\5\:mout VSS) capacitor c=8.73836e-17
C131 (\7\:n20 VSS) capacitor c=8.95382e-17
C132 (\10\:n20 VSS) capacitor c=8.27331e-17
C133 (\11\:Ckbb VSS) capacitor c=1.09307e-17
C134 (\12\:Ckbb VSS) capacitor c=1.88282e-16
C135 (\15\:Ckbb VSS) capacitor c=2.76826e-17
C136 (\16\:Ckbb VSS) capacitor c=1.09283e-16
C137 (\11\:CKb VSS) capacitor c=8.09036e-17
C138 (\12\:CKb VSS) capacitor c=1.6939e-16
C139 (\13\:CKb VSS) capacitor c=1.31946e-16
C140 (\14\:CKb VSS) capacitor c=1.34592e-16
C141 (\15\:CKb VSS) capacitor c=1.31421e-16
C142 (\18\:CKb VSS) capacitor c=4.8027e-17
C143 (\19\:CKb VSS) capacitor c=7.73996e-17
C144 (\5\:D VSS) capacitor c=5.22263e-17
C145 (\3\:Db VSS) capacitor c=1.96302e-16
C146 (\8\:SE VSS) capacitor c=5.05749e-17
C147 (\9\:SE VSS) capacitor c=1.08704e-16
C148 (\10\:SE VSS) capacitor c=5.63534e-17
C149 (\11\:SE VSS) capacitor c=2.53998e-17
C150 (\6\:SEb VSS) capacitor c=8.84453e-17
C151 (\7\:SEb VSS) capacitor c=7.67163e-17
C152 (\5\:VDD VSS) capacitor c=4.5593e-17
C153 (\9\:VDD VSS) capacitor c=8.51111e-18
C154 (\12\:VDD VSS) capacitor c=3.16857e-17
C155 (\15\:VDD VSS) capacitor c=3.51272e-17
C156 (\18\:VDD VSS) capacitor c=1.1838e-17
C157 (\22\:VDD VSS) capacitor c=1.61185e-17
C158 (\25\:VDD VSS) capacitor c=1.63476e-17
Rk13 (\8\:RN RN) resistor r=0.09899 c=0
Rk16 (\9\:RN \10\:RN) resistor r=0.9727 c=0
Rk2 (\4\:QN QN) resistor r=0.07352 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk43 (SE \8\:SE) resistor r=0.1056 c=0
Rk44 (\8\:SE \9\:SE) resistor r=0.4136 c=0
Rk45 (\9\:SE \10\:SE) resistor r=0.4637 c=0
Rk46 (\9\:SE \11\:SE) resistor r=0.101 c=0
Rk6 (Q \2\:Q) resistor r=0.3685 c=0
Rk7 (Q \4\:Q) resistor r=0.1681 c=0
Rk42 (\4\:SI SI) resistor r=0.004561 c=0
Rk50 (\2\:VDD \4\:VDD) resistor r=0.3542 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.4393 c=0
Rk52 (\5\:VDD \7\:VDD) resistor r=0.07393 c=0
Rk53 (\5\:VDD \8\:VDD) resistor r=0.4638 c=0
Rk54 (\8\:VDD \9\:VDD) resistor r=0.0951 c=0
Rk55 (\9\:VDD \11\:VDD) resistor r=0.07393 c=0
Rk56 (\9\:VDD \12\:VDD) resistor r=0.1993 c=0
Rk57 (\12\:VDD \14\:VDD) resistor r=0.04331 c=0
Rk58 (\12\:VDD \15\:VDD) resistor r=0.4792 c=0
Rk59 (\15\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk60 (\15\:VDD \18\:VDD) resistor r=0.2344 c=0
Rk61 (\18\:VDD \20\:VDD) resistor r=0.1808 c=0
Rk62 (\18\:VDD \21\:VDD) resistor r=0.1904 c=0
Rk63 (\21\:VDD \22\:VDD) resistor r=0.04244 c=0
Rk64 (\22\:VDD \24\:VDD) resistor r=0.1742 c=0
Rk67 (\25\:VDD VDD) resistor r=0.1952 c=0
Rk65 (\22\:VDD \25\:VDD) resistor r=0.3131 c=0
Rk66 (\25\:VDD \27\:VDD) resistor r=0.4181 c=0
Rk8 (\4\:CK CK) resistor r=0.1052 c=0
Rk37 (D \5\:D) resistor r=0.1792 c=0
Rk68 (\2\:VSS \3\:VSS) resistor r=0.03742 c=0
Rk69 (\3\:VSS \4\:VSS) resistor r=0.4209 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.4437 c=0
Rk71 (\5\:VSS \6\:VSS) resistor r=0.2446 c=0
Rk72 (\6\:VSS \7\:VSS) resistor r=0.588 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.3685 c=0
Rk74 (\8\:VSS \9\:VSS) resistor r=0.09009 c=0
Rk76 (\10\:VSS VSS) resistor r=0.1952 c=0
Rk75 (\9\:VSS \10\:VSS) resistor r=0.2654 c=0
Rk77 (\3\:VSS \12\:VSS) resistor r=0.1995 c=0
Rk78 (\4\:VSS \14\:VSS) resistor r=0.2091 c=0
Rk79 (\6\:VSS \16\:VSS) resistor r=0.04331 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.2222 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.07393 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.07393 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1328 c=0
Rk4 (\6\:qint \8\:qint) resistor r=0.09313 c=0
Rk5 (\6\:qint \10\:qint) resistor r=0.1309 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.5286 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.09595 c=0
Rk11 (\13\:qbint \16\:qbint) resistor r=0.3845 c=0
Rk12 (\15\:qbint \17\:qbint) resistor r=0.665 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.5978 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8991 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3104 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=0.661 c=0
Rk33 (\15\:CKb \17\:CKb) resistor r=0.5176 c=0
Rk34 (\13\:CKb \18\:CKb) resistor r=0.2445 c=0
Rk35 (\14\:CKb \19\:CKb) resistor r=0.3498 c=0
Rk36 (\15\:CKb \21\:CKb) resistor r=0.08144 c=0
Rk14 (\5\:n30 \6\:n30) resistor r=0.6214 c=0
Rk15 (\5\:n30 \8\:n30) resistor r=0.3881 c=0
Rk17 (\4\:mout \5\:mout) resistor r=0.4455 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.405 c=0
Rk19 (\5\:mout \9\:mout) resistor r=0.05684 c=0
Rk24 (\10\:Ckbb \11\:Ckbb) resistor r=0.08701 c=0
Rk25 (\11\:Ckbb \12\:Ckbb) resistor r=0.4681 c=0
Rk26 (\10\:Ckbb \14\:Ckbb) resistor r=0.5517 c=0
Rk27 (\11\:Ckbb \15\:Ckbb) resistor r=0.1831 c=0
Rk28 (\12\:Ckbb \16\:Ckbb) resistor r=0.8746 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.2028 c=0
Rk22 (\7\:n20 \9\:n20) resistor r=0.2131 c=0
Rk23 (\7\:n20 \10\:n20) resistor r=0.5012 c=0
Rk38 (\2\:Db \3\:Db) resistor r=0.8212 c=0
Rk39 (\3\:Db \5\:Db) resistor r=0.8111 c=0
Rk40 (\5\:Db \7\:Db) resistor r=0.3734 c=0
Rk41 (\3\:Db \9\:Db) resistor r=0.1388 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.04795 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.5048 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.6954 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.2147 c=0
Rl27 (\5\:RN \6\:RN) resistor r=163.027 c=0
Rl28 (\6\:RN \7\:RN) resistor r=69.9225 c=0
Rl14 (\1\:RN \2\:RN) resistor r=69.9225 c=0
Rl15 (\2\:RN \3\:RN) resistor r=26.1806 c=0
Rl16 (\3\:RN \4\:RN) resistor r=87.7867 c=0
Rl46 (\5\:SE \6\:SE) resistor r=193 c=0
Rl47 (\6\:SE \7\:SE) resistor r=29.5379 c=0
Rl43 (\3\:SE \4\:SE) resistor r=81.461 c=0
Rl40 (\1\:SE \2\:SE) resistor r=66.4826 c=0
Rl44 (\1\:SI \2\:SI) resistor r=143.464 c=0
Rl45 (\2\:SI \3\:SI) resistor r=76.1559 c=0
Rl10 (\1\:CK \2\:CK) resistor r=130.002 c=0
Rl11 (\2\:CK \3\:CK) resistor r=101.156 c=0
Rl37 (\1\:D \2\:D) resistor r=191.187 c=0
Rl39 (\2\:D \4\:D) resistor r=46.9565 c=0
Rl38 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=80.7563 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=26.098 c=0
Rl4 (qbint \2\:qbint) resistor r=205.359 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=32.4355 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=7.2648 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=49.521 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=48.048 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=147.001 c=0
Rl35 (\8\:CKb \9\:CKb) resistor r=245.637 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=120.043 c=0
Rl36 (\9\:CKb \10\:CKb) resistor r=52.1723 c=0
Rl33 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl19 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl12 (n30 \2\:n30) resistor r=139.611 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=26.1559 c=0
Rl29 (mout \2\:mout) resistor r=89.6174 c=0
Rl30 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl34 (\7\:Ckbb \8\:Ckbb) resistor r=141.821 c=0
Rl31 (\5\:Ckbb \6\:Ckbb) resistor r=35.7713 c=0
Rl22 (\2\:Ckbb \3\:Ckbb) resistor r=141.851 c=0
Rl21 (Ckbb \2\:Ckbb) resistor r=32.3738 c=0
Rl23 (\2\:Ckbb \4\:Ckbb) resistor r=92.233 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=87.0953 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=49.7141 c=0
Rl24 (n20 \2\:n20) resistor r=11.5001 c=0
Rl41 (SEb \2\:SEb) resistor r=25.0391 c=0
Rl42 (\2\:SEb \3\:SEb) resistor r=195.65 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz14 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz15 (\3\:VDD \21\:VDD) resistor r=6.25 c=0
Rz16 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz19 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz21 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz2 (\7\:qint \8\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz9 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz8 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry19 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry22 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=10.3333 c=0
Ry24 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry25 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\9\:qint \10\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry11 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry10 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx5 (\3\:RN \8\:RN) resistor r=45 c=0
Rx7 (\7\:RN \9\:RN) resistor r=45 c=0
Rx8 (\1\:RN \10\:RN) resistor r=45 c=0
Rx20 (\6\:SE \8\:SE) resistor r=45 c=0
Rx21 (\2\:SE \10\:SE) resistor r=45 c=0
Rx22 (\4\:SE \11\:SE) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (qint \5\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \17\:qbint) resistor r=45 c=0
Rx14 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \18\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx6 (\3\:n30 \6\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\6\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx12 (\7\:Ckbb \15\:Ckbb) resistor r=45 c=0
Rx13 (\4\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx10 (n20 \10\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn56 (\7\:qint \4\:qbint \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.697e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.695e-14 ad=2.03e-14 ps=1.59e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.85e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn20 (\16\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.695e-14 ad=2.32e-14 ps=1.59e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.6e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn46 (\14\:qbint \2\:n30 n9 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.263e-14 ps=4.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn45 (n9 \4\:RN \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=8.7e-15 ps=9.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn50 (n11 \10\:qbint \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=8.7e-15 ps=9.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.87e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn51 (\4\:n30 CKb n11 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.765e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn40 (\8\:mout Ckbb \4\:n30 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=6.235e-14 ps=8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.465e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn30 (\8\:mout \4\:n20 \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.45e-14 ad=6.235e-14 ps=1.44e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=9.9e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n7 \5\:RN \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=8.7e-15 ps=1.44e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=7.25e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=1.958e-14 ps=4.1e-07 pd=5.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.845e-06 sb=6.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn37 (\5\:n20 \5\:Ckbb n5 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn25 (\6\:Db \5\:CKb \5\:n20 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.408e-14 ps=6.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn21 (\9\:Ckbb \8\:CKb \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.395e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn11 (n1 \4\:D \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.205e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.19e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=8.55e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 as=1.16e-14 \
        ad=2.32e-14 ps=4.5e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.05e-07 sb=6.5e-07 sd=160n sca=7.37439 scb=0.00450456 \
        scc=4.82709e-05 m=(1)
mn13 (n3 \3\:SI \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=1.16e-14 ps=9.7e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=5.25e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn10 (\8\:SEb \7\:SE \11\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
ends SDFFRXL
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:47 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX1 CK D Q SE SI SN VDD VSS
mp55 (\1\:Q \3\:qbint \28\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.8e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23077e-07 sd=160n sca=34.9044 \
        scb=0.0259128 scc=0.00343869 m=(1)
mp11 (net390 \1\:D \8\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.248e-13 ps=1.16e-06 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=7.87308e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\6\:Db \3\:SE net390 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=6.24e-14 ps=1.42e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.34551e-07 sb=4.22308e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\6\:Db \3\:SEb net398 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.39551e-07 sb=2.17308e-07 sd=160n sca=13.5765 \
        scb=0.0121847 scc=0.000647513 m=(1)
mp13 (net398 \1\:SI \5\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.44551e-07 sb=1.12308e-07 sd=160n sca=13.8119 \
        scb=0.0122457 scc=0.000647522 m=(1)
C1 (D VSS) capacitor c=5.88872e-17
C2 (Q VSS) capacitor c=3.91174e-17
C3 (CK VSS) capacitor c=4.66852e-17
C4 (SE VSS) capacitor c=9.34148e-17
C5 (SN VSS) capacitor c=1.49038e-16
C6 (SI VSS) capacitor c=7.24525e-17
C7 (VDD VSS) capacitor c=3.44773e-16
C8 (qbint VSS) capacitor c=2.30889e-17
C9 (n30 VSS) capacitor c=3.6891e-17
C10 (net459 VSS) capacitor c=2.23493e-18
C11 (net467 VSS) capacitor c=1.76019e-18
C12 (CKb VSS) capacitor c=4.27708e-17
C13 (mout VSS) capacitor c=5.2055e-17
C14 (CKbb VSS) capacitor c=5.0052e-17
C15 (n20 VSS) capacitor c=1.77838e-17
C16 (net427 VSS) capacitor c=1.82309e-18
C17 (Db VSS) capacitor c=4.34767e-17
C18 (net443 VSS) capacitor c=5.17867e-18
C19 (SEb VSS) capacitor c=4.11859e-17
C20 (net455 VSS) capacitor c=2.6916e-18
C21 (net355 VSS) capacitor c=6.37152e-17
C22 (net378 VSS) capacitor c=1.94844e-18
C23 (net390 VSS) capacitor c=7.41841e-18
C24 (net398 VSS) capacitor c=1.65861e-18
C25 (\4\:SE VSS) capacitor c=2.91345e-17
C26 (\1\:SI VSS) capacitor c=7.31794e-17
C27 (\3\:SEb VSS) capacitor c=7.13102e-17
C28 (\3\:SE VSS) capacitor c=5.28274e-17
C29 (\1\:D VSS) capacitor c=5.57951e-17
C30 (\1\:CK VSS) capacitor c=3.5424e-17
C31 (\7\:CKb VSS) capacitor c=2.25241e-17
C32 (\4\:CKbb VSS) capacitor c=2.23745e-17
C33 (\5\:CKb VSS) capacitor c=5.39062e-17
C34 (\3\:mout VSS) capacitor c=7.86687e-17
C35 (\4\:n20 VSS) capacitor c=4.11907e-17
C36 (\5\:SN VSS) capacitor c=3.94846e-17
C37 (\4\:CKb VSS) capacitor c=5.99704e-17
C38 (\4\:qbint VSS) capacitor c=5.95689e-17
C39 (\1\:SN VSS) capacitor c=4.0552e-17
C40 (\3\:n30 VSS) capacitor c=6.09592e-17
C41 (\3\:qbint VSS) capacitor c=3.21415e-17
C42 (\6\:SE VSS) capacitor c=2.13407e-17
C43 (\3\:SI VSS) capacitor c=6.07582e-17
C44 (\1\:SE VSS) capacitor c=4.74715e-17
C45 (\4\:D VSS) capacitor c=4.74624e-17
C46 (\3\:CK VSS) capacitor c=5.58182e-17
C47 (\12\:CKb VSS) capacitor c=1.47828e-17
C48 (\11\:CKb VSS) capacitor c=2.52375e-17
C49 (\6\:CKbb VSS) capacitor c=9.49699e-17
C50 (\3\:n20 VSS) capacitor c=6.81676e-17
C51 (\8\:SN VSS) capacitor c=6.68929e-17
C52 (\2\:CKbb VSS) capacitor c=4.5712e-17
C53 (\6\:qbint VSS) capacitor c=4.324e-17
C54 (\4\:SN VSS) capacitor c=6.44756e-17
C55 (\5\:SE VSS) capacitor c=2.26956e-17
C56 (\2\:SI VSS) capacitor c=5.91823e-17
C57 (\4\:SEb VSS) capacitor c=4.5037e-17
C58 (\2\:SE VSS) capacitor c=7.101e-17
C59 (\2\:SEb VSS) capacitor c=4.18882e-17
C60 (\3\:D VSS) capacitor c=2.79765e-17
C61 (\2\:CK VSS) capacitor c=3.87226e-17
C62 (\7\:CKbb VSS) capacitor c=1.2852e-17
C63 (\10\:CKb VSS) capacitor c=4.49209e-17
C64 (\6\:CKb VSS) capacitor c=4.59271e-17
C65 (\2\:mout VSS) capacitor c=5.51251e-17
C66 (\7\:SN VSS) capacitor c=4.37988e-17
C67 (\3\:CKb VSS) capacitor c=4.00918e-17
C68 (\3\:CKbb VSS) capacitor c=2.69588e-17
C69 (\2\:CKb VSS) capacitor c=4.04424e-17
C70 (\5\:qbint VSS) capacitor c=5.76553e-17
C71 (\3\:SN VSS) capacitor c=3.39318e-17
C72 (\2\:n30 VSS) capacitor c=5.19368e-17
C73 (\2\:qbint VSS) capacitor c=1.7022e-17
C74 (\1\:VDD VSS) capacitor c=1.21669e-17
C75 (\9\:SEb VSS) capacitor c=7.93699e-17
C76 (\5\:VDD VSS) capacitor c=2.86947e-17
C77 (\6\:Db VSS) capacitor c=1.09323e-16
C78 (\8\:VDD VSS) capacitor c=3.97673e-17
C79 (\23\:CKb VSS) capacitor c=7.9432e-17
C80 (\11\:VDD VSS) capacitor c=6.52106e-17
C81 (\10\:CKbb VSS) capacitor c=9.44957e-17
C82 (\8\:Db VSS) capacitor c=1.22749e-16
C83 (\7\:n20 VSS) capacitor c=1.08254e-16
C84 (\15\:VDD VSS) capacitor c=2.88006e-17
C85 (\12\:mout VSS) capacitor c=5.84144e-17
C86 (\18\:VDD VSS) capacitor c=2.35275e-17
C87 (\14\:mout VSS) capacitor c=3.5681e-17
C88 (\8\:n30 VSS) capacitor c=3.98641e-17
C89 (\21\:VDD VSS) capacitor c=1.39684e-17
C90 (\3\:net355 VSS) capacitor c=6.99263e-17
C91 (\25\:VDD VSS) capacitor c=1.37502e-17
C92 (\11\:qbint VSS) capacitor c=6.20582e-17
C93 (\1\:Q VSS) capacitor c=2.08298e-17
C94 (\28\:VDD VSS) capacitor c=3.21825e-17
C95 (\3\:VDD VSS) capacitor c=8.88707e-17
C96 (\5\:SEb VSS) capacitor c=1.14949e-16
C97 (\19\:CKb VSS) capacitor c=5.66474e-17
C98 (\13\:CKbb VSS) capacitor c=5.74554e-17
C99 (\4\:Db VSS) capacitor c=2.14563e-16
C100 (\5\:n20 VSS) capacitor c=9.5838e-17
C101 (\10\:mout VSS) capacitor c=3.38797e-17
C102 (\8\:mout VSS) capacitor c=5.96934e-17
C103 (\4\:n30 VSS) capacitor c=6.75504e-17
C104 (\9\:qbint VSS) capacitor c=6.40479e-17
C105 (\4\:Q VSS) capacitor c=5.09471e-17
C106 (\2\:SN VSS) capacitor c=3.30105e-17
C107 (\2\:n20 VSS) capacitor c=4.20735e-17
C108 (\5\:CKbb VSS) capacitor c=3.67422e-17
C109 (\9\:CKb VSS) capacitor c=2.94712e-17
C110 (\2\:D VSS) capacitor c=2.74171e-17
C111 (\3\:Q VSS) capacitor c=2.32031e-17
C112 (\7\:qbint VSS) capacitor c=7.12586e-17
C113 (\8\:qbint VSS) capacitor c=7.72901e-17
C114 (\13\:qbint VSS) capacitor c=7.26154e-17
C115 (\6\:n30 VSS) capacitor c=9.64694e-17
C116 (\7\:n30 VSS) capacitor c=9.98037e-17
C117 (\9\:SN VSS) capacitor c=2.2152e-17
C118 (\10\:SN VSS) capacitor c=1.78873e-16
C119 (\4\:mout VSS) capacitor c=4.66176e-17
C120 (\6\:mout VSS) capacitor c=6.82045e-17
C121 (\7\:mout VSS) capacitor c=6.16454e-17
C122 (\9\:n20 VSS) capacitor c=7.33189e-17
C123 (\13\:CKb VSS) capacitor c=1.13205e-16
C124 (\14\:CKb VSS) capacitor c=1.93248e-16
C125 (\15\:CKb VSS) capacitor c=1.43839e-16
C126 (\16\:CKb VSS) capacitor c=1.05029e-16
C127 (\17\:CKb VSS) capacitor c=5.01987e-17
C128 (\18\:CKb VSS) capacitor c=3.40016e-17
C129 (\8\:CKbb VSS) capacitor c=7.63299e-17
C130 (\9\:CKbb VSS) capacitor c=1.87442e-16
C131 (\12\:CKbb VSS) capacitor c=1.49945e-16
C132 (\21\:CKb VSS) capacitor c=6.62043e-17
C133 (\22\:CKb VSS) capacitor c=2.28854e-17
C134 (\4\:CK VSS) capacitor c=8.56792e-17
C135 (\5\:D VSS) capacitor c=4.3805e-17
C136 (\3\:Db VSS) capacitor c=2.58932e-16
C137 (\4\:SI VSS) capacitor c=3.742e-17
C138 (\7\:SEb VSS) capacitor c=1.46552e-16
C139 (\8\:SEb VSS) capacitor c=1.18907e-16
C140 (\7\:SE VSS) capacitor c=1.14557e-16
C141 (\7\:VDD VSS) capacitor c=2.20836e-17
C142 (\10\:VDD VSS) capacitor c=2.73677e-17
C143 (\14\:VDD VSS) capacitor c=3.23674e-17
C144 (\17\:VDD VSS) capacitor c=3.14422e-17
C145 (\20\:VDD VSS) capacitor c=2.47622e-17
C146 (\24\:VDD VSS) capacitor c=9.76404e-18
C147 (\27\:VDD VSS) capacitor c=7.91302e-18
Rk36 (D \5\:D) resistor r=0.0269 c=0
Rk3 (\3\:Q Q) resistor r=0.08203 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.08182 c=0
Rk2 (\3\:Q \5\:Q) resistor r=0.1375 c=0
Rk66 (\2\:VSS \4\:VSS) resistor r=0.6318 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.4017 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.4025 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.197 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=0.2958 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.3307 c=0
Rk72 (\9\:VSS \10\:VSS) resistor r=0.5767 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.04495 c=0
Rk75 (\12\:VSS VSS) resistor r=0.0151 c=0
Rk74 (\11\:VSS \12\:VSS) resistor r=0.4912 c=0
Rk76 (\4\:VSS \14\:VSS) resistor r=0.2376 c=0
Rk77 (\5\:VSS \16\:VSS) resistor r=0.1879 c=0
Rk78 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk79 (\8\:VSS \20\:VSS) resistor r=0.2752 c=0
Rk80 (\9\:VSS \22\:VSS) resistor r=0.1276 c=0
Rk81 (\11\:VSS \24\:VSS) resistor r=0.2601 c=0
Rk82 (\12\:VSS \26\:VSS) resistor r=0.285 c=0
Rk35 (CK \4\:CK) resistor r=0.06218 c=0
Rk45 (\7\:SE SE) resistor r=0.4738 c=0
Rk46 (SE \8\:SE) resistor r=0.01427 c=0
Rk12 (\9\:SN SN) resistor r=0.07197 c=0
Rk13 (SN \10\:SN) resistor r=1.2748 c=0
Rk41 (SI \4\:SI) resistor r=0.06296 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.65 c=0
Rk48 (\4\:VDD \6\:VDD) resistor r=0.271 c=0
Rk49 (\4\:VDD \7\:VDD) resistor r=0.4162 c=0
Rk50 (\7\:VDD \9\:VDD) resistor r=0.2832 c=0
Rk51 (\7\:VDD \10\:VDD) resistor r=0.3382 c=0
Rk52 (\10\:VDD \12\:VDD) resistor r=0.4529 c=0
Rk53 (\10\:VDD \13\:VDD) resistor r=0.2481 c=0
Rk54 (\13\:VDD \14\:VDD) resistor r=0.3626 c=0
Rk55 (\14\:VDD \16\:VDD) resistor r=0.04332 c=0
Rk56 (\14\:VDD \17\:VDD) resistor r=0.251 c=0
Rk57 (\17\:VDD \19\:VDD) resistor r=0.04332 c=0
Rk58 (\17\:VDD \20\:VDD) resistor r=0.394 c=0
Rk59 (\20\:VDD \22\:VDD) resistor r=0.04332 c=0
Rk60 (\20\:VDD \23\:VDD) resistor r=0.1895 c=0
Rk61 (\23\:VDD \24\:VDD) resistor r=0.044 c=0
Rk62 (\24\:VDD \26\:VDD) resistor r=0.04332 c=0
Rk65 (\27\:VDD VDD) resistor r=0.08483 c=0
Rk63 (\24\:VDD \27\:VDD) resistor r=0.42 c=0
Rk64 (\27\:VDD \29\:VDD) resistor r=0.3852 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.4185 c=0
Rk5 (\8\:qbint \10\:qbint) resistor r=0.0632 c=0
Rk6 (\8\:qbint \12\:qbint) resistor r=0.3929 c=0
Rk7 (\10\:qbint \13\:qbint) resistor r=0.6428 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.2753 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.6455 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.1578 c=0
Rk23 (\13\:CKb \14\:CKb) resistor r=0.7225 c=0
Rk24 (\14\:CKb \15\:CKb) resistor r=0.7874 c=0
Rk25 (\15\:CKb \16\:CKb) resistor r=0.7368 c=0
Rk26 (\14\:CKb \17\:CKb) resistor r=0.2372 c=0
Rk27 (\15\:CKb \18\:CKb) resistor r=0.1246 c=0
Rk32 (\20\:CKb \21\:CKb) resistor r=0.2855 c=0
Rk33 (\21\:CKb \22\:CKb) resistor r=0.135 c=0
Rk34 (\21\:CKb \24\:CKb) resistor r=0.5006 c=0
Rk14 (\4\:mout \5\:mout) resistor r=0.2213 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.05931 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.3259 c=0
Rk17 (\7\:mout \9\:mout) resistor r=0.3117 c=0
Rk18 (\5\:mout \11\:mout) resistor r=0.1012 c=0
Rk19 (\6\:mout \13\:mout) resistor r=0.2547 c=0
Rk20 (\7\:mout \15\:mout) resistor r=0.1196 c=0
Rk28 (\8\:CKbb \9\:CKbb) resistor r=0.3224 c=0
Rk29 (\9\:CKbb \11\:CKbb) resistor r=0.6265 c=0
Rk30 (\9\:CKbb \12\:CKbb) resistor r=1.0964 c=0
Rk31 (\11\:CKbb \14\:CKbb) resistor r=0.2948 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.4863 c=0
Rk22 (\8\:n20 \9\:n20) resistor r=0.4589 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.2547 c=0
Rk38 (\3\:Db \5\:Db) resistor r=1.1126 c=0
Rk39 (\3\:Db \7\:Db) resistor r=0.8681 c=0
Rk40 (\5\:Db \9\:Db) resistor r=0.6024 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.8008 c=0
Rk43 (\7\:SEb \8\:SEb) resistor r=0.3798 c=0
Rk44 (\8\:SEb \10\:SEb) resistor r=0.6659 c=0
Rk8 (\2\:net355 \4\:net355) resistor r=0.2136 c=0
Rl33 (\1\:D \2\:D) resistor r=134.329 c=0
Rl35 (\2\:D \4\:D) resistor r=49.7141 c=0
Rl34 (\2\:D \3\:D) resistor r=8.3038 c=0
Rl31 (\1\:CK \2\:CK) resistor r=26.911 c=0
Rl32 (\2\:CK \3\:CK) resistor r=132.487 c=0
Rl42 (\4\:SE \5\:SE) resistor r=74.2328 c=0
Rl43 (\5\:SE \6\:SE) resistor r=30.0021 c=0
Rl38 (\2\:SE \3\:SE) resistor r=125.789 c=0
Rl37 (\1\:SE \2\:SE) resistor r=43.4636 c=0
Rl5 (\1\:SN \2\:SN) resistor r=37.3411 c=0
Rl7 (\2\:SN \4\:SN) resistor r=135.418 c=0
Rl6 (\2\:SN \3\:SN) resistor r=10.9341 c=0
Rl14 (\5\:SN \6\:SN) resistor r=49.7185 c=0
Rl16 (\6\:SN \8\:SN) resistor r=111.257 c=0
Rl15 (\6\:SN \7\:SN) resistor r=3.3229 c=0
Rl40 (\1\:SI \2\:SI) resistor r=41.0764 c=0
Rl41 (\2\:SI \3\:SI) resistor r=144.488 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=131.81 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=26.3736 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=39.6174 c=0
Rl1 (qbint \2\:qbint) resistor r=24.2328 c=0
Rl4 (\2\:n30 \3\:n30) resistor r=116.862 c=0
Rl3 (n30 \2\:n30) resistor r=53.079 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=55.0021 c=0
Rl29 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=47.3097 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=122.977 c=0
Rl10 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl30 (\9\:CKb \12\:CKb) resistor r=23.4163 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=12.6847 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=157.901 c=0
Rl21 (\2\:mout \3\:mout) resistor r=97.872 c=0
Rl20 (mout \2\:mout) resistor r=92.2849 c=0
Rl11 (CKbb \2\:CKbb) resistor r=126.923 c=0
Rl12 (CKbb \3\:CKbb) resistor r=64.1533 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=23.7402 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=197.951 c=0
Rl25 (\5\:CKbb \7\:CKbb) resistor r=5.1011 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=152.291 c=0
Rl17 (n20 \2\:n20) resistor r=0.6084 c=0
Rl39 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl36 (SEb \2\:SEb) resistor r=49.2328 c=0
Rz1 (\4\:Q \5\:Q) resistor r=75 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz20 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz21 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz22 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\3\:VDD \13\:VDD) resistor r=6.25 c=0
Rz14 (\3\:VDD \23\:VDD) resistor r=6.25 c=0
Rz2 (\9\:qbint \10\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz8 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\10\:mout \11\:mout) resistor r=75 c=0
Rz7 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\4\:Db \5\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry24 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry25 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry17 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry22 (\28\:VDD \29\:VDD) resistor r=20.6667 c=0
Ry2 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry10 (\23\:CKb \24\:CKb) resistor r=62 c=0
Ry6 (\12\:mout \13\:mout) resistor r=62 c=0
Ry7 (\14\:mout \15\:mout) resistor r=62 c=0
Ry9 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry8 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\8\:Db \9\:Db) resistor r=62 c=0
Ry13 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry3 (net355 \2\:net355) resistor r=62 c=0
Ry4 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\2\:SE \7\:SE) resistor r=45 c=0
Rx21 (\5\:SE \8\:SE) resistor r=45 c=0
Rx4 (\3\:SN \9\:SN) resistor r=45 c=0
Rx5 (\7\:SN \10\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\5\:qbint \7\:qbint) resistor r=45 c=0
Rx2 (\2\:qbint \13\:qbint) resistor r=45 c=0
Rx3 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx11 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \22\:CKb) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx7 (n20 \9\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx19 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn55 (\4\:Q qbint \25\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=4.94e-14 ps=1.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.9e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn11 (net443 \4\:D \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.29e-14 ps=9.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn12 (Db SEb net443 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.61923e-07 sb=5.1e-07 sd=160n sca=8.51051 scb=0.00656948 \
        scc=0.000151659 m=(1)
mn14 (Db \1\:SE net455 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.66923e-07 sb=3.05e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn13 (net455 \3\:SI \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.12e-14 ps=8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.31923e-07 sb=1.4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn45 (\9\:qbint n30 \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn50 (net459 \4\:SN \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.152e-14 ps=7.3e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.95e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn51 (net467 \6\:qbint net459 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.153e-14 ad=2.768e-14 ps=6.2e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=6.45e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn52 (\4\:n30 CKb net467 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.65e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn40 (\4\:n30 \2\:CKbb \8\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=5.432e-14 ps=7.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=1.55e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn30 (net435 \8\:SN \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.23e-14 ps=1.34e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2.45e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net427 mout \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=1.435e-14 ps=6.9e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn36 (\5\:n20 \6\:CKbb net427 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=3.69e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn25 (\5\:n20 \11\:CKb \4\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=3.69e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.35e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn21 (\13\:CKbb \12\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.48e-14 ad=2.03e-14 ps=1.45e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn20 (\19\:CKb \3\:CK \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=3.988e-14 ps=9.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=9.65e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp45 (\11\:qbint \3\:n30 \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.012e-13 ad=4.34e-14 ps=1.61e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.7e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp50 (\3\:net355 \1\:SN \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.012e-13 ad=4.96e-14 ps=1.61e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.05e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp51 (\3\:net355 \4\:qbint \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.315e-14 ad=4.96e-14 ps=1.51e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1e-07 sd=160n sca=12.9031 scb=0.0116454 \
        scc=0.000496931 m=(1)
mp52 (\8\:n30 CKbb net355 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.52e-14 ad=4.96e-14 ps=1.04e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78065e-07 sb=3.20484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\8\:n30 \4\:CKb \14\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83065e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \5\:SN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.045e-14 ps=1.46e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.14339e-06 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp31 (\12\:mout \4\:n20 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.82e-14 ad=6.045e-14 ps=1.56e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=9.03387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp35 (net378 \3\:mout \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.82e-14 ad=2.48e-14 ps=1.56e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=6.38387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp36 (\7\:n20 \5\:CKb net378 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=7.905e-14 ps=7.8e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=5.13387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp25 (\7\:n20 \4\:CKbb \8\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.615e-14 ad=7.905e-14 ps=1.19e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=2.13387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp21 (\10\:CKbb \7\:CKb \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.333e-14 ad=4.97e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.31163e-07 sb=1.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\23\:CKb \1\:CK \8\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp10 (\9\:SEb \4\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=3.01e-14 ps=1.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=56.5915 scb=0.0440321 \
        scc=0.00674534 m=(1)
ends SDFFSHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:48 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX2 CK D Q SE SI SN VDD VSS
mp11 (net390 \1\:D \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0082e-13 ad=5.07e-14 ps=1.49e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60513e-07 sb=6.62308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp12 (Db \3\:SE net390 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=8.775e-14 ps=1.04e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.35513e-07 sb=4.87308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp14 (Db \3\:SEb net398 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.775e-14 ps=9e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05513e-07 sb=2.17308e-07 sd=160n sca=15.9046 \
        scb=0.0140803 scc=0.00102275 m=(1)
mp13 (net398 \1\:SI \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.10513e-07 sb=1.12308e-07 sd=160n sca=16.3434 \
        scb=0.0143715 scc=0.00102303 m=(1)
mp55 (\1\:Q qbint \27\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.998e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.19615e-07 sd=160n sca=35.0309 \
        scb=0.0261374 scc=0.00344587 m=(2)
C1 (D VSS) capacitor c=5.29578e-17
C2 (Q VSS) capacitor c=2.63499e-17
C3 (VDD VSS) capacitor c=3.40445e-16
C4 (CK VSS) capacitor c=3.8702e-17
C5 (SN VSS) capacitor c=1.84821e-16
C6 (SI VSS) capacitor c=8.02379e-17
C7 (qbint VSS) capacitor c=1.40635e-16
C8 (n30 VSS) capacitor c=5.23765e-17
C9 (net459 VSS) capacitor c=2.63748e-18
C10 (net467 VSS) capacitor c=1.87807e-18
C11 (CKb VSS) capacitor c=4.52896e-17
C12 (mout VSS) capacitor c=5.12983e-17
C13 (CKbb VSS) capacitor c=5.1398e-17
C14 (net435 VSS) capacitor c=3.39619e-19
C15 (n20 VSS) capacitor c=4.91548e-17
C16 (net427 VSS) capacitor c=1.92109e-18
C17 (Db VSS) capacitor c=1.1167e-16
C18 (net443 VSS) capacitor c=1.81971e-18
C19 (SEb VSS) capacitor c=6.68262e-17
C20 (net455 VSS) capacitor c=4.80003e-18
C21 (net355 VSS) capacitor c=7.8405e-17
C22 (net378 VSS) capacitor c=4.33373e-18
C23 (net390 VSS) capacitor c=4.1468e-18
C24 (net398 VSS) capacitor c=1.95393e-18
C25 (\8\:SE VSS) capacitor c=3.4574e-17
C26 (\1\:SI VSS) capacitor c=7.3495e-17
C27 (\3\:SEb VSS) capacitor c=6.52087e-17
C28 (\3\:SE VSS) capacitor c=5.99551e-17
C29 (\1\:D VSS) capacitor c=5.27788e-17
C30 (\1\:CK VSS) capacitor c=2.67583e-17
C31 (\12\:CKb VSS) capacitor c=2.40208e-17
C32 (\4\:CKbb VSS) capacitor c=3.15583e-17
C33 (\5\:CKb VSS) capacitor c=4.87043e-17
C34 (\4\:mout VSS) capacitor c=6.52329e-17
C35 (\5\:SN VSS) capacitor c=4.06403e-17
C36 (\4\:CKb VSS) capacitor c=6.19004e-17
C37 (\9\:qbint VSS) capacitor c=5.80743e-17
C38 (\1\:SN VSS) capacitor c=3.36685e-17
C39 (\7\:SE VSS) capacitor c=2.45497e-17
C40 (\3\:SI VSS) capacitor c=5.37251e-17
C41 (\4\:SE VSS) capacitor c=4.14574e-17
C42 (\4\:D VSS) capacitor c=7.1203e-17
C43 (\3\:CK VSS) capacitor c=3.778e-17
C44 (\7\:CKb VSS) capacitor c=1.75142e-17
C45 (\11\:CKb VSS) capacitor c=2.24303e-17
C46 (\6\:CKbb VSS) capacitor c=7.52173e-17
C47 (\3\:n20 VSS) capacitor c=7.76901e-17
C48 (\7\:SN VSS) capacitor c=6.98078e-17
C49 (\2\:CKbb VSS) capacitor c=4.37712e-17
C50 (\11\:qbint VSS) capacitor c=4.65681e-17
C51 (\4\:SN VSS) capacitor c=5.67273e-17
C52 (\3\:n30 VSS) capacitor c=3.54965e-17
C53 (\5\:SE VSS) capacitor c=1.53897e-17
C54 (\2\:SI VSS) capacitor c=5.5495e-17
C55 (\4\:SEb VSS) capacitor c=3.98124e-17
C56 (\1\:SE VSS) capacitor c=3.58581e-17
C57 (\2\:SEb VSS) capacitor c=4.73597e-17
C58 (\3\:D VSS) capacitor c=3.49529e-17
C59 (\2\:CK VSS) capacitor c=4.47669e-17
C60 (\10\:CKb VSS) capacitor c=3.90015e-17
C61 (\5\:CKbb VSS) capacitor c=4.31262e-17
C62 (\6\:CKb VSS) capacitor c=4.90181e-17
C63 (\3\:mout VSS) capacitor c=1.77446e-17
C64 (\2\:n20 VSS) capacitor c=6.06074e-17
C65 (\6\:SN VSS) capacitor c=5.19323e-17
C66 (\3\:CKb VSS) capacitor c=4.26894e-17
C67 (\3\:CKbb VSS) capacitor c=2.72914e-17
C68 (\2\:CKb VSS) capacitor c=4.28918e-17
C69 (\10\:qbint VSS) capacitor c=5.30469e-17
C70 (\3\:SN VSS) capacitor c=2.38004e-17
C71 (\4\:n30 VSS) capacitor c=3.7446e-17
C72 (\6\:qbint VSS) capacitor c=2.24367e-17
C73 (\1\:VDD VSS) capacitor c=3.28119e-17
C74 (\10\:SEb VSS) capacitor c=8.45943e-17
C75 (\13\:VDD VSS) capacitor c=2.77711e-17
C76 (\15\:VDD VSS) capacitor c=6.11299e-17
C77 (\22\:CKb VSS) capacitor c=7.29473e-17
C78 (\17\:VDD VSS) capacitor c=6.76547e-17
C79 (\10\:CKbb VSS) capacitor c=1.04989e-16
C80 (\6\:Db VSS) capacitor c=1.18822e-16
C81 (\4\:n20 VSS) capacitor c=3.96176e-17
C82 (\19\:VDD VSS) capacitor c=1.86511e-17
C83 (\13\:mout VSS) capacitor c=5.70336e-17
C84 (\21\:VDD VSS) capacitor c=1.99312e-17
C85 (\15\:mout VSS) capacitor c=2.70037e-17
C86 (\7\:n30 VSS) capacitor c=6.19422e-17
C87 (\23\:VDD VSS) capacitor c=1.1498e-17
C88 (\3\:net355 VSS) capacitor c=7.87767e-17
C89 (\25\:VDD VSS) capacitor c=9.79775e-18
C90 (\17\:qbint VSS) capacitor c=6.49483e-17
C91 (\1\:Q VSS) capacitor c=9.20826e-17
C92 (\4\:VDD VSS) capacitor c=6.37141e-17
C93 (\8\:SEb VSS) capacitor c=9.85662e-17
C94 (\8\:Db VSS) capacitor c=4.23144e-17
C95 (\18\:CKb VSS) capacitor c=8.03194e-17
C96 (\12\:CKbb VSS) capacitor c=6.41608e-17
C97 (\4\:Db VSS) capacitor c=1.99635e-16
C98 (\8\:n20 VSS) capacitor c=8.32121e-17
C99 (\11\:mout VSS) capacitor c=5.43357e-17
C100 (\9\:mout VSS) capacitor c=6.31458e-17
C101 (\9\:n30 VSS) capacitor c=7.07719e-17
C102 (\13\:qbint VSS) capacitor c=7.67654e-17
C103 (\4\:Q VSS) capacitor c=1.1876e-17
C104 (\2\:n30 VSS) capacitor c=3.59063e-17
C105 (\2\:SN VSS) capacitor c=2.79941e-17
C106 (\2\:mout VSS) capacitor c=4.31512e-17
C107 (\9\:CKb VSS) capacitor c=2.42316e-17
C108 (\2\:D VSS) capacitor c=3.72314e-17
C109 (\3\:Q VSS) capacitor c=2.20301e-17
C110 (\2\:SE VSS) capacitor c=5.63567e-17
C111 (\6\:SE VSS) capacitor c=1.42305e-17
C112 (\12\:qbint VSS) capacitor c=8.11808e-17
C113 (\15\:qbint VSS) capacitor c=3.28239e-17
C114 (\16\:qbint VSS) capacitor c=2.91872e-17
C115 (\5\:n30 VSS) capacitor c=1.13745e-16
C116 (\6\:n30 VSS) capacitor c=1.1092e-16
C117 (\9\:SN VSS) capacitor c=2.04698e-16
C118 (\5\:mout VSS) capacitor c=4.13086e-17
C119 (\7\:mout VSS) capacitor c=8.53503e-17
C120 (\8\:mout VSS) capacitor c=7.08672e-17
C121 (\6\:n20 VSS) capacitor c=8.36992e-17
C122 (\7\:n20 VSS) capacitor c=6.43714e-17
C123 (\13\:CKb VSS) capacitor c=1.0808e-16
C124 (\14\:CKb VSS) capacitor c=2.00808e-16
C125 (\15\:CKb VSS) capacitor c=2.56147e-16
C126 (\16\:CKb VSS) capacitor c=1.48657e-16
C127 (\17\:CKb VSS) capacitor c=4.22448e-17
C128 (\7\:CKbb VSS) capacitor c=5.78912e-17
C129 (\8\:CKbb VSS) capacitor c=1.69929e-16
C130 (\9\:CKbb VSS) capacitor c=1.85398e-16
C131 (\20\:CKb VSS) capacitor c=7.64401e-17
C132 (\21\:CKb VSS) capacitor c=2.72184e-17
C133 (\4\:CK VSS) capacitor c=7.79089e-17
C134 (\5\:D VSS) capacitor c=6.69652e-17
C135 (\3\:Db VSS) capacitor c=2.35149e-16
C136 (\5\:SEb VSS) capacitor c=2.19109e-17
C137 (\6\:SEb VSS) capacitor c=7.8353e-17
C138 (\7\:SEb VSS) capacitor c=9.75325e-17
C139 (\4\:SI VSS) capacitor c=4.68195e-17
C140 (\9\:SE VSS) capacitor c=8.61384e-17
C141 (\10\:SE VSS) capacitor c=9.99832e-17
C142 (\3\:VDD VSS) capacitor c=1.39465e-17
C143 (\6\:VDD VSS) capacitor c=1.99923e-17
C144 (\7\:VDD VSS) capacitor c=3.01125e-17
C145 (\9\:VDD VSS) capacitor c=2.19016e-17
C146 (\10\:VDD VSS) capacitor c=3.06811e-17
C147 (\11\:VDD VSS) capacitor c=2.68916e-17
C148 (\27\:VDD VSS) capacitor c=1.5213e-16
Rk36 (\5\:D D) resistor r=0.1605 c=0
Rk69 (\2\:VSS \3\:VSS) resistor r=0.5113 c=0
Rk70 (\3\:VSS \5\:VSS) resistor r=0.1152 c=0
Rk71 (\5\:VSS \6\:VSS) resistor r=0.2633 c=0
Rk72 (\6\:VSS \7\:VSS) resistor r=0.3976 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.3401 c=0
Rk74 (\8\:VSS \9\:VSS) resistor r=0.2281 c=0
Rk75 (\9\:VSS \10\:VSS) resistor r=0.3509 c=0
Rk76 (\10\:VSS \11\:VSS) resistor r=0.6246 c=0
Rk77 (\11\:VSS \12\:VSS) resistor r=0.03744 c=0
Rk80 (\13\:VSS VSS) resistor r=0.08235 c=0
Rk78 (\12\:VSS \13\:VSS) resistor r=0.2129 c=0
Rk81 (\3\:VSS \16\:VSS) resistor r=0.1917 c=0
Rk82 (\6\:VSS \18\:VSS) resistor r=0.1884 c=0
Rk83 (\7\:VSS \20\:VSS) resistor r=0.04334 c=0
Rk84 (\9\:VSS \22\:VSS) resistor r=0.2977 c=0
Rk85 (\10\:VSS \24\:VSS) resistor r=0.2925 c=0
Rk86 (\12\:VSS \26\:VSS) resistor r=0.2205 c=0
Rk2 (\3\:Q Q) resistor r=0.07426 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.2624 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.06087 c=0
Rk48 (\2\:VDD \3\:VDD) resistor r=0.6599 c=0
Rk49 (\3\:VDD \5\:VDD) resistor r=0.1152 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.2633 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.4337 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.3059 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.2999 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.2336 c=0
Rk55 (\10\:VDD \11\:VDD) resistor r=0.4519 c=0
Rk56 (\11\:VDD \12\:VDD) resistor r=0.2121 c=0
Rk57 (\3\:VDD \14\:VDD) resistor r=0.2454 c=0
Rk58 (\6\:VDD \16\:VDD) resistor r=0.336 c=0
Rk59 (\7\:VDD \18\:VDD) resistor r=0.4615 c=0
Rk60 (\9\:VDD \20\:VDD) resistor r=0.04334 c=0
Rk61 (\10\:VDD \22\:VDD) resistor r=0.04334 c=0
Rk62 (\11\:VDD \24\:VDD) resistor r=0.04334 c=0
Rk63 (\12\:VDD \26\:VDD) resistor r=0.07151 c=0
Rk68 (\27\:VDD VDD) resistor r=0.08235 c=0
Rk64 (\12\:VDD \27\:VDD) resistor r=0.2643 c=0
Rk35 (CK \4\:CK) resistor r=0.03865 c=0
Rk46 (SE \9\:SE) resistor r=0.005081 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.4235 c=0
Rk12 (SN \8\:SN) resistor r=0.02276 c=0
Rk13 (\8\:SN \9\:SN) resistor r=1.4232 c=0
Rk45 (SI \4\:SI) resistor r=0.07182 c=0
Rk4 (\12\:qbint \14\:qbint) resistor r=0.5082 c=0
Rk5 (\14\:qbint \15\:qbint) resistor r=0.182 c=0
Rk6 (\15\:qbint \16\:qbint) resistor r=0.1523 c=0
Rk7 (\15\:qbint \18\:qbint) resistor r=0.2507 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.6647 c=0
Rk10 (\6\:n30 \8\:n30) resistor r=0.2376 c=0
Rk11 (\6\:n30 \10\:n30) resistor r=0.2901 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.719 c=0
Rk25 (\14\:CKb \15\:CKb) resistor r=1.0761 c=0
Rk26 (\15\:CKb \16\:CKb) resistor r=1.038 c=0
Rk27 (\14\:CKb \17\:CKb) resistor r=0.1713 c=0
Rk32 (\19\:CKb \20\:CKb) resistor r=0.3871 c=0
Rk33 (\20\:CKb \21\:CKb) resistor r=0.1422 c=0
Rk34 (\20\:CKb \23\:CKb) resistor r=0.5243 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.229 c=0
Rk15 (\6\:mout \7\:mout) resistor r=0.04688 c=0
Rk16 (\7\:mout \8\:mout) resistor r=0.4107 c=0
Rk17 (\8\:mout \10\:mout) resistor r=0.3424 c=0
Rk18 (\6\:mout \12\:mout) resistor r=0.1863 c=0
Rk19 (\7\:mout \14\:mout) resistor r=0.278 c=0
Rk20 (\8\:mout \16\:mout) resistor r=0.07544 c=0
Rk28 (\7\:CKbb \8\:CKbb) resistor r=0.2563 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=1.2996 c=0
Rk30 (\8\:CKbb \11\:CKbb) resistor r=0.5365 c=0
Rk31 (\11\:CKbb \13\:CKbb) resistor r=0.324 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.113 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3854 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.3773 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.7304 c=0
Rk38 (\3\:Db \5\:Db) resistor r=1.1244 c=0
Rk39 (\5\:Db \7\:Db) resistor r=0.5304 c=0
Rk40 (\3\:Db \9\:Db) resistor r=0.27 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.04823 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.3083 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.557 c=0
Rk44 (\7\:SEb \11\:SEb) resistor r=0.5177 c=0
Rk8 (\2\:net355 \4\:net355) resistor r=0.2316 c=0
Rl37 (\1\:D \2\:D) resistor r=84.8746 c=0
Rl39 (\2\:D \4\:D) resistor r=97.7584 c=0
Rl38 (\2\:D \3\:D) resistor r=73.0022 c=0
Rl35 (\1\:CK \2\:CK) resistor r=51.1559 c=0
Rl36 (\2\:CK \3\:CK) resistor r=141.541 c=0
Rl43 (\2\:SE \3\:SE) resistor r=133.211 c=0
Rl44 (\2\:SE \4\:SE) resistor r=48.5834 c=0
Rl42 (\1\:SE \2\:SE) resistor r=12.4379 c=0
Rl49 (\6\:SE \8\:SE) resistor r=88.1757 c=0
Rl48 (\6\:SE \7\:SE) resistor r=47.791 c=0
Rl47 (\5\:SE \6\:SE) resistor r=6.7128 c=0
Rl20 (\5\:SN \6\:SN) resistor r=41.4941 c=0
Rl21 (\6\:SN \7\:SN) resistor r=147.31 c=0
Rl11 (\1\:SN \2\:SN) resistor r=34.3295 c=0
Rl13 (\2\:SN \4\:SN) resistor r=111.253 c=0
Rl12 (\2\:SN \3\:SN) resistor r=16.2825 c=0
Rl45 (\1\:SI \2\:SI) resistor r=26.098 c=0
Rl46 (\2\:SI \3\:SI) resistor r=122.252 c=0
Rl14 (\10\:qbint \9\:qbint) resistor r=103.846 c=0
Rl15 (\10\:qbint \11\:qbint) resistor r=26.3736 c=0
Rl5 (\6\:qbint qbint) resistor r=5.1512 c=0
Rl8 (n30 \2\:n30) resistor r=93.4643 c=0
Rl9 (\2\:n30 \3\:n30) resistor r=28.0797 c=0
Rl10 (\2\:n30 \4\:n30) resistor r=91.222 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=22.0693 c=0
Rl33 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=78.079 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=143.744 c=0
Rl16 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl34 (\9\:CKb \12\:CKb) resistor r=47.1143 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=10.2272 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=144.788 c=0
Rl26 (\2\:mout \4\:mout) resistor r=110.418 c=0
Rl24 (mout \2\:mout) resistor r=100.368 c=0
Rl25 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl17 (CKbb \2\:CKbb) resistor r=125 c=0
Rl28 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=191.428 c=0
Rl18 (CKbb \3\:CKbb) resistor r=50.6918 c=0
Rl22 (n20 \2\:n20) resistor r=29.5379 c=0
Rl23 (\2\:n20 \3\:n20) resistor r=194.488 c=0
Rl41 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl40 (SEb \2\:SEb) resistor r=39.6174 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz16 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz17 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz18 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz19 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz20 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz21 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz1 (\5\:Q \4\:Q) resistor r=75 c=0
Rz12 (\5\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Rz14 (\12\:VDD \4\:VDD) resistor r=6.25 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz3 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz8 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz4 (\9\:mout \10\:mout) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz7 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (\4\:Db \5\:Db) resistor r=75 c=0
Rz10 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry24 (\5\:VSS \4\:VSS) resistor r=7.75 c=0
Ry25 (\8\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry26 (\11\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry14 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=20.6667 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry2 (\18\:qbint \17\:qbint) resistor r=31 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry6 (\13\:mout \14\:mout) resistor r=62 c=0
Ry7 (\15\:mout \16\:mout) resistor r=62 c=0
Ry9 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry11 (Db \2\:Db) resistor r=20.6667 c=0
Ry12 (\6\:Db \7\:Db) resistor r=62 c=0
Ry13 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry3 (net355 \2\:net355) resistor r=62 c=0
Ry4 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\5\:SE \9\:SE) resistor r=45 c=0
Rx21 (\1\:SE \10\:SE) resistor r=45 c=0
Rx4 (\3\:SN \8\:SN) resistor r=45 c=0
Rx5 (\6\:SN \9\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx2 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx3 (\4\:n30 \5\:n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \9\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\2\:SEb \5\:SEb) resistor r=45 c=0
Rx18 (\4\:SEb \7\:SEb) resistor r=45 c=0
mn11 (net443 \4\:D \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.322e-14 ad=1.82e-14 ps=1.17e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn12 (\8\:Db SEb net443 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.66923e-07 sb=6.05e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn14 (\8\:Db \4\:SE net455 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.71923e-07 sb=4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn13 (net455 \3\:SI \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=5.59e-14 ps=8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.31923e-07 sb=1.4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn55_1__rcx (\4\:Q qbint \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.735e-14 ad=4.81e-14 ps=8.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.23173e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn45 (\13\:qbint \3\:n30 \13\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn50 (net459 \4\:SN \25\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.215e-14 ad=1.742e-14 ps=8.8e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1878e-07 sb=7.3e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (net467 \11\:qbint net459 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.742e-14 ad=2.767e-14 ps=5.8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4878e-07 sb=6e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn52 (\9\:n30 CKb net467 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=4.817e-14 ps=6.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2878e-07 sb=4.2e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\9\:n30 \2\:CKbb \9\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=4.817e-14 ps=6.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.0878e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (net435 \7\:SN \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.587e-14 ad=1.332e-14 ps=7.6e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=2.5e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn31 (\11\:mout \3\:n20 net435 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.332e-14 ad=2.87e-14 ps=5.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (net427 mout \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn36 (\8\:n20 \6\:CKbb net427 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn25 (\8\:n20 \11\:CKb \4\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn21 (\12\:CKbb \7\:CKb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.445e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\18\:CKb \3\:CK \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.322e-14 ad=2.175e-14 ps=1.17e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.09e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn10 (\8\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45 (\17\:qbint n30 \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.34e-14 ps=1.15e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=36.0877 \
        scb=0.0235247 scc=0.00420471 m=(1)
mp50 (\3\:net355 \1\:SN \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=17.9343 scb=0.0166254 \
        scc=0.0014837 m=(1)
mp51 (\3\:net355 \9\:qbint \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=17.9343 scb=0.0166254 \
        scc=0.0014837 m=(1)
mp52 (\7\:n30 CKbb net355 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.20484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\7\:n30 \4\:CKb \15\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\13\:mout \5\:SN \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.065e-14 ad=4.96e-14 ps=1.41e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.16e-06 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp31 (\13\:mout n20 \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.52e-14 ad=4.96e-14 ps=1.51e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.55e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp35 (net378 \4\:mout \19\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.52e-14 ad=4.185e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=6.9e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp36 (\4\:n20 \5\:CKb net378 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=7.13e-14 ps=8.9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=5.1e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp25 (\4\:n20 \4\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=7.13e-14 ps=1.09e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.35e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp21 (\10\:CKbb \12\:CKb \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0082e-13 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.0593e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp10 (\10\:SEb \8\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
ends SDFFSHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:49 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX4 CK D Q SE SI SN VDD VSS
mp11 (net390 \1\:D \11\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.04e-14 ad=1.1115e-13 ps=1.3e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.08141e-07 sb=7.52308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp12 (\8\:Db \3\:SE net390 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=6.24e-14 ps=1.35e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.38141e-07 sb=4.22308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp14 (\8\:Db \3\:SEb net398 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.43141e-07 sb=2.17308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp13 (net398 \1\:SI \9\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.48141e-07 sb=1.12308e-07 sd=160n sca=15.6043 \
        scb=0.0139625 scc=0.00102271 m=(1)
mp55_1__rcx (Q qbint \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.789e-14 ad=6.338e-14 ps=1.2825e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52679e-06 sd=160n sca=21.8995 \
        scb=0.021439 scc=0.00147164 m=(4)
C1 (D VSS) capacitor c=4.39999e-17
C2 (Q VSS) capacitor c=2.50389e-16
C3 (VDD VSS) capacitor c=3.74067e-16
C4 (CK VSS) capacitor c=7.95186e-17
C5 (SE VSS) capacitor c=1.09785e-16
C6 (SN VSS) capacitor c=1.85396e-16
C7 (SI VSS) capacitor c=8.40853e-17
C8 (qbint VSS) capacitor c=2.41673e-16
C9 (n30 VSS) capacitor c=1.90699e-16
C10 (net459 VSS) capacitor c=6.39422e-18
C11 (net467 VSS) capacitor c=1.0206e-18
C12 (CKb VSS) capacitor c=5.4141e-17
C13 (mout VSS) capacitor c=5.73438e-17
C14 (CKbb VSS) capacitor c=4.9072e-17
C15 (net435 VSS) capacitor c=3.53849e-19
C16 (n20 VSS) capacitor c=4.93707e-17
C17 (net427 VSS) capacitor c=1.92109e-18
C18 (Db VSS) capacitor c=4.09767e-17
C19 (net443 VSS) capacitor c=4.28538e-18
C20 (SEb VSS) capacitor c=5.16208e-17
C21 (net455 VSS) capacitor c=3.38622e-18
C22 (net355 VSS) capacitor c=8.6545e-17
C23 (net378 VSS) capacitor c=3.84145e-18
C24 (net390 VSS) capacitor c=1.48988e-17
C25 (net398 VSS) capacitor c=1.70955e-18
C26 (\5\:SE VSS) capacitor c=3.18794e-17
C27 (\1\:SI VSS) capacitor c=7.46719e-17
C28 (\3\:SEb VSS) capacitor c=7.15664e-17
C29 (\3\:SE VSS) capacitor c=5.75715e-17
C30 (\1\:D VSS) capacitor c=4.56217e-17
C31 (\1\:CK VSS) capacitor c=3.543e-17
C32 (\12\:CKb VSS) capacitor c=2.305e-17
C33 (\4\:CKbb VSS) capacitor c=2.99091e-17
C34 (\5\:CKb VSS) capacitor c=5.12559e-17
C35 (\3\:mout VSS) capacitor c=7.99354e-17
C36 (\5\:SN VSS) capacitor c=3.92193e-17
C37 (\4\:CKb VSS) capacitor c=5.56723e-17
C38 (\13\:qbint VSS) capacitor c=4.6466e-17
C39 (\4\:SN VSS) capacitor c=3.6754e-17
C40 (\7\:SE VSS) capacitor c=2.43633e-17
C41 (\3\:SI VSS) capacitor c=5.62221e-17
C42 (\4\:SE VSS) capacitor c=4.53793e-17
C43 (\4\:D VSS) capacitor c=5.02044e-17
C44 (\4\:CK VSS) capacitor c=3.41946e-17
C45 (\7\:CKb VSS) capacitor c=1.63553e-17
C46 (\11\:CKb VSS) capacitor c=2.27958e-17
C47 (\6\:CKbb VSS) capacitor c=6.39979e-17
C48 (\3\:n20 VSS) capacitor c=7.79368e-17
C49 (\7\:SN VSS) capacitor c=6.95697e-17
C50 (\2\:CKbb VSS) capacitor c=4.17574e-17
C51 (\15\:qbint VSS) capacitor c=4.23122e-17
C52 (\1\:SN VSS) capacitor c=4.68922e-17
C53 (\6\:SE VSS) capacitor c=2.21674e-17
C54 (\2\:SI VSS) capacitor c=6.13009e-17
C55 (\4\:SEb VSS) capacitor c=4.9172e-17
C56 (\1\:SE VSS) capacitor c=2.79192e-17
C57 (\2\:SEb VSS) capacitor c=3.57582e-17
C58 (\3\:D VSS) capacitor c=2.86723e-17
C59 (\3\:CK VSS) capacitor c=2.58036e-17
C60 (\8\:CKb VSS) capacitor c=9.33152e-18
C61 (\10\:CKb VSS) capacitor c=3.51381e-17
C62 (\5\:CKbb VSS) capacitor c=5.26211e-17
C63 (\6\:CKb VSS) capacitor c=4.34844e-17
C64 (\2\:mout VSS) capacitor c=5.11619e-17
C65 (\2\:n20 VSS) capacitor c=6.65371e-17
C66 (\6\:SN VSS) capacitor c=5.07217e-17
C67 (\3\:CKb VSS) capacitor c=3.62499e-17
C68 (\3\:CKbb VSS) capacitor c=2.56437e-17
C69 (\2\:CKb VSS) capacitor c=3.56017e-17
C70 (\14\:qbint VSS) capacitor c=4.02301e-17
C71 (\3\:SN VSS) capacitor c=4.66492e-17
C72 (\1\:VDD VSS) capacitor c=3.01341e-17
C73 (\8\:SEb VSS) capacitor c=1.05441e-16
C74 (\9\:VDD VSS) capacitor c=2.56825e-17
C75 (\8\:Db VSS) capacitor c=1.1704e-16
C76 (\11\:VDD VSS) capacitor c=6.15509e-17
C77 (\22\:CKb VSS) capacitor c=6.14289e-17
C78 (\13\:VDD VSS) capacitor c=5.36115e-17
C79 (\9\:CKbb VSS) capacitor c=1.12515e-16
C80 (\6\:Db VSS) capacitor c=1.10393e-16
C81 (\4\:n20 VSS) capacitor c=3.89772e-17
C82 (\15\:VDD VSS) capacitor c=2.78933e-17
C83 (\12\:mout VSS) capacitor c=5.76484e-17
C84 (\18\:VDD VSS) capacitor c=2.51984e-17
C85 (\14\:mout VSS) capacitor c=2.26467e-17
C86 (\11\:n30 VSS) capacitor c=4.47629e-17
C87 (\21\:VDD VSS) capacitor c=2.99836e-17
C88 (\3\:net355 VSS) capacitor c=8.29913e-17
C89 (\21\:qbint VSS) capacitor c=6.2987e-17
C90 (\4\:VDD VSS) capacitor c=7.93709e-17
C91 (\10\:SEb VSS) capacitor c=1.07499e-16
C92 (\18\:CKb VSS) capacitor c=9.22435e-17
C93 (\7\:CKbb VSS) capacitor c=7.57541e-17
C94 (\4\:Db VSS) capacitor c=2.08793e-16
C95 (\8\:n20 VSS) capacitor c=8.28298e-17
C96 (\10\:mout VSS) capacitor c=5.25115e-17
C97 (\8\:mout VSS) capacitor c=7.52844e-17
C98 (\7\:n30 VSS) capacitor c=6.34867e-17
C99 (\17\:qbint VSS) capacitor c=9.74744e-17
C100 (\9\:CKb VSS) capacitor c=1.80461e-17
C101 (\2\:CK VSS) capacitor c=3.85234e-17
C102 (\2\:D VSS) capacitor c=3.32685e-17
C103 (\2\:SE VSS) capacitor c=4.17187e-17
C104 (\16\:qbint VSS) capacitor c=8.90692e-17
C105 (\19\:qbint VSS) capacitor c=3.48961e-17
C106 (\20\:qbint VSS) capacitor c=2.1481e-17
C107 (\9\:n30 VSS) capacitor c=1.3452e-16
C108 (\10\:n30 VSS) capacitor c=1.35597e-16
C109 (\8\:SN VSS) capacitor c=5.77443e-17
C110 (\9\:SN VSS) capacitor c=1.85676e-16
C111 (\4\:mout VSS) capacitor c=3.88111e-17
C112 (\5\:mout VSS) capacitor c=2.29659e-17
C113 (\6\:mout VSS) capacitor c=6.79378e-17
C114 (\7\:mout VSS) capacitor c=7.45708e-17
C115 (\6\:n20 VSS) capacitor c=8.61254e-17
C116 (\7\:n20 VSS) capacitor c=6.71535e-17
C117 (\13\:CKb VSS) capacitor c=1.07314e-16
C118 (\14\:CKb VSS) capacitor c=2.05196e-16
C119 (\15\:CKb VSS) capacitor c=2.36905e-16
C120 (\16\:CKb VSS) capacitor c=4.46563e-17
C121 (\17\:CKb VSS) capacitor c=1.25615e-16
C122 (\11\:CKbb VSS) capacitor c=1.88149e-16
C123 (\12\:CKbb VSS) capacitor c=1.85396e-16
C124 (\13\:CKbb VSS) capacitor c=5.82882e-17
C125 (\20\:CKb VSS) capacitor c=8.38301e-17
C126 (\21\:CKb VSS) capacitor c=2.40478e-17
C127 (\5\:CK VSS) capacitor c=4.84123e-17
C128 (\5\:D VSS) capacitor c=6.58906e-17
C129 (\3\:Db VSS) capacitor c=2.93853e-16
C130 (\4\:SI VSS) capacitor c=4.08139e-17
C131 (\5\:SEb VSS) capacitor c=2.82635e-17
C132 (\6\:SEb VSS) capacitor c=9.70116e-17
C133 (\7\:SEb VSS) capacitor c=1.12353e-16
C134 (\8\:SE VSS) capacitor c=1.10188e-16
C135 (\3\:VDD VSS) capacitor c=1.97839e-17
C136 (\6\:VDD VSS) capacitor c=1.78854e-17
C137 (\7\:VDD VSS) capacitor c=4.82722e-17
C138 (\17\:VDD VSS) capacitor c=3.40307e-17
C139 (\20\:VDD VSS) capacitor c=3.07775e-17
C140 (\23\:VDD VSS) capacitor c=1.96169e-16
Rk38 (D \5\:D) resistor r=0.1321 c=0
Rk73 (\2\:VSS \3\:VSS) resistor r=0.6032 c=0
Rk74 (\3\:VSS \5\:VSS) resistor r=0.1653 c=0
Rk75 (\5\:VSS \6\:VSS) resistor r=0.213 c=0
Rk76 (\6\:VSS \7\:VSS) resistor r=0.3472 c=0
Rk77 (\7\:VSS \8\:VSS) resistor r=0.6106 c=0
Rk78 (\8\:VSS \9\:VSS) resistor r=0.0299 c=0
Rk79 (\9\:VSS \10\:VSS) resistor r=0.3208 c=0
Rk85 (\11\:VSS VSS) resistor r=0.0798 c=0
Rk80 (\10\:VSS \11\:VSS) resistor r=0.6968 c=0
Rk86 (\3\:VSS \17\:VSS) resistor r=0.2042 c=0
Rk87 (\6\:VSS \19\:VSS) resistor r=0.201 c=0
Rk88 (\7\:VSS \21\:VSS) resistor r=0.04331 c=0
Rk89 (\8\:VSS \23\:VSS) resistor r=0.3354 c=0
Rk90 (\10\:VSS \25\:VSS) resistor r=0.3387 c=0
Rk50 (\2\:VDD \3\:VDD) resistor r=0.705 c=0
Rk51 (\3\:VDD \5\:VDD) resistor r=0.2105 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.213 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.4259 c=0
Rk54 (\7\:VDD \8\:VDD) resistor r=0.5641 c=0
Rk55 (\3\:VDD \10\:VDD) resistor r=0.2443 c=0
Rk56 (\6\:VDD \12\:VDD) resistor r=0.3375 c=0
Rk57 (\7\:VDD \14\:VDD) resistor r=0.4463 c=0
Rk58 (\8\:VDD \16\:VDD) resistor r=0.07147 c=0
Rk59 (\8\:VDD \17\:VDD) resistor r=0.2759 c=0
Rk60 (\17\:VDD \19\:VDD) resistor r=0.04331 c=0
Rk61 (\17\:VDD \20\:VDD) resistor r=0.4601 c=0
Rk62 (\20\:VDD \22\:VDD) resistor r=0.1708 c=0
Rk72 (\23\:VDD VDD) resistor r=0.0798 c=0
Rk63 (\20\:VDD \23\:VDD) resistor r=0.2654 c=0
Rk37 (CK \5\:CK) resistor r=0.0974 c=0
Rk48 (\8\:SE SE) resistor r=0.6485 c=0
Rk49 (SE \9\:SE) resistor r=0.009436 c=0
Rk14 (\8\:SN SN) resistor r=0.318 c=0
Rk15 (SN \9\:SN) resistor r=1.3607 c=0
Rk43 (SI \4\:SI) resistor r=0.09255 c=0
Rk6 (\16\:qbint \18\:qbint) resistor r=0.5802 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.2315 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.1315 c=0
Rk9 (\19\:qbint \22\:qbint) resistor r=0.3026 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.2263 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.8421 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.2043 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.7159 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=1.0979 c=0
Rk28 (\14\:CKb \16\:CKb) resistor r=0.1706 c=0
Rk29 (\15\:CKb \17\:CKb) resistor r=0.9198 c=0
Rk34 (\19\:CKb \20\:CKb) resistor r=0.4256 c=0
Rk35 (\20\:CKb \21\:CKb) resistor r=0.1014 c=0
Rk36 (\20\:CKb \23\:CKb) resistor r=0.4627 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1875 c=0
Rk17 (\5\:mout \6\:mout) resistor r=0.07842 c=0
Rk18 (\6\:mout \7\:mout) resistor r=0.42 c=0
Rk19 (\7\:mout \9\:mout) resistor r=0.3594 c=0
Rk20 (\5\:mout \11\:mout) resistor r=0.1744 c=0
Rk21 (\6\:mout \13\:mout) resistor r=0.2542 c=0
Rk22 (\7\:mout \15\:mout) resistor r=0.05463 c=0
Rk30 (\8\:CKbb \10\:CKbb) resistor r=0.4306 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.5444 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=1.2262 c=0
Rk33 (\11\:CKbb \13\:CKbb) resistor r=0.2551 c=0
Rk23 (\5\:n20 \6\:n20) resistor r=0.1125 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.38 c=0
Rk25 (\6\:n20 \9\:n20) resistor r=0.3757 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.2713 c=0
Rk40 (\3\:Db \5\:Db) resistor r=1.1944 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.5325 c=0
Rk42 (\3\:Db \9\:Db) resistor r=0.8556 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.1874 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.1635 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.8334 c=0
Rk47 (\7\:SEb \11\:SEb) resistor r=0.7053 c=0
Rk10 (\2\:net355 \4\:net355) resistor r=0.2778 c=0
Rl43 (\1\:D \2\:D) resistor r=113.023 c=0
Rl45 (\2\:D \4\:D) resistor r=53.5603 c=0
Rl44 (\2\:D \3\:D) resistor r=13.091 c=0
Rl40 (\1\:CK \2\:CK) resistor r=141.541 c=0
Rl42 (\2\:CK \4\:CK) resistor r=28.0797 c=0
Rl41 (\2\:CK \3\:CK) resistor r=93.1451 c=0
Rl53 (\5\:SE \6\:SE) resistor r=72.3097 c=0
Rl54 (\6\:SE \7\:SE) resistor r=43.4636 c=0
Rl48 (\2\:SE \3\:SE) resistor r=108.645 c=0
Rl49 (\2\:SE \4\:SE) resistor r=48.5834 c=0
Rl47 (\1\:SE \2\:SE) resistor r=2.257 c=0
Rl26 (\5\:SN \6\:SN) resistor r=57.2464 c=0
Rl27 (\6\:SN \7\:SN) resistor r=131.925 c=0
Rl19 (\2\:SN \4\:SN) resistor r=23.7402 c=0
Rl17 (\1\:SN \2\:SN) resistor r=108.001 c=0
Rl18 (\2\:SN \3\:SN) resistor r=4.3511 c=0
Rl51 (\1\:SI \2\:SI) resistor r=29.5379 c=0
Rl52 (\2\:SI \3\:SI) resistor r=134.873 c=0
Rl20 (\14\:qbint \13\:qbint) resistor r=85.7713 c=0
Rl21 (\14\:qbint \15\:qbint) resistor r=24.2328 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=26.9231 c=0
Rl38 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=79.5379 c=0
Rl25 (\3\:CKb \4\:CKb) resistor r=111.516 c=0
Rl22 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl39 (\9\:CKb \12\:CKb) resistor r=39.1248 c=0
Rl36 (\8\:CKb \9\:CKb) resistor r=9.4946 c=0
Rl37 (\9\:CKb \10\:CKb) resistor r=145.249 c=0
Rl31 (\2\:mout \3\:mout) resistor r=106.027 c=0
Rl30 (mout \2\:mout) resistor r=111.796 c=0
Rl23 (CKbb \2\:CKbb) resistor r=113.462 c=0
Rl33 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=191.428 c=0
Rl24 (CKbb \3\:CKbb) resistor r=58.3841 c=0
Rl28 (n20 \2\:n20) resistor r=29.5379 c=0
Rl29 (\2\:n20 \3\:n20) resistor r=190.642 c=0
Rl50 (\3\:SEb \4\:SEb) resistor r=30.2349 c=0
Rl46 (SEb \2\:SEb) resistor r=31.9251 c=0
Rz16 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz20 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz21 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz13 (\5\:VDD \4\:VDD) resistor r=6.25 c=0
Rz14 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Rz15 (\23\:VDD \4\:VDD) resistor r=6.25 c=0
Rz3 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz9 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz6 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\7\:CKbb \8\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\4\:Db \5\:Db) resistor r=75 c=0
Rz12 (\10\:SEb \11\:SEb) resistor r=75 c=0
Ry26 (\5\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry27 (\9\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry28 (\11\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry18 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry19 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry3 (\22\:qbint \21\:qbint) resistor r=31 c=0
Ry6 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry11 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry7 (\12\:mout \13\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry10 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\6\:Db \7\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net355 \2\:net355) resistor r=62 c=0
Ry5 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\3\:CK \5\:CK) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\6\:SE \9\:SE) resistor r=45 c=0
Rx4 (\3\:SN \8\:SN) resistor r=45 c=0
Rx5 (\6\:SN \9\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\16\:qbint \14\:qbint) resistor r=45 c=0
Rx2 (\20\:qbint qbint) resistor r=45 c=0
Rx3 (\10\:n30 n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn11 (net443 \4\:D \18\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.51e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (Db SEb net443 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.31923e-07 sb=5.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn14 (Db \4\:SE net455 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.36923e-07 sb=3.35e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net455 \3\:SI \16\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.9e-14 ps=8e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.31923e-07 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn55_1__rcx (Q qbint \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.178e-14 ad=4.16e-14 ps=8.525e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72817e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn50 (net459 \1\:SN \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.41e-14 ad=4.51e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=8.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (net467 \15\:qbint net459 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=1.64e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=5.7e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn52 (\7\:n30 CKb net467 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.64e-14 ad=5.023e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-06 sb=4.45e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:n30 \2\:CKbb \8\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=5.023e-14 ps=7.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (net435 \7\:SN \24\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=1.23e-14 ps=7.7e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2.45e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn35 (net427 mout \22\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn36 (\8\:n20 \6\:CKbb net427 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn25 (\8\:n20 \11\:CKb \4\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn45_1__rcx (\17\:qbint n30 \11\:VSS VSS) g45n1hvt w=(2.05e-07) \
        l=4.5e-08 nf=1 as=5.081e-14 ad=3.997e-14 ps=9.65e-07 pd=8e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.005e-06 sb=1.34e-06 sd=160n \
        sca=13.8179 scb=0.0141903 scc=0.000851218 m=(2)
mn21 (\7\:CKbb \7\:CKb \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.685e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\18\:CKb \4\:CK \18\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.552e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn10 (\10\:SEb \7\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp50 (\3\:net355 \4\:SN \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.265e-14 ad=8.99e-14 ps=1.77e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=4.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\3\:net355 \13\:qbint \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.99e-14 ad=8.99e-14 ps=1.38e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=1e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp52 (\11\:n30 CKbb net355 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.035e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62419e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\11\:n30 \4\:CKb \14\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67419e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \5\:SN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.25e-14 ad=4.96e-14 ps=1.29e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.155e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp31 (\12\:mout n20 \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=4.96e-14 ps=1.39e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=9.5e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp35 (net378 \3\:mout \15\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=3.72e-14 ps=1.39e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=6.85e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp36 (\4\:n20 \5\:CKb net378 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.72e-14 ad=7.44e-14 ps=8.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.2e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp25 (\4\:n20 \4\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=7.44e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=2.35e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp45_1__rcx (\21\:qbint n30 \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.24e-14 ad=6.045e-14 ps=1.82e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=8.7e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(2)
mp21 (\9\:CKbb \12\:CKb \13\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \11\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.04e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp10 (\8\:SEb \5\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=51.8759 \
        scb=0.0369865 scc=0.00608773 m=(1)
ends SDFFSHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:50 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX8 CK D Q SE SI SN VDD VSS
mp55_1__rcx (Q qbint VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.824e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.34348e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D VSS) capacitor c=6.35862e-17
C2 (VDD VSS) capacitor c=7.67608e-16
C3 (CK VSS) capacitor c=5.71324e-17
C4 (SN VSS) capacitor c=2.14185e-17
C5 (Q VSS) capacitor c=5.56051e-16
C6 (SI VSS) capacitor c=7.63414e-17
C7 (qbint VSS) capacitor c=3.33363e-16
C8 (n30 VSS) capacitor c=1.9978e-16
C9 (net459 VSS) capacitor c=3.48373e-18
C10 (net467 VSS) capacitor c=1.98903e-18
C11 (CKb VSS) capacitor c=4.13913e-17
C12 (mout VSS) capacitor c=3.88092e-17
C13 (CKbb VSS) capacitor c=4.96061e-17
C14 (net435 VSS) capacitor c=3.71162e-19
C15 (n20 VSS) capacitor c=4.70181e-17
C16 (net427 VSS) capacitor c=1.83791e-18
C17 (Db VSS) capacitor c=5.05057e-17
C18 (net443 VSS) capacitor c=9.05262e-18
C19 (SEb VSS) capacitor c=4.06983e-17
C20 (net455 VSS) capacitor c=1.40273e-18
C21 (net355 VSS) capacitor c=9.4347e-17
C22 (net378 VSS) capacitor c=5.94322e-18
C23 (net390 VSS) capacitor c=9.80049e-18
C24 (net398 VSS) capacitor c=1.63377e-18
C25 (\7\:SE VSS) capacitor c=3.54259e-17
C26 (\1\:SI VSS) capacitor c=7.56977e-17
C27 (\3\:SEb VSS) capacitor c=7.2098e-17
C28 (\3\:SE VSS) capacitor c=5.80891e-17
C29 (\1\:D VSS) capacitor c=4.09371e-17
C30 (\1\:CK VSS) capacitor c=2.58688e-17
C31 (\7\:CKb VSS) capacitor c=2.60056e-17
C32 (\4\:CKbb VSS) capacitor c=3.18188e-17
C33 (\5\:CKb VSS) capacitor c=4.79038e-17
C34 (\4\:mout VSS) capacitor c=6.64914e-17
C35 (\4\:SN VSS) capacitor c=5.26958e-17
C36 (\3\:CKb VSS) capacitor c=5.5355e-17
C37 (\2\:CKbb VSS) capacitor c=4.69167e-17
C38 (\23\:qbint VSS) capacitor c=5.41907e-17
C39 (\3\:SN VSS) capacitor c=3.75954e-17
C40 (\6\:SE VSS) capacitor c=2.30831e-17
C41 (\3\:SI VSS) capacitor c=8.02899e-17
C42 (\1\:SE VSS) capacitor c=6.48037e-17
C43 (\4\:D VSS) capacitor c=3.71515e-17
C44 (\4\:CK VSS) capacitor c=2.36134e-17
C45 (\12\:CKb VSS) capacitor c=2.31665e-17
C46 (\10\:CKb VSS) capacitor c=2.14769e-17
C47 (\6\:CKbb VSS) capacitor c=7.17127e-17
C48 (\3\:n20 VSS) capacitor c=9.44449e-17
C49 (\6\:SN VSS) capacitor c=6.88904e-17
C50 (\25\:qbint VSS) capacitor c=3.85372e-17
C51 (\1\:SN VSS) capacitor c=5.93024e-17
C52 (\4\:SE VSS) capacitor c=1.41975e-17
C53 (\2\:SI VSS) capacitor c=6.23989e-17
C54 (\4\:SEb VSS) capacitor c=5.06315e-17
C55 (\2\:SE VSS) capacitor c=7.30555e-17
C56 (\2\:SEb VSS) capacitor c=5.09358e-17
C57 (\3\:D VSS) capacitor c=1.18832e-17
C58 (\3\:CK VSS) capacitor c=1.5668e-17
C59 (\11\:CKb VSS) capacitor c=2.5342e-17
C60 (\5\:CKbb VSS) capacitor c=5.28806e-17
C61 (\9\:CKb VSS) capacitor c=3.26343e-17
C62 (\6\:CKb VSS) capacitor c=4.68092e-17
C63 (\3\:mout VSS) capacitor c=5.42523e-17
C64 (\2\:n20 VSS) capacitor c=5.86116e-17
C65 (\5\:SN VSS) capacitor c=4.94778e-17
C66 (\4\:CKb VSS) capacitor c=3.50837e-17
C67 (\3\:CKbb VSS) capacitor c=2.74516e-17
C68 (\2\:CKb VSS) capacitor c=4.42949e-17
C69 (\24\:qbint VSS) capacitor c=5.16477e-17
C70 (\2\:SN VSS) capacitor c=4.48147e-17
C71 (\1\:VDD VSS) capacitor c=8.43171e-18
C72 (\5\:SEb VSS) capacitor c=7.75828e-17
C73 (\21\:VDD VSS) capacitor c=2.83184e-17
C74 (\6\:Db VSS) capacitor c=1.18474e-16
C75 (\23\:VDD VSS) capacitor c=4.2249e-17
C76 (\22\:CKb VSS) capacitor c=7.07829e-17
C77 (\25\:VDD VSS) capacitor c=6.07148e-17
C78 (\9\:CKbb VSS) capacitor c=1.08698e-16
C79 (\8\:Db VSS) capacitor c=1.05691e-16
C80 (\6\:n20 VSS) capacitor c=1.17393e-16
C81 (\27\:VDD VSS) capacitor c=2.01288e-17
C82 (\12\:mout VSS) capacitor c=5.63276e-17
C83 (\29\:VDD VSS) capacitor c=2.43593e-17
C84 (\14\:mout VSS) capacitor c=2.61445e-17
C85 (\15\:n30 VSS) capacitor c=4.22565e-17
C86 (\31\:VDD VSS) capacitor c=3.1607e-17
C87 (\3\:net355 VSS) capacitor c=9.95318e-17
C88 (\3\:VDD VSS) capacitor c=8.79111e-17
C89 (\9\:SEb VSS) capacitor c=1.00052e-16
C90 (\18\:CKb VSS) capacitor c=5.26915e-17
C91 (\12\:CKbb VSS) capacitor c=7.98463e-17
C92 (\4\:Db VSS) capacitor c=2.89127e-16
C93 (\4\:n20 VSS) capacitor c=1.00254e-16
C94 (\10\:mout VSS) capacitor c=5.54414e-17
C95 (\8\:mout VSS) capacitor c=6.73586e-17
C96 (\13\:n30 VSS) capacitor c=7.43521e-17
C97 (\27\:qbint VSS) capacitor c=3.7657e-16
C98 (\2\:CK VSS) capacitor c=1.70737e-17
C99 (\2\:D VSS) capacitor c=2.4594e-17
C100 (\26\:qbint VSS) capacitor c=7.60937e-17
C101 (\33\:qbint VSS) capacitor c=6.84945e-17
C102 (\5\:SE VSS) capacitor c=1.60122e-17
C103 (\11\:n30 VSS) capacitor c=1.27991e-16
C104 (\12\:n30 VSS) capacitor c=1.26841e-16
C105 (\7\:SN VSS) capacitor c=2.10096e-16
C106 (\8\:SN VSS) capacitor c=1.79359e-16
C107 (\5\:mout VSS) capacitor c=5.479e-17
C108 (\6\:mout VSS) capacitor c=6.79847e-17
C109 (\7\:mout VSS) capacitor c=5.8701e-17
C110 (\8\:n20 VSS) capacitor c=8.01737e-17
C111 (\13\:CKb VSS) capacitor c=1.22949e-16
C112 (\14\:CKb VSS) capacitor c=2.2544e-16
C113 (\15\:CKb VSS) capacitor c=2.23044e-16
C114 (\16\:CKb VSS) capacitor c=1.2445e-16
C115 (\17\:CKb VSS) capacitor c=4.43457e-17
C116 (\7\:CKbb VSS) capacitor c=6.4839e-17
C117 (\8\:CKbb VSS) capacitor c=1.52287e-16
C118 (\11\:CKbb VSS) capacitor c=2.05515e-16
C119 (\20\:CKb VSS) capacitor c=8.2953e-17
C120 (\21\:CKb VSS) capacitor c=5.38537e-17
C121 (\5\:CK VSS) capacitor c=5.63638e-17
C122 (\5\:D VSS) capacitor c=2.81155e-17
C123 (\3\:Db VSS) capacitor c=2.5458e-16
C124 (\7\:SEb VSS) capacitor c=1.01336e-16
C125 (\8\:SEb VSS) capacitor c=1.45979e-16
C126 (\5\:SI VSS) capacitor c=4.1217e-17
C127 (\8\:SE VSS) capacitor c=1.1082e-16
C128 (\9\:SE VSS) capacitor c=7.91339e-17
C129 (\5\:VDD VSS) capacitor c=2.9605e-17
C130 (\6\:VDD VSS) capacitor c=1.95867e-17
C131 (\8\:VDD VSS) capacitor c=2.65975e-17
C132 (\9\:VDD VSS) capacitor c=3.73255e-17
C133 (\10\:VDD VSS) capacitor c=1.29374e-17
C134 (\12\:VDD VSS) capacitor c=2.0078e-17
C135 (\13\:VDD VSS) capacitor c=1.39883e-16
Rk43 (\5\:D D) resistor r=0.1389 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.1897 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.1252 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.3784 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.2983 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.1403 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.6569 c=0
Rk90 (\9\:VSS \10\:VSS) resistor r=0.3508 c=0
Rk91 (\10\:VSS \11\:VSS) resistor r=0.05499 c=0
Rk94 (\12\:VSS VSS) resistor r=0.3784 c=0
Rk92 (\11\:VSS \12\:VSS) resistor r=0.5592 c=0
Rk100 (\5\:VSS \21\:VSS) resistor r=0.2551 c=0
Rk101 (\6\:VSS \23\:VSS) resistor r=0.2519 c=0
Rk102 (\8\:VSS \25\:VSS) resistor r=0.18 c=0
Rk103 (\9\:VSS \27\:VSS) resistor r=0.3145 c=0
Rk104 (\10\:VSS \29\:VSS) resistor r=0.2723 c=0
Rk56 (\2\:VDD \4\:VDD) resistor r=0.3352 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.07256 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.4462 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.2833 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.2381 c=0
Rk61 (\8\:VDD \9\:VDD) resistor r=0.5807 c=0
Rk62 (\9\:VDD \10\:VDD) resistor r=0.2335 c=0
Rk63 (\10\:VDD \11\:VDD) resistor r=0.1469 c=0
Rk64 (\11\:VDD \12\:VDD) resistor r=0.336 c=0
Rk67 (\13\:VDD VDD) resistor r=0.3257 c=0
Rk65 (\12\:VDD \13\:VDD) resistor r=0.2705 c=0
Rk73 (\5\:VDD \22\:VDD) resistor r=0.178 c=0
Rk74 (\6\:VDD \24\:VDD) resistor r=0.2685 c=0
Rk75 (\8\:VDD \26\:VDD) resistor r=0.442 c=0
Rk76 (\9\:VDD \28\:VDD) resistor r=0.04333 c=0
Rk77 (\10\:VDD \30\:VDD) resistor r=0.04333 c=0
Rk78 (\12\:VDD \32\:VDD) resistor r=0.1297 c=0
Rk42 (CK \5\:CK) resistor r=0.1283 c=0
Rk55 (\9\:SE SE) resistor r=0.003494 c=0
Rk54 (\8\:SE \9\:SE) resistor r=0.6233 c=0
Rk22 (\8\:SN SN) resistor r=0.01161 c=0
Rk21 (\7\:SN \8\:SN) resistor r=1.4486 c=0
Rk51 (\4\:SI \5\:SI) resistor r=0.00514 c=0
Rk52 (\6\:SI SI) resistor r=0.00514 c=0
Rk53 (\5\:SI \6\:SI) resistor r=0.05165 c=0
Rk10 (\26\:qbint \27\:qbint) resistor r=0.5082 c=0
Rk14 (\27\:qbint \33\:qbint) resistor r=0.5317 c=0
Rk18 (\11\:n30 \12\:n30) resistor r=0.755 c=0
Rk19 (\12\:n30 \14\:n30) resistor r=0.3055 c=0
Rk20 (\12\:n30 \16\:n30) resistor r=0.1792 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.7837 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=1.1282 c=0
Rk33 (\15\:CKb \16\:CKb) resistor r=0.8407 c=0
Rk34 (\14\:CKb \17\:CKb) resistor r=0.2527 c=0
Rk39 (\19\:CKb \20\:CKb) resistor r=0.1609 c=0
Rk40 (\20\:CKb \21\:CKb) resistor r=0.3243 c=0
Rk41 (\20\:CKb \23\:CKb) resistor r=0.5233 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.3103 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.3325 c=0
Rk25 (\7\:mout \9\:mout) resistor r=0.3617 c=0
Rk26 (\6\:mout \11\:mout) resistor r=0.2149 c=0
Rk27 (\6\:mout \13\:mout) resistor r=0.2613 c=0
Rk28 (\7\:mout \15\:mout) resistor r=0.07997 c=0
Rk35 (\7\:CKbb \8\:CKbb) resistor r=0.2559 c=0
Rk36 (\8\:CKbb \10\:CKbb) resistor r=0.5548 c=0
Rk37 (\8\:CKbb \11\:CKbb) resistor r=1.2865 c=0
Rk38 (\10\:CKbb \13\:CKbb) resistor r=0.3613 c=0
Rk29 (\5\:n20 \7\:n20) resistor r=0.501 c=0
Rk30 (\7\:n20 \8\:n20) resistor r=0.4791 c=0
Rk44 (\2\:Db \3\:Db) resistor r=0.3024 c=0
Rk45 (\3\:Db \5\:Db) resistor r=1.5361 c=0
Rk46 (\3\:Db \7\:Db) resistor r=0.8675 c=0
Rk47 (\5\:Db \9\:Db) resistor r=0.5347 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.5201 c=0
Rk49 (\7\:SEb \8\:SEb) resistor r=0.2961 c=0
Rk50 (\8\:SEb \10\:SEb) resistor r=0.7424 c=0
Rk17 (\2\:net355 \4\:net355) resistor r=0.3066 c=0
Rl57 (\1\:D \2\:D) resistor r=90.0987 c=0
Rl59 (\2\:D \4\:D) resistor r=84.3295 c=0
Rl58 (\2\:D \3\:D) resistor r=10.6974 c=0
Rl54 (\1\:CK \2\:CK) resistor r=113.176 c=0
Rl56 (\2\:CK \4\:CK) resistor r=63.1757 c=0
Rl55 (\2\:CK \3\:CK) resistor r=7.5059 c=0
Rl62 (\2\:SE \3\:SE) resistor r=135.031 c=0
Rl61 (\1\:SE \2\:SE) resistor r=43.4636 c=0
Rl68 (\5\:SE \7\:SE) resistor r=99.7141 c=0
Rl67 (\5\:SE \6\:SE) resistor r=45.868 c=0
Rl66 (\4\:SE \5\:SE) resistor r=11.5001 c=0
Rl39 (\4\:SN \5\:SN) resistor r=48.3726 c=0
Rl40 (\5\:SN \6\:SN) resistor r=147.31 c=0
Rl32 (\2\:SN \3\:SN) resistor r=24.7951 c=0
Rl31 (\1\:SN \2\:SN) resistor r=128.823 c=0
Rl64 (\1\:SI \2\:SI) resistor r=29.5379 c=0
Rl65 (\2\:SI \3\:SI) resistor r=150.257 c=0
Rl33 (\24\:qbint \23\:qbint) resistor r=116.54 c=0
Rl34 (\24\:qbint \25\:qbint) resistor r=24.2328 c=0
Rl53 (\11\:CKb \12\:CKb) resistor r=24.848 c=0
Rl51 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=48.7687 c=0
Rl38 (\3\:CKb \4\:CKb) resistor r=78.079 c=0
Rl35 (CKb \2\:CKb) resistor r=37.2302 c=0
Rl49 (\7\:CKb \8\:CKb) resistor r=80.8559 c=0
Rl52 (\8\:CKb \11\:CKb) resistor r=14.0381 c=0
Rl50 (\8\:CKb \9\:CKb) resistor r=162.618 c=0
Rl45 (\2\:mout \4\:mout) resistor r=102.375 c=0
Rl43 (mout \2\:mout) resistor r=77.3751 c=0
Rl44 (\2\:mout \3\:mout) resistor r=5.376 c=0
Rl36 (CKbb \2\:CKbb) resistor r=93.7964 c=0
Rl47 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl48 (\5\:CKbb \6\:CKbb) resistor r=202.966 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=91.0764 c=0
Rl41 (n20 \2\:n20) resistor r=29.5379 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=232.95 c=0
Rl63 (\3\:SEb \4\:SEb) resistor r=30.2349 c=0
Rl60 (SEb \2\:SEb) resistor r=74.2328 c=0
Rz20 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz25 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz26 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz19 (VDD \3\:VDD) resistor r=6.25 c=0
Rz16 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz17 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz7 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz12 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\10\:mout \11\:mout) resistor r=75 c=0
Rz11 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\4\:Db \5\:Db) resistor r=75 c=0
Rz15 (\9\:SEb \10\:SEb) resistor r=75 c=0
Ry34 (VSS \3\:VSS) resistor r=5.1667 c=0
Ry31 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry32 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry33 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\24\:VDD \23\:VDD) resistor r=20.6667 c=0
Ry22 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry23 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry24 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry25 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry9 (\16\:n30 \15\:n30) resistor r=62 c=0
Ry14 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry10 (\12\:mout \13\:mout) resistor r=62 c=0
Ry11 (\14\:mout \15\:mout) resistor r=62 c=0
Ry13 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry12 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry15 (\6\:Db \7\:Db) resistor r=62 c=0
Ry16 (\8\:Db \9\:Db) resistor r=62 c=0
Ry17 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry7 (net355 \2\:net355) resistor r=62 c=0
Ry8 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\3\:CK \5\:CK) resistor r=45 c=0
Rx20 (\2\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx4 (\5\:SN \7\:SN) resistor r=45 c=0
Rx5 (\2\:SN \8\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\26\:qbint \24\:qbint) resistor r=45 c=0
Rx2 (\33\:qbint qbint) resistor r=45 c=0
Rx3 (\11\:n30 n30) resistor r=45 c=0
Rx8 (\9\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\4\:SEb \7\:SEb) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55 (Q qbint VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 as=4.889e-14 \
        ad=4.994e-14 ps=9.2143e-07 pd=9.2857e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.485e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn11 (net443 \4\:D \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=5.85e-14 ps=1.42e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.16058e-07 sb=7.2e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn12 (Db SEb net443 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.86058e-07 sb=4.5e-07 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(1)
mn14 (Db \1\:SE net455 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91058e-07 sb=2.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn13 (net455 \3\:SI \20\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.96058e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn45_1__rcx (\27\:qbint n30 \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.328e-14 ad=4.333e-14 ps=8.6e-07 pd=8.5333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.2599e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(3)
mn50 (net459 \1\:SN \12\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=2.768e-14 ps=9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=7.8e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (net467 \25\:qbint net459 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=2.768e-14 ps=6.8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=6e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn52 (\13\:n30 CKb net467 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.818e-14 ps=6.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=4.2e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\13\:n30 CKbb \8\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=4.818e-14 ps=6.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (net435 \6\:SN \28\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=1.435e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.55e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=2.87e-14 ps=5.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn35 (net427 mout \26\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn36 (\4\:n20 \6\:CKbb net427 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn25 (\4\:n20 \10\:CKb \4\:Db VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn21 (\12\:CKbb \12\:CKb \24\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.043e-14 ad=2.175e-14 ps=1.17e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=3.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn20 (\18\:CKb \4\:CK \22\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=2.03e-14 ps=1.42e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.215e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn10 (\9\:SEb \6\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp11 (net390 \1\:D \23\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2125e-13 ad=1.287e-13 ps=1.68e-06 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.12885e-07 sb=7.97308e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp12 (\6\:Db \3\:SE net390 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.287e-13 ad=6.24e-14 ps=1.44e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.87885e-07 sb=4.22308e-07 sd=160n sca=11.4656 \
        scb=0.00963696 scc=0.000244209 m=(1)
mp14 (\6\:Db \3\:SEb net398 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.92885e-07 sb=2.17308e-07 sd=160n sca=12.0152 \
        scb=0.00983999 scc=0.000244281 m=(1)
mp13 (net398 \1\:SI \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09788e-06 sb=1.12308e-07 sd=160n sca=12.499 \
        scb=0.0102001 scc=0.000244729 m=(1)
mp45_1__rcx (\27\:qbint n30 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.627e-14 ad=5.747e-14 ps=1.32e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.22051e-07 sb=7.73077e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(3)
mp50 (\3\:net355 \3\:SN \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.04e-13 ad=6.51e-14 ps=1.76e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85323e-07 sb=3.55e-07 sd=160n sca=11.2287 \
        scb=0.00925355 scc=0.000213039 m=(1)
mp51 (\3\:net355 \23\:qbint \31\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.59e-14 ad=6.51e-14 ps=1.22e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40323e-07 sb=1e-07 sd=160n sca=11.2287 \
        scb=0.00925355 scc=0.000213039 m=(1)
mp52 (\15\:n30 \2\:CKbb net355 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.3871e-07 sb=3.20484e-07 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp40 (\15\:n30 \3\:CKb \14\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4371e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \4\:SN \29\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.14e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.12e-06 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp31 (\12\:mout n20 \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=4.96e-14 ps=1.54e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.15e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp35 (net378 \4\:mout \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.565e-14 ps=1.54e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=6.5e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp36 (\6\:n20 \5\:CKb net378 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=6.51e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=4.9e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp25 (\6\:n20 \4\:CKbb \8\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=6.51e-14 ps=1.09e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.35e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp21 (\9\:CKbb \7\:CKb \25\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.2125e-13 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp10 (\5\:SEb \7\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.94e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=24.2122 scb=0.0283954 \
        scc=0.00140518 m=(1)
ends SDFFSHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:51 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX1 CK D Q RN SE SI SN VDD VSS
mp55 (\1\:Q qbint \27\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.75256e-07 sd=160n sca=40.5329 \
        scb=0.0348939 scc=0.00409042 m=(1)
mp11 (net445 \1\:D \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=7.25064e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=6.20064e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp14 (Db SEb net453 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=6.24e-14 ps=1.05e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.45064e-07 sb=4.15064e-07 sd=160n sca=17.1865 scb=0.0150693 \
        scc=0.0012806 m=(1)
mp13 (net453 \3\:SI \12\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.265e-14 ps=1.1e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25064e-07 sb=2.35064e-07 sd=160n sca=18.0577 \
        scb=0.0157675 scc=0.00128176 m=(1)
C1 (RN VSS) capacitor c=4.5125e-17
C2 (D VSS) capacitor c=9.43313e-17
C3 (Q VSS) capacitor c=4.05583e-17
C4 (CK VSS) capacitor c=8.17619e-17
C5 (SE VSS) capacitor c=2.75491e-17
C6 (SI VSS) capacitor c=9.1466e-17
C7 (VDD VSS) capacitor c=4.87659e-16
C8 (qbint VSS) capacitor c=4.61499e-17
C9 (n35 VSS) capacitor c=5.11501e-17
C10 (RNb VSS) capacitor c=1.20199e-16
C11 (net486 VSS) capacitor c=8.11926e-17
C12 (net490 VSS) capacitor c=1.02165e-16
C13 (CKb VSS) capacitor c=3.73091e-17
C14 (mout VSS) capacitor c=3.85275e-17
C15 (CKbb VSS) capacitor c=2.79759e-17
C16 (net469 VSS) capacitor c=5.96903e-17
C17 (n20 VSS) capacitor c=6.11724e-17
C18 (net514 VSS) capacitor c=2.26474e-18
C19 (Db VSS) capacitor c=1.30702e-16
C20 (net522 VSS) capacitor c=6.84163e-18
C21 (SEb VSS) capacitor c=4.59874e-17
C22 (net394 VSS) capacitor c=1.09553e-16
C23 (net437 VSS) capacitor c=1.24016e-18
C24 (net417 VSS) capacitor c=5.66081e-18
C25 (net425 VSS) capacitor c=4.17817e-18
C26 (net445 VSS) capacitor c=2.61316e-18
C27 (net453 VSS) capacitor c=4.79661e-18
C28 (\7\:SE VSS) capacitor c=5.58656e-17
C29 (\3\:SI VSS) capacitor c=6.11769e-17
C30 (\1\:SE VSS) capacitor c=7.51667e-17
C31 (\1\:D VSS) capacitor c=1.05664e-16
C32 (\1\:CK VSS) capacitor c=5.1554e-17
C33 (\5\:CKb VSS) capacitor c=3.21884e-17
C34 (\7\:CKbb VSS) capacitor c=2.76137e-17
C35 (\9\:CKb VSS) capacitor c=5.42306e-17
C36 (\5\:SN VSS) capacitor c=7.43119e-17
C37 (\3\:CKb VSS) capacitor c=4.51816e-17
C38 (\3\:CKbb VSS) capacitor c=5.18957e-17
C39 (\3\:RNb VSS) capacitor c=7.30377e-17
C40 (\5\:qbint VSS) capacitor c=1.38789e-16
C41 (\1\:SN VSS) capacitor c=4.71374e-17
C42 (\1\:RN VSS) capacitor c=2.97248e-17
C43 (\5\:SE VSS) capacitor c=3.43751e-17
C44 (\1\:SI VSS) capacitor c=8.80355e-17
C45 (\3\:SE VSS) capacitor c=7.47651e-17
C46 (\3\:SEb VSS) capacitor c=6.98023e-17
C47 (\4\:D VSS) capacitor c=4.25115e-17
C48 (\3\:CK VSS) capacitor c=3.53017e-17
C49 (\10\:CKb VSS) capacitor c=2.88243e-17
C50 (\11\:CKb VSS) capacitor c=3.22056e-17
C51 (\5\:CKbb VSS) capacitor c=5.04275e-17
C52 (\3\:mout VSS) capacitor c=5.60715e-17
C53 (\4\:SN VSS) capacitor c=6.7642e-17
C54 (\3\:n20 VSS) capacitor c=3.4658e-17
C55 (\4\:RNb VSS) capacitor c=4.94467e-17
C56 (\5\:RNb VSS) capacitor c=6.90286e-17
C57 (\7\:qbint VSS) capacitor c=7.32873e-17
C58 (\3\:SN VSS) capacitor c=3.89452e-17
C59 (\3\:RN VSS) capacitor c=2.83511e-17
C60 (\3\:n35 VSS) capacitor c=3.545e-17
C61 (\3\:qbint VSS) capacitor c=4.21758e-17
C62 (\6\:SE VSS) capacitor c=5.21601e-17
C63 (\2\:SI VSS) capacitor c=5.83459e-17
C64 (\4\:SE VSS) capacitor c=4.67702e-17
C65 (\2\:SEb VSS) capacitor c=5.68171e-17
C66 (\2\:SE VSS) capacitor c=4.82859e-17
C67 (\3\:D VSS) capacitor c=2.71577e-17
C68 (\2\:CK VSS) capacitor c=5.53372e-17
C69 (\6\:CKb VSS) capacitor c=2.27701e-17
C70 (\8\:CKbb VSS) capacitor c=4.20031e-17
C71 (\6\:CKbb VSS) capacitor c=3.9443e-17
C72 (\2\:mout VSS) capacitor c=4.16157e-17
C73 (\4\:n20 VSS) capacitor c=4.25167e-17
C74 (\6\:SN VSS) capacitor c=2.22187e-17
C75 (\4\:CKbb VSS) capacitor c=3.17309e-17
C76 (\4\:CKb VSS) capacitor c=3.71901e-17
C77 (\2\:CKb VSS) capacitor c=2.17093e-17
C78 (\2\:RNb VSS) capacitor c=9.49987e-17
C79 (\2\:SN VSS) capacitor c=3.56577e-17
C80 (\2\:RN VSS) capacitor c=2.21768e-17
C81 (\6\:qbint VSS) capacitor c=3.51809e-17
C82 (\2\:n35 VSS) capacitor c=3.48735e-17
C83 (\4\:qbint VSS) capacitor c=2.23038e-17
C84 (\8\:SEb VSS) capacitor c=1.32744e-17
C85 (\12\:VDD VSS) capacitor c=3.57875e-17
C86 (\14\:VDD VSS) capacitor c=2.15807e-17
C87 (\18\:CKb VSS) capacitor c=7.53285e-17
C88 (\16\:VDD VSS) capacitor c=4.5967e-17
C89 (\11\:CKbb VSS) capacitor c=1.0916e-16
C90 (\7\:Db VSS) capacitor c=1.02575e-16
C91 (\5\:n20 VSS) capacitor c=8.91518e-17
C92 (\18\:VDD VSS) capacitor c=5.83003e-17
C93 (\11\:mout VSS) capacitor c=1.93774e-16
C94 (\20\:VDD VSS) capacitor c=6.20201e-17
C95 (\7\:mout VSS) capacitor c=3.76308e-17
C96 (\4\:n35 VSS) capacitor c=7.861e-17
C97 (\22\:VDD VSS) capacitor c=5.43417e-17
C98 (\3\:net394 VSS) capacitor c=8.88414e-17
C99 (\24\:VDD VSS) capacitor c=7.30001e-17
C100 (\7\:RNb VSS) capacitor c=1.57716e-16
C101 (\9\:qbint VSS) capacitor c=6.49974e-17
C102 (\27\:VDD VSS) capacitor c=6.48088e-17
C103 (\1\:Q VSS) capacitor c=4.84648e-17
C104 (\1\:VDD VSS) capacitor c=1.16089e-16
C105 (\4\:SEb VSS) capacitor c=7.52075e-17
C106 (\9\:Db VSS) capacitor c=4.15316e-17
C107 (\12\:CKb VSS) capacitor c=7.80903e-17
C108 (\9\:CKbb VSS) capacitor c=9.45723e-17
C109 (\5\:Db VSS) capacitor c=1.93386e-16
C110 (\9\:n20 VSS) capacitor c=1.93514e-17
C111 (\9\:mout VSS) capacitor c=1.374e-16
C112 (\3\:net469 VSS) capacitor c=7.53415e-17
C113 (\4\:mout VSS) capacitor c=1.11541e-16
C114 (\8\:n35 VSS) capacitor c=6.26283e-17
C115 (\3\:net490 VSS) capacitor c=1.00647e-16
C116 (\3\:net486 VSS) capacitor c=9.37076e-17
C117 (\9\:RNb VSS) capacitor c=6.87253e-17
C118 (\12\:qbint VSS) capacitor c=5.73093e-17
C119 (\3\:Q VSS) capacitor c=1.51432e-17
C120 (\2\:qbint VSS) capacitor c=1.29501e-17
C121 (\2\:CKbb VSS) capacitor c=6.03263e-17
C122 (\2\:n20 VSS) capacitor c=2.87814e-17
C123 (\8\:qbint VSS) capacitor c=5.24355e-17
C124 (\11\:qbint VSS) capacitor c=5.13994e-17
C125 (\14\:qbint VSS) capacitor c=6.04355e-17
C126 (\7\:CKb VSS) capacitor c=2.43186e-17
C127 (\8\:CKb VSS) capacitor c=6.78167e-17
C128 (\4\:RN VSS) capacitor c=6.628e-17
C129 (\2\:D VSS) capacitor c=2.65256e-17
C130 (\6\:RNb VSS) capacitor c=1.14346e-16
C131 (\6\:n35 VSS) capacitor c=3.14645e-16
C132 (\7\:n35 VSS) capacitor c=2.52605e-16
C133 (\7\:SN VSS) capacitor c=3.09834e-16
C134 (\8\:SN VSS) capacitor c=3.49442e-16
C135 (\6\:mout VSS) capacitor c=1.47581e-16
C136 (\13\:mout VSS) capacitor c=8.13404e-17
C137 (\7\:n20 VSS) capacitor c=1.10497e-16
C138 (\8\:n20 VSS) capacitor c=8.81243e-17
C139 (\13\:CKbb VSS) capacitor c=1.32333e-16
C140 (\14\:CKbb VSS) capacitor c=6.72804e-17
C141 (\15\:CKbb VSS) capacitor c=2.52389e-16
C142 (\16\:CKbb VSS) capacitor c=1.99056e-16
C143 (\4\:CK VSS) capacitor c=3.18919e-17
C144 (\14\:CKb VSS) capacitor c=9.32695e-17
C145 (\15\:CKb VSS) capacitor c=4.08881e-16
C146 (\16\:CKb VSS) capacitor c=5.16271e-16
C147 (\17\:CKb VSS) capacitor c=1.21885e-16
C148 (\4\:Db VSS) capacitor c=1.99268e-16
C149 (\8\:SE VSS) capacitor c=6.69825e-17
C150 (\9\:SE VSS) capacitor c=5.0997e-17
C151 (\10\:SE VSS) capacitor c=4.47963e-17
C152 (\4\:SI VSS) capacitor c=4.53681e-17
C153 (\6\:SEb VSS) capacitor c=1.00378e-16
C154 (\7\:SEb VSS) capacitor c=8.27082e-17
C155 (\3\:VDD VSS) capacitor c=1.26775e-17
C156 (\4\:VDD VSS) capacitor c=2.74357e-17
C157 (\6\:VDD VSS) capacitor c=3.44631e-17
C158 (\7\:VDD VSS) capacitor c=5.19608e-17
C159 (\9\:VDD VSS) capacitor c=3.87947e-17
C160 (\10\:VDD VSS) capacitor c=6.524e-17
C161 (\26\:VDD VSS) capacitor c=3.09613e-17
Rk7 (RN \4\:RN) resistor r=0.1074 c=0
Rk38 (D \5\:D) resistor r=0.004839 c=0
Rk1 (\2\:Q Q) resistor r=0.3083 c=0
Rk2 (Q \4\:Q) resistor r=0.0627 c=0
Rk32 (\4\:CK CK) resistor r=0.1038 c=0
Rk44 (\8\:SE \9\:SE) resistor r=0.3182 c=0
Rk46 (\10\:SE SE) resistor r=0.0304 c=0
Rk45 (\9\:SE \10\:SE) resistor r=0.2328 c=0
Rk17 (\7\:SN SN) resistor r=2.5763 c=0
Rk18 (SN \8\:SN) resistor r=0.003345 c=0
Rk47 (\4\:SI SI) resistor r=0.0223 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.06254 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.4002 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.2874 c=0
Rk54 (\5\:VSS \6\:VSS) resistor r=0.1519 c=0
Rk55 (\6\:VSS \7\:VSS) resistor r=0.621 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.4289 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=1.1432 c=0
Rk58 (\9\:VSS \10\:VSS) resistor r=0.05908 c=0
Rk60 (\11\:VSS VSS) resistor r=0.1075 c=0
Rk59 (\10\:VSS \11\:VSS) resistor r=0.444 c=0
Rk61 (\3\:VSS \13\:VSS) resistor r=0.2932 c=0
Rk62 (\4\:VSS \15\:VSS) resistor r=0.04335 c=0
Rk63 (\6\:VSS \17\:VSS) resistor r=0.04335 c=0
Rk64 (\7\:VSS \19\:VSS) resistor r=0.2208 c=0
Rk65 (\9\:VSS \21\:VSS) resistor r=0.04335 c=0
Rk66 (\11\:VSS \23\:VSS) resistor r=0.3175 c=0
Rk67 (\2\:VDD \3\:VDD) resistor r=0.1002 c=0
Rk68 (\3\:VDD \4\:VDD) resistor r=0.3484 c=0
Rk69 (\4\:VDD \5\:VDD) resistor r=0.3035 c=0
Rk70 (\5\:VDD \6\:VDD) resistor r=0.06003 c=0
Rk71 (\6\:VDD \7\:VDD) resistor r=0.7374 c=0
Rk72 (\7\:VDD \8\:VDD) resistor r=0.4063 c=0
Rk73 (\8\:VDD \9\:VDD) resistor r=0.07509 c=0
Rk74 (\9\:VDD \10\:VDD) resistor r=0.7324 c=0
Rk75 (\10\:VDD \11\:VDD) resistor r=0.3963 c=0
Rk76 (\3\:VDD \13\:VDD) resistor r=0.2559 c=0
Rk77 (\4\:VDD \15\:VDD) resistor r=0.2559 c=0
Rk78 (\6\:VDD \17\:VDD) resistor r=0.3122 c=0
Rk79 (\7\:VDD \19\:VDD) resistor r=0.2365 c=0
Rk80 (\9\:VDD \21\:VDD) resistor r=0.2178 c=0
Rk81 (\10\:VDD \23\:VDD) resistor r=0.2544 c=0
Rk82 (\11\:VDD \25\:VDD) resistor r=0.382 c=0
Rk85 (\26\:VDD VDD) resistor r=0.1225 c=0
Rk83 (\11\:VDD \26\:VDD) resistor r=0.4293 c=0
Rk84 (\26\:VDD \28\:VDD) resistor r=0.373 c=0
Rk3 (\8\:qbint \10\:qbint) resistor r=0.4762 c=0
Rk4 (\10\:qbint \11\:qbint) resistor r=0.2549 c=0
Rk5 (\11\:qbint \13\:qbint) resistor r=0.27 c=0
Rk6 (\11\:qbint \14\:qbint) resistor r=0.3115 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.1981 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.1301 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.2555 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=0.9706 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.3469 c=0
Rk10 (\2\:net486 \4\:net486) resistor r=0.4085 c=0
Rk12 (\2\:net490 \4\:net490) resistor r=0.414 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.5137 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=0.2565 c=0
Rk35 (\15\:CKb \16\:CKb) resistor r=3.0628 c=0
Rk36 (\16\:CKb \17\:CKb) resistor r=0.885 c=0
Rk37 (\15\:CKb \19\:CKb) resistor r=0.5675 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.2728 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.1246 c=0
Rk21 (\5\:mout \10\:mout) resistor r=0.7108 c=0
Rk22 (\6\:mout \12\:mout) resistor r=1.0055 c=0
Rk23 (\12\:mout \13\:mout) resistor r=0.4847 c=0
Rk27 (\10\:CKbb \12\:CKbb) resistor r=0.4924 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.3175 c=0
Rk29 (\13\:CKbb \14\:CKbb) resistor r=0.23 c=0
Rk30 (\13\:CKbb \15\:CKbb) resistor r=0.626 c=0
Rk31 (\15\:CKbb \16\:CKbb) resistor r=1.4759 c=0
Rk16 (\2\:net469 \4\:net469) resistor r=0.3105 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.4561 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.5572 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.03488 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.1635 c=0
Rk40 (\3\:Db \4\:Db) resistor r=0.619 c=0
Rk41 (\4\:Db \6\:Db) resistor r=1.1229 c=0
Rk42 (\6\:Db \8\:Db) resistor r=0.5998 c=0
Rk43 (\4\:Db \10\:Db) resistor r=0.2581 c=0
Rk48 (\5\:SEb \6\:SEb) resistor r=0.7053 c=0
Rk49 (\6\:SEb \7\:SEb) resistor r=0.4832 c=0
Rk50 (\6\:SEb \9\:SEb) resistor r=0.04832 c=0
Rk11 (\2\:net394 \4\:net394) resistor r=0.5311 c=0
Rl6 (\1\:RN \2\:RN) resistor r=28.079 c=0
Rl7 (\2\:RN \3\:RN) resistor r=78.079 c=0
Rl38 (\1\:D \2\:D) resistor r=101.157 c=0
Rl40 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl39 (\2\:D \3\:D) resistor r=58.0656 c=0
Rl36 (\1\:CK \2\:CK) resistor r=166.862 c=0
Rl37 (\2\:CK \3\:CK) resistor r=89.6174 c=0
Rl48 (\6\:SE \7\:SE) resistor r=179.104 c=0
Rl47 (\5\:SE \6\:SE) resistor r=35.3072 c=0
Rl44 (\3\:SE \4\:SE) resistor r=28.079 c=0
Rl41 (\1\:SE \2\:SE) resistor r=31.8672 c=0
Rl24 (\4\:SN \5\:SN) resistor r=197.643 c=0
Rl25 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl8 (\1\:SN \2\:SN) resistor r=28.079 c=0
Rl9 (\2\:SN \3\:SN) resistor r=85.7713 c=0
Rl46 (\2\:SI \3\:SI) resistor r=26.3736 c=0
Rl45 (\1\:SI \2\:SI) resistor r=105.769 c=0
Rl11 (\5\:qbint \7\:qbint) resistor r=175 c=0
Rl10 (\5\:qbint \6\:qbint) resistor r=276.436 c=0
Rl1 (qbint \2\:qbint) resistor r=26.9069 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=72.5882 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=4.4012 c=0
Rl4 (n35 \2\:n35) resistor r=79.5379 c=0
Rl5 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl19 (RNb \4\:RNb) resistor r=165.385 c=0
Rl20 (\3\:RNb \5\:RNb) resistor r=197.643 c=0
Rl17 (RNb \2\:RNb) resistor r=821.693 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=122.31 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl12 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl34 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=14.4132 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=150.722 c=0
Rl35 (\8\:CKb \11\:CKb) resistor r=68.4643 c=0
Rl32 (\7\:CKb \8\:CKb) resistor r=208.53 c=0
Rl26 (mout \2\:mout) resistor r=24.2328 c=0
Rl27 (\2\:mout \3\:mout) resistor r=114.617 c=0
Rl29 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl28 (\5\:CKbb \6\:CKbb) resistor r=62.2302 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=159.159 c=0
Rl14 (CKbb \2\:CKbb) resistor r=34.2969 c=0
Rl16 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl21 (n20 \2\:n20) resistor r=133.849 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=28.0797 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=73.9143 c=0
Rl42 (SEb \2\:SEb) resistor r=26.4372 c=0
Rl43 (\2\:SEb \3\:SEb) resistor r=111.5 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz25 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz26 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz27 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz28 (\1\:VDD \11\:VDD) resistor r=6.25 c=0
Rz2 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (net486 \2\:net486) resistor r=75 c=0
Rz5 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz6 (net490 \2\:net490) resistor r=75 c=0
Rz7 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz15 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz11 (\4\:mout \5\:mout) resistor r=75 c=0
Rz12 (\9\:mout \10\:mout) resistor r=75 c=0
Rz14 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz9 (net469 \2\:net469) resistor r=75 c=0
Rz10 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz13 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz16 (\5\:Db \6\:Db) resistor r=75 c=0
Rz17 (\9\:Db \10\:Db) resistor r=75 c=0
Rz18 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry17 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry18 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry20 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry21 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry26 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry27 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry2 (\9\:qbint \10\:qbint) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=31 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry7 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=62 c=0
Ry13 (Db \3\:Db) resistor r=62 c=0
Ry14 (\7\:Db \8\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net394 \2\:net394) resistor r=62 c=0
Ry5 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx17 (\3\:D \5\:D) resistor r=45 c=0
Rx13 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:SE \8\:SE) resistor r=45 c=0
Rx19 (\4\:SE \9\:SE) resistor r=45 c=0
Rx20 (\6\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx21 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx2 (\4\:qbint \14\:qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx14 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx15 (\4\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \22\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.83846e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
mn11 (net522 \4\:D \14\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=5.46e-14 ps=1.69e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.73558e-07 sb=7.89712e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (\9\:Db \3\:SEb net522 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.2e-14 ps=9.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.28558e-07 sb=5.34712e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (\9\:Db \3\:SE net534 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.2e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.99135e-07 sb=3.41635e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn13 (net534 \1\:SI \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.04135e-07 sb=2.36635e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn45 (\12\:qbint \3\:n35 \22\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.445e-14 ad=4.613e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn50 (\3\:net486 \3\:SN \20\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.115e-14 ad=3.28e-14 ps=1.96e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83537e-07 sb=5.95e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn52 (net490 \7\:qbint \3\:net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=3.383e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.88537e-07 sb=3.9e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.383e-14 ps=7.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98537e-07 sb=1.8e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn53 (\8\:n35 CKb \3\:net490 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=4.92e-14 ps=8.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.7e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\8\:n35 CKbb \4\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=4.92e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\9\:mout \4\:RNb \3\:net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.69e-14 ps=6.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40305e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn32 (\9\:mout \3\:n20 net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.8e-14 ad=3.69e-14 ps=1.09e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.17805e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn30 (net469 \4\:SN \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=6.8e-14 ps=8.3e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.29268e-07 sb=8.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \18\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=2.255e-14 ps=8.3e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.84268e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.255e-14 ad=4.715e-14 ps=6.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13927e-06 sb=4.15e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\5\:Db \11\:CKb \9\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.87e-14 ps=8.7e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41427e-06 sb=1.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn22 (\9\:RNb \3\:RN \20\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.115e-14 ad=2.03e-14 ps=1.96e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.93103e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn21 (\9\:CKbb \10\:CKb \16\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.14e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn20 (\12\:CKb \3\:CK \14\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=2.03e-14 ps=1.69e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24138e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\4\:SEb \5\:SE \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24207e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45 (\9\:qbint n35 \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=3.58e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.15484e-07 sd=160n sca=20.3238 \
        scb=0.019357 scc=0.00139603 m=(1)
mp50 (\3\:net394 \1\:SN \24\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.1305e-13 ad=5.3e-14 ps=1.38e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92339e-07 sb=4.66532e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp52 (\3\:net394 \5\:qbint net437 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=5.3e-14 ps=7.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05403e-07 sb=4e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp51 (net437 \3\:RNb \22\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.145e-14 ad=1.86e-14 ps=1.21e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.10403e-07 sb=2.95e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp53 (\4\:n35 \3\:CKbb net394 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp40 (\4\:n35 \3\:CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2.25e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp31 (net417 RNb \20\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4105e-13 ad=5.58e-14 ps=1.72e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.62e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp32 (\11\:mout n20 net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.51e-14 ps=9.8e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.395e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp30 (\11\:mout \5\:SN \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1945e-13 ad=6.51e-14 ps=1.55e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.14e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp35 (net425 mout \18\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1945e-13 ad=6.045e-14 ps=1.55e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.6e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp36 (\5\:n20 \9\:CKb net425 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=9.455e-14 ps=1.01e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=5.2e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp25 (\5\:n20 \7\:CKbb \7\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.455e-14 ps=9.6e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.7e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp22 (\7\:RNb \1\:RN \24\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1305e-13 ad=2.99e-14 ps=1.38e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3907e-07 sb=8.30349e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp21 (\11\:CKbb \5\:CKb \16\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.052e-14 ps=7.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.6e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp20 (\18\:CKb \1\:CK \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (\8\:SEb \7\:SE \12\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=14.5503 \
        scb=0.0131195 scc=0.000188015 m=(1)
ends SDFFSRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:52 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX2 CK D Q RN SE SI SN VDD VSS
mp11 (net445 \1\:D \17\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=2.34e-14 ps=1.28e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.84679e-07 sb=7.15064e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.89679e-07 sb=6.10064e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp14 (Db SEb net453 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.875e-14 \
        ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.94679e-07 sb=4.05064e-07 sd=160n sca=14.1011 scb=0.0127228 \
        scc=0.000754417 m=(1)
mp13 (net453 \3\:SI \15\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.64679e-07 sb=2.35064e-07 sd=160n sca=14.3864 \
        scb=0.0127998 scc=0.000754431 m=(1)
mp55 (\1\:Q qbint \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.61e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2359e-07 sd=160n sca=34.9044 \
        scb=0.0259128 scc=0.00343869 m=(2)
C1 (RN VSS) capacitor c=3.90112e-17
C2 (D VSS) capacitor c=5.34687e-17
C3 (Q VSS) capacitor c=3.2359e-17
C4 (VDD VSS) capacitor c=5.20649e-16
C5 (CK VSS) capacitor c=5.49145e-17
C6 (SE VSS) capacitor c=3.55505e-17
C7 (SN VSS) capacitor c=3.78456e-16
C8 (SI VSS) capacitor c=9.07852e-17
C9 (qbint VSS) capacitor c=1.48653e-16
C10 (n35 VSS) capacitor c=4.81519e-17
C11 (RNb VSS) capacitor c=5.02041e-17
C12 (net486 VSS) capacitor c=7.68481e-17
C13 (net490 VSS) capacitor c=9.73723e-17
C14 (CKb VSS) capacitor c=3.87621e-17
C15 (mout VSS) capacitor c=4.43934e-17
C16 (CKbb VSS) capacitor c=2.78996e-17
C17 (net469 VSS) capacitor c=6.94527e-17
C18 (n20 VSS) capacitor c=3.36135e-17
C19 (Db VSS) capacitor c=1.25408e-16
C20 (net522 VSS) capacitor c=5.55836e-18
C21 (SEb VSS) capacitor c=4.73269e-17
C22 (net394 VSS) capacitor c=1.13761e-16
C23 (net437 VSS) capacitor c=1.24016e-18
C24 (net417 VSS) capacitor c=2.09234e-18
C25 (net425 VSS) capacitor c=3.37618e-18
C26 (net445 VSS) capacitor c=2.53045e-18
C27 (net453 VSS) capacitor c=4.35364e-18
C28 (\7\:SE VSS) capacitor c=7.28592e-17
C29 (\3\:SI VSS) capacitor c=6.63562e-17
C30 (\1\:SE VSS) capacitor c=7.62269e-17
C31 (\1\:D VSS) capacitor c=9.53868e-17
C32 (\1\:CK VSS) capacitor c=3.19081e-17
C33 (\5\:CKb VSS) capacitor c=3.71724e-17
C34 (\7\:CKbb VSS) capacitor c=4.08721e-17
C35 (\8\:CKb VSS) capacitor c=6.21902e-17
C36 (\5\:SN VSS) capacitor c=7.36903e-17
C37 (\3\:n20 VSS) capacitor c=9.61427e-17
C38 (\2\:RNb VSS) capacitor c=1.73162e-16
C39 (\3\:CKb VSS) capacitor c=3.7077e-17
C40 (\3\:CKbb VSS) capacitor c=4.77985e-17
C41 (\4\:RNb VSS) capacitor c=7.28683e-17
C42 (\8\:qbint VSS) capacitor c=1.35408e-16
C43 (\1\:SN VSS) capacitor c=5.00028e-17
C44 (\1\:RN VSS) capacitor c=3.10126e-17
C45 (\5\:SE VSS) capacitor c=2.63849e-17
C46 (\1\:SI VSS) capacitor c=7.63145e-17
C47 (\3\:SE VSS) capacitor c=7.15827e-17
C48 (\3\:SEb VSS) capacitor c=7.53937e-17
C49 (\4\:D VSS) capacitor c=4.57235e-17
C50 (\4\:CK VSS) capacitor c=3.57582e-17
C51 (\9\:CKb VSS) capacitor c=2.40211e-17
C52 (\10\:CKb VSS) capacitor c=3.33242e-17
C53 (\5\:CKbb VSS) capacitor c=5.03159e-17
C54 (\3\:mout VSS) capacitor c=5.80144e-17
C55 (\4\:SN VSS) capacitor c=6.05516e-17
C56 (\5\:RNb VSS) capacitor c=7.26508e-17
C57 (\10\:qbint VSS) capacitor c=7.49677e-17
C58 (\3\:SN VSS) capacitor c=3.86718e-17
C59 (\3\:RN VSS) capacitor c=2.61693e-17
C60 (\3\:n35 VSS) capacitor c=3.34873e-17
C61 (\6\:SE VSS) capacitor c=4.88996e-17
C62 (\2\:SI VSS) capacitor c=5.06382e-17
C63 (\4\:SE VSS) capacitor c=4.03953e-17
C64 (\2\:SEb VSS) capacitor c=5.31605e-17
C65 (\2\:SE VSS) capacitor c=4.65152e-17
C66 (\3\:D VSS) capacitor c=2.78482e-17
C67 (\3\:CK VSS) capacitor c=3.96455e-17
C68 (\6\:CKb VSS) capacitor c=4.60366e-17
C69 (\8\:CKbb VSS) capacitor c=3.33606e-17
C70 (\6\:CKbb VSS) capacitor c=4.9109e-17
C71 (\2\:mout VSS) capacitor c=4.4017e-17
C72 (\6\:SN VSS) capacitor c=2.13174e-17
C73 (\4\:CKbb VSS) capacitor c=3.13719e-17
C74 (\4\:CKb VSS) capacitor c=3.84954e-17
C75 (\2\:CKb VSS) capacitor c=2.02948e-17
C76 (\3\:RNb VSS) capacitor c=1.03365e-16
C77 (\2\:SN VSS) capacitor c=4.24883e-17
C78 (\2\:RN VSS) capacitor c=2.24026e-17
C79 (\9\:qbint VSS) capacitor c=4.61211e-17
C80 (\2\:n35 VSS) capacitor c=3.42671e-17
C81 (\8\:SEb VSS) capacitor c=2.92271e-17
C82 (\15\:VDD VSS) capacitor c=4.06162e-17
C83 (\17\:VDD VSS) capacitor c=3.51775e-17
C84 (\17\:CKb VSS) capacitor c=5.06976e-17
C85 (\19\:VDD VSS) capacitor c=4.9709e-17
C86 (\13\:CKbb VSS) capacitor c=1.00936e-16
C87 (\8\:Db VSS) capacitor c=7.89544e-17
C88 (\5\:n20 VSS) capacitor c=8.9432e-17
C89 (\21\:VDD VSS) capacitor c=7.24313e-17
C90 (\9\:mout VSS) capacitor c=2.06458e-16
C91 (\23\:VDD VSS) capacitor c=6.36567e-17
C92 (\4\:mout VSS) capacitor c=3.45242e-17
C93 (\4\:n35 VSS) capacitor c=8.2109e-17
C94 (\25\:VDD VSS) capacitor c=5.22521e-17
C95 (\3\:net394 VSS) capacitor c=9.59978e-17
C96 (\27\:VDD VSS) capacitor c=6.58558e-17
C97 (\7\:RNb VSS) capacitor c=1.74849e-16
C98 (\12\:qbint VSS) capacitor c=6.03059e-17
C99 (\1\:Q VSS) capacitor c=7.36755e-17
C100 (\1\:VDD VSS) capacitor c=1.59291e-16
C101 (\4\:SEb VSS) capacitor c=5.9992e-17
C102 (\6\:Db VSS) capacitor c=3.93362e-17
C103 (\11\:CKb VSS) capacitor c=6.95172e-17
C104 (\15\:CKbb VSS) capacitor c=8.45529e-17
C105 (\4\:Db VSS) capacitor c=1.55547e-16
C106 (\9\:n20 VSS) capacitor c=2.07668e-17
C107 (\11\:mout VSS) capacitor c=1.59419e-16
C108 (\3\:net469 VSS) capacitor c=7.23598e-17
C109 (\7\:mout VSS) capacitor c=1.36928e-16
C110 (\8\:n35 VSS) capacitor c=6.64854e-17
C111 (\3\:net490 VSS) capacitor c=9.30075e-17
C112 (\3\:net486 VSS) capacitor c=7.62747e-17
C113 (\9\:RNb VSS) capacitor c=7.67746e-17
C114 (\16\:qbint VSS) capacitor c=7.09271e-17
C115 (\3\:Q VSS) capacitor c=4.4453e-17
C116 (\2\:CKbb VSS) capacitor c=5.77937e-17
C117 (\2\:n20 VSS) capacitor c=6.87702e-17
C118 (\11\:qbint VSS) capacitor c=8.85612e-17
C119 (\14\:qbint VSS) capacitor c=5.14642e-17
C120 (\15\:qbint VSS) capacitor c=5.59866e-17
C121 (\7\:CKb VSS) capacitor c=7.34998e-17
C122 (\4\:RN VSS) capacitor c=8.3503e-17
C123 (\2\:D VSS) capacitor c=2.80555e-17
C124 (\6\:RNb VSS) capacitor c=1.18387e-16
C125 (\6\:n35 VSS) capacitor c=3.17976e-16
C126 (\7\:n35 VSS) capacitor c=2.634e-16
C127 (\7\:SN VSS) capacitor c=3.289e-16
C128 (\6\:mout VSS) capacitor c=1.41117e-16
C129 (\13\:mout VSS) capacitor c=9.12547e-17
C130 (\7\:n20 VSS) capacitor c=1.07857e-16
C131 (\8\:n20 VSS) capacitor c=9.01864e-17
C132 (\9\:CKbb VSS) capacitor c=7.00965e-17
C133 (\10\:CKbb VSS) capacitor c=1.31438e-16
C134 (\11\:CKbb VSS) capacitor c=2.85818e-16
C135 (\12\:CKbb VSS) capacitor c=2.00611e-16
C136 (\13\:CKb VSS) capacitor c=8.5312e-17
C137 (\14\:CKb VSS) capacitor c=4.09922e-16
C138 (\15\:CKb VSS) capacitor c=5.67609e-16
C139 (\16\:CKb VSS) capacitor c=1.28046e-16
C140 (\5\:CK VSS) capacitor c=7.61828e-17
C141 (\6\:D VSS) capacitor c=8.93557e-17
C142 (\3\:Db VSS) capacitor c=2.06949e-16
C143 (\4\:SI VSS) capacitor c=4.54971e-17
C144 (\8\:SE VSS) capacitor c=6.78633e-17
C145 (\9\:SE VSS) capacitor c=8.34943e-17
C146 (\10\:SE VSS) capacitor c=5.33564e-17
C147 (\6\:SEb VSS) capacitor c=1.03344e-16
C148 (\7\:SEb VSS) capacitor c=1.13899e-16
C149 (\3\:VDD VSS) capacitor c=1.97303e-17
C150 (\4\:VDD VSS) capacitor c=2.32474e-17
C151 (\5\:VDD VSS) capacitor c=6.18585e-18
C152 (\7\:VDD VSS) capacitor c=5.42274e-17
C153 (\8\:VDD VSS) capacitor c=2.61359e-17
C154 (\10\:VDD VSS) capacitor c=6.33521e-17
C155 (\11\:VDD VSS) capacitor c=4.26509e-17
C156 (\13\:VDD VSS) capacitor c=1.64205e-16
Rk7 (RN \4\:RN) resistor r=0.03 c=0
Rk40 (D \6\:D) resistor r=0.01506 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.06004 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.4153 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.2914 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.08168 c=0
Rk56 (\6\:VSS \7\:VSS) resistor r=0.5871 c=0
Rk57 (\7\:VSS \8\:VSS) resistor r=0.6172 c=0
Rk58 (\8\:VSS \9\:VSS) resistor r=1.0138 c=0
Rk59 (\9\:VSS \10\:VSS) resistor r=0.1906 c=0
Rk62 (\11\:VSS VSS) resistor r=0.04222 c=0
Rk60 (\10\:VSS \11\:VSS) resistor r=0.3035 c=0
Rk63 (\3\:VSS \14\:VSS) resistor r=0.3135 c=0
Rk64 (\4\:VSS \16\:VSS) resistor r=0.04336 c=0
Rk65 (\5\:VSS \18\:VSS) resistor r=0.04336 c=0
Rk66 (\7\:VSS \20\:VSS) resistor r=0.2353 c=0
Rk67 (\9\:VSS \22\:VSS) resistor r=0.2896 c=0
Rk1 (Q \2\:Q) resistor r=0.04176 c=0
Rk2 (\2\:Q \4\:Q) resistor r=0.4116 c=0
Rk70 (\2\:VDD \3\:VDD) resistor r=0.1178 c=0
Rk71 (\3\:VDD \4\:VDD) resistor r=0.3886 c=0
Rk72 (\4\:VDD \5\:VDD) resistor r=0.2255 c=0
Rk73 (\5\:VDD \6\:VDD) resistor r=0.1203 c=0
Rk74 (\6\:VDD \7\:VDD) resistor r=0.6172 c=0
Rk75 (\7\:VDD \8\:VDD) resistor r=0.5116 c=0
Rk76 (\8\:VDD \9\:VDD) resistor r=0.0751 c=0
Rk77 (\9\:VDD \10\:VDD) resistor r=0.6925 c=0
Rk78 (\10\:VDD \11\:VDD) resistor r=0.3962 c=0
Rk79 (\11\:VDD \12\:VDD) resistor r=0.1153 c=0
Rk82 (\13\:VDD VDD) resistor r=0.08489 c=0
Rk80 (\12\:VDD \13\:VDD) resistor r=0.2608 c=0
Rk83 (\3\:VDD \16\:VDD) resistor r=0.2327 c=0
Rk84 (\4\:VDD \18\:VDD) resistor r=0.3505 c=0
Rk85 (\5\:VDD \20\:VDD) resistor r=0.328 c=0
Rk86 (\7\:VDD \22\:VDD) resistor r=0.2948 c=0
Rk87 (\8\:VDD \24\:VDD) resistor r=0.2211 c=0
Rk88 (\10\:VDD \26\:VDD) resistor r=0.2581 c=0
Rk89 (\11\:VDD \28\:VDD) resistor r=0.2746 c=0
Rk37 (\5\:CK CK) resistor r=0.1318 c=0
Rk46 (\8\:SE \9\:SE) resistor r=0.3533 c=0
Rk48 (\10\:SE SE) resistor r=0.002533 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.4083 c=0
Rk16 (\7\:SN SN) resistor r=2.6432 c=0
Rk17 (SN \8\:SN) resistor r=0.004209 c=0
Rk45 (\4\:SI SI) resistor r=0.01946 c=0
Rk3 (\11\:qbint \13\:qbint) resistor r=0.5771 c=0
Rk4 (\13\:qbint \14\:qbint) resistor r=0.1217 c=0
Rk5 (\14\:qbint \15\:qbint) resistor r=0.2952 c=0
Rk6 (\14\:qbint \17\:qbint) resistor r=0.2994 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.2007 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.1192 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.1633 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=0.9689 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.4667 c=0
Rk10 (\2\:net486 \4\:net486) resistor r=0.3696 c=0
Rk11 (\2\:net490 \4\:net490) resistor r=0.3932 c=0
Rk32 (\12\:CKb \13\:CKb) resistor r=0.3743 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.2517 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=3.2991 c=0
Rk35 (\15\:CKb \16\:CKb) resistor r=0.8595 c=0
Rk36 (\14\:CKb \18\:CKb) resistor r=0.2665 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.08716 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.3071 c=0
Rk21 (\6\:mout \10\:mout) resistor r=1.0086 c=0
Rk22 (\8\:mout \12\:mout) resistor r=0.9249 c=0
Rk23 (\10\:mout \13\:mout) resistor r=0.4058 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.2888 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.6598 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=1.5701 c=0
Rk30 (\10\:CKbb \14\:CKbb) resistor r=0.3783 c=0
Rk31 (\14\:CKbb \16\:CKbb) resistor r=0.4604 c=0
Rk18 (\2\:net469 \4\:net469) resistor r=0.3107 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.4725 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.5302 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.06524 c=0
Rk41 (\2\:Db \3\:Db) resistor r=0.7223 c=0
Rk42 (\3\:Db \5\:Db) resistor r=0.9743 c=0
Rk43 (\3\:Db \7\:Db) resistor r=0.2007 c=0
Rk44 (\5\:Db \9\:Db) resistor r=0.5353 c=0
Rk49 (\5\:SEb \6\:SEb) resistor r=0.5142 c=0
Rk50 (\6\:SEb \7\:SEb) resistor r=0.7687 c=0
Rk51 (\6\:SEb \9\:SEb) resistor r=0.4158 c=0
Rk12 (\2\:net394 \4\:net394) resistor r=0.5841 c=0
Rl9 (\1\:RN \2\:RN) resistor r=31.9251 c=0
Rl10 (\2\:RN \3\:RN) resistor r=64.6174 c=0
Rl41 (\1\:D \2\:D) resistor r=108.849 c=0
Rl43 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl42 (\2\:D \3\:D) resistor r=46.5271 c=0
Rl38 (\1\:CK \2\:CK) resistor r=82.4108 c=0
Rl40 (\2\:CK \4\:CK) resistor r=80.4877 c=0
Rl39 (\2\:CK \3\:CK) resistor r=3.3229 c=0
Rl51 (\6\:SE \7\:SE) resistor r=261.796 c=0
Rl50 (\5\:SE \6\:SE) resistor r=39.1533 c=0
Rl47 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl44 (\1\:SE \2\:SE) resistor r=33.7903 c=0
Rl27 (\4\:SN \5\:SN) resistor r=174.566 c=0
Rl28 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl11 (\1\:SN \2\:SN) resistor r=60.7713 c=0
Rl12 (\2\:SN \3\:SN) resistor r=89.6174 c=0
Rl49 (\2\:SI \3\:SI) resistor r=50.7887 c=0
Rl48 (\1\:SI \2\:SI) resistor r=101.156 c=0
Rl14 (\10\:qbint \8\:qbint) resistor r=178.846 c=0
Rl13 (\9\:qbint \8\:qbint) resistor r=301.835 c=0
Rl7 (n35 \2\:n35) resistor r=59.6154 c=0
Rl8 (\2\:n35 \3\:n35) resistor r=29.9451 c=0
Rl20 (RNb \2\:RNb) resistor r=155.335 c=0
Rl23 (\4\:RNb \5\:RNb) resistor r=199.566 c=0
Rl21 (\2\:RNb \3\:RNb) resistor r=927.462 c=0
Rl22 (\3\:RNb \4\:RNb) resistor r=24.2328 c=0
Rl33 (\5\:CKb \6\:CKb) resistor r=120.387 c=0
Rl36 (\6\:CKb \9\:CKb) resistor r=32.9432 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl15 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=144.953 c=0
Rl37 (\7\:CKb \10\:CKb) resistor r=64.6181 c=0
Rl34 (\6\:CKb \7\:CKb) resistor r=258.107 c=0
Rl29 (mout \2\:mout) resistor r=28.079 c=0
Rl30 (\2\:mout \3\:mout) resistor r=131.925 c=0
Rl32 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl31 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=136.082 c=0
Rl17 (CKbb \2\:CKbb) resistor r=34.2969 c=0
Rl19 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=174.456 c=0
Rl24 (n20 \2\:n20) resistor r=56.6776 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=2.8623 c=0
Rl45 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl46 (\2\:SEb \3\:SEb) resistor r=123.799 c=0
Rz19 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz26 (\2\:VDD \1\:VDD) resistor r=15 c=0
Rz27 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz28 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz29 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (net486 \2\:net486) resistor r=75 c=0
Rz5 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz6 (net490 \2\:net490) resistor r=75 c=0
Rz7 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz15 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz11 (\7\:mout \8\:mout) resistor r=75 c=0
Rz12 (\11\:mout \12\:mout) resistor r=75 c=0
Rz14 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz9 (net469 \2\:net469) resistor r=75 c=0
Rz10 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz13 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz16 (\4\:Db \5\:Db) resistor r=75 c=0
Rz17 (\6\:Db \7\:Db) resistor r=75 c=0
Rz18 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry16 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=31 c=0
Ry19 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry23 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry24 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry25 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=31 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=31 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry7 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=20.6667 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net394 \2\:net394) resistor r=62 c=0
Ry5 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx17 (\3\:D \6\:D) resistor r=45 c=0
Rx16 (\3\:CK \5\:CK) resistor r=45 c=0
Rx19 (\2\:SE \8\:SE) resistor r=45 c=0
Rx20 (\4\:SE \9\:SE) resistor r=45 c=0
Rx21 (\6\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx2 (\15\:qbint qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\3\:RNb \6\:RNb) resistor r=45 c=0
Rx13 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn11 (net522 \4\:D \15\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=4.29e-14 ps=1.56e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.28942e-07 sb=9.17212e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn12 (\6\:Db \3\:SEb net522 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=6.075e-14 ps=8.5e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.38942e-07 sb=7.07212e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn14 (\6\:Db \3\:SE net534 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.075e-14 ps=6.4e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.86442e-07 sb=4.42019e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn13 (net534 \1\:SI \13\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=1.56e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91442e-07 sb=3.37019e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn55_1__rcx (\3\:Q qbint \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.043e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.88846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\16\:qbint \3\:n35 \11\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.445e-14 ad=4.612e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.25e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn50 (\3\:net486 \3\:SN \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.205e-14 ad=3.28e-14 ps=1.15e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33537e-07 sb=6.05e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn52 (net490 \10\:qbint \3\:net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38537e-07 sb=4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.997e-14 ad=3.28e-14 ps=8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.43537e-07 sb=1.95e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn53 (\8\:n35 CKb \3\:net490 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.92e-14 ps=8.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.7e-07 sd=160n sca=10.541 \
        scb=0.00979836 scc=0.000342932 m=(1)
mn40 (\8\:n35 CKbb \7\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=4.92e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.541 \
        scb=0.00979836 scc=0.000342932 m=(1)
mn31 (\11\:mout RNb \3\:net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.588e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.265e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn32 (\11\:mout n20 net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.588e-14 ps=7.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.045e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (net469 \4\:SN \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.612e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=8.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \19\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=2.05e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=3.28e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\4\:Db \10\:CKb \9\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.51e-14 ps=7.3e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2.2e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn22 (\9\:RNb \3\:RN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.15e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\15\:CKbb \9\:CKb \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.845e-14 ad=2.03e-14 ps=1.36e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn20 (\11\:CKb \4\:CK \15\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=2.03e-14 ps=1.56e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37914e-06 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn10 (\4\:SEb \5\:SE \13\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41534e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp45 (\12\:qbint n35 \13\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.27e-14 ps=1.1e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.7e-07 sd=160n sca=36.1524 \
        scb=0.0235548 scc=0.00420472 m=(1)
mp50 (\3\:net394 \1\:SN \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.1695e-13 ad=4.96e-14 ps=1.64e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85323e-07 sb=6.05e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp52 (\3\:net394 \8\:qbint net437 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.90323e-07 sb=4e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp51 (net437 \4\:RNb \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.145e-14 ad=1.86e-14 ps=1.21e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95323e-07 sb=2.95e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp53 (\4\:n35 \3\:CKbb net394 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=7.595e-14 ps=1.13e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=31.4735 \
        scb=0.0225197 scc=0.00370874 m=(1)
mp40 (\4\:n35 \3\:CKb \4\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=7.595e-14 ps=9.6e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.7e-07 sd=160n sca=31.4735 \
        scb=0.0225197 scc=0.00370874 m=(1)
mp31 (net417 \2\:RNb \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.97e-13 ad=1.86e-14 ps=2.13e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.17952e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\9\:mout \3\:n20 net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.975e-14 ps=7.4e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.07452e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout \5\:SN \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.975e-14 ps=1.49e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.04516e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 mout \21\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.045e-14 ps=1.49e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.66613e-07 sb=6.71935e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\5\:n20 \8\:CKb net425 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=8.038e-14 ps=1.01e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20661e-06 sb=4.31935e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp25 (\5\:n20 \7\:CKbb \8\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=8.038e-14 ps=1.02e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38089e-06 sb=2e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp22 (\7\:RNb \1\:RN \27\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=3.762e-14 ps=1.64e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=4.2093e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\13\:CKbb \5\:CKb \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.35e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp20 (\17\:CKb \1\:CK \17\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.20581e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp10 (\8\:SEb \7\:SE \15\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47326e-07 sb=1.4e-07 sd=160n sca=11.412 \
        scb=0.00825607 scc=8.8825e-05 m=(1)
ends SDFFSRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:53 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX4 CK D Q RN SE SI SN VDD VSS
mp11 (net445 \1\:D \21\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=5.27308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\8\:Db \3\:SE net445 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=4.22308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\8\:Db \3\:SEb net453 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45064e-07 sb=2.17308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp13 (net453 \1\:SI \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.50064e-07 sb=1.12308e-07 sd=160n sca=17.4322 \
        scb=0.015316 scc=0.00137893 m=(1)
mp55_1__rcx (Q qbint \14\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28949e-06 sd=160n sca=35.1619 \
        scb=0.02637 scc=0.00345369 m=(4)
C1 (RN VSS) capacitor c=5.9658e-17
C2 (D VSS) capacitor c=5.21983e-17
C3 (Q VSS) capacitor c=2.44956e-16
C4 (VDD VSS) capacitor c=5.07966e-16
C5 (CK VSS) capacitor c=4.25237e-17
C6 (SE VSS) capacitor c=1.03735e-16
C7 (SN VSS) capacitor c=2.35169e-16
C8 (SI VSS) capacitor c=9.87213e-17
C9 (qbint VSS) capacitor c=2.30768e-16
C10 (n35 VSS) capacitor c=1.55975e-17
C11 (RNb VSS) capacitor c=2.50169e-17
C12 (net490 VSS) capacitor c=8.661e-17
C13 (net486 VSS) capacitor c=1.46116e-16
C14 (CKb VSS) capacitor c=3.83318e-17
C15 (mout VSS) capacitor c=9.68847e-17
C16 (CKbb VSS) capacitor c=3.08044e-17
C17 (net469 VSS) capacitor c=5.5088e-17
C18 (n20 VSS) capacitor c=3.6203e-17
C19 (Db VSS) capacitor c=4.41009e-17
C20 (net522 VSS) capacitor c=1.37142e-18
C21 (SEb VSS) capacitor c=6.35501e-17
C22 (net534 VSS) capacitor c=1.71309e-18
C23 (net437 VSS) capacitor c=1.29793e-18
C24 (net394 VSS) capacitor c=9.60395e-17
C25 (net417 VSS) capacitor c=6.38365e-18
C26 (net425 VSS) capacitor c=1.44616e-18
C27 (net445 VSS) capacitor c=1.43883e-18
C28 (net453 VSS) capacitor c=1.71168e-18
C29 (\4\:SE VSS) capacitor c=3.01101e-17
C30 (\1\:SI VSS) capacitor c=7.2315e-17
C31 (\3\:SEb VSS) capacitor c=7.14067e-17
C32 (\3\:SE VSS) capacitor c=9.22986e-17
C33 (\1\:D VSS) capacitor c=1.03623e-16
C34 (\1\:CK VSS) capacitor c=7.09869e-17
C35 (\10\:CKb VSS) capacitor c=3.04452e-17
C36 (\8\:CKbb VSS) capacitor c=4.39317e-17
C37 (\5\:CKb VSS) capacitor c=6.16845e-17
C38 (\4\:mout VSS) capacitor c=6.981e-17
C39 (\6\:SN VSS) capacitor c=8.05155e-17
C40 (\3\:n20 VSS) capacitor c=6.22312e-17
C41 (\6\:RNb VSS) capacitor c=1.17424e-16
C42 (\3\:CKb VSS) capacitor c=4.36028e-17
C43 (\3\:CKbb VSS) capacitor c=5.17995e-17
C44 (\3\:SN VSS) capacitor c=5.02823e-17
C45 (\16\:qbint VSS) capacitor c=9.90159e-17
C46 (\2\:RNb VSS) capacitor c=5.04887e-17
C47 (\3\:RN VSS) capacitor c=3.19642e-17
C48 (\6\:SE VSS) capacitor c=2.19566e-17
C49 (\3\:SI VSS) capacitor c=7.50675e-17
C50 (\1\:SE VSS) capacitor c=5.77599e-17
C51 (\4\:D VSS) capacitor c=8.79536e-17
C52 (\3\:CK VSS) capacitor c=3.37617e-17
C53 (\7\:CKb VSS) capacitor c=2.83321e-17
C54 (\9\:CKb VSS) capacitor c=5.81915e-17
C55 (\9\:CKbb VSS) capacitor c=6.69271e-17
C56 (\5\:SN VSS) capacitor c=7.55788e-17
C57 (\4\:n20 VSS) capacitor c=3.39289e-17
C58 (\8\:RNb VSS) capacitor c=4.30186e-17
C59 (\1\:SN VSS) capacitor c=4.74138e-17
C60 (\13\:qbint VSS) capacitor c=2.99629e-17
C61 (\5\:RNb VSS) capacitor c=4.15857e-17
C62 (\1\:RN VSS) capacitor c=3.62308e-17
C63 (\5\:SE VSS) capacitor c=1.733e-17
C64 (\2\:SI VSS) capacitor c=5.23317e-17
C65 (\4\:SEb VSS) capacitor c=4.3037e-17
C66 (\2\:SE VSS) capacitor c=6.79669e-17
C67 (\2\:SEb VSS) capacitor c=4.57028e-17
C68 (\3\:D VSS) capacitor c=4.21819e-17
C69 (\2\:CK VSS) capacitor c=5.87438e-17
C70 (\8\:CKb VSS) capacitor c=5.33803e-17
C71 (\5\:CKbb VSS) capacitor c=4.59667e-17
C72 (\6\:CKb VSS) capacitor c=4.32095e-17
C73 (\7\:CKbb VSS) capacitor c=5.54029e-17
C74 (\3\:mout VSS) capacitor c=2.02168e-17
C75 (\7\:SN VSS) capacitor c=2.51954e-17
C76 (\4\:CKbb VSS) capacitor c=3.21302e-17
C77 (\4\:CKb VSS) capacitor c=3.89693e-17
C78 (\2\:CKb VSS) capacitor c=2.67405e-17
C79 (\7\:RNb VSS) capacitor c=7.88614e-17
C80 (\4\:SN VSS) capacitor c=2.13464e-17
C81 (\15\:qbint VSS) capacitor c=3.23783e-17
C82 (\4\:RNb VSS) capacitor c=3.12308e-17
C83 (\2\:RN VSS) capacitor c=3.87164e-17
C84 (\1\:VDD VSS) capacitor c=2.61559e-17
C85 (\9\:SEb VSS) capacitor c=1.00144e-16
C86 (\19\:VDD VSS) capacitor c=2.97754e-17
C87 (\8\:Db VSS) capacitor c=1.301e-16
C88 (\21\:VDD VSS) capacitor c=3.73005e-17
C89 (\11\:CKb VSS) capacitor c=7.7734e-17
C90 (\23\:VDD VSS) capacitor c=3.15869e-17
C91 (\13\:CKbb VSS) capacitor c=4.2242e-17
C92 (\6\:Db VSS) capacitor c=1.05231e-16
C93 (\7\:n20 VSS) capacitor c=9.79351e-17
C94 (\25\:VDD VSS) capacitor c=5.76041e-17
C95 (\6\:mout VSS) capacitor c=1.95453e-16
C96 (\27\:VDD VSS) capacitor c=5.34204e-17
C97 (\11\:mout VSS) capacitor c=3.55912e-17
C98 (\9\:n35 VSS) capacitor c=7.63216e-17
C99 (\29\:VDD VSS) capacitor c=3.07421e-17
C100 (\3\:net394 VSS) capacitor c=8.11713e-17
C101 (\31\:VDD VSS) capacitor c=2.01785e-17
C102 (\9\:RNb VSS) capacitor c=4.3815e-17
C103 (\23\:qbint VSS) capacitor c=8.4051e-17
C104 (\3\:VDD VSS) capacitor c=1.03934e-16
C105 (\5\:SEb VSS) capacitor c=1.13441e-16
C106 (\17\:CKb VSS) capacitor c=6.27908e-17
C107 (\15\:CKbb VSS) capacitor c=6.00087e-17
C108 (\4\:Db VSS) capacitor c=1.91528e-16
C109 (\9\:n20 VSS) capacitor c=3.61553e-17
C110 (\13\:mout VSS) capacitor c=1.46571e-16
C111 (\3\:net469 VSS) capacitor c=7.15713e-17
C112 (\9\:mout VSS) capacitor c=1.21388e-16
C113 (\13\:n35 VSS) capacitor c=6.66098e-17
C114 (\3\:net490 VSS) capacitor c=8.09597e-17
C115 (\3\:net486 VSS) capacitor c=1.24199e-16
C116 (\12\:RNb VSS) capacitor c=5.63118e-17
C117 (\21\:qbint VSS) capacitor c=2.20262e-17
C118 (\2\:n35 VSS) capacitor c=1.63969e-16
C119 (\3\:RNb VSS) capacitor c=4.98573e-17
C120 (\14\:qbint VSS) capacitor c=2.93639e-17
C121 (\2\:SN VSS) capacitor c=3.44043e-17
C122 (\2\:CKbb VSS) capacitor c=5.98244e-17
C123 (\2\:n20 VSS) capacitor c=2.5307e-17
C124 (\2\:mout VSS) capacitor c=5.22564e-17
C125 (\6\:CKbb VSS) capacitor c=3.01524e-17
C126 (\4\:RN VSS) capacitor c=5.71963e-17
C127 (\11\:RNb VSS) capacitor c=5.49087e-17
C128 (\2\:D VSS) capacitor c=3.43868e-17
C129 (\17\:qbint VSS) capacitor c=1.6209e-16
C130 (\18\:qbint VSS) capacitor c=1.31012e-16
C131 (\19\:qbint VSS) capacitor c=2.93919e-17
C132 (\20\:qbint VSS) capacitor c=2.83899e-17
C133 (\14\:RNb VSS) capacitor c=1.12889e-16
C134 (\15\:RNb VSS) capacitor c=7.91489e-17
C135 (\11\:n35 VSS) capacitor c=3.10506e-16
C136 (\12\:n35 VSS) capacitor c=2.35508e-16
C137 (\8\:SN VSS) capacitor c=2.26403e-16
C138 (\9\:SN VSS) capacitor c=3.35734e-17
C139 (\5\:mout VSS) capacitor c=5.95155e-17
C140 (\8\:mout VSS) capacitor c=1.48412e-16
C141 (\10\:CKbb VSS) capacitor c=2.19022e-16
C142 (\11\:CKbb VSS) capacitor c=1.93374e-16
C143 (\5\:n20 VSS) capacitor c=6.70997e-17
C144 (\6\:n20 VSS) capacitor c=9.50731e-17
C145 (\12\:CKbb VSS) capacitor c=6.06258e-17
C146 (\4\:CK VSS) capacitor c=6.73649e-17
C147 (\5\:D VSS) capacitor c=7.29229e-17
C148 (\13\:CKb VSS) capacitor c=1.42626e-16
C149 (\14\:CKb VSS) capacitor c=9.65274e-17
C150 (\15\:CKb VSS) capacitor c=3.06975e-16
C151 (\16\:CKb VSS) capacitor c=4.42883e-17
C152 (\19\:CKb VSS) capacitor c=3.64263e-16
C153 (\20\:CKb VSS) capacitor c=1.17428e-16
C154 (\3\:Db VSS) capacitor c=1.90959e-16
C155 (\4\:SI VSS) capacitor c=3.72149e-17
C156 (\7\:SEb VSS) capacitor c=1.51125e-16
C157 (\8\:SEb VSS) capacitor c=1.20847e-16
C158 (\7\:SE VSS) capacitor c=9.09822e-17
C159 (\8\:SE VSS) capacitor c=2.88355e-17
C160 (\5\:VDD VSS) capacitor c=1.37551e-17
C161 (\6\:VDD VSS) capacitor c=2.857e-17
C162 (\7\:VDD VSS) capacitor c=2.00591e-17
C163 (\9\:VDD VSS) capacitor c=4.19707e-17
C164 (\10\:VDD VSS) capacitor c=4.47821e-17
C165 (\12\:VDD VSS) capacitor c=4.95755e-17
C166 (\13\:VDD VSS) capacitor c=3.44118e-17
C167 (\14\:VDD VSS) capacitor c=2.76703e-16
Rk6 (RN \4\:RN) resistor r=0.09921 c=0
Rk36 (D \5\:D) resistor r=0.02137 c=0
Rk81 (\2\:VSS \4\:VSS) resistor r=0.6068 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.08259 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.3549 c=0
Rk84 (\6\:VSS \7\:VSS) resistor r=0.2611 c=0
Rk85 (\7\:VSS \8\:VSS) resistor r=0.2497 c=0
Rk86 (\8\:VSS \9\:VSS) resistor r=0.3134 c=0
Rk87 (\9\:VSS \10\:VSS) resistor r=0.8904 c=0
Rk88 (\10\:VSS \11\:VSS) resistor r=0.2808 c=0
Rk94 (\12\:VSS VSS) resistor r=0.07983 c=0
Rk89 (\11\:VSS \12\:VSS) resistor r=0.7622 c=0
Rk95 (\5\:VSS \18\:VSS) resistor r=0.2001 c=0
Rk96 (\6\:VSS \20\:VSS) resistor r=0.04333 c=0
Rk97 (\7\:VSS \22\:VSS) resistor r=0.04333 c=0
Rk98 (\9\:VSS \24\:VSS) resistor r=0.2403 c=0
Rk99 (\11\:VSS \26\:VSS) resistor r=0.07416 c=0
Rk54 (\2\:VDD \4\:VDD) resistor r=0.7242 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.03493 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.3107 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.4311 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.1754 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.356 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.5114 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.336 c=0
Rk62 (\11\:VDD \12\:VDD) resistor r=0.3752 c=0
Rk63 (\12\:VDD \13\:VDD) resistor r=0.3348 c=0
Rk69 (\14\:VDD VDD) resistor r=0.07983 c=0
Rk64 (\13\:VDD \14\:VDD) resistor r=0.3308 c=0
Rk70 (\5\:VDD \20\:VDD) resistor r=0.2585 c=0
Rk71 (\6\:VDD \22\:VDD) resistor r=0.2689 c=0
Rk72 (\7\:VDD \24\:VDD) resistor r=0.1847 c=0
Rk73 (\9\:VDD \26\:VDD) resistor r=0.2667 c=0
Rk74 (\10\:VDD \28\:VDD) resistor r=0.1733 c=0
Rk75 (\12\:VDD \30\:VDD) resistor r=0.04333 c=0
Rk76 (\13\:VDD \32\:VDD) resistor r=0.07416 c=0
Rk35 (CK \4\:CK) resistor r=0.1413 c=0
Rk52 (SE \7\:SE) resistor r=0.349 c=0
Rk53 (SE \8\:SE) resistor r=0.1576 c=0
Rk22 (\8\:SN SN) resistor r=1.7734 c=0
Rk23 (SN \9\:SN) resistor r=0.1145 c=0
Rk48 (\4\:SI SI) resistor r=0.05445 c=0
Rk9 (\17\:qbint \18\:qbint) resistor r=1.1772 c=0
Rk10 (\18\:qbint \19\:qbint) resistor r=0.1222 c=0
Rk11 (\19\:qbint \20\:qbint) resistor r=0.1635 c=0
Rk12 (\18\:qbint \22\:qbint) resistor r=0.0611 c=0
Rk13 (\19\:qbint \24\:qbint) resistor r=0.2933 c=0
Rk18 (\10\:n35 \11\:n35) resistor r=0.1916 c=0
Rk19 (\11\:n35 \12\:n35) resistor r=2.0548 c=0
Rk20 (\11\:n35 \14\:n35) resistor r=0.1632 c=0
Rk7 (\10\:RNb \11\:RNb) resistor r=0.1366 c=0
Rk8 (\11\:RNb \13\:RNb) resistor r=0.1548 c=0
Rk16 (\14\:RNb \15\:RNb) resistor r=0.6213 c=0
Rk15 (\2\:net490 \4\:net490) resistor r=0.5427 c=0
Rk14 (\2\:net486 \4\:net486) resistor r=0.8494 c=0
Rk37 (\12\:CKb \13\:CKb) resistor r=0.4982 c=0
Rk38 (\13\:CKb \14\:CKb) resistor r=0.3656 c=0
Rk39 (\13\:CKb \15\:CKb) resistor r=0.7856 c=0
Rk40 (\15\:CKb \16\:CKb) resistor r=0.1208 c=0
Rk41 (\14\:CKb \18\:CKb) resistor r=0.3804 c=0
Rk42 (\15\:CKb \19\:CKb) resistor r=1.8482 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.8559 c=0
Rk24 (\5\:mout \7\:mout) resistor r=0.2806 c=0
Rk25 (\7\:mout \8\:mout) resistor r=0.9773 c=0
Rk26 (\8\:mout \10\:mout) resistor r=0.3084 c=0
Rk27 (\8\:mout \12\:mout) resistor r=0.07562 c=0
Rk28 (\10\:mout \14\:mout) resistor r=0.7891 c=0
Rk29 (\10\:CKbb \11\:CKbb) resistor r=1.3392 c=0
Rk33 (\12\:CKbb \14\:CKbb) resistor r=0.1467 c=0
Rk34 (\12\:CKbb \16\:CKbb) resistor r=0.241 c=0
Rk21 (\2\:net469 \4\:net469) resistor r=0.3101 c=0
Rk30 (\5\:n20 \6\:n20) resistor r=0.4012 c=0
Rk31 (\6\:n20 \8\:n20) resistor r=0.4213 c=0
Rk32 (\6\:n20 \10\:n20) resistor r=0.09071 c=0
Rk44 (\2\:Db \3\:Db) resistor r=0.1866 c=0
Rk45 (\3\:Db \5\:Db) resistor r=0.9072 c=0
Rk46 (\5\:Db \7\:Db) resistor r=0.5864 c=0
Rk47 (\3\:Db \9\:Db) resistor r=0.9208 c=0
Rk49 (\6\:SEb \7\:SEb) resistor r=0.7847 c=0
Rk50 (\7\:SEb \8\:SEb) resistor r=0.3186 c=0
Rk51 (\8\:SEb \10\:SEb) resistor r=0.7019 c=0
Rk17 (\2\:net394 \4\:net394) resistor r=0.2992 c=0
Rl20 (\2\:RN \3\:RN) resistor r=26.3736 c=0
Rl19 (\1\:RN \2\:RN) resistor r=94.2308 c=0
Rl56 (\1\:D \2\:D) resistor r=86.5164 c=0
Rl58 (\2\:D \4\:D) resistor r=120.835 c=0
Rl57 (\2\:D \3\:D) resistor r=76.8484 c=0
Rl54 (\1\:CK \2\:CK) resistor r=200.257 c=0
Rl55 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl65 (\4\:SE \5\:SE) resistor r=69.9225 c=0
Rl66 (\5\:SE \6\:SE) resistor r=31.461 c=0
Rl61 (\2\:SE \3\:SE) resistor r=120.067 c=0
Rl60 (\1\:SE \2\:SE) resistor r=34.6154 c=0
Rl41 (\5\:SN \6\:SN) resistor r=193.796 c=0
Rl42 (\6\:SN \7\:SN) resistor r=24.2328 c=0
Rl29 (\2\:SN \3\:SN) resistor r=57.6702 c=0
Rl28 (\1\:SN \2\:SN) resistor r=145.835 c=0
Rl30 (\2\:SN \4\:SN) resistor r=44.1561 c=0
Rl63 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl64 (\2\:SI \3\:SI) resistor r=119.952 c=0
Rl27 (\14\:qbint \16\:qbint) resistor r=95.7383 c=0
Rl25 (\14\:qbint \13\:qbint) resistor r=50.725 c=0
Rl26 (\14\:qbint \15\:qbint) resistor r=15.3358 c=0
Rl12 (\2\:n35 n35) resistor r=1.2713 c=0
Rl37 (\6\:RNb \8\:RNb) resistor r=119.231 c=0
Rl36 (\6\:RNb \7\:RNb) resistor r=718.744 c=0
Rl21 (RNb \2\:RNb) resistor r=24.2328 c=0
Rl22 (\2\:RNb \3\:RNb) resistor r=103.824 c=0
Rl24 (\3\:RNb \5\:RNb) resistor r=82.3738 c=0
Rl23 (\3\:RNb \4\:RNb) resistor r=115.31 c=0
Rl53 (\8\:CKb \10\:CKb) resistor r=78.1713 c=0
Rl51 (\7\:CKb \8\:CKb) resistor r=26.7711 c=0
Rl52 (\8\:CKb \9\:CKb) resistor r=188.381 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl31 (CKb \2\:CKb) resistor r=34.0806 c=0
Rl45 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl43 (mout \2\:mout) resistor r=172.357 c=0
Rl44 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl50 (\7\:CKbb \9\:CKbb) resistor r=85.7713 c=0
Rl34 (\2\:CKbb \3\:CKbb) resistor r=128.39 c=0
Rl33 (CKbb \2\:CKbb) resistor r=38.143 c=0
Rl35 (\2\:CKbb \4\:CKbb) resistor r=150.332 c=0
Rl49 (\6\:CKbb \8\:CKbb) resistor r=82.3738 c=0
Rl47 (\5\:CKbb \6\:CKbb) resistor r=86.4638 c=0
Rl48 (\6\:CKbb \7\:CKbb) resistor r=74.5433 c=0
Rl39 (\2\:n20 \3\:n20) resistor r=88.1101 c=0
Rl40 (\2\:n20 \4\:n20) resistor r=30.5714 c=0
Rl38 (n20 \2\:n20) resistor r=68.8799 c=0
Rl62 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl59 (SEb \2\:SEb) resistor r=31.9251 c=0
Rz24 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz25 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz26 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz27 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz28 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz29 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz20 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz21 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz22 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz4 (\22\:qbint \21\:qbint) resistor r=75 c=0
Rz9 (\14\:n35 \13\:n35) resistor r=75 c=0
Rz3 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz7 (net490 \2\:net490) resistor r=75 c=0
Rz8 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz5 (net486 \2\:net486) resistor r=75 c=0
Rz6 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz16 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz12 (\9\:mout \10\:mout) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz15 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (net469 \2\:net469) resistor r=75 c=0
Rz11 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz14 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz17 (Db \2\:Db) resistor r=75 c=0
Rz18 (\4\:Db \5\:Db) resistor r=75 c=0
Rz19 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry28 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry29 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry30 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry31 (\12\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry17 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry22 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry23 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry4 (\24\:qbint \23\:qbint) resistor r=31 c=0
Ry7 (\10\:n35 \9\:n35) resistor r=31 c=0
Ry3 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry11 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry10 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry13 (\6\:Db \7\:Db) resistor r=62 c=0
Ry14 (\8\:Db \9\:Db) resistor r=62 c=0
Ry15 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (net394 \2\:net394) resistor r=62 c=0
Ry6 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx1 (\2\:RN \4\:RN) resistor r=45 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx24 (\2\:SE \7\:SE) resistor r=45 c=0
Rx25 (\5\:SE \8\:SE) resistor r=45 c=0
Rx8 (\7\:SN \8\:SN) resistor r=45 c=0
Rx9 (\4\:SN \9\:SN) resistor r=45 c=0
Rx21 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\17\:qbint \15\:qbint) resistor r=45 c=0
Rx4 (\20\:qbint qbint) resistor r=45 c=0
Rx7 (\12\:n35 n35) resistor r=45 c=0
Rx2 (\4\:RNb \11\:RNb) resistor r=45 c=0
Rx5 (\7\:RNb \14\:RNb) resistor r=45 c=0
Rx6 (RNb \15\:RNb) resistor r=45 c=0
Rx17 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx18 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx19 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx20 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\5\:CKbb \12\:CKbb) resistor r=45 c=0
Rx13 (n20 \5\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn11 (net522 \4\:D \19\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.415e-14 ad=1.56e-14 ps=1.85e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69231e-07 sb=6.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (Db SEb net522 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=6.5e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.74231e-07 sb=5.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn14 (Db \1\:SE net534 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.5e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.69231e-07 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net534 \3\:SI \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74231e-07 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn55_1__rcx (Q qbint \12\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.947e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28173e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn51 (\3\:net490 \5\:RNb \3\:net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.407e-14 ad=5.33e-14 ps=8.4e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=6.3e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn52 (\3\:net490 \13\:qbint net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.69e-14 ad=5.33e-14 ps=7.7e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.25e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn50 (net486 \1\:SN \25\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=3.69e-14 ps=1.62e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1e-07 sd=160n sca=14.2182 scb=0.0146528 \
        scc=0.000922757 m=(1)
mn53 (\13\:n35 CKb net490 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.21e-14 ad=3.997e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05366e-07 sb=5.25e-07 sd=160n sca=14.6414 \
        scb=0.0151256 scc=0.000999928 m=(1)
mn40 (\13\:n35 CKbb \9\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=3.997e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45366e-07 sb=2.85e-07 sd=160n sca=14.6414 \
        scb=0.0151256 scc=0.000999928 m=(1)
mn31 (\13\:mout \8\:RNb \3\:net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.587e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02317e-06 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn32 (\13\:mout \4\:n20 net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.115e-14 ad=3.587e-14 ps=1.17e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=8.03171e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn30 (net469 \5\:SN \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=6.115e-14 ps=7.3e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.80122e-07 sb=6.55e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn35 (net514 mout \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85122e-07 sb=4.5e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn36 (\9\:n20 \9\:CKbb net514 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.90122e-07 sb=3.45e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn25 (\4\:Db \9\:CKb \9\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09512e-06 sb=1.4e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn45_1__rcx (\21\:qbint \2\:n35 \12\:VSS VSS) g45n1hvt w=(2.05e-07) \
        l=4.5e-08 nf=1 as=4.474e-14 ad=3.28e-14 ps=9.2e-07 pd=7.3e-07 \
        nrd=1.16667 nrs=1.16667 sa=9.6e-07 sb=6.1378e-07 sd=160n \
        sca=13.8179 scb=0.0141903 scc=0.000851218 m=(2)
mn22 (\12\:RNb \1\:RN \12\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.117e-14 ad=2.61e-14 ps=1e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.8e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn21 (\15\:CKbb \7\:CKb \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.152e-14 ad=3.045e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.75e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn20 (\17\:CKb \3\:CK \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.415e-14 ad=2.03e-14 ps=1.85e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.51724e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mp51 (net437 \2\:RNb \31\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2055e-13 ad=1.86e-14 ps=1.79e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=3.40565e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp52 (\3\:net394 \16\:qbint net437 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=5.38e-14 ps=7.4e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2.35565e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp50 (\3\:net394 \3\:SN \29\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.03e-14 ad=5.38e-14 ps=1.39e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.14113e-07 sb=1.1129e-07 sd=160n sca=11.1346 \
        scb=0.00910425 scc=0.000198662 m=(1)
mp53 (\9\:n35 \3\:CKbb net394 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.835e-14 ad=5.58e-14 ps=1.19e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.6e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\9\:n35 \3\:CKb \11\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp31 (net417 \6\:RNb \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.6975e-13 ad=4.805e-14 ps=2.04e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=8.63065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\6\:mout \3\:n20 net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=6.63065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\6\:mout \6\:SN \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=4.58065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 \4\:mout \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=1.86e-14 ps=1.47e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.29677e-07 sb=5.3e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp36 (\7\:n20 \5\:CKb net425 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=7.44e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.34677e-07 sb=4.25e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp25 (\7\:n20 \8\:CKbb \6\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=7.44e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01968e-06 sb=1.4e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp45 (\23\:qbint \2\:n35 \14\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.093e-14 ad=4.96e-14 ps=1.42e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=6.17742e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp22 (\9\:RNb \3\:RN \14\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0425e-13 ad=5.482e-14 ps=1.74e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2.55e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp21 (\13\:CKbb \10\:CKb \23\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.495e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp20 (\11\:CKb \1\:CK \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.39535e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp10 (\9\:SEb \4\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=7.525e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
ends SDFFSRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:54 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX8 CK D Q RN SE SI SN VDD VSS
mp55_1__rcx (Q qbint \13\:VDD VDD) g45p1hvt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90404e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (RN VSS) capacitor c=6.80718e-17
C2 (D VSS) capacitor c=5.87372e-17
C3 (Q VSS) capacitor c=5.05805e-16
C4 (VDD VSS) capacitor c=5.45355e-16
C5 (CK VSS) capacitor c=4.48297e-17
C6 (SN VSS) capacitor c=3.76482e-16
C7 (SI VSS) capacitor c=8.68465e-17
C8 (qbint VSS) capacitor c=3.73935e-16
C9 (n35 VSS) capacitor c=2.11491e-16
C10 (RNb VSS) capacitor c=1.65796e-16
C11 (net486 VSS) capacitor c=7.34225e-17
C12 (net490 VSS) capacitor c=8.21598e-17
C13 (CKb VSS) capacitor c=3.93974e-17
C14 (mout VSS) capacitor c=4.43525e-17
C15 (CKbb VSS) capacitor c=2.70528e-17
C16 (net469 VSS) capacitor c=6.3493e-17
C17 (n20 VSS) capacitor c=3.0866e-17
C18 (Db VSS) capacitor c=1.21801e-16
C19 (net522 VSS) capacitor c=2.73138e-18
C20 (SEb VSS) capacitor c=4.72231e-17
C21 (net394 VSS) capacitor c=1.04385e-16
C22 (net437 VSS) capacitor c=1.85622e-18
C23 (net417 VSS) capacitor c=2.55223e-18
C24 (net425 VSS) capacitor c=3.3732e-18
C25 (net445 VSS) capacitor c=2.58747e-18
C26 (net453 VSS) capacitor c=4.5356e-18
C27 (\7\:SE VSS) capacitor c=7.42423e-17
C28 (\3\:SI VSS) capacitor c=6.39435e-17
C29 (\1\:SE VSS) capacitor c=7.60101e-17
C30 (\1\:D VSS) capacitor c=9.29108e-17
C31 (\1\:CK VSS) capacitor c=3.21348e-17
C32 (\5\:CKb VSS) capacitor c=3.91371e-17
C33 (\7\:CKbb VSS) capacitor c=3.6374e-17
C34 (\9\:CKb VSS) capacitor c=7.15662e-17
C35 (\5\:SN VSS) capacitor c=6.66106e-17
C36 (\3\:n20 VSS) capacitor c=9.84322e-17
C37 (\3\:CKb VSS) capacitor c=4.25917e-17
C38 (\3\:CKbb VSS) capacitor c=5.46046e-17
C39 (\3\:RNb VSS) capacitor c=7.14671e-17
C40 (\22\:qbint VSS) capacitor c=1.22939e-16
C41 (\1\:SN VSS) capacitor c=5.04756e-17
C42 (\1\:RN VSS) capacitor c=3.88914e-17
C43 (\5\:SE VSS) capacitor c=2.66632e-17
C44 (\1\:SI VSS) capacitor c=7.90242e-17
C45 (\3\:SE VSS) capacitor c=6.77048e-17
C46 (\3\:SEb VSS) capacitor c=7.70485e-17
C47 (\4\:D VSS) capacitor c=4.68856e-17
C48 (\3\:CK VSS) capacitor c=2.87783e-17
C49 (\10\:CKb VSS) capacitor c=2.78284e-17
C50 (\11\:CKb VSS) capacitor c=2.68988e-17
C51 (\5\:CKbb VSS) capacitor c=4.60856e-17
C52 (\3\:mout VSS) capacitor c=5.776e-17
C53 (\4\:SN VSS) capacitor c=6.22609e-17
C54 (\4\:RNb VSS) capacitor c=5.25231e-17
C55 (\5\:RNb VSS) capacitor c=6.50315e-17
C56 (\24\:qbint VSS) capacitor c=5.86858e-17
C57 (\3\:SN VSS) capacitor c=3.77502e-17
C58 (\3\:RN VSS) capacitor c=4.45976e-17
C59 (\6\:SE VSS) capacitor c=4.96322e-17
C60 (\2\:SI VSS) capacitor c=5.10002e-17
C61 (\4\:SE VSS) capacitor c=4.75732e-17
C62 (\2\:SEb VSS) capacitor c=5.39941e-17
C63 (\2\:SE VSS) capacitor c=4.85419e-17
C64 (\3\:D VSS) capacitor c=2.67646e-17
C65 (\2\:CK VSS) capacitor c=4.11857e-17
C66 (\6\:CKb VSS) capacitor c=2.04382e-17
C67 (\8\:CKbb VSS) capacitor c=3.3007e-17
C68 (\6\:CKbb VSS) capacitor c=4.28551e-17
C69 (\2\:mout VSS) capacitor c=4.33917e-17
C70 (\6\:SN VSS) capacitor c=2.10287e-17
C71 (\4\:n20 VSS) capacitor c=3.02945e-17
C72 (\4\:CKbb VSS) capacitor c=3.13422e-17
C73 (\4\:CKb VSS) capacitor c=4.02631e-17
C74 (\2\:CKb VSS) capacitor c=2.30048e-17
C75 (\2\:RNb VSS) capacitor c=1.02458e-16
C76 (\2\:SN VSS) capacitor c=3.5735e-17
C77 (\2\:RN VSS) capacitor c=2.86426e-17
C78 (\23\:qbint VSS) capacitor c=4.41693e-17
C79 (\8\:SEb VSS) capacitor c=2.79066e-17
C80 (\1\:VDD VSS) capacitor c=6.85217e-17
C81 (\19\:VDD VSS) capacitor c=3.67025e-17
C82 (\12\:CKb VSS) capacitor c=4.32854e-17
C83 (\21\:VDD VSS) capacitor c=5.12829e-17
C84 (\11\:CKbb VSS) capacitor c=1.14596e-16
C85 (\8\:Db VSS) capacitor c=1.02615e-16
C86 (\5\:n20 VSS) capacitor c=9.22141e-17
C87 (\23\:VDD VSS) capacitor c=7.32794e-17
C88 (\11\:mout VSS) capacitor c=2.07383e-16
C89 (\25\:VDD VSS) capacitor c=6.9828e-17
C90 (\7\:mout VSS) capacitor c=4.34262e-17
C91 (\10\:n35 VSS) capacitor c=7.8723e-17
C92 (\27\:VDD VSS) capacitor c=5.6792e-17
C93 (\3\:net394 VSS) capacitor c=9.258e-17
C94 (\29\:VDD VSS) capacitor c=5.70016e-17
C95 (\7\:RNb VSS) capacitor c=1.80829e-16
C96 (\26\:qbint VSS) capacitor c=3.58869e-16
C97 (\3\:VDD VSS) capacitor c=9.44387e-17
C98 (\4\:SEb VSS) capacitor c=6.51732e-17
C99 (\6\:Db VSS) capacitor c=4.43461e-17
C100 (\18\:CKb VSS) capacitor c=7.74269e-17
C101 (\9\:CKbb VSS) capacitor c=9.38674e-17
C102 (\4\:Db VSS) capacitor c=1.89135e-16
C103 (\9\:n20 VSS) capacitor c=1.99873e-17
C104 (\9\:mout VSS) capacitor c=1.41815e-16
C105 (\3\:net469 VSS) capacitor c=7.87615e-17
C106 (\4\:mout VSS) capacitor c=1.23894e-16
C107 (\14\:n35 VSS) capacitor c=6.20465e-17
C108 (\3\:net490 VSS) capacitor c=9.92022e-17
C109 (\3\:net486 VSS) capacitor c=6.31852e-17
C110 (\9\:RNb VSS) capacitor c=1.09881e-16
C111 (\2\:CKbb VSS) capacitor c=6.31969e-17
C112 (\2\:n20 VSS) capacitor c=3.9342e-17
C113 (\25\:qbint VSS) capacitor c=6.62662e-17
C114 (\31\:qbint VSS) capacitor c=2.7599e-17
C115 (\7\:CKb VSS) capacitor c=2.43988e-17
C116 (\8\:CKb VSS) capacitor c=5.74116e-17
C117 (\4\:RN VSS) capacitor c=5.04418e-17
C118 (\2\:D VSS) capacitor c=2.80808e-17
C119 (\6\:RNb VSS) capacitor c=9.59001e-17
C120 (\12\:n35 VSS) capacitor c=3.24173e-16
C121 (\13\:n35 VSS) capacitor c=2.65705e-16
C122 (\7\:SN VSS) capacitor c=3.30025e-16
C123 (\6\:mout VSS) capacitor c=1.57353e-16
C124 (\13\:mout VSS) capacitor c=9.1204e-17
C125 (\7\:n20 VSS) capacitor c=1.07738e-16
C126 (\8\:n20 VSS) capacitor c=8.90043e-17
C127 (\13\:CKbb VSS) capacitor c=1.36622e-16
C128 (\14\:CKbb VSS) capacitor c=2.78252e-16
C129 (\15\:CKbb VSS) capacitor c=2.08412e-16
C130 (\16\:CKbb VSS) capacitor c=6.99873e-17
C131 (\14\:CKb VSS) capacitor c=4.15954e-16
C132 (\15\:CKb VSS) capacitor c=5.77785e-16
C133 (\16\:CKb VSS) capacitor c=1.22748e-16
C134 (\17\:CKb VSS) capacitor c=7.87225e-17
C135 (\4\:CK VSS) capacitor c=8.21788e-17
C136 (\5\:D VSS) capacitor c=8.52e-17
C137 (\3\:Db VSS) capacitor c=2.12e-16
C138 (\4\:SI VSS) capacitor c=4.65526e-17
C139 (\8\:SE VSS) capacitor c=7.0349e-17
C140 (\9\:SE VSS) capacitor c=7.93743e-17
C141 (\10\:SE VSS) capacitor c=6.63719e-17
C142 (\6\:SEb VSS) capacitor c=9.46081e-17
C143 (\7\:SEb VSS) capacitor c=1.19372e-16
C144 (\5\:VDD VSS) capacitor c=9.49446e-18
C145 (\6\:VDD VSS) capacitor c=4.28071e-17
C146 (\7\:VDD VSS) capacitor c=3.78258e-17
C147 (\9\:VDD VSS) capacitor c=5.53742e-17
C148 (\10\:VDD VSS) capacitor c=3.57565e-17
C149 (\12\:VDD VSS) capacitor c=4.93612e-17
C150 (\13\:VDD VSS) capacitor c=5.37272e-16
Rk19 (\4\:RN RN) resistor r=0.07561 c=0
Rk50 (D \5\:D) resistor r=0.1234 c=0
Rk62 (\2\:VSS \4\:VSS) resistor r=0.5685 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.1243 c=0
Rk64 (\5\:VSS \6\:VSS) resistor r=0.3315 c=0
Rk65 (\6\:VSS \7\:VSS) resistor r=0.6511 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.09266 c=0
Rk67 (\8\:VSS \9\:VSS) resistor r=1.2046 c=0
Rk68 (\9\:VSS \10\:VSS) resistor r=0.2959 c=0
Rk75 (\11\:VSS VSS) resistor r=0.1075 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.5291 c=0
Rk76 (\5\:VSS \18\:VSS) resistor r=0.04335 c=0
Rk77 (\6\:VSS \20\:VSS) resistor r=0.04335 c=0
Rk78 (\7\:VSS \22\:VSS) resistor r=0.235 c=0
Rk79 (\10\:VSS \24\:VSS) resistor r=0.3239 c=0
Rk85 (\2\:VDD \4\:VDD) resistor r=0.5043 c=0
Rk86 (\4\:VDD \5\:VDD) resistor r=0.1554 c=0
Rk87 (\5\:VDD \6\:VDD) resistor r=0.2455 c=0
Rk88 (\6\:VDD \7\:VDD) resistor r=0.7374 c=0
Rk89 (\7\:VDD \8\:VDD) resistor r=0.06505 c=0
Rk90 (\8\:VDD \9\:VDD) resistor r=0.4465 c=0
Rk91 (\9\:VDD \10\:VDD) resistor r=0.7073 c=0
Rk92 (\10\:VDD \11\:VDD) resistor r=0.04999 c=0
Rk93 (\11\:VDD \12\:VDD) resistor r=0.3587 c=0
Rk100 (\13\:VDD VDD) resistor r=0.1075 c=0
Rk94 (\12\:VDD \13\:VDD) resistor r=0.4664 c=0
Rk101 (\5\:VDD \20\:VDD) resistor r=0.3869 c=0
Rk102 (\6\:VDD \22\:VDD) resistor r=0.3388 c=0
Rk103 (\7\:VDD \24\:VDD) resistor r=0.2944 c=0
Rk104 (\9\:VDD \26\:VDD) resistor r=0.235 c=0
Rk105 (\10\:VDD \28\:VDD) resistor r=0.2477 c=0
Rk106 (\12\:VDD \30\:VDD) resistor r=0.2421 c=0
Rk49 (CK \4\:CK) resistor r=0.1415 c=0
Rk56 (SE \8\:SE) resistor r=0.005081 c=0
Rk57 (\8\:SE \9\:SE) resistor r=0.4194 c=0
Rk58 (\9\:SE \10\:SE) resistor r=0.3461 c=0
Rk29 (\8\:SN SN) resistor r=0.01255 c=0
Rk28 (\7\:SN \8\:SN) resistor r=2.6244 c=0
Rk55 (\4\:SI SI) resistor r=0.01944 c=0
Rk11 (\25\:qbint \26\:qbint) resistor r=0.5959 c=0
Rk15 (\26\:qbint \31\:qbint) resistor r=0.1671 c=0
Rk25 (\11\:n35 \12\:n35) resistor r=0.1981 c=0
Rk26 (\12\:n35 \13\:n35) resistor r=2.2074 c=0
Rk27 (\12\:n35 \15\:n35) resistor r=0.2639 c=0
Rk20 (\6\:RNb \8\:RNb) resistor r=0.7607 c=0
Rk21 (\8\:RNb \10\:RNb) resistor r=0.7313 c=0
Rk22 (\2\:net486 \4\:net486) resistor r=0.3453 c=0
Rk24 (\2\:net490 \4\:net490) resistor r=0.3602 c=0
Rk44 (\13\:CKb \14\:CKb) resistor r=0.2884 c=0
Rk45 (\14\:CKb \15\:CKb) resistor r=3.358 c=0
Rk46 (\15\:CKb \16\:CKb) resistor r=0.8883 c=0
Rk47 (\14\:CKb \17\:CKb) resistor r=0.2735 c=0
Rk48 (\17\:CKb \19\:CKb) resistor r=0.454 c=0
Rk31 (\5\:mout \6\:mout) resistor r=0.2545 c=0
Rk32 (\6\:mout \8\:mout) resistor r=0.1517 c=0
Rk33 (\5\:mout \10\:mout) resistor r=0.8346 c=0
Rk34 (\6\:mout \12\:mout) resistor r=1.0011 c=0
Rk35 (\12\:mout \13\:mout) resistor r=0.4052 c=0
Rk39 (\10\:CKbb \12\:CKbb) resistor r=0.4998 c=0
Rk40 (\12\:CKbb \13\:CKbb) resistor r=0.3917 c=0
Rk41 (\13\:CKbb \14\:CKbb) resistor r=0.6589 c=0
Rk42 (\14\:CKbb \15\:CKbb) resistor r=1.5174 c=0
Rk43 (\13\:CKbb \16\:CKbb) resistor r=0.2487 c=0
Rk30 (\2\:net469 \4\:net469) resistor r=0.3376 c=0
Rk36 (\6\:n20 \7\:n20) resistor r=0.4712 c=0
Rk37 (\7\:n20 \8\:n20) resistor r=0.5281 c=0
Rk38 (\7\:n20 \10\:n20) resistor r=0.06512 c=0
Rk51 (\2\:Db \3\:Db) resistor r=0.7142 c=0
Rk52 (\3\:Db \5\:Db) resistor r=1.0156 c=0
Rk53 (\3\:Db \7\:Db) resistor r=0.1796 c=0
Rk54 (\5\:Db \9\:Db) resistor r=0.6334 c=0
Rk59 (\5\:SEb \6\:SEb) resistor r=0.5034 c=0
Rk60 (\6\:SEb \7\:SEb) resistor r=0.7712 c=0
Rk61 (\6\:SEb \9\:SEb) resistor r=0.4152 c=0
Rk23 (\2\:net394 \4\:net394) resistor r=0.4937 c=0
Rl29 (\1\:RN \2\:RN) resistor r=47.3097 c=0
Rl30 (\2\:RN \3\:RN) resistor r=76.1559 c=0
Rl61 (\1\:D \2\:D) resistor r=103.08 c=0
Rl63 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl62 (\2\:D \3\:D) resistor r=46.5271 c=0
Rl59 (\1\:CK \2\:CK) resistor r=90.9234 c=0
Rl60 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl71 (\6\:SE \7\:SE) resistor r=261.796 c=0
Rl70 (\5\:SE \6\:SE) resistor r=39.1533 c=0
Rl67 (\3\:SE \4\:SE) resistor r=31.3807 c=0
Rl64 (\1\:SE \2\:SE) resistor r=33.7903 c=0
Rl47 (\4\:SN \5\:SN) resistor r=172.643 c=0
Rl48 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl31 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl32 (\2\:SN \3\:SN) resistor r=93.4636 c=0
Rl69 (\2\:SI \3\:SI) resistor r=37.4409 c=0
Rl68 (\1\:SI \2\:SI) resistor r=110.771 c=0
Rl34 (\24\:qbint \22\:qbint) resistor r=146.154 c=0
Rl33 (\23\:qbint \22\:qbint) resistor r=314.898 c=0
Rl42 (RNb \4\:RNb) resistor r=150 c=0
Rl43 (\3\:RNb \5\:RNb) resistor r=166.873 c=0
Rl40 (RNb \2\:RNb) resistor r=873.616 c=0
Rl41 (\2\:RNb \3\:RNb) resistor r=39.6174 c=0
Rl53 (\5\:CKb \6\:CKb) resistor r=133.848 c=0
Rl36 (\3\:CKb \4\:CKb) resistor r=35.3072 c=0
Rl35 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl57 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl54 (\6\:CKb \7\:CKb) resistor r=15.351 c=0
Rl56 (\8\:CKb \9\:CKb) resistor r=194.953 c=0
Rl58 (\8\:CKb \11\:CKb) resistor r=45.3874 c=0
Rl55 (\7\:CKb \8\:CKb) resistor r=208.53 c=0
Rl49 (mout \2\:mout) resistor r=28.079 c=0
Rl50 (\2\:mout \3\:mout) resistor r=131.925 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl38 (\2\:CKbb \3\:CKbb) resistor r=164.928 c=0
Rl37 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl39 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl45 (\2\:n20 \3\:n20) resistor r=156.078 c=0
Rl44 (n20 \2\:n20) resistor r=23.7402 c=0
Rl46 (\2\:n20 \4\:n20) resistor r=6.6011 c=0
Rl65 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl66 (\2\:SEb \3\:SEb) resistor r=121.875 c=0
Rz23 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz24 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz25 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz26 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz33 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz34 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz35 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz36 (\13\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\15\:n35 \14\:n35) resistor r=75 c=0
Rz7 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz8 (net486 \2\:net486) resistor r=75 c=0
Rz9 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz10 (net490 \2\:net490) resistor r=75 c=0
Rz11 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz19 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz15 (\4\:mout \5\:mout) resistor r=75 c=0
Rz16 (\9\:mout \10\:mout) resistor r=75 c=0
Rz18 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz13 (net469 \2\:net469) resistor r=75 c=0
Rz14 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz17 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz20 (\4\:Db \5\:Db) resistor r=75 c=0
Rz21 (\6\:Db \7\:Db) resistor r=75 c=0
Rz22 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry19 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry21 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry22 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry23 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry26 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry27 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry28 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry10 (\11\:n35 \10\:n35) resistor r=31 c=0
Ry7 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry15 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry11 (\7\:mout \8\:mout) resistor r=62 c=0
Ry12 (\11\:mout \12\:mout) resistor r=62 c=0
Ry14 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry13 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry16 (Db \2\:Db) resistor r=20.6667 c=0
Ry17 (\8\:Db \9\:Db) resistor r=62 c=0
Ry18 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry8 (net394 \2\:net394) resistor r=62 c=0
Ry9 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx17 (\3\:D \5\:D) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\6\:SE \8\:SE) resistor r=45 c=0
Rx20 (\4\:SE \9\:SE) resistor r=45 c=0
Rx21 (\2\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx2 (\31\:qbint qbint) resistor r=45 c=0
Rx5 (\13\:n35 n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx13 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx15 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (Q qbint \11\:VSS VSS) g45n1hvt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn11 (net522 \4\:D \17\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.535e-14 ad=4.03e-14 ps=1.5e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.34519e-07 sb=8.94038e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn12 (\6\:Db \3\:SEb net522 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=6.257e-14 ps=8.3e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.34519e-07 sb=6.94038e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn14 (\6\:Db \3\:SE net534 VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.257e-14 ps=6.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.42308e-07 sb=4.42019e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn13 (net534 \1\:SI \1\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=1.56e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47308e-07 sb=3.37019e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn45_1__rcx (\26\:qbint n35 \11\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.623e-14 ad=4.81e-14 ps=8.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(3)
mn22 (\9\:RNb \3\:RN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.297e-14 ad=2.755e-14 ps=9.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.3e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn21 (\9\:CKbb \10\:CKb \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.185e-14 ad=2.03e-14 ps=1.25e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn20 (\18\:CKb \3\:CK \17\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.535e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30362e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39414e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn50 (\3\:net486 \3\:SN \23\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.297e-14 ad=4.92e-14 ps=9.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75854e-07 sb=6.3e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn52 (net490 \24\:qbint \3\:net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.92e-14 ad=3.28e-14 ps=8.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.60854e-07 sb=3.45e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65854e-07 sb=1.4e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn53 (\14\:n35 CKb \3\:net490 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.612e-14 ad=5.125e-14 ps=8.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=5.8e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\14\:n35 CKbb \4\:mout VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\9\:mout \4\:RNb \3\:net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=4.612e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn32 (\9\:mout n20 net469 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.612e-14 ps=7.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.055e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (net469 \4\:SN \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=3.382e-14 ps=8.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=8.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \21\:VSS VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.05e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.92e-14 ps=6.1e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\4\:Db \11\:CKb \9\:n20 VSS) g45n1hvt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=2.87e-14 ps=8.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mp11 (net445 \1\:D \19\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=2.34e-14 ps=1.28e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.84679e-07 sb=7.15064e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.89679e-07 sb=6.10064e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp14 (Db SEb net453 VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 as=4.875e-14 \
        ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.94679e-07 sb=4.05064e-07 sd=160n sca=19.0259 scb=0.0163587 \
        scc=0.00171562 m=(1)
mp13 (net453 \3\:SI \1\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.64679e-07 sb=2.35064e-07 sd=160n sca=19.3112 \
        scb=0.0164357 scc=0.00171563 m=(1)
mp45_1__rcx (\26\:qbint n35 \13\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.98e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp22 (\7\:RNb \1\:RN \29\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.85e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp21 (\11\:CKbb \5\:CKb \21\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.35e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp20 (\12\:CKb \1\:CK \19\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.20581e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1hvt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47326e-07 sb=1.4e-07 sd=160n sca=12.2443 \
        scb=0.00977105 scc=0.000188654 m=(1)
mp50 (\3\:net394 \1\:SN \29\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.57e-14 ad=7.44e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.67984e-07 sb=6.85e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp52 (\3\:net394 \22\:qbint net437 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=7.44e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.52984e-07 sb=4e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (net437 \3\:RNb \27\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0045e-13 ad=1.86e-14 ps=1.36e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.57984e-07 sb=2.95e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp53 (\10\:n35 \3\:CKbb net394 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\10\:n35 \3\:CKb \7\:mout VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp31 (net417 RNb \25\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.946e-13 ad=1.86e-14 ps=2.09e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.17952e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\11\:mout \3\:n20 net417 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.975e-14 ps=7.4e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.07452e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\11\:mout \5\:SN \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.975e-14 ps=1.49e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.04516e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 mout \23\:VDD VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.045e-14 ps=1.49e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.66613e-07 sb=7.26129e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\5\:n20 \9\:CKb net425 VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=9.193e-14 ps=1.01e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20661e-06 sb=4.86129e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp25 (\5\:n20 \7\:CKbb \8\:Db VDD) g45p1hvt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.193e-14 ps=9.6e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49815e-06 sb=1.7e-07 sd=160n sca=17.9343 \
        scb=0.0166254 scc=0.0014837 m=(1)
ends SDFFSRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  1 09:15:55 2013 )
// Library name: gsclib045_hvt
// Cell name: SDFFSRX1
// View name: extracted

simulator lang=spectre

subckt SDFFSRX1 CK D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:net573 \29\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.4399 \
        scb=0.0250891 scc=0.0034155 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1hvt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.51603e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
C1 (CK VSS) capacitor c=5.62586e-17
C2 (SE VSS) capacitor c=4.0188e-17
C3 (SN VSS) capacitor c=3.22418e-16
C4 (SI VSS) capacitor c=6.81016e-17
C5 (QN VSS) capacitor c=2.27442e-17
C6 (VDD VSS) capacitor c=4.99504e-16
C7 (RN VSS) capacitor c=1.13428e-16
C8 (D VSS) capacitor c=9.34936e-17
C9 (Q VSS) capacitor c=9.09667e-17
C10 (net573 VSS) capacitor c=2.30725e-17
C11 (qbint VSS) capacitor c=5.66428e-17
C12 (RNb VSS) capacitor c=5.37175e-17
C13 (n35 VSS) capacitor c=1.56855e-17
C14 (n8 VSS) capacitor c=9.07161e-17
C15 (n10 VSS) capacitor c=6.83427e-17
C16 (CKb VSS) capacitor c=4.22183e-17
C17 (mout VSS) capacitor c=6.95851e-17
C18 (CKbb VSS) capacitor c=4.38991e-17
C19 (n4 VSS) capacitor c=7.30927e-17
C20 (n20 VSS) capacitor c=5.36921e-17
C21 (Db VSS) capacitor c=6.63967e-17
C22 (n0 VSS) capacitor c=3.58747e-18
C23 (SEb VSS) capacitor c=3.46603e-17
C24 (n11 VSS) capacitor c=1.17908e-16
C25 (n9 VSS) capacitor c=1.57959e-18
C26 (n5 VSS) capacitor c=2.63396e-18
C27 (n7 VSS) capacitor c=9.53981e-19
C28 (n1 VSS) capacitor c=4.42426e-18
C29 (\7\:SE VSS) capacitor c=4.2485e-17
C30 (\3\:SI VSS) capacitor c=4.61022e-17
C31 (\1\:SE VSS) capacitor c=4.01582e-17
C32 (\4\:D VSS) capacitor c=4.73068e-17
C33 (\1\:CK VSS) capacitor c=3.41836e-17
C34 (\8\:CKb VSS) capacitor c=2.69835e-17
C35 (\7\:CKb VSS) capacitor c=6.86005e-17
C36 (\5\:SN VSS) capacitor c=6.2396e-17
C37 (\5\:RNb VSS) capacitor c=6.79361e-17
C38 (\5\:CKb VSS) capacitor c=3.63364e-17
C39 (\5\:CKbb VSS) capacitor c=6.37756e-17
C40 (\2\:RNb VSS) capacitor c=8.99091e-17
C41 (\8\:qbint VSS) capacitor c=9.70006e-17
C42 (\1\:SN VSS) capacitor c=4.18519e-17
C43 (\4\:n35 VSS) capacitor c=4.50283e-17
C44 (\1\:RN VSS) capacitor c=3.52467e-17
C45 (\7\:qbint VSS) capacitor c=3.09009e-17
C46 (\4\:net573 VSS) capacitor c=4.43707e-17
C47 (\5\:SE VSS) capacitor c=2.5707e-17
C48 (\1\:SI VSS) capacitor c=6.39182e-17
C49 (\3\:SE VSS) capacitor c=6.72329e-17
C50 (\3\:SEb VSS) capacitor c=6.66298e-17
C51 (\1\:D VSS) capacitor c=4.39588e-17
C52 (\3\:CK VSS) capacitor c=3.95678e-17
C53 (\11\:CKb VSS) capacitor c=2.49378e-17
C54 (\10\:CKb VSS) capacitor c=5.94161e-17
C55 (\3\:CKbb VSS) capacitor c=1.52417e-16
C56 (\3\:mout VSS) capacitor c=6.96952e-17
C57 (\4\:SN VSS) capacitor c=7.06495e-17
C58 (\3\:n20 VSS) capacitor c=3.88735e-17
C59 (\4\:RNb VSS) capacitor c=5.50532e-17
C60 (\4\:CKbb VSS) capacitor c=1.13689e-16
C61 (\9\:qbint VSS) capacitor c=4.60521e-17
C62 (\3\:SN VSS) capacitor c=6.10201e-17
C63 (\3\:n35 VSS) capacitor c=3.92586e-17
C64 (\3\:RN VSS) capacitor c=6.25955e-17
C65 (\5\:qbint VSS) capacitor c=3.34832e-17
C66 (\4\:qbint VSS) capacitor c=2.19185e-17
C67 (\3\:net573 VSS) capacitor c=3.53746e-17
C68 (\6\:SE VSS) capacitor c=4.50444e-17
C69 (\2\:SI VSS) capacitor c=6.25939e-17
C70 (\4\:SE VSS) capacitor c=4.91872e-17
C71 (\2\:SEb VSS) capacitor c=6.18403e-17
C72 (\2\:SE VSS) capacitor c=3.97849e-17
C73 (\3\:D VSS) capacitor c=2.24213e-17
C74 (\2\:CK VSS) capacitor c=4.69604e-17
C75 (\9\:CKb VSS) capacitor c=5.61622e-17
C76 (\6\:CKbb VSS) capacitor c=5.01993e-17
C77 (\6\:CKb VSS) capacitor c=3.24296e-17
C78 (\2\:mout VSS) capacitor c=5.80138e-17
C79 (\6\:SN VSS) capacitor c=3.2527e-17
C80 (\3\:CKb VSS) capacitor c=3.72733e-17
C81 (\6\:RNb VSS) capacitor c=2.25402e-17
C82 (\4\:CKb VSS) capacitor c=4.26252e-17
C83 (\2\:CKb VSS) capacitor c=3.44547e-17
C84 (\3\:RNb VSS) capacitor c=2.52191e-17
C85 (\10\:qbint VSS) capacitor c=2.66494e-17
C86 (\2\:SN VSS) capacitor c=4.58394e-17
C87 (\2\:RN VSS) capacitor c=4.7259e-17
C88 (\6\:qbint VSS) capacitor c=2.01122e-17
C89 (\4\:SEb VSS) capacitor c=1.40313e-17
C90 (\5\:VDD VSS) capacitor c=2.83518e-17
C91 (\6\:Db VSS) capacitor c=8.42596e-17
C92 (\7\:VDD VSS) capacitor c=3.19444e-17
C93 (\14\:CKb VSS) capacitor c=6.18834e-17
C94 (\10\:VDD VSS) capacitor c=1.44065e-17
C95 (\7\:CKbb VSS) capacitor c=4.34264e-17
C96 (\8\:Db VSS) capacitor c=8.20843e-17
C97 (\9\:n20 VSS) capacitor c=5.1279e-17
C98 (\13\:VDD VSS) capacitor c=1.11069e-17
C99 (\10\:mout VSS) capacitor c=3.75532e-17
C100 (\16\:VDD VSS) capacitor c=1.94575e-17
C101 (\8\:mout VSS) capacitor c=7.45935e-17
C102 (\9\:n35 VSS) capacitor c=4.76028e-17
C103 (\19\:VDD VSS) capacitor c=3.40776e-17
C104 (\3\:n11 VSS) capacitor c=1.18843e-16
C105 (\22\:VDD VSS) capacitor c=1.21258e-17
C106 (\16\:qbint VSS) capacitor c=6.34454e-17
C107 (\10\:RNb VSS) capacitor c=2.60095e-17
C108 (\26\:VDD VSS) capacitor c=3.24491e-17
C109 (\1\:Q VSS) capacitor c=6.5282e-17
C110 (\5\:net573 VSS) capacitor c=3.20403e-17
C111 (\29\:VDD VSS) capacitor c=5.79931e-17
C112 (\1\:QN VSS) capacitor c=4.74368e-17
C113 (\1\:VDD VSS) capacitor c=1.02487e-16
C114 (\8\:SEb VSS) capacitor c=5.17732e-17
C115 (\22\:CKb VSS) capacitor c=6.41049e-17
C116 (\10\:CKbb VSS) capacitor c=5.56683e-17
C117 (\4\:Db VSS) capacitor c=1.63835e-16
C118 (\5\:n20 VSS) capacitor c=2.76045e-17
C119 (\12\:mout VSS) capacitor c=3.01948e-17
C120 (\3\:n4 VSS) capacitor c=7.40068e-17
C121 (\14\:mout VSS) capacitor c=4.23574e-17
C122 (\5\:n35 VSS) capacitor c=4.1861e-17
C123 (\3\:n8 VSS) capacitor c=8.34018e-17
C124 (\3\:n10 VSS) capacitor c=8.40599e-17
C125 (\13\:qbint VSS) capacitor c=6.47677e-17
C126 (\12\:RNb VSS) capacitor c=1.41964e-16
C127 (\3\:Q VSS) capacitor c=2.98462e-17
C128 (\9\:net573 VSS) capacitor c=3.84613e-17
C129 (\3\:QN VSS) capacitor c=3.62602e-17
C130 (\2\:net573 VSS) capacitor c=8.34485e-18
C131 (\2\:qbint VSS) capacitor c=2.16421e-17
C132 (\3\:qbint VSS) capacitor c=3.3136e-17
C133 (\2\:n35 VSS) capacitor c=2.03286e-17
C134 (\2\:n20 VSS) capacitor c=4.65515e-17
C135 (\2\:CKbb VSS) capacitor c=5.7222e-17
C136 (\7\:net573 VSS) capacitor c=2.96014e-17
C137 (\8\:net573 VSS) capacitor c=2.88677e-17
C138 (\2\:D VSS) capacitor c=4.65419e-17
C139 (\11\:qbint VSS) capacitor c=1.19854e-16
C140 (\12\:qbint VSS) capacitor c=1.17134e-16
C141 (\15\:qbint VSS) capacitor c=6.39045e-17
C142 (\7\:n35 VSS) capacitor c=1.63841e-16
C143 (\8\:n35 VSS) capacitor c=1.39359e-16
C144 (\12\:CKb VSS) capacitor c=1.11813e-16
C145 (\13\:CKb VSS) capacitor c=6.76952e-17
C146 (\7\:RNb VSS) capacitor c=1.37388e-16
C147 (\8\:RNb VSS) capacitor c=2.16131e-16
C148 (\9\:RNb VSS) capacitor c=1.3143e-16
C149 (\7\:SN VSS) capacitor c=2.71878e-16
C150 (\4\:mout VSS) capacitor c=4.35504e-17
C151 (\5\:mout VSS) capacitor c=4.53129e-17
C152 (\6\:mout VSS) capacitor c=6.40828e-17
C153 (\7\:mout VSS) capacitor c=5.87654e-17
C154 (\7\:n20 VSS) capacitor c=6.14204e-17
C155 (\8\:n20 VSS) capacitor c=7.58387e-17
C156 (\9\:CKbb VSS) capacitor c=4.997e-17
C157 (\16\:CKb VSS) capacitor c=6.58781e-17
C158 (\17\:CKb VSS) capacitor c=1.40702e-16
C159 (\18\:CKb VSS) capacitor c=1.47472e-16
C160 (\20\:CKb VSS) capacitor c=8.64984e-17
C161 (\21\:CKb VSS) capacitor c=2.07551e-17
C162 (\4\:CK VSS) capacitor c=8.13987e-17
C163 (\5\:D VSS) capacitor c=3.33259e-17
C164 (\3\:Db VSS) capacitor c=2.072e-16
C165 (\4\:SI VSS) capacitor c=7.25936e-17
C166 (\8\:SE VSS) capacitor c=7.15729e-17
C167 (\9\:SE VSS) capacitor c=7.97685e-17
C168 (\10\:SE VSS) capacitor c=3.69921e-17
C169 (\6\:SEb VSS) capacitor c=7.96664e-17
C170 (\7\:SEb VSS) capacitor c=6.65436e-17
C171 (\3\:VDD VSS) capacitor c=2.23958e-17
C172 (\9\:VDD VSS) capacitor c=2.43694e-17
C173 (\12\:VDD VSS) capacitor c=4.40864e-17
C174 (\18\:VDD VSS) capacitor c=3.40321e-17
C175 (\21\:VDD VSS) capacitor c=3.0118e-17
C176 (\25\:VDD VSS) capacitor c=1.40813e-17
C177 (\28\:VDD VSS) capacitor c=1.98425e-17
Rk59 (\2\:VSS \3\:VSS) resistor r=0.1754 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.3758 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.1001 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.2948 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.4752 c=0
Rk64 (\7\:VSS \8\:VSS) resistor r=0.4312 c=0
Rk65 (\8\:VSS \9\:VSS) resistor r=0.8542 c=0
Rk66 (\9\:VSS \10\:VSS) resistor r=0.3475 c=0
Rk67 (\10\:VSS \11\:VSS) resistor r=0.03492 c=0
Rk69 (\12\:VSS VSS) resistor r=0.1977 c=0
Rk68 (\11\:VSS \12\:VSS) resistor r=0.3182 c=0
Rk70 (\3\:VSS \14\:VSS) resistor r=0.2715 c=0
Rk71 (\4\:VSS \16\:VSS) resistor r=0.2199 c=0
Rk72 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk73 (\7\:VSS \20\:VSS) resistor r=0.3395 c=0
Rk74 (\9\:VSS \22\:VSS) resistor r=0.04332 c=0
Rk75 (\11\:VSS \24\:VSS) resistor r=0.2582 c=0
Rk76 (\12\:VSS \26\:VSS) resistor r=0.371 c=0
Rk46 (\4\:CK CK) resistor r=0.09742 c=0
Rk54 (\8\:SE SE) resistor r=0.1336 c=0
Rk53 (\8\:SE \9\:SE) resistor r=0.4362 c=0
Rk55 (SE \10\:SE) resistor r=0.1164 c=0
Rk25 (\7\:SN SN) resistor r=2.0206 c=0
Rk26 (SN \8\:SN) resistor r=0.00358 c=0
Rk52 (\4\:SI SI) resistor r=0.05785 c=0
Rk2 (\4\:QN QN) resistor r=0.09048 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3061 c=0
Rk77 (\2\:VDD \3\:VDD) resistor r=0.213 c=0
Rk78 (\3\:VDD \4\:VDD) resistor r=0.4387 c=0
Rk79 (\3\:VDD \6\:VDD) resistor r=0.2447 c=0
Rk80 (\4\:VDD \8\:VDD) resistor r=0.2864 c=0
Rk81 (\4\:VDD \9\:VDD) resistor r=0.2954 c=0
Rk82 (\9\:VDD \11\:VDD) resistor r=0.04332 c=0
Rk83 (\9\:VDD \12\:VDD) resistor r=0.4401 c=0
Rk84 (\12\:VDD \14\:VDD) resistor r=0.07405 c=0
Rk85 (\12\:VDD \15\:VDD) resistor r=0.4663 c=0
Rk86 (\15\:VDD \17\:VDD) resistor r=0.07149 c=0
Rk87 (\15\:VDD \18\:VDD) resistor r=0.5351 c=0
Rk88 (\18\:VDD \20\:VDD) resistor r=0.1463 c=0
Rk89 (\18\:VDD \21\:VDD) resistor r=0.3207 c=0
Rk90 (\21\:VDD \23\:VDD) resistor r=0.07405 c=0
Rk91 (\21\:VDD \24\:VDD) resistor r=0.3485 c=0
Rk92 (\24\:VDD \25\:VDD) resistor r=0.03492 c=0
Rk93 (\25\:VDD \27\:VDD) resistor r=0.215 c=0
Rk96 (\28\:VDD VDD) resistor r=0.1977 c=0
Rk94 (\25\:VDD \28\:VDD) resistor r=0.3182 c=0
Rk95 (\28\:VDD \30\:VDD) resistor r=0.4362 c=0
Rk8 (\4\:RN RN) resistor r=0.003004 c=0
Rk47 (\5\:D D) resistor r=0.08082 c=0
Rk6 (\2\:Q Q) resistor r=0.3961 c=0
Rk7 (Q \4\:Q) resistor r=0.1585 c=0
Rk3 (\6\:net573 \7\:net573) resistor r=0.1149 c=0
Rk4 (\7\:net573 \8\:net573) resistor r=0.1195 c=0
Rk5 (\7\:net573 \10\:net573) resistor r=0.1089 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.7739 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.1162 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.3429 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.4197 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=1.0444 c=0
Rk21 (\8\:RNb \9\:RNb) resistor r=0.6935 c=0
Rk22 (\9\:RNb \11\:RNb) resistor r=0.04766 c=0
Rk23 (\9\:RNb \13\:RNb) resistor r=0.7351 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=0.1596 c=0
Rk17 (\7\:n35 \8\:n35) resistor r=1.0844 c=0
Rk18 (\7\:n35 \10\:n35) resistor r=0.1645 c=0
Rk13 (\2\:n8 \4\:n8) resistor r=0.613 c=0
Rk15 (\2\:n10 \4\:n10) resistor r=0.3049 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.6601 c=0
Rk39 (\15\:CKb \16\:CKb) resistor r=0.302 c=0
Rk40 (\16\:CKb \17\:CKb) resistor r=0.4743 c=0
Rk41 (\17\:CKb \18\:CKb) resistor r=0.9474 c=0
Rk42 (\16\:CKb \19\:CKb) resistor r=0.3363 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.03275 c=0
Rk44 (\17\:CKb \21\:CKb) resistor r=0.05544 c=0
Rk45 (\19\:CKb \23\:CKb) resistor r=0.4207 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2298 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.2759 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.3131 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.3646 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.08682 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1233 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1374 c=0
Rk37 (\8\:CKbb \9\:CKbb) resistor r=0.1548 c=0
Rk38 (\9\:CKbb \11\:CKbb) resistor r=0.2173 c=0
Rk24 (\2\:n4 \4\:n4) resistor r=0.5012 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.1221 c=0
Rk35 (\7\:n20 \8\:n20) resistor r=0.3813 c=0
Rk36 (\7\:n20 \10\:n20) resistor r=0.2062 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.3369 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.0737 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.627 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.409 c=0
Rk56 (\5\:SEb \6\:SEb) resistor r=0.09154 c=0
Rk57 (\6\:SEb \7\:SEb) resistor r=0.4471 c=0
Rk58 (\6\:SEb \9\:SEb) resistor r=0.4716 c=0
Rk14 (\2\:n11 \4\:n11) resistor r=0.4176 c=0
Rl42 (\1\:CK \2\:CK) resistor r=39.1533 c=0
Rl43 (\2\:CK \3\:CK) resistor r=144.923 c=0
Rl54 (\6\:SE \7\:SE) resistor r=170.604 c=0
Rl53 (\5\:SE \6\:SE) resistor r=51.9231 c=0
Rl50 (\3\:SE \4\:SE) resistor r=35.7134 c=0
Rl47 (\1\:SE \2\:SE) resistor r=71.8456 c=0
Rl29 (\4\:SN \5\:SN) resistor r=138.487 c=0
Rl30 (\5\:SN \6\:SN) resistor r=50.6918 c=0
Rl15 (\1\:SN \2\:SN) resistor r=31.461 c=0
Rl16 (\2\:SN \3\:SN) resistor r=104.538 c=0
Rl52 (\2\:SI \3\:SI) resistor r=109.066 c=0
Rl51 (\1\:SI \2\:SI) resistor r=113.462 c=0
Rl10 (\1\:RN \2\:RN) resistor r=54.5379 c=0
Rl11 (\2\:RN \3\:RN) resistor r=204.538 c=0
Rl46 (\2\:D \4\:D) resistor r=106.794 c=0
Rl44 (\1\:D \2\:D) resistor r=178.614 c=0
Rl45 (\2\:D \3\:D) resistor r=5.487 c=0
Rl3 (\2\:net573 \4\:net573) resistor r=47.791 c=0
Rl2 (\2\:net573 \3\:net573) resistor r=36.2526 c=0
Rl1 (net573 \2\:net573) resistor r=5.915 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=161.538 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=38.5707 c=0
Rl4 (qbint \2\:qbint) resistor r=124.847 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=36.3849 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=6.2575 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=150.199 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=136.906 c=0
Rl19 (RNb \2\:RNb) resistor r=264.95 c=0
Rl25 (\5\:RNb \6\:RNb) resistor r=114.898 c=0
Rl20 (\2\:RNb \3\:RNb) resistor r=43.4636 c=0
Rl14 (\2\:n35 \4\:n35) resistor r=100.803 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=50.8027 c=0
Rl12 (n35 \2\:n35) resistor r=1.2334 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=74.7951 c=0
Rl41 (\9\:CKb \11\:CKb) resistor r=33.4251 c=0
Rl40 (\9\:CKb \10\:CKb) resistor r=180.746 c=0
Rl33 (\6\:CKb \7\:CKb) resistor r=66.8866 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=53.3592 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=117.979 c=0
Rl21 (CKb \2\:CKb) resistor r=93.4636 c=0
Rl31 (mout \2\:mout) resistor r=39.6174 c=0
Rl32 (\2\:mout \3\:mout) resistor r=87.6944 c=0
Rl37 (\4\:CKbb \5\:CKbb) resistor r=147.208 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=695.72 c=0
Rl34 (CKbb \2\:CKbb) resistor r=70.8353 c=0
Rl35 (\2\:CKbb \3\:CKbb) resistor r=146.132 c=0
Rl38 (\2\:CKbb \6\:CKbb) resistor r=86.4638 c=0
Rl26 (n20 \2\:n20) resistor r=97.2294 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=37.614 c=0
Rl28 (\2\:n20 \4\:n20) resistor r=4.7568 c=0
Rl48 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=193.464 c=0
Rz21 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz28 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz29 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz30 (\1\:VDD \15\:VDD) resistor r=6.25 c=0
Rz31 (\1\:VDD \24\:VDD) resistor r=6.25 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\9\:net573 \10\:net573) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\5\:n35 \6\:n35) resistor r=75 c=0
Rz5 (n8 \2\:n8) resistor r=75 c=0
Rz6 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz7 (n10 \2\:n10) resistor r=75 c=0
Rz8 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz17 (\22\:CKb \23\:CKb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz16 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (n4 \2\:n4) resistor r=75 c=0
Rz12 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry17 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry18 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry20 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry21 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry22 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry23 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry24 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry25 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry26 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry27 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry28 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\5\:net573 \6\:net573) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry13 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry12 (\7\:CKbb \8\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry5 (n11 \2\:n11) resistor r=62 c=0
Ry6 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx21 (\4\:SE \8\:SE) resistor r=45 c=0
Rx22 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\6\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx20 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (net573 \8\:net573) resistor r=45 c=0
Rx3 (\6\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \15\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (n35 \8\:n35) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx15 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx14 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx13 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net573 \25\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55 (\3\:Q \5\:qbint \23\:VSS VSS) g45n1hvt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.00769e-07 sd=160n sca=11.5806 scb=0.0111274 \
        scc=0.000535497 m=(1)
mn56 (\9\:net573 \4\:qbint \25\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=2.03e-14 ps=8.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\12\:RNb \3\:RN \23\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn45 (\13\:qbint \3\:n35 \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.97e-14 ad=2.03e-14 ps=1.36e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn50 (n8 \3\:SN \21\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=2.32e-14 ps=1.36e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.8e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn52 (\3\:n10 \9\:qbint n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.438e-14 ps=6.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.75e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=5.438e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.55e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn53 (\5\:n35 CKb n10 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:n35 \4\:CKbb \14\:mout VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \4\:RNb \3\:n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.682e-14 ps=5.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn32 (\12\:mout \3\:n20 n4 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=8.6e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn30 (n4 \4\:SN \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (n6 \3\:mout \19\:VSS VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=4.5e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1hvt w=(1.45e-07) l=4.5e-08 nf=1 \
