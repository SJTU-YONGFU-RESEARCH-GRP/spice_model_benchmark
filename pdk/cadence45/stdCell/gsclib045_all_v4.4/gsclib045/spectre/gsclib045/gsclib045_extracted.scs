        sa=2.45e-07 sb=5.65e-07 sd=160n sca=36.1614 scb=0.0267849 \
        scc=0.00344655 m=(1)
mp2 (n0 \1\:C n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.63e-14 \
        ad=4.095e-14 ps=1.12e-06 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=3.5e-07 sd=160n sca=35.408 scb=0.0252222 \
        scc=0.00339762 m=(1)
mp3 (\1\:Y \3\:D n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=7.8e-14 ps=9.9e-07 pd=1.18e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-07 sd=160n sca=39.5482 scb=0.03284 scc=0.00384048 \
        m=(1)
ends NOR4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:24:43 2012 )
// Library name: gsclib045
// Cell name: NOR4X2
// View name: extracted

simulator lang=spectre

subckt NOR4X2 A B C D VDD VSS Y
mp0 (2 \1\:A \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.42e-06 sd=160n sca=18.6506 \
        scb=0.0190998 scc=0.000768188 m=(1)
C1 (C VSS) capacitor c=4.45251e-17
C2 (D VSS) capacitor c=7.91693e-17
C3 (A VSS) capacitor c=5.48031e-16
C4 (VDD VSS) capacitor c=1.20782e-16
C5 (Y VSS) capacitor c=1.29428e-16
C6 (2 VSS) capacitor c=2.71439e-18
C7 (3 VSS) capacitor c=6.11733e-18
C8 (4 VSS) capacitor c=1.13875e-17
C9 (6 VSS) capacitor c=6.26401e-18
C10 (7 VSS) capacitor c=5.8704e-18
C11 (8 VSS) capacitor c=3.24579e-18
C12 (\6\:A VSS) capacitor c=6.61604e-17
C13 (\6\:B VSS) capacitor c=8.07439e-17
C14 (\4\:C VSS) capacitor c=8.33899e-17
C15 (\1\:D VSS) capacitor c=5.53486e-17
C16 (\4\:D VSS) capacitor c=2.48911e-17
C17 (\1\:C VSS) capacitor c=4.17998e-17
C18 (\1\:B VSS) capacitor c=7.34669e-17
C19 (\1\:A VSS) capacitor c=5.95702e-17
C20 (\3\:D VSS) capacitor c=8.72912e-17
C21 (\2\:C VSS) capacitor c=3.79774e-16
C22 (\2\:B VSS) capacitor c=5.14314e-16
C23 (\1\:VDD VSS) capacitor c=4.25311e-17
C24 (\9\:Y VSS) capacitor c=9.79601e-17
C25 (\6\:VDD VSS) capacitor c=3.33808e-17
C26 (\1\:Y VSS) capacitor c=3.20993e-16
C27 (\2\:D VSS) capacitor c=2.19711e-17
C28 (\8\:D VSS) capacitor c=6.46352e-17
C29 (\4\:VDD VSS) capacitor c=3.52865e-17
C30 (\5\:VDD VSS) capacitor c=1.4839e-17
Rk17 (\1\:VSS VSS) resistor r=0.0151 c=0
Rk20 (\1\:VSS \10\:VSS) resistor r=0.1993 c=0
Rk6 (C \2\:C) resistor r=0.1193 c=0
Rk3 (D \8\:D) resistor r=0.0177 c=0
Rk26 (\2\:VDD \4\:VDD) resistor r=0.4119 c=0
Rk28 (\5\:VDD VDD) resistor r=0.07227 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.3784 c=0
Rk29 (\5\:VDD \7\:VDD) resistor r=0.224 c=0
Rk13 (\1\:Y Y) resistor r=0.6934 c=0
Rk14 (Y \10\:Y) resistor r=0.6432 c=0
Rk5 (\2\:B B) resistor r=0.005639 c=0
Rl12 (\2\:C \4\:C) resistor r=114.153 c=0
Rl5 (\2\:C \1\:C) resistor r=56.461 c=0
Rl7 (\2\:D \1\:D) resistor r=100.426 c=0
Rl9 (\2\:D \4\:D) resistor r=35.772 c=0
Rl8 (\2\:D \3\:D) resistor r=87.6951 c=0
Rl17 (A \6\:A) resistor r=59.8103 c=0
Rl1 (A \1\:A) resistor r=49.05 c=0
Rl15 (\2\:B \6\:B) resistor r=29.5379 c=0
Rl3 (\2\:B \1\:B) resistor r=44.9225 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\10\:Y \9\:Y) resistor r=62 c=0
Rx1 (\8\:D \3\:D) resistor r=45 c=0
mn0 (\1\:Y A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.55e-14 ps=8.15e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (\1\:Y \2\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.55e-14 ps=8.55e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.46e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2 (\1\:Y \2\:C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.745e-14 ps=8.55e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.24e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn3 (\1\:Y \3\:D \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.745e-14 ps=8.4e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.02e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp1 (3 \1\:B 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.825e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.315e-06 sd=160n sca=16.4248 scb=0.0152088 \
        scc=0.000666128 m=(1)
mp2 (3 \1\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.75e-14 \
        ad=6.825e-14 ps=1.28e-06 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=1.095e-06 sd=160n sca=14.4756 scb=0.0126313 \
        scc=0.000647839 m=(1)
mp3 (\9\:Y \4\:D 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.75e-14 \
        ad=6.24e-14 ps=1.28e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=7.6e-07 sb=8e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (\9\:Y \1\:D 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=5.95e-07 sd=160n sca=13.8806 \
        scb=0.0122706 scc=0.000647529 m=(1)
mp2_1__rcx (6 \4\:C 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.485e-14 ps=1.01e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=4.35e-07 sd=160n sca=14.5014 \
        scb=0.0126527 scc=0.000647871 m=(1)
mp1_1__rcx (8 \6\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=2.75e-07 sd=160n sca=15.7201 \
        scb=0.0141032 scc=0.000654378 m=(1)
mp0_1__rcx (8 \6\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=2.34e-14 ps=1.57e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.7e-07 sd=160n sca=17.2962 \
        scb=0.0167016 scc=0.000693147 m=(1)
ends NOR4X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:25:23 2012 )
// Library name: gsclib045
// Cell name: NOR4X4
// View name: extracted

simulator lang=spectre

subckt NOR4X4 A B C D VDD VSS Y
mp0 (n2 A \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.094e-14 ps=1.1e-06 pd=1.0925e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.58e-06 sd=160n sca=22.8747 scb=0.0261588 \
        scc=0.00121841 m=(4)
C1 (Y VSS) capacitor c=2.35683e-16
C2 (B VSS) capacitor c=4.37015e-16
C3 (D VSS) capacitor c=5.06793e-17
C4 (A VSS) capacitor c=3.62286e-16
C5 (C VSS) capacitor c=3.74424e-16
C6 (VDD VSS) capacitor c=2.50693e-16
C7 (n2 VSS) capacitor c=3.92667e-16
C8 (n1 VSS) capacitor c=1.75576e-16
C9 (n0 VSS) capacitor c=3.65698e-16
C10 (\1\:D VSS) capacitor c=3.17502e-16
C11 (\18\:Y VSS) capacitor c=3.42599e-16
C12 (\4\:n1 VSS) capacitor c=1.49031e-16
C13 (\1\:VDD VSS) capacitor c=1.61943e-16
C14 (\1\:Y VSS) capacitor c=1.08062e-16
C15 (\5\:Y VSS) capacitor c=1.22523e-16
C16 (\9\:Y VSS) capacitor c=1.06564e-16
C17 (\14\:Y VSS) capacitor c=7.91868e-17
C18 (\13\:Y VSS) capacitor c=2.87777e-17
C19 (\4\:VDD VSS) capacitor c=1.18205e-16
Rk29 (Y \18\:Y) resistor r=1.6043 c=0
Rk21 (\1\:Y \5\:Y) resistor r=0.281 c=0
Rk23 (\5\:Y \9\:Y) resistor r=0.2729 c=0
Rk28 (\13\:Y Y) resistor r=0.136 c=0
Rk25 (\9\:Y \13\:Y) resistor r=0.2413 c=0
Rk26 (\13\:Y \14\:Y) resistor r=0.05874 c=0
Rk19 (\1\:D D) resistor r=0.1482 c=0
Rk48 (\16\:VSS VSS) resistor r=0.04989 c=0
Rk47 (\1\:VSS \16\:VSS) resistor r=0.1076 c=0
Rk57 (\2\:VDD \3\:VDD) resistor r=0.9527 c=0
Rk60 (\4\:VDD VDD) resistor r=0.1023 c=0
Rk58 (\3\:VDD \4\:VDD) resistor r=0.243 c=0
Rk15 (n1 \4\:n1) resistor r=0.4695 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz19 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry20 (\1\:VSS \3\:VSS) resistor r=3.6471 c=0
Ry21 (\16\:VSS \3\:VSS) resistor r=31 c=0
mn0 (\14\:Y A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
mn1 (\9\:Y B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
mn2 (\5\:Y C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(4)
mn3 (\1\:Y \1\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(4)
mp1 (\4\:n1 B n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.094e-14 \
        ad=6.24e-14 ps=1.0925e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.65e-07 sb=7.55e-07 sd=160n sca=12.0739 scb=0.0104574 \
        scc=0.000357242 m=(4)
mp2 (n0 C n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp3 (\18\:Y \1\:D n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=13.7486 \
        scb=0.0122257 scc=0.000647518 m=(4)
ends NOR4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:26:01 2012 )
// Library name: gsclib045
// Cell name: NOR4X6
// View name: extracted

simulator lang=spectre

subckt NOR4X6 A B C D VDD VSS Y
mp0 (n2 \1\:A \4\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.52e-14 ps=1.252e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=35.9918 scb=0.0311691 \
        scc=0.00336409 m=(5)
C1 (B VSS) capacitor c=2.7624e-17
C2 (D VSS) capacitor c=1.87078e-17
C3 (A VSS) capacitor c=2.02693e-17
C4 (VDD VSS) capacitor c=1.2857e-16
C5 (Y VSS) capacitor c=1.75887e-17
C6 (C VSS) capacitor c=1.87813e-17
C7 (n2 VSS) capacitor c=3.92045e-16
C8 (n1 VSS) capacitor c=3.82306e-16
C9 (n0 VSS) capacitor c=4.05138e-16
C10 (\1\:A VSS) capacitor c=3.26105e-16
C11 (\1\:D VSS) capacitor c=3.2843e-16
C12 (\1\:C VSS) capacitor c=3.91865e-16
C13 (\1\:B VSS) capacitor c=3.43571e-16
C14 (\1\:Y VSS) capacitor c=2.10101e-16
C15 (\1\:VDD VSS) capacitor c=2.154e-16
C16 (\6\:Y VSS) capacitor c=4.28757e-16
C17 (\23\:Y VSS) capacitor c=4.30661e-16
C18 (\4\:VDD VSS) capacitor c=1.39517e-16
Rk48 (\1\:VSS \7\:VSS) resistor r=0.2558 c=0
Rk55 (\7\:VSS \14\:VSS) resistor r=0.1201 c=0
Rk61 (\15\:VSS VSS) resistor r=0.02713 c=0
Rk56 (\14\:VSS \15\:VSS) resistor r=0.1126 c=0
Rk4 (\1\:B B) resistor r=0.02719 c=0
Rk16 (D \1\:D) resistor r=0.04317 c=0
Rk1 (A \1\:A) resistor r=0.03496 c=0
Rk72 (\2\:VDD \3\:VDD) resistor r=0.9525 c=0
Rk78 (\4\:VDD VDD) resistor r=0.02713 c=0
Rk73 (\3\:VDD \4\:VDD) resistor r=0.6139 c=0
Rk24 (\1\:Y Y) resistor r=0.1752 c=0
Rk25 (Y \6\:Y) resistor r=0.03789 c=0
Rk36 (\6\:Y \23\:Y) resistor r=0.372 c=0
Rk10 (C \1\:C) resistor r=0.03296 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz23 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz25 (\4\:VDD \1\:VDD) resistor r=15 c=0
Ry21 (\1\:VSS \3\:VSS) resistor r=7.75 c=0
Ry22 (\7\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry24 (\14\:VSS \3\:VSS) resistor r=31 c=0
Ry26 (\15\:VSS \3\:VSS) resistor r=12.4 c=0
mn0 (\23\:Y \1\:A \15\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.301e-14 ps=9.32e-07 pd=9.62e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn1 (\23\:Y \1\:B \7\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=5.301e-14 ps=9.84e-07 pd=9.62e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn2 (\6\:Y \1\:C \7\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=5.549e-14 ps=9.84e-07 pd=9.78e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn3 (\6\:Y \1\:D \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.549e-14 ps=9.32e-07 pd=9.78e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mp1 (n1 \1\:B n2 VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=8.554e-14 \
        ad=8.037e-14 ps=1.304e-06 pd=1.282e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.165e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
mp2 (n0 \1\:C n1 VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=8.037e-14 \
        ad=8.225e-14 ps=1.282e-06 pd=1.29e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 scc=0.0027966 \
        m=(5)
mp3 (\1\:Y \1\:D n0 VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=8.225e-14 \
        ad=8.554e-14 ps=1.29e-06 pd=1.304e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.025e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
ends NOR4X6
// End of subcircuit definition.

// Generated for: spectre (May  9 16:26:40 2012 )
// Library name: gsclib045
// Cell name: NOR4X8
// View name: extracted

simulator lang=spectre

subckt NOR4X8 A B C D VDD VSS Y
mp0 (n2 \1\:A VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=6.993e-14 \
        ad=7.438e-14 ps=1.20429e-06 pd=1.22429e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=40.0554 scb=0.035826 \
        scc=0.00405312 m=(7)
C1 (B VSS) capacitor c=2.59026e-17
C2 (D VSS) capacitor c=2.91724e-17
C3 (A VSS) capacitor c=1.86567e-17
C4 (VDD VSS) capacitor c=4.21936e-16
C5 (Y VSS) capacitor c=2.78438e-16
C6 (C VSS) capacitor c=2.40417e-17
C7 (n2 VSS) capacitor c=5.42238e-16
C8 (n1 VSS) capacitor c=4.70434e-16
C9 (n0 VSS) capacitor c=5.21197e-16
C10 (\1\:D VSS) capacitor c=4.60382e-16
C11 (\1\:C VSS) capacitor c=5.22583e-16
C12 (\1\:B VSS) capacitor c=4.19574e-16
C13 (\1\:A VSS) capacitor c=4.2486e-16
C14 (\1\:VDD VSS) capacitor c=2.17172e-16
C15 (\18\:Y VSS) capacitor c=3.50623e-16
C16 (\5\:Y VSS) capacitor c=3.75148e-16
Rk72 (\3\:VSS VSS) resistor r=0.2226 c=0
Rk8 (\1\:B B) resistor r=0.002661 c=0
Rk29 (\1\:D D) resistor r=0.01651 c=0
Rk4 (\1\:A A) resistor r=0.01721 c=0
Rk91 (\3\:VDD VDD) resistor r=1.1293 c=0
Rk90 (\2\:VDD \3\:VDD) resistor r=0.9517 c=0
Rk39 (Y \5\:Y) resistor r=0.1924 c=0
Rk46 (\5\:Y \18\:Y) resistor r=0.2806 c=0
Rk26 (\1\:C C) resistor r=0.05244 c=0
Rz32 (VDD \1\:VDD) resistor r=6.25 c=0
Rz30 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz31 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Ry27 (\1\:VSS \3\:VSS) resistor r=0.2023 c=0
mn0 (\18\:Y \1\:A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.931e-14 ps=9.0429e-07 pd=9.2429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.06566 scb=0.00745694 \
        scc=0.000223945 m=(7)
mn1 (\18\:Y \1\:B \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.931e-14 ps=9.1e-07 pd=9.2429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=2e-06 sd=160n sca=9.06566 \
        scb=0.00745694 scc=0.000223945 m=(7)
mn2 (\5\:Y \1\:C \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.06566 scb=0.00745694 \
        scc=0.000223945 m=(7)
mn3 (\5\:Y \1\:D \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=9.06566 \
        scb=0.00745694 scc=0.000223945 m=(7)
mp1 (n1 \1\:B n2 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.438e-14 \
        ad=7.12e-14 ps=1.22429e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.625e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(7)
mp2 (n0 \1\:C n1 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.12e-14 \
        ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 scc=0.00295096 \
        m=(7)
mp3 (Y \1\:D n0 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.12e-14 \
        ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.37e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(7)
ends NOR4X8
// End of subcircuit definition.

// Generated for: spectre (May  9 16:27:19 2012 )
// Library name: gsclib045
// Cell name: NOR4XL
// View name: extracted

simulator lang=spectre

subckt NOR4XL A B C D VDD VSS Y
mp0 (n2 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=53.7316 \
        scb=0.0398978 scc=0.00628878 m=(1)
C1 (B VSS) capacitor c=7.99274e-17
C2 (D VSS) capacitor c=5.70989e-17
C3 (A VSS) capacitor c=5.53085e-17
C4 (VDD VSS) capacitor c=5.82427e-17
C5 (C VSS) capacitor c=6.62415e-17
C6 (n1 VSS) capacitor c=5.18066e-18
C7 (n0 VSS) capacitor c=1.84302e-19
C8 (\3\:D VSS) capacitor c=3.59967e-17
C9 (\1\:C VSS) capacitor c=3.95164e-17
C10 (\1\:B VSS) capacitor c=2.7433e-17
C11 (\1\:A VSS) capacitor c=2.73784e-17
C12 (\1\:D VSS) capacitor c=3.03876e-17
C13 (\3\:C VSS) capacitor c=3.88626e-17
C14 (\3\:B VSS) capacitor c=4.63369e-17
C15 (\3\:A VSS) capacitor c=3.249e-17
C16 (\2\:D VSS) capacitor c=4.00648e-17
C17 (\2\:C VSS) capacitor c=5.08445e-17
C18 (\2\:B VSS) capacitor c=4.91436e-17
C19 (\2\:A VSS) capacitor c=3.537e-17
C20 (\1\:Y VSS) capacitor c=7.78888e-17
C21 (\5\:VDD VSS) capacitor c=3.09709e-17
C22 (\1\:VDD VSS) capacitor c=2.89701e-17
C23 (\6\:Y VSS) capacitor c=2.82032e-17
C24 (\4\:Y VSS) capacitor c=6.51892e-17
C25 (\4\:A VSS) capacitor c=3.46066e-17
C26 (\4\:B VSS) capacitor c=2.80311e-17
C27 (\4\:C VSS) capacitor c=6.10294e-17
C28 (\4\:D VSS) capacitor c=6.44684e-17
C29 (\3\:Y VSS) capacitor c=9.85847e-17
Rk11 (\2\:VSS \4\:VSS) resistor r=0.2781 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.1577 c=0
Rk13 (\5\:VSS \6\:VSS) resistor r=0.09255 c=0
Rk15 (\7\:VSS VSS) resistor r=0.03715 c=0
Rk14 (\6\:VSS \7\:VSS) resistor r=0.1126 c=0
Rk17 (\5\:VSS \10\:VSS) resistor r=0.2008 c=0
Rk18 (\7\:VSS \12\:VSS) resistor r=0.1993 c=0
Rk4 (\4\:B B) resistor r=0.03896 c=0
Rk6 (D \4\:D) resistor r=0.2144 c=0
Rk1 (\4\:A A) resistor r=0.1003 c=0
Rk20 (\3\:VDD VDD) resistor r=0.03715 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.263 c=0
Rk22 (\3\:VDD \6\:VDD) resistor r=0.4163 c=0
Rk7 (Y \2\:Y) resistor r=0.002892 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.5939 c=0
Rk9 (\3\:Y \5\:Y) resistor r=0.4263 c=0
Rk10 (\3\:Y \7\:Y) resistor r=0.09641 c=0
Rk5 (C \4\:C) resistor r=0.2038 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=133.384 c=0
Rl8 (\2\:D \3\:D) resistor r=72.5275 c=0
Rl7 (\1\:D \2\:D) resistor r=92.3077 c=0
Rl1 (\1\:A \2\:A) resistor r=72.3097 c=0
Rl2 (\2\:A \3\:A) resistor r=87.6944 c=0
Rl5 (\1\:C \2\:C) resistor r=62.2302 c=0
Rl6 (\2\:C \3\:C) resistor r=100.692 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Ry4 (\3\:VSS VSS) resistor r=62 c=0
Ry2 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry3 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (\4\:Y \3\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.2e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn1 (\4\:Y \3\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.15e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (\6\:Y \3\:C \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.827e-14 ps=6.7e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.8e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn3 (\6\:Y \1\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.828e-14 ps=5.7e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.4e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mp1 (n1 \1\:B n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=4.085e-14 ps=7.5e-07 pd=8.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=6.25e-07 sd=160n sca=48.9361 scb=0.0309872 \
        scc=0.00589512 m=(1)
mp2 (n0 \1\:C n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.085e-14 \
        ad=2.58e-14 ps=8.1e-07 pd=6.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.8e-07 sb=3.9e-07 sd=160n sca=48.9361 scb=0.0309872 \
        scc=0.00589512 m=(1)
mp3 (\1\:Y \3\:D n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=2.58e-14 \
        ad=4.838e-14 ps=6.7e-07 pd=8.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.45e-07 sb=2.25e-07 sd=160n sca=52.0454 scb=0.0370257 \
        scc=0.00608774 m=(1)
ends NOR4XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:18:56 2012 )
// Library name: gsclib045
// Cell name: OA21X1
// View name: extracted

simulator lang=spectre

subckt OA21X1 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.85e-07 sd=160n sca=26.8266 \
        scb=0.0313637 scc=0.00190754 m=(1)
C1 (B0 VSS) capacitor c=4.14605e-17
C2 (A1 VSS) capacitor c=4.75635e-17
C3 (VDD VSS) capacitor c=8.19909e-17
C4 (Y VSS) capacitor c=1.23893e-17
C5 (net107 VSS) capacitor c=6.19835e-17
C6 (net95 VSS) capacitor c=3.86581e-17
C7 (net98 VSS) capacitor c=8.98266e-18
C8 (\4\:net95 VSS) capacitor c=4.77688e-17
C9 (\1\:B0 VSS) capacitor c=6.11187e-17
C10 (\1\:A1 VSS) capacitor c=3.86324e-17
C11 (\1\:A0 VSS) capacitor c=4.75352e-17
C12 (\3\:B0 VSS) capacitor c=2.80236e-17
C13 (\3\:A1 VSS) capacitor c=5.33822e-17
C14 (\4\:A0 VSS) capacitor c=3.12319e-17
C15 (\3\:net95 VSS) capacitor c=2.46289e-17
C16 (\2\:B0 VSS) capacitor c=5.10039e-17
C17 (\2\:A1 VSS) capacitor c=5.59085e-17
C18 (\3\:A0 VSS) capacitor c=1.45659e-17
C19 (\1\:Y VSS) capacitor c=7.17598e-17
C20 (\1\:VDD VSS) capacitor c=6.44634e-17
C21 (\8\:net95 VSS) capacitor c=6.17774e-17
C22 (\5\:VDD VSS) capacitor c=1.83048e-17
C23 (\3\:Y VSS) capacitor c=4.80424e-17
C24 (\5\:net95 VSS) capacitor c=5.64841e-17
C25 (\3\:net107 VSS) capacitor c=4.18056e-17
C26 (\2\:A0 VSS) capacitor c=3.17177e-17
C27 (\2\:net95 VSS) capacitor c=1.92177e-17
C28 (\5\:A0 VSS) capacitor c=3.93457e-17
C29 (\7\:A0 VSS) capacitor c=3.76154e-17
C30 (\4\:A1 VSS) capacitor c=3.2107e-17
C31 (\6\:B0 VSS) capacitor c=4.58927e-17
C32 (\7\:net95 VSS) capacitor c=7.35732e-17
C33 (\4\:VDD VSS) capacitor c=2.81124e-17
Rk6 (\4\:B0 B0) resistor r=0.006735 c=0
Rk8 (\4\:B0 \6\:B0) resistor r=0.02172 c=0
Rk7 (\5\:B0 \6\:B0) resistor r=0.006735 c=0
Rk4 (\4\:A1 A1) resistor r=0.1016 c=0
Rk21 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk20 (\2\:VDD \4\:VDD) resistor r=0.3682 c=0
Rk22 (VDD \6\:VDD) resistor r=0.3148 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002221 c=0
Rk2 (A0 \7\:A0) resistor r=0.002132 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.1329 c=0
Rk12 (\4\:Y Y) resistor r=0.03658 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5453 c=0
Rk13 (\2\:VSS \3\:VSS) resistor r=0.07749 c=0
Rk14 (\3\:VSS \4\:VSS) resistor r=0.1226 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.1326 c=0
Rk17 (\6\:VSS VSS) resistor r=0.04987 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.06747 c=0
Rk18 (\3\:VSS \8\:VSS) resistor r=0.1333 c=0
Rk19 (\5\:VSS \10\:VSS) resistor r=0.07346 c=0
Rk5 (\2\:net107 \4\:net107) resistor r=0.2251 c=0
Rk9 (\6\:net95 \7\:net95) resistor r=0.2976 c=0
Rk10 (\7\:net95 \9\:net95) resistor r=0.3018 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=153.021 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=26.098 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=62.6365 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.483 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.022 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=36.2526 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=4.3144 c=0
Rl8 (net95 \2\:net95) resistor r=122.357 c=0
Rl10 (\2\:net95 \4\:net95) resistor r=57.4064 c=0
Rl9 (\2\:net95 \3\:net95) resistor r=4.3144 c=0
Rz4 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\5\:net95 \6\:net95) resistor r=75 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\8\:net95 \9\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
Rx4 (\3\:net95 \7\:net95) resistor r=45 c=0
mn0 (\3\:net107 \4\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (net107 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.465e-14 ps=1.31e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:net95 \3\:B0 net107 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.67e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp1 (\8\:net95 \1\:A1 net98 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.655e-14 ps=7.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.9e-07 sd=160n sca=17.3843 \
        scb=0.0171664 scc=0.000551089 m=(1)
mp2 (\8\:net95 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.75e-07 sd=160n sca=15.8515 \
        scb=0.0140891 scc=0.000503754 m=(1)
mp3 (\1\:Y \4\:net95 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95577e-07 sb=1.4e-07 sd=160n sca=17.0231 \
        scb=0.0168642 scc=0.000422034 m=(1)
ends OA21X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:28:35 2012 )
// Library name: gsclib045
// Cell name: OA21X2
// View name: extracted

simulator lang=spectre

subckt OA21X2 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=16.3381 \
        scb=0.0159051 scc=0.000527857 m=(1)
C1 (B0 VSS) capacitor c=4.52623e-17
C2 (A1 VSS) capacitor c=5.30179e-17
C3 (VDD VSS) capacitor c=9.11576e-17
C4 (A0 VSS) capacitor c=5.79148e-17
C5 (Y VSS) capacitor c=6.42076e-17
C6 (net107 VSS) capacitor c=4.0773e-17
C7 (net95 VSS) capacitor c=5.60414e-17
C8 (\1\:B0 VSS) capacitor c=5.83617e-17
C9 (\1\:A1 VSS) capacitor c=5.17765e-17
C10 (\1\:A0 VSS) capacitor c=4.08265e-17
C11 (\3\:B0 VSS) capacitor c=2.76426e-17
C12 (\3\:A1 VSS) capacitor c=3.59487e-17
C13 (\4\:A0 VSS) capacitor c=3.17701e-17
C14 (\5\:net95 VSS) capacitor c=1.76663e-17
C15 (\2\:B0 VSS) capacitor c=3.67845e-17
C16 (\2\:A1 VSS) capacitor c=4.44842e-17
C17 (\3\:A0 VSS) capacitor c=1.44244e-17
C18 (\1\:Y VSS) capacitor c=9.81773e-17
C19 (\12\:net95 VSS) capacitor c=3.76137e-17
C20 (\12\:VDD VSS) capacitor c=2.46494e-17
C21 (\1\:VDD VSS) capacitor c=3.1186e-17
C22 (\3\:Y VSS) capacitor c=1.15629e-17
C23 (\10\:net95 VSS) capacitor c=7.22444e-17
C24 (\3\:net107 VSS) capacitor c=6.15537e-17
C25 (\2\:A0 VSS) capacitor c=2.81475e-17
C26 (\3\:net95 VSS) capacitor c=8.05225e-17
C27 (\5\:A0 VSS) capacitor c=3.73361e-17
C28 (\4\:A1 VSS) capacitor c=3.83291e-17
C29 (\4\:B0 VSS) capacitor c=6.73026e-17
C30 (\9\:net95 VSS) capacitor c=7.51373e-17
C31 (\3\:VDD VSS) capacitor c=1.08475e-16
C32 (\7\:VDD VSS) capacitor c=2.61173e-18
Rk4 (B0 \4\:B0) resistor r=0.2022 c=0
Rk2 (\4\:A1 A1) resistor r=0.1814 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.08184 c=0
Rk22 (\3\:VDD \6\:VDD) resistor r=0.2608 c=0
Rk24 (\7\:VDD VDD) resistor r=0.1139 c=0
Rk23 (\6\:VDD \7\:VDD) resistor r=0.08432 c=0
Rk27 (\7\:VDD \13\:VDD) resistor r=0.3012 c=0
Rk1 (A0 \5\:A0) resistor r=0.1398 c=0
Rk7 (\2\:Y Y) resistor r=0.4606 c=0
Rk8 (Y \4\:Y) resistor r=0.119 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.02964 c=0
Rk12 (\3\:VSS \6\:VSS) resistor r=0.149 c=0
Rk13 (\6\:VSS \7\:VSS) resistor r=0.1664 c=0
Rk15 (\8\:VSS VSS) resistor r=0.09918 c=0
Rk14 (\7\:VSS \8\:VSS) resistor r=0.1316 c=0
Rk18 (\7\:VSS \14\:VSS) resistor r=0.0722 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.233 c=0
Rk5 (\9\:net95 \11\:net95) resistor r=0.3825 c=0
Rk6 (\9\:net95 \13\:net95) resistor r=0.2905 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=156.461 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.5379 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=146.846 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=39.1533 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.022 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=36.2526 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=11.4953 c=0
Rl9 (\3\:net95 net95) resistor r=70.2199 c=0
Rl11 (\3\:net95 \5\:net95) resistor r=4.6885 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz10 (\6\:VDD \1\:VDD) resistor r=15 c=0
Rz4 (\4\:Y \3\:Y) resistor r=75 c=0
Rz7 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\11\:net95 \10\:net95) resistor r=75 c=0
Ry9 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry3 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry4 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry5 (\6\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry6 (\8\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry1 (\13\:net95 \12\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\9\:net95 \5\:net95) resistor r=45 c=0
mn0 (net107 \4\:A0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\3\:net107 \3\:A1 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=2.9e-14 ps=1.31e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=4.8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\10\:net95 \3\:B0 \3\:net107 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=3.407e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.35e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mp1 (\12\:net95 \1\:A1 net98 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=4.3e-14 ps=7.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=8.45e-07 sd=160n sca=14.3247 \
        scb=0.0130249 scc=0.000501931 m=(1)
mp2 (\12\:net95 \1\:B0 \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=4.3e-14 ps=1.2e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=6e-07 sd=160n sca=13.4265 scb=0.0124078 \
        scc=0.000501184 m=(1)
mp3 (\1\:Y \3\:net95 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.23141e-07 sb=3.45e-07 sd=160n sca=12.736 \
        scb=0.0105861 scc=0.000311807 m=(2)
ends OA21X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:29:14 2012 )
// Library name: gsclib045
// Cell name: OA21X4
// View name: extracted

simulator lang=spectre

subckt OA21X4 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=21.318 \
        scb=0.0198005 scc=0.0015222 m=(1)
C1 (B0 VSS) capacitor c=7.51839e-17
C2 (A1 VSS) capacitor c=3.28799e-17
C3 (A0 VSS) capacitor c=3.56627e-17
C4 (Y VSS) capacitor c=5.38026e-17
C5 (VDD VSS) capacitor c=9.95732e-17
C6 (net107 VSS) capacitor c=6.25735e-17
C7 (net95 VSS) capacitor c=3.00377e-16
C8 (\1\:B0 VSS) capacitor c=4.35721e-17
C9 (\1\:A1 VSS) capacitor c=9.0068e-17
C10 (\1\:A0 VSS) capacitor c=7.3961e-17
C11 (\3\:B0 VSS) capacitor c=3.56554e-17
C12 (\3\:A1 VSS) capacitor c=4.32375e-17
C13 (\4\:A0 VSS) capacitor c=3.74913e-17
C14 (\2\:B0 VSS) capacitor c=3.67765e-17
C15 (\2\:A1 VSS) capacitor c=5.83505e-17
C16 (\3\:A0 VSS) capacitor c=1.7297e-17
C17 (\1\:VDD VSS) capacitor c=1.68446e-16
C18 (\1\:Y VSS) capacitor c=2.05914e-16
C19 (\18\:net95 VSS) capacitor c=8.97062e-17
C20 (\14\:VDD VSS) capacitor c=1.98345e-17
C21 (\3\:VDD VSS) capacitor c=4.15509e-17
C22 (\4\:Y VSS) capacitor c=1.02213e-16
C23 (\20\:net95 VSS) capacitor c=5.81315e-17
C24 (\3\:net107 VSS) capacitor c=4.66603e-17
C25 (\2\:A0 VSS) capacitor c=5.03809e-17
C26 (\5\:A0 VSS) capacitor c=1.62866e-17
C27 (\4\:A1 VSS) capacitor c=7.02816e-17
C28 (\4\:B0 VSS) capacitor c=3.17114e-17
C29 (\17\:net95 VSS) capacitor c=9.83923e-17
C30 (\13\:VDD VSS) capacitor c=4.54432e-19
Rk4 (\4\:B0 B0) resistor r=0.164 c=0
Rk2 (A1 \4\:A1) resistor r=0.06334 c=0
Rk17 (\1\:VSS \7\:VSS) resistor r=0.1977 c=0
Rk18 (\7\:VSS \8\:VSS) resistor r=0.1426 c=0
Rk20 (\9\:VSS VSS) resistor r=0.04984 c=0
Rk19 (\8\:VSS \9\:VSS) resistor r=0.1075 c=0
Rk23 (\8\:VSS \15\:VSS) resistor r=0.1726 c=0
Rk1 (A0 \5\:A0) resistor r=0.0987 c=0
Rk10 (\1\:Y Y) resistor r=0.1568 c=0
Rk11 (Y \4\:Y) resistor r=0.1759 c=0
Rk30 (\1\:VDD \12\:VDD) resistor r=0.2127 c=0
Rk33 (\13\:VDD VDD) resistor r=0.1047 c=0
Rk31 (\12\:VDD \13\:VDD) resistor r=0.04488 c=0
Rk32 (\13\:VDD \15\:VDD) resistor r=0.2588 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.2381 c=0
Rk6 (net95 \17\:net95) resistor r=0.1939 c=0
Rk7 (\17\:net95 \19\:net95) resistor r=0.6004 c=0
Rk8 (\17\:net95 \21\:net95) resistor r=0.3853 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=98.7687 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=56.461 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=102.615 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=52.6149 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=101.317 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=60.1705 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=22.7732 c=0
Rz9 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz10 (\1\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz12 (\12\:VDD \3\:VDD) resistor r=18.75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\21\:net95 \20\:net95) resistor r=75 c=0
Ry4 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry5 (\7\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry6 (\9\:VSS \3\:VSS) resistor r=31 c=0
Ry10 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\19\:net95 \18\:net95) resistor r=31 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (\3\:net107 \4\:A0 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.28462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (net107 \3\:A1 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.23462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\20\:net95 \3\:B0 net107 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.08e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.18462e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\4\:Y net95 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mp1 (\18\:net95 \1\:A1 net98 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.365e-06 sd=160n sca=19.8317 \
        scb=0.0173912 scc=0.00148974 m=(1)
mp2 (\18\:net95 \1\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=6.24e-14 ps=1.5e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.16e-06 sd=160n sca=18.4632 \
        scb=0.0159033 scc=0.00148415 m=(1)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.55e-07 sd=160n sca=17.7856 \
        scb=0.015626 scc=0.00148402 m=(4)
ends OA21X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:29:52 2012 )
// Library name: gsclib045
// Cell name: OA21XL
// View name: extracted

simulator lang=spectre

subckt OA21XL A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.398e-14 ps=7.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=19.249 scb=0.0210034 \
        scc=0.000704741 m=(1)
C1 (B0 VSS) capacitor c=4.89713e-17
C2 (A1 VSS) capacitor c=6.9298e-17
C3 (A0 VSS) capacitor c=8.98531e-17
C4 (Y VSS) capacitor c=6.96147e-17
C5 (VDD VSS) capacitor c=6.64712e-17
C6 (net107 VSS) capacitor c=2.90283e-17
C7 (net95 VSS) capacitor c=2.59945e-17
C8 (\4\:net95 VSS) capacitor c=3.51612e-17
C9 (\1\:B0 VSS) capacitor c=4.46058e-17
C10 (\4\:A1 VSS) capacitor c=6.65838e-17
C11 (\1\:A0 VSS) capacitor c=4.73719e-17
C12 (\3\:B0 VSS) capacitor c=2.35687e-17
C13 (\3\:A1 VSS) capacitor c=3.75895e-17
C14 (\3\:A0 VSS) capacitor c=4.24458e-17
C15 (\3\:net95 VSS) capacitor c=2.27847e-17
C16 (\2\:B0 VSS) capacitor c=5.7994e-17
C17 (\1\:A1 VSS) capacitor c=1.71398e-17
C18 (\2\:A0 VSS) capacitor c=5.18022e-17
C19 (\1\:Y VSS) capacitor c=4.07248e-17
C20 (\1\:VDD VSS) capacitor c=3.14302e-17
C21 (\8\:net95 VSS) capacitor c=6.24011e-17
C22 (\6\:VDD VSS) capacitor c=1.38918e-17
C23 (\3\:VDD VSS) capacitor c=2.12466e-17
C24 (\5\:net95 VSS) capacitor c=4.55836e-17
C25 (\3\:net107 VSS) capacitor c=6.39855e-17
C26 (\2\:A1 VSS) capacitor c=3.9317e-17
C27 (\2\:net95 VSS) capacitor c=2.29357e-17
C28 (\5\:A1 VSS) capacitor c=6.6889e-17
C29 (\4\:B0 VSS) capacitor c=7.56792e-17
C30 (\7\:net95 VSS) capacitor c=1.05273e-16
C31 (\5\:VDD VSS) capacitor c=1.19621e-17
Rk4 (B0 \4\:B0) resistor r=0.2021 c=0
Rk2 (A1 \5\:A1) resistor r=0.2229 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.1215 c=0
Rk10 (\3\:VSS \4\:VSS) resistor r=0.1762 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.2159 c=0
Rk13 (\6\:VSS VSS) resistor r=0.04943 c=0
Rk12 (\5\:VSS \6\:VSS) resistor r=0.08177 c=0
Rk14 (\3\:VSS \8\:VSS) resistor r=0.07209 c=0
Rk15 (\5\:VSS \10\:VSS) resistor r=0.07209 c=0
Rk1 (\4\:A0 A0) resistor r=0.002972 c=0
Rk7 (\2\:Y Y) resistor r=0.3726 c=0
Rk8 (Y \4\:Y) resistor r=0.03525 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3463 c=0
Rk19 (\5\:VDD VDD) resistor r=0.05668 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.3406 c=0
Rk18 (\5\:VDD \7\:VDD) resistor r=0.3008 c=0
Rk3 (\2\:net107 \4\:net107) resistor r=0.2329 c=0
Rk5 (\6\:net95 \7\:net95) resistor r=0.2237 c=0
Rk6 (\7\:net95 \9\:net95) resistor r=0.3673 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=158.09 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.9451 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=146.957 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=54.6488 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=1.8584 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=71.1538 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=118.013 c=0
Rl8 (net95 \2\:net95) resistor r=121.462 c=0
Rl10 (\2\:net95 \4\:net95) resistor r=92.9709 c=0
Rl9 (\2\:net95 \3\:net95) resistor r=5.1011 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz8 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\5\:net95 \6\:net95) resistor r=75 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\8\:net95 \9\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\1\:A1 \5\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\3\:net95 \7\:net95) resistor r=45 c=0
mn0 (net107 \3\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\3\:net107 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=3.045e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=4.8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:net95 \3\:B0 \3\:net107 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.045e-14 ad=3.263e-14 ps=7.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=2.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp1 (\8\:net95 \4\:A1 net98 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.397e-14 ad=6.45e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=6.9e-07 sd=160n sca=16.4235 \
        scb=0.0160509 scc=0.000530362 m=(1)
mp2 (\8\:net95 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.45e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=13.9642 \
        scb=0.012601 scc=0.000501242 m=(1)
mp3 (\1\:Y \4\:net95 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.4e-07 sd=160n sca=14.3559 scb=0.0130561 \
        scc=0.000502004 m=(1)
ends OA21XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:19:41 2012 )
// Library name: gsclib045
// Cell name: OA22X1
// View name: extracted

simulator lang=spectre

subckt OA22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.11e-06 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
C1 (Y VSS) capacitor c=6.96707e-17
C2 (A0 VSS) capacitor c=2.51715e-17
C3 (B0 VSS) capacitor c=2.99308e-17
C4 (VDD VSS) capacitor c=9.88477e-17
C5 (net124 VSS) capacitor c=6.30758e-17
C6 (net128 VSS) capacitor c=4.02728e-17
C7 (net115 VSS) capacitor c=5.90412e-18
C8 (\1\:B0 VSS) capacitor c=3.15524e-17
C9 (\1\:B1 VSS) capacitor c=3.84538e-17
C10 (\1\:A1 VSS) capacitor c=3.96309e-17
C11 (\1\:A0 VSS) capacitor c=4.87224e-17
C12 (\4\:net128 VSS) capacitor c=3.05463e-17
C13 (\3\:B0 VSS) capacitor c=5.19971e-17
C14 (\4\:B1 VSS) capacitor c=4.97988e-17
C15 (\3\:A1 VSS) capacitor c=5.44284e-17
C16 (\3\:A0 VSS) capacitor c=3.243e-17
C17 (\3\:net128 VSS) capacitor c=1.98466e-17
C18 (\2\:B0 VSS) capacitor c=4.37009e-17
C19 (\3\:B1 VSS) capacitor c=2.67932e-17
C20 (\2\:A1 VSS) capacitor c=6.52062e-17
C21 (\2\:A0 VSS) capacitor c=4.42142e-17
C22 (\1\:Y VSS) capacitor c=4.53056e-17
C23 (\1\:VDD VSS) capacitor c=3.34793e-17
C24 (\7\:net128 VSS) capacitor c=7.03485e-17
C25 (\5\:VDD VSS) capacitor c=1.79918e-17
C26 (\9\:net128 VSS) capacitor c=3.77039e-17
C27 (\3\:net124 VSS) capacitor c=7.62639e-17
C28 (\5\:net124 VSS) capacitor c=4.01018e-17
C29 (\2\:B1 VSS) capacitor c=3.69476e-17
C30 (\4\:A0 VSS) capacitor c=2.18375e-17
C31 (\4\:A1 VSS) capacitor c=2.96184e-17
C32 (\5\:A1 VSS) capacitor c=3.21622e-17
C33 (\5\:B1 VSS) capacitor c=4.72659e-17
C34 (\7\:B1 VSS) capacitor c=4.46163e-17
C35 (\5\:B0 VSS) capacitor c=4.55269e-17
C36 (\5\:net128 VSS) capacitor c=4.86506e-17
C37 (\6\:net128 VSS) capacitor c=1.01158e-16
C38 (\4\:VDD VSS) capacitor c=3.75691e-17
Rk2 (A1 \4\:A1) resistor r=0.008275 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.04592 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.008415 c=0
Rk17 (\4\:Y Y) resistor r=0.01657 c=0
Rk16 (\2\:Y \4\:Y) resistor r=0.4069 c=0
Rk1 (A0 \4\:A0) resistor r=0.02361 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.01028 c=0
Rk11 (\6\:B0 B0) resistor r=0.01028 c=0
Rk12 (\5\:B0 \6\:B0) resistor r=0.0192 c=0
Rk26 (\4\:VDD VDD) resistor r=0.3003 c=0
Rk25 (\2\:VDD \4\:VDD) resistor r=0.4626 c=0
Rk27 (VDD \6\:VDD) resistor r=0.2804 c=0
Rk5 (\5\:B1 \6\:B1) resistor r=0.005269 c=0
Rk6 (B1 \7\:B1) resistor r=0.005137 c=0
Rk7 (\5\:B1 \7\:B1) resistor r=0.05797 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.0949 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.155 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.2325 c=0
Rk22 (\6\:VSS VSS) resistor r=0.0498 c=0
Rk21 (\5\:VSS \6\:VSS) resistor r=0.06737 c=0
Rk23 (\3\:VSS \8\:VSS) resistor r=0.07311 c=0
Rk24 (\5\:VSS \10\:VSS) resistor r=0.07311 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.5039 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.2707 c=0
Rk13 (\5\:net128 \6\:net128) resistor r=0.2724 c=0
Rk14 (\6\:net128 \8\:net128) resistor r=0.526 c=0
Rk15 (\6\:net128 \10\:net128) resistor r=0.1688 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=47.2519 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=131.867 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=153.021 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.098 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=31.461 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=154.538 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=64.2642 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=137.341 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=1.8551 c=0
Rl10 (net128 \2\:net128) resistor r=72.791 c=0
Rl12 (\2\:net128 \4\:net128) resistor r=38.1757 c=0
Rl11 (\2\:net128 \3\:net128) resistor r=0.5166 c=0
Rz5 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\9\:net128 \10\:net128) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\7\:net128 \8\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
Rx5 (\3\:net128 \5\:net128) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.03e-14 ps=1.41e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\3\:net124 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn3 (\9\:net128 \4\:B1 \3\:net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\9\:net128 \3\:B0 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn4 (\3\:Y \4\:net128 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.89e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
mp1 (\7\:net128 \1\:A1 net119 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=9.15e-07 sd=160n sca=15.1901 \
        scb=0.0142438 scc=0.000270537 m=(1)
mp3 (\7\:net128 \1\:B1 net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=7.1e-07 sd=160n sca=13.0859 \
        scb=0.0105161 scc=0.000221881 m=(1)
mp2 (net115 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=5.05e-07 sd=160n sca=13.1252 \
        scb=0.0105805 scc=0.000222119 m=(1)
mp4 (\1\:Y net128 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=5.46e-14 ps=1.42e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.56795e-07 sb=1.4e-07 sd=160n sca=31.7169 \
        scb=0.0333373 scc=0.002913 m=(1)
ends OA22X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:31:10 2012 )
// Library name: gsclib045
// Cell name: OA22X2
// View name: extracted

simulator lang=spectre

subckt OA22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.375e-06 sd=160n sca=15.6738 \
        scb=0.0150674 scc=0.000231884 m=(1)
C1 (A1 VSS) capacitor c=1.17521e-16
C2 (Y VSS) capacitor c=2.45593e-17
C3 (A0 VSS) capacitor c=5.97509e-17
C4 (B0 VSS) capacitor c=5.70198e-17
C5 (VDD VSS) capacitor c=1.08321e-16
C6 (B1 VSS) capacitor c=7.10995e-17
C7 (net124 VSS) capacitor c=7.79015e-17
C8 (net128 VSS) capacitor c=5.82477e-17
C9 (net115 VSS) capacitor c=6.49082e-18
C10 (\3\:B0 VSS) capacitor c=3.03867e-17
C11 (\1\:B1 VSS) capacitor c=5.01349e-17
C12 (\1\:A1 VSS) capacitor c=3.80594e-17
C13 (\1\:A0 VSS) capacitor c=4.6116e-17
C14 (\1\:B0 VSS) capacitor c=4.96811e-17
C15 (\3\:B1 VSS) capacitor c=4.12088e-17
C16 (\3\:A1 VSS) capacitor c=6.45431e-17
C17 (\3\:A0 VSS) capacitor c=3.51406e-17
C18 (\4\:net128 VSS) capacitor c=1.86093e-17
C19 (\2\:B0 VSS) capacitor c=5.01683e-17
C20 (\2\:B1 VSS) capacitor c=5.23083e-17
C21 (\2\:A1 VSS) capacitor c=6.31827e-17
C22 (\2\:A0 VSS) capacitor c=4.82051e-17
C23 (\1\:VDD VSS) capacitor c=8.45184e-17
C24 (\1\:Y VSS) capacitor c=9.12885e-17
C25 (\10\:net128 VSS) capacitor c=6.48897e-17
C26 (\8\:VDD VSS) capacitor c=2.0957e-17
C27 (\3\:VDD VSS) capacitor c=3.78999e-17
C28 (\3\:Y VSS) capacitor c=1.35753e-17
C29 (\12\:net128 VSS) capacitor c=4.71552e-17
C30 (\3\:net124 VSS) capacitor c=1.28405e-16
C31 (\5\:net124 VSS) capacitor c=5.96431e-17
C32 (\3\:net128 VSS) capacitor c=7.56234e-17
C33 (\4\:A0 VSS) capacitor c=3.00985e-17
C34 (\4\:B1 VSS) capacitor c=5.92717e-17
C35 (\4\:B0 VSS) capacitor c=6.06726e-17
C36 (\8\:net128 VSS) capacitor c=4.65337e-17
C37 (\9\:net128 VSS) capacitor c=1.14236e-16
C38 (\7\:VDD VSS) capacitor c=1.80953e-17
Rk2 (\4\:A1 A1) resistor r=0.002985 c=0
Rk10 (\2\:Y Y) resistor r=0.3671 c=0
Rk11 (Y \4\:Y) resistor r=0.03241 c=0
Rk1 (A0 \4\:A0) resistor r=0.07164 c=0
Rk6 (B0 \4\:B0) resistor r=0.1526 c=0
Rk26 (\7\:VDD VDD) resistor r=0.06701 c=0
Rk24 (\1\:VDD \7\:VDD) resistor r=0.432 c=0
Rk25 (\7\:VDD \9\:VDD) resistor r=0.2279 c=0
Rk3 (B1 \4\:B1) resistor r=0.1851 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.06976 c=0
Rk15 (\3\:VSS \6\:VSS) resistor r=0.2097 c=0
Rk16 (\6\:VSS \7\:VSS) resistor r=0.2346 c=0
Rk18 (\8\:VSS VSS) resistor r=0.04971 c=0
Rk17 (\7\:VSS \8\:VSS) resistor r=0.1147 c=0
Rk21 (\7\:VSS \14\:VSS) resistor r=0.2295 c=0
Rk4 (\2\:net124 \4\:net124) resistor r=0.6137 c=0
Rk5 (\4\:net124 \6\:net124) resistor r=0.503 c=0
Rk7 (\8\:net128 \9\:net128) resistor r=0.2755 c=0
Rk8 (\9\:net128 \11\:net128) resistor r=0.5091 c=0
Rk9 (\9\:net128 \13\:net128) resistor r=0.3314 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=41.0764 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=218 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.944 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=97.2519 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=41.4835 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=219.231 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=158.384 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=100.692 c=0
Rl10 (\3\:net128 net128) resistor r=57.0886 c=0
Rl11 (\3\:net128 \4\:net128) resistor r=10.0647 c=0
Rz5 (\4\:Y \3\:Y) resistor r=75 c=0
Rz10 (VDD \3\:VDD) resistor r=75 c=0
Rz9 (\1\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz8 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\13\:net128 \12\:net128) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry9 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry3 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry4 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry5 (\6\:VSS \1\:VSS) resistor r=12.4 c=0
Ry6 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\11\:net128 \10\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\8\:net128 \4\:net128) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn1 (\3\:net124 \3\:A1 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.65e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn3 (\12\:net128 \3\:B1 \3\:net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn2 (\12\:net128 \1\:B0 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.988e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn4 (\3\:Y net128 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mp1 (\10\:net128 \1\:A1 net119 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.18e-06 sd=160n sca=12.1772 \
        scb=0.00916323 scc=9.24857e-05 m=(1)
mp3 (\10\:net128 \1\:B1 net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=9.75e-07 sd=160n sca=10.8981 \
        scb=0.00784736 scc=8.82336e-05 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=4.73e-14 ps=1.42e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=7.1e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp4 (\1\:Y \3\:net128 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.045e-14 ad=6.24e-14 ps=1.24e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.89872e-07 sb=3.45e-07 sd=160n sca=15.2316 \
        scb=0.0133702 scc=0.000755104 m=(2)
ends OA22X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:31:48 2012 )
// Library name: gsclib045
// Cell name: OA22X4
// View name: extracted

simulator lang=spectre

subckt OA22X4 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.525e-06 sd=160n sca=16.0461 \
        scb=0.0153344 scc=0.000433465 m=(1)
C1 (A0 VSS) capacitor c=7.41254e-17
C2 (B0 VSS) capacitor c=8.0521e-17
C3 (VDD VSS) capacitor c=1.10795e-16
C4 (B1 VSS) capacitor c=8.831e-17
C5 (Y VSS) capacitor c=2.12307e-17
C6 (net124 VSS) capacitor c=6.83437e-17
C7 (net128 VSS) capacitor c=3.48322e-16
C8 (net119 VSS) capacitor c=2.70639e-18
C9 (net115 VSS) capacitor c=8.08886e-18
C10 (\3\:B0 VSS) capacitor c=5.06772e-17
C11 (\1\:B1 VSS) capacitor c=5.54479e-17
C12 (\1\:A1 VSS) capacitor c=5.22008e-17
C13 (\1\:A0 VSS) capacitor c=5.24163e-17
C14 (\1\:B0 VSS) capacitor c=4.49395e-17
C15 (\4\:B1 VSS) capacitor c=4.49082e-17
C16 (\3\:A1 VSS) capacitor c=5.73512e-17
C17 (\3\:A0 VSS) capacitor c=3.52734e-17
C18 (\3\:B1 VSS) capacitor c=5.05099e-17
C19 (\2\:A1 VSS) capacitor c=5.5477e-17
C20 (\2\:A0 VSS) capacitor c=4.7467e-17
C21 (\1\:VDD VSS) capacitor c=2.02158e-16
C22 (\17\:net128 VSS) capacitor c=1.05055e-16
C23 (\12\:VDD VSS) capacitor c=3.68759e-17
C24 (\1\:Y VSS) capacitor c=1.22214e-16
C25 (\14\:net128 VSS) capacitor c=3.27166e-17
C26 (\3\:net124 VSS) capacitor c=9.61133e-17
C27 (\5\:net124 VSS) capacitor c=5.74694e-17
C28 (\2\:B0 VSS) capacitor c=4.13905e-17
C29 (\4\:A0 VSS) capacitor c=2.43506e-17
C30 (\4\:A1 VSS) capacitor c=1.30859e-16
C31 (\5\:B1 VSS) capacitor c=6.45462e-17
C32 (\5\:B0 VSS) capacitor c=3.68121e-17
C33 (\16\:net128 VSS) capacitor c=1.33663e-16
C34 (\3\:Y VSS) capacitor c=3.81701e-17
C35 (\4\:Y VSS) capacitor c=1.76481e-16
C36 (\7\:VDD VSS) capacitor c=1.88852e-17
Rk4 (\4\:A1 A1) resistor r=0.003676 c=0
Rk19 (\2\:VSS \3\:VSS) resistor r=0.05991 c=0
Rk22 (\3\:VSS \6\:VSS) resistor r=0.1225 c=0
Rk24 (\7\:VSS VSS) resistor r=0.1774 c=0
Rk23 (\6\:VSS \7\:VSS) resistor r=0.3229 c=0
Rk28 (\7\:VSS \15\:VSS) resistor r=0.2573 c=0
Rk3 (\4\:A0 A0) resistor r=0.04486 c=0
Rk8 (B0 \5\:B0) resistor r=0.1375 c=0
Rk33 (\7\:VDD VDD) resistor r=0.09723 c=0
Rk32 (\1\:VDD \7\:VDD) resistor r=0.3853 c=0
Rk36 (\7\:VDD \13\:VDD) resistor r=0.1991 c=0
Rk5 (B1 \5\:B1) resistor r=0.1585 c=0
Rk17 (\3\:Y Y) resistor r=0.06291 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.3638 c=0
Rk14 (\3\:Y \4\:Y) resistor r=0.2258 c=0
Rk6 (\2\:net124 \4\:net124) resistor r=0.4671 c=0
Rk7 (\4\:net124 \6\:net124) resistor r=0.4212 c=0
Rk11 (\16\:net128 net128) resistor r=0.3532 c=0
Rk9 (\15\:net128 \16\:net128) resistor r=0.1366 c=0
Rk10 (\16\:net128 \18\:net128) resistor r=0.6444 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=117.999 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=96.3069 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=53.0211 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=77.3776 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=88.9161 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=5.0149 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=99.7141 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=65.0987 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.5166 c=0
Rz10 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\15\:net128 \14\:net128) resistor r=75 c=0
Ry4 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry5 (\6\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry9 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\18\:net128 \17\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \5\:B1) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn1 (\3\:net124 \3\:A1 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn3 (\14\:net128 \4\:B1 \3\:net124 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn2 (\14\:net128 \1\:B0 net124 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.29e-14 ps=8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn4 (\1\:Y net128 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mp1 (\17\:net128 \1\:A1 net119 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.365e-06 sd=160n sca=13.8829 \
        scb=0.0118891 scc=0.000386328 m=(1)
mp3 (\17\:net128 \1\:B1 net115 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.16e-06 sd=160n sca=12.7362 \
        scb=0.0108186 scc=0.000383639 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=9.6e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp4 (\4\:Y net128 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=7.55e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
ends OA22X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:32:25 2012 )
// Library name: gsclib045
// Cell name: OA22XL
// View name: extracted

simulator lang=spectre

subckt OA22XL A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=15.0366 \
        scb=0.0139559 scc=0.00019117 m=(1)
C1 (A1 VSS) capacitor c=1.11505e-16
C2 (Y VSS) capacitor c=6.74884e-17
C3 (A0 VSS) capacitor c=3.11614e-17
C4 (B1 VSS) capacitor c=7.83272e-17
C5 (VDD VSS) capacitor c=1.37776e-16
C6 (net124 VSS) capacitor c=8.13808e-17
C7 (net128 VSS) capacitor c=3.03201e-17
C8 (net115 VSS) capacitor c=3.22087e-18
C9 (\3\:net128 VSS) capacitor c=5.97991e-17
C10 (\3\:B0 VSS) capacitor c=4.99078e-17
C11 (\1\:B1 VSS) capacitor c=5.3638e-17
C12 (\1\:A1 VSS) capacitor c=6.57085e-17
C13 (\1\:A0 VSS) capacitor c=5.0322e-17
C14 (\1\:B0 VSS) capacitor c=4.52564e-17
C15 (\3\:B1 VSS) capacitor c=3.41597e-17
C16 (\3\:A1 VSS) capacitor c=3.64948e-17
C17 (\4\:A0 VSS) capacitor c=4.2681e-17
C18 (\2\:net128 VSS) capacitor c=5.8455e-17
C19 (\2\:B0 VSS) capacitor c=6.41554e-17
C20 (\2\:B1 VSS) capacitor c=4.91915e-17
C21 (\2\:A1 VSS) capacitor c=6.00468e-17
C22 (\3\:A0 VSS) capacitor c=4.65497e-17
C23 (\3\:Y VSS) capacitor c=3.12672e-17
C24 (\1\:VDD VSS) capacitor c=3.59209e-17
C25 (\6\:net128 VSS) capacitor c=9.56214e-17
C26 (\6\:VDD VSS) capacitor c=1.26132e-17
C27 (\1\:Y VSS) capacitor c=5.0187e-17
C28 (\8\:net128 VSS) capacitor c=2.9091e-17
C29 (\3\:net124 VSS) capacitor c=9.20927e-17
C30 (\5\:net124 VSS) capacitor c=3.23145e-17
C31 (\5\:A0 VSS) capacitor c=5.97288e-17
C32 (\4\:B1 VSS) capacitor c=4.81806e-17
C33 (\4\:B0 VSS) capacitor c=1.04739e-16
C34 (\4\:net128 VSS) capacitor c=3.36054e-17
C35 (\5\:net128 VSS) capacitor c=1.07777e-16
C36 (\4\:VDD VSS) capacitor c=5.96845e-17
C37 (\5\:VDD VSS) capacitor c=1.44522e-17
Rk2 (A1 \4\:A1) resistor r=0.003947 c=0
Rk10 (\2\:Y Y) resistor r=0.6708 c=0
Rk11 (Y \4\:Y) resistor r=0.07319 c=0
Rk1 (A0 \5\:A0) resistor r=0.06559 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1046 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.2442 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.2018 c=0
Rk16 (\6\:VSS VSS) resistor r=0.04963 c=0
Rk15 (\5\:VSS \6\:VSS) resistor r=0.147 c=0
Rk17 (\3\:VSS \8\:VSS) resistor r=0.07265 c=0
Rk18 (\5\:VSS \10\:VSS) resistor r=0.07265 c=0
Rk4 (\4\:B0 B0) resistor r=0.002981 c=0
Rk3 (\4\:B1 B1) resistor r=0.1925 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.306 c=0
Rk21 (\5\:VDD VDD) resistor r=0.07937 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.319 c=0
Rk22 (\5\:VDD \7\:VDD) resistor r=0.1713 c=0
Rk5 (\2\:net124 \4\:net124) resistor r=0.6714 c=0
Rk6 (\4\:net124 \6\:net124) resistor r=0.275 c=0
Rk7 (\4\:net128 \5\:net128) resistor r=0.2348 c=0
Rk8 (\5\:net128 \7\:net128) resistor r=0.633 c=0
Rk9 (\5\:net128 \9\:net128) resistor r=0.1357 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=219.923 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=39.1533 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=184.329 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=92.0218 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=0.5166 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=147.528 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=113.462 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=193 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=66.0764 c=0
Rl10 (net128 \2\:net128) resistor r=104.386 c=0
Rl11 (\2\:net128 \3\:net128) resistor r=230.002 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\8\:net128 \9\:net128) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\6\:net128 \7\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx5 (\2\:net128 \4\:net128) resistor r=45 c=0
mn0 (\5\:net124 \4\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.03e-14 ps=1.33e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\3\:net124 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.828e-14 ps=1.33e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=7.1e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\8\:net128 \3\:B1 \3\:net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=4.132e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=4.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\8\:net128 \1\:B0 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.132e-14 ps=5.7e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (\1\:Y net128 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mp1 (\6\:net128 \1\:A1 net119 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=4.192e-14 ps=7.3e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=8.4e-07 sd=160n sca=12.0447 \
        scb=0.00904147 scc=0.000101203 m=(1)
mp3 (\6\:net128 \1\:B1 net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=4.192e-14 ps=8.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6e-07 sd=160n sca=10.7796 \
        scb=0.00791215 scc=9.84845e-05 m=(1)
mp2 (net115 \3\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=3.45e-07 sd=160n sca=10.9535 \
        scb=0.00800214 scc=9.85336e-05 m=(1)
mp4 (\3\:Y \3\:net128 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.4e-07 sd=160n sca=12.1773 \
        scb=0.00921403 scc=0.000102074 m=(1)
ends OA22XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:20:27 2012 )
// Library name: gsclib045
// Cell name: OAI211X1
// View name: extracted

simulator lang=spectre

subckt OAI211X1 A0 A1 B0 C0 VDD VSS Y
mp0 (n2 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=26.0122 \
        scb=0.0294337 scc=0.00173965 m=(1)
C1 (Y VSS) capacitor c=3.34454e-17
C2 (VDD VSS) capacitor c=8.74289e-17
C3 (C0 VSS) capacitor c=7.62507e-17
C4 (n1 VSS) capacitor c=5.9525e-17
C5 (n0 VSS) capacitor c=3.39295e-18
C6 (\1\:C0 VSS) capacitor c=4.91214e-17
C7 (\3\:B0 VSS) capacitor c=5.18131e-17
C8 (\3\:A1 VSS) capacitor c=8.6448e-17
C9 (\1\:A0 VSS) capacitor c=6.29686e-17
C10 (\3\:C0 VSS) capacitor c=4.2044e-17
C11 (\1\:B0 VSS) capacitor c=5.4932e-17
C12 (\1\:A1 VSS) capacitor c=4.71955e-17
C13 (\4\:A0 VSS) capacitor c=5.4425e-17
C14 (\2\:C0 VSS) capacitor c=5.0634e-17
C15 (\2\:B0 VSS) capacitor c=5.78918e-17
C16 (\2\:A1 VSS) capacitor c=6.60025e-17
C17 (\3\:A0 VSS) capacitor c=1.44632e-17
C18 (\1\:VDD VSS) capacitor c=6.32746e-17
C19 (\4\:Y VSS) capacitor c=7.30896e-17
C20 (\5\:VDD VSS) capacitor c=3.82612e-17
C21 (\1\:Y VSS) capacitor c=8.48571e-17
C22 (\3\:n1 VSS) capacitor c=3.87351e-17
C23 (\2\:A0 VSS) capacitor c=4.98784e-17
C24 (\5\:A0 VSS) capacitor c=2.84633e-17
C25 (\7\:A0 VSS) capacitor c=2.71305e-17
C26 (\4\:A1 VSS) capacitor c=3.2148e-17
C27 (\6\:A1 VSS) capacitor c=3.58791e-17
C28 (\4\:B0 VSS) capacitor c=5.04094e-17
C29 (\5\:B0 VSS) capacitor c=5.31996e-17
C30 (\4\:C0 VSS) capacitor c=6.67667e-17
C31 (\3\:Y VSS) capacitor c=6.38463e-17
C32 (\4\:VDD VSS) capacitor c=3.08158e-17
Rk14 (\3\:Y Y) resistor r=0.1013 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5242 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.3771 c=0
Rk15 (Y \7\:Y) resistor r=0.01164 c=0
Rk8 (B0 \4\:B0) resistor r=0.0105 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.05693 c=0
Rk9 (\5\:B0 \6\:B0) resistor r=0.01062 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.004734 c=0
Rk5 (A1 \6\:A1) resistor r=0.004599 c=0
Rk6 (\4\:A1 \6\:A1) resistor r=0.05081 c=0
Rk20 (\3\:VSS VSS) resistor r=0.1024 c=0
Rk21 (\3\:VSS \5\:VSS) resistor r=0.1814 c=0
Rk17 (\4\:VDD VDD) resistor r=0.2007 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3526 c=0
Rk18 (VDD \6\:VDD) resistor r=0.2435 c=0
Rk11 (\4\:C0 C0) resistor r=0.1732 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002117 c=0
Rk2 (A0 \7\:A0) resistor r=0.001975 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.04803 c=0
Rk7 (\2\:n1 \4\:n1) resistor r=0.2718 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=76.903 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=110.307 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=101.718 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=86.5156 c=0
Rl8 (\1\:C0 \2\:C0) resistor r=89.6174 c=0
Rl9 (\2\:C0 \3\:C0) resistor r=97.3098 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=34.3295 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=172.791 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.9102 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n1 \2\:n1) resistor r=75 c=0
Rz2 (\3\:n1 \4\:n1) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx3 (\2\:B0 \6\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
mn0 (\3\:n1 \4\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (n1 \1\:A1 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.25e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (n1 \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.2e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn3 (\1\:Y \3\:C0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=3.64e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=7.3e-07 \
        sb=1.4e-07 sd=160n sca=8.09546 scb=0.00588493 scc=0.000117119 \
        m=(1)
mp1 (\4\:Y \3\:A1 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.165e-14 ps=9e-07 pd=1.25e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.25e-07 sd=160n sca=19.2311 scb=0.0199775 \
        scc=0.000575468 m=(1)
mp2 (\4\:Y \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.165e-14 ps=1.1e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=3.45e-07 sd=160n sca=16.9088 \
        scb=0.0154331 scc=0.000373012 m=(1)
mp3 (\6\:Y \1\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=25.4829 \
        scb=0.0288592 scc=0.00163037 m=(1)
ends OAI211X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:33:41 2012 )
// Library name: gsclib045
// Cell name: OAI211X2
// View name: extracted

simulator lang=spectre

subckt OAI211X2 A0 A1 B0 C0 VDD VSS Y
mp0 (2 \1\:A0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.535e-14 ps=1.06e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=21.5541 \
        scb=0.0195467 scc=0.00162283 m=(1)
C1 (C0 VSS) capacitor c=4.65746e-17
C2 (A1 VSS) capacitor c=4.03633e-17
C3 (Y VSS) capacitor c=9.87089e-17
C4 (B0 VSS) capacitor c=8.83167e-17
C5 (VDD VSS) capacitor c=9.96416e-17
C6 (A0 VSS) capacitor c=2.31743e-17
C7 (n1 VSS) capacitor c=1.61172e-16
C8 (n0 VSS) capacitor c=1.7107e-16
C9 (2 VSS) capacitor c=5.82715e-18
C10 (4 VSS) capacitor c=2.26173e-18
C11 (\6\:A0 VSS) capacitor c=8.02403e-17
C12 (\1\:A1 VSS) capacitor c=7.71649e-17
C13 (\5\:A1 VSS) capacitor c=5.39823e-17
C14 (\1\:A0 VSS) capacitor c=6.35727e-17
C15 (\1\:C0 VSS) capacitor c=7.79746e-17
C16 (\1\:B0 VSS) capacitor c=7.75037e-17
C17 (\3\:B0 VSS) capacitor c=9.23416e-17
C18 (\2\:A1 VSS) capacitor c=2.27226e-17
C19 (\2\:A0 VSS) capacitor c=2.9301e-16
C20 (\9\:Y VSS) capacitor c=8.35052e-17
C21 (\7\:Y VSS) capacitor c=2.90698e-17
C22 (\4\:Y VSS) capacitor c=7.57659e-17
C23 (\16\:VDD VSS) capacitor c=4.91137e-17
C24 (\1\:VDD VSS) capacitor c=5.82087e-17
C25 (\1\:Y VSS) capacitor c=1.55173e-16
C26 (\5\:n1 VSS) capacitor c=1.24434e-16
C27 (\3\:A1 VSS) capacitor c=9.66967e-17
C28 (\3\:C0 VSS) capacitor c=9.54641e-17
C29 (\7\:A1 VSS) capacitor c=6.90159e-17
C30 (\8\:B0 VSS) capacitor c=6.03901e-17
C31 (\3\:Y VSS) capacitor c=7.11412e-17
C32 (\7\:C0 VSS) capacitor c=3.10565e-17
C33 (\3\:VDD VSS) capacitor c=1.53981e-16
C34 (\9\:VDD VSS) capacitor c=1.3377e-18
Rk17 (\7\:C0 C0) resistor r=0.1521 c=0
Rk1 (\7\:A1 A1) resistor r=0.1413 c=0
Rk9 (\2\:Y Y) resistor r=0.9513 c=0
Rk10 (Y \3\:Y) resistor r=0.009359 c=0
Rk11 (\3\:Y \5\:Y) resistor r=0.5137 c=0
Rk12 (\3\:Y \6\:Y) resistor r=0.0712 c=0
Rk13 (\6\:Y \8\:Y) resistor r=0.05921 c=0
Rk14 (\6\:Y \10\:Y) resistor r=0.3907 c=0
Rk6 (\7\:B0 \8\:B0) resistor r=0.002322 c=0
Rk7 (\9\:B0 B0) resistor r=0.002322 c=0
Rk8 (\8\:B0 \9\:B0) resistor r=0.06937 c=0
Rk18 (\2\:VDD \3\:VDD) resistor r=0.1076 c=0
Rk23 (\3\:VDD \8\:VDD) resistor r=0.2404 c=0
Rk25 (\9\:VDD VDD) resistor r=0.1148 c=0
Rk24 (\8\:VDD \9\:VDD) resistor r=0.08501 c=0
Rk29 (\9\:VDD \17\:VDD) resistor r=0.3309 c=0
Rk3 (\2\:A0 A0) resistor r=0.01892 c=0
Rk35 (\3\:VSS VSS) resistor r=0.04968 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.3381 c=0
Rk38 (\3\:VSS \12\:VSS) resistor r=0.2051 c=0
Rk5 (n1 \6\:n1) resistor r=0.5755 c=0
Rl16 (\3\:C0 \1\:C0) resistor r=130.542 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=94.9751 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=25.3108 c=0
Rl4 (\3\:A1 \2\:A1) resistor r=10.2925 c=0
Rl11 (\3\:B0 \1\:B0) resistor r=42.0732 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=97.5275 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=53.8233 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz10 (\3\:VDD \1\:VDD) resistor r=15 c=0
Rz11 (\8\:VDD \1\:VDD) resistor r=15 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz3 (\6\:n1 \5\:n1) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=31 c=0
Ry2 (\8\:Y \7\:Y) resistor r=31 c=0
Ry3 (\10\:Y \9\:Y) resistor r=31 c=0
Ry7 (\17\:VDD \16\:VDD) resistor r=31 c=0
Ry11 (VSS \1\:VSS) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Rx5 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\7\:B0 \3\:B0) resistor r=45 c=0
mn0 (n1 \2\:A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.615e-14 ps=8e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.9e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn1 (n1 \3\:A1 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.615e-14 ps=8.4e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=5.5e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn2 (\5\:n1 \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=4.16e-14 ps=8.75e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=7.95e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn3 (\1\:Y \1\:C0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.05e-07 sb=3.45e-07 sd=160n sca=9.50447 scb=0.0081528 \
        scc=0.00025289 m=(2)
mp1 (\4\:Y \5\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.535e-14 \
        ad=7.215e-14 ps=9.1e-07 pd=1.15e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.5e-07 sb=1.48e-06 sd=160n sca=20.1813 scb=0.0174167 \
        scc=0.00159977 m=(1)
mp1_1__rcx (\4\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.215e-14 ps=9e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.25e-06 sd=160n sca=18.8666 \
        scb=0.016155 scc=0.0015962 m=(1)
mp0_1__rcx (4 \6\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3455e-13 ad=2.34e-14 ps=1.47e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.145e-06 sd=160n sca=18.5611 \
        scb=0.0160319 scc=0.00159616 m=(1)
mp2 (\7\:Y \3\:B0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.848e-14 ad=6.24e-14 ps=1.285e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
mp3 (\9\:Y \3\:C0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=3.45e-07 sd=160n sca=19.0572 \
        scb=0.0162666 scc=0.00159628 m=(2)
ends OAI211X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:34:20 2012 )
// Library name: gsclib045
// Cell name: OAI211X4
// View name: extracted

simulator lang=spectre

subckt OAI211X4 A0 A1 B0 C0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=1.0335e-13 ps=1.06e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=24.4649 scb=0.024645 \
        scc=0.00179971 m=(1)
C1 (Y VSS) capacitor c=3.03561e-16
C2 (B0 VSS) capacitor c=3.97478e-16
C3 (A0 VSS) capacitor c=1.82154e-17
C4 (VDD VSS) capacitor c=1.42631e-16
C5 (C0 VSS) capacitor c=3.22967e-16
C6 (A1 VSS) capacitor c=4.27504e-16
C7 (n1 VSS) capacitor c=2.04889e-16
C8 (n0 VSS) capacitor c=3.38039e-16
C9 (4 VSS) capacitor c=3.24837e-18
C10 (5 VSS) capacitor c=1.94902e-18
C11 (6 VSS) capacitor c=3.97122e-18
C12 (\10\:A0 VSS) capacitor c=6.09229e-17
C13 (\7\:A1 VSS) capacitor c=5.14479e-17
C14 (\11\:A1 VSS) capacitor c=5.89618e-17
C15 (\4\:A0 VSS) capacitor c=7.73685e-17
C16 (\7\:A0 VSS) capacitor c=4.20443e-17
C17 (\1\:A1 VSS) capacitor c=5.8557e-17
C18 (\5\:A1 VSS) capacitor c=2.3106e-17
C19 (\1\:A0 VSS) capacitor c=3.39915e-17
C20 (\2\:A0 VSS) capacitor c=5.34136e-16
C21 (\1\:VDD VSS) capacitor c=2.46749e-16
C22 (\7\:Y VSS) capacitor c=1.10996e-16
C23 (\22\:VDD VSS) capacitor c=3.76068e-17
C24 (\9\:Y VSS) capacitor c=9.11673e-17
C25 (\24\:VDD VSS) capacitor c=2.52917e-17
C26 (\3\:VDD VSS) capacitor c=4.70866e-17
C27 (\1\:Y VSS) capacitor c=2.36746e-16
C28 (\3\:n1 VSS) capacitor c=3.18648e-16
C29 (\5\:A0 VSS) capacitor c=2.59761e-17
C30 (\17\:Y VSS) capacitor c=1.49134e-16
C31 (\11\:VDD VSS) capacitor c=1.64632e-17
C32 (\12\:VDD VSS) capacitor c=1.28779e-17
Rk16 (\1\:Y Y) resistor r=1.127 c=0
Rk17 (Y \8\:Y) resistor r=0.3902 c=0
Rk18 (\8\:Y \10\:Y) resistor r=0.5044 c=0
Rk19 (\10\:Y \11\:Y) resistor r=0.1464 c=0
Rk24 (\8\:Y \16\:Y) resistor r=0.1464 c=0
Rk25 (Y \17\:Y) resistor r=0.3091 c=0
Rk5 (\2\:A0 A0) resistor r=0.09652 c=0
Rk49 (\2\:VSS VSS) resistor r=0.6891 c=0
Rk38 (\1\:VDD \10\:VDD) resistor r=0.278 c=0
Rk39 (\10\:VDD \11\:VDD) resistor r=0.05996 c=0
Rk41 (\12\:VDD VDD) resistor r=0.0572 c=0
Rk40 (\11\:VDD \12\:VDD) resistor r=0.4332 c=0
Rk47 (\11\:VDD \23\:VDD) resistor r=0.2632 c=0
Rk48 (\12\:VDD \25\:VDD) resistor r=0.3314 c=0
Rk8 (n1 \3\:n1) resistor r=0.4755 c=0
Rl18 (\2\:A0 \10\:A0) resistor r=91.0764 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=87.6944 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=82.1768 c=0
Rl10 (\5\:A0 \7\:A0) resistor r=38.0255 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=23.0585 c=0
Rl13 (A1 \7\:A1) resistor r=85.3597 c=0
Rl16 (A1 \11\:A1) resistor r=25.3108 c=0
Rl3 (A1 \1\:A1) resistor r=75.2759 c=0
Rl6 (A1 \5\:A1) resistor r=28.079 c=0
Rz17 (VDD \3\:VDD) resistor r=75 c=0
Rz15 (\1\:VDD \3\:VDD) resistor r=9.375 c=0
Rz16 (\10\:VDD \3\:VDD) resistor r=7.5 c=0
Ry2 (\8\:Y \7\:Y) resistor r=62 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry4 (\11\:Y \9\:Y) resistor r=62 c=0
Ry7 (\16\:Y \7\:Y) resistor r=62 c=0
Ry18 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry15 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry16 (\25\:VDD \24\:VDD) resistor r=31 c=0
mn0_1__rcx (\3\:n1 \2\:A0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn1_1__rcx (\3\:n1 A1 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn2_1__rcx (n1 B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.518e-14 ad=4.16e-14 ps=8.675e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.605e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn3_1__rcx (\1\:Y C0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mp1_1__rcx (\9\:Y \5\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.24e-14 ps=1.31e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=19.5407 scb=0.0166665 \
        scc=0.0015969 m=(1)
mp1_2__rcx (\9\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2e-06 sd=160n sca=18.6789 scb=0.0160714 \
        scc=0.00159617 m=(1)
mp0_2__rcx (4 \7\:A0 \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=3.9e-14 ps=1.1e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0 (5 \4\:A0 \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=2e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp1 (\7\:Y \11\:A1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.11e-06 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp1_3__rcx (\7\:Y \7\:A1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=2e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp0_3__rcx (6 \10\:A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=4.485e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.84e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp2_1__rcx (Y B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3_1__rcx (\17\:Y C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(4)
ends OAI211X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:34:57 2012 )
// Library name: gsclib045
// Cell name: OAI211XL
// View name: extracted

simulator lang=spectre

subckt OAI211XL A0 A1 B0 C0 VDD VSS Y
mp0 (n2 \1\:A0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=2.15e-14 ps=1.35e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.9e-07 sd=160n sca=16.7249 scb=0.0166366 \
        scc=0.000331722 m=(1)
C1 (Y VSS) capacitor c=1.65068e-17
C2 (B0 VSS) capacitor c=9.11678e-17
C3 (A1 VSS) capacitor c=1.23758e-16
C4 (VDD VSS) capacitor c=9.21142e-17
C5 (C0 VSS) capacitor c=6.16762e-17
C6 (A0 VSS) capacitor c=4.23322e-17
C7 (n1 VSS) capacitor c=4.85859e-17
C8 (\1\:C0 VSS) capacitor c=3.57047e-17
C9 (\1\:B0 VSS) capacitor c=6.14242e-17
C10 (\3\:A1 VSS) capacitor c=4.88174e-17
C11 (\1\:A0 VSS) capacitor c=4.07863e-17
C12 (\3\:C0 VSS) capacitor c=6.31739e-17
C13 (\3\:B0 VSS) capacitor c=5.16109e-17
C14 (\1\:A1 VSS) capacitor c=4.95107e-17
C15 (\3\:A0 VSS) capacitor c=4.37847e-17
C16 (\2\:C0 VSS) capacitor c=5.71927e-17
C17 (\2\:B0 VSS) capacitor c=6.57034e-17
C18 (\2\:A1 VSS) capacitor c=6.28964e-17
C19 (\2\:A0 VSS) capacitor c=5.2961e-17
C20 (\3\:Y VSS) capacitor c=8.0491e-17
C21 (\7\:VDD VSS) capacitor c=1.28977e-17
C22 (\5\:Y VSS) capacitor c=4.58684e-17
C23 (\9\:VDD VSS) capacitor c=1.78528e-17
C24 (\1\:VDD VSS) capacitor c=2.43657e-17
C25 (\1\:Y VSS) capacitor c=6.92572e-17
C26 (\3\:n1 VSS) capacitor c=7.11853e-17
C27 (\4\:A0 VSS) capacitor c=4.1614e-17
C28 (\4\:B0 VSS) capacitor c=4.17516e-17
C29 (\4\:C0 VSS) capacitor c=6.98723e-17
C30 (\3\:VDD VSS) capacitor c=6.5765e-18
C31 (\5\:VDD VSS) capacitor c=3.72799e-18
Rk10 (\4\:Y Y) resistor r=0.03755 c=0
Rk8 (\2\:Y \4\:Y) resistor r=0.585 c=0
Rk9 (\4\:Y \6\:Y) resistor r=0.3026 c=0
Rk6 (\4\:B0 B0) resistor r=0.08091 c=0
Rk2 (\4\:A1 A1) resistor r=0.002987 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.1823 c=0
Rk20 (\4\:VSS VSS) resistor r=0.04976 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.1173 c=0
Rk21 (\3\:VSS \6\:VSS) resistor r=0.1994 c=0
Rk11 (\2\:VDD \3\:VDD) resistor r=0.06231 c=0
Rk12 (\3\:VDD \4\:VDD) resistor r=0.1873 c=0
Rk14 (\5\:VDD VDD) resistor r=0.08707 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.1123 c=0
Rk16 (\3\:VDD \8\:VDD) resistor r=0.073 c=0
Rk17 (\5\:VDD \10\:VDD) resistor r=0.073 c=0
Rk7 (C0 \4\:C0) resistor r=0.2091 c=0
Rk1 (A0 \4\:A0) resistor r=0.224 c=0
Rk3 (\2\:n1 \4\:n1) resistor r=0.4489 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=144.923 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=102.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=93.4066 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=155.769 c=0
Rl7 (\1\:C0 \2\:C0) resistor r=30.7692 c=0
Rl8 (\2\:C0 \3\:C0) resistor r=218.407 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=85.7134 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=154.944 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (n1 \2\:n1) resistor r=75 c=0
Rz2 (\3\:n1 \4\:n1) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (n1 \3\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn1 (\3\:n1 \1\:A1 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.7e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn2 (\3\:n1 \3\:B0 n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.32e-14 ps=4.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.65e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn3 (\1\:Y \3\:C0 n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.378e-14 ad=3.263e-14 ps=4.8e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.25e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mp1 (\5\:Y \3\:A1 n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=4.623e-14 ps=6.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=14.2593 \
        scb=0.0117802 scc=0.000198925 m=(1)
mp2 (\5\:Y \1\:B0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.623e-14 ps=1.45e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=3.85e-07 sd=160n sca=14.4951 \
        scb=0.0122555 scc=0.000205064 m=(1)
mp3 (\3\:Y \1\:C0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.085e-14 ps=1.45e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.9e-07 sd=160n sca=19.8673 scb=0.021958 \
        scc=0.00070962 m=(1)
ends OAI211XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:35:36 2012 )
// Library name: gsclib045
// Cell name: OAI21X1
// View name: extracted

simulator lang=spectre

subckt OAI21X1 A0 A1 B0 VDD VSS Y
mp0 (n1 \1\:A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=18.8564 \
        scb=0.0195514 scc=0.000495827 m=(1)
C1 (A1 VSS) capacitor c=1.92888e-17
C2 (A0 VSS) capacitor c=2.07752e-17
C3 (Y VSS) capacitor c=8.75335e-17
C4 (B0 VSS) capacitor c=2.10018e-17
C5 (VDD VSS) capacitor c=6.89553e-17
C6 (n0 VSS) capacitor c=7.37162e-17
C7 (\1\:B0 VSS) capacitor c=3.78701e-17
C8 (\1\:A1 VSS) capacitor c=9.16816e-17
C9 (\1\:A0 VSS) capacitor c=1.02646e-16
C10 (\3\:B0 VSS) capacitor c=5.3178e-17
C11 (\3\:A1 VSS) capacitor c=6.18671e-17
C12 (\3\:A0 VSS) capacitor c=4.31175e-17
C13 (\2\:B0 VSS) capacitor c=4.60978e-17
C14 (\2\:A1 VSS) capacitor c=5.77813e-17
C15 (\2\:A0 VSS) capacitor c=4.82578e-17
C16 (\1\:VDD VSS) capacitor c=4.75457e-17
C17 (\3\:Y VSS) capacitor c=7.52001e-17
C18 (\7\:VDD VSS) capacitor c=3.5255e-17
C19 (\3\:VDD VSS) capacitor c=2.03528e-17
C20 (\1\:Y VSS) capacitor c=6.35968e-17
C21 (\3\:n0 VSS) capacitor c=6.89166e-17
C22 (\4\:A0 VSS) capacitor c=3.91051e-17
C23 (\4\:A1 VSS) capacitor c=4.91793e-17
C24 (\4\:B0 VSS) capacitor c=8.15815e-17
C25 (\5\:VDD VSS) capacitor c=8.54071e-18
Rk2 (\4\:A1 A1) resistor r=0.05761 c=0
Rk1 (\4\:A0 A0) resistor r=0.0525 c=0
Rk5 (\2\:Y Y) resistor r=0.4894 c=0
Rk6 (Y \4\:Y) resistor r=0.2783 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1965 c=0
Rk14 (\4\:VSS VSS) resistor r=0.0498 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.05141 c=0
Rk15 (\3\:VSS \6\:VSS) resistor r=0.1182 c=0
Rk4 (B0 \4\:B0) resistor r=0.03123 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.2834 c=0
Rk9 (\5\:VDD VDD) resistor r=0.0496 c=0
Rk8 (\4\:VDD \5\:VDD) resistor r=0.2 c=0
Rk11 (\5\:VDD \8\:VDD) resistor r=0.2518 c=0
Rk3 (\2\:n0 \4\:n0) resistor r=0.4252 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=87.2302 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=117.999 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=169.894 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=49.1749 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=29.9442 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=168.406 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\3\:VDD VDD) resistor r=75 c=0
Rz4 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz1 (n0 \2\:n0) resistor r=37.5 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=3.64e-14 ps=1.14e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (n0 \3\:A1 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=4.16e-14 ps=1.14e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \3\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=5.5e-07 \
        sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 scc=9.84911e-05 \
        m=(1)
mp1 (\3\:Y \1\:A1 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=3.45e-07 sd=160n sca=16.4103 scb=0.0148066 \
        scc=0.000275039 m=(1)
mp2 (\3\:Y \1\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=16.6925 \
        scb=0.0153965 scc=0.00029244 m=(1)
ends OAI21X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:36:14 2012 )
// Library name: gsclib045
// Cell name: OAI21X2
// View name: extracted

simulator lang=spectre

subckt OAI21X2 A0 A1 B0 VDD VSS Y
mp0 (2 \1\:A0 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=3.315e-14 ps=1.08e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.025e-06 sd=160n sca=14.3979 \
        scb=0.0128198 scc=0.000254146 m=(1)
C1 (Y VSS) capacitor c=3.0408e-17
C2 (B0 VSS) capacitor c=1.55804e-17
C3 (A0 VSS) capacitor c=3.24425e-16
C4 (VDD VSS) capacitor c=9.58915e-17
C5 (A1 VSS) capacitor c=5.61967e-17
C6 (n0 VSS) capacitor c=9.13231e-17
C7 (2 VSS) capacitor c=3.4798e-18
C8 (4 VSS) capacitor c=1.86068e-18
C9 (\6\:A0 VSS) capacitor c=8.4416e-17
C10 (\1\:A1 VSS) capacitor c=6.19994e-17
C11 (\6\:A1 VSS) capacitor c=4.26043e-17
C12 (\1\:A0 VSS) capacitor c=6.609e-17
C13 (\1\:B0 VSS) capacitor c=1.53119e-16
C14 (\4\:Y VSS) capacitor c=8.529e-17
C15 (\6\:Y VSS) capacitor c=9.70774e-17
C16 (\12\:VDD VSS) capacitor c=5.1919e-17
C17 (\1\:VDD VSS) capacitor c=4.14773e-17
C18 (\1\:Y VSS) capacitor c=4.15345e-17
C19 (\2\:A1 VSS) capacitor c=1.40447e-16
C20 (\7\:A1 VSS) capacitor c=6.39228e-17
C21 (\3\:Y VSS) capacitor c=4.60025e-17
C22 (\8\:B0 VSS) capacitor c=8.26963e-17
C23 (\2\:n0 VSS) capacitor c=1.70299e-16
C24 (\3\:VDD VSS) capacitor c=9.00789e-17
C25 (\7\:VDD VSS) capacitor c=2.30922e-18
Rk6 (\3\:Y Y) resistor r=0.1105 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.2433 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.2361 c=0
Rk7 (\5\:Y \7\:Y) resistor r=0.3796 c=0
Rk8 (\7\:Y \8\:Y) resistor r=0.1523 c=0
Rk9 (\5\:Y \9\:Y) resistor r=0.1555 c=0
Rk10 (B0 \8\:B0) resistor r=0.02037 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.08467 c=0
Rk17 (\3\:VDD \6\:VDD) resistor r=0.2419 c=0
Rk19 (\7\:VDD VDD) resistor r=0.1144 c=0
Rk18 (\6\:VDD \7\:VDD) resistor r=0.08467 c=0
Rk22 (\7\:VDD \13\:VDD) resistor r=0.2616 c=0
Rk1 (\7\:A1 A1) resistor r=0.192 c=0
Rk25 (\1\:VSS VSS) resistor r=0.1843 c=0
Rl9 (A0 \6\:A0) resistor r=78.6412 c=0
Rl1 (A0 \1\:A0) resistor r=96.1538 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=47.3105 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=24.2328 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\6\:VDD \1\:VDD) resistor r=15 c=0
Rz2 (\2\:n0 n0) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\8\:Y \6\:Y) resistor r=62 c=0
Ry4 (\9\:Y \4\:Y) resistor r=62 c=0
Ry7 (\13\:VDD \12\:VDD) resistor r=20.6667 c=0
Rx4 (\8\:B0 \1\:B0) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
mn0 (\2\:n0 A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.745e-14 ps=8.4e-07 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn1 (n0 \2\:A1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.025e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\1\:Y \1\:B0 \2\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.745e-14 ad=4.16e-14 ps=8.85e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp1 (\6\:Y \6\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.315e-14 \
        ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.8e-07 sb=8.95e-07 sd=160n sca=12.9324 scb=0.0106401 \
        scc=0.000233941 m=(1)
mp1_1__rcx (\6\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.85e-07 sb=6.9e-07 sd=160n sca=11.8564 \
        scb=0.00969513 scc=0.0002319 m=(1)
mp0_1__rcx (4 \6\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.605e-14 ad=2.34e-14 ps=1.17e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=5.85e-07 sd=160n sca=11.6462 \
        scb=0.00959597 scc=0.000231862 m=(1)
mp2 (\4\:Y \1\:B0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.532e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=3.45e-07 sd=160n sca=12.2699 \
        scb=0.00996585 scc=0.000232152 m=(2)
ends OAI21X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:36:53 2012 )
// Library name: gsclib045
// Cell name: OAI21X4
// View name: extracted

simulator lang=spectre

subckt OAI21X4 A0 A1 B0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=7.995e-14 ps=1.06e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.9101 scb=0.0232377 \
        scc=0.0012647 m=(1)
C1 (A0 VSS) capacitor c=4.15692e-17
C2 (Y VSS) capacitor c=4.50789e-18
C3 (A1 VSS) capacitor c=2.75487e-17
C4 (VDD VSS) capacitor c=1.07897e-16
C5 (B0 VSS) capacitor c=3.33531e-16
C6 (n0 VSS) capacitor c=4.89804e-16
C7 (4 VSS) capacitor c=1.92642e-18
C8 (5 VSS) capacitor c=1.92642e-18
C9 (6 VSS) capacitor c=5.41429e-18
C10 (\12\:A0 VSS) capacitor c=5.83614e-17
C11 (\12\:A1 VSS) capacitor c=4.35389e-17
C12 (\10\:A1 VSS) capacitor c=5.93128e-17
C13 (\4\:A0 VSS) capacitor c=7.52454e-17
C14 (\7\:A0 VSS) capacitor c=6.81789e-17
C15 (\1\:A1 VSS) capacitor c=6.41638e-17
C16 (\5\:A1 VSS) capacitor c=2.68717e-17
C17 (\1\:A0 VSS) capacitor c=4.25745e-17
C18 (\2\:A1 VSS) capacitor c=4.23011e-16
C19 (\2\:A0 VSS) capacitor c=5.47367e-16
C20 (\1\:VDD VSS) capacitor c=1.53024e-16
C21 (\1\:Y VSS) capacitor c=2.12046e-16
C22 (\10\:Y VSS) capacitor c=1.0763e-16
C23 (\15\:VDD VSS) capacitor c=3.84986e-17
C24 (\12\:Y VSS) capacitor c=9.20484e-17
C25 (\17\:VDD VSS) capacitor c=3.14137e-17
C26 (\4\:VDD VSS) capacitor c=4.08129e-17
C27 (\6\:Y VSS) capacitor c=1.56939e-16
C28 (\5\:A0 VSS) capacitor c=3.33329e-17
C29 (\7\:VDD VSS) capacitor c=1.51713e-17
Rk3 (A0 \2\:A0) resistor r=0.1463 c=0
Rk15 (\1\:Y Y) resistor r=0.08385 c=0
Rk10 (\1\:Y \6\:Y) resistor r=0.4346 c=0
Rk12 (\1\:Y \11\:Y) resistor r=0.4446 c=0
Rk13 (\11\:Y \13\:Y) resistor r=0.4712 c=0
Rk14 (\13\:Y \14\:Y) resistor r=0.1562 c=0
Rk16 (Y \15\:Y) resistor r=0.04792 c=0
Rk17 (\11\:Y \16\:Y) resistor r=0.1562 c=0
Rk2 (\2\:A1 A1) resistor r=0.06619 c=0
Rk41 (\3\:VSS VSS) resistor r=0.08978 c=0
Rk36 (\2\:VSS \3\:VSS) resistor r=0.5461 c=0
Rk27 (\1\:VDD \7\:VDD) resistor r=0.3505 c=0
Rk28 (\7\:VDD \8\:VDD) resistor r=0.1853 c=0
Rk30 (\9\:VDD VDD) resistor r=0.05218 c=0
Rk29 (\8\:VDD \9\:VDD) resistor r=0.1978 c=0
Rk34 (\7\:VDD \16\:VDD) resistor r=0.2429 c=0
Rk35 (\9\:VDD \18\:VDD) resistor r=0.3326 c=0
Rl19 (\2\:A0 \12\:A0) resistor r=91.7582 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=99.2328 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=128.331 c=0
Rl10 (\5\:A0 \7\:A0) resistor r=84.1794 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=6.3032 c=0
Rl17 (\2\:A1 \12\:A1) resistor r=82.6695 c=0
Rl15 (\2\:A1 \10\:A1) resistor r=30.5643 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=65.924 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=49.6216 c=0
Rz12 (VDD \4\:VDD) resistor r=75 c=0
Rz10 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz11 (\8\:VDD \4\:VDD) resistor r=18.75 c=0
Ry4 (\11\:Y \10\:Y) resistor r=62 c=0
Ry5 (\13\:Y \12\:Y) resistor r=62 c=0
Ry6 (\14\:Y \12\:Y) resistor r=62 c=0
Ry7 (\15\:Y \1\:Y) resistor r=62 c=0
Ry8 (\16\:Y \10\:Y) resistor r=62 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry12 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
mn0 (n0 \2\:A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn1 (n0 \2\:A1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn2 (\6\:Y B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.82e-06 sb=7.55e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mp1_1__rcx (\12\:Y \5\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.985e-06 sd=160n sca=17.1039 \
        scb=0.0151782 scc=0.00102545 m=(1)
mp1_2__rcx (\12\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.78e-06 sd=160n sca=15.9572 \
        scb=0.0141077 scc=0.00102277 m=(1)
mp0_2__rcx (4 \7\:A0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.675e-06 sd=160n sca=15.641 scb=0.0139735 \
        scc=0.00102271 m=(1)
mp0 (5 \4\:A0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.47e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1 (\10\:Y \10\:A1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.365e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_3__rcx (\10\:Y \12\:A1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=1.16e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp0_3__rcx (6 \12\:A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=5.46e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=9.75e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2 (\1\:Y B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.191e-14 ad=6.24e-14 ps=1.0975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62e-06 sb=7.55e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(4)
ends OAI21X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:37:32 2012 )
// Library name: gsclib045
// Cell name: OAI21XL
// View name: extracted

simulator lang=spectre

subckt OAI21XL A0 A1 B0 VDD VSS Y
mp0 (n1 \1\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.45e-07 sd=160n sca=19.4229 \
        scb=0.0204259 scc=0.000577964 m=(1)
C1 (A1 VSS) capacitor c=4.63019e-17
C2 (Y VSS) capacitor c=8.01201e-17
C3 (A0 VSS) capacitor c=6.92851e-17
C4 (VDD VSS) capacitor c=1.08665e-16
C5 (B0 VSS) capacitor c=1.23667e-16
C6 (n0 VSS) capacitor c=4.93859e-17
C7 (\1\:B0 VSS) capacitor c=4.30224e-17
C8 (\1\:A1 VSS) capacitor c=4.69882e-17
C9 (\1\:A0 VSS) capacitor c=3.17955e-17
C10 (\3\:B0 VSS) capacitor c=2.71898e-17
C11 (\3\:A1 VSS) capacitor c=4.53271e-17
C12 (\4\:A0 VSS) capacitor c=4.78935e-17
C13 (\2\:B0 VSS) capacitor c=4.9457e-17
C14 (\2\:A1 VSS) capacitor c=5.43298e-17
C15 (\3\:A0 VSS) capacitor c=1.66797e-17
C16 (\1\:VDD VSS) capacitor c=2.39653e-17
C17 (\3\:Y VSS) capacitor c=6.42403e-17
C18 (\7\:VDD VSS) capacitor c=1.90402e-17
C19 (\3\:VDD VSS) capacitor c=2.34949e-17
C20 (\1\:Y VSS) capacitor c=6.22881e-17
C21 (\3\:n0 VSS) capacitor c=8.08197e-17
C22 (\2\:A0 VSS) capacitor c=3.6043e-17
C23 (\4\:A1 VSS) capacitor c=5.07137e-17
C24 (\5\:VDD VSS) capacitor c=6.83594e-18
Rk2 (A1 \4\:A1) resistor r=0.2246 c=0
Rk5 (\2\:Y Y) resistor r=0.4753 c=0
Rk6 (Y \4\:Y) resistor r=0.3247 c=0
Rk1 (\5\:A0 A0) resistor r=0.002995 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1652 c=0
Rk14 (\4\:VSS VSS) resistor r=0.04987 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.08501 c=0
Rk15 (\3\:VSS \6\:VSS) resistor r=0.2805 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.3112 c=0
Rk9 (\5\:VDD VDD) resistor r=0.03213 c=0
Rk8 (\4\:VDD \5\:VDD) resistor r=0.2178 c=0
Rk11 (\5\:VDD \8\:VDD) resistor r=0.1731 c=0
Rk4 (\4\:B0 B0) resistor r=0.002995 c=0
Rk3 (\2\:n0 \4\:n0) resistor r=0.4851 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=143 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.076 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=81.5719 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=193.11 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=14.2236 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=221.551 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=39.5604 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\3\:VDD VDD) resistor r=75 c=0
Rz4 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (n0 \4\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\3\:n0 \3\:A1 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.5e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\1\:Y \3\:B0 \3\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp1 (\3\:Y \1\:A1 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.4e-07 sd=160n sca=14.8962 \
        scb=0.0119773 scc=0.000116187 m=(1)
mp2 (\3\:Y \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=1.4e-07 sd=160n sca=22.0785 \
        scb=0.0241761 scc=0.00103379 m=(1)
ends OAI21XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:21:12 2012 )
// Library name: gsclib045
// Cell name: OAI221X1
// View name: extracted

simulator lang=spectre

subckt OAI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (net115 \1\:A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.2e-07 sd=160n sca=20.0914 \
        scb=0.0223631 scc=0.000753507 m=(1)
C1 (C0 VSS) capacitor c=4.50596e-17
C2 (A1 VSS) capacitor c=1.81179e-17
C3 (A0 VSS) capacitor c=1.78216e-17
C4 (Y VSS) capacitor c=4.53565e-18
C5 (B0 VSS) capacitor c=4.65606e-17
C6 (B1 VSS) capacitor c=6.91485e-17
C7 (VDD VSS) capacitor c=1.22987e-16
C8 (net132 VSS) capacitor c=1.12939e-16
C9 (net128 VSS) capacitor c=4.88827e-17
C10 (net115 VSS) capacitor c=1.40103e-18
C11 (net123 VSS) capacitor c=2.6962e-18
C12 (\3\:C0 VSS) capacitor c=4.66444e-17
C13 (\3\:B0 VSS) capacitor c=9.67493e-17
C14 (\1\:B1 VSS) capacitor c=7.82903e-17
C15 (\1\:A1 VSS) capacitor c=6.27412e-17
C16 (\1\:A0 VSS) capacitor c=7.42135e-17
C17 (\1\:C0 VSS) capacitor c=3.28921e-17
C18 (\1\:B0 VSS) capacitor c=3.85439e-17
C19 (\3\:B1 VSS) capacitor c=5.05151e-17
C20 (\3\:A1 VSS) capacitor c=5.22917e-17
C21 (\3\:A0 VSS) capacitor c=3.39197e-17
C22 (\2\:C0 VSS) capacitor c=3.96263e-17
C23 (\2\:B0 VSS) capacitor c=6.09671e-17
C24 (\2\:B1 VSS) capacitor c=5.01819e-17
C25 (\2\:A1 VSS) capacitor c=4.75032e-17
C26 (\2\:A0 VSS) capacitor c=4.88472e-17
C27 (\4\:Y VSS) capacitor c=5.35894e-17
C28 (\1\:VDD VSS) capacitor c=6.26183e-17
C29 (\6\:Y VSS) capacitor c=7.30941e-17
C30 (\7\:VDD VSS) capacitor c=2.44727e-17
C31 (\3\:VDD VSS) capacitor c=4.38979e-17
C32 (\1\:Y VSS) capacitor c=6.29074e-17
C33 (\3\:net128 VSS) capacitor c=6.27213e-17
C34 (\3\:net132 VSS) capacitor c=3.98705e-17
C35 (\4\:A0 VSS) capacitor c=2.04777e-17
C36 (\4\:A1 VSS) capacitor c=2.73473e-17
C37 (\4\:B0 VSS) capacitor c=4.17075e-17
C38 (\4\:C0 VSS) capacitor c=6.01573e-17
C39 (\3\:Y VSS) capacitor c=8.8101e-17
Rk7 (C0 \4\:C0) resistor r=0.1175 c=0
Rk2 (\4\:A1 A1) resistor r=0.04077 c=0
Rk1 (\4\:A0 A0) resistor r=0.0408 c=0
Rk9 (\3\:Y Y) resistor r=0.03094 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.3302 c=0
Rk10 (Y \5\:Y) resistor r=0.01294 c=0
Rk11 (\3\:Y \7\:Y) resistor r=0.5051 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.2344 c=0
Rk19 (\4\:VSS VSS) resistor r=0.05048 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.1141 c=0
Rk20 (VSS \6\:VSS) resistor r=0.08738 c=0
Rk21 (\3\:VSS \8\:VSS) resistor r=0.06833 c=0
Rk5 (B0 \4\:B0) resistor r=0.0569 c=0
Rk3 (\4\:B1 B1) resistor r=0.002995 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.3 c=0
Rk14 (\5\:VDD VDD) resistor r=0.02963 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.3206 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.2263 c=0
Rk4 (\2\:net132 \4\:net132) resistor r=0.4182 c=0
Rk6 (\2\:net128 \4\:net128) resistor r=0.3041 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=82.6695 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=55.5643 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=110.307 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=78.8233 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=59.4104 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=119.964 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=26.9231 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=79.5379 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=60.3072 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz8 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\3\:VDD VDD) resistor r=75 c=0
Rz6 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz1 (net132 \2\:net132) resistor r=75 c=0
Rz2 (\3\:net132 \4\:net132) resistor r=75 c=0
Rz3 (net128 \2\:net128) resistor r=75 c=0
Rz4 (\3\:net128 \4\:net128) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (\3\:net132 \3\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.39e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:net132 \3\:A1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.56e-14 ad=4.16e-14 ps=1.52e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn3 (net132 \3\:B1 \3\:net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (net132 \1\:B0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4 (\1\:Y \1\:C0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp1 (\6\:Y \1\:A1 net115 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.15e-07 sd=160n sca=15.9166 \
        scb=0.0154749 scc=0.000316749 m=(1)
mp3 (\6\:Y \1\:B1 net123 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.5e-07 sd=160n sca=12.9574 \
        scb=0.0102588 scc=0.000232318 m=(1)
mp2 (net123 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=3.45e-07 sd=160n sca=13.2989 \
        scb=0.010817 scc=0.000234376 m=(1)
mp4 (\4\:Y \3\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.4e-07 sd=160n sca=16.1834 \
        scb=0.0159482 scc=0.0003331 m=(1)
ends OAI221X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:38:50 2012 )
// Library name: gsclib045
// Cell name: OAI221X2
// View name: extracted

simulator lang=spectre

subckt OAI221X2 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.0138 scb=0.0145482 \
        scc=0.00065833 m=(1)
C1 (A1 VSS) capacitor c=5.48011e-17
C2 (Y VSS) capacitor c=7.68356e-17
C3 (B0 VSS) capacitor c=1.13213e-16
C4 (B1 VSS) capacitor c=5.44998e-17
C5 (VDD VSS) capacitor c=1.24021e-16
C6 (C0 VSS) capacitor c=3.6804e-17
C7 (A0 VSS) capacitor c=1.66867e-17
C8 (net132 VSS) capacitor c=1.75049e-16
C9 (net128 VSS) capacitor c=1.71756e-16
C10 (2 VSS) capacitor c=1.56659e-18
C11 (4 VSS) capacitor c=4.27073e-18
C12 (5 VSS) capacitor c=4.42571e-18
C13 (6 VSS) capacitor c=9.60727e-18
C14 (\6\:B0 VSS) capacitor c=4.11272e-17
C15 (\1\:B1 VSS) capacitor c=3.35827e-17
C16 (\7\:B1 VSS) capacitor c=4.75867e-17
C17 (\1\:B0 VSS) capacitor c=4.1635e-17
C18 (\6\:A0 VSS) capacitor c=4.22529e-17
C19 (\1\:A1 VSS) capacitor c=4.8119e-17
C20 (\6\:A1 VSS) capacitor c=6.9974e-17
C21 (\1\:A0 VSS) capacitor c=8.89392e-17
C22 (\1\:C0 VSS) capacitor c=1.57323e-16
C23 (\2\:B0 VSS) capacitor c=2.78466e-16
C24 (\2\:A0 VSS) capacitor c=2.96725e-16
C25 (\8\:Y VSS) capacitor c=3.5317e-17
C26 (\4\:Y VSS) capacitor c=1.30936e-16
C27 (\14\:VDD VSS) capacitor c=4.84363e-17
C28 (\6\:Y VSS) capacitor c=1.07401e-16
C29 (\16\:VDD VSS) capacitor c=1.66253e-17
C30 (\1\:VDD VSS) capacitor c=4.98834e-17
C31 (\1\:Y VSS) capacitor c=3.99893e-17
C32 (\5\:net128 VSS) capacitor c=8.20332e-17
C33 (\3\:net132 VSS) capacitor c=1.28895e-16
C34 (\2\:A1 VSS) capacitor c=9.70737e-17
C35 (\2\:B1 VSS) capacitor c=9.72351e-17
C36 (\7\:A1 VSS) capacitor c=6.8357e-17
C37 (\8\:B1 VSS) capacitor c=6.71416e-17
C38 (\9\:C0 VSS) capacitor c=8.7587e-17
C39 (\3\:Y VSS) capacitor c=9.04302e-17
C40 (\3\:VDD VSS) capacitor c=1.24989e-16
C41 (\6\:VDD VSS) capacitor c=9.61838e-18
C42 (\8\:VDD VSS) capacitor c=9.86746e-19
Rk1 (\7\:A1 A1) resistor r=0.05745 c=0
Rk13 (\2\:Y Y) resistor r=0.221 c=0
Rk14 (Y \3\:Y) resistor r=0.306 c=0
Rk15 (\3\:Y \5\:Y) resistor r=0.4876 c=0
Rk16 (\5\:Y \7\:Y) resistor r=0.7161 c=0
Rk17 (\3\:Y \9\:Y) resistor r=0.04731 c=0
Rk8 (B0 \2\:B0) resistor r=0.01196 c=0
Rk4 (\8\:B1 B1) resistor r=0.05745 c=0
Rk33 (\2\:VSS \3\:VSS) resistor r=0.7007 c=0
Rk37 (\4\:VSS VSS) resistor r=0.01957 c=0
Rk34 (\3\:VSS \4\:VSS) resistor r=0.04985 c=0
Rk39 (\4\:VSS \10\:VSS) resistor r=0.2418 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.03484 c=0
Rk23 (\3\:VDD \5\:VDD) resistor r=0.1675 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.3927 c=0
Rk25 (\6\:VDD \7\:VDD) resistor r=0.1575 c=0
Rk26 (\7\:VDD \8\:VDD) resistor r=0.16 c=0
Rk28 (\9\:VDD VDD) resistor r=0.0498 c=0
Rk27 (\8\:VDD \9\:VDD) resistor r=0.08989 c=0
Rk31 (\6\:VDD \15\:VDD) resistor r=0.2175 c=0
Rk32 (\8\:VDD \17\:VDD) resistor r=0.222 c=0
Rk12 (C0 \9\:C0) resistor r=0.03288 c=0
Rk3 (\2\:A0 A0) resistor r=0.01831 c=0
Rk5 (net132 \3\:net132) resistor r=0.4025 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=99.7141 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=91.7582 c=0
Rl19 (\2\:B0 \6\:B0) resistor r=41.4835 c=0
Rl10 (\2\:B0 \1\:B0) resistor r=30.7692 c=0
Rl12 (\2\:B1 \1\:B1) resistor r=99.7141 c=0
Rl17 (\2\:B1 \7\:B1) resistor r=99.7141 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=29.9451 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=62.5949 c=0
Rz5 (\2\:Y \1\:Y) resistor r=75 c=0
Rz15 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz11 (\5\:VDD \1\:VDD) resistor r=9.375 c=0
Rz12 (\7\:VDD \1\:VDD) resistor r=25 c=0
Rz13 (\9\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (net128 \5\:net128) resistor r=75 c=0
Ry1 (\5\:Y \4\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\9\:Y \8\:Y) resistor r=31 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry6 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\17\:VDD \16\:VDD) resistor r=62 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\8\:B1 \2\:B1) resistor r=45 c=0
Rx7 (\9\:C0 \1\:C0) resistor r=45 c=0
mn0 (\3\:net132 \2\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=5.98e-14 ps=8e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.95e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn1 (\3\:net132 \2\:A1 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.98e-14 ps=8.4e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.85e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn2 (net132 \2\:B0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=8.65e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.31e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn3 (net132 \2\:B1 \5\:net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.46e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.105e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn4 (\1\:Y \1\:C0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mp1_1__rcx (\6\:Y \6\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.9982 scb=0.0131496 \
        scc=0.000649094 m=(1)
mp1 (\6\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.875e-06 sd=160n sca=13.9871 scb=0.012316 \
        scc=0.000647546 m=(1)
mp0 (4 \6\:A0 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.833e-13 ad=4.095e-14 ps=1.72e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.725e-06 sd=160n sca=13.6057 \
        scb=0.0121904 scc=0.000647513 m=(1)
mp2 (5 \1\:B0 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.833e-13 ad=4.095e-14 ps=1.72e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.21e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (\4\:Y \7\:B1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.265e-06 sb=1.06e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (\4\:Y \1\:B1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=8.55e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2_1__rcx (6 \6\:B0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.995e-14 ps=1.1e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=6.05e-07 sd=160n sca=14.1837 \
        scb=0.0124217 scc=0.000647608 m=(1)
mp4 (\8\:Y \1\:C0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.922e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=4e-07 sd=160n sca=15.4628 \
        scb=0.0137376 scc=0.00065186 m=(2)
ends OAI221X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:39:30 2012 )
// Library name: gsclib045
// Cell name: OAI221X4
// View name: extracted

simulator lang=spectre

subckt OAI221X4 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (3 \1\:A0 \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.71923e-07 sd=160n sca=15.6591 \
        scb=0.0148836 scc=0.000346323 m=(1)
C1 (C0 VSS) capacitor c=3.3748e-16
C2 (A0 VSS) capacitor c=1.98405e-17
C3 (A1 VSS) capacitor c=3.99784e-16
C4 (Y VSS) capacitor c=4.15674e-17
C5 (B0 VSS) capacitor c=6.13017e-16
C6 (VDD VSS) capacitor c=2.7857e-16
C7 (net132 VSS) capacitor c=3.36326e-16
C8 (net128 VSS) capacitor c=4.4301e-16
C9 (5 VSS) capacitor c=1.84995e-18
C10 (6 VSS) capacitor c=1.83145e-18
C11 (7 VSS) capacitor c=1.84995e-18
C12 (8 VSS) capacitor c=7.34662e-18
C13 (9 VSS) capacitor c=2.39145e-18
C14 (10 VSS) capacitor c=2.39145e-18
C15 (11 VSS) capacitor c=9.81103e-18
C16 (\12\:B0 VSS) capacitor c=3.98624e-17
C17 (\13\:B1 VSS) capacitor c=3.2162e-17
C18 (\12\:B1 VSS) capacitor c=6.93705e-17
C19 (\9\:B0 VSS) capacitor c=5.68581e-17
C20 (\7\:B0 VSS) capacitor c=7.56857e-17
C21 (\1\:B1 VSS) capacitor c=6.73206e-17
C22 (\6\:B1 VSS) capacitor c=3.91652e-17
C23 (\1\:B0 VSS) capacitor c=3.35061e-17
C24 (\10\:A0 VSS) capacitor c=6.12301e-17
C25 (\7\:A1 VSS) capacitor c=7.31523e-17
C26 (\12\:A1 VSS) capacitor c=6.73335e-17
C27 (\4\:A0 VSS) capacitor c=8.44561e-17
C28 (\6\:A0 VSS) capacitor c=8.29419e-17
C29 (\1\:A1 VSS) capacitor c=6.39443e-17
C30 (\5\:A1 VSS) capacitor c=7.16094e-17
C31 (\1\:A0 VSS) capacitor c=6.8043e-17
C32 (\3\:B1 VSS) capacitor c=3.52702e-16
C33 (\2\:A0 VSS) capacitor c=5.40926e-16
C34 (\5\:Y VSS) capacitor c=2.12989e-16
C35 (\9\:Y VSS) capacitor c=1.19232e-16
C36 (\17\:VDD VSS) capacitor c=3.37363e-17
C37 (\11\:Y VSS) capacitor c=1.39476e-16
C38 (\19\:VDD VSS) capacitor c=4.32423e-17
C39 (\13\:Y VSS) capacitor c=1.38245e-16
C40 (\21\:VDD VSS) capacitor c=3.27707e-17
C41 (\15\:Y VSS) capacitor c=8.91604e-17
C42 (\24\:VDD VSS) capacitor c=1.11723e-17
C43 (\1\:VDD VSS) capacitor c=7.00562e-17
C44 (\1\:Y VSS) capacitor c=1.1884e-16
C45 (\7\:net132 VSS) capacitor c=2.76149e-16
C46 (\8\:A1 VSS) capacitor c=4.19023e-17
C47 (\2\:B1 VSS) capacitor c=3.31295e-17
C48 (\3\:VDD VSS) capacitor c=1.60783e-16
C49 (\8\:VDD VSS) capacitor c=2.66694e-17
C50 (\9\:VDD VSS) capacitor c=3.93033e-17
C51 (\23\:VDD VSS) capacitor c=1.71665e-17
Rk5 (\2\:A0 A0) resistor r=0.01833 c=0
Rk23 (Y \5\:Y) resistor r=0.3502 c=0
Rk22 (\1\:Y Y) resistor r=0.1668 c=0
Rk25 (\5\:Y \10\:Y) resistor r=0.5056 c=0
Rk26 (\10\:Y \12\:Y) resistor r=0.4546 c=0
Rk27 (\12\:Y \14\:Y) resistor r=0.6899 c=0
Rk28 (\14\:Y \16\:Y) resistor r=0.6463 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.03488 c=0
Rk39 (\3\:VDD \7\:VDD) resistor r=0.2554 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.1326 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.4882 c=0
Rk42 (\9\:VDD \10\:VDD) resistor r=0.4308 c=0
Rk46 (\8\:VDD \18\:VDD) resistor r=0.1816 c=0
Rk47 (\9\:VDD \20\:VDD) resistor r=0.1816 c=0
Rk48 (\10\:VDD \22\:VDD) resistor r=0.2277 c=0
Rk51 (\23\:VDD VDD) resistor r=0.09477 c=0
Rk49 (\10\:VDD \23\:VDD) resistor r=0.306 c=0
Rk50 (\23\:VDD \25\:VDD) resistor r=0.1861 c=0
Rk7 (\3\:B1 B1) resistor r=0.005369 c=0
Rk62 (\1\:VSS VSS) resistor r=0.0196 c=0
Rk10 (net132 \7\:net132) resistor r=0.4036 c=0
Rl19 (\2\:A0 \10\:A0) resistor r=24.2328 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=100.276 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=101.477 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=69.387 c=0
Rl3 (A1 \1\:A1) resistor r=62.2713 c=0
Rl6 (A1 \5\:A1) resistor r=109.593 c=0
Rl14 (\8\:A1 A1) resistor r=3.3726 c=0
Rl13 (\8\:A1 \7\:A1) resistor r=119.437 c=0
Rl17 (\8\:A1 \12\:A1) resistor r=83.3806 c=0
Rl40 (B0 \12\:B0) resistor r=29.9065 c=0
Rl33 (B0 \9\:B0) resistor r=21.9171 c=0
Rl31 (B0 \7\:B0) resistor r=77.1158 c=0
Rl21 (B0 \1\:B0) resistor r=40.3846 c=0
Rl38 (\3\:B1 \13\:B1) resistor r=88.6564 c=0
Rl37 (\3\:B1 \12\:B1) resistor r=100.195 c=0
Rl23 (\2\:B1 \1\:B1) resistor r=82.2563 c=0
Rl27 (\2\:B1 \6\:B1) resistor r=126.408 c=0
Rl24 (\2\:B1 \3\:B1) resistor r=3.9095 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz19 (\3\:VDD \1\:VDD) resistor r=75 c=0
Rz20 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\10\:VDD \1\:VDD) resistor r=8.3333 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry4 (\12\:Y \11\:Y) resistor r=62 c=0
Ry5 (\14\:Y \13\:Y) resistor r=62 c=0
Ry6 (\16\:Y \15\:Y) resistor r=62 c=0
Ry10 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry11 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry12 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry13 (\25\:VDD \24\:VDD) resistor r=62 c=0
mn0_1__rcx (\7\:net132 \2\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=3.9e-14 ad=4.225e-14 ps=8.2e-07 pd=8.45e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.585e-06 sd=160n \
        sca=16.9678 scb=0.0167861 scc=0.00150639 m=(4)
mn1_1__rcx (\7\:net132 A1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.37e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn2_1__rcx (net132 B0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn3_1__rcx (net132 \3\:B1 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn4_1__rcx (\1\:Y C0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=7.55e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mp1_1__rcx (\15\:Y \5\:A1 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.99231e-07 sd=160n sca=13.9858 \
        scb=0.012083 scc=0.000300035 m=(1)
mp1 (\15\:Y \1\:A1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=7.57308e-07 sd=160n sca=12.4846 scb=0.0103323 scc=0.000291984 \
        m=(1)
mp0 (5 \6\:A0 \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.044e-13 ad=2.34e-14 ps=2.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=6.84615e-07 sd=160n sca=12.0928 \
        scb=0.0101069 scc=0.000291823 m=(1)
mp0_2__rcx (6 \4\:A0 \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.044e-13 ad=2.34e-14 ps=2.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_1__rcx (8 \1\:B0 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.6185e-13 ad=6.24e-14 ps=1.61e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25808e-06 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp1_2__rcx (\13\:Y \12\:A1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.88077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp1_3__rcx (\13\:Y \7\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.93077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp0_3__rcx (7 \10\:A0 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.6185e-13 ad=2.34e-14 ps=1.61e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98077e-07 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_3__rcx (11 \12\:B0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.385e-14 ps=1.1e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.03e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_1__rcx (\11\:Y \6\:B1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43231e-06 sb=2e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_2__rcx (\11\:Y \1\:B1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.57423e-06 sb=1.91e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2_2__rcx (9 \7\:B0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64692e-06 sb=1.805e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp2 (10 \9\:B0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78885e-06 sb=1.6e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3 (\9\:Y \12\:B1 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86154e-06 sb=1.495e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp3_3__rcx (\9\:Y \13\:B1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.29e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp4_1__rcx (\5\:Y C0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.728e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=11.7295 \
        scb=0.00999684 scc=0.000291798 m=(4)
ends OAI221X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:40:07 2012 )
// Library name: gsclib045
// Cell name: OAI221XL
// View name: extracted

simulator lang=spectre

subckt OAI221XL A0 A1 B0 B1 C0 VDD VSS Y
mp0 (net115 \1\:A0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.258e-14 ps=7.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=15.6738 \
        scb=0.0150674 scc=0.000231884 m=(1)
C1 (C0 VSS) capacitor c=1.02437e-16
C2 (A1 VSS) capacitor c=4.63272e-17
C3 (A0 VSS) capacitor c=4.82804e-17
C4 (B0 VSS) capacitor c=6.00671e-17
C5 (B1 VSS) capacitor c=5.42256e-17
C6 (VDD VSS) capacitor c=1.41807e-16
C7 (net132 VSS) capacitor c=6.15823e-17
C8 (net128 VSS) capacitor c=8.65993e-17
C9 (net115 VSS) capacitor c=5.51879e-18
C10 (net123 VSS) capacitor c=2.97781e-19
C11 (\3\:C0 VSS) capacitor c=5.57982e-17
C12 (\3\:B0 VSS) capacitor c=4.02148e-17
C13 (\1\:B1 VSS) capacitor c=3.81812e-17
C14 (\1\:A1 VSS) capacitor c=4.36584e-17
C15 (\1\:A0 VSS) capacitor c=5.03247e-17
C16 (\1\:C0 VSS) capacitor c=2.65864e-17
C17 (\1\:B0 VSS) capacitor c=5.09953e-17
C18 (\3\:B1 VSS) capacitor c=4.5297e-17
C19 (\3\:A1 VSS) capacitor c=3.87191e-17
C20 (\3\:A0 VSS) capacitor c=2.55432e-17
C21 (\2\:C0 VSS) capacitor c=5.43425e-17
C22 (\2\:B0 VSS) capacitor c=6.09608e-17
C23 (\2\:B1 VSS) capacitor c=4.77967e-17
C24 (\2\:A1 VSS) capacitor c=4.28846e-17
C25 (\2\:A0 VSS) capacitor c=4.64098e-17
C26 (\6\:Y VSS) capacitor c=2.33433e-17
C27 (\7\:VDD VSS) capacitor c=2.98221e-17
C28 (\4\:Y VSS) capacitor c=5.93602e-17
C29 (\9\:VDD VSS) capacitor c=1.83411e-17
C30 (\1\:VDD VSS) capacitor c=5.25012e-17
C31 (\1\:Y VSS) capacitor c=7.38853e-17
C32 (\3\:net132 VSS) capacitor c=1.05431e-16
C33 (\3\:net128 VSS) capacitor c=9.77361e-17
C34 (\4\:A0 VSS) capacitor c=3.48095e-17
C35 (\4\:A1 VSS) capacitor c=5.2757e-17
C36 (\4\:B1 VSS) capacitor c=3.3542e-17
C37 (\4\:B0 VSS) capacitor c=5.10201e-17
C38 (\4\:C0 VSS) capacitor c=3.75264e-17
C39 (\3\:Y VSS) capacitor c=1.15974e-16
C40 (\3\:VDD VSS) capacitor c=1.34304e-18
C41 (\5\:VDD VSS) capacitor c=1.10633e-18
Rk9 (\4\:C0 C0) resistor r=0.04912 c=0
Rk2 (A1 \4\:A1) resistor r=0.2201 c=0
Rk1 (A0 \4\:A0) resistor r=0.1822 c=0
Rk12 (\3\:Y Y) resistor r=0.03931 c=0
Rk10 (\2\:Y \3\:Y) resistor r=0.5404 c=0
Rk11 (\3\:Y \5\:Y) resistor r=0.4972 c=0
Rk13 (Y \7\:Y) resistor r=0.001679 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.2898 c=0
Rk22 (\3\:VSS \4\:VSS) resistor r=0.1098 c=0
Rk24 (\5\:VSS VSS) resistor r=0.05956 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.08982 c=0
Rk26 (\3\:VSS \8\:VSS) resistor r=0.073 c=0
Rk27 (\5\:VSS \10\:VSS) resistor r=0.073 c=0
Rk5 (B0 \4\:B0) resistor r=0.1733 c=0
Rk3 (\4\:B1 B1) resistor r=0.07737 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.1173 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.2823 c=0
Rk17 (\5\:VDD VDD) resistor r=0.06706 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.2823 c=0
Rk19 (\3\:VDD \8\:VDD) resistor r=0.2283 c=0
Rk20 (\5\:VDD \10\:VDD) resistor r=0.2283 c=0
Rk4 (\2\:net132 \4\:net132) resistor r=0.6015 c=0
Rk6 (\2\:net128 \4\:net128) resistor r=0.4518 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=213.257 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=44.4893 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=108.384 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=77.6149 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=157.692 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=29.9451 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=74.1758 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=184.615 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=116.076 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=141.076 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz1 (net132 \2\:net132) resistor r=75 c=0
Rz2 (\3\:net132 \4\:net132) resistor r=75 c=0
Rz3 (net128 \2\:net128) resistor r=75 c=0
Rz4 (\3\:net128 \4\:net128) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\6\:Y \7\:Y) resistor r=62 c=0
Ry7 (\1\:VSS VSS) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=10.3333 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (net132 \3\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.315e-14 ad=2.32e-14 ps=1.44e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn1 (net132 \3\:A1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.315e-14 ad=2.32e-14 ps=1.44e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn3 (\3\:net132 \3\:B1 \3\:net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.248e-14 ad=3.118e-14 ps=6e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=6.55e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (\3\:net132 \1\:B0 net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.118e-14 ps=7.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=3.95e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn4 (\1\:Y \1\:C0 net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.4e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mp1 (\4\:Y \1\:A1 net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=1.1287e-13 ps=6.4e-07 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=1.14e-06 sd=160n sca=12.6662 \
        scb=0.00987777 scc=9.80167e-05 m=(1)
mp3 (\4\:Y \1\:B1 net123 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.1287e-13 ps=7.5e-07 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.7e-07 sd=160n sca=10.8786 \
        scb=0.00783555 scc=8.82249e-05 m=(1)
mp2 (net123 \3\:B0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=3.65e-07 sd=160n sca=12.1296 \
        scb=0.0090984 scc=9.21052e-05 m=(1)
mp4 (\6\:Y \3\:C0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.01e-14 ps=7.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.4e-07 sd=160n sca=16.5578 \
        scb=0.0165885 scc=0.000310105 m=(1)
ends OAI221XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:22:00 2012 )
// Library name: gsclib045
// Cell name: OAI222X1
// View name: extracted

simulator lang=spectre

subckt OAI222X1 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13e-06 sd=160n sca=19.3961 \
        scb=0.0212947 scc=0.000662871 m=(1)
C1 (A0 VSS) capacitor c=2.43623e-17
C2 (B0 VSS) capacitor c=5.22226e-17
C3 (C1 VSS) capacitor c=2.03038e-17
C4 (Y VSS) capacitor c=2.35658e-17
C5 (A1 VSS) capacitor c=4.78962e-17
C6 (VDD VSS) capacitor c=1.23367e-16
C7 (n0 VSS) capacitor c=9.57779e-17
C8 (n1 VSS) capacitor c=6.29072e-17
C9 (n2 VSS) capacitor c=1.65716e-18
C10 (n3 VSS) capacitor c=6.31835e-18
C11 (n4 VSS) capacitor c=2.99166e-18
C12 (\3\:C1 VSS) capacitor c=7.45055e-17
C13 (\1\:C0 VSS) capacitor c=1.04222e-16
C14 (\1\:B0 VSS) capacitor c=5.47956e-17
C15 (\1\:B1 VSS) capacitor c=4.52187e-17
C16 (\1\:A1 VSS) capacitor c=7.39982e-17
C17 (\1\:A0 VSS) capacitor c=6.19371e-17
C18 (\1\:C1 VSS) capacitor c=4.34716e-17
C19 (\3\:C0 VSS) capacitor c=4.15718e-17
C20 (\3\:B0 VSS) capacitor c=5.53159e-17
C21 (\3\:B1 VSS) capacitor c=5.04392e-17
C22 (\3\:A1 VSS) capacitor c=4.378e-17
C23 (\3\:A0 VSS) capacitor c=4.39191e-17
C24 (\2\:C1 VSS) capacitor c=6.12696e-17
C25 (\2\:C0 VSS) capacitor c=5.93779e-17
C26 (\2\:B0 VSS) capacitor c=5.84186e-17
C27 (\2\:B1 VSS) capacitor c=4.87008e-17
C28 (\2\:A1 VSS) capacitor c=4.1755e-17
C29 (\2\:A0 VSS) capacitor c=4.699e-17
C30 (\6\:Y VSS) capacitor c=3.01102e-17
C31 (\1\:VDD VSS) capacitor c=5.27873e-17
C32 (\4\:Y VSS) capacitor c=1.17026e-16
C33 (\7\:VDD VSS) capacitor c=2.92755e-17
C34 (\3\:VDD VSS) capacitor c=6.01362e-17
C35 (\1\:Y VSS) capacitor c=1.04101e-16
C36 (\3\:n1 VSS) capacitor c=7.99084e-17
C37 (\5\:n1 VSS) capacitor c=6.64271e-17
C38 (\3\:n0 VSS) capacitor c=5.2109e-17
C39 (\4\:A0 VSS) capacitor c=5.99845e-17
C40 (\4\:A1 VSS) capacitor c=1.06857e-16
C41 (\4\:B1 VSS) capacitor c=1.1347e-16
C42 (\4\:B0 VSS) capacitor c=3.97717e-17
C43 (\4\:C0 VSS) capacitor c=5.09448e-17
C44 (\5\:C0 VSS) capacitor c=3.90843e-17
C45 (\4\:C1 VSS) capacitor c=3.91621e-17
C46 (\3\:Y VSS) capacitor c=1.11214e-16
C47 (\5\:VDD VSS) capacitor c=1.64665e-17
Rk1 (\4\:A0 A0) resistor r=0.03923 c=0
Rk5 (B0 \4\:B0) resistor r=0.1139 c=0
Rk3 (B1 \4\:B1) resistor r=0.00365 c=0
Rk9 (C1 \4\:C1) resistor r=0.01123 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5951 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.6465 c=0
Rk15 (\7\:Y Y) resistor r=0.06034 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.06822 c=0
Rk22 (\3\:VSS VSS) resistor r=0.1751 c=0
Rk23 (VSS \5\:VSS) resistor r=0.07638 c=0
Rk24 (\3\:VSS \7\:VSS) resistor r=0.05844 c=0
Rk6 (C0 \4\:C0) resistor r=0.003363 c=0
Rk8 (\4\:C0 \5\:C0) resistor r=0.09016 c=0
Rk7 (\5\:C0 \6\:C0) resistor r=0.003462 c=0
Rk2 (A1 \4\:A1) resistor r=0.1575 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3047 c=0
Rk18 (\5\:VDD VDD) resistor r=0.03721 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.3639 c=0
Rk20 (\5\:VDD \8\:VDD) resistor r=0.2435 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.5007 c=0
Rk10 (\2\:n1 \4\:n1) resistor r=0.3063 c=0
Rk11 (\4\:n1 \6\:n1) resistor r=0.3082 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=110.372 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=72.2519 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=122.252 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=75.6918 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=125.692 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=78.9444 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=126.923 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=152.615 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=48.7687 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=79.9442 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=49.1749 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz10 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz3 (n1 \2\:n1) resistor r=75 c=0
Rz4 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz5 (\5\:n1 \6\:n1) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \6\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:n0 \3\:A1 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.05e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (n0 \3\:B1 \5\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (n0 \3\:B0 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (\1\:Y \1\:C1 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.55e-07 sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
mp1 (\4\:Y \1\:A1 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.2675e-13 ps=9e-07 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.025e-06 sd=160n sca=15.6981 scb=0.0150296 \
        scc=0.000323375 m=(1)
mp3 (\4\:Y \1\:B1 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=1.2675e-13 ps=1.1e-06 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.15e-07 sb=6.55e-07 sd=160n sca=12.3518 scb=0.0100158 \
        scc=0.000258343 m=(1)
mp2 (n3 \1\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=4.5e-07 sd=160n sca=12.6156 \
        scb=0.0103368 scc=0.000258831 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.45e-07 sd=160n sca=14.6264 \
        scb=0.0131608 scc=0.000282649 m=(1)
mp5 (\6\:Y \3\:C1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.13e-06 sb=1.4e-07 sd=160n sca=17.0903 scb=0.0174873 \
        scc=0.00041511 m=(1)
ends OAI222X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:41:22 2012 )
// Library name: gsclib045
// Cell name: OAI222X2
// View name: extracted

simulator lang=spectre

subckt OAI222X2 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.825e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.1227 scb=0.0199265 \
        scc=0.000804362 m=(1)
C1 (Y VSS) capacitor c=9.24036e-17
C2 (B1 VSS) capacitor c=3.88458e-17
C3 (C0 VSS) capacitor c=4.18148e-16
C4 (VDD VSS) capacitor c=1.50525e-16
C5 (A0 VSS) capacitor c=8.14642e-17
C6 (C1 VSS) capacitor c=1.05934e-16
C7 (n0 VSS) capacitor c=1.81325e-16
C8 (n1 VSS) capacitor c=1.74312e-16
C9 (2 VSS) capacitor c=4.56923e-18
C10 (4 VSS) capacitor c=4.50828e-18
C11 (5 VSS) capacitor c=4.44019e-18
C12 (6 VSS) capacitor c=1.32459e-17
C13 (7 VSS) capacitor c=2.44041e-18
C14 (8 VSS) capacitor c=2.44041e-18
C15 (\7\:C0 VSS) capacitor c=7.42508e-17
C16 (\6\:C1 VSS) capacitor c=6.58933e-17
C17 (\4\:C1 VSS) capacitor c=6.16536e-17
C18 (\1\:C0 VSS) capacitor c=7.25386e-17
C19 (\4\:B0 VSS) capacitor c=3.88045e-17
C20 (\7\:B1 VSS) capacitor c=3.01045e-17
C21 (\5\:B1 VSS) capacitor c=5.6159e-17
C22 (\1\:B0 VSS) capacitor c=4.08436e-17
C23 (\4\:A0 VSS) capacitor c=4.0626e-17
C24 (\1\:A1 VSS) capacitor c=5.58617e-17
C25 (\6\:A1 VSS) capacitor c=3.70001e-17
C26 (\1\:A0 VSS) capacitor c=2.76305e-17
C27 (\1\:C1 VSS) capacitor c=8.53519e-17
C28 (\1\:B1 VSS) capacitor c=7.55332e-17
C29 (\3\:C1 VSS) capacitor c=5.57786e-17
C30 (\2\:B0 VSS) capacitor c=3.65767e-16
C31 (\2\:A0 VSS) capacitor c=2.36952e-16
C32 (\11\:VDD VSS) capacitor c=3.25286e-17
C33 (\3\:Y VSS) capacitor c=1.78697e-16
C34 (\13\:VDD VSS) capacitor c=3.57384e-17
C35 (\5\:Y VSS) capacitor c=1.40321e-16
C36 (\15\:VDD VSS) capacitor c=4.8428e-17
C37 (\7\:Y VSS) capacitor c=1.01337e-16
C38 (\17\:VDD VSS) capacitor c=1.438e-17
C39 (\1\:VDD VSS) capacitor c=1.09869e-16
C40 (\1\:Y VSS) capacitor c=1.44634e-16
C41 (\3\:n1 VSS) capacitor c=7.83086e-17
C42 (\7\:n1 VSS) capacitor c=8.89027e-17
C43 (\5\:n0 VSS) capacitor c=1.29213e-16
C44 (\2\:A1 VSS) capacitor c=1.19857e-16
C45 (\4\:B1 VSS) capacitor c=3.1175e-17
C46 (\7\:A1 VSS) capacitor c=3.22001e-17
C47 (\9\:A1 VSS) capacitor c=4.94881e-17
C48 (\8\:B1 VSS) capacitor c=6.38039e-17
C49 (\3\:VDD VSS) capacitor c=1.12607e-18
C50 (\5\:VDD VSS) capacitor c=1.64115e-18
C51 (\7\:VDD VSS) capacitor c=1.42837e-18
C52 (\9\:VDD VSS) capacitor c=9.65167e-19
Rk1 (\7\:A1 \8\:A1) resistor r=0.0129 c=0
Rk2 (A1 \9\:A1) resistor r=0.01276 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.04398 c=0
Rk42 (\3\:VSS VSS) resistor r=0.03709 c=0
Rk37 (\2\:VSS \3\:VSS) resistor r=0.5904 c=0
Rk45 (\3\:VSS \12\:VSS) resistor r=0.2021 c=0
Rk19 (\1\:Y Y) resistor r=0.3767 c=0
Rk20 (Y \4\:Y) resistor r=0.8614 c=0
Rk21 (\4\:Y \6\:Y) resistor r=0.6011 c=0
Rk22 (\6\:Y \8\:Y) resistor r=0.7364 c=0
Rk11 (\2\:B0 B0) resistor r=0.005612 c=0
Rk6 (B1 \8\:B1) resistor r=0.1155 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.1349 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.165 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.1449 c=0
Rk27 (\5\:VDD \6\:VDD) resistor r=0.3051 c=0
Rk28 (\6\:VDD \7\:VDD) resistor r=0.3051 c=0
Rk29 (\7\:VDD \8\:VDD) resistor r=0.195 c=0
Rk31 (\9\:VDD VDD) resistor r=0.06462 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.185 c=0
Rk33 (\3\:VDD \12\:VDD) resistor r=0.2175 c=0
Rk34 (\5\:VDD \14\:VDD) resistor r=0.2175 c=0
Rk35 (\7\:VDD \16\:VDD) resistor r=0.2175 c=0
Rk36 (\9\:VDD \18\:VDD) resistor r=0.222 c=0
Rk4 (A0 \2\:A0) resistor r=0.01196 c=0
Rk12 (\7\:C1 C1) resistor r=0.00375 c=0
Rk8 (n0 \5\:n0) resistor r=0.505 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=146.132 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=105.002 c=0
Rl18 (\2\:B0 \4\:B0) resistor r=29.5379 c=0
Rl10 (\2\:B0 \1\:B0) resistor r=44.9225 c=0
Rl13 (\1\:B1 \3\:B1) resistor r=0.075 c=0
Rl17 (\4\:B1 \7\:B1) resistor r=107.256 c=0
Rl15 (\4\:B1 \5\:B1) resistor r=151.408 c=0
Rl14 (\4\:B1 \3\:B1) resistor r=3.9095 c=0
Rl29 (C0 \7\:C0) resistor r=100.539 c=0
Rl20 (C0 \1\:C0) resistor r=37.3411 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=41.0764 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.7692 c=0
Rl27 (\3\:C1 \6\:C1) resistor r=82.6695 c=0
Rl25 (\3\:C1 \4\:C1) resistor r=59.5926 c=0
Rl24 (\1\:C1 \3\:C1) resistor r=58.644 c=0
Rz18 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz16 (\1\:VDD VDD) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz14 (\1\:VDD \6\:VDD) resistor r=12.5 c=0
Rz15 (\1\:VDD \8\:VDD) resistor r=18.75 c=0
Rz6 (n1 \3\:n1) resistor r=75 c=0
Rz8 (n1 \7\:n1) resistor r=75 c=0
Ry11 (VSS \1\:VSS) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry2 (\6\:Y \5\:Y) resistor r=62 c=0
Ry3 (\8\:Y \7\:Y) resistor r=62 c=0
Ry4 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry5 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry6 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry7 (\17\:VDD \18\:VDD) resistor r=62 c=0
Rx1 (\8\:A1 \2\:A1) resistor r=45 c=0
Rx4 (\8\:B1 \3\:B1) resistor r=45 c=0
Rx7 (\7\:C1 \3\:C1) resistor r=45 c=0
mn0 (\5\:n0 \2\:A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.485e-14 ps=8e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (\5\:n0 \2\:A1 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.485e-14 ps=8.4e-07 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2 (n0 \2\:B0 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.9e-14 \
        ad=5.07e-14 ps=8.2e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.645e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn3 (n0 \1\:B1 \7\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.07e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.44e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn4 (\1\:Y C0 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.9e-14 \
        ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.03e-06 sb=7.55e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(2)
mn5 (\1\:Y \1\:C1 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp1_1__rcx (\7\:Y \6\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=15.2793 scb=0.0134932 \
        scc=0.000650526 m=(1)
mp1 (\7\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.65e-07 sb=2e-06 sd=160n sca=14.1076 scb=0.0123774 \
        scc=0.000647578 m=(1)
mp0 (4 \4\:A0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.911e-13 ad=4.485e-14 ps=1.76e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.98e-06 sd=160n sca=13.6573 \
        scb=0.0122016 scc=0.000647515 m=(1)
mp2_1__rcx (5 \1\:B0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.911e-13 ad=4.485e-14 ps=1.76e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.445e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3_1__rcx (\5\:Y \5\:B1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.285e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (\5\:Y \7\:B1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=1.08e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (6 \4\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.0725e-13 ps=1.1e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.945e-06 sb=7.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp4_1__rcx (7 \1\:C0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp5_1__rcx (\3\:Y \4\:C1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=13.5861 scb=0.0121865 \
        scc=0.000647513 m=(1)
mp5 (\3\:Y \6\:C1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.45e-07 sd=160n sca=14.1449 scb=0.0123986 scc=0.000647592 \
        m=(1)
mp4 (8 \7\:C0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.6385 scb=0.0127742 \
        scc=0.000648083 m=(1)
ends OAI222X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:42:00 2012 )
// Library name: gsclib045
// Cell name: OAI222X4
// View name: extracted

simulator lang=spectre

subckt OAI222X4 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0_1__rcx (2 \1\:A0 \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.1864 scb=0.011023 \
        scc=0.000312795 m=(1)
C1 (A1 VSS) capacitor c=2.44607e-17
C2 (Y VSS) capacitor c=6.41138e-17
C3 (B0 VSS) capacitor c=6.42476e-16
C4 (B1 VSS) capacitor c=2.7207e-17
C5 (C0 VSS) capacitor c=6.18321e-16
C6 (VDD VSS) capacitor c=3.18732e-16
C7 (A0 VSS) capacitor c=6.01775e-16
C8 (C1 VSS) capacitor c=4.42074e-16
C9 (n0 VSS) capacitor c=3.50317e-16
C10 (n1 VSS) capacitor c=5.85495e-16
C11 (4 VSS) capacitor c=3.21829e-18
C12 (5 VSS) capacitor c=1.75543e-18
C13 (6 VSS) capacitor c=1.75543e-18
C14 (7 VSS) capacitor c=4.6408e-18
C15 (8 VSS) capacitor c=7.42917e-18
C16 (9 VSS) capacitor c=3.36458e-18
C17 (10 VSS) capacitor c=2.48686e-18
C18 (11 VSS) capacitor c=3.31694e-18
C19 (12 VSS) capacitor c=1.75543e-18
C20 (13 VSS) capacitor c=1.90172e-18
C21 (14 VSS) capacitor c=1.75543e-18
C22 (\12\:C0 VSS) capacitor c=6.12135e-17
C23 (\11\:C1 VSS) capacitor c=6.59453e-17
C24 (\10\:C1 VSS) capacitor c=6.90885e-17
C25 (\9\:C0 VSS) capacitor c=5.40528e-17
C26 (\7\:C0 VSS) capacitor c=7.56842e-17
C27 (\5\:C1 VSS) capacitor c=6.81891e-17
C28 (\4\:C1 VSS) capacitor c=4.10045e-17
C29 (\1\:C0 VSS) capacitor c=5.04786e-17
C30 (\12\:B0 VSS) capacitor c=6.00994e-17
C31 (\7\:B1 VSS) capacitor c=5.32037e-17
C32 (\12\:B1 VSS) capacitor c=4.38765e-17
C33 (\4\:B0 VSS) capacitor c=3.9606e-17
C34 (\9\:B0 VSS) capacitor c=2.37506e-17
C35 (\1\:B1 VSS) capacitor c=3.02428e-17
C36 (\6\:B1 VSS) capacitor c=3.67063e-17
C37 (\1\:B0 VSS) capacitor c=3.50823e-17
C38 (\11\:A0 VSS) capacitor c=6.98637e-17
C39 (\8\:A1 VSS) capacitor c=7.12102e-17
C40 (\13\:A1 VSS) capacitor c=6.82034e-17
C41 (\4\:A0 VSS) capacitor c=6.20686e-17
C42 (\9\:A0 VSS) capacitor c=3.65448e-17
C43 (\1\:A1 VSS) capacitor c=4.97332e-17
C44 (\4\:A1 VSS) capacitor c=6.72197e-17
C45 (\1\:A0 VSS) capacitor c=8.20839e-17
C46 (\2\:B1 VSS) capacitor c=3.9882e-16
C47 (\3\:A1 VSS) capacitor c=3.66272e-16
C48 (\6\:VDD VSS) capacitor c=2.19419e-17
C49 (\7\:Y VSS) capacitor c=1.13514e-16
C50 (\8\:VDD VSS) capacitor c=2.44939e-17
C51 (\9\:Y VSS) capacitor c=1.15833e-16
C52 (\10\:VDD VSS) capacitor c=2.88155e-17
C53 (\11\:Y VSS) capacitor c=1.48796e-16
C54 (\13\:VDD VSS) capacitor c=2.6958e-17
C55 (\13\:Y VSS) capacitor c=1.39041e-16
C56 (\16\:VDD VSS) capacitor c=3.35112e-17
C57 (\15\:Y VSS) capacitor c=1.38333e-16
C58 (\20\:VDD VSS) capacitor c=2.49225e-17
C59 (\17\:Y VSS) capacitor c=7.32377e-17
C60 (\23\:VDD VSS) capacitor c=1.32934e-17
C61 (\1\:VDD VSS) capacitor c=5.16037e-17
C62 (\1\:Y VSS) capacitor c=3.07376e-16
C63 (\9\:n0 VSS) capacitor c=2.65164e-16
C64 (\2\:A1 VSS) capacitor c=5.51285e-17
C65 (\3\:VDD VSS) capacitor c=1.5271e-17
C66 (\4\:VDD VSS) capacitor c=2.8024e-17
C67 (\12\:VDD VSS) capacitor c=3.68168e-17
C68 (\15\:VDD VSS) capacitor c=3.0981e-17
C69 (\19\:VDD VSS) capacitor c=1.4325e-17
C70 (\22\:VDD VSS) capacitor c=1.95112e-17
Rk3 (\3\:A1 A1) resistor r=0.009916 c=0
Rk61 (\2\:VSS \3\:VSS) resistor r=0.9016 c=0
Rk72 (\4\:VSS VSS) resistor r=0.02209 c=0
Rk62 (\3\:VSS \4\:VSS) resistor r=0.6084 c=0
Rk29 (\1\:Y Y) resistor r=0.1729 c=0
Rk30 (Y \8\:Y) resistor r=0.5304 c=0
Rk31 (\8\:Y \10\:Y) resistor r=0.4577 c=0
Rk32 (\10\:Y \12\:Y) resistor r=0.5482 c=0
Rk33 (\12\:Y \14\:Y) resistor r=0.627 c=0
Rk34 (\14\:Y \16\:Y) resistor r=0.6475 c=0
Rk35 (\16\:Y \18\:Y) resistor r=0.4908 c=0
Rk9 (\2\:B1 B1) resistor r=0.01977 c=0
Rk45 (\2\:VDD \3\:VDD) resistor r=0.07995 c=0
Rk46 (\3\:VDD \4\:VDD) resistor r=0.3127 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.3579 c=0
Rk48 (\3\:VDD \7\:VDD) resistor r=0.1846 c=0
Rk49 (\4\:VDD \9\:VDD) resistor r=0.1846 c=0
Rk50 (\5\:VDD \11\:VDD) resistor r=0.2307 c=0
Rk51 (\5\:VDD \12\:VDD) resistor r=0.3736 c=0
Rk52 (\12\:VDD \14\:VDD) resistor r=0.1846 c=0
Rk53 (\12\:VDD \15\:VDD) resistor r=0.5506 c=0
Rk54 (\15\:VDD \17\:VDD) resistor r=0.1846 c=0
Rk55 (\15\:VDD \18\:VDD) resistor r=0.2778 c=0
Rk56 (\18\:VDD \19\:VDD) resistor r=0.03236 c=0
Rk57 (\19\:VDD \21\:VDD) resistor r=0.1846 c=0
Rk60 (\22\:VDD VDD) resistor r=0.1974 c=0
Rk58 (\19\:VDD \22\:VDD) resistor r=0.3202 c=0
Rk59 (\22\:VDD \24\:VDD) resistor r=0.1892 c=0
Rk13 (n0 \9\:n0) resistor r=0.4089 c=0
Rl15 (\3\:A1 \8\:A1) resistor r=119.539 c=0
Rl19 (\3\:A1 \13\:A1) resistor r=87.4359 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=124.484 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=80.3332 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=3.9095 c=0
Rl40 (B0 \12\:B0) resistor r=70.3297 c=0
Rl29 (B0 \4\:B0) resistor r=67.2856 c=0
Rl33 (B0 \9\:B0) resistor r=22.4021 c=0
Rl22 (B0 \1\:B0) resistor r=29.5379 c=0
Rl34 (\2\:B1 \7\:B1) resistor r=83.8489 c=0
Rl38 (\2\:B1 \12\:B1) resistor r=83.4251 c=0
Rl24 (\2\:B1 \1\:B1) resistor r=83.4251 c=0
Rl28 (\2\:B1 \6\:B1) resistor r=83.8489 c=0
Rl58 (C0 \12\:C0) resistor r=24.7951 c=0
Rl51 (C0 \9\:C0) resistor r=28.7343 c=0
Rl49 (C0 \7\:C0) resistor r=74.6548 c=0
Rl41 (C0 \1\:C0) resistor r=64.1533 c=0
Rl20 (A0 \11\:A0) resistor r=69.9225 c=0
Rl9 (A0 \4\:A0) resistor r=67.9002 c=0
Rl13 (A0 \9\:A0) resistor r=33.6242 c=0
Rl1 (A0 \1\:A0) resistor r=119.208 c=0
Rl56 (C1 \11\:C1) resistor r=75.2936 c=0
Rl55 (C1 \10\:C1) resistor r=120.873 c=0
Rl46 (C1 \5\:C1) resistor r=94.6378 c=0
Rl45 (C1 \4\:C1) resistor r=114.708 c=0
Rz22 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz23 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz24 (\1\:VDD \18\:VDD) resistor r=6.25 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\4\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry1 (\8\:Y \7\:Y) resistor r=62 c=0
Ry2 (\10\:Y \9\:Y) resistor r=62 c=0
Ry3 (\12\:Y \11\:Y) resistor r=62 c=0
Ry4 (\14\:Y \13\:Y) resistor r=62 c=0
Ry5 (\16\:Y \15\:Y) resistor r=62 c=0
Ry6 (\18\:Y \17\:Y) resistor r=62 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry11 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry12 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry13 (\23\:VDD \24\:VDD) resistor r=62 c=0
mn0_1__rcx (\9\:n0 A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn1_1__rcx (\9\:n0 \3\:A1 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn2_1__rcx (n0 B0 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.03e-14 \
        ad=4.388e-14 ps=8.3e-07 pd=8.575e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn3_1__rcx (n0 \2\:B1 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.388e-14 ps=8.4e-07 pd=8.575e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mn4_1__rcx (\1\:Y C0 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn5_1__rcx (\1\:Y C1 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
mp1_1__rcx (\17\:Y \4\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.592 scb=0.010475 \
        scc=0.000311666 m=(1)
mp1 (\17\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=6.24e-14 ps=1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=2e-06 sd=160n sca=11.9394 scb=0.0101617 scc=0.000311483 m=(1)
mp0 (4 \9\:A0 \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.29e-14 ps=1.1e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp0_2__rcx (5 \4\:A0 \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp1_2__rcx (\15\:Y \13\:A1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp1_3__rcx (\15\:Y \8\:A1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp0_3__rcx (6 \11\:A0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=2.34e-14 ps=1.5e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=2e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp2_1__rcx (7 \1\:B0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=6.24e-14 ps=1.5e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3_1__rcx (\13\:Y \6\:B1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp3_2__rcx (\13\:Y \1\:B1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp2_2__rcx (8 \9\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.36e-14 ps=1.1e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp2 (9 \4\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.485e-14 ps=1.1e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3 (\11\:Y \12\:B1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.86e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3_3__rcx (\11\:Y \7\:B1 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.315e-14 ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.655e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp2_3__rcx (10 \12\:B0 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.165e-14 ad=3.315e-14 ps=1.25e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.525e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp4_1__rcx (11 \1\:C0 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.165e-14 ad=4.875e-14 ps=1.25e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.245e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5_1__rcx (\9\:Y \4\:C1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.075e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5 (\9\:Y \5\:C1 12 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=8.7e-07 sd=160n sca=11.8275 scb=0.0101379 scc=0.000311481 m=(1)
mp5_3__rcx (\7\:Y \11\:C1 14 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=12.9282 scb=0.0107566 \
        scc=0.000312107 m=(1)
mp4 (12 \7\:C0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.65e-07 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp4_3__rcx (14 \12\:C0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.7232 scb=0.0116925 \
        scc=0.000315829 m=(1)
mp4_2__rcx (13 \9\:C0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.535e-14 ps=1.1e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.6e-07 sd=160n sca=11.8465 scb=0.0101414 \
        scc=0.000311481 m=(1)
mp5_2__rcx (\7\:Y \10\:C1 13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.535e-14 ad=6.24e-14 ps=9.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=12.099 scb=0.0102099 \
        scc=0.000311493 m=(1)
ends OAI222X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:22:48 2012 )
// Library name: gsclib045
// Cell name: OAI222XL
// View name: extracted

simulator lang=spectre

subckt OAI222XL A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=18.9152 \
        scb=0.020298 scc=0.000602167 m=(1)
C1 (A0 VSS) capacitor c=1.6562e-17
C2 (B0 VSS) capacitor c=8.60494e-17
C3 (C1 VSS) capacitor c=4.01545e-17
C4 (Y VSS) capacitor c=7.07863e-17
C5 (C0 VSS) capacitor c=5.0151e-17
C6 (VDD VSS) capacitor c=1.7419e-16
C7 (n0 VSS) capacitor c=9.73681e-17
C8 (n1 VSS) capacitor c=9.57211e-17
C9 (n3 VSS) capacitor c=3.04162e-18
C10 (n4 VSS) capacitor c=1.35183e-18
C11 (\3\:C1 VSS) capacitor c=7.01833e-17
C12 (\1\:C0 VSS) capacitor c=7.43524e-17
C13 (\3\:B0 VSS) capacitor c=5.13574e-17
C14 (\1\:B1 VSS) capacitor c=3.77975e-17
C15 (\1\:A1 VSS) capacitor c=6.94768e-17
C16 (\1\:A0 VSS) capacitor c=4.80177e-17
C17 (\1\:C1 VSS) capacitor c=3.0848e-17
C18 (\3\:C0 VSS) capacitor c=3.61428e-17
C19 (\1\:B0 VSS) capacitor c=3.58932e-17
C20 (\3\:B1 VSS) capacitor c=4.45788e-17
C21 (\3\:A1 VSS) capacitor c=3.65323e-17
C22 (\3\:A0 VSS) capacitor c=4.68054e-17
C23 (\2\:C1 VSS) capacitor c=6.62292e-17
C24 (\2\:C0 VSS) capacitor c=7.17833e-17
C25 (\2\:B0 VSS) capacitor c=6.01441e-17
C26 (\2\:B1 VSS) capacitor c=5.13752e-17
C27 (\2\:A1 VSS) capacitor c=4.4655e-17
C28 (\2\:A0 VSS) capacitor c=5.5328e-17
C29 (\3\:Y VSS) capacitor c=7.36874e-17
C30 (\1\:VDD VSS) capacitor c=3.81778e-17
C31 (\5\:Y VSS) capacitor c=1.03638e-16
C32 (\7\:VDD VSS) capacitor c=1.96885e-17
C33 (\3\:VDD VSS) capacitor c=4.02758e-17
C34 (\5\:n1 VSS) capacitor c=7.00787e-17
C35 (\1\:Y VSS) capacitor c=1.0539e-16
C36 (\3\:n1 VSS) capacitor c=1.13791e-16
C37 (\3\:n0 VSS) capacitor c=5.98786e-17
C38 (\4\:A0 VSS) capacitor c=2.21635e-17
C39 (\5\:A1 VSS) capacitor c=1.34572e-17
C40 (\6\:A1 VSS) capacitor c=3.71958e-17
C41 (\4\:B1 VSS) capacitor c=8.25153e-17
C42 (\6\:B1 VSS) capacitor c=4.10578e-17
C43 (\4\:B0 VSS) capacitor c=4.46002e-17
C44 (\4\:C0 VSS) capacitor c=7.07e-17
C45 (\4\:C1 VSS) capacitor c=7.43981e-17
Rk1 (A0 \4\:A0) resistor r=0.03137 c=0
Rk9 (\4\:B0 B0) resistor r=0.01901 c=0
Rk5 (\4\:B1 \5\:B1) resistor r=0.002784 c=0
Rk6 (B1 \6\:B1) resistor r=0.002691 c=0
Rk7 (\4\:B1 \6\:B1) resistor r=0.02706 c=0
Rk11 (C1 \4\:C1) resistor r=0.1316 c=0
Rk12 (\2\:Y Y) resistor r=0.6481 c=0
Rk13 (Y \4\:Y) resistor r=0.04934 c=0
Rk14 (\4\:Y \6\:Y) resistor r=0.5229 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.3012 c=0
Rk24 (\4\:VSS VSS) resistor r=0.1003 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.1006 c=0
Rk26 (\3\:VSS \7\:VSS) resistor r=0.1201 c=0
Rk27 (VSS \9\:VSS) resistor r=0.1008 c=0
Rk10 (C0 \4\:C0) resistor r=0.1479 c=0
Rk2 (\4\:A1 \5\:A1) resistor r=0.004738 c=0
Rk3 (\6\:A1 A1) resistor r=0.004738 c=0
Rk4 (\5\:A1 \6\:A1) resistor r=0.03868 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.2171 c=0
Rk19 (\5\:VDD VDD) resistor r=0.02964 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.3709 c=0
Rk21 (\5\:VDD \8\:VDD) resistor r=0.224 c=0
Rk8 (\2\:n0 \4\:n0) resistor r=0.6051 c=0
Rk15 (\2\:n1 \4\:n1) resistor r=0.4682 c=0
Rk16 (\4\:n1 \6\:n1) resistor r=0.4818 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=163.257 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=129.538 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=74.9799 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=59.6085 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=142.301 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=136.146 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=78.8462 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=133.79 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=66.4826 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=127.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=79.5379 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz10 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz6 (\5\:n1 \6\:n1) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry8 (\1\:VSS VSS) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry6 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \5\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.09e-14 ad=2.32e-14 ps=1.35e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn1 (\3\:n0 \3\:A1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.09e-14 ad=2.32e-14 ps=1.35e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn3 (n0 \3\:B1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.85e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (n0 \1\:B0 \3\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.392e-14 ps=6.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.5e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn5 (\1\:Y \1\:C1 \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mp1 (\5\:Y \1\:A1 n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.88e-14 ps=5.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.045e-06 sd=160n sca=14.7404 \
        scb=0.0134098 scc=0.000165408 m=(1)
mp3 (\5\:Y \1\:B1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.88e-14 ps=7e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.8e-07 sd=160n sca=11.0531 \
        scb=0.00777426 scc=8.06272e-05 m=(1)
mp2 (n3 \3\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.903e-14 ps=8.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5e-07 sd=160n sca=11.1457 scb=0.00788341 \
        scc=8.07632e-05 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=1.29e-14 ps=8.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2.45e-07 sd=160n sca=13.3848 \
        scb=0.0110305 scc=0.000107196 m=(1)
mp5 (\3\:Y \3\:C1 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=15.9357 \
        scb=0.0155108 scc=0.000251633 m=(1)
ends OAI222XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:43:14 2012 )
// Library name: gsclib045
// Cell name: OAI22X1
// View name: extracted

simulator lang=spectre

subckt OAI22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (net93 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.383 \
        scb=0.0290112 scc=0.00169816 m=(1)
C1 (A0 VSS) capacitor c=4.14832e-17
C2 (B0 VSS) capacitor c=3.46645e-17
C3 (B1 VSS) capacitor c=3.99164e-17
C4 (A1 VSS) capacitor c=4.45412e-17
C5 (VDD VSS) capacitor c=8.15359e-17
C6 (net102 VSS) capacitor c=8.50022e-17
C7 (net93 VSS) capacitor c=2.01834e-18
C8 (net85 VSS) capacitor c=8.01381e-18
C9 (\3\:B0 VSS) capacitor c=4.54577e-17
C10 (\1\:B1 VSS) capacitor c=4.19834e-17
C11 (\3\:A1 VSS) capacitor c=4.77153e-17
C12 (\1\:A0 VSS) capacitor c=5.36755e-17
C13 (\4\:B0 VSS) capacitor c=3.60007e-17
C14 (\3\:B1 VSS) capacitor c=5.07066e-17
C15 (\1\:A1 VSS) capacitor c=5.41832e-17
C16 (\4\:A0 VSS) capacitor c=4.21436e-17
C17 (\1\:B0 VSS) capacitor c=1.25535e-17
C18 (\2\:B1 VSS) capacitor c=4.87335e-17
C19 (\2\:A1 VSS) capacitor c=4.90749e-17
C20 (\3\:A0 VSS) capacitor c=1.3562e-17
C21 (\1\:VDD VSS) capacitor c=4.12684e-17
C22 (\3\:Y VSS) capacitor c=1.22083e-16
C23 (\5\:VDD VSS) capacitor c=3.42722e-17
C24 (\1\:Y VSS) capacitor c=1.16131e-16
C25 (\3\:net102 VSS) capacitor c=1.07935e-16
C26 (\5\:net102 VSS) capacitor c=6.59145e-17
C27 (\2\:A0 VSS) capacitor c=2.67035e-17
C28 (\2\:B0 VSS) capacitor c=3.06143e-17
C29 (\5\:A0 VSS) capacitor c=4.1225e-17
C30 (\4\:A1 VSS) capacitor c=5.77929e-17
C31 (\4\:B1 VSS) capacitor c=5.68041e-17
C32 (\5\:B0 VSS) capacitor c=4.28572e-17
C33 (\4\:VDD VSS) capacitor c=2.95176e-17
Rk1 (A0 \5\:A0) resistor r=0.08512 c=0
Rk6 (B0 \5\:B0) resistor r=0.1139 c=0
Rk3 (B1 \4\:B1) resistor r=0.1438 c=0
Rk5 (\4\:Y Y) resistor r=0.0929 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.6176 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.263 c=0
Rk14 (\4\:VSS VSS) resistor r=0.04988 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.0374 c=0
Rk15 (\3\:VSS \6\:VSS) resistor r=0.2896 c=0
Rk2 (A1 \4\:A1) resistor r=0.1199 c=0
Rk10 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk9 (\2\:VDD \4\:VDD) resistor r=0.3927 c=0
Rk11 (VDD \6\:VDD) resistor r=0.2386 c=0
Rk7 (\2\:net102 \4\:net102) resistor r=0.5941 c=0
Rk8 (\4\:net102 \6\:net102) resistor r=0.4267 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=106.572 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=41.1873 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=8.9604 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=70.7981 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=64.7092 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=2.0623 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=24.2328 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=105.002 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=105.746 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (net102 \2\:net102) resistor r=37.5 c=0
Rz3 (\3\:net102 \4\:net102) resistor r=37.5 c=0
Rz4 (\5\:net102 \6\:net102) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\5\:net102 \4\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=3.64e-14 ps=1.48e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\3\:net102 \1\:A1 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=4.81e-14 ps=1.48e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\1\:Y \3\:B1 \3\:net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.16e-14 ps=8.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\1\:Y \4\:B0 net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp1 (\3\:Y \3\:A1 net93 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=8.97e-14 ps=1.01e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=5.95e-07 sd=160n sca=16.6664 scb=0.0162415 \
        scc=0.000384527 m=(1)
mp3 (\3\:Y \1\:B1 net85 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.97e-14 ps=1.05e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.2e-07 sd=160n sca=14.4478 \
        scb=0.0118157 scc=0.000294931 m=(1)
mp2 (net85 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.265e-14 ps=1.06e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=16.2261 \
        scb=0.0153801 scc=0.000356933 m=(1)
ends OAI22X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:43:53 2012 )
// Library name: gsclib045
// Cell name: OAI22X2
// View name: extracted

simulator lang=spectre

subckt OAI22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (2 \1\:A0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.445e-06 sd=160n sca=19.9512 \
        scb=0.0180582 scc=0.00139447 m=(1)
C1 (B1 VSS) capacitor c=7.20286e-17
C2 (Y VSS) capacitor c=1.90625e-17
C3 (A0 VSS) capacitor c=3.39302e-16
C4 (VDD VSS) capacitor c=8.74915e-17
C5 (A1 VSS) capacitor c=5.93108e-17
C6 (B0 VSS) capacitor c=3.56248e-16
C7 (net102 VSS) capacitor c=1.01481e-16
C8 (4 VSS) capacitor c=2.01268e-18
C9 (5 VSS) capacitor c=6.16192e-18
C10 (\7\:B0 VSS) capacitor c=7.92081e-17
C11 (\1\:B1 VSS) capacitor c=5.68696e-17
C12 (\5\:B1 VSS) capacitor c=3.74892e-17
C13 (\4\:B0 VSS) capacitor c=4.51515e-17
C14 (\4\:A0 VSS) capacitor c=8.99397e-17
C15 (\1\:A1 VSS) capacitor c=7.78032e-17
C16 (\5\:A1 VSS) capacitor c=5.78383e-17
C17 (\1\:A0 VSS) capacitor c=9.07131e-17
C18 (\2\:B1 VSS) capacitor c=3.66058e-17
C19 (\2\:A1 VSS) capacitor c=2.14537e-17
C20 (\1\:VDD VSS) capacitor c=4.80027e-17
C21 (\1\:Y VSS) capacitor c=6.5833e-17
C22 (\9\:VDD VSS) capacitor c=3.72327e-17
C23 (\8\:Y VSS) capacitor c=5.05405e-17
C24 (\11\:VDD VSS) capacitor c=2.76476e-17
C25 (\3\:VDD VSS) capacitor c=4.6528e-17
C26 (\7\:net102 VSS) capacitor c=7.65995e-17
C27 (\4\:Y VSS) capacitor c=2.10516e-16
C28 (\3\:A1 VSS) capacitor c=1.12048e-16
C29 (\3\:B1 VSS) capacitor c=9.1917e-17
C30 (\7\:A1 VSS) capacitor c=5.65082e-17
C31 (\3\:Y VSS) capacitor c=6.91694e-17
C32 (\7\:B1 VSS) capacitor c=4.65564e-17
C33 (\2\:net102 VSS) capacitor c=1.58991e-16
C34 (\5\:VDD VSS) capacitor c=6.96026e-18
Rk11 (B1 \7\:B1) resistor r=0.2077 c=0
Rk7 (\3\:Y Y) resistor r=0.04356 c=0
Rk5 (\3\:Y \4\:Y) resistor r=0.4825 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.4284 c=0
Rk8 (Y \9\:Y) resistor r=0.2428 c=0
Rk26 (\3\:VSS VSS) resistor r=0.09729 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.5316 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.2604 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.1401 c=0
Rk19 (\6\:VDD \7\:VDD) resistor r=0.1702 c=0
Rk21 (\8\:VDD VDD) resistor r=0.04987 c=0
Rk20 (\7\:VDD \8\:VDD) resistor r=0.08 c=0
Rk22 (\5\:VDD \10\:VDD) resistor r=0.2562 c=0
Rk23 (\7\:VDD \12\:VDD) resistor r=0.2562 c=0
Rk1 (\7\:A1 A1) resistor r=0.2826 c=0
Rl14 (\2\:B1 \1\:B1) resistor r=21.9779 c=0
Rl17 (\2\:B1 \5\:B1) resistor r=77.1158 c=0
Rl15 (\3\:B1 \2\:B1) resistor r=65.8294 c=0
Rl8 (A0 \4\:A0) resistor r=104.827 c=0
Rl1 (A0 \1\:A0) resistor r=151.489 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=84.7158 c=0
Rl6 (\2\:A1 \5\:A1) resistor r=36.8321 c=0
Rl4 (\3\:A1 \2\:A1) resistor r=3.2713 c=0
Rl20 (B0 \7\:B0) resistor r=95.3297 c=0
Rl13 (B0 \4\:B0) resistor r=52.7257 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz9 (\3\:VDD \6\:VDD) resistor r=25 c=0
Rz10 (\3\:VDD \8\:VDD) resistor r=37.5 c=0
Rz3 (\2\:net102 net102) resistor r=75 c=0
Rz6 (\2\:net102 \7\:net102) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=31 c=0
Ry2 (\9\:Y \8\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Rx6 (\7\:B1 \2\:B1) resistor r=45 c=0
Rx1 (\7\:A1 \2\:A1) resistor r=45 c=0
mn0 (\2\:net102 A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.225e-14 ps=8.7e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.615e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn1 (net102 \3\:A1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.395e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2 (\4\:Y B0 \2\:net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=7.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn3 (\4\:Y \3\:B1 \7\:net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp1 (\8\:Y \5\:A1 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.34e-06 sd=160n sca=18.8244 scb=0.0164205 \
        scc=0.00138121 m=(1)
mp1_1__rcx (\8\:Y \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.135e-06 sd=160n sca=17.7255 \
        scb=0.0154354 scc=0.00137898 m=(1)
mp0_1__rcx (4 \4\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.03e-06 sd=160n sca=17.42 \
        scb=0.0153123 scc=0.00137893 m=(1)
mp2_1__rcx (5 \4\:B0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.995e-14 ps=1.1e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=8.25e-07 sd=160n sca=17.3286 \
        scb=0.0152882 scc=0.00137893 m=(1)
mp3_1__rcx (\1\:Y \5\:B1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=5.75e-07 sd=160n sca=18.1728 \
        scb=0.0157393 scc=0.00137928 m=(1)
mp3 (\1\:Y \1\:B1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.215e-06 sb=3.7e-07 sd=160n sca=19.9512 scb=0.0180582 \
        scc=0.00139447 m=(1)
mp2 (6 \7\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=2.34e-14 ps=1.31e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=2.65e-07 sd=160n sca=22.0353 \
        scb=0.0216797 scc=0.00148017 m=(1)
ends OAI22X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:44:32 2012 )
// Library name: gsclib045
// Cell name: OAI22X4
// View name: extracted

simulator lang=spectre

subckt OAI22X4 A0 A1 B0 B1 VDD VSS Y
mp0 (3 \1\:A0 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.2882 scb=0.0164375 \
        scc=0.00159648 m=(1)
C1 (A1 VSS) capacitor c=4.6309e-16
C2 (B0 VSS) capacitor c=3.15993e-17
C3 (B1 VSS) capacitor c=4.32296e-16
C4 (Y VSS) capacitor c=1.52736e-17
C5 (VDD VSS) capacitor c=1.25618e-16
C6 (A0 VSS) capacitor c=5.34906e-16
C7 (net102 VSS) capacitor c=5.89642e-16
C8 (5 VSS) capacitor c=2.0348e-18
C9 (6 VSS) capacitor c=3.88442e-18
C10 (7 VSS) capacitor c=2.28185e-18
C11 (8 VSS) capacitor c=3.92748e-18
C12 (9 VSS) capacitor c=2.02598e-18
C13 (10 VSS) capacitor c=2.21173e-18
C14 (\13\:B0 VSS) capacitor c=1.08603e-16
C15 (\12\:B1 VSS) capacitor c=5.98972e-17
C16 (\10\:B1 VSS) capacitor c=7.76411e-17
C17 (\10\:B0 VSS) capacitor c=6.87409e-17
C18 (\8\:B0 VSS) capacitor c=7.37935e-17
C19 (\6\:B1 VSS) capacitor c=5.85587e-17
C20 (\4\:B1 VSS) capacitor c=4.7495e-17
C21 (\1\:B0 VSS) capacitor c=6.03361e-17
C22 (\11\:A0 VSS) capacitor c=7.37691e-17
C23 (\7\:A1 VSS) capacitor c=6.55253e-17
C24 (\11\:A1 VSS) capacitor c=3.66479e-17
C25 (\4\:A0 VSS) capacitor c=5.51248e-17
C26 (\6\:A0 VSS) capacitor c=7.00635e-17
C27 (\1\:A1 VSS) capacitor c=7.73929e-17
C28 (\5\:A1 VSS) capacitor c=5.85745e-17
C29 (\1\:A0 VSS) capacitor c=1.17601e-16
C30 (\2\:B0 VSS) capacitor c=5.51573e-16
C31 (\11\:VDD VSS) capacitor c=4.01264e-17
C32 (\21\:Y VSS) capacitor c=9.16035e-17
C33 (\13\:VDD VSS) capacitor c=4.10758e-17
C34 (\18\:Y VSS) capacitor c=5.96711e-17
C35 (\15\:VDD VSS) capacitor c=2.91263e-17
C36 (\11\:Y VSS) capacitor c=2.73702e-17
C37 (\17\:VDD VSS) capacitor c=4.53487e-17
C38 (\15\:Y VSS) capacitor c=4.54754e-17
C39 (\19\:VDD VSS) capacitor c=3.83841e-17
C40 (\1\:VDD VSS) capacitor c=5.61733e-17
C41 (\1\:Y VSS) capacitor c=4.3253e-16
C42 (\7\:B0 VSS) capacitor c=3.85415e-17
C43 (\9\:Y VSS) capacitor c=5.76625e-17
C44 (\10\:Y VSS) capacitor c=5.65951e-17
C45 (\13\:Y VSS) capacitor c=2.1983e-17
C46 (\14\:Y VSS) capacitor c=4.93444e-17
C47 (\3\:VDD VSS) capacitor c=1.33203e-17
C48 (\4\:VDD VSS) capacitor c=1.8339e-17
C49 (\6\:VDD VSS) capacitor c=1.87004e-17
Rk25 (\2\:B0 B0) resistor r=0.08407 c=0
Rk11 (\1\:Y \9\:Y) resistor r=0.6175 c=0
Rk12 (\9\:Y \10\:Y) resistor r=0.2661 c=0
Rk13 (\10\:Y \12\:Y) resistor r=0.05031 c=0
Rk15 (\13\:Y Y) resistor r=0.03891 c=0
Rk14 (\9\:Y \13\:Y) resistor r=0.1352 c=0
Rk16 (\10\:Y \14\:Y) resistor r=0.4505 c=0
Rk17 (\14\:Y \16\:Y) resistor r=0.05702 c=0
Rk18 (\10\:Y \17\:Y) resistor r=0.1099 c=0
Rk19 (\13\:Y \19\:Y) resistor r=0.2419 c=0
Rk20 (\14\:Y \20\:Y) resistor r=0.1166 c=0
Rk21 (\19\:Y \22\:Y) resistor r=0.4349 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.1174 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.3249 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.2075 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.2025 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.3675 c=0
Rk39 (\7\:VDD \8\:VDD) resistor r=0.1299 c=0
Rk40 (\8\:VDD \9\:VDD) resistor r=0.165 c=0
Rk42 (\10\:VDD VDD) resistor r=0.09985 c=0
Rk41 (\9\:VDD \10\:VDD) resistor r=0.1349 c=0
Rk43 (\3\:VDD \12\:VDD) resistor r=0.351 c=0
Rk44 (\4\:VDD \14\:VDD) resistor r=0.2572 c=0
Rk45 (\6\:VDD \16\:VDD) resistor r=0.1778 c=0
Rk46 (\7\:VDD \18\:VDD) resistor r=0.2572 c=0
Rk47 (\9\:VDD \20\:VDD) resistor r=0.351 c=0
Rk56 (\1\:VSS VSS) resistor r=0.0498 c=0
Rl12 (A1 \7\:A1) resistor r=106.514 c=0
Rl15 (A1 \11\:A1) resistor r=25.3108 c=0
Rl3 (A1 \1\:A1) resistor r=82.6695 c=0
Rl6 (A1 \5\:A1) resistor r=24.7951 c=0
Rl38 (\2\:B0 \13\:B0) resistor r=163.4 c=0
Rl19 (\2\:B0 \1\:B0) resistor r=91.0764 c=0
Rl31 (\7\:B0 \10\:B0) resistor r=85.0356 c=0
Rl29 (\7\:B0 \8\:B0) resistor r=123.107 c=0
Rl28 (\7\:B0 \2\:B0) resistor r=3.8223 c=0
Rl36 (B1 \12\:B1) resistor r=27.0846 c=0
Rl34 (B1 \10\:B1) resistor r=76.8424 c=0
Rl25 (B1 \6\:B1) resistor r=27.0846 c=0
Rl23 (B1 \4\:B1) resistor r=76.8424 c=0
Rl18 (A0 \11\:A0) resistor r=93.4636 c=0
Rl8 (A0 \4\:A0) resistor r=141.129 c=0
Rl9 (A0 \6\:A0) resistor r=94.5244 c=0
Rl1 (A0 \1\:A0) resistor r=237.546 c=0
Rz14 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz15 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Rz16 (\1\:VDD \8\:VDD) resistor r=25 c=0
Rz17 (\1\:VDD \10\:VDD) resistor r=25 c=0
Ry1 (\12\:Y \11\:Y) resistor r=62 c=0
Ry2 (\16\:Y \15\:Y) resistor r=62 c=0
Ry3 (\17\:Y \11\:Y) resistor r=62 c=0
Ry4 (\19\:Y \18\:Y) resistor r=62 c=0
Ry5 (\20\:Y \15\:Y) resistor r=62 c=0
Ry6 (\22\:Y \21\:Y) resistor r=20.6667 c=0
Ry7 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry8 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry9 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry10 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\19\:VDD \20\:VDD) resistor r=20.6667 c=0
mn0_1__rcx (net102 A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.55e-14 ps=1.35e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn1_1__rcx (net102 A1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.16e-14 ps=1.35e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn2_1__rcx (\1\:Y \2\:B0 net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn3_1__rcx (\1\:Y B1 net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp1 (\15\:Y \5\:A1 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=18.8494 scb=0.0161462 \
        scc=0.00159619 m=(1)
mp1_1__rcx (\15\:Y \1\:A1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp0_1__rcx (5 \6\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp1_2__rcx (\11\:Y \11\:A1 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=1.94e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp0_2__rcx (6 \4\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp1_3__rcx (\11\:Y \7\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=6.24e-14 ps=9.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.735e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp0_3__rcx (7 \11\:A0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4115e-13 ad=3.12e-14 ps=1.67e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.61e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp2_1__rcx (8 \1\:B0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4115e-13 ad=4.875e-14 ps=1.67e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.24e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3_2__rcx (\18\:Y \6\:B1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp3_1__rcx (\18\:Y \4\:B1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.07e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp2_2__rcx (9 \8\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(1)
mp2_3__rcx (10 \10\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=18.3986 scb=0.0159927 \
        scc=0.00159615 m=(1)
mp3_3__rcx (\21\:Y \10\:B1 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=18.6377 scb=0.0160565 \
        scc=0.00159616 m=(1)
mp3 (\21\:Y \12\:B1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=19.4511 scb=0.0165805 \
        scc=0.00159672 m=(1)
mp2 (11 \13\:B0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.2277 scb=0.017479 \
        scc=0.00160012 m=(1)
ends OAI22X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:45:10 2012 )
// Library name: gsclib045
// Cell name: OAI22XL
// View name: extracted

simulator lang=spectre

subckt OAI22XL A0 A1 B0 B1 VDD VSS Y
mp0 (net93 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.472e-14 ps=7.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=24.4755 \
        scb=0.0279779 scc=0.00151773 m=(1)
C1 (A0 VSS) capacitor c=9.93003e-17
C2 (B0 VSS) capacitor c=4.39472e-17
C3 (B1 VSS) capacitor c=5.35099e-17
C4 (Y VSS) capacitor c=8.79193e-17
C5 (A1 VSS) capacitor c=8.24578e-17
C6 (VDD VSS) capacitor c=8.32114e-17
C7 (net102 VSS) capacitor c=6.19853e-17
C8 (net85 VSS) capacitor c=6.83633e-18
C9 (\3\:B0 VSS) capacitor c=4.02791e-17
C10 (\1\:B1 VSS) capacitor c=3.74484e-17
C11 (\3\:A1 VSS) capacitor c=5.53813e-17
C12 (\1\:A0 VSS) capacitor c=4.96561e-17
C13 (\1\:B0 VSS) capacitor c=2.52331e-17
C14 (\3\:B1 VSS) capacitor c=4.42904e-17
C15 (\1\:A1 VSS) capacitor c=3.40914e-17
C16 (\4\:A0 VSS) capacitor c=3.46616e-17
C17 (\2\:B0 VSS) capacitor c=4.58902e-17
C18 (\2\:B1 VSS) capacitor c=4.61434e-17
C19 (\2\:A1 VSS) capacitor c=5.81634e-17
C20 (\3\:A0 VSS) capacitor c=1.44156e-17
C21 (\7\:VDD VSS) capacitor c=2.30745e-17
C22 (\3\:Y VSS) capacitor c=2.32925e-17
C23 (\5\:VDD VSS) capacitor c=2.73605e-17
C24 (\1\:VDD VSS) capacitor c=1.802e-17
C25 (\1\:Y VSS) capacitor c=9.26136e-17
C26 (\3\:net102 VSS) capacitor c=1.00915e-16
C27 (\5\:net102 VSS) capacitor c=3.88396e-17
C28 (\2\:A0 VSS) capacitor c=4.09376e-17
C29 (\4\:A1 VSS) capacitor c=4.85869e-17
C30 (\4\:B1 VSS) capacitor c=6.36778e-17
C31 (\4\:B0 VSS) capacitor c=3.67342e-17
C32 (\3\:VDD VSS) capacitor c=4.51036e-18
Rk1 (\5\:A0 A0) resistor r=0.002993 c=0
Rk6 (B0 \4\:B0) resistor r=0.2245 c=0
Rk3 (B1 \4\:B1) resistor r=0.2245 c=0
Rk4 (\2\:Y Y) resistor r=0.5695 c=0
Rk5 (Y \4\:Y) resistor r=0.08683 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.2303 c=0
Rk16 (\4\:VSS VSS) resistor r=0.04986 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.06996 c=0
Rk17 (\3\:VSS \6\:VSS) resistor r=0.07334 c=0
Rk2 (\4\:A1 A1) resistor r=0.1056 c=0
Rk9 (\2\:VDD \3\:VDD) resistor r=0.06746 c=0
Rk11 (\4\:VDD VDD) resistor r=0.2006 c=0
Rk10 (\3\:VDD \4\:VDD) resistor r=0.2328 c=0
Rk12 (VDD \6\:VDD) resistor r=0.2798 c=0
Rk13 (\3\:VDD \8\:VDD) resistor r=0.2724 c=0
Rk7 (\2\:net102 \4\:net102) resistor r=0.6324 c=0
Rk8 (\4\:net102 \6\:net102) resistor r=0.2725 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=170.868 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=43.9449 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=7.5059 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=158.791 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=40.3846 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=85.3072 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=112.23 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=153.641 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=43.3029 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz2 (net102 \2\:net102) resistor r=75 c=0
Rz3 (\3\:net102 \4\:net102) resistor r=75 c=0
Rz4 (\5\:net102 \6\:net102) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry2 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=62 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\5\:net102 \4\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.5e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\3\:net102 \1\:A1 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=3.118e-14 ps=1.35e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=6.55e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\1\:Y \3\:B1 \3\:net102 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.045e-14 ps=7.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (\1\:Y \1\:B0 net102 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.045e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp1 (\3\:Y \3\:A1 net93 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=5.375e-14 ps=6.6e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=6.35e-07 sd=160n sca=16.1871 scb=0.0155626 \
        scc=0.00030556 m=(1)
mp3 (\3\:Y \1\:B1 net85 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=5.375e-14 ps=7.4e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.4e-07 sd=160n sca=14.1665 \
        scb=0.0115254 scc=0.000225012 m=(1)
mp2 (net85 \3\:B0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.333e-14 ps=7.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.4e-07 sd=160n sca=16.9689 \
        scb=0.0170565 scc=0.000364407 m=(1)
ends OAI22XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:23:35 2012 )
// Library name: gsclib045
// Cell name: OAI2BB1X1
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y \3\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.31026e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(1)
C1 (A0N VSS) capacitor c=8.84019e-17
C2 (B0 VSS) capacitor c=5.19126e-17
C3 (VDD VSS) capacitor c=7.47073e-17
C4 (A1N VSS) capacitor c=4.26802e-17
C5 (Y VSS) capacitor c=6.07664e-17
C6 (n0 VSS) capacitor c=5.77466e-17
C7 (\1\:A1N VSS) capacitor c=4.42846e-17
C8 (\3\:A0N VSS) capacitor c=5.06226e-17
C9 (\1\:B0 VSS) capacitor c=6.02141e-17
C10 (\3\:n0 VSS) capacitor c=4.36399e-17
C11 (\3\:A1N VSS) capacitor c=5.25362e-17
C12 (\1\:A0N VSS) capacitor c=6.55052e-17
C13 (\3\:B0 VSS) capacitor c=7.64891e-17
C14 (\4\:A1N VSS) capacitor c=1.27107e-17
C15 (\2\:A0N VSS) capacitor c=6.30152e-17
C16 (\2\:B0 VSS) capacitor c=5.31515e-17
C17 (\2\:n0 VSS) capacitor c=5.19716e-17
C18 (\1\:VDD VSS) capacitor c=3.55973e-18
C19 (\4\:n0 VSS) capacitor c=6.20868e-17
C20 (\9\:VDD VSS) capacitor c=4.54146e-17
C21 (\1\:Y VSS) capacitor c=1.278e-16
C22 (\7\:VDD VSS) capacitor c=5.09303e-17
C23 (\3\:VDD VSS) capacitor c=1.95459e-17
C24 (\8\:n0 VSS) capacitor c=4.31601e-17
C25 (\3\:Y VSS) capacitor c=4.53076e-17
C26 (\2\:A1N VSS) capacitor c=4.47144e-17
C27 (\4\:B0 VSS) capacitor c=5.49366e-17
C28 (\4\:A0N VSS) capacitor c=5.31363e-17
C29 (\6\:n0 VSS) capacitor c=1.26319e-16
C30 (\7\:n0 VSS) capacitor c=8.27662e-17
C31 (\7\:A1N VSS) capacitor c=5.22702e-17
C32 (\5\:VDD VSS) capacitor c=8.35058e-18
Rk4 (\4\:A0N A0N) resistor r=0.1281 c=0
Rk18 (\4\:VSS VSS) resistor r=0.2007 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.3044 c=0
Rk3 (\4\:B0 B0) resistor r=0.1234 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.07834 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1958 c=0
Rk14 (\6\:VDD VDD) resistor r=0.1508 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.05508 c=0
Rk15 (VDD \8\:VDD) resistor r=0.3287 c=0
Rk16 (\5\:VDD \10\:VDD) resistor r=0.281 c=0
Rk8 (\5\:A1N A1N) resistor r=0.002535 c=0
Rk10 (\5\:A1N \7\:A1N) resistor r=0.03925 c=0
Rk9 (\6\:A1N \7\:A1N) resistor r=0.002438 c=0
Rk1 (\2\:Y Y) resistor r=0.6897 c=0
Rk2 (Y \4\:Y) resistor r=0.04817 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.5312 c=0
Rk6 (\6\:n0 \7\:n0) resistor r=0.3644 c=0
Rk7 (\6\:n0 \9\:n0) resistor r=0.1721 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=92.2876 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=112.23 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=52.6149 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.2302 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=134.077 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=86.0481 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=4.5402 c=0
Rl1 (n0 \2\:n0) resistor r=53.6362 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.5604 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=18.75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y n0 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=4.45769e-07 sd=160n sca=8.65991 scb=0.00681295 scc=0.000165238 \
        m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.40769e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn0 (n1 \1\:A0N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=8.7e-15 ps=9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.65e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (\8\:n0 \3\:A1N n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp2 (\1\:Y \1\:B0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.26026e-07 sd=160n sca=24.0497 \
        scb=0.0216272 scc=0.0017588 m=(1)
mp0 (\4\:n0 \3\:A0N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.05e-07 sd=160n sca=16.4198 \
        scb=0.014982 scc=0.000248552 m=(1)
mp1 (\4\:n0 \1\:A1N \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1e-07 sd=160n sca=27.6521 scb=0.0306729 \
        scc=0.00212413 m=(1)
ends OAI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:46:27 2012 )
// Library name: gsclib045
// Cell name: OAI2BB1X2
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X2 A0N A1N B0 VDD VSS Y
mp2 (\1\:Y \2\:B0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.496e-14 ad=6.24e-14 ps=1.335e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.90641e-07 sd=160n sca=17.4719 \
        scb=0.0181939 scc=0.00043542 m=(2)
C1 (Y VSS) capacitor c=1.94376e-17
C2 (A0N VSS) capacitor c=2.66686e-17
C3 (B0 VSS) capacitor c=1.71366e-17
C4 (VDD VSS) capacitor c=1.59551e-16
C5 (A1N VSS) capacitor c=3.31769e-17
C6 (8 VSS) capacitor c=1.49756e-18
C7 (n0 VSS) capacitor c=8.61617e-17
C8 (\4\:A1N VSS) capacitor c=2.55225e-17
C9 (\1\:A0N VSS) capacitor c=4.95173e-17
C10 (\3\:A1N VSS) capacitor c=2.81998e-17
C11 (\3\:A0N VSS) capacitor c=2.83653e-17
C12 (\6\:B0 VSS) capacitor c=6.15837e-17
C13 (\4\:n0 VSS) capacitor c=5.56225e-17
C14 (\6\:n0 VSS) capacitor c=6.36958e-17
C15 (\1\:B0 VSS) capacitor c=5.12108e-17
C16 (\1\:A1N VSS) capacitor c=1.46313e-17
C17 (\2\:A0N VSS) capacitor c=3.76643e-17
C18 (\2\:B0 VSS) capacitor c=3.38504e-16
C19 (\11\:VDD VSS) capacitor c=4.81638e-18
C20 (\7\:n0 VSS) capacitor c=1.98722e-17
C21 (\1\:Y VSS) capacitor c=1.44673e-16
C22 (\15\:VDD VSS) capacitor c=3.51433e-17
C23 (\1\:VDD VSS) capacitor c=5.43964e-17
C24 (\11\:n0 VSS) capacitor c=4.43954e-17
C25 (\7\:Y VSS) capacitor c=8.66478e-17
C26 (\3\:n0 VSS) capacitor c=4.39481e-17
C27 (\2\:A1N VSS) capacitor c=3.05072e-17
C28 (\4\:Y VSS) capacitor c=6.66345e-17
C29 (\4\:A0N VSS) capacitor c=7.1851e-17
C30 (\9\:n0 VSS) capacitor c=1.01808e-16
C31 (\10\:n0 VSS) capacitor c=8.79396e-17
C32 (\5\:A1N VSS) capacitor c=4.60957e-17
C33 (\3\:VDD VSS) capacitor c=2.90546e-18
C34 (\5\:VDD VSS) capacitor c=3.62995e-17
Rk3 (\4\:Y Y) resistor r=0.03517 c=0
Rk2 (\1\:Y \4\:Y) resistor r=0.1798 c=0
Rk5 (\4\:Y \8\:Y) resistor r=0.5502 c=0
Rk9 (\4\:A0N A0N) resistor r=0.07481 c=0
Rk8 (\2\:B0 B0) resistor r=0.005177 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.05218 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.147 c=0
Rk21 (\5\:VDD VDD) resistor r=0.05692 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.06715 c=0
Rk23 (\3\:VDD \12\:VDD) resistor r=0.07265 c=0
Rk25 (\5\:VDD \16\:VDD) resistor r=0.1812 c=0
Rk13 (A1N \5\:A1N) resistor r=0.2077 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.3579 c=0
Rk29 (\5\:VSS VSS) resistor r=0.1068 c=0
Rk28 (\4\:VSS \5\:VSS) resistor r=0.2916 c=0
Rk30 (\5\:VSS \7\:VSS) resistor r=0.2766 c=0
Rk10 (\8\:n0 \9\:n0) resistor r=0.09629 c=0
Rk11 (\9\:n0 \10\:n0) resistor r=0.4716 c=0
Rk12 (\9\:n0 \12\:n0) resistor r=0.3874 c=0
Rl10 (\1\:A0N \2\:A0N) resistor r=98.7687 c=0
Rl11 (\2\:A0N \3\:A0N) resistor r=44.9225 c=0
Rl9 (\2\:B0 \6\:B0) resistor r=40.1797 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=40.1797 c=0
Rl14 (\2\:A1N \4\:A1N) resistor r=74.7141 c=0
Rl13 (\2\:A1N \3\:A1N) resistor r=86.2526 c=0
Rl12 (\1\:A1N \2\:A1N) resistor r=29.0533 c=0
Rl4 (\3\:n0 n0) resistor r=10.2925 c=0
Rl5 (\3\:n0 \4\:n0) resistor r=86.6019 c=0
Rl7 (\3\:n0 \6\:n0) resistor r=136.023 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Rz7 (VDD \1\:VDD) resistor r=75 c=0
Rz3 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz4 (\4\:VDD \1\:VDD) resistor r=37.5 c=0
Rz5 (\5\:VDD \1\:VDD) resistor r=18.75 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry4 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry6 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry3 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx3 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx5 (\1\:A1N \5\:A1N) resistor r=45 c=0
Rx4 (\10\:n0 n0) resistor r=45 c=0
mn2 (8 \1\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.89615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn3 (\7\:Y \6\:n0 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.84615e-07 sd=160n sca=16.3874 scb=0.0162972 \
        scc=0.00139495 m=(1)
mn3_1__rcx (\7\:Y \4\:n0 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.79615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn2_1__rcx (9 \6\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.74615e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn0 (n1 \3\:A0N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=3.117e-14 ps=1.11e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=4e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn1 (\11\:n0 \3\:A1N n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mp3 (\1\:Y n0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.85641e-07 sd=160n sca=13.3812 \
        scb=0.0112303 scc=0.000237076 m=(2)
mp0 (\7\:n0 \1\:A0N \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.532e-14 ad=4.622e-14 ps=1.61e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.6e-07 sd=160n sca=13.2854 \
        scb=0.0114741 scc=0.000332863 m=(1)
mp1 (\7\:n0 \4\:A1N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=4.622e-14 ps=1.42e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1e-07 sd=160n sca=16.6544 \
        scb=0.0167336 scc=0.000417003 m=(1)
ends OAI2BB1X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:47:05 2012 )
// Library name: gsclib045
// Cell name: OAI2BB1X4
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X4 A0N A1N B0 VDD VSS Y
mp2 (\1\:Y \2\:B0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.337e-14 ps=1.12e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.9187 scb=0.0234591 \
        scc=0.000905231 m=(4)
C1 (A0N VSS) capacitor c=4.31387e-17
C2 (B0 VSS) capacitor c=1.82042e-17
C3 (VDD VSS) capacitor c=1.77221e-16
C4 (A1N VSS) capacitor c=5.14083e-17
C5 (Y VSS) capacitor c=7.55217e-17
C6 (8 VSS) capacitor c=1.85166e-18
C7 (n0 VSS) capacitor c=5.05828e-16
C8 (9 VSS) capacitor c=3.55348e-18
C9 (10 VSS) capacitor c=3.80467e-18
C10 (\1\:A1N VSS) capacitor c=3.27381e-17
C11 (\1\:A0N VSS) capacitor c=3.85714e-17
C12 (\3\:A1N VSS) capacitor c=5.53611e-17
C13 (\3\:A0N VSS) capacitor c=4.24361e-17
C14 (\13\:B0 VSS) capacitor c=2.72416e-17
C15 (\12\:n0 VSS) capacitor c=2.66164e-17
C16 (\11\:n0 VSS) capacitor c=4.46473e-17
C17 (\8\:B0 VSS) capacitor c=3.01417e-17
C18 (\7\:B0 VSS) capacitor c=3.3184e-17
C19 (\6\:n0 VSS) capacitor c=2.87348e-17
C20 (\5\:n0 VSS) capacitor c=4.41809e-17
C21 (\1\:B0 VSS) capacitor c=4.86904e-17
C22 (\4\:A1N VSS) capacitor c=1.19047e-17
C23 (\2\:A0N VSS) capacitor c=3.60342e-17
C24 (\2\:B0 VSS) capacitor c=5.87378e-16
C25 (\15\:VDD VSS) capacitor c=2.89857e-17
C26 (\19\:n0 VSS) capacitor c=4.45163e-17
C27 (\1\:Y VSS) capacitor c=3.4273e-16
C28 (\1\:VDD VSS) capacitor c=9.2599e-17
C29 (\14\:n0 VSS) capacitor c=3.67348e-17
C30 (\14\:Y VSS) capacitor c=8.38094e-17
C31 (\12\:Y VSS) capacitor c=1.52396e-16
C32 (\2\:A1N VSS) capacitor c=1.69046e-17
C33 (\4\:A0N VSS) capacitor c=6.4534e-17
C34 (\16\:n0 VSS) capacitor c=1.19864e-16
C35 (\5\:A1N VSS) capacitor c=3.46373e-17
C36 (\3\:VDD VSS) capacitor c=1.42356e-18
C37 (\5\:VDD VSS) capacitor c=2.17223e-16
Rk14 (\4\:A0N A0N) resistor r=0.1012 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.1953 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.4058 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.04742 c=0
Rk44 (\6\:VSS VSS) resistor r=0.06471 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.3379 c=0
Rk46 (\3\:VSS \9\:VSS) resistor r=0.2861 c=0
Rk47 (\5\:VSS \11\:VSS) resistor r=0.2815 c=0
Rk48 (\6\:VSS \13\:VSS) resistor r=0.2815 c=0
Rk13 (\2\:B0 B0) resistor r=0.02733 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.05494 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1452 c=0
Rk32 (\5\:VDD VDD) resistor r=0.02963 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1452 c=0
Rk34 (\3\:VDD \16\:VDD) resistor r=0.2263 c=0
Rk20 (\5\:A1N A1N) resistor r=0.1642 c=0
Rk4 (\1\:Y Y) resistor r=0.2349 c=0
Rk8 (Y \13\:Y) resistor r=0.5999 c=0
Rk9 (\13\:Y \15\:Y) resistor r=0.5051 c=0
Rk16 (\16\:n0 n0) resistor r=0.6413 c=0
Rk15 (\15\:n0 \16\:n0) resistor r=0.364 c=0
Rk18 (\16\:n0 \20\:n0) resistor r=0.1273 c=0
Rl22 (\1\:A0N \2\:A0N) resistor r=64.1533 c=0
Rl23 (\2\:A0N \3\:A0N) resistor r=60.3072 c=0
Rl21 (\2\:B0 \13\:B0) resistor r=41.1873 c=0
Rl12 (\2\:B0 \8\:B0) resistor r=28.6412 c=0
Rl11 (\2\:B0 \7\:B0) resistor r=71.1317 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=28.6412 c=0
Rl24 (\1\:A1N \2\:A1N) resistor r=73.7402 c=0
Rl25 (\2\:A1N \3\:A1N) resistor r=104.154 c=0
Rl26 (\2\:A1N \4\:A1N) resistor r=12.1383 c=0
Rl17 (n0 \12\:n0) resistor r=86.22 c=0
Rl16 (n0 \11\:n0) resistor r=119.208 c=0
Rl7 (n0 \6\:n0) resistor r=28.0797 c=0
Rl6 (n0 \5\:n0) resistor r=28.0797 c=0
Rz11 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (VDD \1\:VDD) resistor r=75 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz5 (\4\:VDD \1\:VDD) resistor r=25 c=0
Rz6 (\5\:VDD \1\:VDD) resistor r=9.375 c=0
Rz1 (\13\:Y \12\:Y) resistor r=75 c=0
Rz2 (\15\:Y \14\:Y) resistor r=75 c=0
Rz3 (\15\:n0 \14\:n0) resistor r=75 c=0
Ry14 (\1\:VSS VSS) resistor r=62 c=0
Ry12 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry13 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry6 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry5 (\20\:n0 \19\:n0) resistor r=20.6667 c=0
Rx4 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx7 (\4\:A1N \5\:A1N) resistor r=45 c=0
mn2_1__rcx (8 \1\:B0 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.905e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_1__rcx (\12\:Y \5\:n0 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.8e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_2__rcx (\12\:Y \6\:n0 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.595e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_2__rcx (9 \7\:B0 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.435e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (10 \8\:B0 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.23e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\14\:Y \11\:n0 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.07e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_3__rcx (\14\:Y \12\:n0 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=8.65e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_3__rcx (11 \13\:B0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.76e-14 ps=9.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn0 (n1 \3\:A0N \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=2.86e-14 ps=9.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.95e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\14\:n0 \3\:A1N n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=3.64e-14 ps=7.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp3 (\1\:Y n0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.337e-14 ps=1.1e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96e-06 sd=160n sca=14.8572 \
        scb=0.0133107 scc=0.000397776 m=(4)
mp0 (\19\:n0 \1\:A0N \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=1.053e-13 ps=1.22e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-06 sb=4.55e-07 sd=160n sca=13.3748 \
        scb=0.0113115 scc=0.000384334 m=(1)
mp1 (\19\:n0 \1\:A1N \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=1.053e-13 ps=1.06e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.4901 scb=0.0196141 \
        scc=0.000605547 m=(1)
ends OAI2BB1X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:47:43 2012 )
// Library name: gsclib045
// Cell name: OAI2BB1XL
// View name: extracted

simulator lang=spectre

subckt OAI2BB1XL A0N A1N B0 VDD VSS Y
mp3 (\3\:Y \3\:n0 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.35e-07 sd=160n sca=16.7249 scb=0.0166366 \
        scc=0.000331722 m=(1)
C1 (Y VSS) capacitor c=8.97839e-17
C2 (A0N VSS) capacitor c=2.88015e-17
C3 (VDD VSS) capacitor c=1.01859e-16
C4 (A1N VSS) capacitor c=1.95762e-17
C5 (n0 VSS) capacitor c=4.21709e-17
C6 (\1\:A1N VSS) capacitor c=2.47745e-17
C7 (\1\:A0N VSS) capacitor c=4.0212e-17
C8 (\1\:B0 VSS) capacitor c=5.46062e-17
C9 (\3\:n0 VSS) capacitor c=5.95125e-17
C10 (\3\:A1N VSS) capacitor c=8.89003e-17
C11 (\3\:A0N VSS) capacitor c=9.21643e-17
C12 (\3\:B0 VSS) capacitor c=7.66081e-17
C13 (\4\:A1N VSS) capacitor c=1.42069e-17
C14 (\2\:A0N VSS) capacitor c=8.00462e-17
C15 (\2\:B0 VSS) capacitor c=6.65405e-17
C16 (\2\:n0 VSS) capacitor c=5.86305e-17
C17 (\6\:VDD VSS) capacitor c=4.02463e-18
C18 (\8\:n0 VSS) capacitor c=7.77419e-17
C19 (\8\:VDD VSS) capacitor c=5.01208e-18
C20 (\3\:Y VSS) capacitor c=8.47473e-17
C21 (\12\:VDD VSS) capacitor c=1.38292e-17
C22 (\1\:VDD VSS) capacitor c=2.65398e-17
C23 (\4\:n0 VSS) capacitor c=1.82224e-17
C24 (\1\:Y VSS) capacitor c=3.41164e-17
C25 (\2\:A1N VSS) capacitor c=5.9724e-17
C26 (\4\:B0 VSS) capacitor c=1.3143e-16
C27 (\4\:A0N VSS) capacitor c=1.03441e-16
C28 (\6\:n0 VSS) capacitor c=9.87199e-17
C29 (\7\:n0 VSS) capacitor c=5.51082e-17
C30 (\5\:A1N VSS) capacitor c=5.67909e-17
Rk1 (\2\:Y Y) resistor r=0.2199 c=0
Rk2 (Y \4\:Y) resistor r=0.7547 c=0
Rk6 (\4\:A0N A0N) resistor r=0.01793 c=0
Rk3 (\4\:B0 B0) resistor r=0.002989 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.03234 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.06737 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1001 c=0
Rk16 (\3\:VDD \7\:VDD) resistor r=0.07311 c=0
Rk17 (\5\:VDD \9\:VDD) resistor r=0.1191 c=0
Rk18 (\5\:VDD \10\:VDD) resistor r=0.1507 c=0
Rk21 (\11\:VDD VDD) resistor r=0.08714 c=0
Rk19 (\10\:VDD \11\:VDD) resistor r=0.06236 c=0
Rk20 (\11\:VDD \13\:VDD) resistor r=0.07311 c=0
Rk12 (\5\:A1N A1N) resistor r=0.01793 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.1399 c=0
Rk25 (\4\:VSS VSS) resistor r=0.09985 c=0
Rk24 (\3\:VSS \4\:VSS) resistor r=0.16 c=0
Rk26 (\3\:VSS \6\:VSS) resistor r=0.179 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.1651 c=0
Rk8 (\6\:n0 \7\:n0) resistor r=0.3581 c=0
Rk9 (\6\:n0 \9\:n0) resistor r=0.5336 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=29.5379 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=229.538 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=97.8081 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=162.637 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=24.4619 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=270.663 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=12.2705 c=0
Rl1 (n0 \2\:n0) resistor r=28.8462 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=232.143 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz5 (\1\:VDD \5\:VDD) resistor r=75 c=0
Rz6 (\1\:VDD \10\:VDD) resistor r=37.5 c=0
Rz8 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry5 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \5\:A1N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\1\:Y n0 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.7e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mn2 (n2 \3\:B0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.65e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn0 (n1 \3\:A0N \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=2.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (\4\:n0 \3\:A1N n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mp2 (\3\:Y \1\:B0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.3e-07 sd=160n sca=13.903 \
        scb=0.0110664 scc=0.000192019 m=(1)
mp0 (\8\:n0 \1\:A0N \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.085e-14 ps=1.45e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=3.35e-07 sd=160n sca=14.4432 scb=0.0121509 \
        scc=0.000203603 m=(1)
mp1 (\8\:n0 \1\:A1N \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=4.085e-14 ps=1.35e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1e-07 sd=160n sca=22.3297 scb=0.0253475 \
        scc=0.00112325 m=(1)
ends OAI2BB1XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:48:22 2012 )
// Library name: gsclib045
// Cell name: OAI2BB2X1
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X1 A0N A1N B0 B1 VDD VSS Y
mp1 (\6\:n1 \1\:A1N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.45e-07 sd=160n sca=14.4258 \
        scb=0.0129222 scc=0.000259662 m=(1)
C1 (B1 VSS) capacitor c=1.12926e-16
C2 (Y VSS) capacitor c=4.37038e-17
C3 (A0N VSS) capacitor c=4.70931e-17
C4 (A1N VSS) capacitor c=4.51397e-17
C5 (B0 VSS) capacitor c=4.0062e-17
C6 (VDD VSS) capacitor c=1.31581e-16
C7 (n1 VSS) capacitor c=5.77028e-17
C8 (n0 VSS) capacitor c=3.98857e-17
C9 (n4 VSS) capacitor c=6.53772e-17
C10 (n2 VSS) capacitor c=6.28521e-18
C11 (n3 VSS) capacitor c=9.50322e-18
C12 (\3\:B0 VSS) capacitor c=3.95735e-17
C13 (\3\:B1 VSS) capacitor c=5.10317e-17
C14 (\3\:A0N VSS) capacitor c=2.83595e-17
C15 (\1\:A1N VSS) capacitor c=3.43479e-17
C16 (\1\:B0 VSS) capacitor c=3.51202e-17
C17 (\1\:B1 VSS) capacitor c=3.8775e-17
C18 (\3\:n1 VSS) capacitor c=3.80475e-17
C19 (\3\:n0 VSS) capacitor c=3.60972e-17
C20 (\1\:A0N VSS) capacitor c=4.73676e-17
C21 (\3\:A1N VSS) capacitor c=3.5436e-17
C22 (\4\:B0 VSS) capacitor c=1.36974e-17
C23 (\2\:B1 VSS) capacitor c=4.80051e-17
C24 (\2\:n1 VSS) capacitor c=4.24287e-17
C25 (\2\:n0 VSS) capacitor c=3.0943e-17
C26 (\2\:A0N VSS) capacitor c=3.91073e-17
C27 (\2\:A1N VSS) capacitor c=3.70602e-17
C28 (\7\:VDD VSS) capacitor c=5.69815e-17
C29 (\3\:Y VSS) capacitor c=1.10432e-16
C30 (\9\:VDD VSS) capacitor c=7.12906e-17
C31 (\6\:n0 VSS) capacitor c=7.7427e-17
C32 (\11\:VDD VSS) capacitor c=3.6336e-17
C33 (\6\:n1 VSS) capacitor c=5.73562e-17
C34 (\1\:VDD VSS) capacitor c=1.40918e-17
C35 (\5\:n4 VSS) capacitor c=5.8385e-17
C36 (\1\:Y VSS) capacitor c=1.39265e-16
C37 (\3\:n4 VSS) capacitor c=1.04463e-16
C38 (\8\:n0 VSS) capacitor c=6.19042e-17
C39 (\8\:n1 VSS) capacitor c=1.61447e-17
C40 (\2\:B0 VSS) capacitor c=2.15889e-17
C41 (\4\:A1N VSS) capacitor c=6.96145e-17
C42 (\4\:A0N VSS) capacitor c=6.73823e-17
C43 (\4\:n0 VSS) capacitor c=5.04838e-17
C44 (\5\:n0 VSS) capacitor c=7.70516e-17
C45 (\4\:n1 VSS) capacitor c=1.98547e-16
C46 (\5\:n1 VSS) capacitor c=2.22372e-16
C47 (\5\:B0 VSS) capacitor c=5.0518e-17
C48 (\3\:VDD VSS) capacitor c=1.79011e-17
C49 (\4\:VDD VSS) capacitor c=1.93783e-17
C50 (\6\:VDD VSS) capacitor c=1.62676e-17
Rk9 (\4\:B1 B1) resistor r=0.002999 c=0
Rk11 (\4\:Y Y) resistor r=0.162 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.8246 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.326 c=0
Rk24 (\3\:VSS \5\:VSS) resistor r=0.4636 c=0
Rk26 (\6\:VSS VSS) resistor r=0.1 c=0
Rk25 (\3\:VSS \6\:VSS) resistor r=0.1377 c=0
Rk27 (\5\:VSS \8\:VSS) resistor r=0.2603 c=0
Rk2 (\4\:A0N A0N) resistor r=0.00989 c=0
Rk1 (A1N \4\:A1N) resistor r=0.1066 c=0
Rk14 (B0 \5\:B0) resistor r=0.1009 c=0
Rk15 (\2\:VDD \3\:VDD) resistor r=0.0349 c=0
Rk16 (\3\:VDD \4\:VDD) resistor r=0.4634 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.1026 c=0
Rk19 (\6\:VDD VDD) resistor r=0.2252 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.2756 c=0
Rk20 (\3\:VDD \8\:VDD) resistor r=0.3539 c=0
Rk21 (\4\:VDD \10\:VDD) resistor r=0.3795 c=0
Rk22 (\6\:VDD \12\:VDD) resistor r=0.2814 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=1.4576 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.6195 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.09247 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.2654 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.5092 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.2704 c=0
Rk12 (\2\:n4 \4\:n4) resistor r=0.3145 c=0
Rk13 (\4\:n4 \6\:n4) resistor r=0.4324 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=87.6944 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=45.3867 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=29.9451 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=148.077 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=77.6148 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=98.7687 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=63.4394 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=99.9628 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=23.4664 c=0
Rl7 (n1 \2\:n1) resistor r=102.615 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=33.3841 c=0
Rl5 (n0 \2\:n0) resistor r=39.6174 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=93.4636 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz8 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Rz2 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz6 (\5\:n4 \6\:n4) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry7 (\4\:VSS \5\:VSS) resistor r=6.8889 c=0
Ry8 (\4\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry2 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx4 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\8\:n0 \1\:A0N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2.25e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (n4 \3\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mn3 (\3\:n4 \3\:n1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.55e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.95e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn5 (\1\:Y \1\:B1 \3\:n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.94e-14 ps=8.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.75e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn4 (\1\:Y \1\:B0 \5\:n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.94e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=8e-07 sb=1.4e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mp0 (\6\:n0 \3\:A0N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5073 \
        scb=0.0103104 scc=0.000239765 m=(1)
mp2 (n2 n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.8e-14 \
        ad=6.24e-14 ps=1.18e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-07 sb=8e-07 sd=160n sca=23.3582 scb=0.018284 scc=0.00243236 \
        m=(1)
mp3 (\3\:Y n1 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.95e-07 sd=160n sca=23.9563 scb=0.0185363 \
        scc=0.00243248 m=(1)
mp5 (\3\:Y \3\:B1 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.9e-07 sd=160n sca=25.2941 \
        scb=0.0199646 scc=0.00243758 m=(1)
mp4 (n3 \3\:B0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.825e-14 ps=1.12e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=29.982 scb=0.0279319 \
        scc=0.00269613 m=(1)
ends OAI2BB2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:49:00 2012 )
// Library name: gsclib045
// Cell name: OAI2BB2X2
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X2 A0N A1N B0 B1 VDD VSS Y
mp1 (\10\:n1 \1\:A1N \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=3.01e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=52.067 scb=0.0373106 \
        scc=0.00610613 m=(1)
C1 (Y VSS) capacitor c=3.52407e-17
C2 (A0N VSS) capacitor c=5.50565e-17
C3 (A1N VSS) capacitor c=1.29171e-16
C4 (B0 VSS) capacitor c=1.72567e-17
C5 (B1 VSS) capacitor c=8.4818e-17
C6 (VDD VSS) capacitor c=1.63163e-16
C7 (n1 VSS) capacitor c=4.58935e-17
C8 (n0 VSS) capacitor c=5.6244e-17
C9 (n4 VSS) capacitor c=7.90962e-17
C10 (5 VSS) capacitor c=3.11944e-18
C11 (7 VSS) capacitor c=4.37739e-18
C12 (8 VSS) capacitor c=4.42239e-18
C13 (9 VSS) capacitor c=1.50384e-18
C14 (\6\:B0 VSS) capacitor c=8.33439e-17
C15 (\6\:B1 VSS) capacitor c=6.35455e-17
C16 (\5\:B1 VSS) capacitor c=4.52603e-17
C17 (\1\:B0 VSS) capacitor c=5.61201e-17
C18 (\4\:n0 VSS) capacitor c=5.23062e-17
C19 (\6\:n1 VSS) capacitor c=5.54186e-17
C20 (\4\:A0N VSS) capacitor c=2.10933e-17
C21 (\1\:A1N VSS) capacitor c=2.69168e-17
C22 (\1\:B1 VSS) capacitor c=1.05668e-16
C23 (\1\:A0N VSS) capacitor c=2.20999e-17
C24 (\3\:A1N VSS) capacitor c=1.85925e-17
C25 (\2\:B0 VSS) capacitor c=3.73596e-16
C26 (\2\:n0 VSS) capacitor c=3.21591e-16
C27 (\3\:A0N VSS) capacitor c=2.92288e-17
C28 (\2\:A1N VSS) capacitor c=2.92553e-17
C29 (\9\:VDD VSS) capacitor c=1.51151e-17
C30 (\8\:Y VSS) capacitor c=5.86828e-17
C31 (\11\:VDD VSS) capacitor c=3.80558e-17
C32 (\1\:Y VSS) capacitor c=3.69731e-17
C33 (\13\:VDD VSS) capacitor c=3.84095e-17
C34 (\13\:n0 VSS) capacitor c=1.84538e-17
C35 (\15\:VDD VSS) capacitor c=4.19461e-17
C36 (\10\:n1 VSS) capacitor c=5.84718e-17
C37 (\1\:VDD VSS) capacitor c=2.76693e-17
C38 (\7\:n4 VSS) capacitor c=9.36557e-17
C39 (\11\:n0 VSS) capacitor c=5.28384e-17
C40 (\8\:n1 VSS) capacitor c=2.09847e-16
C41 (\2\:n1 VSS) capacitor c=1.31911e-16
C42 (\4\:B1 VSS) capacitor c=2.85571e-17
C43 (\5\:A0N VSS) capacitor c=6.7475e-17
C44 (\7\:n1 VSS) capacitor c=1.94355e-16
C45 (\10\:n0 VSS) capacitor c=6.56148e-17
C46 (\3\:Y VSS) capacitor c=2.81831e-17
C47 (\4\:Y VSS) capacitor c=1.05906e-16
C48 (\5\:Y VSS) capacitor c=1.87502e-16
C49 (\7\:B1 VSS) capacitor c=3.60446e-17
C50 (\2\:n4 VSS) capacitor c=1.72164e-16
C51 (\3\:VDD VSS) capacitor c=1.74848e-17
C52 (\4\:VDD VSS) capacitor c=2.25235e-17
C53 (\6\:VDD VSS) capacitor c=1.32976e-17
C54 (\7\:VDD VSS) capacitor c=1.06417e-17
Rk10 (\3\:Y Y) resistor r=0.1229 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.1205 c=0
Rk11 (\3\:Y \4\:Y) resistor r=0.2838 c=0
Rk12 (\4\:Y \5\:Y) resistor r=0.4737 c=0
Rk14 (\4\:Y \9\:Y) resistor r=0.4072 c=0
Rk2 (\5\:A0N A0N) resistor r=0.1983 c=0
Rk1 (A1N \4\:A1N) resistor r=0.00411 c=0
Rk34 (\2\:VSS \3\:VSS) resistor r=0.2203 c=0
Rk36 (\3\:VSS \5\:VSS) resistor r=0.2103 c=0
Rk37 (\5\:VSS \6\:VSS) resistor r=0.2479 c=0
Rk39 (\7\:VSS VSS) resistor r=0.09998 c=0
Rk38 (\6\:VSS \7\:VSS) resistor r=0.1025 c=0
Rk42 (\6\:VSS \13\:VSS) resistor r=0.188 c=0
Rk18 (\2\:B0 B0) resistor r=0.01895 c=0
Rk16 (\7\:B1 B1) resistor r=0.06822 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.09502 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.373 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.2328 c=0
Rk26 (\5\:VDD \6\:VDD) resistor r=0.1476 c=0
Rk27 (\6\:VDD \7\:VDD) resistor r=0.4456 c=0
Rk29 (\8\:VDD VDD) resistor r=0.04986 c=0
Rk28 (\7\:VDD \8\:VDD) resistor r=0.1076 c=0
Rk30 (\3\:VDD \10\:VDD) resistor r=0.1895 c=0
Rk31 (\4\:VDD \12\:VDD) resistor r=0.1849 c=0
Rk32 (\6\:VDD \14\:VDD) resistor r=0.279 c=0
Rk33 (\7\:VDD \16\:VDD) resistor r=0.4195 c=0
Rk3 (\7\:n1 \9\:n1) resistor r=1.4234 c=0
Rk4 (\9\:n1 \11\:n1) resistor r=0.4681 c=0
Rk6 (\2\:n0 \10\:n0) resistor r=0.3619 c=0
Rk7 (\10\:n0 \12\:n0) resistor r=0.2495 c=0
Rk8 (\10\:n0 \14\:n0) resistor r=0.1364 c=0
Rl5 (\2\:A0N \4\:A0N) resistor r=84.3339 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=67.0262 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=3.3229 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=71.1538 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=53.022 c=0
Rl24 (\2\:B0 \6\:B0) resistor r=115.362 c=0
Rl16 (\2\:B0 \1\:B0) resistor r=75.6918 c=0
Rl22 (\4\:B1 \6\:B1) resistor r=59.1794 c=0
Rl21 (\4\:B1 \5\:B1) resistor r=103.331 c=0
Rl20 (\4\:B1 \1\:B1) resistor r=6.3032 c=0
Rl8 (\2\:n1 n1) resistor r=181.926 c=0
Rl12 (\2\:n1 \6\:n1) resistor r=160.771 c=0
Rl6 (\2\:n0 n0) resistor r=92.1028 c=0
Rl13 (\2\:n0 \4\:n0) resistor r=105.483 c=0
Rz15 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz11 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz1 (\9\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\12\:n0 \11\:n0) resistor r=75 c=0
Rz5 (\2\:n4 n4) resistor r=75 c=0
Rz8 (\2\:n4 \7\:n4) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry4 (\9\:Y \8\:Y) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry10 (\5\:VSS \1\:VSS) resistor r=15.5 c=0
Ry11 (\7\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry8 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\14\:n0 \13\:n0) resistor r=62 c=0
Rx2 (\3\:A0N \5\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx3 (\7\:n1 \2\:n1) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.09e-13 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\11\:n0 \1\:A0N \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.09e-13 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\2\:n4 \2\:n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.615e-14 ps=8.7e-07 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.79e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (n4 \2\:n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.57e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn4 (\5\:Y \2\:B0 \2\:n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=6.045e-14 ps=8.6e-07 pd=9.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn5 (\5\:Y \1\:B1 \7\:n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=6.045e-14 ps=8.4e-07 pd=9.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=6.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp0 (\13\:n0 \4\:A0N \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=3.44e-14 ps=1.18e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.6e-07 sd=160n sca=46.4272 \
        scb=0.0285818 scc=0.00588427 m=(1)
mp2_1__rcx (5 n0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.44e-06 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp3_1__rcx (\1\:Y \6\:n1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.28e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp3 (\1\:Y n1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.05e-07 sb=1.075e-06 sd=160n sca=11.8275 scb=0.0101379 \
        scc=0.000311481 m=(1)
mp5_1__rcx (\8\:Y \5\:B1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=4.5e-07 sd=160n sca=12.2157 \
        scb=0.0102564 scc=0.000311508 m=(1)
mp2 (7 \4\:n0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=6.825e-14 ps=1.18e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=8.55e-07 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp4_1__rcx (8 \1\:B0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=4.485e-14 ps=1.18e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=6.1e-07 sd=160n sca=11.8275 \
        scb=0.0101379 scc=0.000311481 m=(1)
mp5 (\8\:Y \6\:B1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.335e-06 sb=2.45e-07 sd=160n sca=13.1864 scb=0.011023 \
        scc=0.000312795 m=(1)
mp4 (9 \6\:B0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=1.4e-07 sd=160n sca=14.1519 \
        scb=0.0123146 scc=0.000320502 m=(1)
ends OAI2BB2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:49:37 2012 )
// Library name: gsclib045
// Cell name: OAI2BB2X4
// View name: extracted

simulator lang=spectre

subckt OAI2BB2X4 A0N A1N B0 B1 VDD VSS Y
mp1 (\19\:n1 \1\:A1N \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.8434 \
        scb=0.0211629 scc=0.00086948 m=(1)
C1 (Y VSS) capacitor c=4.14878e-17
C2 (A0N VSS) capacitor c=5.98449e-17
C3 (A1N VSS) capacitor c=9.25036e-17
C4 (B0 VSS) capacitor c=4.27062e-17
C5 (VDD VSS) capacitor c=3.61921e-16
C6 (n1 VSS) capacitor c=7.32797e-17
C7 (n0 VSS) capacitor c=9.29095e-17
C8 (n4 VSS) capacitor c=1.7429e-15
C9 (5 VSS) capacitor c=2.26562e-18
C10 (7 VSS) capacitor c=2.72975e-18
C11 (8 VSS) capacitor c=3.41961e-18
C12 (9 VSS) capacitor c=5.80348e-18
C13 (10 VSS) capacitor c=3.46881e-18
C14 (11 VSS) capacitor c=5.44125e-18
C15 (12 VSS) capacitor c=4.25442e-18
C16 (13 VSS) capacitor c=7.05326e-19
C17 (\14\:B0 VSS) capacitor c=6.41813e-17
C18 (\12\:B1 VSS) capacitor c=7.5707e-17
C19 (\17\:B1 VSS) capacitor c=4.28995e-17
C20 (\5\:B0 VSS) capacitor c=4.16039e-17
C21 (\11\:B0 VSS) capacitor c=3.91064e-17
C22 (\1\:B1 VSS) capacitor c=3.68188e-17
C23 (\10\:B1 VSS) capacitor c=3.63838e-17
C24 (\1\:B0 VSS) capacitor c=5.11004e-17
C25 (\13\:n0 VSS) capacitor c=4.65193e-17
C26 (\10\:n1 VSS) capacitor c=4.51653e-17
C27 (\15\:n1 VSS) capacitor c=5.81324e-17
C28 (\7\:n0 VSS) capacitor c=5.33693e-17
C29 (\12\:n0 VSS) capacitor c=6.3289e-17
C30 (\8\:n1 VSS) capacitor c=7.58404e-17
C31 (\1\:A0N VSS) capacitor c=4.92643e-17
C32 (\1\:A1N VSS) capacitor c=4.55796e-17
C33 (\3\:A0N VSS) capacitor c=4.09326e-17
C34 (\3\:A1N VSS) capacitor c=3.18642e-17
C35 (\3\:B1 VSS) capacitor c=3.671e-16
C36 (\2\:n1 VSS) capacitor c=3.67798e-16
C37 (\6\:n1 VSS) capacitor c=2.14738e-17
C38 (\4\:n0 VSS) capacitor c=3.45778e-17
C39 (\2\:A0N VSS) capacitor c=3.81917e-17
C40 (\2\:A1N VSS) capacitor c=3.26507e-17
C41 (\6\:VDD VSS) capacitor c=2.7396e-17
C42 (\1\:Y VSS) capacitor c=1.06993e-16
C43 (\8\:VDD VSS) capacitor c=2.69583e-17
C44 (\3\:Y VSS) capacitor c=1.43464e-16
C45 (\11\:VDD VSS) capacitor c=3.50352e-17
C46 (\10\:Y VSS) capacitor c=1.00017e-16
C47 (\15\:VDD VSS) capacitor c=3.17605e-17
C48 (\12\:Y VSS) capacitor c=9.80025e-17
C49 (\18\:VDD VSS) capacitor c=4.8497e-17
C50 (\18\:n0 VSS) capacitor c=6.42754e-17
C51 (\22\:VDD VSS) capacitor c=4.09567e-17
C52 (\19\:n1 VSS) capacitor c=8.10479e-17
C53 (\1\:VDD VSS) capacitor c=1.39816e-16
C54 (\6\:Y VSS) capacitor c=4.03333e-16
C55 (\20\:n0 VSS) capacitor c=5.02331e-17
C56 (\17\:n1 VSS) capacitor c=2.03116e-16
C57 (\2\:n0 VSS) capacitor c=7.03202e-16
C58 (\2\:B0 VSS) capacitor c=5.77398e-16
C59 (\11\:B1 VSS) capacitor c=1.53294e-17
C60 (\2\:B1 VSS) capacitor c=1.12429e-17
C61 (\9\:B1 VSS) capacitor c=2.30627e-17
C62 (\4\:A1N VSS) capacitor c=4.09146e-17
C63 (\4\:A0N VSS) capacitor c=5.67531e-17
C64 (\17\:n0 VSS) capacitor c=8.25948e-17
C65 (\16\:n1 VSS) capacitor c=1.67569e-16
C66 (\18\:B1 VSS) capacitor c=1.07969e-16
C67 (\5\:Y VSS) capacitor c=1.08367e-16
C68 (\3\:VDD VSS) capacitor c=5.89353e-18
C69 (\10\:VDD VSS) capacitor c=3.5493e-17
C70 (\14\:VDD VSS) capacitor c=2.87814e-17
C71 (\17\:VDD VSS) capacitor c=1.6599e-17
C72 (\21\:VDD VSS) capacitor c=1.55415e-18
Rk10 (\18\:B1 B1) resistor r=0.009408 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.6698 c=0
Rk16 (\5\:Y Y) resistor r=0.02575 c=0
Rk14 (\5\:Y \6\:Y) resistor r=0.6799 c=0
Rk13 (\4\:Y \5\:Y) resistor r=0.4471 c=0
Rk17 (Y \11\:Y) resistor r=0.2404 c=0
Rk18 (\11\:Y \13\:Y) resistor r=0.5364 c=0
Rk50 (\2\:VSS \3\:VSS) resistor r=0.7029 c=0
Rk51 (\3\:VSS \4\:VSS) resistor r=0.3553 c=0
Rk57 (\4\:VSS \10\:VSS) resistor r=0.2584 c=0
Rk58 (\10\:VSS \11\:VSS) resistor r=0.2609 c=0
Rk60 (\12\:VSS VSS) resistor r=0.04996 c=0
Rk59 (\11\:VSS \12\:VSS) resistor r=0.09018 c=0
Rk65 (\11\:VSS \22\:VSS) resistor r=0.2323 c=0
Rk2 (A0N \4\:A0N) resistor r=0.1808 c=0
Rk1 (A1N \4\:A1N) resistor r=0.06631 c=0
Rk21 (B0 \2\:B0) resistor r=0.04362 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.1002 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.1504 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.2516 c=0
Rk36 (\3\:VDD \7\:VDD) resistor r=0.1035 c=0
Rk37 (\5\:VDD \9\:VDD) resistor r=0.1502 c=0
Rk38 (\5\:VDD \10\:VDD) resistor r=0.4733 c=0
Rk39 (\10\:VDD \12\:VDD) resistor r=0.04337 c=0
Rk40 (\10\:VDD \13\:VDD) resistor r=0.1771 c=0
Rk41 (\13\:VDD \14\:VDD) resistor r=0.2734 c=0
Rk42 (\14\:VDD \16\:VDD) resistor r=0.1035 c=0
Rk43 (\14\:VDD \17\:VDD) resistor r=0.3209 c=0
Rk44 (\17\:VDD \19\:VDD) resistor r=0.2596 c=0
Rk45 (\17\:VDD \20\:VDD) resistor r=0.2584 c=0
Rk46 (\20\:VDD \21\:VDD) resistor r=0.2433 c=0
Rk47 (\21\:VDD \23\:VDD) resistor r=0.2364 c=0
Rk49 (\24\:VDD VDD) resistor r=0.04996 c=0
Rk48 (\21\:VDD \24\:VDD) resistor r=0.1077 c=0
Rk5 (\16\:n1 \18\:n1) resistor r=1.2382 c=0
Rk6 (\18\:n1 \20\:n1) resistor r=0.6321 c=0
Rk3 (\17\:n0 \19\:n0) resistor r=0.4471 c=0
Rk4 (\17\:n0 \21\:n0) resistor r=0.2298 c=0
Rl51 (\3\:B1 \12\:B1) resistor r=120.387 c=0
Rl55 (\3\:B1 \17\:B1) resistor r=90.1797 c=0
Rl40 (\3\:B1 \8\:B1) resistor r=3.9152 c=0
Rl34 (\2\:B1 \1\:B1) resistor r=40.1923 c=0
Rl35 (\2\:B1 \3\:B1) resistor r=43.2713 c=0
Rl44 (\2\:B1 \11\:B1) resistor r=46.3175 c=0
Rl42 (\9\:B1 \10\:B1) resistor r=43.1761 c=0
Rl41 (\9\:B1 \8\:B1) resistor r=21.0032 c=0
Rl43 (\9\:B1 \11\:B1) resistor r=50.1411 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=56.461 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=87.6365 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=53.0211 c=0
Rl57 (\2\:B0 \14\:B0) resistor r=24.7951 c=0
Rl45 (\2\:B0 \5\:B0) resistor r=55.7471 c=0
Rl50 (\2\:B0 \11\:B0) resistor r=34.3295 c=0
Rl31 (\2\:B0 \1\:B0) resistor r=37.477 c=0
Rl10 (\2\:n1 n1) resistor r=99.7951 c=0
Rl23 (\2\:n1 \10\:n1) resistor r=137.695 c=0
Rl27 (\2\:n1 \15\:n1) resistor r=110.513 c=0
Rl16 (\2\:n1 \8\:n1) resistor r=114.969 c=0
Rl14 (\2\:n1 \6\:n1) resistor r=9.3321 c=0
Rl5 (\2\:n0 n0) resistor r=161.516 c=0
Rl28 (\2\:n0 \13\:n0) resistor r=37.3411 c=0
Rl18 (\2\:n0 \7\:n0) resistor r=69.2087 c=0
Rl22 (\2\:n0 \12\:n0) resistor r=28.079 c=0
Rl7 (\2\:n0 \4\:n0) resistor r=158.53 c=0
Rz26 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \5\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \13\:VDD) resistor r=6.25 c=0
Rz20 (\1\:VDD \20\:VDD) resistor r=15 c=0
Rz21 (\1\:VDD \24\:VDD) resistor r=37.5 c=0
Rz2 (\18\:n1 \17\:n1) resistor r=75 c=0
Rz1 (\21\:n0 \20\:n0) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=62 c=0
Ry4 (\4\:Y \3\:Y) resistor r=62 c=0
Ry5 (\11\:Y \10\:Y) resistor r=62 c=0
Ry6 (\13\:Y \12\:Y) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\4\:VSS \1\:VSS) resistor r=15.5 c=0
Ry17 (\10\:VSS \1\:VSS) resistor r=12.4 c=0
Ry18 (\12\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry10 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry11 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry12 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry2 (\20\:n1 \19\:n1) resistor r=62 c=0
Ry1 (\19\:n0 \18\:n0) resistor r=62 c=0
Rx10 (\18\:B1 \8\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx4 (\16\:n1 \6\:n1) resistor r=45 c=0
Rx3 (\17\:n0 \4\:n0) resistor r=45 c=0
mn1 (\17\:n1 \3\:A1N \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=3.64e-14 ps=9.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0 (\20\:n0 \3\:A0N \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=5.72e-14 ps=9.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2.2e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (n4 \2\:n0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=4.323e-14 ps=1.04e-06 pd=8.525e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn3_1__rcx (n4 \2\:n1 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=4.355e-14 ps=1.04e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn4_1__rcx (\6\:Y \2\:B0 n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.518e-14 ad=5.298e-14 ps=8.675e-07 pd=9.275e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mn5_1__rcx (\6\:Y \3\:B1 n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=5.298e-14 ps=8.55e-07 pd=9.275e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp0 (\18\:n0 \1\:A0N \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.6131 \
        scb=0.0139483 scc=0.000653233 m=(1)
mp2_1__rcx (5 n0 \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_1__rcx (\12\:Y \8\:n1 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_2__rcx (\12\:Y n1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp4_1__rcx (10 \1\:B0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.655e-14 ps=1.75e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=1.68e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp2_2__rcx (7 \12\:n0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.215e-13 ad=2.34e-14 ps=1.77e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp2 (8 \7\:n0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.215e-13 ad=3.51e-14 ps=1.77e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3 (\10\:Y \15\:n1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp3_3__rcx (\10\:Y \10\:n1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp2_3__rcx (9 \13\:n0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=8.58e-14 ps=1.75e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.945e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5_1__rcx (\3\:Y \10\:B1 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=1.3455e-13 ps=1.07e-06 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-06 sb=1.49e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5_2__rcx (\3\:Y \1\:B1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=1.3455e-13 ps=1.05e-06 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.1e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp4_2__rcx (11 \11\:B0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.265e-14 ps=1.75e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.2e-07 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(1)
mp4 (12 \5\:B0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.176e-13 ad=5.07e-14 ps=1.75e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.55e-07 sd=160n sca=16.4245 scb=0.0146155 \
        scc=0.00118862 m=(1)
mp5 (\1\:Y \17\:B1 12 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=6.24e-14 ps=1.04e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.8e-07 sd=160n sca=16.9872 scb=0.0148857 \
        scc=0.00118877 m=(1)
mp5_3__rcx (\1\:Y \12\:B1 13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.75e-07 sd=160n sca=18.4199 scb=0.0164999 \
        scc=0.00119548 m=(1)
mp4_3__rcx (13 \14\:B0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.81e-14 ad=2.34e-14 ps=1.65e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.7e-07 sd=160n sca=19.996 scb=0.0190983 \
        scc=0.00123425 m=(1)
ends OAI2BB2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:50:16 2012 )
// Library name: gsclib045
// Cell name: OAI2BB2XL
// View name: extracted

simulator lang=spectre

subckt OAI2BB2XL A0N A1N B0 B1 VDD VSS Y
mp1 (\7\:n1 \1\:A1N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.45e-07 sd=160n sca=21.2082 \
        scb=0.024206 scc=0.000913232 m=(1)
C1 (VDD VSS) capacitor c=1.51333e-16
C2 (A0N VSS) capacitor c=1.0347e-16
C3 (A1N VSS) capacitor c=7.25065e-17
C4 (B0 VSS) capacitor c=5.38315e-17
C5 (n1 VSS) capacitor c=1.13345e-16
C6 (n0 VSS) capacitor c=9.15304e-17
C7 (n4 VSS) capacitor c=5.91037e-17
C8 (n3 VSS) capacitor c=6.6552e-18
C9 (\3\:B0 VSS) capacitor c=6.52235e-17
C10 (\1\:B1 VSS) capacitor c=7.39996e-17
C11 (\1\:A0N VSS) capacitor c=4.50919e-17
C12 (\1\:A1N VSS) capacitor c=3.10674e-17
C13 (\1\:B0 VSS) capacitor c=4.25192e-17
C14 (\3\:B1 VSS) capacitor c=4.46387e-17
C15 (\2\:n1 VSS) capacitor c=4.9018e-17
C16 (\3\:n0 VSS) capacitor c=3.11316e-17
C17 (\3\:A0N VSS) capacitor c=3.35019e-17
C18 (\3\:A1N VSS) capacitor c=4.16353e-17
C19 (\4\:B0 VSS) capacitor c=1.22587e-17
C20 (\2\:B1 VSS) capacitor c=5.92715e-17
C21 (\3\:n1 VSS) capacitor c=2.53512e-17
C22 (\2\:n0 VSS) capacitor c=3.88134e-17
C23 (\2\:A0N VSS) capacitor c=3.59187e-17
C24 (\2\:A1N VSS) capacitor c=3.97656e-17
C25 (\9\:VDD VSS) capacitor c=2.55734e-17
C26 (\3\:Y VSS) capacitor c=1.33311e-16
C27 (\1\:VDD VSS) capacitor c=1.09252e-17
C28 (\8\:n0 VSS) capacitor c=3.71495e-17
C29 (\11\:VDD VSS) capacitor c=2.78596e-17
C30 (\7\:n1 VSS) capacitor c=6.53757e-17
C31 (\4\:VDD VSS) capacitor c=3.43135e-17
C32 (\1\:Y VSS) capacitor c=1.09265e-16
C33 (\3\:n4 VSS) capacitor c=1.89158e-16
C34 (\5\:n4 VSS) capacitor c=1.43442e-16
C35 (\6\:n0 VSS) capacitor c=5.98678e-17
C36 (\5\:n1 VSS) capacitor c=2.21205e-16
C37 (\2\:B0 VSS) capacitor c=4.41298e-17
C38 (\4\:A1N VSS) capacitor c=5.28362e-17
C39 (\4\:A0N VSS) capacitor c=2.53826e-17
C40 (\4\:n0 VSS) capacitor c=4.04103e-17
C41 (\5\:n0 VSS) capacitor c=6.67238e-17
C42 (\4\:n1 VSS) capacitor c=2.31468e-16
C43 (\4\:B1 VSS) capacitor c=1.25716e-16
C44 (\5\:B0 VSS) capacitor c=4.08739e-17
C45 (\3\:VDD VSS) capacitor c=1.4155e-17
C46 (\6\:VDD VSS) capacitor c=5.83252e-18
Rk10 (\4\:B1 B1) resistor r=0.003 c=0
Rk11 (\2\:Y Y) resistor r=0.715 c=0
Rk12 (Y \4\:Y) resistor r=0.003012 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.2273 c=0
Rk17 (\3\:VDD \5\:VDD) resistor r=0.2029 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.2681 c=0
Rk20 (\7\:VDD VDD) resistor r=0.0499 c=0
Rk19 (\6\:VDD \7\:VDD) resistor r=0.08255 c=0
Rk21 (\3\:VDD \8\:VDD) resistor r=0.248 c=0
Rk22 (\8\:VDD \10\:VDD) resistor r=0.2803 c=0
Rk23 (\6\:VDD \12\:VDD) resistor r=0.2974 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.2455 c=0
Rk25 (\3\:VSS \4\:VSS) resistor r=0.2054 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.238 c=0
Rk28 (\6\:VSS VSS) resistor r=0.0499 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.06249 c=0
Rk29 (\3\:VSS \8\:VSS) resistor r=0.275 c=0
Rk30 (\5\:VSS \10\:VSS) resistor r=0.07381 c=0
Rk4 (\4\:A0N A0N) resistor r=0.009001 c=0
Rk1 (A1N \4\:A1N) resistor r=0.165 c=0
Rk15 (B0 \5\:B0) resistor r=0.1827 c=0
Rk8 (\4\:n1 \6\:n1) resistor r=1.6729 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.5418 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.267 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.3793 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.1828 c=0
Rk13 (\2\:n4 \4\:n4) resistor r=0.5383 c=0
Rk14 (\4\:n4 \6\:n4) resistor r=1.0234 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=116.076 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=131.461 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=149.175 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=35.7134 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=41.0764 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=150.692 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=124.51 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=166.77 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=4.5402 c=0
Rl7 (n1 \2\:n1) resistor r=273.077 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=37.2302 c=0
Rl5 (n0 \2\:n0) resistor r=203.4 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=149.233 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\4\:VDD \5\:VDD) resistor r=15 c=0
Rz8 (\4\:VDD \7\:VDD) resistor r=37.5 c=0
Rz9 (\4\:VDD \8\:VDD) resistor r=18.75 c=0
Rz10 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz11 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz2 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz6 (\5\:n4 \6\:n4) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry9 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx4 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\5\:n1 \3\:A1N \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.465e-14 ps=1.32e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\6\:n0 \3\:A0N \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=3.19e-14 ps=1.32e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2.2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:n4 \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=3.698e-14 ps=1.01e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.005e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn3 (\3\:n4 \2\:n1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.32e-14 ps=1.01e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=6e-07 sd=160n sca=8.70265 scb=0.00681258 \
        scc=0.000126945 m=(1)
mn5 (\1\:Y \3\:B1 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.95e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn4 (\1\:Y \1\:B0 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.045e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mp0 (\8\:n0 \1\:A0N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.16e-14 ps=7.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.4e-07 sd=160n sca=15.1467 \
        scb=0.0140576 scc=0.000405776 m=(1)
mp2 (n2 n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.6631 scb=0.00766851 \
        scc=8.4038e-05 m=(1)
mp3 (\3\:Y n1 n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.5e-07 sd=160n sca=11.0775 scb=0.00792476 \
        scc=8.42509e-05 m=(1)
mp5 (\3\:Y \1\:B1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.45e-07 sd=160n sca=12.6898 \
        scb=0.00990074 scc=9.48225e-05 m=(1)
mp4 (n3 \3\:B0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=14.5245 \
        scb=0.0130308 scc=0.000155148 m=(1)
ends OAI2BB2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:50:54 2012 )
// Library name: gsclib045
// Cell name: OAI31X1
// View name: extracted

simulator lang=spectre

subckt OAI31X1 A0 A1 A2 B0 VDD VSS Y
mp0 (n2 \1\:A0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=15.9959 \
        scb=0.0151266 scc=0.000303017 m=(1)
C1 (A0 VSS) capacitor c=4.22066e-17
C2 (B0 VSS) capacitor c=8.34264e-17
C3 (Y VSS) capacitor c=8.96908e-17
C4 (A2 VSS) capacitor c=1.21011e-16
C5 (VDD VSS) capacitor c=7.9664e-17
C6 (A1 VSS) capacitor c=4.69265e-17
C7 (n0 VSS) capacitor c=8.29615e-17
C8 (n1 VSS) capacitor c=2.06673e-18
C9 (\3\:B0 VSS) capacitor c=3.86178e-17
C10 (\3\:A2 VSS) capacitor c=5.88785e-17
C11 (\1\:A1 VSS) capacitor c=1.04471e-16
C12 (\1\:A0 VSS) capacitor c=9.54768e-17
C13 (\1\:B0 VSS) capacitor c=4.93739e-17
C14 (\1\:A2 VSS) capacitor c=5.40773e-17
C15 (\3\:A1 VSS) capacitor c=4.33991e-17
C16 (\4\:A0 VSS) capacitor c=3.67732e-17
C17 (\2\:B0 VSS) capacitor c=4.3291e-17
C18 (\2\:A2 VSS) capacitor c=5.59483e-17
C19 (\2\:A1 VSS) capacitor c=6.54322e-17
C20 (\3\:A0 VSS) capacitor c=1.34257e-17
C21 (\6\:VDD VSS) capacitor c=4.40072e-17
C22 (\3\:Y VSS) capacitor c=1.27349e-16
C23 (\8\:VDD VSS) capacitor c=3.73228e-17
C24 (\1\:VDD VSS) capacitor c=2.15532e-17
C25 (\1\:Y VSS) capacitor c=2.76282e-17
C26 (\3\:n0 VSS) capacitor c=7.20689e-17
C27 (\2\:A0 VSS) capacitor c=5.09101e-17
C28 (\5\:A0 VSS) capacitor c=2.65487e-17
C29 (\4\:A1 VSS) capacitor c=5.63239e-17
C30 (\5\:B0 VSS) capacitor c=4.12704e-17
C31 (\3\:VDD VSS) capacitor c=1.12084e-17
C32 (\5\:VDD VSS) capacitor c=4.76365e-18
Rk1 (\5\:A0 A0) resistor r=0.1432 c=0
Rk7 (B0 \5\:B0) resistor r=0.06633 c=0
Rk8 (\2\:Y Y) resistor r=0.07668 c=0
Rk9 (Y \4\:Y) resistor r=0.8007 c=0
Rk3 (\4\:A2 A2) resistor r=0.003 c=0
Rk10 (\2\:VDD \3\:VDD) resistor r=0.0675 c=0
Rk11 (\3\:VDD \4\:VDD) resistor r=0.233 c=0
Rk13 (\5\:VDD VDD) resistor r=0.08731 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1126 c=0
Rk14 (\3\:VDD \7\:VDD) resistor r=0.2228 c=0
Rk15 (\5\:VDD \9\:VDD) resistor r=0.264 c=0
Rk2 (A1 \4\:A1) resistor r=0.225 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.1543 c=0
Rk17 (\3\:VSS \4\:VSS) resistor r=0.09414 c=0
Rk19 (\5\:VSS VSS) resistor r=0.03716 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.1126 c=0
Rk21 (\3\:VSS \8\:VSS) resistor r=0.1185 c=0
Rk22 (\5\:VSS \10\:VSS) resistor r=0.2228 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.4289 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=178.356 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=51.385 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=4.5402 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=37.6374 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=169.231 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=76.098 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=122.252 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=148.769 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=56.461 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz1 (n0 \2\:n0) resistor r=37.5 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry3 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \4\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:n0 \3\:A1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (n0 \1\:A2 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.55e-14 ps=8.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.55e-14 \
        ad=3.64e-14 ps=8.7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=7.8e-07 \
        sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 scc=9.84911e-05 \
        m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.07e-14 \
        ad=2.34e-14 ps=1.04e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.2e-07 sd=160n sca=14.532 scb=0.0121946 \
        scc=0.000242813 m=(1)
mp2 (\3\:Y \3\:A2 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.07e-14 \
        ad=6.24e-14 ps=1.04e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.2e-07 sb=3.45e-07 sd=160n sca=14.1757 scb=0.0114808 \
        scc=0.000235907 m=(1)
mp3 (\3\:Y \3\:B0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.4e-07 sd=160n sca=16.9977 \
        scb=0.017051 scc=0.00037561 m=(1)
ends OAI31X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:51:32 2012 )
// Library name: gsclib045
// Cell name: OAI31X2
// View name: extracted

simulator lang=spectre

subckt OAI31X2 A0 A1 A2 B0 VDD VSS Y
mp0 (3 \1\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.505e-06 sd=160n sca=15.7135 \
        scb=0.0146768 scc=0.000444335 m=(1)
C1 (A0 VSS) capacitor c=4.88099e-16
C2 (A1 VSS) capacitor c=1.47379e-17
C3 (Y VSS) capacitor c=1.68157e-17
C4 (A2 VSS) capacitor c=5.87673e-17
C5 (B0 VSS) capacitor c=6.98595e-17
C6 (VDD VSS) capacitor c=9.64126e-17
C7 (n0 VSS) capacitor c=2.97886e-16
C8 (3 VSS) capacitor c=9.07464e-20
C9 (4 VSS) capacitor c=9.96283e-20
C10 (6 VSS) capacitor c=4.04974e-18
C11 (7 VSS) capacitor c=4.86917e-18
C12 (\6\:A0 VSS) capacitor c=6.28802e-17
C13 (\4\:A1 VSS) capacitor c=7.06922e-17
C14 (\1\:A2 VSS) capacitor c=3.5653e-17
C15 (\5\:A2 VSS) capacitor c=2.97658e-17
C16 (\1\:A1 VSS) capacitor c=7.89405e-17
C17 (\1\:A0 VSS) capacitor c=7.91161e-17
C18 (\1\:B0 VSS) capacitor c=6.74617e-17
C19 (\2\:A2 VSS) capacitor c=3.04868e-17
C20 (\2\:A1 VSS) capacitor c=3.52039e-16
C21 (\1\:VDD VSS) capacitor c=1.12623e-16
C22 (\4\:Y VSS) capacitor c=9.73227e-17
C23 (\6\:Y VSS) capacitor c=6.64214e-17
C24 (\9\:VDD VSS) capacitor c=2.80019e-17
C25 (\1\:Y VSS) capacitor c=7.37852e-17
C26 (\3\:A2 VSS) capacitor c=1.06212e-16
C27 (\3\:B0 VSS) capacitor c=7.30234e-17
C28 (\7\:A2 VSS) capacitor c=6.53483e-17
C29 (\3\:Y VSS) capacitor c=7.16433e-17
C30 (\7\:B0 VSS) capacitor c=2.79806e-17
C31 (\5\:VDD VSS) capacitor c=2.73278e-17
C32 (\6\:VDD VSS) capacitor c=1.36679e-17
Rk3 (\2\:A1 A1) resistor r=0.02427 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.2473 c=0
Rk30 (\8\:VSS VSS) resistor r=0.04976 c=0
Rk29 (\3\:VSS \8\:VSS) resistor r=0.08231 c=0
Rk32 (\3\:VSS \12\:VSS) resistor r=0.1015 c=0
Rk9 (\3\:Y Y) resistor r=0.01229 c=0
Rk7 (\2\:Y \3\:Y) resistor r=0.5074 c=0
Rk8 (\3\:Y \5\:Y) resistor r=0.02358 c=0
Rk10 (\5\:Y \7\:Y) resistor r=0.5598 c=0
Rk4 (A2 \7\:A2) resistor r=0.02393 c=0
Rk13 (\7\:B0 B0) resistor r=0.05078 c=0
Rk19 (\1\:VDD \5\:VDD) resistor r=0.1748 c=0
Rk21 (\6\:VDD VDD) resistor r=0.1096 c=0
Rk20 (\5\:VDD \6\:VDD) resistor r=0.3899 c=0
Rk23 (\6\:VDD \10\:VDD) resistor r=0.291 c=0
Rl13 (A0 \6\:A0) resistor r=101.06 c=0
Rl1 (A0 \1\:A0) resistor r=111.004 c=0
Rl10 (\2\:A1 \4\:A1) resistor r=87.2302 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=87.2302 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=21.9779 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=77.1158 c=0
Rl6 (\3\:A2 \2\:A2) resistor r=58.1371 c=0
Rl15 (\3\:B0 \1\:B0) resistor r=69.0037 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry7 (\3\:VSS \1\:VSS) resistor r=12.4 c=0
Ry9 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry5 (\10\:VDD \9\:VDD) resistor r=20.6667 c=0
Rx3 (\7\:A2 \2\:A2) resistor r=45 c=0
Rx6 (\7\:B0 \1\:B0) resistor r=45 c=0
mn0 (n0 A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=9.26e-14 \
        ad=4.42e-14 ps=1.55e-06 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.795e-06 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(2)
mn1 (n0 \2\:A1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.26e-14 ad=4.16e-14 ps=1.55e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.53e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(2)
mn2 (n0 \3\:A2 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.26e-14 ad=4.16e-14 ps=1.55e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.325e-06 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(2)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.59e-06 sb=3.45e-07 sd=160n sca=14.8545 scb=0.0148797 \
        scc=0.00110433 m=(2)
mp1 (3 \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=1.0335e-13 \
        ad=2.34e-14 ps=1.31e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-06 sd=160n sca=14.3102 scb=0.0124442 \
        scc=0.000417178 m=(1)
mp2 (\6\:Y \5\:A2 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.24e-14 ps=1.31e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.09e-06 sd=160n sca=12.6509 \
        scb=0.0108992 scc=0.000412427 m=(1)
mp2_1__rcx (\6\:Y \1\:A2 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=8.85e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp1_1__rcx (6 \4\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.485e-14 ps=1.04e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=7.25e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp0_1__rcx (7 \6\:A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.07e-14 ps=1.1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=5.5e-07 sd=160n sca=12.6936 \
        scb=0.0109155 scc=0.000412431 m=(1)
mp3 (\4\:Y \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=3.45e-07 sd=160n sca=13.5897 \
        scb=0.0115632 scc=0.000413321 m=(2)
ends OAI31X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:52:10 2012 )
// Library name: gsclib045
// Cell name: OAI31X4
// View name: extracted

simulator lang=spectre

subckt OAI31X4 A0 A1 A2 B0 VDD VSS Y
mp0_1__rcx (3 \1\:A0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.9706 scb=0.0178952 \
        scc=0.000725233 m=(1)
C1 (A2 VSS) capacitor c=4.80447e-16
C2 (A0 VSS) capacitor c=2.5678e-17
C3 (A1 VSS) capacitor c=8.34399e-16
C4 (Y VSS) capacitor c=2.94821e-17
C5 (VDD VSS) capacitor c=1.91469e-16
C6 (n0 VSS) capacitor c=5.40531e-16
C7 (4 VSS) capacitor c=8.75165e-18
C8 (6 VSS) capacitor c=2.23753e-18
C9 (7 VSS) capacitor c=9.96539e-18
C10 (8 VSS) capacitor c=7.14868e-18
C11 (9 VSS) capacitor c=9.49966e-18
C12 (10 VSS) capacitor c=9.75673e-18
C13 (11 VSS) capacitor c=5.54553e-18
C14 (\13\:A0 VSS) capacitor c=4.32839e-17
C15 (\10\:A1 VSS) capacitor c=5.87975e-17
C16 (\12\:A2 VSS) capacitor c=3.68011e-17
C17 (\11\:A2 VSS) capacitor c=2.69477e-17
C18 (\9\:A1 VSS) capacitor c=4.5856e-17
C19 (\4\:A0 VSS) capacitor c=3.13434e-17
C20 (\9\:A0 VSS) capacitor c=2.39627e-17
C21 (\4\:A1 VSS) capacitor c=7.53492e-17
C22 (\1\:A2 VSS) capacitor c=6.39519e-17
C23 (\5\:A2 VSS) capacitor c=2.28873e-17
C24 (\1\:A1 VSS) capacitor c=8.27436e-17
C25 (\1\:A0 VSS) capacitor c=6.64063e-17
C26 (\1\:B0 VSS) capacitor c=3.35064e-16
C27 (\2\:A0 VSS) capacitor c=8.57209e-16
C28 (\1\:VDD VSS) capacitor c=1.81473e-16
C29 (\1\:Y VSS) capacitor c=2.05135e-16
C30 (\13\:Y VSS) capacitor c=2.03285e-17
C31 (\14\:VDD VSS) capacitor c=3.56876e-17
C32 (\11\:Y VSS) capacitor c=1.37471e-16
C33 (\16\:VDD VSS) capacitor c=3.57162e-17
C34 (\4\:VDD VSS) capacitor c=4.19818e-17
C35 (\4\:Y VSS) capacitor c=1.52026e-16
C36 (\2\:A2 VSS) capacitor c=3.53052e-17
C37 (\10\:A2 VSS) capacitor c=2.23816e-17
C38 (\10\:Y VSS) capacitor c=1.8051e-16
C39 (\7\:VDD VSS) capacitor c=3.15129e-17
C40 (\9\:VDD VSS) capacitor c=1.61643e-17
Rk20 (\1\:B0 B0) resistor r=0.009285 c=0
Rk9 (\2\:A0 A0) resistor r=0.01764 c=0
Rk51 (\1\:VSS VSS) resistor r=0.04986 c=0
Rk12 (\1\:Y Y) resistor r=0.02446 c=0
Rk13 (Y \4\:Y) resistor r=0.3546 c=0
Rk16 (\1\:Y \10\:Y) resistor r=0.6786 c=0
Rk17 (\10\:Y \12\:Y) resistor r=1.0047 c=0
Rk18 (\10\:Y \14\:Y) resistor r=0.05744 c=0
Rk32 (\1\:VDD \7\:VDD) resistor r=0.6686 c=0
Rk33 (\7\:VDD \8\:VDD) resistor r=0.1602 c=0
Rk35 (\9\:VDD VDD) resistor r=0.08475 c=0
Rk34 (\8\:VDD \9\:VDD) resistor r=0.4659 c=0
Rk38 (\7\:VDD \15\:VDD) resistor r=0.2226 c=0
Rk39 (\9\:VDD \17\:VDD) resistor r=0.3056 c=0
Rl6 (\2\:A2 A2) resistor r=71.9912 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=65.3625 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=67.2856 c=0
Rl22 (\10\:A2 A2) resistor r=77.3125 c=0
Rl24 (\10\:A2 \12\:A2) resistor r=100.426 c=0
Rl23 (\10\:A2 \11\:A2) resistor r=35.772 c=0
Rl28 (\2\:A0 \13\:A0) resistor r=26.3736 c=0
Rl12 (\2\:A0 \4\:A0) resistor r=68.032 c=0
Rl16 (\2\:A0 \9\:A0) resistor r=34.3295 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=39.6174 c=0
Rl25 (A1 \10\:A1) resistor r=114.153 c=0
Rl19 (A1 \9\:A1) resistor r=56.8681 c=0
Rl10 (A1 \4\:A1) resistor r=56.461 c=0
Rl3 (A1 \1\:A1) resistor r=114.153 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\8\:VDD \4\:VDD) resistor r=6.25 c=0
Ry3 (\12\:Y \11\:Y) resistor r=31 c=0
Ry4 (\14\:Y \13\:Y) resistor r=31 c=0
Ry8 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry9 (\17\:VDD \16\:VDD) resistor r=20.6667 c=0
mn0_1__rcx (n0 \2\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.485e-14 ps=1.43e-06 pd=8.65e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn1_1__rcx (n0 A1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2_1__rcx (n0 A2 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn3_1__rcx (\4\:Y \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mp1_1__rcx (3 \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=2.34e-14 ps=1.42e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.0776 scb=0.014648 \
        scc=0.000659357 m=(1)
mp2_1__rcx (\11\:Y \5\:A2 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=6.24e-14 ps=1.42e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=13.8386 scb=0.012255 \
        scc=0.000647525 m=(1)
mp2_2__rcx (\11\:Y \1\:A2 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (6 \4\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (7 \9\:A0 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=8.58e-14 ps=1.11e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0 (8 \4\:A0 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (11 \13\:A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=5.655e-14 ps=1.19e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (\1\:Y \1\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp1 (8 \9\:A1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.385e-14 \
        ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.6e-06 sb=1.925e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2 (\13\:Y \11\:A2 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86e-06 sb=1.665e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2_3__rcx (\13\:Y \12\:A2 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.46e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (10 \10\:A1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=8.58e-14 ps=1.07e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.195e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
ends OAI31X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:52:47 2012 )
// Library name: gsclib045
// Cell name: OAI31XL
// View name: extracted

simulator lang=spectre

subckt OAI31XL A0 A1 A2 B0 VDD VSS Y
mp0 (n2 \1\:A0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.05e-07 sd=160n sca=16.0188 \
        scb=0.015713 scc=0.000313368 m=(1)
C1 (A0 VSS) capacitor c=5.71704e-17
C2 (B0 VSS) capacitor c=1.32084e-16
C3 (Y VSS) capacitor c=7.92159e-17
C4 (A2 VSS) capacitor c=7.60418e-17
C5 (VDD VSS) capacitor c=1.00551e-16
C6 (A1 VSS) capacitor c=1.60347e-17
C7 (n0 VSS) capacitor c=6.73503e-17
C8 (\1\:B0 VSS) capacitor c=4.05708e-17
C9 (\1\:A2 VSS) capacitor c=5.42234e-17
C10 (\1\:A1 VSS) capacitor c=5.30086e-17
C11 (\1\:A0 VSS) capacitor c=7.75964e-17
C12 (\3\:B0 VSS) capacitor c=3.15911e-17
C13 (\3\:A2 VSS) capacitor c=3.9178e-17
C14 (\3\:A1 VSS) capacitor c=5.97041e-17
C15 (\4\:A0 VSS) capacitor c=2.91738e-17
C16 (\2\:B0 VSS) capacitor c=4.79899e-17
C17 (\2\:A2 VSS) capacitor c=5.83156e-17
C18 (\2\:A1 VSS) capacitor c=6.69765e-17
C19 (\3\:A0 VSS) capacitor c=1.16046e-17
C20 (\6\:VDD VSS) capacitor c=3.42607e-17
C21 (\3\:Y VSS) capacitor c=7.44513e-17
C22 (\8\:VDD VSS) capacitor c=1.74903e-17
C23 (\1\:VDD VSS) capacitor c=1.77123e-17
C24 (\1\:Y VSS) capacitor c=6.73879e-17
C25 (\3\:n0 VSS) capacitor c=7.85278e-17
C26 (\2\:A0 VSS) capacitor c=3.71975e-17
C27 (\4\:A1 VSS) capacitor c=7.64523e-17
C28 (\4\:A2 VSS) capacitor c=4.53125e-17
C29 (\3\:VDD VSS) capacitor c=9.62603e-18
C30 (\5\:VDD VSS) capacitor c=2.39877e-18
Rk1 (\5\:A0 A0) resistor r=0.002987 c=0
Rk6 (\2\:Y Y) resistor r=0.5268 c=0
Rk7 (Y \4\:Y) resistor r=0.2612 c=0
Rk3 (A2 \4\:A2) resistor r=0.1105 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.08482 c=0
Rk9 (\3\:VDD \4\:VDD) resistor r=0.2648 c=0
Rk11 (\5\:VDD VDD) resistor r=0.07956 c=0
Rk10 (\4\:VDD \5\:VDD) resistor r=0.1198 c=0
Rk12 (\3\:VDD \7\:VDD) resistor r=0.2756 c=0
Rk13 (\5\:VDD \9\:VDD) resistor r=0.2712 c=0
Rk2 (\4\:A1 A1) resistor r=0.0239 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.2148 c=0
Rk16 (\4\:VSS VSS) resistor r=0.1001 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.1348 c=0
Rk17 (VSS \6\:VSS) resistor r=0.181 c=0
Rk18 (\3\:VSS \8\:VSS) resistor r=0.1774 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.4883 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=213.83 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=104.649 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.6709 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=162.23 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=96.8456 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=158.384 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=100.692 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=229.538 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 B0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (n0 \4\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.19e-14 ps=5.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (n0 \3\:A1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\3\:n0 \3\:A2 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \3\:B0 \3\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.19e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2.2e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6e-07 sd=160n sca=14.06 scb=0.0122317 \
        scc=0.00023485 m=(1)
mp2 (\3\:Y \1\:A2 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.95e-07 sd=160n sca=12.9232 \
        scb=0.0102558 scc=0.000221094 m=(1)
mp3 (\3\:Y \1\:B0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.4e-07 sd=160n sca=14.0029 \
        scb=0.0121262 scc=0.000233621 m=(1)
ends OAI31XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:24:21 2012 )
// Library name: gsclib045
// Cell name: OAI32X1
// View name: extracted

simulator lang=spectre

subckt OAI32X1 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (n2 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.25e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
C1 (A2 VSS) capacitor c=5.958e-17
C2 (A1 VSS) capacitor c=5.56388e-17
C3 (Y VSS) capacitor c=2.468e-17
C4 (VDD VSS) capacitor c=8.26706e-17
C5 (A0 VSS) capacitor c=3.54303e-17
C6 (n0 VSS) capacitor c=9.43358e-17
C7 (n2 VSS) capacitor c=7.98026e-18
C8 (n1 VSS) capacitor c=5.42414e-18
C9 (\3\:B0 VSS) capacitor c=7.89868e-17
C10 (\1\:B1 VSS) capacitor c=6.52769e-17
C11 (\4\:A2 VSS) capacitor c=4.20152e-17
C12 (\3\:A1 VSS) capacitor c=4.71145e-17
C13 (\1\:A0 VSS) capacitor c=4.39655e-17
C14 (\1\:B0 VSS) capacitor c=3.05661e-17
C15 (\3\:B1 VSS) capacitor c=5.35683e-17
C16 (\1\:A2 VSS) capacitor c=4.40458e-17
C17 (\1\:A1 VSS) capacitor c=5.03474e-17
C18 (\4\:A0 VSS) capacitor c=4.01942e-17
C19 (\4\:B0 VSS) capacitor c=1.15653e-17
C20 (\2\:B1 VSS) capacitor c=5.22265e-17
C21 (\3\:A2 VSS) capacitor c=4.99611e-17
C22 (\2\:A1 VSS) capacitor c=5.9576e-17
C23 (\3\:A0 VSS) capacitor c=1.34193e-17
C24 (\1\:VDD VSS) capacitor c=5.0103e-17
C25 (\3\:Y VSS) capacitor c=1.38262e-16
C26 (\5\:VDD VSS) capacitor c=5.98643e-17
C27 (\1\:Y VSS) capacitor c=1.1651e-16
C28 (\3\:n0 VSS) capacitor c=1.08506e-16
C29 (\5\:n0 VSS) capacitor c=7.22642e-17
C30 (\2\:A0 VSS) capacitor c=3.21084e-17
C31 (\2\:B0 VSS) capacitor c=2.9228e-17
C32 (\5\:A0 VSS) capacitor c=5.1118e-17
C33 (\4\:A1 VSS) capacitor c=7.35719e-17
C34 (\5\:A2 VSS) capacitor c=7.24368e-17
C35 (\5\:B1 VSS) capacitor c=4.04629e-17
C36 (\6\:B1 VSS) capacitor c=4.42863e-17
C37 (\5\:B0 VSS) capacitor c=1.08873e-16
C38 (\4\:VDD VSS) capacitor c=3.34424e-17
Rk16 (\3\:VSS VSS) resistor r=0.1905 c=0
Rk17 (VSS \5\:VSS) resistor r=0.2789 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2241 c=0
Rk3 (\5\:A2 A2) resistor r=0.174 c=0
Rk2 (A1 \4\:A1) resistor r=0.2255 c=0
Rk5 (\4\:Y Y) resistor r=0.1562 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.6299 c=0
Rk11 (B0 \5\:B0) resistor r=0.004147 c=0
Rk13 (\4\:VDD VDD) resistor r=0.301 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.5313 c=0
Rk14 (VDD \6\:VDD) resistor r=0.3525 c=0
Rk6 (\4\:B1 \5\:B1) resistor r=0.0031 c=0
Rk7 (B1 \6\:B1) resistor r=0.0031 c=0
Rk8 (\4\:B1 \6\:B1) resistor r=0.02257 c=0
Rk1 (A0 \5\:A0) resistor r=0.006797 c=0
Rk9 (\2\:n0 \4\:n0) resistor r=0.5778 c=0
Rk10 (\4\:n0 \6\:n0) resistor r=0.4262 c=0
Rl8 (\2\:A2 \4\:A2) resistor r=88.9346 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=71.7177 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=1.2666 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=105.746 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=117.577 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=26.5731 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=3.8588 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=26.9231 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=106.437 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=41.1873 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=106.572 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=2.4801 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (n0 \2\:n0) resistor r=37.5 c=0
Rz3 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Rx3 (\3\:A2 \5\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx4 (\2\:B1 \5\:B1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (\5\:n0 \4\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (\5\:n0 \1\:A1 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (\3\:n0 \1\:A2 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.5e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\1\:Y \3\:B1 \3\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=3.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=9.6e-07 \
        sb=1.4e-07 sd=160n sca=10.104 scb=0.00906063 scc=0.000325539 m=(1)
mp1 (n2 \3\:A1 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.215e-14 \
        ad=4.485e-14 ps=1.15e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=7.65e-07 sd=160n sca=21.3946 scb=0.02109 \
        scc=0.00137328 m=(1)
mp2 (\3\:Y \4\:A2 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=9.555e-14 ps=1.15e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.35e-07 sd=160n sca=18.501 \
        scb=0.0159575 scc=0.00128203 m=(1)
mp4 (\3\:Y \1\:B1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.555e-14 ps=9e-07 pd=1.27e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.2e-07 sb=2.45e-07 sd=160n sca=18.9491 scb=0.0167251 \
        scc=0.00128629 m=(1)
mp3 (n4 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.4e-07 sd=160n sca=20.266 \
        scb=0.0190952 scc=0.00131874 m=(1)
ends OAI32X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:54:01 2012 )
// Library name: gsclib045
// Cell name: OAI32X2
// View name: extracted

simulator lang=spectre

subckt OAI32X2 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (3 \1\:A0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=20.0993 \
        scb=0.0192799 scc=0.0012385 m=(1)
C1 (A0 VSS) capacitor c=4.85328e-16
C2 (A1 VSS) capacitor c=2.76205e-17
C3 (B0 VSS) capacitor c=3.21164e-17
C4 (VDD VSS) capacitor c=9.64244e-17
C5 (B1 VSS) capacitor c=3.80616e-17
C6 (Y VSS) capacitor c=3.48725e-17
C7 (A2 VSS) capacitor c=5.86971e-17
C8 (n0 VSS) capacitor c=3.35463e-16
C9 (3 VSS) capacitor c=1.24857e-18
C10 (4 VSS) capacitor c=1.52163e-18
C11 (6 VSS) capacitor c=6.05118e-18
C12 (7 VSS) capacitor c=5.15309e-18
C13 (8 VSS) capacitor c=1.73737e-18
C14 (\6\:B0 VSS) capacitor c=6.60103e-17
C15 (\6\:B1 VSS) capacitor c=4.43188e-17
C16 (\4\:B1 VSS) capacitor c=6.07282e-17
C17 (\1\:B0 VSS) capacitor c=8.63707e-17
C18 (\6\:A0 VSS) capacitor c=6.06096e-17
C19 (\4\:A1 VSS) capacitor c=5.69991e-17
C20 (\6\:A2 VSS) capacitor c=4.03681e-17
C21 (\5\:A2 VSS) capacitor c=2.44073e-17
C22 (\1\:A1 VSS) capacitor c=8.7569e-17
C23 (\1\:A0 VSS) capacitor c=8.25668e-17
C24 (\1\:B1 VSS) capacitor c=9.49935e-17
C25 (\1\:A2 VSS) capacitor c=1.01341e-16
C26 (\3\:B1 VSS) capacitor c=4.85001e-17
C27 (\2\:B0 VSS) capacitor c=3.16553e-16
C28 (\3\:A2 VSS) capacitor c=2.81478e-17
C29 (\2\:A1 VSS) capacitor c=3.63241e-16
C30 (\7\:VDD VSS) capacitor c=3.65331e-17
C31 (\9\:Y VSS) capacitor c=5.98789e-17
C32 (\9\:VDD VSS) capacitor c=3.53118e-17
C33 (\6\:Y VSS) capacitor c=5.71729e-17
C34 (\11\:VDD VSS) capacitor c=4.59859e-17
C35 (\1\:VDD VSS) capacitor c=2.61301e-17
C36 (\9\:n0 VSS) capacitor c=7.96369e-17
C37 (\1\:Y VSS) capacitor c=2.2233e-16
C38 (\7\:A2 VSS) capacitor c=4.34902e-17
C39 (\7\:B1 VSS) capacitor c=6.02875e-17
C40 (\5\:Y VSS) capacitor c=9.62057e-17
C41 (\3\:VDD VSS) capacitor c=1.65615e-17
C42 (\4\:VDD VSS) capacitor c=2.01755e-17
C43 (\6\:VDD VSS) capacitor c=1.4529e-17
Rk2 (A1 \2\:A1) resistor r=0.05061 c=0
Rk15 (\2\:B0 B0) resistor r=0.09124 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.08496 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.3903 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1751 c=0
Rk25 (\6\:VDD VDD) resistor r=0.09723 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.403 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.3383 c=0
Rk27 (\4\:VDD \10\:VDD) resistor r=0.1581 c=0
Rk28 (\6\:VDD \12\:VDD) resistor r=0.3383 c=0
Rk7 (B1 \7\:B1) resistor r=0.1011 c=0
Rk10 (\5\:Y Y) resistor r=0.08382 c=0
Rk9 (\1\:Y \5\:Y) resistor r=0.6159 c=0
Rk11 (Y \7\:Y) resistor r=0.3161 c=0
Rk12 (\7\:Y \8\:Y) resistor r=0.1458 c=0
Rk13 (\5\:Y \10\:Y) resistor r=0.447 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.2152 c=0
Rk34 (\7\:VSS VSS) resistor r=0.04984 c=0
Rk33 (\3\:VSS \7\:VSS) resistor r=0.06492 c=0
Rk36 (\3\:VSS \11\:VSS) resistor r=0.1018 c=0
Rk1 (\7\:A2 A2) resistor r=0.2015 c=0
Rl13 (A0 \6\:A0) resistor r=103.079 c=0
Rl1 (A0 \1\:A0) resistor r=124.566 c=0
Rl10 (\2\:A1 \4\:A1) resistor r=79.9442 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=90.1797 c=0
Rl22 (\2\:B0 \6\:B0) resistor r=105.708 c=0
Rl14 (\2\:B0 \1\:B0) resistor r=94.9225 c=0
Rl20 (\3\:B1 \6\:B1) resistor r=42.1458 c=0
Rl18 (\3\:B1 \4\:B1) resistor r=56.2772 c=0
Rl17 (\1\:B1 \3\:B1) resistor r=60.4528 c=0
Rl9 (\3\:A2 \6\:A2) resistor r=105.323 c=0
Rl8 (\3\:A2 \5\:A2) resistor r=24.2328 c=0
Rl6 (\1\:A2 \3\:A2) resistor r=68.1451 c=0
Rz9 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz10 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Rz12 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (n0 \9\:n0) resistor r=75 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry1 (\7\:Y \6\:Y) resistor r=62 c=0
Ry2 (\8\:Y \6\:Y) resistor r=62 c=0
Ry3 (\10\:Y \9\:Y) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\7\:VSS \1\:VSS) resistor r=31 c=0
Rx6 (\7\:B1 \3\:B1) resistor r=45 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
mn0 (n0 A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=8.18e-14 \
        ad=4.55e-14 ps=1.37e-06 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=9.50447 scb=0.0081528 \
        scc=0.00025289 m=(2)
mn1 (n0 \2\:A1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=4.16e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.95e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn2 (n0 \1\:A2 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=4.16e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.745e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn3 (\1\:Y \2\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.55e-14 \
        ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.6e-06 sb=7.55e-07 sd=160n sca=9.50447 scb=0.0081528 \
        scc=0.00025289 m=(2)
mn4 (\1\:Y \1\:B1 \9\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.5e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mp1 (3 \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.41e-14 \
        ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.765e-06 sd=160n sca=18.4756 scb=0.0165821 \
        scc=0.00119613 m=(1)
mp2 (\6\:Y \5\:A2 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.41e-14 \
        ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=1.53e-06 sd=160n sca=16.8836 scb=0.0148184 \
        scc=0.00118871 m=(1)
mp2_1__rcx (\6\:Y \6\:A2 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=6.24e-14 ps=1.14e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=1.325e-06 sd=160n sca=16.3055 \
        scb=0.014587 scc=0.00118861 m=(1)
mp1_1__rcx (6 \4\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.1e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp4_1__rcx (\9\:Y \4\:B1 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.75e-07 sd=160n sca=16.6397 \
        scb=0.0146915 scc=0.00118864 m=(1)
mp0_1__rcx (7 \6\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=5.265e-14 ps=1.63e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=9.2e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3_1__rcx (8 \1\:B0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=2.34e-14 ps=1.63e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.8e-07 sd=160n sca=16.3679 \
        scb=0.0146009 scc=0.00118861 m=(1)
mp4 (\9\:Y \6\:B1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.315e-14 \
        ad=6.24e-14 ps=9.5e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.74e-06 sb=2.7e-07 sd=160n sca=17.591 scb=0.0154265 \
        scc=0.00118981 m=(1)
mp3 (9 \6\:B0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.315e-14 ps=1.06e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.4e-07 sd=160n sca=18.843 \
        scb=0.0171484 scc=0.00120158 m=(1)
ends OAI32X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:54:39 2012 )
// Library name: gsclib045
// Cell name: OAI32X4
// View name: extracted

simulator lang=spectre

subckt OAI32X4 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (3 \1\:A0 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.1962 scb=0.0165264 \
        scc=0.000689254 m=(1)
C1 (A0 VSS) capacitor c=1.51232e-17
C2 (A1 VSS) capacitor c=8.34268e-16
C3 (B0 VSS) capacitor c=2.37216e-17
C4 (VDD VSS) capacitor c=2.48489e-16
C5 (B1 VSS) capacitor c=3.97533e-16
C6 (Y VSS) capacitor c=1.08397e-17
C7 (A2 VSS) capacitor c=4.59104e-16
C8 (n0 VSS) capacitor c=6.67622e-16
C9 (3 VSS) capacitor c=1.56659e-18
C10 (4 VSS) capacitor c=7.85867e-18
C11 (6 VSS) capacitor c=2.44041e-18
C12 (7 VSS) capacitor c=1.60048e-17
C13 (8 VSS) capacitor c=2.44041e-18
C14 (9 VSS) capacitor c=9.8578e-18
C15 (10 VSS) capacitor c=9.28055e-18
C16 (11 VSS) capacitor c=6.77142e-18
C17 (12 VSS) capacitor c=4.03715e-18
C18 (13 VSS) capacitor c=2.44041e-18
C19 (14 VSS) capacitor c=2.44041e-18
C20 (15 VSS) capacitor c=1.56659e-18
C21 (\12\:B0 VSS) capacitor c=5.86066e-17
C22 (\12\:B1 VSS) capacitor c=6.30944e-17
C23 (\10\:B1 VSS) capacitor c=6.93265e-17
C24 (\9\:B0 VSS) capacitor c=5.62168e-17
C25 (\7\:B0 VSS) capacitor c=7.55822e-17
C26 (\6\:B1 VSS) capacitor c=6.51264e-17
C27 (\5\:B1 VSS) capacitor c=5.52576e-17
C28 (\1\:B0 VSS) capacitor c=5.9538e-17
C29 (\12\:A0 VSS) capacitor c=4.91253e-17
C30 (\10\:A1 VSS) capacitor c=4.33131e-17
C31 (\12\:A2 VSS) capacitor c=3.88761e-17
C32 (\11\:A2 VSS) capacitor c=2.62898e-17
C33 (\9\:A1 VSS) capacitor c=7.31081e-17
C34 (\4\:A0 VSS) capacitor c=7.92986e-17
C35 (\8\:A0 VSS) capacitor c=1.86036e-17
C36 (\4\:A1 VSS) capacitor c=7.03439e-17
C37 (\1\:A2 VSS) capacitor c=6.22419e-17
C38 (\5\:A2 VSS) capacitor c=2.49487e-17
C39 (\1\:A1 VSS) capacitor c=7.18736e-17
C40 (\1\:A0 VSS) capacitor c=6.07987e-17
C41 (\2\:B0 VSS) capacitor c=6.14279e-16
C42 (\2\:A0 VSS) capacitor c=8.90682e-16
C43 (\11\:VDD VSS) capacitor c=1.82166e-17
C44 (\17\:Y VSS) capacitor c=7.60857e-17
C45 (\13\:VDD VSS) capacitor c=3.48847e-17
C46 (\15\:Y VSS) capacitor c=9.27402e-17
C47 (\15\:VDD VSS) capacitor c=2.94095e-17
C48 (\11\:Y VSS) capacitor c=1.46215e-16
C49 (\17\:VDD VSS) capacitor c=3.89773e-17
C50 (\13\:Y VSS) capacitor c=1.21494e-16
C51 (\19\:VDD VSS) capacitor c=2.14969e-17
C52 (\1\:VDD VSS) capacitor c=8.06632e-17
C53 (\1\:Y VSS) capacitor c=3.45643e-16
C54 (\2\:A2 VSS) capacitor c=3.68757e-17
C55 (\10\:A2 VSS) capacitor c=2.25233e-17
C56 (\4\:B1 VSS) capacitor c=3.24096e-17
C57 (\9\:Y VSS) capacitor c=1.07647e-16
C58 (\10\:Y VSS) capacitor c=5.55392e-17
C59 (\3\:VDD VSS) capacitor c=1.82475e-18
C60 (\5\:VDD VSS) capacitor c=1.47451e-17
C61 (\6\:VDD VSS) capacitor c=1.56552e-17
C62 (\8\:VDD VSS) capacitor c=3.09173e-17
C63 (\10\:VDD VSS) capacitor c=1.21581e-17
Rk10 (\2\:A0 A0) resistor r=0.03156 c=0
Rk13 (B0 \2\:B0) resistor r=0.1123 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.1448 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.1548 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.1698 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.3472 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.1323 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.5024 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.3974 c=0
Rk45 (\10\:VDD VDD) resistor r=0.1021 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.2473 c=0
Rk46 (\3\:VDD \12\:VDD) resistor r=0.2217 c=0
Rk47 (\5\:VDD \14\:VDD) resistor r=0.2171 c=0
Rk48 (\6\:VDD \16\:VDD) resistor r=0.1775 c=0
Rk49 (\8\:VDD \18\:VDD) resistor r=0.2171 c=0
Rk50 (\10\:VDD \20\:VDD) resistor r=0.2217 c=0
Rk20 (\1\:Y \9\:Y) resistor r=0.5732 c=0
Rk25 (\10\:Y Y) resistor r=0.009903 c=0
Rk21 (\9\:Y \10\:Y) resistor r=0.3024 c=0
Rk22 (\10\:Y \12\:Y) resistor r=0.2417 c=0
Rk23 (\12\:Y \14\:Y) resistor r=0.9153 c=0
Rk24 (\9\:Y \16\:Y) resistor r=0.2873 c=0
Rk26 (\16\:Y \18\:Y) resistor r=0.4527 c=0
Rk63 (\1\:VSS VSS) resistor r=0.04976 c=0
Rl27 (\2\:A0 \12\:A0) resistor r=24.2328 c=0
Rl12 (\2\:A0 \4\:A0) resistor r=105.323 c=0
Rl15 (\2\:A0 \8\:A0) resistor r=24.2328 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=45.6195 c=0
Rl24 (A1 \10\:A1) resistor r=44.9225 c=0
Rl18 (A1 \9\:A1) resistor r=41.4826 c=0
Rl10 (A1 \4\:A1) resistor r=52.6149 c=0
Rl3 (A1 \1\:A1) resistor r=52.6149 c=0
Rl46 (\2\:B0 \12\:B0) resistor r=24.2328 c=0
Rl39 (\2\:B0 \9\:B0) resistor r=24.2328 c=0
Rl37 (\2\:B0 \7\:B0) resistor r=75.6352 c=0
Rl28 (\2\:B0 \1\:B0) resistor r=26.098 c=0
Rl44 (B1 \12\:B1) resistor r=52.6559 c=0
Rl42 (B1 \10\:B1) resistor r=99.9772 c=0
Rl32 (\4\:B1 B1) resistor r=6.3032 c=0
Rl34 (\4\:B1 \6\:B1) resistor r=74.564 c=0
Rl33 (\4\:B1 \5\:B1) resistor r=118.715 c=0
Rl6 (\2\:A2 A2) resistor r=71.9912 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=65.3625 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=67.2856 c=0
Rl21 (\10\:A2 A2) resistor r=77.3125 c=0
Rl23 (\10\:A2 \12\:A2) resistor r=100.426 c=0
Rl22 (\10\:A2 \11\:A2) resistor r=35.772 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=7.5 c=0
Rz19 (\1\:VDD \9\:VDD) resistor r=9.375 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry6 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry8 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry9 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry1 (\12\:Y \11\:Y) resistor r=62 c=0
Ry2 (\14\:Y \13\:Y) resistor r=62 c=0
Ry3 (\16\:Y \15\:Y) resistor r=62 c=0
Ry4 (\18\:Y \17\:Y) resistor r=62 c=0
mn0_1__rcx (n0 \2\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.03e-14 ps=1.43e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn1_1__rcx (n0 A1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2_1__rcx (n0 A2 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn3_1__rcx (\1\:Y \2\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn4_1__rcx (\1\:Y B1 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mp1 (3 \1\:A1 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=1.0725e-13 \
        ad=2.34e-14 ps=1.33e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=15.6659 scb=0.0140242 \
        scc=0.000653779 m=(1)
mp2 (\13\:Y \5\:A2 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=13.8663 scb=0.0122652 \
        scc=0.000647528 m=(1)
mp2_1__rcx (\13\:Y \1\:A2 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_1__rcx (6 \4\:A1 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=2.34e-14 ps=1.45e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_1__rcx (7 \8\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.3065e-13 ps=1.1e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (8 \4\:A0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (8 \9\:A1 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=2.34e-14 ps=1.19e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_2__rcx (\11\:Y \11\:A2 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_3__rcx (\11\:Y \12\:A2 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.96e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (10 \10\:A1 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=8.58e-14 ps=1.11e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.695e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_1__rcx (\15\:Y \5\:B1 12 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.07e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (11 \12\:A0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=6.435e-14 ps=1.34e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.485e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_1__rcx (12 \1\:B0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=4.095e-14 ps=1.34e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.22e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_2__rcx (\15\:Y \6\:B1 13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_2__rcx (13 \7\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp3_3__rcx (14 \9\:B0 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4_3__rcx (\17\:Y \10\:B1 14 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp4 (\17\:Y \12\:B1 15 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=13.9711 scb=0.0123086 \
        scc=0.000647543 m=(1)
mp3 (15 \12\:B0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.3777 scb=0.0125541 \
        scc=0.000647737 m=(1)
ends OAI32X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:55:16 2012 )
// Library name: gsclib045
// Cell name: OAI32XL
// View name: extracted

simulator lang=spectre

subckt OAI32XL A0 A1 A2 B0 B1 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=15.8878 \
        scb=0.0154804 scc=0.000305546 m=(1)
C1 (A2 VSS) capacitor c=3.44385e-17
C2 (A1 VSS) capacitor c=1.07379e-16
C3 (Y VSS) capacitor c=1.21599e-17
C4 (B0 VSS) capacitor c=3.18766e-17
C5 (VDD VSS) capacitor c=1.07109e-16
C6 (B1 VSS) capacitor c=4.59664e-17
C7 (A0 VSS) capacitor c=4.9345e-17
C8 (n0 VSS) capacitor c=7.3653e-17
C9 (n2 VSS) capacitor c=7.42025e-18
C10 (\1\:B0 VSS) capacitor c=5.3023e-17
C11 (\1\:B1 VSS) capacitor c=3.3925e-17
C12 (\1\:A2 VSS) capacitor c=3.64582e-17
C13 (\1\:A1 VSS) capacitor c=4.21802e-17
C14 (\1\:A0 VSS) capacitor c=3.89786e-17
C15 (\3\:B0 VSS) capacitor c=3.00306e-17
C16 (\3\:B1 VSS) capacitor c=6.63138e-17
C17 (\3\:A2 VSS) capacitor c=3.09109e-17
C18 (\3\:A1 VSS) capacitor c=4.33499e-17
C19 (\4\:A0 VSS) capacitor c=2.41323e-17
C20 (\2\:B0 VSS) capacitor c=5.71994e-17
C21 (\2\:B1 VSS) capacitor c=5.12961e-17
C22 (\2\:A2 VSS) capacitor c=4.53394e-17
C23 (\2\:A1 VSS) capacitor c=6.13912e-17
C24 (\3\:A0 VSS) capacitor c=9.79543e-18
C25 (\1\:VDD VSS) capacitor c=3.55779e-17
C26 (\4\:Y VSS) capacitor c=1.39965e-17
C27 (\6\:VDD VSS) capacitor c=2.59955e-17
C28 (\1\:Y VSS) capacitor c=7.17897e-17
C29 (\3\:n0 VSS) capacitor c=1.23653e-16
C30 (\5\:n0 VSS) capacitor c=8.06164e-17
C31 (\2\:A0 VSS) capacitor c=3.63088e-17
C32 (\5\:A0 VSS) capacitor c=4.47683e-17
C33 (\4\:A2 VSS) capacitor c=7.0674e-17
C34 (\3\:Y VSS) capacitor c=6.75561e-17
C35 (\4\:B1 VSS) capacitor c=4.79339e-17
C36 (\4\:B0 VSS) capacitor c=4.37999e-17
C37 (\4\:VDD VSS) capacitor c=2.53091e-17
C38 (\5\:VDD VSS) capacitor c=1.232e-17
Rk17 (\4\:VSS VSS) resistor r=0.08179 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.189 c=0
Rk18 (\3\:VSS \6\:VSS) resistor r=0.2779 c=0
Rk19 (\4\:VSS \8\:VSS) resistor r=0.2788 c=0
Rk3 (A2 \4\:A2) resistor r=0.05396 c=0
Rk2 (A1 \4\:A1) resistor r=0.003944 c=0
Rk5 (\3\:Y Y) resistor r=0.003054 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.4944 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.101 c=0
Rk10 (B0 \4\:B0) resistor r=0.1867 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.5845 c=0
Rk13 (\5\:VDD VDD) resistor r=0.08179 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.3163 c=0
Rk14 (\5\:VDD \7\:VDD) resistor r=0.2696 c=0
Rk9 (\4\:B1 B1) resistor r=0.1663 c=0
Rk1 (A0 \5\:A0) resistor r=0.2235 c=0
Rk7 (\2\:n0 \4\:n0) resistor r=0.6168 c=0
Rk8 (\4\:n0 \6\:n0) resistor r=0.4906 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=118.464 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=76.1559 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=87.6944 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=106.925 c=0
Rl10 (\1\:B0 \2\:B0) resistor r=136.333 c=0
Rl11 (\2\:B0 \3\:B0) resistor r=63.4387 c=0
Rl8 (\1\:B1 \2\:B1) resistor r=46.8456 c=0
Rl9 (\2\:B1 \3\:B1) resistor r=171.411 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=166.187 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=46.9565 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=1.2301 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (n0 \2\:n0) resistor r=75 c=0
Rz3 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (\5\:n0 \4\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\5\:n0 \3\:A1 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (\3\:n0 \3\:A2 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.003e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.35e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:B1 \3\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.32e-14 ps=9.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\1\:Y \3\:B0 n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=9.95e-07 sd=160n sca=12.9037 scb=0.0106456 \
        scc=0.000222738 m=(1)
mp2 (\4\:Y \1\:A2 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=9.567e-14 ps=7.5e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.9e-07 sd=160n sca=11.8276 \
        scb=0.00970062 scc=0.000220696 m=(1)
mp4 (\4\:Y \1\:B1 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=9.567e-14 ps=6.6e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=3e-07 sd=160n sca=13.2535 scb=0.0110982 \
        scc=0.000225 m=(1)
mp3 (n4 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.472e-14 ps=7.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=15.7614 \
        scb=0.0152558 scc=0.000298372 m=(1)
ends OAI32XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:55:54 2012 )
// Library name: gsclib045
// Cell name: OAI33X1
// View name: extracted

simulator lang=spectre

subckt OAI33X1 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=16.1236 \
        scb=0.0157073 scc=0.000369518 m=(1)
C1 (B1 VSS) capacitor c=6.05862e-17
C2 (A1 VSS) capacitor c=5.13527e-17
C3 (B2 VSS) capacitor c=6.09137e-17
C4 (A0 VSS) capacitor c=6.25517e-17
C5 (Y VSS) capacitor c=1.19562e-16
C6 (VDD VSS) capacitor c=9.47662e-17
C7 (A2 VSS) capacitor c=2.60752e-17
C8 (B0 VSS) capacitor c=6.89707e-17
C9 (no VSS) capacitor c=5.21604e-17
C10 (n1 VSS) capacitor c=2.11046e-18
C11 (n3 VSS) capacitor c=6.59856e-18
C12 (n4 VSS) capacitor c=2.33123e-18
C13 (\3\:B0 VSS) capacitor c=6.54801e-17
C14 (\3\:B1 VSS) capacitor c=9.89122e-17
C15 (\1\:B2 VSS) capacitor c=6.36979e-17
C16 (\1\:A2 VSS) capacitor c=4.00788e-17
C17 (\1\:A1 VSS) capacitor c=9.7338e-17
C18 (\1\:A0 VSS) capacitor c=8.10048e-17
C19 (\1\:B0 VSS) capacitor c=4.97302e-17
C20 (\1\:B1 VSS) capacitor c=4.2791e-17
C21 (\3\:B2 VSS) capacitor c=4.19179e-17
C22 (\3\:A2 VSS) capacitor c=6.3469e-17
C23 (\3\:A1 VSS) capacitor c=4.34728e-17
C24 (\3\:A0 VSS) capacitor c=3.27648e-17
C25 (\2\:B0 VSS) capacitor c=5.09008e-17
C26 (\2\:B1 VSS) capacitor c=5.2247e-17
C27 (\2\:B2 VSS) capacitor c=4.77501e-17
C28 (\2\:A2 VSS) capacitor c=4.74363e-17
C29 (\2\:A1 VSS) capacitor c=6.97052e-17
C30 (\2\:A0 VSS) capacitor c=6.38918e-17
C31 (\1\:VDD VSS) capacitor c=4.93868e-17
C32 (\5\:Y VSS) capacitor c=8.17918e-17
C33 (\6\:VDD VSS) capacitor c=3.49407e-17
C34 (\3\:Y VSS) capacitor c=8.04183e-17
C35 (\5\:no VSS) capacitor c=6.30776e-17
C36 (\1\:Y VSS) capacitor c=6.01822e-17
C37 (\3\:no VSS) capacitor c=8.57992e-17
C38 (\4\:A0 VSS) capacitor c=2.59325e-17
C39 (\4\:A1 VSS) capacitor c=6.52885e-17
C40 (\4\:A2 VSS) capacitor c=9.15768e-17
C41 (\4\:B2 VSS) capacitor c=5.70102e-17
C42 (\4\:B1 VSS) capacitor c=6.43761e-17
C43 (\4\:B0 VSS) capacitor c=6.71244e-17
C44 (\4\:VDD VSS) capacitor c=3.19047e-17
C45 (\5\:VDD VSS) capacitor c=1.31675e-17
Rk7 (B1 \4\:B1) resistor r=0.2253 c=0
Rk2 (A1 \4\:A1) resistor r=0.2253 c=0
Rk6 (B2 \4\:B2) resistor r=0.2253 c=0
Rk1 (A0 \4\:A0) resistor r=0.1112 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.2607 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.0901 c=0
Rk21 (\5\:VSS VSS) resistor r=0.03467 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.1152 c=0
Rk23 (\3\:VSS \8\:VSS) resistor r=0.1804 c=0
Rk24 (\5\:VSS \10\:VSS) resistor r=0.1744 c=0
Rk12 (\4\:Y Y) resistor r=0.4427 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.3019 c=0
Rk13 (Y \6\:Y) resistor r=0.6371 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.3945 c=0
Rk16 (\5\:VDD VDD) resistor r=0.08483 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.2657 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2313 c=0
Rk5 (\4\:A2 A2) resistor r=0.05107 c=0
Rk10 (B0 \4\:B0) resistor r=0.04807 c=0
Rk8 (\2\:no \4\:no) resistor r=0.4175 c=0
Rk9 (\4\:no \6\:no) resistor r=0.3343 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=136.333 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=53.0142 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=141.076 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=56.461 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=141.076 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=56.461 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=144.021 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=56.8681 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=29.5379 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=168 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=44.208 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=153.641 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\3\:Y \4\:Y) resistor r=75 c=0
Rz1 (no \2\:no) resistor r=75 c=0
Rz2 (\3\:no \4\:no) resistor r=75 c=0
Rz3 (\5\:no \6\:no) resistor r=75 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\5\:Y \6\:Y) resistor r=31 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=31 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (no \3\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (no \3\:A1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\3\:no \3\:A2 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.94e-14 ps=8.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (\1\:Y \3\:B2 \3\:no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \1\:B1 \5\:no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\3\:Y \1\:B0 \5\:no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.85e-07 sd=160n sca=14.2305 scb=0.0124601 \
        scc=0.000303643 m=(1)
mp2 (\5\:Y \1\:A2 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.8e-07 sd=160n sca=12.6688 scb=0.0104218 \
        scc=0.00029207 m=(1)
mp5 (\5\:Y \1\:B2 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=7.41e-14 ps=1.09e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=4.45e-07 sd=160n sca=12.6688 \
        scb=0.0104218 scc=0.00029207 m=(1)
mp3 (n3 \3\:B1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.045e-14 ps=9e-07 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.85e-07 sb=2.45e-07 sd=160n sca=14.1668 scb=0.0123603 \
        scc=0.000302616 m=(1)
mp4 (n4 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.4e-07 sd=160n sca=16.0015 \
        scb=0.0154903 scc=0.000362941 m=(1)
ends OAI33X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:56:33 2012 )
// Library name: gsclib045
// Cell name: OAI33X2
// View name: extracted

simulator lang=spectre

subckt OAI33X2 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0_1__rcx (4 \1\:A0 \1\:VDD VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.71e-14 ad=1.59e-14 ps=8.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98151e-06 sd=160n sca=14.2659 \
        scb=0.0126092 scc=0.000180096 m=(1)
C1 (B2 VSS) capacitor c=2.47905e-17
C2 (A0 VSS) capacitor c=4.84158e-16
C3 (A2 VSS) capacitor c=5.4901e-16
C4 (B0 VSS) capacitor c=5.56479e-16
C5 (VDD VSS) capacitor c=3.22495e-16
C6 (B1 VSS) capacitor c=2.45573e-17
C7 (A1 VSS) capacitor c=6.4462e-16
C8 (Y VSS) capacitor c=2.84413e-17
C9 (n0 VSS) capacitor c=7.25209e-16
C10 (6 VSS) capacitor c=3.52724e-18
C11 (7 VSS) capacitor c=1.84995e-18
C12 (8 VSS) capacitor c=1.18802e-17
C13 (9 VSS) capacitor c=6.49682e-18
C14 (10 VSS) capacitor c=2.1945e-18
C15 (11 VSS) capacitor c=5.0251e-18
C16 (12 VSS) capacitor c=3.71511e-18
C17 (13 VSS) capacitor c=3.62862e-18
C18 (14 VSS) capacitor c=3.47743e-18
C19 (15 VSS) capacitor c=2.72147e-18
C20 (\9\:B0 VSS) capacitor c=4.07093e-17
C21 (\10\:B1 VSS) capacitor c=6.74207e-17
C22 (\9\:B2 VSS) capacitor c=4.85975e-17
C23 (\6\:B2 VSS) capacitor c=4.7128e-17
C24 (\5\:B1 VSS) capacitor c=5.87281e-17
C25 (\4\:B0 VSS) capacitor c=3.16275e-17
C26 (\1\:B0 VSS) capacitor c=2.53622e-17
C27 (\4\:B1 VSS) capacitor c=6.08727e-17
C28 (\1\:B2 VSS) capacitor c=8.84814e-17
C29 (\7\:A2 VSS) capacitor c=3.77539e-17
C30 (\7\:A1 VSS) capacitor c=3.82497e-17
C31 (\10\:A0 VSS) capacitor c=2.30473e-17
C32 (\8\:A0 VSS) capacitor c=7.35364e-17
C33 (\6\:A1 VSS) capacitor c=8.66331e-17
C34 (\4\:A2 VSS) capacitor c=2.99952e-17
C35 (\1\:A2 VSS) capacitor c=2.0173e-17
C36 (\1\:A1 VSS) capacitor c=7.07638e-17
C37 (\1\:A0 VSS) capacitor c=8.18958e-17
C38 (\1\:B1 VSS) capacitor c=6.96788e-16
C39 (\2\:B2 VSS) capacitor c=5.56871e-16
C40 (\14\:VDD VSS) capacitor c=3.55946e-17
C41 (\1\:Y VSS) capacitor c=2.02331e-16
C42 (\11\:VDD VSS) capacitor c=3.17832e-17
C43 (\6\:Y VSS) capacitor c=1.69526e-16
C44 (\7\:VDD VSS) capacitor c=3.70436e-17
C45 (\8\:Y VSS) capacitor c=1.27687e-16
C46 (\1\:VDD VSS) capacitor c=1.07197e-17
C47 (\4\:VDD VSS) capacitor c=1.20511e-16
C48 (\7\:A0 VSS) capacitor c=3.22518e-17
C49 (\3\:Y VSS) capacitor c=4.68499e-16
C50 (\3\:VDD VSS) capacitor c=6.50428e-18
C51 (\6\:VDD VSS) capacitor c=1.37501e-17
C52 (\10\:VDD VSS) capacitor c=1.242e-17
Rk11 (\2\:B2 B2) resistor r=0.08585 c=0
Rk58 (\3\:VSS VSS) resistor r=0.05469 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.5812 c=0
Rk42 (\3\:VDD VDD) resistor r=0.1048 c=0
Rk41 (\2\:VDD \3\:VDD) resistor r=0.2263 c=0
Rk43 (\3\:VDD \5\:VDD) resistor r=0.1953 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.3331 c=0
Rk45 (\6\:VDD \8\:VDD) resistor r=0.1818 c=0
Rk46 (\6\:VDD \9\:VDD) resistor r=0.4183 c=0
Rk47 (\9\:VDD \10\:VDD) resistor r=0.3832 c=0
Rk48 (\10\:VDD \12\:VDD) resistor r=0.1818 c=0
Rk49 (\10\:VDD \13\:VDD) resistor r=0.3682 c=0
Rk50 (\13\:VDD \15\:VDD) resistor r=0.3811 c=0
Rk14 (\1\:B1 B1) resistor r=0.0584 c=0
Rk40 (\3\:Y Y) resistor r=0.01995 c=0
Rk29 (\2\:Y \3\:Y) resistor r=0.8504 c=0
Rk31 (\2\:Y \7\:Y) resistor r=0.9077 c=0
Rk32 (\7\:Y \9\:Y) resistor r=1.0469 c=0
Rl36 (\2\:B2 \9\:B2) resistor r=145.949 c=0
Rl34 (\2\:B2 \6\:B2) resistor r=149.176 c=0
Rl22 (\2\:B2 \1\:B2) resistor r=144.026 c=0
Rl1 (A0 \1\:A0) resistor r=159.411 c=0
Rl13 (\7\:A0 A0) resistor r=119.604 c=0
Rl16 (\7\:A0 \10\:A0) resistor r=49.9779 c=0
Rl14 (\7\:A0 \8\:A0) resistor r=105.747 c=0
Rl20 (A2 \7\:A2) resistor r=29.5379 c=0
Rl7 (A2 \4\:A2) resistor r=29.5379 c=0
Rl5 (A2 \1\:A2) resistor r=29.5379 c=0
Rl40 (B0 \9\:B0) resistor r=34.4104 c=0
Rl29 (B0 \4\:B0) resistor r=24.2328 c=0
Rl27 (B0 \1\:B0) resistor r=24.2328 c=0
Rl38 (\1\:B1 \10\:B1) resistor r=84.4104 c=0
Rl31 (\1\:B1 \5\:B1) resistor r=87.2302 c=0
Rl26 (\1\:B1 \4\:B1) resistor r=54.6488 c=0
Rl17 (A1 \7\:A1) resistor r=106.572 c=0
Rl10 (A1 \6\:A1) resistor r=94.0258 c=0
Rl3 (A1 \1\:A1) resistor r=98.7687 c=0
Rz15 (\4\:VDD \5\:VDD) resistor r=10.7143 c=0
Rz16 (\4\:VDD \9\:VDD) resistor r=9.375 c=0
Rz17 (\4\:VDD \13\:VDD) resistor r=10.7143 c=0
Ry12 (VSS \1\:VSS) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=62 c=0
Ry2 (\7\:Y \6\:Y) resistor r=62 c=0
Ry3 (\9\:Y \8\:Y) resistor r=62 c=0
mn0_1__rcx (n0 A0 \3\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.438e-14 ad=2.8e-14 ps=7.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98071e-06 sd=160n sca=9.07807 \
        scb=0.007472 scc=0.000167841 m=(2)
mn1_1__rcx (n0 A1 \3\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=4.45e-14 ad=2.8e-14 ps=8.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.97486e-06 sd=160n sca=9.07807 \
        scb=0.007472 scc=0.000167841 m=(2)
mn2_1__rcx (n0 A2 \3\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=4.45e-14 ad=2.975e-14 ps=8.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.96729e-06 sd=160n sca=9.07807 \
        scb=0.007472 scc=0.000167841 m=(2)
mn0 (n0 A0 \3\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 as=4.425e-14 \
        ad=2.72e-14 ps=8.9e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.56e-06 sb=1.99662e-06 sd=160n sca=9.14613 scb=0.00758408 \
        scc=0.000172013 m=(1)
mn1_2__rcx (n0 A1 \3\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=2.72e-14 ps=8.9e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=1.99059e-06 sd=160n sca=9.14613 \
        scb=0.00758408 scc=0.000172013 m=(1)
mn2 (n0 A2 \3\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 as=4.4e-14 \
        ad=3.195e-14 ps=8.9e-07 pd=7.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.98279e-06 sd=160n sca=9.14613 scb=0.00758408 \
        scc=0.000172013 m=(1)
mn5 (\3\:Y \2\:B2 n0 VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.11e-14 ad=3.063e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94571e-06 sb=1.85043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn3_1__rcx (\3\:Y \1\:B1 n0 VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=2.844e-14 ad=3.063e-14 ps=6.75e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.952e-06 sb=1.63043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn4_1__rcx (\3\:Y B0 n0 VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=2.844e-14 ad=3.238e-14 ps=6.75e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.958e-06 sb=1.42043e-06 sd=160n sca=9.24372 \
        scb=0.00774894 scc=0.000182948 m=(2)
mn5_2__rcx (\3\:Y \2\:B2 n0 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=3.025e-14 ad=2.975e-14 ps=7e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9825e-06 sb=5.65e-07 sd=160n sca=9.31415 \
        scb=0.0078649 scc=0.000187493 m=(1)
mn3 (\3\:Y \1\:B1 n0 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 as=2.72e-14 \
        ad=2.975e-14 ps=6.6e-07 pd=6.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98897e-06 sb=3.45e-07 sd=160n sca=9.31415 scb=0.0078649 \
        scc=0.000187493 m=(1)
mn4_2__rcx (\3\:Y B0 n0 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=2.72e-14 ad=2.38e-14 ps=6.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=1.4e-07 sd=160n sca=9.31415 \
        scb=0.0078649 scc=0.000187493 m=(1)
mp1_1__rcx (4 \1\:A1 5 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=1.59e-14 ps=9.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.97953e-06 sd=160n sca=12.7796 \
        scb=0.0101999 scc=0.00014764 m=(1)
mp2_1__rcx (\8\:Y \1\:A2 5 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=4.505e-14 ps=9.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.97453e-06 sd=160n sca=11.1864 \
        scb=0.00858333 scc=0.000141961 m=(1)
mp1_2__rcx (6 \6\:A1 7 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=1.59e-14 ad=3.048e-14 ps=6.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.96745e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp2_2__rcx (\8\:Y \4\:A2 6 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.048e-14 ad=4.505e-14 ps=7.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.97047e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp0_2__rcx (7 \8\:A0 \7\:VDD VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=1.59e-14 ps=1.09e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.96547e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp0 (8 \10\:A0 \7\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=9.49e-14 ps=1.09e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=2e-06 sd=160n sca=10.7426 \
        scb=0.0084509 scc=0.000143085 m=(1)
mp1 (8 \7\:A1 9 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=9.49e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.665e-06 sb=1.99279e-06 sd=160n sca=10.7426 scb=0.0084509 \
        scc=0.000143085 m=(1)
mp2 (\6\:Y \7\:A2 9 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=7.85e-14 ps=9.6e-07 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.93e-06 sb=1.92885e-06 sd=160n sca=10.7426 scb=0.0084509 \
        scc=0.000143085 m=(1)
mp5_1__rcx (\6\:Y \1\:B2 10 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=1.59e-14 ad=7.85e-14 ps=6.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96415e-06 sb=1.58406e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp3_2__rcx (13 \5\:B1 12 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.313e-14 ad=3.18e-14 ps=7.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9783e-06 sb=8.34057e-07 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp3_1__rcx (11 \4\:B1 10 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=1.59e-14 ad=4.373e-14 ps=6.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96613e-06 sb=1.47906e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp4_1__rcx (11 \1\:B0 \11\:VDD VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=6.55e-14 ad=4.373e-14 ps=1.09e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97009e-06 sb=1.26906e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp4_2__rcx (12 \4\:B0 \11\:VDD VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=6.55e-14 ad=3.313e-14 ps=1.09e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97509e-06 sb=1.00406e-06 sd=160n sca=10.7335 \
        scb=0.00843468 scc=0.00014192 m=(1)
mp5_2__rcx (\1\:Y \6\:B2 13 VDD) g45p1svt w=(2.65e-07) l=4.5e-08 nf=1 \
        as=3.18e-14 ad=4.47e-14 ps=7.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98142e-06 sb=6.69057e-07 sd=160n sca=10.7821 \
        scb=0.00844411 scc=0.000141921 m=(1)
mp5 (\1\:Y \9\:B2 14 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.47e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98519e-06 sb=4.65e-07 sd=160n sca=11.3498 scb=0.00860452 \
        scc=0.000134096 m=(1)
mp3 (15 \10\:B1 14 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=2.34e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.98827e-06 sb=3.05e-07 sd=160n sca=12.2993 scb=0.00952904 \
        scc=0.000136475 m=(1)
mp4 (15 \9\:B0 \14\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.14e-14 ad=2.34e-14 ps=9.8e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99087e-06 sb=1.7e-07 sd=160n sca=13.932 \
        scb=0.0120305 scc=0.000163154 m=(1)
ends OAI33X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:57:11 2012 )
// Library name: gsclib045
// Cell name: OAI33X4
// View name: extracted

simulator lang=spectre

subckt OAI33X4 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0_1__rcx (n2 A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=20.9952 \
        scb=0.0222834 scc=0.00110072 m=(4)
C1 (B1 VSS) capacitor c=3.78481e-16
C2 (A1 VSS) capacitor c=3.70749e-16
C3 (B2 VSS) capacitor c=3.72627e-16
C4 (A0 VSS) capacitor c=3.30817e-16
C5 (Y VSS) capacitor c=1.38589e-17
C6 (A2 VSS) capacitor c=3.93566e-16
C7 (B0 VSS) capacitor c=3.56885e-16
C8 (VDD VSS) capacitor c=2.41708e-16
C9 (no VSS) capacitor c=8.86584e-16
C10 (n2 VSS) capacitor c=3.57262e-16
C11 (n1 VSS) capacitor c=1.3448e-16
C12 (n3 VSS) capacitor c=1.21593e-16
C13 (n4 VSS) capacitor c=3.57454e-16
C14 (\5\:n3 VSS) capacitor c=1.331e-16
C15 (\5\:n1 VSS) capacitor c=1.24532e-16
C16 (\1\:VDD VSS) capacitor c=2.12878e-16
C17 (\1\:Y VSS) capacitor c=1.45327e-16
C18 (\5\:Y VSS) capacitor c=1.64478e-16
C19 (\9\:Y VSS) capacitor c=2.19978e-16
C20 (\14\:Y VSS) capacitor c=1.34902e-16
C21 (\15\:Y VSS) capacitor c=3.7594e-16
C22 (\3\:VDD VSS) capacitor c=1.15e-16
C23 (\7\:VDD VSS) capacitor c=8.85448e-17
Rk77 (\2\:VSS \3\:VSS) resistor r=0.9021 c=0
Rk78 (\3\:VSS \4\:VSS) resistor r=0.3757 c=0
Rk80 (\4\:VSS \6\:VSS) resistor r=0.1151 c=0
Rk81 (\6\:VSS \7\:VSS) resistor r=0.09001 c=0
Rk84 (\7\:VSS \10\:VSS) resistor r=0.105 c=0
Rk85 (\10\:VSS \11\:VSS) resistor r=0.1 c=0
Rk89 (\14\:VSS VSS) resistor r=0.09998 c=0
Rk88 (\11\:VSS \14\:VSS) resistor r=0.1451 c=0
Rk27 (\1\:Y \5\:Y) resistor r=0.2789 c=0
Rk29 (\5\:Y \9\:Y) resistor r=0.2789 c=0
Rk33 (\14\:Y Y) resistor r=0.003068 c=0
Rk32 (\9\:Y \14\:Y) resistor r=0.9402 c=0
Rk34 (\14\:Y \15\:Y) resistor r=0.1112 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.1727 c=0
Rk66 (\3\:VDD \5\:VDD) resistor r=0.2729 c=0
Rk67 (\5\:VDD \6\:VDD) resistor r=1.2028 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.5887 c=0
Rk72 (\10\:VDD VDD) resistor r=0.04986 c=0
Rk71 (\7\:VDD \10\:VDD) resistor r=0.1076 c=0
Rk14 (n1 \5\:n1) resistor r=0.4078 c=0
Rk24 (n3 \5\:n3) resistor r=0.4061 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz21 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\7\:VDD \1\:VDD) resistor r=37.5 c=0
Rz24 (\10\:VDD \1\:VDD) resistor r=37.5 c=0
Ry29 (\2\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry30 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry31 (\6\:VSS \1\:VSS) resistor r=31 c=0
Ry32 (\7\:VSS \1\:VSS) resistor r=31 c=0
Ry33 (\10\:VSS \1\:VSS) resistor r=31 c=0
Ry34 (\11\:VSS \1\:VSS) resistor r=31 c=0
Ry35 (\14\:VSS \1\:VSS) resistor r=20.6667 c=0
mn0_1__rcx (no A0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn1_1__rcx (no A1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn2_1__rcx (no A2 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn5_1__rcx (\9\:Y B2 no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn3_1__rcx (\5\:Y B1 no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn4_1__rcx (\1\:Y B0 no VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mp1_1__rcx (n2 A1 \5\:n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=14.7189 \
        scb=0.0133035 scc=0.000878755 m=(4)
mp2_1__rcx (\15\:Y A2 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.595e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp5_1__rcx (\15\:Y B2 \5\:n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=7.65e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3_1__rcx (n3 B1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(4)
mp4_1__rcx (n4 B0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=15.4443 \
        scb=0.013925 scc=0.00102271 m=(4)
ends OAI33X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:57:48 2012 )
// Library name: gsclib045
// Cell name: OAI33XL
// View name: extracted

simulator lang=spectre

subckt OAI33XL A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (n2 \1\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=14.5245 \
        scb=0.0130308 scc=0.000155148 m=(1)
C1 (A1 VSS) capacitor c=7.66428e-17
C2 (B2 VSS) capacitor c=4.27587e-17
C3 (A0 VSS) capacitor c=2.57559e-17
C4 (Y VSS) capacitor c=1.02683e-16
C5 (VDD VSS) capacitor c=1.53258e-16
C6 (no VSS) capacitor c=6.4365e-17
C7 (n1 VSS) capacitor c=6.10291e-18
C8 (n3 VSS) capacitor c=2.97781e-19
C9 (\3\:B0 VSS) capacitor c=7.2996e-17
C10 (\1\:B1 VSS) capacitor c=6.93903e-17
C11 (\1\:B2 VSS) capacitor c=3.47479e-17
C12 (\1\:A2 VSS) capacitor c=4.02455e-17
C13 (\1\:A1 VSS) capacitor c=7.7267e-17
C14 (\1\:A0 VSS) capacitor c=8.84791e-17
C15 (\1\:B0 VSS) capacitor c=3.63272e-17
C16 (\3\:B1 VSS) capacitor c=5.44915e-17
C17 (\3\:B2 VSS) capacitor c=5.76261e-17
C18 (\3\:A2 VSS) capacitor c=4.47237e-17
C19 (\3\:A1 VSS) capacitor c=4.92712e-17
C20 (\3\:A0 VSS) capacitor c=3.72725e-17
C21 (\2\:B0 VSS) capacitor c=7.16837e-17
C22 (\2\:B1 VSS) capacitor c=8.1835e-17
C23 (\2\:B2 VSS) capacitor c=5.58328e-17
C24 (\2\:A2 VSS) capacitor c=6.1386e-17
C25 (\2\:A1 VSS) capacitor c=8.97612e-17
C26 (\2\:A0 VSS) capacitor c=7.43196e-17
C27 (\1\:VDD VSS) capacitor c=4.09501e-17
C28 (\4\:Y VSS) capacitor c=8.31562e-17
C29 (\6\:VDD VSS) capacitor c=1.46743e-17
C30 (\6\:Y VSS) capacitor c=3.02357e-17
C31 (\5\:no VSS) capacitor c=1.12033e-16
C32 (\1\:Y VSS) capacitor c=7.20822e-17
C33 (\3\:no VSS) capacitor c=1.03331e-16
C34 (\4\:A0 VSS) capacitor c=4.64345e-17
C35 (\4\:A1 VSS) capacitor c=2.86131e-17
C36 (\4\:A2 VSS) capacitor c=1.16994e-16
C37 (\4\:B2 VSS) capacitor c=6.02421e-17
C38 (\4\:B1 VSS) capacitor c=1.11281e-16
C39 (\4\:B0 VSS) capacitor c=1.2242e-16
C40 (\3\:Y VSS) capacitor c=7.05936e-17
C41 (\4\:VDD VSS) capacitor c=3.34985e-17
C42 (\5\:VDD VSS) capacitor c=1.61245e-17
Rk7 (\4\:B1 B1) resistor r=0.002997 c=0
Rk4 (\4\:A1 A1) resistor r=0.02997 c=0
Rk6 (\4\:B2 B2) resistor r=0.2018 c=0
Rk1 (\4\:A0 A0) resistor r=0.08702 c=0
Rk19 (\2\:VSS \3\:VSS) resistor r=0.3081 c=0
Rk20 (\3\:VSS \4\:VSS) resistor r=0.09255 c=0
Rk22 (\5\:VSS VSS) resistor r=0.03715 c=0
Rk21 (\4\:VSS \5\:VSS) resistor r=0.1126 c=0
Rk24 (\3\:VSS \8\:VSS) resistor r=0.1843 c=0
Rk25 (\5\:VSS \10\:VSS) resistor r=0.1793 c=0
Rk12 (\3\:Y Y) resistor r=0.439 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.3711 c=0
Rk13 (Y \5\:Y) resistor r=0.6486 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.05799 c=0
Rk15 (\2\:VDD \4\:VDD) resistor r=0.5073 c=0
Rk17 (\5\:VDD VDD) resistor r=0.08728 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.3131 c=0
Rk18 (\5\:VDD \7\:VDD) resistor r=0.1834 c=0
Rk5 (\4\:A2 A2) resistor r=0.002997 c=0
Rk10 (\4\:B0 B0) resistor r=0.008207 c=0
Rk8 (\2\:no \4\:no) resistor r=0.5366 c=0
Rk9 (\4\:no \6\:no) resistor r=0.5703 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=141.076 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=168 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=158.384 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=150.692 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=69.9225 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=239.153 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=219.208 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=109.41 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=141.076 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=168 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=215.18 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=96.2379 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\6\:Y \7\:Y) resistor r=75 c=0
Rz1 (no \2\:no) resistor r=75 c=0
Rz2 (\3\:no \4\:no) resistor r=75 c=0
Rz3 (\5\:no \6\:no) resistor r=75 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=10.3333 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (no \3\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (no \3\:A1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.18e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\3\:no \3\:A2 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=4.857e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=9.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn5 (\1\:Y \3\:B2 \3\:no VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.537e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=5.65e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y \3\:B1 \5\:no VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=3.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn4 (\6\:Y \1\:B0 \5\:no VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mp1 (n2 \1\:A1 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.085e-14 \
        ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.1e-06 sd=160n sca=12.6898 scb=0.00990074 \
        scc=9.48225e-05 m=(1)
mp2 (\4\:Y \1\:A2 n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.203e-14 ps=8.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=8.65e-07 sd=160n sca=10.9418 \
        scb=0.00782693 scc=8.41447e-05 m=(1)
mp5 (\4\:Y \1\:B2 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=7.203e-14 ps=7.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=4.85e-07 sd=160n sca=11.0076 \
        scb=0.00787274 scc=8.41904e-05 m=(1)
mp3 (n3 \1\:B1 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.72e-14 \
        ad=3.762e-14 ps=5.9e-07 pd=7.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.08e-06 sb=2.65e-07 sd=160n sca=12.6898 scb=0.00990074 \
        scc=9.48225e-05 m=(1)
mp4 (n4 \3\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.72e-14 ps=7.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=15.0399 \
        scb=0.0139456 scc=0.00018525 m=(1)
ends OAI33XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:25:10 2012 )
// Library name: gsclib045
// Cell name: OR2X1
// View name: extracted

simulator lang=spectre

subckt OR2X1 A B VDD VSS Y
mp1 (\6\:n0 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=56.6055 \
        scb=0.0430318 scc=0.00645527 m=(1)
C1 (A VSS) capacitor c=7.16644e-17
C2 (B VSS) capacitor c=2.99685e-17
C3 (VDD VSS) capacitor c=4.39096e-17
C4 (Y VSS) capacitor c=4.74405e-17
C5 (n0 VSS) capacitor c=4.43431e-17
C6 (n1 VSS) capacitor c=9.48821e-19
C7 (\3\:A VSS) capacitor c=5.37595e-17
C8 (\1\:B VSS) capacitor c=5.67131e-17
C9 (\3\:n0 VSS) capacitor c=3.93729e-17
C10 (\1\:A VSS) capacitor c=3.74782e-17
C11 (\4\:B VSS) capacitor c=2.76607e-17
C12 (\2\:n0 VSS) capacitor c=3.60314e-17
C13 (\2\:A VSS) capacitor c=4.94166e-17
C14 (\3\:B VSS) capacitor c=1.55855e-17
C15 (\1\:Y VSS) capacitor c=3.4992e-17
C16 (\1\:VDD VSS) capacitor c=8.27373e-17
C17 (\6\:n0 VSS) capacitor c=6.87528e-17
C18 (\3\:Y VSS) capacitor c=4.82441e-17
C19 (\8\:n0 VSS) capacitor c=2.47557e-17
C20 (\2\:B VSS) capacitor c=2.47153e-17
C21 (\5\:B VSS) capacitor c=3.82588e-17
C22 (\4\:A VSS) capacitor c=6.7711e-17
C23 (\4\:n0 VSS) capacitor c=7.64438e-17
C24 (\5\:n0 VSS) capacitor c=6.34048e-17
C25 (\4\:VDD VSS) capacitor c=1.89863e-17
Rk2 (\4\:A A) resistor r=0.1787 c=0
Rk1 (B \5\:B) resistor r=0.04349 c=0
Rk9 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.4545 c=0
Rk6 (\2\:Y Y) resistor r=0.1673 c=0
Rk7 (Y \4\:Y) resistor r=0.2251 c=0
Rk10 (\2\:VSS VSS) resistor r=0.1107 c=0
Rk11 (VSS \4\:VSS) resistor r=0.1511 c=0
Rk12 (\4\:VSS \6\:VSS) resistor r=0.393 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.2897 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.3221 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.05545 c=0
Rl5 (\2\:A \3\:A) resistor r=26.098 c=0
Rl4 (\1\:A \2\:A) resistor r=43.4057 c=0
Rl1 (\1\:B \2\:B) resistor r=69.5391 c=0
Rl3 (\2\:B \4\:B) resistor r=25.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=9.7447 c=0
Rl6 (n0 \2\:n0) resistor r=41.4826 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=28.0211 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\8\:n0 \4\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.04e-14 ad=2.32e-14 ps=1.45e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn0 (\8\:n0 \1\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.45e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn2 (\3\:Y \3\:n0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.28654e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=53.5433 \
        scb=0.0379171 scc=0.00600127 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.27436e-07 sb=1.4e-07 sd=160n sca=45.5228 \
        scb=0.0401019 scc=0.00476865 m=(1)
ends OR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:25:57 2012 )
// Library name: gsclib045
// Cell name: OR2X2
// View name: extracted

simulator lang=spectre

subckt OR2X2 A B VDD VSS Y
mp1 (\9\:n0 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=2.63e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.45e-07 sd=160n sca=35.2408 \
        scb=0.036114 scc=0.00353857 m=(1)
C1 (A VSS) capacitor c=6.43959e-17
C2 (B VSS) capacitor c=4.25212e-17
C3 (Y VSS) capacitor c=5.61442e-17
C4 (VDD VSS) capacitor c=5.96457e-17
C5 (n0 VSS) capacitor c=1.56651e-16
C6 (n1 VSS) capacitor c=2.34162e-18
C7 (\1\:A VSS) capacitor c=5.72843e-17
C8 (\1\:B VSS) capacitor c=6.74595e-17
C9 (\3\:A VSS) capacitor c=4.18221e-17
C10 (\4\:B VSS) capacitor c=2.41253e-17
C11 (\2\:A VSS) capacitor c=5.8185e-17
C12 (\3\:B VSS) capacitor c=1.28788e-17
C13 (\1\:VDD VSS) capacitor c=9.50547e-17
C14 (\1\:Y VSS) capacitor c=4.80529e-17
C15 (\9\:n0 VSS) capacitor c=4.44458e-17
C16 (\3\:Y VSS) capacitor c=2.61415e-17
C17 (\11\:n0 VSS) capacitor c=3.54377e-17
C18 (\2\:B VSS) capacitor c=3.55809e-17
C19 (\5\:B VSS) capacitor c=4.8387e-17
C20 (\4\:A VSS) capacitor c=8.63054e-17
C21 (\7\:n0 VSS) capacitor c=7.26079e-17
C22 (\8\:n0 VSS) capacitor c=1.07258e-16
Rk2 (\4\:A A) resistor r=0.1524 c=0
Rk12 (\1\:VSS VSS) resistor r=0.2015 c=0
Rk14 (VSS \8\:VSS) resistor r=0.08493 c=0
Rk1 (B \5\:B) resistor r=0.1051 c=0
Rk6 (\2\:Y Y) resistor r=0.2027 c=0
Rk7 (Y \4\:Y) resistor r=0.2241 c=0
Rk9 (\1\:VDD VDD) resistor r=0.2006 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3016 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.3347 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.1024 c=0
Rl4 (\1\:A \2\:A) resistor r=48.7687 c=0
Rl5 (\2\:A \3\:A) resistor r=75.6918 c=0
Rl1 (\1\:B \2\:B) resistor r=131.078 c=0
Rl3 (\2\:B \4\:B) resistor r=23.7402 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rz6 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry1 (\10\:n0 \9\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\11\:n0 \4\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.28e-14 ad=2.32e-14 ps=1.3e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.45e-07 sd=160n sca=12.2839 scb=0.0124725 \
        scc=0.000542081 m=(1)
mn0 (\11\:n0 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.521e-14 ad=4.16e-14 ps=1.19e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45385e-07 sb=3.05e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(2)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.27326e-07 sb=5.4e-07 sd=160n sca=31.5798 \
        scb=0.0296345 scc=0.00310241 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.363e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17692e-07 sb=3.05e-07 sd=160n sca=24.1823 \
        scb=0.0219058 scc=0.0017667 m=(2)
ends OR2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:26:51 2012 )
// Library name: gsclib045
// Cell name: OR2X4
// View name: extracted

simulator lang=spectre

subckt OR2X4 A B VDD VSS Y
mp1 (\16\:n0 \1\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.095e-06 sd=160n sca=18.2281 \
        scb=0.0183524 scc=0.000740229 m=(1)
C1 (A VSS) capacitor c=5.23667e-17
C2 (VDD VSS) capacitor c=1.02521e-16
C3 (Y VSS) capacitor c=3.32752e-17
C4 (B VSS) capacitor c=5.80901e-17
C5 (n0 VSS) capacitor c=3.85994e-16
C6 (n1 VSS) capacitor c=1.04006e-18
C7 (\1\:A VSS) capacitor c=8.1133e-17
C8 (\1\:B VSS) capacitor c=8.7234e-17
C9 (\3\:A VSS) capacitor c=5.09622e-17
C10 (\4\:B VSS) capacitor c=3.4227e-17
C11 (\2\:A VSS) capacitor c=5.72164e-17
C12 (\3\:B VSS) capacitor c=1.36834e-17
C13 (\1\:Y VSS) capacitor c=2.52366e-16
C14 (\16\:n0 VSS) capacitor c=9.9309e-17
C15 (\1\:VDD VSS) capacitor c=3.4562e-17
C16 (\18\:n0 VSS) capacitor c=4.91928e-17
C17 (\2\:B VSS) capacitor c=4.59814e-17
C18 (\5\:B VSS) capacitor c=4.12674e-17
C19 (\4\:A VSS) capacitor c=5.93886e-17
C20 (\15\:n0 VSS) capacitor c=1.05046e-16
C21 (\4\:Y VSS) capacitor c=2.05238e-16
C22 (\3\:VDD VSS) capacitor c=1.96744e-16
Rk2 (\4\:A A) resistor r=0.1336 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.03997 c=0
Rk19 (\8\:VDD VDD) resistor r=0.1002 c=0
Rk18 (\3\:VDD \8\:VDD) resistor r=0.1354 c=0
Rk8 (\1\:Y Y) resistor r=0.1468 c=0
Rk9 (Y \4\:Y) resistor r=0.1025 c=0
Rk1 (\5\:B B) resistor r=0.1316 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.03997 c=0
Rk28 (\3\:VSS \8\:VSS) resistor r=0.08516 c=0
Rk30 (\9\:VSS VSS) resistor r=0.02968 c=0
Rk29 (\8\:VSS \9\:VSS) resistor r=0.1203 c=0
Rk35 (\9\:VSS \18\:VSS) resistor r=0.2327 c=0
Rk4 (n0 \15\:n0) resistor r=0.3857 c=0
Rk5 (\15\:n0 \17\:n0) resistor r=0.405 c=0
Rk6 (\15\:n0 \19\:n0) resistor r=0.1942 c=0
Rl4 (\1\:A \2\:A) resistor r=69.9225 c=0
Rl5 (\2\:A \3\:A) resistor r=106.461 c=0
Rl1 (\1\:B \2\:B) resistor r=156.078 c=0
Rl3 (\2\:B \4\:B) resistor r=50.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=7.3511 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz7 (\8\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=37.5 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=37.5 c=0
Ry11 (VSS \1\:VSS) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry10 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\17\:n0 \16\:n0) resistor r=20.6667 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
mn1 (\18\:n0 \4\:B \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\18\:n0 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\4\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.323e-14 ad=4.16e-14 ps=8.525e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.7e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp0 (n1 \1\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.9e-07 sd=160n sca=16.2105 \
        scb=0.0148596 scc=0.000661709 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.7e-07 sd=160n sca=14.5024 \
        scb=0.0125934 scc=0.000647761 m=(4)
ends OR2X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:27:38 2012 )
// Library name: gsclib045
// Cell name: OR2X6
// View name: extracted

simulator lang=spectre

subckt OR2X6 A B VDD VSS Y
mp0 (3 \1\:A \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.68e-06 sd=160n sca=18.0856 \
        scb=0.0187649 scc=0.00060075 m=(1)
C1 (Y VSS) capacitor c=2.24543e-17
C2 (A VSS) capacitor c=2.64898e-17
C3 (VDD VSS) capacitor c=1.0842e-16
C4 (B VSS) capacitor c=3.50776e-17
C5 (n0 VSS) capacitor c=4.28685e-16
C6 (3 VSS) capacitor c=1.21067e-18
C7 (5 VSS) capacitor c=1.33527e-18
C8 (\6\:A VSS) capacitor c=8.67337e-17
C9 (\1\:B VSS) capacitor c=7.68936e-17
C10 (\5\:B VSS) capacitor c=4.22224e-17
C11 (\1\:A VSS) capacitor c=5.93981e-17
C12 (\2\:B VSS) capacitor c=2.92452e-17
C13 (\2\:A VSS) capacitor c=3.56524e-16
C14 (\1\:Y VSS) capacitor c=2.88332e-16
C15 (\23\:n0 VSS) capacitor c=9.40939e-17
C16 (\16\:VDD VSS) capacitor c=4.36455e-17
C17 (\1\:VDD VSS) capacitor c=5.16649e-17
C18 (\3\:B VSS) capacitor c=9.60239e-17
C19 (\7\:B VSS) capacitor c=3.70096e-17
C20 (\19\:n0 VSS) capacitor c=1.2088e-16
C21 (\20\:n0 VSS) capacitor c=2.34595e-16
C22 (\4\:Y VSS) capacitor c=2.99999e-16
C23 (\3\:VDD VSS) capacitor c=2.39326e-16
C24 (\8\:VDD VSS) capacitor c=1.22816e-17
Rk20 (\4\:Y Y) resistor r=0.06242 c=0
Rk11 (\1\:Y \4\:Y) resistor r=0.1348 c=0
Rk3 (\2\:A A) resistor r=0.01427 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1153 c=0
Rk25 (\3\:VDD \7\:VDD) resistor r=0.03996 c=0
Rk27 (\8\:VDD VDD) resistor r=0.06481 c=0
Rk26 (\7\:VDD \8\:VDD) resistor r=0.2859 c=0
Rk32 (\8\:VDD \17\:VDD) resistor r=0.3 c=0
Rk33 (\2\:VSS VSS) resistor r=0.1153 c=0
Rk44 (VSS \18\:VSS) resistor r=0.3168 c=0
Rk1 (B \7\:B) resistor r=0.04792 c=0
Rk5 (n0 \19\:n0) resistor r=0.2354 c=0
Rk6 (\19\:n0 \20\:n0) resistor r=0.3061 c=0
Rk8 (\19\:n0 \24\:n0) resistor r=0.6687 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz9 (VDD \1\:VDD) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\7\:VDD \1\:VDD) resistor r=12.5 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=37.5 c=0
Ry8 (\17\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry10 (VSS \1\:VSS) resistor r=6.8889 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\24\:n0 \23\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\20\:n0 \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=4.355e-14 ps=8.85e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.81e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn1 (\20\:n0 \3\:B \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.59e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn2 (\4\:Y n0 VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.978e-14 \
        ad=4.836e-14 ps=9.46e-07 pd=9.32e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.46452e-07 sb=9.6e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mp1 (\23\:n0 \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.545e-06 sd=160n sca=15.1734 scb=0.013698 \
        scc=0.000458097 m=(1)
mp1_1__rcx (\23\:n0 \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.34e-06 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_1__rcx (5 \6\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=2.34e-14 ps=1.4e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.235e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=7.332e-14 ps=1.288e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30638e-07 sb=9.6e-07 sd=160n sca=16.497 \
        scb=0.0142421 scc=0.00124485 m=(5)
ends OR2X6
// End of subcircuit definition.

// Generated for: spectre (May  8 15:28:26 2012 )
// Library name: gsclib045
// Cell name: OR2X8
// View name: extracted

simulator lang=spectre

subckt OR2X8 A B VDD VSS Y
mp0 (3 \1\:A \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.0856 scb=0.0187649 \
        scc=0.00060075 m=(1)
C1 (Y VSS) capacitor c=1.97308e-17
C2 (A VSS) capacitor c=2.44302e-17
C3 (VDD VSS) capacitor c=1.4172e-16
C4 (B VSS) capacitor c=3.5955e-17
C5 (n0 VSS) capacitor c=6.27249e-16
C6 (3 VSS) capacitor c=1.2068e-18
C7 (5 VSS) capacitor c=1.33304e-18
C8 (\6\:A VSS) capacitor c=8.67308e-17
C9 (\1\:B VSS) capacitor c=7.6852e-17
C10 (\5\:B VSS) capacitor c=4.21805e-17
C11 (\1\:A VSS) capacitor c=5.94081e-17
C12 (\2\:B VSS) capacitor c=2.91242e-17
C13 (\2\:A VSS) capacitor c=3.55553e-16
C14 (\1\:Y VSS) capacitor c=4.20907e-16
C15 (\30\:n0 VSS) capacitor c=9.44353e-17
C16 (\20\:VDD VSS) capacitor c=4.2369e-17
C17 (\1\:VDD VSS) capacitor c=6.86343e-17
C18 (\3\:B VSS) capacitor c=9.60212e-17
C19 (\7\:B VSS) capacitor c=3.6763e-17
C20 (\26\:n0 VSS) capacitor c=1.19699e-16
C21 (\27\:n0 VSS) capacitor c=2.34143e-16
C22 (\4\:Y VSS) capacitor c=4.37834e-16
C23 (\3\:VDD VSS) capacitor c=3.08631e-16
C24 (\10\:VDD VSS) capacitor c=1.22986e-17
Rk25 (\4\:Y Y) resistor r=0.05758 c=0
Rk12 (\1\:Y \4\:Y) resistor r=0.1288 c=0
Rk3 (\2\:A A) resistor r=0.01429 c=0
Rk26 (\2\:VDD \3\:VDD) resistor r=0.1103 c=0
Rk32 (\3\:VDD \9\:VDD) resistor r=0.03998 c=0
Rk34 (\10\:VDD VDD) resistor r=0.06483 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.286 c=0
Rk40 (\10\:VDD \21\:VDD) resistor r=0.3009 c=0
Rk41 (\2\:VSS VSS) resistor r=0.1103 c=0
Rk55 (VSS \22\:VSS) resistor r=0.3178 c=0
Rk1 (B \7\:B) resistor r=0.04793 c=0
Rk6 (n0 \26\:n0) resistor r=0.2362 c=0
Rk7 (\26\:n0 \27\:n0) resistor r=0.3069 c=0
Rk9 (\26\:n0 \31\:n0) resistor r=0.6715 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz11 (VDD \1\:VDD) resistor r=75 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz10 (\9\:VDD \1\:VDD) resistor r=12.5 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=37.5 c=0
Ry10 (\21\:VDD \20\:VDD) resistor r=20.6667 c=0
Ry14 (VSS \1\:VSS) resistor r=5.6364 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\31\:n0 \30\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\27\:n0 \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=4.355e-14 ps=8.75e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn1 (\27\:n0 \3\:B \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn2 (\4\:Y n0 VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 as=4.821e-14 \
        ad=4.714e-14 ps=9.2429e-07 pd=9.1429e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.71333e-07 sb=1.37e-06 sd=160n sca=15.1988 scb=0.0148036 \
        scc=0.00121652 m=(7)
mp1 (\30\:n0 \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.955e-06 sd=160n sca=15.1734 scb=0.013698 \
        scc=0.000458097 m=(1)
mp1_1__rcx (\30\:n0 \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.75e-06 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_1__rcx (5 \6\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.57e-14 ad=2.34e-14 ps=1.36e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.645e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.539e-14 ad=7.071e-14 ps=1.24e-06 pd=1.21429e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.58667e-07 sb=1.37e-06 sd=160n sca=15.101 \
        scb=0.013378 scc=0.000967521 m=(7)
ends OR2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:01:33 2012 )
// Library name: gsclib045
// Cell name: OR2XL
// View name: extracted

simulator lang=spectre

subckt OR2XL A B VDD VSS Y
mp1 (\7\:n0 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=33.4025 \
        scb=0.0357193 scc=0.00295004 m=(1)
C1 (A VSS) capacitor c=6.33076e-17
C2 (B VSS) capacitor c=3.00121e-17
C3 (VDD VSS) capacitor c=4.94164e-17
C4 (Y VSS) capacitor c=3.9276e-17
C5 (n0 VSS) capacitor c=3.87755e-17
C6 (n1 VSS) capacitor c=1.01303e-18
C7 (\1\:A VSS) capacitor c=5.19601e-17
C8 (\1\:B VSS) capacitor c=6.45544e-17
C9 (\3\:n0 VSS) capacitor c=3.16861e-17
C10 (\3\:A VSS) capacitor c=4.99974e-17
C11 (\4\:B VSS) capacitor c=2.85385e-17
C12 (\2\:n0 VSS) capacitor c=3.45102e-17
C13 (\2\:A VSS) capacitor c=5.56468e-17
C14 (\3\:B VSS) capacitor c=1.20072e-17
C15 (\3\:Y VSS) capacitor c=2.76126e-17
C16 (\1\:VDD VSS) capacitor c=4.03415e-17
C17 (\7\:n0 VSS) capacitor c=4.83923e-17
C18 (\1\:Y VSS) capacitor c=3.60415e-17
C19 (\4\:n0 VSS) capacitor c=1.33006e-17
C20 (\2\:B VSS) capacitor c=3.35945e-17
C21 (\5\:B VSS) capacitor c=3.42752e-17
C22 (\4\:A VSS) capacitor c=3.68143e-17
C23 (\6\:n0 VSS) capacitor c=6.48277e-17
C24 (\9\:n0 VSS) capacitor c=5.72201e-17
C25 (\4\:VDD VSS) capacitor c=1.39496e-17
Rk2 (\4\:A A) resistor r=0.05173 c=0
Rk9 (\4\:VSS VSS) resistor r=0.1507 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.1159 c=0
Rk10 (VSS \6\:VSS) resistor r=0.08235 c=0
Rk1 (B \5\:B) resistor r=0.09876 c=0
Rk12 (\4\:VDD VDD) resistor r=0.1501 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.4078 c=0
Rk6 (\2\:Y Y) resistor r=0.2341 c=0
Rk7 (Y \4\:Y) resistor r=0.1131 c=0
Rk3 (\5\:n0 \6\:n0) resistor r=0.1202 c=0
Rk4 (\6\:n0 \8\:n0) resistor r=0.4183 c=0
Rk5 (\6\:n0 \9\:n0) resistor r=0.1765 c=0
Rl4 (\1\:A \2\:A) resistor r=31.461 c=0
Rl5 (\2\:A \3\:A) resistor r=100.692 c=0
Rl1 (\1\:B \2\:B) resistor r=125.308 c=0
Rl3 (\2\:B \4\:B) resistor r=37.2017 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl6 (n0 \2\:n0) resistor r=100.692 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=31.461 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry1 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\2\:n0 \9\:n0) resistor r=45 c=0
mn1 (\4\:n0 \4\:B \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.22e-14 ad=2.32e-14 ps=1.29e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.6e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn0 (\4\:n0 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn2 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.175e-14 ps=1.41e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=30.554 \
        scb=0.0308989 scc=0.00253599 m=(1)
mp2 (\3\:Y n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=35.6113 \
        scb=0.0387304 scc=0.00336179 m=(1)
ends OR2XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:29:12 2012 )
// Library name: gsclib045
// Cell name: OR3X1
// View name: extracted

simulator lang=spectre

subckt OR3X1 A B C VDD VSS Y
mp2 (\11\:n0 \1\:C n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=25.9711 scb=0.030099 \
        scc=0.00176698 m=(1)
C1 (Y VSS) capacitor c=1.96149e-17
C2 (C VSS) capacitor c=3.48509e-17
C3 (A VSS) capacitor c=4.65865e-17
C4 (VDD VSS) capacitor c=8.96527e-17
C5 (n0 VSS) capacitor c=4.67931e-17
C6 (n2 VSS) capacitor c=9.47701e-18
C7 (n1 VSS) capacitor c=6.32316e-18
C8 (\1\:A VSS) capacitor c=5.15304e-17
C9 (\1\:B VSS) capacitor c=3.77316e-17
C10 (\1\:C VSS) capacitor c=4.92391e-17
C11 (\3\:n0 VSS) capacitor c=3.53794e-17
C12 (\3\:A VSS) capacitor c=3.84388e-17
C13 (\4\:B VSS) capacitor c=5.02672e-17
C14 (\4\:C VSS) capacitor c=3.38176e-17
C15 (\2\:n0 VSS) capacitor c=2.51117e-17
C16 (\2\:A VSS) capacitor c=4.76141e-17
C17 (\3\:B VSS) capacitor c=2.38718e-17
C18 (\3\:C VSS) capacitor c=1.4037e-17
C19 (\3\:Y VSS) capacitor c=6.55932e-17
C20 (\5\:VDD VSS) capacitor c=4.63907e-17
C21 (\11\:n0 VSS) capacitor c=8.51099e-17
C22 (\1\:VDD VSS) capacitor c=9.94629e-18
C23 (\1\:Y VSS) capacitor c=7.07594e-17
C24 (\9\:n0 VSS) capacitor c=2.99757e-17
C25 (\7\:n0 VSS) capacitor c=5.92443e-17
C26 (\2\:C VSS) capacitor c=4.20855e-17
C27 (\2\:B VSS) capacitor c=4.08596e-17
C28 (\5\:C VSS) capacitor c=1.88362e-17
C29 (\5\:B VSS) capacitor c=3.4527e-17
C30 (\7\:B VSS) capacitor c=4.92237e-17
C31 (\4\:A VSS) capacitor c=4.72463e-17
C32 (\4\:n0 VSS) capacitor c=7.95339e-17
C33 (\6\:n0 VSS) capacitor c=1.50909e-16
Rk11 (Y \2\:Y) resistor r=0.05713 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.4047 c=0
Rk1 (C \5\:C) resistor r=0.01625 c=0
Rk5 (A \4\:A) resistor r=0.09354 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.1201 c=0
Rk15 (\4\:VDD VDD) resistor r=0.1502 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.1803 c=0
Rk16 (\3\:VDD \6\:VDD) resistor r=0.3128 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.03992 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.2077 c=0
Rk20 (\5\:VSS VSS) resistor r=0.04989 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.05245 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.2402 c=0
Rk22 (\4\:VSS \9\:VSS) resistor r=0.2428 c=0
Rk2 (\5\:B \6\:B) resistor r=0.005209 c=0
Rk3 (B \7\:B) resistor r=0.005093 c=0
Rk4 (\5\:B \7\:B) resistor r=0.07853 c=0
Rk6 (\4\:n0 \5\:n0) resistor r=0.3674 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.04641 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.3505 c=0
Rk9 (\5\:n0 \10\:n0) resistor r=0.07643 c=0
Rk10 (\6\:n0 \12\:n0) resistor r=0.7331 c=0
Rl1 (\1\:C \2\:C) resistor r=141.187 c=0
Rl3 (\2\:C \4\:C) resistor r=85.4181 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl7 (\1\:A \2\:A) resistor r=133.384 c=0
Rl8 (\2\:A \3\:A) resistor r=77.6149 c=0
Rl4 (\1\:B \2\:B) resistor r=68.1104 c=0
Rl6 (\2\:B \4\:B) resistor r=158.495 c=0
Rl5 (\2\:B \3\:B) resistor r=1.8551 c=0
Rl9 (n0 \2\:n0) resistor r=66.0764 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=33.3841 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \5\:VSS) resistor r=31 c=0
Ry1 (\11\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\3\:B \6\:B) resistor r=45 c=0
Rx4 (\2\:n0 \4\:n0) resistor r=45 c=0
mn2 (\7\:n0 \4\:C \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn1 (\9\:n0 \4\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.95e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn0 (\9\:n0 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=2.393e-14 ps=9.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn3 (\1\:Y \3\:n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.90385e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.548e-14 \
        ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=5.95e-07 sd=160n sca=16.3573 scb=0.0155593 \
        scc=0.000402391 m=(1)
mp0 (n1 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=3.548e-14 ps=1.18e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=15.0007 \
        scb=0.0128338 scc=0.000363258 m=(1)
mp3 (\3\:Y n0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=5.46e-14 ps=1.18e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.03846e-07 sb=1.4e-07 sd=160n sca=32.724 \
        scb=0.0269508 scc=0.00310791 m=(1)
ends OR3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:02:50 2012 )
// Library name: gsclib045
// Cell name: OR3X2
// View name: extracted

simulator lang=spectre

subckt OR3X2 A B C VDD VSS Y
mp2 (\15\:n0 \1\:C n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05e-06 sd=160n sca=25.9711 \
        scb=0.030099 scc=0.00176698 m=(1)
C1 (C VSS) capacitor c=2.89122e-17
C2 (A VSS) capacitor c=7.65594e-17
C3 (VDD VSS) capacitor c=8.43486e-17
C4 (B VSS) capacitor c=3.07725e-17
C5 (n0 VSS) capacitor c=1.73412e-16
C6 (n2 VSS) capacitor c=5.10147e-18
C7 (n1 VSS) capacitor c=7.68444e-18
C8 (\3\:A VSS) capacitor c=5.40427e-17
C9 (\1\:B VSS) capacitor c=4.13385e-17
C10 (\1\:C VSS) capacitor c=4.83244e-17
C11 (\1\:A VSS) capacitor c=3.87793e-17
C12 (\4\:B VSS) capacitor c=5.16524e-17
C13 (\4\:C VSS) capacitor c=3.73019e-17
C14 (\2\:A VSS) capacitor c=6.43705e-17
C15 (\3\:B VSS) capacitor c=2.84261e-17
C16 (\3\:C VSS) capacitor c=1.69431e-17
C17 (\2\:Y VSS) capacitor c=7.82304e-17
C18 (\15\:n0 VSS) capacitor c=7.82472e-17
C19 (\1\:VDD VSS) capacitor c=1.45216e-17
C20 (\4\:Y VSS) capacitor c=6.09126e-17
C21 (\13\:n0 VSS) capacitor c=2.73249e-17
C22 (\11\:n0 VSS) capacitor c=5.48314e-17
C23 (\2\:C VSS) capacitor c=4.38218e-17
C24 (\2\:B VSS) capacitor c=4.03684e-17
C25 (\5\:C VSS) capacitor c=4.16361e-17
C26 (\5\:B VSS) capacitor c=5.88444e-17
C27 (\8\:n0 VSS) capacitor c=6.32231e-17
C28 (\9\:n0 VSS) capacitor c=2.67157e-17
C29 (\10\:n0 VSS) capacitor c=1.14728e-16
C30 (\1\:Y VSS) capacitor c=5.28046e-17
C31 (\3\:VDD VSS) capacitor c=9.89144e-17
Rk9 (Y \1\:Y) resistor r=0.02462 c=0
Rk10 (\1\:Y \3\:Y) resistor r=0.3696 c=0
Rk11 (\1\:Y \5\:Y) resistor r=0.2381 c=0
Rk1 (C \5\:C) resistor r=0.1167 c=0
Rk3 (\4\:A A) resistor r=0.004839 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.0424 c=0
Rk22 (\5\:VDD VDD) resistor r=0.2503 c=0
Rk21 (\3\:VDD \5\:VDD) resistor r=0.07748 c=0
Rk14 (\1\:VSS \6\:VSS) resistor r=0.2126 c=0
Rk16 (\7\:VSS VSS) resistor r=0.04986 c=0
Rk15 (\6\:VSS \7\:VSS) resistor r=0.05242 c=0
Rk18 (\6\:VSS \11\:VSS) resistor r=0.1755 c=0
Rk2 (B \5\:B) resistor r=0.1047 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.3198 c=0
Rk5 (\9\:n0 \10\:n0) resistor r=0.04884 c=0
Rk6 (\10\:n0 \12\:n0) resistor r=0.3857 c=0
Rk7 (\9\:n0 \14\:n0) resistor r=0.09798 c=0
Rk8 (\10\:n0 \16\:n0) resistor r=0.7681 c=0
Rl1 (\1\:C \2\:C) resistor r=154.649 c=0
Rl3 (\2\:C \4\:C) resistor r=108.495 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl8 (\2\:A \3\:A) resistor r=145.69 c=0
Rl7 (\1\:A \2\:A) resistor r=101.718 c=0
Rl4 (\1\:B \2\:B) resistor r=85.4181 c=0
Rl6 (\2\:B \4\:B) resistor r=177.726 c=0
Rl5 (\2\:B \3\:B) resistor r=3.1183 c=0
Rz3 (\5\:Y \4\:Y) resistor r=37.5 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz8 (\5\:VDD \1\:VDD) resistor r=12.5 c=0
Rz6 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Rz2 (\14\:n0 \13\:n0) resistor r=75 c=0
Ry2 (\3\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry4 (\7\:VSS \3\:VSS) resistor r=31 c=0
Ry1 (\16\:n0 \15\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\3\:B \5\:B) resistor r=45 c=0
Rx4 (\8\:n0 n0) resistor r=45 c=0
mn2 (\11\:n0 \4\:C \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.095e-06 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\13\:n0 \4\:B \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.972e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\13\:n0 \1\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.775e-14 ad=2.972e-14 ps=1.02e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=6.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\4\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.207e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.40577e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp1 (n2 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.655e-14 \
        ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=8.45e-07 sd=160n sca=15.9373 scb=0.0154264 \
        scc=0.000402358 m=(1)
mp0 (n1 \3\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=6.3e-07 sd=160n sca=13.9701 \
        scb=0.0119484 scc=0.000361488 m=(1)
mp3 (\2\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.973e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.0109e-07 sb=3.95e-07 sd=160n sca=29.1463 \
        scb=0.0209237 scc=0.00296778 m=(2)
ends OR3X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:29:59 2012 )
// Library name: gsclib045
// Cell name: OR3X4
// View name: extracted

simulator lang=spectre

subckt OR3X4 A B C VDD VSS Y
mp2 (\19\:n0 \1\:C n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=22.1268 \
        scb=0.0251863 scc=0.00108449 m=(1)
C1 (C VSS) capacitor c=3.20224e-17
C2 (A VSS) capacitor c=4.4988e-17
C3 (VDD VSS) capacitor c=1.28808e-16
C4 (Y VSS) capacitor c=1.86027e-17
C5 (B VSS) capacitor c=6.65032e-17
C6 (n0 VSS) capacitor c=3.64942e-16
C7 (n2 VSS) capacitor c=6.99106e-18
C8 (n1 VSS) capacitor c=1.03954e-17
C9 (\3\:A VSS) capacitor c=4.83927e-17
C10 (\3\:B VSS) capacitor c=8.41582e-17
C11 (\1\:C VSS) capacitor c=8.71936e-17
C12 (\4\:A VSS) capacitor c=4.83433e-17
C13 (\1\:B VSS) capacitor c=4.60766e-17
C14 (\4\:C VSS) capacitor c=3.66873e-17
C15 (\2\:B VSS) capacitor c=6.72932e-17
C16 (\3\:C VSS) capacitor c=1.67417e-17
C17 (\1\:VDD VSS) capacitor c=2.31747e-16
C18 (\19\:n0 VSS) capacitor c=8.16747e-17
C19 (\21\:n0 VSS) capacitor c=3.12314e-17
C20 (\17\:n0 VSS) capacitor c=4.78037e-17
C21 (\2\:C VSS) capacitor c=4.54042e-17
C22 (\2\:A VSS) capacitor c=4.79077e-17
C23 (\5\:C VSS) capacitor c=3.18017e-17
C24 (\4\:B VSS) capacitor c=4.62745e-17
C25 (\5\:A VSS) capacitor c=4.79497e-17
C26 (\15\:n0 VSS) capacitor c=1.49688e-16
C27 (\16\:n0 VSS) capacitor c=3.10459e-17
C28 (\1\:Y VSS) capacitor c=3.08193e-17
C29 (\2\:Y VSS) capacitor c=2.33712e-16
C30 (\5\:Y VSS) capacitor c=1.69356e-16
Rk17 (\2\:VSS \3\:VSS) resistor r=0.03994 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.06753 c=0
Rk23 (\8\:VSS VSS) resistor r=0.1124 c=0
Rk22 (\7\:VSS \8\:VSS) resistor r=0.1378 c=0
Rk27 (\8\:VSS \16\:VSS) resistor r=0.1811 c=0
Rk1 (C \5\:C) resistor r=0.1112 c=0
Rk3 (A \5\:A) resistor r=0.1472 c=0
Rk31 (\1\:VDD VDD) resistor r=0.3156 c=0
Rk10 (Y \1\:Y) resistor r=0.005323 c=0
Rk11 (\1\:Y \2\:Y) resistor r=0.2944 c=0
Rk13 (\1\:Y \5\:Y) resistor r=0.2054 c=0
Rk2 (\4\:B B) resistor r=0.194 c=0
Rk5 (n0 \15\:n0) resistor r=0.3625 c=0
Rk6 (\15\:n0 \16\:n0) resistor r=0.1086 c=0
Rk7 (\16\:n0 \18\:n0) resistor r=0.3418 c=0
Rk8 (\15\:n0 \20\:n0) resistor r=0.7963 c=0
Rk9 (\16\:n0 \22\:n0) resistor r=0.09038 c=0
Rl1 (\1\:C \2\:C) resistor r=151.157 c=0
Rl3 (\2\:C \4\:C) resistor r=68.7458 c=0
Rl2 (\2\:C \3\:C) resistor r=10.2762 c=0
Rl7 (\2\:A \3\:A) resistor r=100.412 c=0
Rl8 (\2\:A \4\:A) resistor r=116.083 c=0
Rl6 (\1\:A \2\:A) resistor r=2.0692 c=0
Rl5 (\2\:B \3\:B) resistor r=118.407 c=0
Rl4 (\1\:B \2\:B) resistor r=80.5087 c=0
Rz8 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\18\:n0 \17\:n0) resistor r=37.5 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=37.5 c=0
Ry4 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry5 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\7\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\20\:n0 \19\:n0) resistor r=31 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\1\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn2 (\17\:n0 \4\:C \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\21\:n0 \1\:B \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.23e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\21\:n0 \4\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.025e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\5\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.355e-14 ps=8.55e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp1 (n2 \3\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.36e-14 \
        ad=2.34e-14 ps=1.26e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.245e-06 sd=160n sca=16.9551 scb=0.0171783 \
        scc=0.000423515 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.36e-14 ps=1.1e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=9.6e-07 sd=160n sca=12.8811 \
        scb=0.0106724 scc=0.000292552 m=(1)
mp3 (\2\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.55e-07 sd=160n sca=12.0193 \
        scb=0.0100773 scc=0.000291813 m=(4)
ends OR3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:04:06 2012 )
// Library name: gsclib045
// Cell name: OR3X6
// View name: extracted

simulator lang=spectre

subckt OR3X6 A B C VDD VSS Y
mp0 (3 \1\:A \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.2198 scb=0.0165162 \
        scc=0.00111264 m=(1)
C1 (A VSS) capacitor c=4.64703e-16
C2 (B VSS) capacitor c=2.84287e-17
C3 (VDD VSS) capacitor c=9.09483e-17
C4 (C VSS) capacitor c=5.55954e-17
C5 (n0 VSS) capacitor c=3.76248e-16
C6 (4 VSS) capacitor c=5.29833e-18
C7 (6 VSS) capacitor c=3.40734e-18
C8 (7 VSS) capacitor c=4.05024e-18
C9 (\6\:A VSS) capacitor c=7.73146e-17
C10 (\4\:B VSS) capacitor c=6.92006e-17
C11 (\1\:C VSS) capacitor c=4.99445e-17
C12 (\5\:C VSS) capacitor c=2.2908e-17
C13 (\1\:B VSS) capacitor c=8.1727e-17
C14 (\1\:A VSS) capacitor c=8.6689e-17
C15 (\2\:C VSS) capacitor c=2.23961e-17
C16 (\2\:B VSS) capacitor c=3.71162e-16
C17 (\1\:VDD VSS) capacitor c=2.3776e-16
C18 (\21\:n0 VSS) capacitor c=8.80381e-17
C19 (\13\:VDD VSS) capacitor c=3.6473e-17
C20 (\4\:VDD VSS) capacitor c=1.13356e-17
C21 (\1\:Y VSS) capacitor c=1.96096e-16
C22 (\23\:n0 VSS) capacitor c=1.59521e-16
C23 (\25\:n0 VSS) capacitor c=8.84788e-17
C24 (\3\:C VSS) capacitor c=1.04823e-16
C25 (\7\:C VSS) capacitor c=5.15574e-17
C26 (\20\:n0 VSS) capacitor c=1.07993e-16
C27 (\4\:Y VSS) capacitor c=2.82741e-16
C28 (\7\:VDD VSS) capacitor c=2.22476e-17
Rk2 (B \2\:B) resistor r=0.0343 c=0
Rk41 (\1\:VDD \7\:VDD) resistor r=0.5534 c=0
Rk43 (\8\:VDD VDD) resistor r=0.04986 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.09252 c=0
Rk46 (\7\:VDD \14\:VDD) resistor r=0.3354 c=0
Rk15 (\1\:Y Y) resistor r=0.02579 c=0
Rk16 (Y \4\:Y) resistor r=0.1697 c=0
Rk33 (\1\:VSS VSS) resistor r=0.03965 c=0
Rk1 (\7\:C C) resistor r=0.1956 c=0
Rk8 (n0 \20\:n0) resistor r=0.2124 c=0
Rk10 (\20\:n0 \23\:n0) resistor r=0.4007 c=0
Rk9 (\20\:n0 \22\:n0) resistor r=0.5856 c=0
Rk13 (\22\:n0 \29\:n0) resistor r=0.146 c=0
Rl13 (A \6\:A) resistor r=99.4612 c=0
Rl1 (A \1\:A) resistor r=143.796 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl5 (\2\:C \1\:C) resistor r=77.4283 c=0
Rl8 (\2\:C \5\:C) resistor r=21.9171 c=0
Rl6 (\3\:C \2\:C) resistor r=58.1371 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz14 (\8\:VDD \4\:VDD) resistor r=37.5 c=0
Rz2 (\25\:n0 \23\:n0) resistor r=75 c=0
Ry14 (\14\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry10 (VSS \3\:VSS) resistor r=62 c=0
Ry6 (\1\:VSS \3\:VSS) resistor r=4.7692 c=0
Ry1 (\22\:n0 \21\:n0) resistor r=62 c=0
Ry2 (\29\:n0 \21\:n0) resistor r=62 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn0 (\23\:n0 A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=4.16e-14 ps=1.2e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.89462e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn1 (\23\:n0 \2\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.48e-14 ad=4.16e-14 ps=1.42e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.86308e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn2 (\25\:n0 \3\:C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.48e-14 ad=4.16e-14 ps=1.42e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.78846e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(2)
mn3 (\1\:Y n0 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.548e-14 ad=4.836e-14 ps=1.12e-06 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12903e-06 sb=1.02e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mp1 (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.96e-06 sd=160n sca=17.2297 scb=0.0151721 \
        scc=0.00110421 m=(1)
mp2 (\21\:n0 \5\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.1e-07 sb=1.695e-06 sd=160n sca=16.0668 scb=0.0143054 \
        scc=0.00110277 m=(1)
mp2_1__rcx (\21\:n0 \1\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.49e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp1_1__rcx (6 \4\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.485e-14 ps=1.02e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.33e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp0_1__rcx (7 \6\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.04e-14 ad=4.68e-14 ps=1.26e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.165e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp3 (\4\:Y n0 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.05011e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends OR3X6
// End of subcircuit definition.

// Generated for: spectre (May  9 17:04:44 2012 )
// Library name: gsclib045
// Cell name: OR3X8
// View name: extracted

simulator lang=spectre

subckt OR3X8 A B C VDD VSS Y
mp0 (3 \1\:A \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.1638 scb=0.0188942 \
        scc=0.00161316 m=(1)
C1 (B VSS) capacitor c=3.67145e-17
C2 (VDD VSS) capacitor c=9.61045e-17
C3 (Y VSS) capacitor c=1.19488e-17
C4 (C VSS) capacitor c=3.2841e-17
C5 (n0 VSS) capacitor c=5.24403e-16
C6 (4 VSS) capacitor c=5.41575e-18
C7 (6 VSS) capacitor c=3.36624e-18
C8 (7 VSS) capacitor c=4.14525e-18
C9 (\6\:A VSS) capacitor c=7.50945e-17
C10 (\4\:B VSS) capacitor c=6.90735e-17
C11 (\1\:C VSS) capacitor c=4.97463e-17
C12 (\5\:C VSS) capacitor c=2.26551e-17
C13 (\1\:B VSS) capacitor c=8.14141e-17
C14 (\1\:A VSS) capacitor c=8.41352e-17
C15 (\2\:C VSS) capacitor c=2.24778e-17
C16 (\2\:B VSS) capacitor c=3.66086e-16
C17 (\2\:A VSS) capacitor c=4.63835e-16
C18 (\1\:Y VSS) capacitor c=4.08473e-16
C19 (\35\:n0 VSS) capacitor c=8.78498e-17
C20 (\17\:VDD VSS) capacitor c=3.72878e-17
C21 (\1\:VDD VSS) capacitor c=3.51756e-17
C22 (\29\:n0 VSS) capacitor c=1.6122e-16
C23 (\31\:n0 VSS) capacitor c=9.19085e-17
C24 (\3\:C VSS) capacitor c=1.04313e-16
C25 (\7\:C VSS) capacitor c=6.88795e-17
C26 (\28\:n0 VSS) capacitor c=1.12411e-16
C27 (\4\:Y VSS) capacitor c=2.01395e-16
C28 (\3\:VDD VSS) capacitor c=2.96051e-16
C29 (\8\:VDD VSS) capacitor c=1.54312e-17
Rk5 (\2\:A A) resistor r=0.002993 c=0
Rk2 (B \2\:B) resistor r=0.06925 c=0
Rk46 (\2\:VDD \3\:VDD) resistor r=0.05493 c=0
Rk50 (\3\:VDD \7\:VDD) resistor r=0.1301 c=0
Rk52 (\8\:VDD VDD) resistor r=0.1273 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.4233 c=0
Rk57 (\8\:VDD \18\:VDD) resistor r=0.352 c=0
Rk14 (\1\:Y Y) resistor r=0.1633 c=0
Rk15 (Y \4\:Y) resistor r=0.01235 c=0
Rk38 (\1\:VSS VSS) resistor r=0.02461 c=0
Rk33 (\1\:VSS \11\:VSS) resistor r=0.06614 c=0
Rk1 (\7\:C C) resistor r=0.1926 c=0
Rk8 (n0 \28\:n0) resistor r=0.236 c=0
Rk9 (\28\:n0 \29\:n0) resistor r=0.4278 c=0
Rk12 (\28\:n0 \36\:n0) resistor r=0.6699 c=0
Rl13 (\2\:A \6\:A) resistor r=82.4874 c=0
Rl1 (\2\:A \1\:A) resistor r=134.181 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl5 (\2\:C \1\:C) resistor r=77.4283 c=0
Rl8 (\2\:C \5\:C) resistor r=21.9171 c=0
Rl6 (\3\:C \2\:C) resistor r=52.3679 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz16 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\31\:n0 \29\:n0) resistor r=75 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry1 (\36\:n0 \35\:n0) resistor r=31 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn0 (\29\:n0 \2\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.338e-14 ad=4.16e-14 ps=1.2e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82875e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn1 (\29\:n0 \2\:B \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.36e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7775e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn2 (\31\:n0 \3\:C \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.36e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.71125e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(2)
mn3 (\4\:Y n0 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.336e-14 ad=4.636e-14 ps=1.00857e-06 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05847e-06 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mp1 (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
