        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(5)
mp0_1__rcx (\52\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.38e-14 ad=6.084e-14 ps=1.128e-06 pd=1.092e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(5)
ends BUFX20
// End of subcircuit definition.

// Generated for: spectre (May  9 13:48:01 2012 )
// Library name: gsclib045
// Cell name: BUFX3
// View name: extracted

simulator lang=spectre

subckt BUFX3 A VDD VSS Y
mp1 (Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.98e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.8768 scb=0.0296503 \
        scc=0.00178994 m=(3)
C1 (Y VSS) capacitor c=3.28471e-16
C2 (A VSS) capacitor c=2.75414e-17
C3 (VDD VSS) capacitor c=9.04714e-17
C4 (n0 VSS) capacitor c=1.83194e-16
C5 (\1\:A VSS) capacitor c=4.72344e-17
C6 (\3\:A VSS) capacitor c=3.77496e-17
C7 (\2\:A VSS) capacitor c=4.35953e-17
C8 (\7\:n0 VSS) capacitor c=3.83863e-17
C9 (\11\:n0 VSS) capacitor c=7.83174e-17
C10 (\1\:VDD VSS) capacitor c=1.97518e-16
C11 (\14\:n0 VSS) capacitor c=6.84466e-17
C12 (\4\:A VSS) capacitor c=6.38101e-17
C13 (\13\:n0 VSS) capacitor c=1.12876e-16
Rk16 (\1\:VSS VSS) resistor r=0.1023 c=0
Rk7 (\4\:A A) resistor r=0.02444 c=0
Rk12 (\1\:VDD VDD) resistor r=0.1023 c=0
Rk8 (\12\:n0 \13\:n0) resistor r=0.5178 c=0
Rk9 (\13\:n0 \15\:n0) resistor r=0.4356 c=0
Rl10 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl11 (\2\:A \3\:A) resistor r=55.0021 c=0
Rl6 (n0 \7\:n0) resistor r=3.8801 c=0
Rz3 (\15\:n0 \14\:n0) resistor r=37.5 c=0
Ry3 (\12\:n0 \11\:n0) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\13\:n0 \7\:n0) resistor r=45 c=0
mn1 (\1\:VSS n0 Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.987e-14 \
        ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(3)
mn0 (\1\:VSS \3\:A \14\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mp0 (\11\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=16.7198 \
        scb=0.0160191 scc=0.000448714 m=(1)
ends BUFX3
// End of subcircuit definition.

// Generated for: spectre (May  9 13:48:38 2012 )
// Library name: gsclib045
// Cell name: BUFX4
// View name: extracted

simulator lang=spectre

subckt BUFX4 A VDD VSS Y
mp1 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.337e-14 \
        ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.75e-07 sd=160n sca=29.498 scb=0.0332632 \
        scc=0.00250913 m=(4)
C1 (VDD VSS) capacitor c=3.01779e-16
C2 (A VSS) capacitor c=3.07415e-17
C3 (Y VSS) capacitor c=2.49889e-17
C4 (n0 VSS) capacitor c=2.38664e-16
C5 (\1\:A VSS) capacitor c=4.25632e-17
C6 (\3\:A VSS) capacitor c=4.62351e-17
C7 (\2\:A VSS) capacitor c=4.05121e-17
C8 (\8\:n0 VSS) capacitor c=3.80763e-17
C9 (\14\:n0 VSS) capacitor c=8.79699e-17
C10 (\1\:Y VSS) capacitor c=3.63794e-16
C11 (\17\:n0 VSS) capacitor c=5.7025e-17
C12 (\4\:A VSS) capacitor c=6.13399e-17
C13 (\16\:n0 VSS) capacitor c=9.48436e-17
Rk7 (\4\:A A) resistor r=0.01672 c=0
Rk3 (\1\:Y Y) resistor r=0.1185 c=0
Rk8 (\15\:n0 \16\:n0) resistor r=0.5815 c=0
Rk9 (\16\:n0 \18\:n0) resistor r=0.3907 c=0
Rl13 (\1\:A \2\:A) resistor r=55.0021 c=0
Rl14 (\2\:A \3\:A) resistor r=105.002 c=0
Rl7 (n0 \8\:n0) resistor r=3.8088 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=37.5 c=0
Ry3 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\16\:n0 \8\:n0) resistor r=45 c=0
mn1 (VSS n0 \1\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.75e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
mn0 (VSS \3\:A \17\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp0 (\14\:n0 \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=20.4961 \
        scb=0.0204164 scc=0.00119548 m=(1)
ends BUFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:49:15 2012 )
// Library name: gsclib045
// Cell name: BUFX6
// View name: extracted

simulator lang=spectre

subckt BUFX6 A VDD VSS Y
mp1 (Y n0 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.424e-14 \
        ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.2934e-06 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(5)
C1 (Y VSS) capacitor c=4.7101e-16
C2 (VDD VSS) capacitor c=6.4914e-17
C3 (A VSS) capacitor c=3.54357e-17
C4 (n0 VSS) capacitor c=2.93528e-16
C5 (\1\:A VSS) capacitor c=1.54437e-16
C6 (\6\:A VSS) capacitor c=1.06276e-17
C7 (\1\:VDD VSS) capacitor c=3.65582e-16
C8 (\17\:n0 VSS) capacitor c=7.78289e-17
C9 (\21\:n0 VSS) capacitor c=5.7952e-17
C10 (\19\:n0 VSS) capacitor c=4.30856e-17
C11 (\20\:n0 VSS) capacitor c=3.42976e-17
C12 (\8\:A VSS) capacitor c=2.90076e-17
Rk20 (\1\:VDD VDD) resistor r=0.1024 c=0
Rk13 (\8\:A \9\:A) resistor r=0.006005 c=0
Rk14 (\10\:A A) resistor r=0.006353 c=0
Rk15 (\9\:A \10\:A) resistor r=0.03706 c=0
Rk28 (\1\:VSS VSS) resistor r=0.1024 c=0
Rk10 (\18\:n0 \19\:n0) resistor r=0.2612 c=0
Rk11 (\19\:n0 \20\:n0) resistor r=0.1652 c=0
Rk12 (\19\:n0 \22\:n0) resistor r=0.2473 c=0
Rl20 (\1\:A \6\:A) resistor r=4.8851 c=0
Rl8 (n0 \9\:n0) resistor r=3.8088 c=0
Rz4 (\22\:n0 \21\:n0) resistor r=37.5 c=0
Ry4 (\18\:n0 \17\:n0) resistor r=20.6667 c=0
Rx2 (\8\:A \6\:A) resistor r=45 c=0
Rx1 (\20\:n0 \9\:n0) resistor r=45 c=0
mn1 (\1\:VSS n0 Y VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=4.9e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.29742e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn0 (\1\:VSS \1\:A \21\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.15e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mp0 (\17\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=32.0467 \
        scb=0.0213026 scc=0.00336306 m=(2)
ends BUFX6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:49:53 2012 )
// Library name: gsclib045
// Cell name: BUFX8
// View name: extracted

simulator lang=spectre

subckt BUFX8 A VDD VSS Y
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72438e-06 sd=160n sca=25.5327 \
        scb=0.0229112 scc=0.00209852 m=(7)
C1 (Y VSS) capacitor c=1.73032e-17
C2 (VDD VSS) capacitor c=7.91219e-17
C3 (n0 VSS) capacitor c=6.68268e-16
C4 (\1\:A VSS) capacitor c=1.49716e-16
C5 (\6\:A VSS) capacitor c=1.74337e-17
C6 (\1\:VDD VSS) capacitor c=4.29708e-16
C7 (\22\:n0 VSS) capacitor c=7.78088e-17
C8 (\1\:Y VSS) capacitor c=4.07433e-16
C9 (\28\:n0 VSS) capacitor c=2.17286e-17
C10 (\6\:Y VSS) capacitor c=4.29277e-16
C11 (\24\:n0 VSS) capacitor c=4.10445e-17
C12 (\8\:A VSS) capacitor c=7.68118e-17
Rk4 (\1\:Y Y) resistor r=0.1156 c=0
Rk5 (Y \6\:Y) resistor r=0.09208 c=0
Rk26 (\1\:VDD VDD) resistor r=0.1802 c=0
Rk20 (A \8\:A) resistor r=0.01092 c=0
Rk36 (\1\:VSS VSS) resistor r=0.1802 c=0
Rk16 (\24\:n0 n0) resistor r=0.1704 c=0
Rk15 (\23\:n0 \24\:n0) resistor r=0.2673 c=0
Rk19 (\24\:n0 \29\:n0) resistor r=0.164 c=0
Rl23 (\1\:A \6\:A) resistor r=10.1271 c=0
Rz5 (\29\:n0 \28\:n0) resistor r=75 c=0
Ry5 (\23\:n0 \22\:n0) resistor r=20.6667 c=0
Rx4 (\8\:A \6\:A) resistor r=45 c=0
mn1 (\1\:VSS n0 \6\:Y VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.69e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72661e-06 sd=160n sca=14.382 \
        scb=0.0140935 scc=0.0010585 m=(7)
mn0 (\1\:VSS \1\:A \28\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.075e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mp0 (\22\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(2)
ends BUFX8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:50:31 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X12
// View name: extracted

simulator lang=spectre

subckt CLKAND2X12 A B VDD VSS Y
mp1 (\44\:net61 \2\:B \1\:VDD VDD) g45p1svt w=(2.35e-07) l=4.5e-08 nf=1 \
        as=5.53e-14 ad=3.76e-14 ps=1.43e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.9528 scb=0.026615 \
        scc=0.00120831 m=(5)
C1 (B VSS) capacitor c=1.39949e-17
C2 (Y VSS) capacitor c=1.81535e-17
C3 (VDD VSS) capacitor c=2.15266e-16
C4 (A VSS) capacitor c=6.68613e-16
C5 (7 VSS) capacitor c=2.60375e-18
C6 (net61 VSS) capacitor c=8.39292e-16
C7 (8 VSS) capacitor c=1.81486e-18
C8 (9 VSS) capacitor c=4.09274e-18
C9 (10 VSS) capacitor c=7.00208e-18
C10 (11 VSS) capacitor c=1.93492e-18
C11 (\16\:A VSS) capacitor c=6.66239e-17
C12 (\13\:B VSS) capacitor c=5.61865e-17
C13 (\14\:B VSS) capacitor c=2.4603e-17
C14 (\12\:A VSS) capacitor c=3.284e-17
C15 (\11\:A VSS) capacitor c=3.96594e-17
C16 (\8\:B VSS) capacitor c=2.86598e-17
C17 (\7\:B VSS) capacitor c=5.54153e-17
C18 (\1\:A VSS) capacitor c=5.0846e-17
C19 (\7\:A VSS) capacitor c=4.18917e-17
C20 (\1\:B VSS) capacitor c=5.08353e-17
C21 (\2\:B VSS) capacitor c=6.29462e-16
C22 (\1\:VDD VSS) capacitor c=5.57876e-16
C23 (\44\:net61 VSS) capacitor c=2.95641e-16
C24 (\1\:Y VSS) capacitor c=4.88939e-16
C25 (\54\:net61 VSS) capacitor c=2.45227e-17
C26 (\40\:net61 VSS) capacitor c=1.52433e-16
C27 (\42\:net61 VSS) capacitor c=5.68994e-17
C28 (\38\:net61 VSS) capacitor c=7.27412e-17
C29 (\39\:net61 VSS) capacitor c=8.75962e-17
C30 (\9\:Y VSS) capacitor c=6.14007e-16
Rk2 (\2\:B B) resistor r=0.02594 c=0
Rk27 (\1\:Y Y) resistor r=0.2439 c=0
Rk28 (Y \9\:Y) resistor r=0.05423 c=0
Rk58 (\1\:VDD VDD) resistor r=0.02463 c=0
Rk78 (\1\:VSS \13\:VSS) resistor r=0.2581 c=0
Rk79 (\13\:VSS \14\:VSS) resistor r=0.3506 c=0
Rk81 (\15\:VSS VSS) resistor r=0.1 c=0
Rk80 (\14\:VSS \15\:VSS) resistor r=0.1427 c=0
Rk87 (\13\:VSS \27\:VSS) resistor r=0.254 c=0
Rk88 (\14\:VSS \29\:VSS) resistor r=0.254 c=0
Rk12 (net61 \38\:net61) resistor r=0.112 c=0
Rk16 (\38\:net61 \44\:net61) resistor r=0.3956 c=0
Rk13 (\38\:net61 \39\:net61) resistor r=0.4363 c=0
Rk14 (\39\:net61 \41\:net61) resistor r=0.6352 c=0
Rk15 (\41\:net61 \43\:net61) resistor r=0.5463 c=0
Rk21 (\39\:net61 \55\:net61) resistor r=0.05786 c=0
Rl21 (\2\:B \13\:B) resistor r=58.8489 c=0
Rl22 (\2\:B \14\:B) resistor r=35.7713 c=0
Rl12 (\2\:B \8\:B) resistor r=24.7951 c=0
Rl11 (\2\:B \7\:B) resistor r=71.1317 c=0
Rl1 (\2\:B \1\:B) resistor r=44.0258 c=0
Rl25 (A \16\:A) resistor r=53.6412 c=0
Rl17 (A \12\:A) resistor r=93.9123 c=0
Rl16 (A \11\:A) resistor r=97.9249 c=0
Rl3 (A \1\:A) resistor r=33.5003 c=0
Rl8 (A \7\:A) resistor r=35.9003 c=0
Rz23 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz24 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz1 (\41\:net61 \40\:net61) resistor r=75 c=0
Rz2 (\43\:net61 \42\:net61) resistor r=37.5 c=0
Rz3 (\55\:net61 \54\:net61) resistor r=37.5 c=0
Ry26 (\15\:VSS \1\:VSS) resistor r=20.6667 c=0
mn1_1__rcx (\42\:net61 \1\:B 7 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.635e-14 ad=4.34e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_1__rcx (7 \7\:A \28\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=2.635e-14 ps=9.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0 (8 \1\:A \28\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.86e-14 ps=9.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn1 (\40\:net61 \7\:B 8 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn1_2__rcx (\40\:net61 \8\:B 9 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_2__rcx (9 \11\:A \26\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_3__rcx (10 \12\:A \26\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.665e-14 ps=9.4e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn1_3__rcx (\54\:net61 \14\:B 10 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=4.96e-14 ps=1.05e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.435e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn1_4__rcx (\54\:net61 \13\:B 11 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(1)
mn0_4__rcx (11 \16\:A \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=1.86e-14 ps=1.08e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.745e-06 sb=2e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(1)
mn2_1__rcx (\1\:Y net61 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.332e-14 ad=4.96e-14 ps=9.64e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(10)
mp0_1__rcx (\44\:net61 A \1\:VDD VDD) g45p1svt w=(2.35e-07) l=4.5e-08 \
        nf=1 as=7.119e-14 ad=3.76e-14 ps=1.66e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.4006 scb=0.0157854 \
        scc=0.000608134 m=(5)
mp2_1__rcx (\9\:Y net61 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.798e-14 ad=7.52e-14 ps=1.32e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06266e-06 sb=1.985e-06 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(10)
ends CLKAND2X12
// End of subcircuit definition.

// Generated for: spectre (May  9 13:51:08 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X2
// View name: extracted

simulator lang=spectre

subckt CLKAND2X2 A B VDD VSS Y
mp1 (\10\:net61 \4\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=4.623e-14 ps=1.35e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=8.6e-07 sd=160n sca=29.6691 scb=0.0324961 \
        scc=0.00263757 m=(1)
C1 (Y VSS) capacitor c=1.54631e-17
C2 (B VSS) capacitor c=9.53773e-17
C3 (VDD VSS) capacitor c=6.22165e-17
C4 (A VSS) capacitor c=6.3779e-17
C5 (net69 VSS) capacitor c=2.52116e-18
C6 (net61 VSS) capacitor c=1.67803e-16
C7 (\1\:A VSS) capacitor c=4.9973e-17
C8 (\4\:B VSS) capacitor c=2.7664e-17
C9 (\3\:A VSS) capacitor c=7.49496e-17
C10 (\1\:B VSS) capacitor c=7.38325e-17
C11 (\2\:A VSS) capacitor c=5.90254e-17
C12 (\3\:B VSS) capacitor c=1.12079e-17
C13 (\4\:Y VSS) capacitor c=8.47662e-17
C14 (\10\:net61 VSS) capacitor c=9.47515e-17
C15 (\11\:VDD VSS) capacitor c=1.75478e-17
C16 (\1\:VDD VSS) capacitor c=1.87633e-17
C17 (\2\:Y VSS) capacitor c=4.98096e-17
C18 (\8\:net61 VSS) capacitor c=7.72777e-17
C19 (\2\:B VSS) capacitor c=3.62946e-17
C20 (\4\:A VSS) capacitor c=5.33769e-17
C21 (\7\:net61 VSS) capacitor c=6.80323e-17
C22 (\1\:Y VSS) capacitor c=5.55941e-17
C23 (\3\:VDD VSS) capacitor c=8.62435e-17
Rk5 (Y \1\:Y) resistor r=0.01983 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.2677 c=0
Rk7 (\1\:Y \5\:Y) resistor r=0.4037 c=0
Rk1 (B \5\:B) resistor r=0.002991 c=0
Rk19 (\3\:VSS VSS) resistor r=0.2001 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.0549 c=0
Rk11 (\3\:VDD VDD) resistor r=0.2153 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.0549 c=0
Rk15 (VDD \12\:VDD) resistor r=0.1006 c=0
Rk2 (A \4\:A) resistor r=0.1841 c=0
Rk3 (\7\:net61 \9\:net61) resistor r=0.3931 c=0
Rk4 (\9\:net61 \11\:net61) resistor r=0.4633 c=0
Rl3 (\2\:B \4\:B) resistor r=87.2017 c=0
Rl1 (\1\:B \2\:B) resistor r=144.539 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl4 (\1\:A \2\:A) resistor r=135.307 c=0
Rl5 (\2\:A \3\:A) resistor r=44.9225 c=0
Rz2 (\3\:Y \2\:Y) resistor r=75 c=0
Rz5 (VDD \1\:VDD) resistor r=75 c=0
Rz3 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz4 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz1 (\9\:net61 \8\:net61) resistor r=75 c=0
Ry2 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry7 (\3\:VSS \1\:VSS) resistor r=12.4 c=0
Ry5 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\11\:net61 \10\:net61) resistor r=62 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:net61 net61) resistor r=45 c=0
mn1 (\8\:net61 \1\:B net69 VSS) g45n1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=4.06e-14 ps=7e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.53276e-07 sd=160n sca=11.0503 \
        scb=0.01032 scc=0.000482273 m=(1)
mn0 (net69 \3\:A \3\:VSS VSS) g45n1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=4.46e-14 ad=1.74e-14 ps=9e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.48276e-07 sd=160n sca=11.0503 scb=0.01032 \
        scc=0.000482273 m=(1)
mn2 (\2\:Y net61 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.7e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=3.95e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(2)
mp0 (\10\:net61 \1\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.623e-14 ps=1.1e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6e-07 sd=160n sca=14.8606 scb=0.0129927 \
        scc=0.000217202 m=(1)
mp2 (\4\:Y net61 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.3e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.56346e-07 sb=3.95e-07 sd=160n sca=21.7424 \
        scb=0.0181571 scc=0.00171859 m=(2)
ends CLKAND2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:51:46 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X3
// View name: extracted

simulator lang=spectre

subckt CLKAND2X3 A B VDD VSS Y
mp0 (\13\:net61 A VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.642e-14 ad=3.12e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43e-06 sd=160n sca=42.2144 \
        scb=0.0437053 scc=0.00493222 m=(2)
C1 (Y VSS) capacitor c=1.8667e-17
C2 (VDD VSS) capacitor c=1.68702e-16
C3 (A VSS) capacitor c=3.223e-16
C4 (7 VSS) capacitor c=5.24971e-20
C5 (net61 VSS) capacitor c=1.94067e-16
C6 (8 VSS) capacitor c=1.71309e-18
C7 (\1\:B VSS) capacitor c=1.06821e-16
C8 (\6\:A VSS) capacitor c=5.37178e-17
C9 (\5\:B VSS) capacitor c=5.72848e-17
C10 (\4\:B VSS) capacitor c=5.91741e-17
C11 (\1\:A VSS) capacitor c=5.07666e-17
C12 (\1\:Y VSS) capacitor c=1.2648e-16
C13 (\13\:net61 VSS) capacitor c=1.10728e-16
C14 (\15\:VDD VSS) capacitor c=6.43585e-18
C15 (\1\:VDD VSS) capacitor c=4.21438e-17
C16 (\4\:Y VSS) capacitor c=7.99663e-17
C17 (\17\:net61 VSS) capacitor c=7.45401e-17
C18 (\8\:B VSS) capacitor c=6.70717e-17
C19 (\9\:B VSS) capacitor c=3.94058e-17
C20 (\11\:net61 VSS) capacitor c=2.86422e-17
C21 (\12\:net61 VSS) capacitor c=7.85344e-17
Rk1 (\7\:B \8\:B) resistor r=0.001871 c=0
Rk2 (\9\:B B) resistor r=0.001871 c=0
Rk3 (\8\:B \9\:B) resistor r=0.0327 c=0
Rk11 (\1\:Y Y) resistor r=0.1674 c=0
Rk12 (Y \4\:Y) resistor r=0.1131 c=0
Rk15 (\2\:VDD VDD) resistor r=0.1046 c=0
Rk25 (VDD \16\:VDD) resistor r=0.07277 c=0
Rk28 (\1\:VSS \6\:VSS) resistor r=0.1446 c=0
Rk30 (\7\:VSS VSS) resistor r=0.04948 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.1496 c=0
Rk33 (\7\:VSS \12\:VSS) resistor r=0.2012 c=0
Rk7 (\12\:net61 \13\:net61) resistor r=0.3997 c=0
Rk6 (\11\:net61 \12\:net61) resistor r=0.1104 c=0
Rk9 (\12\:net61 \18\:net61) resistor r=0.4532 c=0
Rl6 (\1\:B \5\:B) resistor r=99.2335 c=0
Rl5 (\1\:B \4\:B) resistor r=98.8098 c=0
Rl9 (A \6\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=28.6412 c=0
Rz5 (VDD \1\:VDD) resistor r=10.7143 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz10 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\18\:net61 \17\:net61) resistor r=75 c=0
Ry8 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry11 (VSS \3\:VSS) resistor r=62 c=0
Ry9 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry10 (\6\:VSS \3\:VSS) resistor r=20.6667 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
Rx4 (\11\:net61 net61) resistor r=45 c=0
mn0 (7 \1\:A \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.27e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\17\:net61 \4\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.165e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (\17\:net61 \5\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.6e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_1__rcx (8 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=8.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\4\:Y net61 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.027e-14 ad=3.987e-14 ps=9.0667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.5e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(3)
mp1 (\13\:net61 \1\:B \15\:VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=3.12e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.225e-06 sd=160n sca=32.1806 \
        scb=0.0290326 scc=0.0035676 m=(2)
mp2 (\1\:Y net61 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.012e-14 ad=5.98e-14 ps=1.38333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=5.5e-07 sd=160n sca=20.4293 \
        scb=0.0170251 scc=0.00184286 m=(3)
ends CLKAND2X3
// End of subcircuit definition.

// Generated for: spectre (May  9 13:52:23 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X4
// View name: extracted

simulator lang=spectre

subckt CLKAND2X4 A B VDD VSS Y
mp0 (\17\:net61 A \1\:VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.995e-14 ad=3.12e-14 ps=1.84e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.645e-06 sd=160n sca=36.6813 \
        scb=0.0366529 scc=0.00396633 m=(2)
C1 (B VSS) capacitor c=4.79816e-17
C2 (Y VSS) capacitor c=1.99818e-17
C3 (VDD VSS) capacitor c=8.04772e-17
C4 (A VSS) capacitor c=3.27117e-16
C5 (7 VSS) capacitor c=1.16406e-19
C6 (net61 VSS) capacitor c=3.16961e-16
C7 (8 VSS) capacitor c=2.0482e-18
C8 (\1\:B VSS) capacitor c=9.96877e-17
C9 (\6\:A VSS) capacitor c=5.49695e-17
C10 (\4\:B VSS) capacitor c=5.90794e-17
C11 (\5\:B VSS) capacitor c=5.95588e-17
C12 (\1\:A VSS) capacitor c=5.06578e-17
C13 (\1\:VDD VSS) capacitor c=1.39807e-16
C14 (\17\:net61 VSS) capacitor c=1.11446e-16
C15 (\12\:VDD VSS) capacitor c=7.43275e-18
C16 (\3\:VDD VSS) capacitor c=4.22272e-17
C17 (\1\:Y VSS) capacitor c=1.32862e-16
C18 (\21\:net61 VSS) capacitor c=6.74949e-17
C19 (\7\:B VSS) capacitor c=9.09586e-17
C20 (\16\:net61 VSS) capacitor c=8.38262e-17
C21 (\5\:Y VSS) capacitor c=1.81922e-16
Rk1 (B \7\:B) resistor r=0.1107 c=0
Rk10 (\1\:Y Y) resistor r=0.2801 c=0
Rk11 (Y \5\:Y) resistor r=0.07296 c=0
Rk24 (\1\:VDD VDD) resistor r=0.05447 c=0
Rk20 (\1\:VDD \13\:VDD) resistor r=0.07277 c=0
Rk26 (\2\:VSS \3\:VSS) resistor r=0.05971 c=0
Rk30 (\3\:VSS \7\:VSS) resistor r=0.07968 c=0
Rk32 (\8\:VSS VSS) resistor r=0.08442 c=0
Rk31 (\7\:VSS \8\:VSS) resistor r=0.2145 c=0
Rk36 (\8\:VSS \16\:VSS) resistor r=0.2078 c=0
Rk5 (net61 \16\:net61) resistor r=0.1872 c=0
Rk6 (\16\:net61 \17\:net61) resistor r=0.3734 c=0
Rk8 (\16\:net61 \22\:net61) resistor r=0.4469 c=0
Rl5 (\1\:B \4\:B) resistor r=111.253 c=0
Rl6 (\1\:B \5\:B) resistor r=103.297 c=0
Rl9 (A \6\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=28.6412 c=0
Rz7 (VDD \3\:VDD) resistor r=75 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz11 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\22\:net61 \21\:net61) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry12 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
mn0 (7 \1\:A \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.445e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn1 (\21\:net61 \5\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.34e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn1_1__rcx (\21\:net61 \4\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.135e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn0_1__rcx (8 \6\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.03e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(1)
mn2 (\1\:Y net61 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=7.55e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(4)
mp1 (\17\:net61 \1\:B \12\:VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=3.12e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.44e-06 sd=160n sca=31.0619 \
        scb=0.0271542 scc=0.0035377 m=(2)
mp2 (\5\:Y net61 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.673e-14 ad=6.24e-14 ps=1.3075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=7.55e-07 sd=160n sca=20.0159 \
        scb=0.0168107 scc=0.00184273 m=(4)
ends CLKAND2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:53:01 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X6
// View name: extracted

simulator lang=spectre

subckt CLKAND2X6 A B VDD VSS Y
mp0 (\20\:net61 A VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=3.12e-14 ps=1.4e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=59.1807 scb=0.0520305 \
        scc=0.00794391 m=(4)
C1 (B VSS) capacitor c=4.02346e-16
C2 (Y VSS) capacitor c=1.17741e-17
C3 (VDD VSS) capacitor c=4.16603e-16
C4 (A VSS) capacitor c=5.61227e-16
C5 (net61 VSS) capacitor c=3.91854e-16
C6 (8 VSS) capacitor c=1.73025e-18
C7 (9 VSS) capacitor c=5.09438e-18
C8 (10 VSS) capacitor c=1.73025e-18
C9 (\12\:A VSS) capacitor c=6.50244e-17
C10 (\11\:B VSS) capacitor c=4.44897e-17
C11 (\12\:B VSS) capacitor c=2.42822e-17
C12 (\8\:A VSS) capacitor c=2.88651e-17
C13 (\7\:A VSS) capacitor c=4.79006e-17
C14 (\1\:B VSS) capacitor c=5.60844e-17
C15 (\4\:B VSS) capacitor c=3.48802e-17
C16 (\1\:A VSS) capacitor c=3.09781e-17
C17 (\1\:Y VSS) capacitor c=2.92562e-16
C18 (\20\:net61 VSS) capacitor c=2.04685e-16
C19 (\28\:net61 VSS) capacitor c=1.20396e-16
C20 (\30\:net61 VSS) capacitor c=8.25501e-17
C21 (\19\:net61 VSS) capacitor c=7.98491e-17
C22 (\4\:Y VSS) capacitor c=2.13702e-16
Rk15 (\1\:Y Y) resistor r=0.003371 c=0
Rk16 (Y \4\:Y) resistor r=0.1832 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.08001 c=0
Rk44 (\3\:VSS \7\:VSS) resistor r=0.06999 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.2856 c=0
Rk46 (\8\:VSS \9\:VSS) resistor r=0.1652 c=0
Rk48 (\10\:VSS VSS) resistor r=0.02963 c=0
Rk47 (\9\:VSS \10\:VSS) resistor r=0.1703 c=0
Rk53 (\8\:VSS \19\:VSS) resistor r=0.1987 c=0
Rk54 (\10\:VSS \21\:VSS) resistor r=0.2033 c=0
Rk7 (net61 \19\:net61) resistor r=0.199 c=0
Rk8 (\19\:net61 \20\:net61) resistor r=0.3493 c=0
Rk12 (\19\:net61 \29\:net61) resistor r=0.4711 c=0
Rk13 (\29\:net61 \31\:net61) resistor r=0.534 c=0
Rl16 (B \11\:B) resistor r=28.0797 c=0
Rl17 (B \12\:B) resistor r=27.2353 c=0
Rl3 (B \1\:B) resistor r=100.478 c=0
Rl5 (B \4\:B) resistor r=90.0661 c=0
Rl20 (A \12\:A) resistor r=43.4636 c=0
Rl11 (A \8\:A) resistor r=58.8489 c=0
Rl10 (A \7\:A) resistor r=28.6412 c=0
Rl1 (A \1\:A) resistor r=36.3335 c=0
Rz11 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz12 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz1 (\29\:net61 \28\:net61) resistor r=75 c=0
Rz2 (\31\:net61 \30\:net61) resistor r=75 c=0
Ry21 (VSS \1\:VSS) resistor r=62 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry18 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry19 (\7\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry20 (\9\:VSS \1\:VSS) resistor r=20.6667 c=0
mn0 (7 \1\:A \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (\30\:net61 \4\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (\30\:net61 \1\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_1__rcx (8 \7\:A \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.925e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (9 \8\:A \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.72e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\28\:net61 \12\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.525e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\28\:net61 \11\:B 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.32e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (10 \12\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.96e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.215e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\4\:Y net61 \3\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.836e-14 ps=9.6e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35806e-06 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp1 (\20\:net61 B VDD VDD) g45p1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=5.215e-14 ad=3.12e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=44.2595 scb=0.0339396 \
        scc=0.00538195 m=(4)
mp2 (\1\:Y net61 VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.408e-14 ad=7.332e-14 ps=1.302e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.83457e-07 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends CLKAND2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:53:38 2012 )
// Library name: gsclib045
// Cell name: CLKAND2X8
// View name: extracted

simulator lang=spectre

subckt CLKAND2X8 A B VDD VSS Y
mp0_1__rcx (\27\:net61 \2\:A \1\:VDD VDD) g45p1svt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=6.552e-14 ad=3.12e-14 ps=1.8125e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=39.3523 \
        scb=0.0403906 scc=0.00438703 m=(4)
C1 (B VSS) capacitor c=4.26362e-17
C2 (Y VSS) capacitor c=1.59607e-17
C3 (VDD VSS) capacitor c=1.36317e-16
C4 (A VSS) capacitor c=5.36371e-17
C5 (net61 VSS) capacitor c=5.11138e-16
C6 (8 VSS) capacitor c=1.75543e-18
C7 (9 VSS) capacitor c=5.27015e-18
C8 (10 VSS) capacitor c=1.75543e-18
C9 (\12\:A VSS) capacitor c=6.36392e-17
C10 (\11\:B VSS) capacitor c=4.42795e-17
C11 (\12\:B VSS) capacitor c=2.50827e-17
C12 (\8\:A VSS) capacitor c=2.83186e-17
C13 (\7\:A VSS) capacitor c=4.63743e-17
C14 (\1\:B VSS) capacitor c=5.74758e-17
C15 (\6\:B VSS) capacitor c=3.33426e-17
C16 (\1\:A VSS) capacitor c=2.82062e-17
C17 (\2\:B VSS) capacitor c=3.97161e-16
C18 (\2\:A VSS) capacitor c=5.32383e-16
C19 (\1\:Y VSS) capacitor c=3.53768e-16
C20 (\27\:net61 VSS) capacitor c=2.08292e-16
C21 (\1\:VDD VSS) capacitor c=3.50775e-16
C22 (\35\:net61 VSS) capacitor c=1.14543e-16
C23 (\37\:net61 VSS) capacitor c=8.65036e-17
C24 (\26\:net61 VSS) capacitor c=7.02906e-17
C25 (\4\:Y VSS) capacitor c=2.26215e-16
Rk1 (B \2\:B) resistor r=0.05403 c=0
Rk16 (\1\:Y Y) resistor r=0.05411 c=0
Rk17 (Y \4\:Y) resistor r=0.1785 c=0
Rk42 (\1\:VDD VDD) resistor r=0.03451 c=0
Rk5 (\2\:A A) resistor r=0.002519 c=0
Rk55 (\1\:VSS \7\:VSS) resistor r=0.36 c=0
Rk57 (\8\:VSS VSS) resistor r=0.06451 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.3346 c=0
Rk62 (\7\:VSS \17\:VSS) resistor r=0.2627 c=0
Rk63 (\8\:VSS \19\:VSS) resistor r=0.2213 c=0
Rk8 (net61 \26\:net61) resistor r=0.2095 c=0
Rk9 (\26\:net61 \27\:net61) resistor r=0.3425 c=0
Rk13 (\26\:net61 \36\:net61) resistor r=0.4242 c=0
Rk14 (\36\:net61 \38\:net61) resistor r=0.5298 c=0
Rl16 (\2\:B \11\:B) resistor r=28.0797 c=0
Rl17 (\2\:B \12\:B) resistor r=27.2353 c=0
Rl3 (\2\:B \1\:B) resistor r=111.254 c=0
Rl7 (\2\:B \6\:B) resistor r=90.0661 c=0
Rl20 (\2\:A \12\:A) resistor r=40.1797 c=0
Rl11 (\2\:A \8\:A) resistor r=55.0028 c=0
Rl10 (\2\:A \7\:A) resistor r=31.9251 c=0
Rl1 (\2\:A \1\:A) resistor r=28.6412 c=0
Rz20 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (\36\:net61 \35\:net61) resistor r=75 c=0
Rz2 (\38\:net61 \37\:net61) resistor r=75 c=0
Ry19 (VSS \3\:VSS) resistor r=62 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry18 (\7\:VSS \3\:VSS) resistor r=8.8571 c=0
mn0 (7 \1\:A \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.9e-14 ps=8e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (\37\:net61 \6\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (\37\:net61 \1\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0_1__rcx (8 \7\:A \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_2__rcx (9 \8\:A \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_2__rcx (\35\:net61 \12\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.955e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_3__rcx (\35\:net61 \11\:B 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=1.75e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (10 \12\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=1.645e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\4\:Y net61 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=4.95e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44847e-06 sb=1.37e-06 sd=160n sca=11.5122 \
        scb=0.0109007 scc=0.000558627 m=(7)
mp1_1__rcx (\27\:net61 \2\:B \1\:VDD VDD) g45p1svt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=6.215e-14 ad=3.12e-14 ps=1.81e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=31.6431 \
        scb=0.0281062 scc=0.00355025 m=(4)
mp2_1__rcx (\1\:Y net61 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.267e-14 ad=6.993e-14 ps=1.30571e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.20843e-07 sb=1.37e-06 sd=160n \
        sca=18.517 scb=0.0155152 scc=0.00162155 m=(7)
ends CLKAND2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:54:15 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX12
// View name: extracted

simulator lang=spectre

subckt CLKBUFX12 A VDD VSS Y
mp1 (Y net44 VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.573e-14 \
        ad=7.52e-14 ps=1.266e-06 pd=1.26e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.99064e-06 sd=160n sca=28.0481 scb=0.031636 \
        scc=0.00223037 m=(10)
C1 (Y VSS) capacitor c=5.24938e-16
C2 (VDD VSS) capacitor c=6.77653e-16
C3 (A VSS) capacitor c=5.12729e-17
C4 (net44 VSS) capacitor c=8.19303e-16
C5 (\1\:A VSS) capacitor c=2.28606e-16
C6 (\31\:net44 VSS) capacitor c=1.39212e-16
C7 (\7\:Y VSS) capacitor c=4.78535e-16
C8 (\10\:A VSS) capacitor c=4.96214e-17
C9 (\34\:net44 VSS) capacitor c=1.13406e-16
Rk5 (Y \7\:Y) resistor r=0.4369 c=0
Rk19 (A \10\:A) resistor r=0.1302 c=0
Rk23 (\34\:net44 net44) resistor r=0.4423 c=0
Rk21 (\31\:net44 \34\:net44) resistor r=0.276 c=0
Rx1 (\10\:A \1\:A) resistor r=45 c=0
mn1 (\7\:Y net44 VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.998e-14 ad=4.96e-14 ps=9.46e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99113e-06 sd=160n sca=9.61806 \
        scb=0.00827687 scc=0.000298696 m=(10)
mn0 (\34\:net44 \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.76e-14 ad=5.373e-14 ps=9.0667e-07 pd=9.3333e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.3e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(3)
mp0 (\31\:net44 \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.157e-14 ad=8.06e-14 ps=1.18667e-06 pd=1.19333e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.3e-07 sd=160n sca=12.7559 scb=0.0106631 \
        scc=0.000333478 m=(3)
ends CLKBUFX12
// End of subcircuit definition.

// Generated for: spectre (May  9 13:54:53 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX16
// View name: extracted

simulator lang=spectre

subckt CLKBUFX16 A VDD VSS Y
mp1_1__rcx (Y net44 VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.033e-14 ad=7.12e-14 ps=1.20714e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (Y VSS) capacitor c=8.74251e-16
C2 (VDD VSS) capacitor c=8.76829e-16
C3 (A VSS) capacitor c=3.24217e-16
C4 (net44 VSS) capacitor c=1.13644e-15
C5 (\43\:net44 VSS) capacitor c=1.7182e-16
C6 (\49\:net44 VSS) capacitor c=8.57213e-17
C7 (\9\:Y VSS) capacitor c=4.77804e-16
C8 (\48\:net44 VSS) capacitor c=2.3432e-17
Rk7 (Y \9\:Y) resistor r=0.2351 c=0
Rk26 (\48\:net44 net44) resistor r=0.1464 c=0
Rk23 (\43\:net44 \48\:net44) resistor r=0.2122 c=0
Rk24 (\48\:net44 \49\:net44) resistor r=0.1301 c=0
mn1_1__rcx (\9\:Y net44 VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.663e-14 ad=4.72e-14 ps=9.0714e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
mn0_1__rcx (\49\:net44 A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.118e-14 ad=4.16e-14 ps=8.475e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mp0_1__rcx (\43\:net44 A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.158e-14 ad=6.24e-14 ps=1.1675e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.55e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
ends CLKBUFX16
// End of subcircuit definition.

// Generated for: spectre (May  9 13:55:31 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX2
// View name: extracted

simulator lang=spectre

subckt CLKBUFX2 A VDD VSS Y
mp1 (\1\:Y net44 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.97949e-07 sd=160n sca=30.8133 \
        scb=0.0297121 scc=0.00267709 m=(2)
C1 (VDD VSS) capacitor c=5.39446e-17
C2 (A VSS) capacitor c=6.7833e-17
C3 (Y VSS) capacitor c=1.13305e-17
C4 (net44 VSS) capacitor c=1.58894e-16
C5 (\1\:A VSS) capacitor c=4.31466e-17
C6 (\3\:A VSS) capacitor c=4.04961e-17
C7 (\2\:A VSS) capacitor c=4.60528e-17
C8 (\7\:net44 VSS) capacitor c=4.73974e-17
C9 (\1\:Y VSS) capacitor c=7.47423e-17
C10 (\1\:VDD VSS) capacitor c=2.54153e-17
C11 (\11\:net44 VSS) capacitor c=1.5361e-17
C12 (\4\:Y VSS) capacitor c=2.18363e-17
C13 (\3\:Y VSS) capacitor c=5.24471e-17
C14 (\4\:A VSS) capacitor c=4.15443e-17
C15 (\9\:net44 VSS) capacitor c=5.17816e-17
C16 (\10\:net44 VSS) capacitor c=5.42501e-17
C17 (\3\:VDD VSS) capacitor c=8.17456e-17
Rk18 (\3\:VSS VSS) resistor r=0.03712 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.1075 c=0
Rk11 (\3\:VDD VDD) resistor r=0.03712 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.1075 c=0
Rk4 (\4\:A A) resistor r=0.1206 c=0
Rk3 (\3\:Y Y) resistor r=0.002419 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.421 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.1064 c=0
Rk5 (\8\:net44 \9\:net44) resistor r=0.3792 c=0
Rk6 (\9\:net44 \10\:net44) resistor r=0.2891 c=0
Rk7 (\9\:net44 \12\:net44) resistor r=0.12 c=0
Rl6 (\1\:A \2\:A) resistor r=91.0764 c=0
Rl7 (\2\:A \3\:A) resistor r=100.692 c=0
Rz5 (VDD \1\:VDD) resistor r=75 c=0
Rz3 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz4 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\12\:net44 \11\:net44) resistor r=75 c=0
Ry7 (VSS \1\:VSS) resistor r=62 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\8\:net44 \7\:net44) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\10\:net44 net44) resistor r=45 c=0
mn1 (\4\:Y net44 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.00192e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mn0 (\11\:net44 \3\:A \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.553e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp0 (\7\:net44 \1\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.267e-14 ps=1.1e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.45e-07 sd=160n sca=19.2351 \
        scb=0.0201659 scc=0.000554323 m=(1)
ends CLKBUFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:56:09 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX20
// View name: extracted

simulator lang=spectre

subckt CLKBUFX20 A VDD VSS Y
mp1_1__rcx (\1\:Y net44 \1\:VDD VDD) g45p1svt w=(4.55e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=6.37e-14 ps=1.24e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=39.6635 scb=0.0369516 \
        scc=0.00411991 m=(1)
C1 (Y VSS) capacitor c=1.32297e-17
C2 (VDD VSS) capacitor c=1.58598e-16
C3 (A VSS) capacitor c=3.98349e-16
C4 (net44 VSS) capacitor c=1.44779e-15
C5 (\52\:net44 VSS) capacitor c=2.28524e-16
C6 (\1\:Y VSS) capacitor c=1.06496e-15
C7 (\1\:VDD VSS) capacitor c=8.93884e-16
C8 (\57\:net44 VSS) capacitor c=1.35211e-16
C9 (\11\:Y VSS) capacitor c=8.12287e-16
C10 (\56\:net44 VSS) capacitor c=2.21677e-17
Rk9 (\1\:Y Y) resistor r=0.1726 c=0
Rk10 (Y \11\:Y) resistor r=0.02804 c=0
Rk70 (\1\:VDD VDD) resistor r=0.1025 c=0
Rk99 (\1\:VSS VSS) resistor r=0.1025 c=0
Rk43 (\56\:net44 net44) resistor r=0.1404 c=0
Rk39 (\52\:net44 \56\:net44) resistor r=0.2212 c=0
Rk40 (\56\:net44 \57\:net44) resistor r=0.1372 c=0
mn1_1__rcx (\11\:Y net44 \1\:VSS VSS) g45n1svt w=(3.05e-07) l=4.5e-08 \
        nf=1 as=4.864e-14 ad=4.844e-14 ps=9.3e-07 pd=9.2765e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 \
        scb=0.0155296 scc=0.00139557 m=(17)
mn0_1__rcx (\57\:net44 A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.25e-14 ad=4.056e-14 ps=8.58e-07 pd=8.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(5)
mp1_2__rcx (\1\:Y net44 \1\:VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.36e-14 ps=1.24e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.42337e-07 sb=2e-06 sd=160n sca=30.979 \
        scb=0.0224787 scc=0.002898 m=(16)
mp0_1__rcx (\52\:net44 A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.38e-14 ad=6.084e-14 ps=1.128e-06 pd=1.092e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=9.6e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(5)
ends CLKBUFX20
// End of subcircuit definition.

// Generated for: spectre (May  9 13:56:46 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX3
// View name: extracted

simulator lang=spectre

subckt CLKBUFX3 A VDD VSS Y
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.98e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=17.5421 \
        scb=0.0176137 scc=0.000504265 m=(3)
C1 (Y VSS) capacitor c=1.80048e-17
C2 (A VSS) capacitor c=8.48872e-17
C3 (VDD VSS) capacitor c=7.06896e-17
C4 (net44 VSS) capacitor c=1.04209e-16
C5 (\1\:A VSS) capacitor c=4.45875e-17
C6 (\3\:A VSS) capacitor c=3.49354e-17
C7 (\2\:A VSS) capacitor c=4.47376e-17
C8 (\3\:net44 VSS) capacitor c=1.04024e-16
C9 (\11\:net44 VSS) capacitor c=8.18918e-17
C10 (\1\:VDD VSS) capacitor c=1.38598e-16
C11 (\1\:Y VSS) capacitor c=1.17689e-16
C12 (\13\:net44 VSS) capacitor c=5.52126e-17
C13 (\4\:Y VSS) capacitor c=1.14189e-16
C14 (\4\:A VSS) capacitor c=3.69968e-17
C15 (\15\:net44 VSS) capacitor c=5.44215e-17
Rk16 (\2\:VSS \3\:VSS) resistor r=0.08997 c=0
Rk20 (\6\:VSS VSS) resistor r=0.04984 c=0
Rk19 (\3\:VSS \6\:VSS) resistor r=0.105 c=0
Rk2 (\1\:Y Y) resistor r=0.003365 c=0
Rk3 (Y \4\:Y) resistor r=0.2851 c=0
Rk9 (\4\:A A) resistor r=0.04486 c=0
Rk14 (\1\:VDD VDD) resistor r=0.1749 c=0
Rk10 (\12\:net44 \14\:net44) resistor r=0.5066 c=0
Rk11 (\14\:net44 \15\:net44) resistor r=0.3154 c=0
Rl10 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl11 (\2\:A \3\:A) resistor r=47.3281 c=0
Rl2 (net44 \3\:net44) resistor r=34.2287 c=0
Rz3 (\14\:net44 \13\:net44) resistor r=75 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry8 (\6\:VSS \1\:VSS) resistor r=31 c=0
Ry3 (\12\:net44 \11\:net44) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\15\:net44 \3\:net44) resistor r=45 c=0
mn1 (\4\:Y \3\:net44 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.377e-14 ad=3.987e-14 ps=8.5667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(3)
mn0 (\13\:net44 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mp0 (\11\:net44 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.655e-14 ps=1.1e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.45e-07 sd=160n sca=22.6205 \
        scb=0.0258254 scc=0.00117627 m=(1)
ends CLKBUFX3
// End of subcircuit definition.

// Generated for: spectre (May  9 13:57:24 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX4
// View name: extracted

simulator lang=spectre

subckt CLKBUFX4 A VDD VSS Y
mp1 (\1\:Y net44 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.337e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=29.498 \
        scb=0.0332632 scc=0.00250913 m=(4)
C1 (VDD VSS) capacitor c=2.74226e-16
C2 (A VSS) capacitor c=5.0618e-17
C3 (Y VSS) capacitor c=2.46544e-17
C4 (net44 VSS) capacitor c=3.60569e-16
C5 (\1\:A VSS) capacitor c=4.27931e-17
C6 (\3\:A VSS) capacitor c=4.5123e-17
C7 (\2\:A VSS) capacitor c=3.90793e-17
C8 (\13\:net44 VSS) capacitor c=6.51516e-17
C9 (\1\:Y VSS) capacitor c=2.00901e-16
C10 (\18\:net44 VSS) capacitor c=3.2775e-17
C11 (\6\:Y VSS) capacitor c=1.79259e-16
C12 (\4\:A VSS) capacitor c=3.52613e-17
C13 (\15\:net44 VSS) capacitor c=5.95507e-17
Rk7 (\4\:A A) resistor r=0.04123 c=0
Rk2 (\1\:Y Y) resistor r=0.09251 c=0
Rk4 (Y \6\:Y) resistor r=0.2245 c=0
Rk9 (\15\:net44 net44) resistor r=0.3253 c=0
Rk8 (\14\:net44 \15\:net44) resistor r=0.3896 c=0
Rk11 (\15\:net44 \19\:net44) resistor r=0.1771 c=0
Rl11 (\1\:A \2\:A) resistor r=55.0021 c=0
Rl12 (\2\:A \3\:A) resistor r=105.002 c=0
Rz3 (\19\:net44 \18\:net44) resistor r=37.5 c=0
Ry3 (\14\:net44 \13\:net44) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn1 (\6\:Y net44 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mn0 (\18\:net44 \3\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp0 (\13\:net44 \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=1.4e-07 sd=160n sca=20.4961 \
        scb=0.0204164 scc=0.00119548 m=(1)
ends CLKBUFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:58:01 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX6
// View name: extracted

simulator lang=spectre

subckt CLKBUFX6 A VDD VSS Y
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2934e-06 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(5)
C1 (Y VSS) capacitor c=1.29608e-17
C2 (VDD VSS) capacitor c=6.0481e-17
C3 (A VSS) capacitor c=3.86327e-17
C4 (net44 VSS) capacitor c=4.28678e-16
C5 (\1\:A VSS) capacitor c=1.36204e-16
C6 (\6\:A VSS) capacitor c=1.1125e-17
C7 (\1\:VDD VSS) capacitor c=3.26437e-16
C8 (\16\:net44 VSS) capacitor c=8.19056e-17
C9 (\1\:Y VSS) capacitor c=2.96953e-16
C10 (\21\:net44 VSS) capacitor c=3.06611e-17
C11 (\5\:Y VSS) capacitor c=2.30781e-16
C12 (\18\:net44 VSS) capacitor c=6.10551e-17
C13 (\9\:A VSS) capacitor c=7.38647e-17
Rk3 (\1\:Y Y) resistor r=0.05801 c=0
Rk4 (Y \5\:Y) resistor r=0.1508 c=0
Rk22 (\1\:VDD VDD) resistor r=0.1024 c=0
Rk17 (A \9\:A) resistor r=0.03004 c=0
Rk30 (\1\:VSS VSS) resistor r=0.1024 c=0
Rk12 (\18\:net44 net44) resistor r=0.5569 c=0
Rk11 (\17\:net44 \18\:net44) resistor r=0.2535 c=0
Rk14 (\18\:net44 \22\:net44) resistor r=0.1818 c=0
Rl18 (\1\:A \6\:A) resistor r=4.8851 c=0
Rz4 (\22\:net44 \21\:net44) resistor r=75 c=0
Ry4 (\17\:net44 \16\:net44) resistor r=20.6667 c=0
Rx3 (\9\:A \6\:A) resistor r=45 c=0
mn1 (\5\:Y net44 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.9e-14 ad=4.836e-14 ps=9.4e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29742e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mn0 (\21\:net44 \1\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.15e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mp0 (\16\:net44 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=32.0467 \
        scb=0.0213026 scc=0.00336306 m=(2)
ends CLKBUFX6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:58:38 2012 )
// Library name: gsclib045
// Cell name: CLKBUFX8
// View name: extracted

simulator lang=spectre

subckt CLKBUFX8 A VDD VSS Y
mp1 (\1\:Y net44 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72438e-06 sd=160n sca=25.5327 \
        scb=0.0229112 scc=0.00209852 m=(7)
C1 (Y VSS) capacitor c=1.07424e-17
C2 (VDD VSS) capacitor c=7.81082e-17
C3 (A VSS) capacitor c=3.3161e-17
C4 (net44 VSS) capacitor c=6.64777e-16
C5 (\1\:A VSS) capacitor c=1.62554e-16
C6 (\1\:VDD VSS) capacitor c=4.06022e-16
C7 (\22\:net44 VSS) capacitor c=6.8447e-17
C8 (\1\:Y VSS) capacitor c=4.09598e-16
C9 (\28\:net44 VSS) capacitor c=6.32958e-17
C10 (\6\:Y VSS) capacitor c=4.34344e-16
C11 (\24\:net44 VSS) capacitor c=4.49846e-17
C12 (\9\:A VSS) capacitor c=3.68058e-17
Rk4 (\1\:Y Y) resistor r=0.09531 c=0
Rk5 (Y \6\:Y) resistor r=0.08628 c=0
Rk28 (\1\:VDD VDD) resistor r=0.1803 c=0
Rk20 (\8\:A \9\:A) resistor r=0.008317 c=0
Rk21 (\10\:A A) resistor r=0.008468 c=0
Rk22 (\9\:A \10\:A) resistor r=0.03387 c=0
Rk38 (\1\:VSS VSS) resistor r=0.1803 c=0
Rk16 (\24\:net44 net44) resistor r=0.183 c=0
Rk15 (\23\:net44 \24\:net44) resistor r=0.2599 c=0
Rk19 (\24\:net44 \29\:net44) resistor r=0.2347 c=0
Rz5 (\29\:net44 \28\:net44) resistor r=37.5 c=0
Ry5 (\23\:net44 \22\:net44) resistor r=20.6667 c=0
Rx4 (\8\:A \1\:A) resistor r=45 c=0
mn1 (\6\:Y net44 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72661e-06 sd=160n sca=14.382 \
        scb=0.0140935 scc=0.0010585 m=(7)
mn0 (\28\:net44 \1\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.075e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mp0 (\22\:net44 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=3.45e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(2)
ends CLKBUFX8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:59:15 2012 )
// Library name: gsclib045
// Cell name: CLKINVX1
// View name: extracted

simulator lang=spectre

subckt CLKINVX1 A VDD VSS Y
mp0 (\1\:Y \1\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.86e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24615e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=4.99334e-17
C2 (VDD VSS) capacitor c=2.30994e-17
C3 (\1\:A VSS) capacitor c=2.5566e-17
C4 (\4\:A VSS) capacitor c=2.0528e-17
C5 (\3\:A VSS) capacitor c=1.55142e-17
C6 (\1\:Y VSS) capacitor c=4.03422e-17
C7 (\3\:VDD VSS) capacitor c=4.73358e-17
C8 (\2\:A VSS) capacitor c=9.60186e-18
C9 (\5\:A VSS) capacitor c=3.69476e-17
C10 (\7\:A VSS) capacitor c=3.8843e-17
Rk9 (VSS \4\:VSS) resistor r=0.3102 c=0
Rk1 (\5\:A \6\:A) resistor r=0.004811 c=0
Rk2 (A \7\:A) resistor r=0.004651 c=0
Rk3 (\5\:A \7\:A) resistor r=0.04303 c=0
Rk4 (\2\:Y Y) resistor r=0.2477 c=0
Rk5 (Y \4\:Y) resistor r=0.06047 c=0
Rk7 (VDD \4\:VDD) resistor r=0.3843 c=0
Rl1 (\1\:A \2\:A) resistor r=61.2526 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=4.3144 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\3\:VDD \4\:VDD) resistor r=20.6667 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
mn0 (\3\:Y \4\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.08e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.18462e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
ends CLKINVX1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:59:53 2012 )
// Library name: gsclib045
// Cell name: CLKINVX12
// View name: extracted

simulator lang=spectre

subckt CLKINVX12 A VDD VSS Y
mp0 (Y A VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=8.554e-14 \
        ad=7.661e-14 ps=1.304e-06 pd=1.266e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(10)
C1 (A VSS) capacitor c=7.80084e-16
C2 (VDD VSS) capacitor c=4.28656e-16
C3 (Y VSS) capacitor c=4.76359e-16
C4 (\9\:Y VSS) capacitor c=4.81026e-16
Rk12 (Y \9\:Y) resistor r=0.4398 c=0
mn0 (\9\:Y A VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=5.859e-14 ps=9.32e-07 pd=9.98e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=8.7305 scb=0.00693421 \
        scc=0.00019605 m=(10)
ends CLKINVX12
// End of subcircuit definition.

// Generated for: spectre (May  9 14:00:32 2012 )
// Library name: gsclib045
// Cell name: CLKINVX16
// View name: extracted

simulator lang=spectre

subckt CLKINVX16 A VDD VSS Y
mp0 (Y \1\:A \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=33.496 scb=0.0262642 \
        scc=0.00310781 m=(14)
C1 (A VSS) capacitor c=2.15234e-17
C2 (VDD VSS) capacitor c=8.5437e-17
C3 (Y VSS) capacitor c=6.74311e-16
C4 (\1\:A VSS) capacitor c=9.22338e-16
C5 (\1\:VDD VSS) capacitor c=4.59867e-16
C6 (\17\:Y VSS) capacitor c=4.06403e-16
Rk59 (\1\:VSS VSS) resistor r=0.06467 c=0
Rk8 (\1\:A A) resistor r=0.01234 c=0
Rk40 (\1\:VDD VDD) resistor r=0.06468 c=0
Rk19 (Y \17\:Y) resistor r=0.2528 c=0
mn0 (\17\:Y \1\:A \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
ends CLKINVX16
// End of subcircuit definition.

// Generated for: spectre (May  9 14:01:10 2012 )
// Library name: gsclib045
// Cell name: CLKINVX2
// View name: extracted

simulator lang=spectre

subckt CLKINVX2 A VDD VSS Y
mp0 (\3\:Y \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.0826 \
        scb=0.0294587 scc=0.00345874 m=(2)
C1 (A VSS) capacitor c=2.50497e-17
C2 (VDD VSS) capacitor c=2.13062e-17
C3 (Y VSS) capacitor c=2.6263e-17
C4 (\1\:A VSS) capacitor c=9.90968e-17
C5 (\4\:A VSS) capacitor c=1.17735e-17
C6 (\1\:VDD VSS) capacitor c=1.2367e-16
C7 (\3\:Y VSS) capacitor c=9.62526e-17
C8 (\1\:Y VSS) capacitor c=1.63563e-17
C9 (\8\:A VSS) capacitor c=6.608e-17
Rk10 (\1\:VSS VSS) resistor r=0.09222 c=0
Rk1 (A \8\:A) resistor r=0.1424 c=0
Rk6 (\1\:VDD VDD) resistor r=0.09222 c=0
Rk2 (Y \2\:Y) resistor r=0.05085 c=0
Rk3 (Y \4\:Y) resistor r=0.2572 c=0
Rl3 (\1\:A \4\:A) resistor r=4.8851 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Ry1 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Rx1 (\8\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \1\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
ends CLKINVX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:01:48 2012 )
// Library name: gsclib045
// Cell name: CLKINVX20
// View name: extracted

simulator lang=spectre

subckt CLKINVX20 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.301e-14 ad=7.36e-14 ps=1.2375e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.0128 scb=0.0371513 \
        scc=0.00426262 m=(16)
C1 (A VSS) capacitor c=1.6561e-17
C2 (VDD VSS) capacitor c=6.44327e-16
C3 (Y VSS) capacitor c=1.06114e-17
C4 (\1\:A VSS) capacitor c=1.26807e-15
C5 (\1\:Y VSS) capacitor c=8.26369e-16
C6 (\12\:Y VSS) capacitor c=7.91569e-16
Rk9 (\1\:A A) resistor r=0.01718 c=0
Rk18 (\1\:Y Y) resistor r=0.03951 c=0
Rk19 (\1\:Y \12\:Y) resistor r=0.1937 c=0
mn0 (\12\:Y \1\:A VSS VSS) g45n1svt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.844e-14 ps=9.2765e-07 pd=9.2765e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
mp0_16__rcx (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.55e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=1.0238e-13 ps=1.24e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=32.0859 scb=0.0265913 \
        scc=0.00291711 m=(1)
ends CLKINVX20
// End of subcircuit definition.

// Generated for: spectre (May  9 14:02:25 2012 )
// Library name: gsclib045
// Cell name: CLKINVX3
// View name: extracted

simulator lang=spectre

subckt CLKINVX3 A VDD VSS Y
mp0 (\1\:Y \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=5.98e-14 ps=1.08667e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=36.7233 \
        scb=0.0278991 scc=0.00349312 m=(3)
C1 (A VSS) capacitor c=2.33239e-17
C2 (VDD VSS) capacitor c=4.0555e-17
C3 (Y VSS) capacitor c=1.24607e-17
C4 (\1\:A VSS) capacitor c=1.39706e-16
C5 (\6\:A VSS) capacitor c=1.12992e-17
C6 (\1\:Y VSS) capacitor c=1.20434e-16
C7 (\1\:VDD VSS) capacitor c=1.12198e-16
C8 (\3\:VDD VSS) capacitor c=1.66238e-17
C9 (\4\:Y VSS) capacitor c=6.70811e-17
C10 (\12\:A VSS) capacitor c=8.08026e-17
Rk14 (\1\:VSS VSS) resistor r=0.06971 c=0
Rk1 (A \12\:A) resistor r=0.05007 c=0
Rk10 (\1\:VDD VDD) resistor r=0.06971 c=0
Rk3 (\1\:Y Y) resistor r=0.02731 c=0
Rk4 (Y \4\:Y) resistor r=0.1524 c=0
Rl5 (\1\:A \6\:A) resistor r=4.3693 c=0
Rz4 (VDD \3\:VDD) resistor r=75 c=0
Rz3 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Ry6 (VSS \3\:VSS) resistor r=62 c=0
Ry5 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Rx1 (\12\:A \6\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=3.987e-14 ps=8.2667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
ends CLKINVX3
// End of subcircuit definition.

// Generated for: spectre (May  9 14:03:03 2012 )
// Library name: gsclib045
// Cell name: CLKINVX4
// View name: extracted

simulator lang=spectre

subckt CLKINVX4 A VDD VSS Y
mp0 (Y A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.054e-14 \
        ad=6.24e-14 ps=1.245e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.15e-07 sd=160n sca=33.7975 scb=0.0358754 \
        scc=0.00324911 m=(4)
C1 (Y VSS) capacitor c=1.98811e-16
C2 (A VSS) capacitor c=3.3079e-16
C3 (VDD VSS) capacitor c=1.84538e-16
C4 (\4\:Y VSS) capacitor c=1.92574e-16
Rk4 (Y \4\:Y) resistor r=0.2069 c=0
mn0 (\4\:Y A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.306e-14 \
        ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.15e-07 sd=160n sca=16.9678 scb=0.0167861 \
        scc=0.00150639 m=(4)
ends CLKINVX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:03:41 2012 )
// Library name: gsclib045
// Cell name: CLKINVX6
// View name: extracted

simulator lang=spectre

subckt CLKINVX6 A VDD VSS Y
mp0 (\1\:Y A VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.52e-14 \
        ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.7e-07 sd=160n sca=40.6416 scb=0.0369115 \
        scc=0.00420297 m=(5)
C1 (A VSS) capacitor c=3.56226e-16
C2 (VDD VSS) capacitor c=2.16243e-16
C3 (Y VSS) capacitor c=1.66063e-17
C4 (\1\:Y VSS) capacitor c=2.02364e-16
C5 (\6\:Y VSS) capacitor c=2.05249e-16
Rk5 (\1\:Y Y) resistor r=0.02733 c=0
Rk6 (Y \6\:Y) resistor r=0.2233 c=0
mn0 (\6\:Y A VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.836e-14 \
        ad=4.96e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.7e-07 sd=160n sca=9.23999 scb=0.00771541 \
        scc=0.000252587 m=(5)
ends CLKINVX6
// End of subcircuit definition.

// Generated for: spectre (May  9 14:04:18 2012 )
// Library name: gsclib045
// Cell name: CLKINVX8
// View name: extracted

simulator lang=spectre

subckt CLKINVX8 A VDD VSS Y
mp0 (\1\:Y \1\:A \3\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.993e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=37.2769 \
        scb=0.0322553 scc=0.00356814 m=(7)
C1 (A VSS) capacitor c=2.08574e-17
C2 (VDD VSS) capacitor c=4.76812e-17
C3 (Y VSS) capacitor c=1.43971e-17
C4 (\1\:A VSS) capacitor c=3.86617e-16
C5 (\1\:Y VSS) capacitor c=2.7873e-16
C6 (\1\:VDD VSS) capacitor c=4.88946e-17
C7 (\4\:Y VSS) capacitor c=1.65567e-16
C8 (\3\:VDD VSS) capacitor c=1.69346e-16
Rk36 (\3\:VSS VSS) resistor r=0.02458 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.1099 c=0
Rk3 (\1\:A A) resistor r=0.02659 c=0
Rk24 (\3\:VDD VDD) resistor r=0.02458 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.1099 c=0
Rk5 (\1\:Y Y) resistor r=0.1992 c=0
Rk6 (Y \4\:Y) resistor r=0.01233 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=10.7143 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=8.8571 c=0
mn0 (\4\:Y \1\:A \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.636e-14 ps=9.0429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
ends CLKINVX8
// End of subcircuit definition.

// Generated for: spectre (May  9 14:04:55 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X12
// View name: extracted

simulator lang=spectre

subckt CLKMX2X12 A B S0 VDD VSS Y
mp0 (\9\:S0b \1\:S0 \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.61026e-06 sd=160n sca=16.3241 \
        scb=0.0161972 scc=0.000342398 m=(1)
C1 (S0 VSS) capacitor c=6.4121e-17
C2 (Y VSS) capacitor c=9.48548e-16
C3 (VDD VSS) capacitor c=2.26513e-16
C4 (B VSS) capacitor c=3.90266e-17
C5 (S0b VSS) capacitor c=5.06139e-17
C6 (n0 VSS) capacitor c=5.80351e-16
C7 (net140 VSS) capacitor c=8.56299e-18
C8 (net123 VSS) capacitor c=3.58658e-18
C9 (net115 VSS) capacitor c=4.99478e-18
C10 (\1\:B VSS) capacitor c=3.74245e-17
C11 (\3\:S0b VSS) capacitor c=3.46243e-17
C12 (\6\:S0 VSS) capacitor c=4.38578e-17
C13 (\1\:A VSS) capacitor c=6.94848e-17
C14 (\1\:S0 VSS) capacitor c=4.89705e-17
C15 (\3\:B VSS) capacitor c=5.53557e-17
C16 (\4\:S0 VSS) capacitor c=6.15764e-17
C17 (\2\:S0b VSS) capacitor c=6.69981e-17
C18 (\3\:A VSS) capacitor c=9.43733e-17
C19 (\3\:S0 VSS) capacitor c=5.4997e-17
C20 (\2\:B VSS) capacitor c=4.04663e-17
C21 (\4\:S0b VSS) capacitor c=3.52371e-17
C22 (\5\:S0 VSS) capacitor c=7.35485e-17
C23 (\2\:A VSS) capacitor c=5.48266e-17
C24 (\2\:S0 VSS) capacitor c=4.30501e-17
C25 (\44\:n0 VSS) capacitor c=9.86554e-17
C26 (\24\:VDD VSS) capacitor c=3.77853e-17
C27 (\9\:S0b VSS) capacitor c=9.79992e-17
C28 (\1\:VDD VSS) capacitor c=3.71012e-17
C29 (\42\:n0 VSS) capacitor c=5.69983e-17
C30 (\7\:S0b VSS) capacitor c=8.87701e-17
C31 (\4\:A VSS) capacitor c=4.1913e-17
C32 (\5\:A VSS) capacitor c=5.20883e-17
C33 (\7\:S0 VSS) capacitor c=3.38027e-17
C34 (\8\:S0 VSS) capacitor c=8.3699e-17
C35 (\5\:S0b VSS) capacitor c=7.98713e-17
C36 (\6\:S0b VSS) capacitor c=9.00219e-17
C37 (\4\:B VSS) capacitor c=6.15779e-17
C38 (\40\:n0 VSS) capacitor c=5.62436e-17
C39 (\41\:n0 VSS) capacitor c=1.18687e-16
C40 (\3\:VDD VSS) capacitor c=5.18297e-16
C41 (\11\:VDD VSS) capacitor c=2.83963e-17
Rk4 (S0 \7\:S0) resistor r=0.03903 c=0
Rk5 (S0 \8\:S0) resistor r=0.4084 c=0
Rk1 (A \4\:A) resistor r=0.002332 c=0
Rk3 (\4\:A \5\:A) resistor r=0.03791 c=0
Rk2 (\5\:A \6\:A) resistor r=0.002413 c=0
Rk31 (\2\:VDD \3\:VDD) resistor r=0.0951 c=0
Rk38 (\3\:VDD \10\:VDD) resistor r=0.1302 c=0
Rk40 (\11\:VDD VDD) resistor r=0.1776 c=0
Rk39 (\10\:VDD \11\:VDD) resistor r=0.3735 c=0
Rk47 (\11\:VDD \25\:VDD) resistor r=0.1786 c=0
Rk54 (\1\:VSS \10\:VSS) resistor r=0.2155 c=0
Rk56 (\11\:VSS VSS) resistor r=0.1776 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.223 c=0
Rk62 (\11\:VSS \23\:VSS) resistor r=0.2209 c=0
Rk9 (\4\:B B) resistor r=0.01175 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.4236 c=0
Rk7 (\6\:S0b \8\:S0b) resistor r=0.3474 c=0
Rk8 (\8\:S0b \10\:S0b) resistor r=0.735 c=0
Rk10 (\40\:n0 \41\:n0) resistor r=0.3134 c=0
Rk11 (\41\:n0 \43\:n0) resistor r=0.4108 c=0
Rk12 (\41\:n0 \45\:n0) resistor r=0.5789 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=28.2967 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=218.796 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=26.098 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=145.329 c=0
Rl3 (\1\:A \2\:A) resistor r=81.461 c=0
Rl4 (\2\:A \3\:A) resistor r=148.769 c=0
Rl9 (\1\:B \2\:B) resistor r=33.3841 c=0
Rl10 (\2\:B \3\:B) resistor r=196.846 c=0
Rl5 (S0b \2\:S0b) resistor r=42.6366 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=30.0021 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=12.5 c=0
Rz10 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz17 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz1 (\7\:S0b \8\:S0b) resistor r=75 c=0
Rz2 (\43\:n0 \42\:n0) resistor r=75 c=0
Ry14 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=6.2 c=0
Ry17 (\10\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry1 (\9\:S0b \10\:S0b) resistor r=62 c=0
Ry2 (\45\:n0 \44\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \6\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\40\:n0 n0) resistor r=45 c=0
mn0 (\7\:S0b \3\:S0 \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59808e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (net148 \3\:A \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=1.23e-14 ps=8.4e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn2 (\42\:n0 \2\:S0b net148 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn4 (\42\:n0 \4\:S0 net140 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=3.28e-14 ps=1.04e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2e-06 sd=160n sca=8.84876 scb=0.0071018 \
        scc=0.000159248 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.048e-14 ad=6.458e-14 ps=1.01e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=2e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn5_1__rcx (Y n0 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.217e-14 ad=4.96e-14 ps=9.63e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6379e-07 sb=2e-06 sd=160n sca=11.8347 \
        scb=0.0112322 scc=0.000626052 m=(10)
mp1 (net123 \1\:A \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=3.255e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=12.241 scb=0.00942952 \
        scc=0.00011999 m=(1)
mp2 (\44\:n0 \6\:S0 net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.255e-14 ad=6.82e-14 ps=8.3e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=11.314 scb=0.00849585 \
        scc=0.00011741 m=(1)
mp4 (\44\:n0 \3\:S0b net115 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=6.82e-14 ps=1.04e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp3 (net115 \1\:B \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.059e-13 ad=6.51e-14 ps=1.52e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=2e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5_1__rcx (Y n0 \3\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.733e-14 ad=7.52e-14 ps=1.282e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.24468e-07 sb=1.985e-06 sd=160n sca=13.3727 \
        scb=0.0119208 scc=0.000609828 m=(10)
ends CLKMX2X12
// End of subcircuit definition.

// Generated for: spectre (May  9 14:05:32 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X2
// View name: extracted

simulator lang=spectre

subckt CLKMX2X2 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=15.5214 \
        scb=0.0147757 scc=0.000215748 m=(1)
C1 (S0 VSS) capacitor c=2.91092e-17
C2 (A VSS) capacitor c=5.58985e-17
C3 (Y VSS) capacitor c=2.80361e-17
C4 (VDD VSS) capacitor c=1.74236e-16
C5 (S0b VSS) capacitor c=6.69807e-17
C6 (n0 VSS) capacitor c=1.64943e-16
C7 (net140 VSS) capacitor c=5.81197e-18
C8 (net115 VSS) capacitor c=1.60173e-18
C9 (\4\:B VSS) capacitor c=6.8063e-17
C10 (\3\:S0b VSS) capacitor c=4.75274e-17
C11 (\6\:S0 VSS) capacitor c=3.98795e-17
C12 (\1\:A VSS) capacitor c=4.08451e-17
C13 (\1\:S0 VSS) capacitor c=3.14955e-17
C14 (\3\:B VSS) capacitor c=5.48489e-17
C15 (\4\:S0 VSS) capacitor c=5.95684e-17
C16 (\3\:A VSS) capacitor c=9.12679e-17
C17 (\3\:S0 VSS) capacitor c=5.51852e-17
C18 (\4\:n0 VSS) capacitor c=4.27849e-17
C19 (\1\:B VSS) capacitor c=2.36277e-17
C20 (\4\:S0b VSS) capacitor c=4.56261e-17
C21 (\5\:S0 VSS) capacitor c=8.05547e-17
C22 (\2\:S0b VSS) capacitor c=5.5911e-17
C23 (\2\:A VSS) capacitor c=7.17473e-17
C24 (\2\:S0 VSS) capacitor c=5.50919e-17
C25 (\1\:VDD VSS) capacitor c=1.07652e-16
C26 (\4\:Y VSS) capacitor c=1.01119e-16
C27 (\12\:n0 VSS) capacitor c=9.40393e-17
C28 (\10\:VDD VSS) capacitor c=3.89249e-17
C29 (\10\:S0b VSS) capacitor c=9.36025e-17
C30 (\4\:VDD VSS) capacitor c=2.54193e-17
C31 (\2\:Y VSS) capacitor c=3.02148e-17
C32 (\10\:n0 VSS) capacitor c=5.55217e-17
C33 (\8\:S0b VSS) capacitor c=2.07595e-17
C34 (\2\:B VSS) capacitor c=5.0803e-17
C35 (\4\:A VSS) capacitor c=6.08979e-17
C36 (\7\:S0 VSS) capacitor c=8.21499e-17
C37 (\8\:S0 VSS) capacitor c=7.29225e-17
C38 (\5\:S0b VSS) capacitor c=7.65749e-17
C39 (\6\:S0b VSS) capacitor c=1.2174e-16
C40 (\7\:S0b VSS) capacitor c=8.11883e-17
C41 (\5\:B VSS) capacitor c=1.23536e-16
C42 (\8\:n0 VSS) capacitor c=3.63116e-17
C43 (\9\:n0 VSS) capacitor c=1.11003e-16
C44 (\1\:Y VSS) capacitor c=5.12165e-17
C45 (\6\:VDD VSS) capacitor c=1.4654e-17
Rk3 (\8\:S0 S0) resistor r=0.02104 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.417 c=0
Rk1 (A \4\:A) resistor r=0.07467 c=0
Rk12 (Y \1\:Y) resistor r=0.111 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.1478 c=0
Rk14 (\1\:Y \5\:Y) resistor r=0.502 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.09513 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.3309 c=0
Rk19 (\7\:VDD VDD) resistor r=0.04992 c=0
Rk18 (\6\:VDD \7\:VDD) resistor r=0.1202 c=0
Rk21 (\6\:VDD \11\:VDD) resistor r=0.2093 c=0
Rk23 (\1\:VSS \5\:VSS) resistor r=0.09513 c=0
Rk24 (\5\:VSS \6\:VSS) resistor r=0.3309 c=0
Rk26 (\7\:VSS VSS) resistor r=0.04992 c=0
Rk25 (\6\:VSS \7\:VSS) resistor r=0.1202 c=0
Rk28 (\6\:VSS \11\:VSS) resistor r=0.194 c=0
Rk8 (B \5\:B) resistor r=0.006762 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4511 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3941 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09765 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7268 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.1576 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.4052 c=0
Rk11 (\9\:n0 \13\:n0) resistor r=0.5968 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=236.093 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=41.0764 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=248.769 c=0
Rl3 (\1\:A \2\:A) resistor r=76.1559 c=0
Rl4 (\2\:A \3\:A) resistor r=210.771 c=0
Rl11 (\2\:B \4\:B) resistor r=128.56 c=0
Rl10 (\2\:B \3\:B) resistor r=178.56 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=62.9746 c=0
Rl5 (S0b \2\:S0b) resistor r=83.8482 c=0
Rl14 (n0 \4\:n0) resistor r=4.1351 c=0
Rz3 (\3\:Y \2\:Y) resistor r=75 c=0
Rz4 (\5\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz5 (\7\:VDD \4\:VDD) resistor r=37.5 c=0
Rz8 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\5\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry8 (\7\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\8\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn1 (net148 \3\:A \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn2 (\10\:n0 S0b net148 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.075e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn4 (\10\:n0 \4\:S0 net140 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.7e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn5 (\2\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.10673e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp1 (net123 \1\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.977e-14 ps=7.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=11.7983 \
        scb=0.00857189 scc=7.47494e-05 m=(1)
mp2 (\12\:n0 \6\:S0 net123 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=9.5e-07 sd=160n sca=10.5655 \
        scb=0.0074576 scc=7.20375e-05 m=(1)
mp4 (\12\:n0 \3\:S0b net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.73e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.85e-07 sd=160n sca=10.707 \
        scb=0.00753257 scc=7.20801e-05 m=(1)
mp3 (net115 \4\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.935e-14 ps=1.1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=11.3858 \
        scb=0.0080918 scc=7.29969e-05 m=(1)
mp5 (\4\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.03654e-07 sb=3.45e-07 sd=160n sca=15.9948 \
        scb=0.0151656 scc=0.000454155 m=(2)
ends CLKMX2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:06:10 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X3
// View name: extracted

simulator lang=spectre

subckt CLKMX2X3 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=4.837e-14 ps=1.64e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.9e-06 sd=160n sca=26.5704 \
        scb=0.0277882 scc=0.00223218 m=(1)
C1 (A VSS) capacitor c=1.27489e-16
C2 (Y VSS) capacitor c=2.07348e-17
C3 (VDD VSS) capacitor c=1.23335e-16
C4 (S0b VSS) capacitor c=6.98721e-17
C5 (n0 VSS) capacitor c=2.20704e-16
C6 (net140 VSS) capacitor c=9.82845e-18
C7 (net123 VSS) capacitor c=4.69865e-18
C8 (net115 VSS) capacitor c=4.37059e-18
C9 (\4\:B VSS) capacitor c=4.55872e-17
C10 (\3\:S0b VSS) capacitor c=4.85253e-17
C11 (\7\:S0 VSS) capacitor c=4.57934e-17
C12 (\1\:A VSS) capacitor c=5.68939e-17
C13 (\1\:S0 VSS) capacitor c=2.37162e-17
C14 (\3\:B VSS) capacitor c=4.58377e-17
C15 (\4\:S0 VSS) capacitor c=5.83172e-17
C16 (\3\:A VSS) capacitor c=7.15871e-17
C17 (\3\:S0 VSS) capacitor c=3.08726e-17
C18 (\1\:B VSS) capacitor c=2.45845e-17
C19 (\4\:S0b VSS) capacitor c=3.65572e-17
C20 (\6\:S0 VSS) capacitor c=5.54029e-17
C21 (\2\:S0b VSS) capacitor c=4.38427e-17
C22 (\2\:A VSS) capacitor c=5.02048e-17
C23 (\2\:S0 VSS) capacitor c=2.75818e-17
C24 (\1\:Y VSS) capacitor c=1.52687e-16
C25 (\14\:n0 VSS) capacitor c=9.88787e-17
C26 (\12\:VDD VSS) capacitor c=5.00782e-17
C27 (\8\:S0b VSS) capacitor c=5.57772e-17
C28 (\1\:VDD VSS) capacitor c=3.09182e-17
C29 (\12\:n0 VSS) capacitor c=5.76324e-17
C30 (\10\:S0b VSS) capacitor c=1.84044e-17
C31 (\2\:B VSS) capacitor c=2.71482e-17
C32 (\8\:S0 VSS) capacitor c=1.33028e-16
C33 (\9\:S0 VSS) capacitor c=1.14012e-16
C34 (\5\:S0b VSS) capacitor c=7.44003e-17
C35 (\6\:S0b VSS) capacitor c=9.40719e-17
C36 (\7\:S0b VSS) capacitor c=8.36562e-17
C37 (\5\:B VSS) capacitor c=1.22515e-16
C38 (\10\:n0 VSS) capacitor c=4.89457e-17
C39 (\11\:n0 VSS) capacitor c=9.68411e-17
C40 (\4\:Y VSS) capacitor c=7.25031e-17
C41 (\3\:VDD VSS) capacitor c=1.48202e-16
C42 (\6\:VDD VSS) capacitor c=8.56197e-18
Rk2 (\8\:S0 S0) resistor r=0.8194 c=0
Rk3 (S0 \9\:S0) resistor r=0.002989 c=0
Rk13 (\1\:Y Y) resistor r=0.01846 c=0
Rk14 (Y \4\:Y) resistor r=0.2044 c=0
Rk18 (\2\:VDD \3\:VDD) resistor r=0.1024 c=0
Rk20 (\3\:VDD \5\:VDD) resistor r=0.2525 c=0
Rk22 (\6\:VDD VDD) resistor r=0.2898 c=0
Rk21 (\5\:VDD \6\:VDD) resistor r=0.16 c=0
Rk26 (\6\:VDD \13\:VDD) resistor r=0.2439 c=0
Rk27 (\2\:VSS \3\:VSS) resistor r=0.1024 c=0
Rk29 (\3\:VSS \5\:VSS) resistor r=0.1525 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.4077 c=0
Rk32 (\7\:VSS VSS) resistor r=0.0498 c=0
Rk31 (\6\:VSS \7\:VSS) resistor r=0.09239 c=0
Rk35 (\6\:VSS \13\:VSS) resistor r=0.294 c=0
Rk8 (B \5\:B) resistor r=0.004698 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.34 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5036 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.3484 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.0962 c=0
Rk9 (\10\:n0 \11\:n0) resistor r=0.2249 c=0
Rk10 (\11\:n0 \13\:n0) resistor r=0.3794 c=0
Rk11 (\11\:n0 \15\:n0) resistor r=0.5369 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=36.5385 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=101.099 c=0
Rl8 (\5\:S0 \7\:S0) resistor r=69.3988 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=143.857 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=1.2666 c=0
Rl3 (\1\:A \2\:A) resistor r=65.3618 c=0
Rl4 (\2\:A \3\:A) resistor r=82.4874 c=0
Rl12 (\2\:B \4\:B) resistor r=34.3295 c=0
Rl11 (\2\:B \3\:B) resistor r=117.022 c=0
Rl10 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl9 (\3\:S0b \4\:S0b) resistor r=51.3412 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz6 (\5\:VDD \1\:VDD) resistor r=7.5 c=0
Rz9 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\13\:n0 \12\:n0) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry10 (\5\:VSS \1\:VSS) resistor r=7.75 c=0
Ry11 (\7\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx2 (\6\:S0 \8\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \9\:S0) resistor r=45 c=0
Rx1 (\2\:A A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\10\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \3\:S0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=2.03e-14 ps=1.32e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.955e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (net148 \3\:A \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=1.56e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.70481e-07 sb=1.51e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (\12\:n0 S0b net148 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75481e-07 sb=1.405e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\12\:n0 \4\:S0 net140 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.32e-14 ad=4.16e-14 ps=1.16e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.80481e-07 sb=1.2e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (net140 \3\:B \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=8.32e-14 ps=8.4e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04548e-06 sb=8.35e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn5 (\4\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.373e-14 ps=8.4e-07 pd=9.3333e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25048e-06 sb=6.3e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(3)
mp1 (net123 \1\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=5.265e-14 ps=1.64e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.48718e-07 sb=1.425e-06 sd=160n sca=16.6245 \
        scb=0.014685 scc=0.00118863 m=(1)
mp2 (\14\:n0 \7\:S0 net123 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=6.24e-14 ps=1.05e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.28718e-07 sb=1.245e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp4 (\14\:n0 \3\:S0b net115 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.33718e-07 sb=1.04e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3 (net115 \4\:B \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03872e-06 sb=8.35e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp5 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.06e-14 ps=1.1e-06 pd=1.19333e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24372e-06 sb=6.3e-07 sd=160n sca=16.6869 \
        scb=0.0147126 scc=0.00118865 m=(3)
ends CLKMX2X3
// End of subcircuit definition.

// Generated for: spectre (May  9 14:06:47 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X4
// View name: extracted

simulator lang=spectre

subckt CLKMX2X4 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=3.01e-14 ps=9.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
C1 (S0 VSS) capacitor c=1.14008e-16
C2 (A VSS) capacitor c=1.17291e-16
C3 (Y VSS) capacitor c=4.08591e-17
C4 (VDD VSS) capacitor c=1.94876e-16
C5 (B VSS) capacitor c=6.43648e-17
C6 (S0b VSS) capacitor c=4.6429e-17
C7 (n0 VSS) capacitor c=3.13989e-16
C8 (net140 VSS) capacitor c=2.39347e-18
C9 (net123 VSS) capacitor c=3.92428e-18
C10 (net115 VSS) capacitor c=3.57588e-18
C11 (\3\:B VSS) capacitor c=5.13054e-17
C12 (\3\:S0b VSS) capacitor c=4.36168e-17
C13 (\6\:S0 VSS) capacitor c=5.07646e-17
C14 (\3\:A VSS) capacitor c=7.20322e-17
C15 (\1\:S0 VSS) capacitor c=4.20603e-17
C16 (\1\:B VSS) capacitor c=7.18775e-17
C17 (\4\:S0 VSS) capacitor c=8.97371e-17
C18 (\2\:S0b VSS) capacitor c=4.30819e-17
C19 (\1\:A VSS) capacitor c=5.75146e-17
C20 (\3\:S0 VSS) capacitor c=5.51187e-17
C21 (\4\:B VSS) capacitor c=2.80304e-17
C22 (\4\:S0b VSS) capacitor c=4.73041e-17
C23 (\5\:S0 VSS) capacitor c=9.00725e-17
C24 (\2\:A VSS) capacitor c=6.02101e-17
C25 (\2\:S0 VSS) capacitor c=5.59727e-17
C26 (\1\:Y VSS) capacitor c=1.56112e-16
C27 (\16\:n0 VSS) capacitor c=8.95888e-17
C28 (\15\:VDD VSS) capacitor c=3.94521e-17
C29 (\10\:S0b VSS) capacitor c=1.03792e-16
C30 (\1\:VDD VSS) capacitor c=3.80134e-17
C31 (\18\:n0 VSS) capacitor c=6.0584e-17
C32 (\8\:S0b VSS) capacitor c=1.32496e-17
C33 (\2\:B VSS) capacitor c=4.69763e-17
C34 (\8\:S0 VSS) capacitor c=9.5e-17
C35 (\5\:S0b VSS) capacitor c=6.51327e-17
C36 (\6\:S0b VSS) capacitor c=9.57712e-17
C37 (\7\:S0b VSS) capacitor c=9.92121e-17
C38 (\5\:B VSS) capacitor c=5.32193e-17
C39 (\14\:n0 VSS) capacitor c=5.26735e-17
C40 (\15\:n0 VSS) capacitor c=1.09505e-16
C41 (\4\:Y VSS) capacitor c=8.53662e-17
C42 (\3\:VDD VSS) capacitor c=1.79739e-16
C43 (\8\:VDD VSS) capacitor c=1.78872e-17
Rk2 (\7\:S0 S0) resistor r=0.002995 c=0
Rk3 (S0 \8\:S0) resistor r=0.6145 c=0
Rk1 (\4\:A A) resistor r=0.002995 c=0
Rk13 (\1\:Y Y) resistor r=0.001906 c=0
Rk14 (Y \4\:Y) resistor r=0.3586 c=0
Rk18 (\2\:VDD \3\:VDD) resistor r=0.06496 c=0
Rk22 (\3\:VDD \7\:VDD) resistor r=0.1853 c=0
Rk24 (\8\:VDD VDD) resistor r=0.1765 c=0
Rk23 (\7\:VDD \8\:VDD) resistor r=0.2219 c=0
Rk28 (\8\:VDD \16\:VDD) resistor r=0.1185 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.06496 c=0
Rk34 (\3\:VSS \8\:VSS) resistor r=0.3206 c=0
Rk36 (\9\:VSS VSS) resistor r=0.185 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.06496 c=0
Rk40 (\9\:VSS \17\:VSS) resistor r=0.1864 c=0
Rk8 (\5\:B B) resistor r=0.06791 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.3117 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4883 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.05422 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7841 c=0
Rk9 (\14\:n0 \15\:n0) resistor r=0.2366 c=0
Rk10 (\15\:n0 \17\:n0) resistor r=0.5687 c=0
Rk11 (\15\:n0 \19\:n0) resistor r=0.348 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=266.862 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=73.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=212.23 c=0
Rl4 (\2\:A \3\:A) resistor r=118.644 c=0
Rl3 (\1\:A \2\:A) resistor r=134.226 c=0
Rl10 (\2\:B \3\:B) resistor r=78.3537 c=0
Rl9 (\1\:B \2\:B) resistor r=187.375 c=0
Rl11 (\2\:B \4\:B) resistor r=5.7469 c=0
Rl5 (S0b \2\:S0b) resistor r=60.6943 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=41.3047 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\7\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz11 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry8 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\3\:VSS \1\:VSS) resistor r=12.4 c=0
Ry12 (\8\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\17\:n0 \16\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\4\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\14\:n0 n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (net148 \1\:A \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.69e-14 ps=7.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.635e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn2 (\18\:n0 \2\:S0b net148 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.28e-14 ps=7.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3122e-07 sb=1.41e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn4 (\18\:n0 \4\:S0 net140 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=3.28e-14 ps=6.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3622e-07 sb=1.205e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn3 (net140 \1\:B \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.46e-14 ps=8.4e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0122e-07 sb=1.04e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn5 (\4\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.948e-14 ad=5.2e-14 ps=8.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93365e-07 sb=8.35e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
mp1 (net123 \3\:A \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=4.185e-14 ps=9.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80323e-07 sb=1.65e-06 sd=160n sca=12.241 \
        scb=0.00942952 scc=0.00011999 m=(1)
mp2 (\16\:n0 \6\:S0 net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60323e-07 sb=1.47e-06 sd=160n sca=11.1885 \
        scb=0.00841332 scc=0.000117337 m=(1)
mp4 (\16\:n0 \3\:S0b net115 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65323e-07 sb=1.265e-06 sd=160n sca=10.6105 \
        scb=0.00818197 scc=0.000117242 m=(1)
mp3 (net115 \3\:B \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.65e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.60323e-07 sb=1.07e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.238e-14 ad=7.8e-14 ps=1.105e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99359e-07 sb=8.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
ends CLKMX2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:07:25 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X6
// View name: extracted

simulator lang=spectre

subckt CLKMX2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \3\:S0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=4.085e-14 ps=1.24e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=16.964 scb=0.0172681 \
        scc=0.000351906 m=(1)
C1 (S0 VSS) capacitor c=5.94555e-17
C2 (A VSS) capacitor c=4.15369e-17
C3 (Y VSS) capacitor c=5.27604e-16
C4 (VDD VSS) capacitor c=1.48814e-16
C5 (B VSS) capacitor c=1.07512e-16
C6 (S0b VSS) capacitor c=6.79041e-17
C7 (n0 VSS) capacitor c=3.22079e-16
C8 (net140 VSS) capacitor c=4.72889e-18
C9 (net123 VSS) capacitor c=4.33011e-18
C10 (net115 VSS) capacitor c=2.50176e-18
C11 (\1\:B VSS) capacitor c=4.8996e-17
C12 (\3\:S0b VSS) capacitor c=4.28647e-17
C13 (\6\:S0 VSS) capacitor c=4.14711e-17
C14 (\1\:A VSS) capacitor c=5.57812e-17
C15 (\3\:S0 VSS) capacitor c=3.12704e-17
C16 (\3\:B VSS) capacitor c=5.29058e-17
C17 (\4\:S0 VSS) capacitor c=6.25961e-17
C18 (\3\:A VSS) capacitor c=8.37484e-17
C19 (\1\:S0 VSS) capacitor c=4.54596e-17
C20 (\2\:B VSS) capacitor c=4.3285e-17
C21 (\4\:S0b VSS) capacitor c=4.30341e-17
C22 (\5\:S0 VSS) capacitor c=9.06394e-17
C23 (\2\:S0b VSS) capacitor c=5.57777e-17
C24 (\2\:A VSS) capacitor c=6.14835e-17
C25 (\2\:S0 VSS) capacitor c=4.37726e-17
C26 (\1\:VDD VSS) capacitor c=2.66516e-16
C27 (\23\:n0 VSS) capacitor c=9.79654e-17
C28 (\11\:VDD VSS) capacitor c=3.12776e-17
C29 (\8\:S0b VSS) capacitor c=7.34478e-17
C30 (\4\:VDD VSS) capacitor c=2.95793e-17
C31 (\21\:n0 VSS) capacitor c=4.24567e-17
C32 (\10\:S0b VSS) capacitor c=1.21011e-17
C33 (\4\:A VSS) capacitor c=7.6583e-17
C34 (\7\:S0 VSS) capacitor c=8.73056e-17
C35 (\8\:S0 VSS) capacitor c=3.64648e-17
C36 (\5\:S0b VSS) capacitor c=7.24098e-17
C37 (\6\:S0b VSS) capacitor c=8.59123e-17
C38 (\7\:S0b VSS) capacitor c=7.73268e-17
C39 (\19\:n0 VSS) capacitor c=6.19494e-17
C40 (\20\:n0 VSS) capacitor c=1.10471e-16
C41 (\10\:VDD VSS) capacitor c=1.96916e-17
Rk2 (\7\:S0 S0) resistor r=0.424 c=0
Rk3 (S0 \8\:S0) resistor r=0.03791 c=0
Rk1 (A \4\:A) resistor r=0.03583 c=0
Rk25 (\1\:VDD \10\:VDD) resistor r=0.5496 c=0
Rk26 (\10\:VDD \12\:VDD) resistor r=0.231 c=0
Rk28 (\13\:VDD VDD) resistor r=0.04991 c=0
Rk27 (\10\:VDD \13\:VDD) resistor r=0.1026 c=0
Rk32 (\1\:VSS \7\:VSS) resistor r=0.3333 c=0
Rk34 (\8\:VSS VSS) resistor r=0.2278 c=0
Rk33 (\7\:VSS \8\:VSS) resistor r=0.07253 c=0
Rk37 (\8\:VSS \14\:VSS) resistor r=0.1775 c=0
Rk8 (B \4\:B) resistor r=0.003002 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.337 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5013 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.6219 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.05463 c=0
Rk9 (\19\:n0 \20\:n0) resistor r=0.3487 c=0
Rk10 (\20\:n0 \22\:n0) resistor r=0.3306 c=0
Rk11 (\20\:n0 \24\:n0) resistor r=0.5496 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=29.5379 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=229.104 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=66.4835 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=194.231 c=0
Rl3 (\1\:A \2\:A) resistor r=77.6148 c=0
Rl4 (\2\:A \3\:A) resistor r=144.923 c=0
Rl9 (\1\:B \2\:B) resistor r=73.7687 c=0
Rl10 (\2\:B \3\:B) resistor r=148.769 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=55.2823 c=0
Rl5 (S0b \2\:S0b) resistor r=68.4636 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz7 (\13\:VDD \4\:VDD) resistor r=37.5 c=0
Rz11 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=75 c=0
Ry9 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry11 (\7\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\24\:n0 \23\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\19\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \1\:S0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.79977 scb=0.00524357 \
        scc=6.87485e-05 m=(1)
mn1 (net148 \3\:A \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52195e-07 sb=1.84e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (\21\:n0 S0b net148 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.57195e-07 sb=1.735e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.74e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57195e-07 sb=1.235e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn4 (\21\:n0 \4\:S0 net140 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.28e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.62195e-07 sb=1.53e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn5 (Y n0 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.916e-14 \
        ad=5.456e-14 ps=9.48e-07 pd=9.72e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.15645e-07 sb=1.01e-06 sd=160n sca=8.89324 scb=0.00718666 \
        scc=0.00021338 m=(5)
mp1 (net123 \1\:A \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=3.875e-14 ps=1.24e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08629e-07 sb=1.865e-06 sd=160n sca=12.5498 \
        scb=0.0102845 scc=0.000266006 m=(1)
mp2 (\23\:n0 \6\:S0 net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=6.2e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78629e-07 sb=1.695e-06 sd=160n sca=11.8758 \
        scb=0.0098568 scc=0.000265591 m=(1)
mp4 (\23\:n0 \3\:S0b net115 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=6.2e-14 ps=9.1e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=1.45e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp3 (net115 \1\:B \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01363e-06 sb=1.26e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp5 (Y n0 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.917e-14 \
        ad=7.332e-14 ps=1.298e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.00479e-07 sb=9.6e-07 sd=160n sca=21.0172 scb=0.0163249 \
        scc=0.00202715 m=(5)
ends CLKMX2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 14:08:02 2012 )
// Library name: gsclib045
// Cell name: CLKMX2X8
// View name: extracted

simulator lang=spectre

subckt CLKMX2X8 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.837e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.0095 scb=0.0106782 \
        scc=0.000192315 m=(1)
C1 (S0 VSS) capacitor c=5.04731e-17
C2 (Y VSS) capacitor c=4.66661e-16
C3 (VDD VSS) capacitor c=2.10059e-16
C4 (B VSS) capacitor c=3.45381e-17
C5 (S0b VSS) capacitor c=3.58743e-17
C6 (n0 VSS) capacitor c=3.45918e-16
C7 (net140 VSS) capacitor c=3.99956e-18
C8 (net123 VSS) capacitor c=5.92273e-18
C9 (net115 VSS) capacitor c=4.68461e-18
C10 (\1\:B VSS) capacitor c=3.68376e-17
C11 (\6\:S0 VSS) capacitor c=4.37212e-17
C12 (\1\:A VSS) capacitor c=6.20872e-17
C13 (\1\:S0 VSS) capacitor c=3.55211e-17
C14 (\3\:B VSS) capacitor c=4.44063e-17
C15 (\4\:S0 VSS) capacitor c=7.05579e-17
C16 (\3\:S0b VSS) capacitor c=3.01833e-17
C17 (\3\:A VSS) capacitor c=4.20689e-17
C18 (\3\:S0 VSS) capacitor c=5.0664e-17
C19 (\2\:B VSS) capacitor c=3.8918e-17
C20 (\2\:S0b VSS) capacitor c=3.89366e-17
C21 (\4\:S0b VSS) capacitor c=4.42893e-17
C22 (\5\:S0 VSS) capacitor c=8.2789e-17
C23 (\2\:A VSS) capacitor c=4.87445e-17
C24 (\2\:S0 VSS) capacitor c=3.80996e-17
C25 (\1\:VDD VSS) capacitor c=2.96065e-16
C26 (\26\:n0 VSS) capacitor c=8.32103e-17
C27 (\17\:VDD VSS) capacitor c=3.96936e-17
C28 (\8\:S0b VSS) capacitor c=9.63338e-17
C29 (\4\:VDD VSS) capacitor c=5.70676e-17
C30 (\23\:n0 VSS) capacitor c=4.38947e-17
C31 (\5\:S0b VSS) capacitor c=1.19487e-17
C32 (\4\:A VSS) capacitor c=4.64474e-17
C33 (\6\:A VSS) capacitor c=6.82596e-17
C34 (\7\:S0 VSS) capacitor c=9.96392e-17
C35 (\8\:S0 VSS) capacitor c=8.68902e-17
C36 (\7\:S0b VSS) capacitor c=1.06645e-16
C37 (\10\:S0b VSS) capacitor c=7.66225e-17
C38 (\11\:S0b VSS) capacitor c=5.47622e-17
C39 (\4\:B VSS) capacitor c=5.91086e-17
C40 (\25\:n0 VSS) capacitor c=1.13858e-16
C41 (\28\:n0 VSS) capacitor c=6.14614e-17
C42 (\9\:VDD VSS) capacitor c=1.71013e-18
Rk4 (S0 \7\:S0) resistor r=0.07534 c=0
Rk5 (\7\:S0 \8\:S0) resistor r=0.6924 c=0
Rk1 (\4\:A \5\:A) resistor r=0.003456 c=0
Rk2 (A \6\:A) resistor r=0.003369 c=0
Rk3 (\4\:A \6\:A) resistor r=0.1037 c=0
Rk29 (\1\:VDD \8\:VDD) resistor r=0.2953 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.2828 c=0
Rk32 (\10\:VDD VDD) resistor r=0.09993 c=0
Rk31 (\9\:VDD \10\:VDD) resistor r=0.1676 c=0
Rk36 (\9\:VDD \18\:VDD) resistor r=0.1979 c=0
Rk41 (\1\:VSS \8\:VSS) resistor r=0.403 c=0
Rk43 (\9\:VSS VSS) resistor r=0.2826 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.06743 c=0
Rk47 (\9\:VSS \17\:VSS) resistor r=0.2422 c=0
Rk10 (B \4\:B) resistor r=0.1626 c=0
Rk6 (\6\:S0b \7\:S0b) resistor r=0.05402 c=0
Rk7 (\7\:S0b \9\:S0b) resistor r=0.7964 c=0
Rk8 (\7\:S0b \10\:S0b) resistor r=0.5536 c=0
Rk9 (\10\:S0b \11\:S0b) resistor r=0.2331 c=0
Rk11 (\24\:n0 \25\:n0) resistor r=0.3054 c=0
Rk12 (\25\:n0 \27\:n0) resistor r=0.5835 c=0
Rk13 (\25\:n0 \28\:n0) resistor r=0.3686 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=169.923 c=0
Rl3 (\1\:A \2\:A) resistor r=133.384 c=0
Rl4 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl9 (\1\:B \2\:B) resistor r=81.461 c=0
Rl10 (\2\:B \3\:B) resistor r=117.999 c=0
Rl5 (S0b \2\:S0b) resistor r=33.8482 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=66.8207 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz8 (\8\:VDD \4\:VDD) resistor r=12.5 c=0
Rz9 (\10\:VDD \4\:VDD) resistor r=25 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\5\:S0b \6\:S0b) resistor r=75 c=0
Rz2 (\24\:n0 \23\:n0) resistor r=75 c=0
Ry11 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry13 (\8\:VSS \4\:VSS) resistor r=7.75 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\27\:n0 \26\:n0) resistor r=31 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \10\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \11\:S0b) resistor r=45 c=0
Rx7 (\28\:n0 n0) resistor r=45 c=0
mn0 (\5\:S0b \3\:S0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.1906 scb=0.0108717 \
        scc=0.000387468 m=(1)
mn1 (net148 \3\:A \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=4.817e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn2 (\23\:n0 \3\:S0b net148 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.715e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn4 (\23\:n0 \4\:S0 net140 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.715e-14 ps=7.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6122e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn3 (net140 \3\:B \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.357e-14 ad=3.382e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07122e-06 sb=1.8e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn5 (Y n0 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=5.097e-14 \
        ad=5.226e-14 ps=9.5429e-07 pd=9.4429e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.02508e-06 sb=1.44e-06 sd=160n sca=13.5379 scb=0.0132414 \
        scc=0.000904444 m=(7)
mp1 (net123 \1\:A \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=5.735e-14 ps=1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61935e-07 sb=2e-06 sd=160n sca=11.3406 \
        scb=0.00879396 scc=0.000154509 m=(1)
mp2 (\26\:n0 \6\:S0 net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.425e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp4 (\26\:n0 S0b net115 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.37e-14 ad=5.425e-14 ps=1.16e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.11935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp3 (net115 \1\:B \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=8.37e-14 ps=1.52e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12694e-06 sb=1.8e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp5 (Y n0 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.691e-14 \
        ad=7.883e-14 ps=1.25429e-06 pd=1.24429e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.06618e-06 sb=1.44e-06 sd=160n sca=14.4925 scb=0.0129103 \
        scc=0.000843152 m=(7)
ends CLKMX2X8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:05:24 2012 )
// Library name: gsclib045
// Cell name: CLKXOR2X1
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X1 A B VDD VSS Y
mp5 (\1\:Y \4\:n0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.03654e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (A VSS) capacitor c=8.00895e-17
C2 (VDD VSS) capacitor c=1.11234e-16
C3 (Y VSS) capacitor c=4.65451e-17
C4 (B VSS) capacitor c=5.62075e-17
C5 (n0 VSS) capacitor c=2.31009e-17
C6 (n1 VSS) capacitor c=5.73225e-17
C7 (n2 VSS) capacitor c=5.36738e-17
C8 (net130 VSS) capacitor c=2.04336e-18
C9 (\7\:B VSS) capacitor c=3.66009e-17
C10 (\3\:n1 VSS) capacitor c=8.20754e-17
C11 (\2\:n2 VSS) capacitor c=8.55393e-17
C12 (\1\:B VSS) capacitor c=3.45616e-17
C13 (\1\:A VSS) capacitor c=4.34486e-17
C14 (\4\:n0 VSS) capacitor c=3.55243e-17
C15 (\5\:B VSS) capacitor c=4.09537e-17
C16 (\3\:B VSS) capacitor c=7.55568e-17
C17 (\3\:A VSS) capacitor c=4.29572e-17
C18 (\3\:n0 VSS) capacitor c=4.1059e-17
C19 (\6\:B VSS) capacitor c=5.5532e-17
C20 (\2\:n1 VSS) capacitor c=8.06528e-17
C21 (\4\:B VSS) capacitor c=7.42055e-17
C22 (\3\:n2 VSS) capacitor c=3.34781e-17
C23 (\2\:B VSS) capacitor c=4.08191e-17
C24 (\2\:A VSS) capacitor c=5.64424e-17
C25 (\4\:n2 VSS) capacitor c=1.30072e-17
C26 (\1\:VDD VSS) capacitor c=5.52247e-17
C27 (\8\:n0 VSS) capacitor c=1.22943e-16
C28 (\8\:n1 VSS) capacitor c=6.65993e-17
C29 (\6\:VDD VSS) capacitor c=2.75383e-17
C30 (\1\:Y VSS) capacitor c=7.9451e-17
C31 (\8\:n2 VSS) capacitor c=5.38146e-17
C32 (\5\:n0 VSS) capacitor c=1.25811e-16
C33 (\6\:n1 VSS) capacitor c=6.55325e-17
C34 (\3\:Y VSS) capacitor c=2.57719e-17
C35 (\2\:n0 VSS) capacitor c=1.93156e-17
C36 (\4\:A VSS) capacitor c=4.5403e-17
C37 (\7\:n0 VSS) capacitor c=2.3861e-16
C38 (\4\:n1 VSS) capacitor c=5.84406e-17
C39 (\5\:n1 VSS) capacitor c=1.27503e-16
C40 (\8\:B VSS) capacitor c=3.74346e-17
C41 (\9\:B VSS) capacitor c=4.43416e-17
C42 (\10\:B VSS) capacitor c=6.73304e-17
C43 (\6\:n2 VSS) capacitor c=1.15345e-16
C44 (\7\:n2 VSS) capacitor c=7.92174e-17
C45 (\4\:VDD VSS) capacitor c=4.21006e-17
C46 (\5\:VDD VSS) capacitor c=1.35036e-17
Rk3 (A \4\:A) resistor r=0.111 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.1128 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.2884 c=0
Rk18 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.1479 c=0
Rk19 (\3\:VSS \7\:VSS) resistor r=0.242 c=0
Rk20 (\5\:VSS \9\:VSS) resistor r=0.2349 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4973 c=0
Rk23 (\5\:VDD VDD) resistor r=0.1166 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2323 c=0
Rk24 (\5\:VDD \7\:VDD) resistor r=0.06846 c=0
Rk1 (\2\:Y Y) resistor r=0.4562 c=0
Rk2 (Y \4\:Y) resistor r=0.04518 c=0
Rk9 (\8\:B B) resistor r=0.1323 c=0
Rk10 (B \9\:B) resistor r=0.08217 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2616 c=0
Rk4 (\6\:n0 \7\:n0) resistor r=0.9732 c=0
Rk5 (\7\:n0 \9\:n0) resistor r=0.8284 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.3091 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.2829 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.4309 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.03827 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5822 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.5296 c=0
Rl4 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl5 (\2\:A \3\:A) resistor r=110.307 c=0
Rl13 (\6\:B \7\:B) resistor r=76.2049 c=0
Rl12 (\5\:B \6\:B) resistor r=126.718 c=0
Rl9 (\3\:B \4\:B) resistor r=130.002 c=0
Rl6 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl1 (n0 \2\:n0) resistor r=1.2334 c=0
Rl3 (\2\:n0 \4\:n0) resistor r=43.1104 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=87.3411 c=0
Rl10 (n1 \2\:n1) resistor r=72.7035 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=140.679 c=0
Rl7 (n2 \2\:n2) resistor r=241.883 c=0
Rl8 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry3 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry4 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (n0 \7\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.29519e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (\6\:n1 \3\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.915e-14 ps=9.2e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.7e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn4 (\5\:n0 n2 \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=6.55e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn3 (\5\:n0 \3\:B net139 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=4.5e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn2 (net139 n1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=3.45e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn1 (\8\:n2 \5\:B \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=1.4e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mp0 (\8\:n1 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.5e-07 sd=160n sca=15.6438 \
        scb=0.0148425 scc=0.000445561 m=(1)
mp4 (\8\:n0 \1\:B \8\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=7.45e-07 sd=160n sca=13.754 \
        scb=0.0122361 scc=0.000425664 m=(1)
mp3 (\8\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=5.25e-07 sd=160n sca=13.561 \
        scb=0.0120014 scc=0.000425312 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.45e-07 sd=160n sca=14.4668 \
        scb=0.0130588 scc=0.000428492 m=(1)
mp1 (\4\:n2 \7\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=17.9454 \
        scb=0.0188744 scc=0.000556907 m=(1)
ends CLKXOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:09:16 2012 )
// Library name: gsclib045
// Cell name: CLKXOR2X2
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X2 A B VDD VSS Y
mp5 (\3\:Y n0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.826e-14 ad=6.24e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.73526e-07 sd=160n sca=22.1173 \
        scb=0.0235828 scc=0.00128647 m=(2)
C1 (Y VSS) capacitor c=6.22403e-17
C2 (VDD VSS) capacitor c=1.19273e-16
C3 (B VSS) capacitor c=5.61544e-17
C4 (n0 VSS) capacitor c=1.31997e-16
C5 (n1 VSS) capacitor c=4.78161e-17
C6 (n2 VSS) capacitor c=2.97981e-17
C7 (net130 VSS) capacitor c=1.88405e-18
C8 (\7\:B VSS) capacitor c=3.75135e-17
C9 (\3\:n1 VSS) capacitor c=8.85616e-17
C10 (\2\:n2 VSS) capacitor c=7.84385e-17
C11 (\1\:B VSS) capacitor c=4.11561e-17
C12 (\1\:A VSS) capacitor c=3.64951e-17
C13 (\5\:B VSS) capacitor c=3.98244e-17
C14 (\3\:B VSS) capacitor c=6.95992e-17
C15 (\3\:n2 VSS) capacitor c=7.24839e-17
C16 (\3\:A VSS) capacitor c=3.97592e-17
C17 (\6\:B VSS) capacitor c=5.33522e-17
C18 (\2\:n1 VSS) capacitor c=7.82379e-17
C19 (\4\:B VSS) capacitor c=7.10654e-17
C20 (\2\:B VSS) capacitor c=4.43991e-17
C21 (\2\:A VSS) capacitor c=3.5925e-17
C22 (\8\:n2 VSS) capacitor c=1.08999e-17
C23 (\1\:VDD VSS) capacitor c=6.78298e-17
C24 (\10\:n0 VSS) capacitor c=1.13399e-16
C25 (\6\:n1 VSS) capacitor c=5.98114e-17
C26 (\3\:Y VSS) capacitor c=8.60307e-17
C27 (\4\:n2 VSS) capacitor c=5.56552e-17
C28 (\7\:n0 VSS) capacitor c=1.05194e-16
C29 (\8\:n1 VSS) capacitor c=3.78471e-17
C30 (\1\:Y VSS) capacitor c=4.48088e-17
C31 (\4\:A VSS) capacitor c=1.29509e-16
C32 (\9\:n0 VSS) capacitor c=2.55324e-16
C33 (\4\:n1 VSS) capacitor c=8.9777e-17
C34 (\5\:n1 VSS) capacitor c=9.09507e-17
C35 (\8\:B VSS) capacitor c=2.95882e-17
C36 (\9\:B VSS) capacitor c=3.35638e-17
C37 (\10\:B VSS) capacitor c=4.60794e-17
C38 (\6\:n2 VSS) capacitor c=1.11553e-16
C39 (\7\:n2 VSS) capacitor c=8.167e-17
C40 (\4\:VDD VSS) capacitor c=3.70884e-17
C41 (\5\:VDD VSS) capacitor c=9.02123e-17
Rk3 (A \4\:A) resistor r=0.03171 c=0
Rk1 (\2\:Y Y) resistor r=0.1481 c=0
Rk2 (Y \4\:Y) resistor r=0.4376 c=0
Rk24 (\2\:VDD \4\:VDD) resistor r=0.5922 c=0
Rk27 (\5\:VDD VDD) resistor r=0.02463 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.1794 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.1026 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.248 c=0
Rk20 (\5\:VSS VSS) resistor r=0.02463 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.2455 c=0
Rk21 (\3\:VSS \9\:VSS) resistor r=0.31 c=0
Rk9 (\8\:B B) resistor r=0.1668 c=0
Rk10 (B \9\:B) resistor r=0.06849 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2021 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.9513 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.9572 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4557 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.3155 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.1277 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.524 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.6001 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04786 c=0
Rl6 (\1\:A \2\:A) resistor r=60.7134 c=0
Rl7 (\2\:A \3\:A) resistor r=99.1749 c=0
Rl15 (\6\:B \7\:B) resistor r=78.8233 c=0
Rl14 (\5\:B \6\:B) resistor r=86.3335 c=0
Rl11 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl8 (\1\:B \2\:B) resistor r=71.8456 c=0
Rl12 (n1 \2\:n1) resistor r=31.791 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=149.361 c=0
Rl9 (n2 \2\:n2) resistor r=24.2328 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=208.747 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz5 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry8 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\4\:VSS \1\:VSS) resistor r=12.4 c=0
Ry7 (\5\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry2 (\11\:n0 \10\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (n2 \7\:n2) resistor r=45 c=0
mn5 (\1\:Y n0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.483e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.95577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\8\:n1 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=5.728e-14 ps=9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.095e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net139 n1 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\7\:n0 \3\:n2 \8\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.32e-14 ps=1.08e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\7\:n0 \3\:B net139 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0243e-13 ad=5.805e-14 ps=1.74e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.015e-06 sd=160n sca=13.1802 \
        scb=0.0118482 scc=0.000425234 m=(1)
mp4 (\10\:n0 \1\:B \6\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.87e-14 ps=9.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=7e-07 sd=160n sca=12.8224 scb=0.011715 \
        scc=0.000425192 m=(1)
mp3 (\10\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.87e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=4.75e-07 sd=160n sca=13.569 \
        scb=0.0120992 scc=0.00042546 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=3.45e-07 sd=160n sca=14.4226 \
        scb=0.0130013 scc=0.000428203 m=(1)
mp1 (\8\:n2 \7\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=17.794 \
        scb=0.0186079 scc=0.000545865 m=(1)
ends CLKXOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:09:53 2012 )
// Library name: gsclib045
// Cell name: CLKXOR2X4
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X4 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.523e-14 \
        ad=6.24e-14 ps=1.1575e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.44314e-06 sd=160n sca=44.1638 scb=0.0392167 \
        scc=0.00476734 m=(4)
C1 (A VSS) capacitor c=3.39402e-17
C2 (Y VSS) capacitor c=1.539e-17
C3 (VDD VSS) capacitor c=2.90029e-16
C4 (B VSS) capacitor c=4.57258e-17
C5 (n0 VSS) capacitor c=2.22323e-16
C6 (n1 VSS) capacitor c=6.27824e-17
C7 (n2 VSS) capacitor c=3.29879e-17
C8 (net130 VSS) capacitor c=2.2278e-18
C9 (\4\:B VSS) capacitor c=4.88242e-17
C10 (\3\:n2 VSS) capacitor c=5.85123e-17
C11 (\3\:B VSS) capacitor c=5.23609e-17
C12 (\1\:A VSS) capacitor c=3.52088e-17
C13 (\6\:B VSS) capacitor c=4.06262e-17
C14 (\3\:n1 VSS) capacitor c=7.17432e-17
C15 (\1\:B VSS) capacitor c=4.79265e-17
C16 (\3\:A VSS) capacitor c=3.07316e-17
C17 (\5\:B VSS) capacitor c=5.00644e-17
C18 (\2\:n1 VSS) capacitor c=6.12227e-17
C19 (\2\:B VSS) capacitor c=7.52839e-17
C20 (\4\:n2 VSS) capacitor c=4.79018e-17
C21 (\2\:n2 VSS) capacitor c=3.30014e-17
C22 (\2\:A VSS) capacitor c=3.52749e-17
C23 (\10\:n2 VSS) capacitor c=6.27418e-17
C24 (\9\:VDD VSS) capacitor c=3.13624e-17
C25 (\13\:n0 VSS) capacitor c=1.10338e-16
C26 (\5\:n1 VSS) capacitor c=1.15302e-16
C27 (\1\:Y VSS) capacitor c=1.84802e-16
C28 (\1\:VDD VSS) capacitor c=3.43873e-17
C29 (\5\:n2 VSS) capacitor c=1.92862e-17
C30 (\17\:n0 VSS) capacitor c=1.50844e-16
C31 (\7\:n1 VSS) capacitor c=9.62286e-17
C32 (\4\:Y VSS) capacitor c=1.18252e-16
C33 (\4\:A VSS) capacitor c=8.60675e-17
C34 (\15\:n0 VSS) capacitor c=2.60977e-16
C35 (\16\:n0 VSS) capacitor c=2.78611e-17
C36 (\4\:n1 VSS) capacitor c=9.5375e-17
C37 (\7\:B VSS) capacitor c=5.83892e-17
C38 (\8\:B VSS) capacitor c=6.29394e-17
C39 (\7\:n2 VSS) capacitor c=1.04966e-16
C40 (\8\:n2 VSS) capacitor c=8.05899e-17
C41 (\9\:n2 VSS) capacitor c=3.94407e-17
C42 (\12\:n2 VSS) capacitor c=6.98915e-17
C43 (\3\:VDD VSS) capacitor c=1.974e-17
Rk6 (A \4\:A) resistor r=0.04241 c=0
Rk28 (\2\:VSS \3\:VSS) resistor r=0.09763 c=0
Rk30 (\4\:VSS VSS) resistor r=0.0901 c=0
Rk29 (\3\:VSS \4\:VSS) resistor r=0.5541 c=0
Rk34 (\3\:VSS \10\:VSS) resistor r=0.1804 c=0
Rk2 (\1\:Y Y) resistor r=0.04859 c=0
Rk3 (Y \4\:Y) resistor r=0.2441 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.09763 c=0
Rk21 (\4\:VDD VDD) resistor r=0.0901 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.5541 c=0
Rk25 (\3\:VDD \10\:VDD) resistor r=0.3116 c=0
Rk12 (B \7\:B) resistor r=0.1082 c=0
Rk13 (\7\:B \8\:B) resistor r=0.2003 c=0
Rk7 (\14\:n0 \15\:n0) resistor r=1.0715 c=0
Rk8 (\15\:n0 \16\:n0) resistor r=0.1125 c=0
Rk9 (\15\:n0 \18\:n0) resistor r=1.1451 c=0
Rk10 (\4\:n1 \6\:n1) resistor r=0.5836 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.4358 c=0
Rk14 (\6\:n2 \7\:n2) resistor r=0.09749 c=0
Rk15 (\7\:n2 \8\:n2) resistor r=0.572 c=0
Rk16 (\8\:n2 \9\:n2) resistor r=0.08682 c=0
Rk17 (\7\:n2 \11\:n2) resistor r=0.5084 c=0
Rk18 (\8\:n2 \12\:n2) resistor r=0.2933 c=0
Rl12 (\1\:A \2\:A) resistor r=87.2302 c=0
Rl13 (\2\:A \3\:A) resistor r=89.1533 c=0
Rl20 (\4\:B \5\:B) resistor r=131.867 c=0
Rl21 (\5\:B \6\:B) resistor r=97.2519 c=0
Rl17 (\2\:B \3\:B) resistor r=158.232 c=0
Rl16 (\1\:B \2\:B) resistor r=64.6174 c=0
Rl18 (n1 \2\:n1) resistor r=29.5379 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=146.846 c=0
Rl15 (\3\:n2 \4\:n2) resistor r=39.6174 c=0
Rl14 (n2 \2\:n2) resistor r=66.8207 c=0
Rz9 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\4\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=75 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry11 (\4\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry7 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=62 c=0
Ry4 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry5 (\10\:n2 \11\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\16\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn5 (\4\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.075e-14 \
        ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.43163e-06 sd=160n sca=9.89531 scb=0.00874901 \
        scc=0.000299334 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=9.445e-14 ps=9.6e-07 pd=1.63e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.26362e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn4 (\17\:n0 n2 \7\:n1 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=3.28e-14 ps=1.63e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21402e-06 sb=6.38293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn3 (\17\:n0 \1\:B net139 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=3.28e-14 ps=6.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41902e-06 sb=4.33293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (net139 \3\:n1 \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.358e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55073e-06 sb=2.73293e-07 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn1 (\5\:n2 \6\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44966e-06 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mp0 (\5\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.15e-14 ad=1.4818e-13 ps=1.37e-06 pd=1.91e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.25674e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp4 (\13\:n0 \3\:B \5\:n1 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4818e-13 ad=4.96e-14 ps=1.91e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21661e-06 sb=5.99919e-07 sd=160n sca=19.4676 \
        scb=0.0175759 scc=0.00172296 m=(1)
mp3 (\13\:n0 \3\:n2 net130 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=4.96e-14 ps=7.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42161e-06 sb=3.94919e-07 sd=160n sca=20.3464 \
        scb=0.0181967 scc=0.00172377 m=(1)
mp2 (net130 n1 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=2.48e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51887e-06 sb=2.69919e-07 sd=160n sca=21.4199 \
        scb=0.0195761 scc=0.00173118 m=(1)
mp1 (\10\:n2 \4\:B \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39686e-06 sb=1.4e-07 sd=160n sca=20.5353 \
        scb=0.0230763 scc=0.000857203 m=(1)
ends CLKXOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:10:30 2012 )
// Library name: gsclib045
// Cell name: CLKXOR2X8
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X8 A B VDD VSS Y
mp5 (\1\:Y n0 \5\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.234e-14 ad=6.993e-14 ps=1.22857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.67124e-06 sd=160n \
        sca=27.6714 scb=0.0224014 scc=0.0024948 m=(7)
C1 (A VSS) capacitor c=8.63589e-17
C2 (Y VSS) capacitor c=1.27988e-17
C3 (VDD VSS) capacitor c=1.3195e-16
C4 (B VSS) capacitor c=2.68366e-17
C5 (n0 VSS) capacitor c=3.42175e-16
C6 (n1 VSS) capacitor c=5.43652e-17
C7 (n2 VSS) capacitor c=4.06703e-17
C8 (net130 VSS) capacitor c=3.84808e-18
C9 (\7\:B VSS) capacitor c=3.61153e-17
C10 (\3\:n1 VSS) capacitor c=5.00422e-17
C11 (\3\:n2 VSS) capacitor c=4.81818e-17
C12 (\3\:B VSS) capacitor c=5.28036e-17
C13 (\1\:A VSS) capacitor c=3.37654e-17
C14 (\5\:B VSS) capacitor c=4.615e-17
C15 (\1\:B VSS) capacitor c=3.6041e-17
C16 (\3\:A VSS) capacitor c=3.56437e-17
C17 (\6\:B VSS) capacitor c=4.16964e-17
C18 (\2\:n1 VSS) capacitor c=5.6185e-17
C19 (\4\:B VSS) capacitor c=3.70852e-17
C20 (\4\:n2 VSS) capacitor c=5.48169e-17
C21 (\2\:n2 VSS) capacitor c=3.31717e-17
C22 (\2\:A VSS) capacitor c=3.28224e-17
C23 (\10\:n2 VSS) capacitor c=5.73119e-17
C24 (\1\:VDD VSS) capacitor c=4.07403e-17
C25 (\23\:n0 VSS) capacitor c=1.06916e-16
C26 (\5\:n1 VSS) capacitor c=1.27149e-16
C27 (\1\:Y VSS) capacitor c=3.48738e-16
C28 (\3\:VDD VSS) capacitor c=4.46773e-17
C29 (\5\:n2 VSS) capacitor c=2.00388e-17
C30 (\27\:n0 VSS) capacitor c=1.11532e-16
C31 (\7\:n1 VSS) capacitor c=6.89239e-17
C32 (\6\:Y VSS) capacitor c=1.74499e-16
C33 (\2\:B VSS) capacitor c=6.07343e-17
C34 (\4\:A VSS) capacitor c=2.94912e-17
C35 (\25\:n0 VSS) capacitor c=2.38683e-16
C36 (\26\:n0 VSS) capacitor c=6.25748e-17
C37 (\4\:n1 VSS) capacitor c=8.39487e-17
C38 (\8\:B VSS) capacitor c=6.41489e-17
C39 (\9\:B VSS) capacitor c=5.19553e-17
C40 (\7\:n2 VSS) capacitor c=9.52318e-17
C41 (\8\:n2 VSS) capacitor c=7.4154e-17
C42 (\9\:n2 VSS) capacitor c=3.58401e-17
C43 (\12\:n2 VSS) capacitor c=3.13248e-17
C44 (\5\:VDD VSS) capacitor c=3.01717e-16
Rk12 (A \4\:A) resistor r=0.01779 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.08752 c=0
Rk26 (\3\:VSS \4\:VSS) resistor r=0.1627 c=0
Rk32 (\5\:VSS VSS) resistor r=0.195 c=0
Rk27 (\4\:VSS \5\:VSS) resistor r=0.506 c=0
Rk33 (\3\:VSS \11\:VSS) resistor r=0.1731 c=0
Rk4 (\1\:Y Y) resistor r=0.1964 c=0
Rk5 (Y \6\:Y) resistor r=0.1046 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.6963 c=0
Rk47 (\5\:VDD VDD) resistor r=0.2006 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.2529 c=0
Rk19 (\9\:B B) resistor r=0.0179 c=0
Rk18 (\8\:B \9\:B) resistor r=0.2816 c=0
Rk13 (\24\:n0 \25\:n0) resistor r=0.9828 c=0
Rk14 (\25\:n0 \26\:n0) resistor r=0.3588 c=0
Rk15 (\25\:n0 \28\:n0) resistor r=0.9432 c=0
Rk16 (\4\:n1 \6\:n1) resistor r=0.5904 c=0
Rk17 (\6\:n1 \8\:n1) resistor r=0.4262 c=0
Rk20 (\6\:n2 \7\:n2) resistor r=0.1114 c=0
Rk21 (\7\:n2 \8\:n2) resistor r=0.6139 c=0
Rk22 (\8\:n2 \9\:n2) resistor r=0.136 c=0
Rk23 (\7\:n2 \11\:n2) resistor r=0.4872 c=0
Rk24 (\8\:n2 \12\:n2) resistor r=0.1309 c=0
Rl22 (\1\:A \2\:A) resistor r=89.1533 c=0
Rl23 (\2\:A \3\:A) resistor r=83.3841 c=0
Rl32 (\6\:B \7\:B) resistor r=37.9121 c=0
Rl31 (\5\:B \6\:B) resistor r=159.615 c=0
Rl27 (\2\:B \3\:B) resistor r=138.77 c=0
Rl26 (\1\:B \2\:B) resistor r=64.1248 c=0
Rl28 (\2\:B \4\:B) resistor r=28.0958 c=0
Rl29 (n1 \2\:n1) resistor r=148.077 c=0
Rl30 (\2\:n1 \3\:n1) resistor r=26.3736 c=0
Rl25 (\3\:n2 \4\:n2) resistor r=39.9593 c=0
Rl24 (n2 \2\:n2) resistor r=75.6918 c=0
Rz8 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz14 (\5\:VDD \3\:VDD) resistor r=15 c=0
Rz5 (\28\:n0 \27\:n0) resistor r=75 c=0
Rz6 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz7 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry5 (\24\:n0 \23\:n0) resistor r=62 c=0
Ry6 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry7 (\10\:n2 \11\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:B \8\:B) resistor r=45 c=0
Rx5 (\6\:B \9\:B) resistor r=45 c=0
Rx2 (\26\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn5 (\6\:Y n0 \5\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.745e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.66136e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mn0 (\7\:n1 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.895e-14 ad=6.908e-14 ps=1.05e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=1.31466e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn4 (\27\:n0 n2 \7\:n1 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.908e-14 ad=3.28e-14 ps=1.28e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4439e-06 sb=8.72805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mn3 (\27\:n0 \1\:B net139 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.15e-14 ad=3.28e-14 ps=1.01e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5039e-06 sb=6.67805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mn2 (net139 n1 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.355e-14 ad=6.15e-14 ps=7.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60488e-06 sb=3.22805e-07 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(1)
mn1 (\5\:n2 \5\:B \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.355e-14 ad=2.61e-14 ps=7.9e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53862e-06 sb=1.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp0 (\5\:n1 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.918e-14 ad=1.256e-13 ps=1.34e-06 pd=1.7e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=1.33e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp4 (\23\:n0 \3\:B \5\:n1 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.256e-13 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41774e-06 sb=6.72984e-07 sd=160n sca=21.4696 \
        scb=0.0188478 scc=0.00214554 m=(1)
mp3 (\23\:n0 \3\:n2 net130 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.72e-14 ad=4.96e-14 ps=8.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48056e-06 sb=4.67984e-07 sd=160n sca=22.0887 \
        scb=0.019123 scc=0.00214568 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.72e-14 ps=1e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53113e-06 sb=3.02984e-07 sd=160n sca=23.1022 \
        scb=0.0201418 scc=0.00214855 m=(1)
mp1 (\10\:n2 \7\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=32.0046 scb=0.0317061 \
        scc=0.00322039 m=(1)
ends CLKXOR2X8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:06:12 2012 )
// Library name: gsclib045
// Cell name: DFFHQX1
// View name: extracted

simulator lang=spectre

subckt DFFHQX1 CK D Q VDD VSS
mp55 (\1\:Q \4\:qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.30833e-07 sd=160n sca=29.0978 \
        scb=0.0329394 scc=0.00242907 m=(1)
C1 (D VSS) capacitor c=3.79633e-17
C2 (VDD VSS) capacitor c=1.57444e-16
C3 (CK VSS) capacitor c=4.49227e-17
C4 (qbint VSS) capacitor c=1.81781e-17
C5 (CKb VSS) capacitor c=2.98332e-17
C6 (n30 VSS) capacitor c=3.59565e-17
C7 (net172 VSS) capacitor c=3.17549e-18
C8 (mout VSS) capacitor c=9.77052e-17
C9 (CKbb VSS) capacitor c=5.04488e-17
C10 (n20 VSS) capacitor c=4.4832e-17
C11 (net192 VSS) capacitor c=2.98175e-18
C12 (n21 VSS) capacitor c=2.12137e-18
C13 (net123 VSS) capacitor c=5.06907e-18
C14 (net147 VSS) capacitor c=1.69422e-18
C15 (n22 VSS) capacitor c=5.79395e-18
C16 (\10\:CKb VSS) capacitor c=4.28594e-17
C17 (\1\:D VSS) capacitor c=4.60829e-17
C18 (\5\:CKbb VSS) capacitor c=6.63975e-17
C19 (\4\:CKb VSS) capacitor c=6.97562e-17
C20 (\5\:qbint VSS) capacitor c=5.9926e-17
C21 (\3\:n30 VSS) capacitor c=4.71864e-17
C22 (\3\:CK VSS) capacitor c=4.22351e-17
C23 (\4\:qbint VSS) capacitor c=5.68934e-17
C24 (\8\:CKb VSS) capacitor c=2.99928e-17
C25 (\3\:D VSS) capacitor c=6.92698e-17
C26 (\6\:CKb VSS) capacitor c=5.44589e-17
C27 (\7\:CKbb VSS) capacitor c=2.88179e-17
C28 (\3\:mout VSS) capacitor c=3.71421e-17
C29 (\3\:n20 VSS) capacitor c=4.96991e-17
C30 (\3\:CKbb VSS) capacitor c=2.69704e-17
C31 (\3\:CKb VSS) capacitor c=7.11703e-17
C32 (\8\:qbint VSS) capacitor c=5.44164e-17
C33 (\1\:CK VSS) capacitor c=4.58547e-17
C34 (\3\:qbint VSS) capacitor c=2.89848e-17
C35 (\9\:CKb VSS) capacitor c=3.92271e-17
C36 (\2\:D VSS) capacitor c=5.52871e-17
C37 (\7\:CKb VSS) capacitor c=3.92214e-17
C38 (\5\:CKb VSS) capacitor c=3.35438e-17
C39 (\6\:CKbb VSS) capacitor c=6.19267e-17
C40 (\2\:mout VSS) capacitor c=5.0257e-17
C41 (\2\:n20 VSS) capacitor c=4.0605e-17
C42 (\4\:CKbb VSS) capacitor c=4.051e-17
C43 (\2\:CKb VSS) capacitor c=6.70086e-17
C44 (\2\:CKbb VSS) capacitor c=4.54283e-17
C45 (\7\:qbint VSS) capacitor c=2.30771e-17
C46 (\2\:n30 VSS) capacitor c=4.62549e-17
C47 (\2\:CK VSS) capacitor c=3.90204e-17
C48 (\8\:CKbb VSS) capacitor c=4.37886e-17
C49 (\8\:VDD VSS) capacitor c=4.44756e-17
C50 (\8\:n20 VSS) capacitor c=3.55344e-17
C51 (\10\:VDD VSS) capacitor c=3.75964e-17
C52 (\4\:mout VSS) capacitor c=8.14631e-17
C53 (\8\:n30 VSS) capacitor c=5.01226e-17
C54 (\12\:VDD VSS) capacitor c=4.99186e-17
C55 (\14\:qbint VSS) capacitor c=9.50205e-17
C56 (\20\:CKb VSS) capacitor c=3.27976e-17
C57 (\14\:VDD VSS) capacitor c=4.4253e-17
C58 (\1\:Q VSS) capacitor c=5.65164e-17
C59 (\1\:VDD VSS) capacitor c=2.88071e-17
C60 (\10\:CKbb VSS) capacitor c=1.23096e-16
C61 (\4\:n20 VSS) capacitor c=7.83202e-17
C62 (\7\:mout VSS) capacitor c=4.69619e-17
C63 (\4\:n30 VSS) capacitor c=9.05188e-17
C64 (\11\:qbint VSS) capacitor c=7.46668e-17
C65 (\18\:CKb VSS) capacitor c=1.14883e-16
C66 (\3\:Q VSS) capacitor c=5.95396e-17
C67 (\2\:qbint VSS) capacitor c=1.69147e-17
C68 (\6\:qbint VSS) capacitor c=3.32063e-17
C69 (\4\:CK VSS) capacitor c=9.51602e-17
C70 (\9\:qbint VSS) capacitor c=7.45606e-17
C71 (\10\:qbint VSS) capacitor c=1.05324e-16
C72 (\13\:qbint VSS) capacitor c=1.16493e-16
C73 (\6\:n30 VSS) capacitor c=1.18108e-16
C74 (\7\:n30 VSS) capacitor c=8.64226e-17
C75 (\6\:mout VSS) capacitor c=7.29788e-17
C76 (\9\:mout VSS) capacitor c=5.94404e-17
C77 (\6\:n20 VSS) capacitor c=8.31854e-17
C78 (\7\:n20 VSS) capacitor c=5.60523e-17
C79 (\5\:D VSS) capacitor c=4.85548e-17
C80 (\11\:CKb VSS) capacitor c=7.12176e-17
C81 (\12\:CKb VSS) capacitor c=1.24062e-16
C82 (\13\:CKb VSS) capacitor c=9.76323e-17
C83 (\14\:CKb VSS) capacitor c=1.12222e-16
C84 (\15\:CKb VSS) capacitor c=6.85827e-17
C85 (\16\:CKb VSS) capacitor c=2.54138e-17
C86 (\17\:CKb VSS) capacitor c=1.48771e-16
C87 (\12\:CKbb VSS) capacitor c=1.97647e-16
C88 (\13\:CKbb VSS) capacitor c=1.2998e-16
C89 (\14\:CKbb VSS) capacitor c=4.32298e-17
C90 (\15\:CKbb VSS) capacitor c=6.74577e-17
C91 (\3\:VDD VSS) capacitor c=1.26931e-17
C92 (\4\:VDD VSS) capacitor c=2.95395e-17
C93 (\6\:VDD VSS) capacitor c=1.19106e-17
C94 (\7\:VDD VSS) capacitor c=1.8559e-17
Rk17 (\4\:D \5\:D) resistor r=0.01233 c=0
Rk18 (\6\:D D) resistor r=0.0125 c=0
Rk19 (\5\:D \6\:D) resistor r=0.02493 c=0
Rk33 (\2\:VSS \4\:VSS) resistor r=0.1771 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.3487 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.2031 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.2609 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.2408 c=0
Rk39 (\9\:VSS VSS) resistor r=0.1025 c=0
Rk38 (\8\:VSS \9\:VSS) resistor r=0.09771 c=0
Rk40 (\5\:VSS \11\:VSS) resistor r=0.1319 c=0
Rk41 (\7\:VSS \13\:VSS) resistor r=0.2162 c=0
Rk42 (\9\:VSS \15\:VSS) resistor r=0.2903 c=0
Rk43 (\2\:VDD \3\:VDD) resistor r=0.05754 c=0
Rk44 (\3\:VDD \4\:VDD) resistor r=0.3914 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.3515 c=0
Rk46 (\5\:VDD \6\:VDD) resistor r=0.1219 c=0
Rk48 (\7\:VDD VDD) resistor r=0.1025 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.325 c=0
Rk49 (\3\:VDD \9\:VDD) resistor r=0.357 c=0
Rk50 (\4\:VDD \11\:VDD) resistor r=0.1323 c=0
Rk51 (\6\:VDD \13\:VDD) resistor r=0.1563 c=0
Rk52 (\7\:VDD \15\:VDD) resistor r=0.2566 c=0
Rk3 (\4\:CK CK) resistor r=0.101 c=0
Rk1 (\2\:Q Q) resistor r=0.3913 c=0
Rk2 (Q \4\:Q) resistor r=0.09099 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.401 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06291 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6085 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.417 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.2921 c=0
Rk21 (\12\:CKb \13\:CKb) resistor r=0.6435 c=0
Rk22 (\13\:CKb \14\:CKb) resistor r=0.4535 c=0
Rk23 (\14\:CKb \15\:CKb) resistor r=0.2689 c=0
Rk24 (\13\:CKb \16\:CKb) resistor r=0.08897 c=0
Rk25 (\14\:CKb \17\:CKb) resistor r=0.7035 c=0
Rk26 (\17\:CKb \19\:CKb) resistor r=0.4767 c=0
Rk27 (\17\:CKb \21\:CKb) resistor r=0.0696 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.5389 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.4421 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1644 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3339 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1232 c=0
Rk13 (\6\:mout \9\:mout) resistor r=0.2346 c=0
Rk28 (\9\:CKbb \11\:CKbb) resistor r=0.4434 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.7898 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.8589 c=0
Rk31 (\12\:CKbb \14\:CKbb) resistor r=0.1406 c=0
Rk32 (\13\:CKbb \15\:CKbb) resistor r=0.3031 c=0
Rk14 (\5\:n20 \6\:n20) resistor r=0.3828 c=0
Rk15 (\6\:n20 \7\:n20) resistor r=0.3082 c=0
Rk16 (\6\:n20 \9\:n20) resistor r=0.132 c=0
Rl23 (\1\:D \2\:D) resistor r=62.6944 c=0
Rl24 (\2\:D \3\:D) resistor r=89.6174 c=0
Rl5 (\2\:CK \3\:CK) resistor r=68.4066 c=0
Rl4 (\1\:CK \2\:CK) resistor r=107.692 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=90.0987 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=57.4064 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=115.099 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\9\:CKb \10\:CKb) resistor r=120.949 c=0
Rl25 (\8\:CKb \9\:CKb) resistor r=30.0511 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=47.3097 c=0
Rl19 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl12 (CKb \2\:CKb) resistor r=28.6412 c=0
Rl13 (\2\:CKb \3\:CKb) resistor r=193.774 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=78.022 c=0
Rl17 (mout \2\:mout) resistor r=125.692 c=0
Rl18 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=156.3 c=0
Rl21 (\6\:CKbb \7\:CKbb) resistor r=26.4372 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=39.9512 c=0
Rl11 (CKbb \2\:CKbb) resistor r=48.7687 c=0
Rl15 (n20 \2\:n20) resistor r=49.1749 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=99.1749 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz10 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz11 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz13 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz5 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry9 (\3\:VSS \6\:VSS) resistor r=12.4 c=0
Ry10 (\3\:VSS \8\:VSS) resistor r=12.4 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry6 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx8 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.90577e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20 (\18\:CKb \1\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn45 (\11\:qbint n30 \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.383e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96341e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn50 (net172 \8\:qbint \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.383e-14 ad=2.05e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.83122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\4\:n30 \3\:CKb net172 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=5.843e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.68622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=1.35622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\7\:mout \3\:n20 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.238e-14 ad=3.28e-14 ps=1.28e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.15122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net192 \3\:mout \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=2.768e-14 ps=1.28e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=8.8122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\4\:n20 \7\:CKbb net192 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.408e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=7.0122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn26 (\4\:n20 \6\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.408e-14 ps=5.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=4.4122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=3.3622e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn21 (\10\:CKbb \8\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mp20 (\20\:CKb \3\:CK \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=2.63e-14 ps=1.12e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.22326e-07 sd=160n sca=13.9323 \
        scb=0.0120188 scc=0.000146665 m=(1)
mp45 (\14\:qbint \3\:n30 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=3.64e-14 ps=1.32e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17419e-07 sb=1.96935e-06 sd=160n sca=19.4821 \
        scb=0.0175815 scc=0.00172296 m=(1)
mp50 (net123 \5\:qbint \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=3.1e-14 ps=1.32e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.82419e-07 sb=1.81879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 CKbb net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.27419e-07 sb=1.67379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\4\:mout CKb \8\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=6.82e-14 ps=1.07e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.97419e-07 sb=1.40379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\4\:mout n20 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=6.82e-14 ps=1.78e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06242e-06 sb=1.13879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net147 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=1.86e-14 ps=1.78e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33242e-06 sb=8.6879e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\8\:n20 \4\:CKb net147 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43742e-06 sb=7.6379e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp26 (\8\:n20 \5\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64242e-06 sb=5.5879e-07 sd=160n sca=19.3989 \
        scb=0.017551 scc=0.00172296 m=(1)
mp25 (n22 \1\:D \8\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.63e-14 ad=5.89e-14 ps=1.02e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.87742e-06 sb=3.2379e-07 sd=160n sca=20.3782 \
        scb=0.0182292 scc=0.00172385 m=(1)
mp21 (\8\:CKbb \10\:CKb \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.63e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=27.2531 scb=0.0271167 \
        scc=0.00250214 m=(1)
ends DFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:11:45 2012 )
// Library name: gsclib045
// Cell name: DFFHQX2
// View name: extracted

simulator lang=spectre

subckt DFFHQX2 CK D Q VDD VSS
mp20 (\22\:CKb \1\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=52.067 scb=0.0373106 \
        scc=0.00610613 m=(1)
C1 (D VSS) capacitor c=5.02915e-17
C2 (CK VSS) capacitor c=2.96179e-17
C3 (Q VSS) capacitor c=6.29335e-17
C4 (VDD VSS) capacitor c=2.36246e-16
C5 (CKb VSS) capacitor c=5.70905e-17
C6 (CKbb VSS) capacitor c=4.80436e-17
C7 (n21 VSS) capacitor c=7.79438e-19
C8 (n20 VSS) capacitor c=4.08417e-17
C9 (net192 VSS) capacitor c=4.92035e-18
C10 (mout VSS) capacitor c=8.46045e-17
C11 (n30 VSS) capacitor c=2.54759e-17
C12 (net172 VSS) capacitor c=1.57933e-18
C13 (qbint VSS) capacitor c=1.69197e-16
C14 (n22 VSS) capacitor c=8.34168e-18
C15 (net147 VSS) capacitor c=3.32808e-18
C16 (net123 VSS) capacitor c=2.18543e-18
C17 (\3\:n30 VSS) capacitor c=5.27969e-17
C18 (\11\:qbint VSS) capacitor c=6.4048e-17
C19 (\4\:CKbb VSS) capacitor c=7.75309e-17
C20 (\8\:CKb VSS) capacitor c=2.72539e-17
C21 (\6\:CKb VSS) capacitor c=5.61819e-17
C22 (\3\:CKbb VSS) capacitor c=2.36264e-17
C23 (\3\:D VSS) capacitor c=5.08739e-17
C24 (\1\:CK VSS) capacitor c=2.42468e-17
C25 (\7\:qbint VSS) capacitor c=5.99447e-17
C26 (\10\:CKb VSS) capacitor c=6.6668e-17
C27 (\6\:CKbb VSS) capacitor c=3.96387e-17
C28 (\3\:n20 VSS) capacitor c=3.39124e-17
C29 (\3\:mout VSS) capacitor c=2.93556e-17
C30 (\4\:CKb VSS) capacitor c=5.10991e-17
C31 (\1\:D VSS) capacitor c=5.0887e-17
C32 (\2\:CKb VSS) capacitor c=3.38605e-17
C33 (\4\:CK VSS) capacitor c=2.06026e-17
C34 (\2\:n30 VSS) capacitor c=4.5845e-17
C35 (\11\:CKb VSS) capacitor c=4.76364e-17
C36 (\5\:CKbb VSS) capacitor c=4.88997e-17
C37 (\9\:CKb VSS) capacitor c=2.71572e-17
C38 (\2\:n20 VSS) capacitor c=3.73392e-17
C39 (\2\:mout VSS) capacitor c=5.35519e-17
C40 (\7\:CKb VSS) capacitor c=3.72744e-17
C41 (\2\:CKbb VSS) capacitor c=4.40002e-17
C42 (\5\:CKb VSS) capacitor c=3.97764e-17
C43 (\2\:D VSS) capacitor c=5.96396e-17
C44 (\3\:CKb VSS) capacitor c=1.83321e-17
C45 (\3\:CK VSS) capacitor c=1.0418e-17
C46 (\16\:qbint VSS) capacitor c=3.48892e-17
C47 (\3\:Q VSS) capacitor c=5.68656e-17
C48 (\4\:n30 VSS) capacitor c=1.14074e-16
C49 (\8\:mout VSS) capacitor c=6.99946e-17
C50 (\10\:VDD VSS) capacitor c=3.51941e-17
C51 (\5\:n20 VSS) capacitor c=1.28395e-16
C52 (\13\:VDD VSS) capacitor c=3.10584e-17
C53 (\13\:CKbb VSS) capacitor c=2.36072e-17
C54 (\22\:CKb VSS) capacitor c=5.98417e-17
C55 (\17\:VDD VSS) capacitor c=3.74815e-17
C56 (\1\:VDD VSS) capacitor c=1.01188e-16
C57 (\12\:qbint VSS) capacitor c=3.58468e-17
C58 (\1\:Q VSS) capacitor c=6.52721e-17
C59 (\7\:n30 VSS) capacitor c=3.92707e-17
C60 (\4\:mout VSS) capacitor c=5.47304e-17
C61 (\7\:n20 VSS) capacitor c=9.77041e-17
C62 (\10\:CKbb VSS) capacitor c=8.67501e-17
C63 (\17\:CKb VSS) capacitor c=6.37504e-17
C64 (\2\:CK VSS) capacitor c=9.33209e-18
C65 (\6\:qbint VSS) capacitor c=4.42445e-17
C66 (\5\:CK VSS) capacitor c=6.14001e-17
C67 (\4\:D VSS) capacitor c=7.6982e-17
C68 (\4\:n20 VSS) capacitor c=7.55755e-17
C69 (\6\:mout VSS) capacitor c=6.60463e-17
C70 (\7\:mout VSS) capacitor c=5.32682e-17
C71 (\7\:CKbb VSS) capacitor c=1.68682e-16
C72 (\8\:CKbb VSS) capacitor c=1.7531e-16
C73 (\9\:CKbb VSS) capacitor c=1.03184e-16
C74 (\12\:CKbb VSS) capacitor c=2.59701e-17
C75 (\12\:CKb VSS) capacitor c=5.35429e-17
C76 (\13\:CKb VSS) capacitor c=1.14281e-16
C77 (\14\:CKb VSS) capacitor c=2.13131e-16
C78 (\15\:CKb VSS) capacitor c=1.16725e-16
C79 (\16\:CKb VSS) capacitor c=9.3373e-17
C80 (\19\:CKb VSS) capacitor c=4.20972e-17
C81 (\20\:CKb VSS) capacitor c=4.99381e-17
C82 (\21\:CKb VSS) capacitor c=3.92307e-17
C83 (\6\:n30 VSS) capacitor c=1.46981e-16
C84 (\9\:n30 VSS) capacitor c=1.42544e-16
C85 (\14\:qbint VSS) capacitor c=3.95195e-17
C86 (\15\:qbint VSS) capacitor c=4.29206e-17
C87 (\3\:VDD VSS) capacitor c=1.75807e-16
C88 (\12\:VDD VSS) capacitor c=2.20174e-17
C89 (\16\:VDD VSS) capacitor c=4.54883e-18
Rk2 (D \4\:D) resistor r=0.05798 c=0
Rk32 (\1\:VSS \6\:VSS) resistor r=0.2832 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.2882 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.213 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.1879 c=0
Rk36 (\9\:VSS \10\:VSS) resistor r=0.213 c=0
Rk38 (\11\:VSS VSS) resistor r=0.07479 c=0
Rk37 (\10\:VSS \11\:VSS) resistor r=0.1754 c=0
Rk41 (\7\:VSS \16\:VSS) resistor r=0.3346 c=0
Rk42 (\9\:VSS \18\:VSS) resistor r=0.3342 c=0
Rk43 (\11\:VSS \20\:VSS) resistor r=0.07393 c=0
Rk1 (\5\:CK CK) resistor r=0.1128 c=0
Rk22 (\2\:Q Q) resistor r=0.3653 c=0
Rk23 (Q \4\:Q) resistor r=0.1634 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.04244 c=0
Rk46 (\3\:VDD \5\:VDD) resistor r=0.554 c=0
Rk49 (\5\:VDD \11\:VDD) resistor r=0.07147 c=0
Rk50 (\5\:VDD \12\:VDD) resistor r=0.5828 c=0
Rk51 (\12\:VDD \14\:VDD) resistor r=0.1842 c=0
Rk52 (\12\:VDD \15\:VDD) resistor r=0.1703 c=0
Rk55 (\16\:VDD VDD) resistor r=0.05473 c=0
Rk53 (\15\:VDD \16\:VDD) resistor r=0.1453 c=0
Rk54 (\16\:VDD \18\:VDD) resistor r=0.4181 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.2579 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.9845 c=0
Rk15 (\14\:CKb \15\:CKb) resistor r=0.688 c=0
Rk16 (\15\:CKb \16\:CKb) resistor r=0.4308 c=0
Rk17 (\16\:CKb \18\:CKb) resistor r=0.3377 c=0
Rk18 (\13\:CKb \19\:CKb) resistor r=0.1497 c=0
Rk19 (\14\:CKb \20\:CKb) resistor r=0.2518 c=0
Rk20 (\15\:CKb \21\:CKb) resistor r=0.1462 c=0
Rk21 (\18\:CKb \23\:CKb) resistor r=0.2859 c=0
Rk8 (\7\:CKbb \8\:CKbb) resistor r=1.2992 c=0
Rk9 (\8\:CKbb \9\:CKbb) resistor r=0.4755 c=0
Rk10 (\9\:CKbb \11\:CKbb) resistor r=0.4315 c=0
Rk11 (\8\:CKbb \12\:CKbb) resistor r=0.1348 c=0
Rk12 (\9\:CKbb \14\:CKbb) resistor r=0.05277 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.5132 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.549 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.1928 c=0
Rk6 (\6\:mout \7\:mout) resistor r=0.2403 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.2949 c=0
Rk24 (\5\:n30 \6\:n30) resistor r=0.5981 c=0
Rk25 (\6\:n30 \8\:n30) resistor r=0.2352 c=0
Rk26 (\6\:n30 \9\:n30) resistor r=0.9167 c=0
Rk27 (\13\:qbint \14\:qbint) resistor r=0.3349 c=0
Rk28 (\14\:qbint \15\:qbint) resistor r=0.1763 c=0
Rk29 (\14\:qbint \17\:qbint) resistor r=0.1769 c=0
Rl7 (\2\:D \3\:D) resistor r=110.307 c=0
Rl6 (\1\:D \2\:D) resistor r=66.7194 c=0
Rl1 (\1\:CK \2\:CK) resistor r=49.7141 c=0
Rl3 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl2 (\2\:CK \3\:CK) resistor r=1.2666 c=0
Rl4 (CKb \2\:CKb) resistor r=226.923 c=0
Rl19 (\10\:CKb \11\:CKb) resistor r=53.079 c=0
Rl16 (\8\:CKb \9\:CKb) resistor r=35.7713 c=0
Rl11 (\6\:CKb \7\:CKb) resistor r=48.7687 c=0
Rl8 (\4\:CKb \5\:CKb) resistor r=74.2328 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl17 (\4\:CKbb \5\:CKbb) resistor r=77.4625 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=126.156 c=0
Rl9 (CKbb \2\:CKbb) resistor r=161.516 c=0
Rl10 (\2\:CKbb \3\:CKbb) resistor r=24.7951 c=0
Rl14 (n20 \2\:n20) resistor r=37.2302 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=127.615 c=0
Rl12 (mout \2\:mout) resistor r=108.848 c=0
Rl13 (\2\:mout \3\:mout) resistor r=68.3618 c=0
Rl30 (n30 \2\:n30) resistor r=34.2718 c=0
Rl31 (\2\:n30 \3\:n30) resistor r=109.066 c=0
Rl24 (\6\:qbint qbint) resistor r=112.377 c=0
Rl29 (\6\:qbint \11\:qbint) resistor r=78.0797 c=0
Rl25 (\6\:qbint \7\:qbint) resistor r=108.849 c=0
Rz10 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz5 (\2\:Q \1\:Q) resistor r=75 c=0
Rz16 (VDD \1\:VDD) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz14 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz15 (\15\:VDD \1\:VDD) resistor r=25 c=0
Rz4 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz7 (\13\:qbint \12\:qbint) resistor r=75 c=0
Ry12 (VSS \3\:VSS) resistor r=62 c=0
Ry8 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry9 (\6\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry10 (\8\:VSS \3\:VSS) resistor r=15.5 c=0
Ry11 (\10\:VSS \3\:VSS) resistor r=15.5 c=0
Ry5 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry15 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry4 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry3 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\4\:n30 \5\:n30) resistor r=31 c=0
Ry7 (\17\:qbint \16\:qbint) resistor r=31 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx9 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \20\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \21\:CKb) resistor r=45 c=0
Rx5 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx6 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx12 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx13 (\15\:qbint qbint) resistor r=45 c=0
mn20 (\17\:CKb \4\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\10\:CKbb \2\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.407e-14 ad=2.32e-14 ps=1.04e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \1\:D \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=1.435e-14 ps=1.04e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.0878e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn26 (\7\:n20 \4\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=4.51e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2378e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn36 (\7\:n20 CKbb net192 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=4.51e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8878e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net192 \3\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=4.715e-14 ps=9.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06378e-06 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (\4\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.638e-14 ad=9.533e-14 ps=9.6e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38378e-06 sb=1.835e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\4\:mout \6\:CKbb \7\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=9.533e-14 ps=7.3e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.89024e-06 sb=1.325e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (\7\:n30 \10\:CKb net172 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95024e-06 sb=1.12e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net172 \7\:qbint \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.23e-14 ps=1.13e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98098e-06 sb=1.015e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn45 (\12\:qbint n30 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.777e-14 ad=2.87e-14 ps=1.03e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn55 (\1\:Q qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=4.68e-14 ps=1.08e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=5.93077e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp21 (\13\:CKbb CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=3.01e-14 ps=1.08e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.8597 scb=0.00777428 \
        scc=8.41005e-05 m=(1)
mp25 (n22 \3\:D \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=8.06e-14 ps=1.08e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.18468e-07 sb=2e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.023e-13 ps=1.14e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.23468e-07 sb=2e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp36 (\5\:n20 \6\:CKb net147 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.17e-14 ad=1.023e-13 ps=7.6e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.98468e-07 sb=1.96387e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp35 (net147 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=2.17e-14 ps=1.39e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11347e-06 sb=1.91935e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp30 (\8\:mout n20 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=8.835e-14 ps=1.39e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37847e-06 sb=1.65435e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp40 (\8\:mout \8\:CKb \4\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=8.835e-14 ps=1.3e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.70847e-06 sb=1.32435e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp51 (\4\:n30 \4\:CKbb net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=1.054e-13 ps=7.4e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96169e-06 sb=9.39355e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp50 (net123 \11\:qbint \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.49e-14 ad=1.86e-14 ps=1.32e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99387e-06 sb=8.34355e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp55 (\3\:Q qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.25e-14 ad=6.24e-14 ps=1.24e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61846e-06 sb=5.31795e-07 sd=160n sca=12.0426 \
        scb=0.00999671 scc=0.000274125 m=(2)
mp45 (\16\:qbint \3\:n30 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.01e-14 ad=4.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63355e-06 sb=1.4e-07 sd=160n sca=16.7687 \
        scb=0.0168289 scc=0.000420091 m=(1)
ends DFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:12:23 2012 )
// Library name: gsclib045
// Cell name: DFFHQX4
// View name: extracted

simulator lang=spectre

subckt DFFHQX4 CK D Q VDD VSS
mp20 (\20\:CKb \1\:CK \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.86465e-06 sd=160n sca=34.311 \
        scb=0.0304179 scc=0.00380485 m=(1)
C1 (D VSS) capacitor c=1.59268e-16
C2 (Q VSS) capacitor c=2.82363e-16
C3 (CK VSS) capacitor c=3.6117e-17
C4 (VDD VSS) capacitor c=2.02496e-16
C5 (CKb VSS) capacitor c=5.13504e-17
C6 (qbint VSS) capacitor c=2.52666e-16
C7 (n30 VSS) capacitor c=1.47416e-16
C8 (net172 VSS) capacitor c=2.72667e-18
C9 (mout VSS) capacitor c=2.76671e-17
C10 (CKbb VSS) capacitor c=7.36208e-17
C11 (n20 VSS) capacitor c=1.83804e-17
C12 (net192 VSS) capacitor c=9.46485e-18
C13 (n21 VSS) capacitor c=3.62743e-19
C14 (net147 VSS) capacitor c=6.38904e-18
C15 (n22 VSS) capacitor c=9.53459e-18
C16 (\10\:CKb VSS) capacitor c=4.51068e-17
C17 (\3\:D VSS) capacitor c=4.67259e-17
C18 (\5\:CKbb VSS) capacitor c=2.67384e-17
C19 (\4\:CKb VSS) capacitor c=3.95498e-17
C20 (\3\:mout VSS) capacitor c=6.99881e-17
C21 (\4\:n20 VSS) capacitor c=3.31716e-17
C22 (\17\:qbint VSS) capacitor c=7.37326e-17
C23 (\1\:CK VSS) capacitor c=3.29225e-17
C24 (\8\:CKb VSS) capacitor c=3.11288e-17
C25 (\1\:D VSS) capacitor c=7.52873e-17
C26 (\6\:CKb VSS) capacitor c=6.38892e-17
C27 (\7\:CKbb VSS) capacitor c=3.77316e-17
C28 (\3\:n20 VSS) capacitor c=4.40881e-17
C29 (\3\:CKbb VSS) capacitor c=3.015e-17
C30 (\3\:CKb VSS) capacitor c=2.61153e-17
C31 (\15\:qbint VSS) capacitor c=3.54822e-17
C32 (\3\:CK VSS) capacitor c=2.93943e-17
C33 (\9\:CKb VSS) capacitor c=3.65132e-17
C34 (\2\:D VSS) capacitor c=5.93571e-17
C35 (\7\:CKb VSS) capacitor c=3.80748e-17
C36 (\6\:CKbb VSS) capacitor c=3.20261e-17
C37 (\5\:CKb VSS) capacitor c=3.33944e-17
C38 (\2\:mout VSS) capacitor c=4.83729e-17
C39 (\4\:CKbb VSS) capacitor c=2.65612e-17
C40 (\2\:CKb VSS) capacitor c=4.76431e-17
C41 (\2\:CKbb VSS) capacitor c=3.41563e-17
C42 (\16\:qbint VSS) capacitor c=5.13744e-17
C43 (\2\:CK VSS) capacitor c=3.19829e-17
C44 (\10\:CKbb VSS) capacitor c=9.90032e-17
C45 (\1\:VDD VSS) capacitor c=3.39202e-17
C46 (\7\:n20 VSS) capacitor c=1.26864e-16
C47 (\6\:VDD VSS) capacitor c=2.98802e-17
C48 (\8\:mout VSS) capacitor c=6.88912e-17
C49 (\12\:n30 VSS) capacitor c=4.81366e-17
C50 (\24\:qbint VSS) capacitor c=4.05808e-17
C51 (\20\:CKb VSS) capacitor c=5.78509e-17
C52 (\3\:VDD VSS) capacitor c=7.49987e-17
C53 (\8\:CKbb VSS) capacitor c=6.02685e-17
C54 (\5\:n20 VSS) capacitor c=9.77924e-17
C55 (\6\:mout VSS) capacitor c=3.89531e-17
C56 (\8\:n30 VSS) capacitor c=6.75314e-17
C57 (\22\:qbint VSS) capacitor c=4.24151e-17
C58 (\15\:CKb VSS) capacitor c=2.81867e-16
C59 (\2\:n20 VSS) capacitor c=2.30724e-17
C60 (\4\:CK VSS) capacitor c=8.01765e-17
C61 (\18\:qbint VSS) capacitor c=7.22913e-17
C62 (\19\:qbint VSS) capacitor c=8.24964e-17
C63 (\21\:qbint VSS) capacitor c=7.24642e-17
C64 (\10\:n30 VSS) capacitor c=7.57793e-17
C65 (\11\:n30 VSS) capacitor c=6.79831e-17
C66 (\4\:mout VSS) capacitor c=6.1891e-17
C67 (\5\:mout VSS) capacitor c=5.01257e-17
C68 (\9\:n20 VSS) capacitor c=8.31055e-17
C69 (\11\:CKb VSS) capacitor c=4.64218e-17
C70 (\12\:CKb VSS) capacitor c=9.8328e-17
C71 (\13\:CKb VSS) capacitor c=2.26576e-16
C72 (\14\:CKb VSS) capacitor c=3.88087e-16
C73 (\17\:CKb VSS) capacitor c=2.64058e-17
C74 (\18\:CKb VSS) capacitor c=5.68987e-17
C75 (\19\:CKb VSS) capacitor c=3.59035e-17
C76 (\12\:CKbb VSS) capacitor c=1.38668e-16
C77 (\13\:CKbb VSS) capacitor c=1.43385e-16
C78 (\14\:CKbb VSS) capacitor c=5.30989e-17
C79 (\15\:CKbb VSS) capacitor c=3.54618e-17
C80 (\16\:CKbb VSS) capacitor c=5.46764e-17
C81 (\5\:VDD VSS) capacitor c=2.67571e-17
C82 (\9\:VDD VSS) capacitor c=3.24911e-16
Rk38 (\2\:VSS \3\:VSS) resistor r=0.1177 c=0
Rk39 (\3\:VSS \4\:VSS) resistor r=0.233 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.2455 c=0
Rk41 (\5\:VSS \6\:VSS) resistor r=0.3057 c=0
Rk48 (\7\:VSS VSS) resistor r=0.134 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.2932 c=0
Rk49 (\3\:VSS \14\:VSS) resistor r=0.3285 c=0
Rk50 (\5\:VSS \16\:VSS) resistor r=0.2243 c=0
Rk3 (\4\:CK CK) resistor r=0.03301 c=0
Rk55 (\2\:VDD \4\:VDD) resistor r=0.357 c=0
Rk56 (\4\:VDD \5\:VDD) resistor r=0.5094 c=0
Rk57 (\5\:VDD \7\:VDD) resistor r=0.2039 c=0
Rk58 (\5\:VDD \8\:VDD) resistor r=0.3433 c=0
Rk68 (\9\:VDD VDD) resistor r=0.2027 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.2656 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2254 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=0.7773 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=1.0373 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=2.2675 c=0
Rk27 (\12\:CKb \17\:CKb) resistor r=0.06418 c=0
Rk28 (\13\:CKb \18\:CKb) resistor r=0.2445 c=0
Rk29 (\14\:CKb \19\:CKb) resistor r=0.1092 c=0
Rk30 (\16\:CKb \21\:CKb) resistor r=0.4379 c=0
Rk10 (\18\:qbint \19\:qbint) resistor r=0.3362 c=0
Rk11 (\19\:qbint \20\:qbint) resistor r=0.04851 c=0
Rk12 (\20\:qbint \21\:qbint) resistor r=0.3881 c=0
Rk13 (\19\:qbint \23\:qbint) resistor r=0.1149 c=0
Rk14 (\20\:qbint \25\:qbint) resistor r=0.2614 c=0
Rk15 (\9\:n30 \10\:n30) resistor r=0.3553 c=0
Rk16 (\10\:n30 \11\:n30) resistor r=0.37 c=0
Rk17 (\10\:n30 \13\:n30) resistor r=0.1513 c=0
Rk18 (\4\:mout \5\:mout) resistor r=0.2631 c=0
Rk19 (\5\:mout \7\:mout) resistor r=0.1203 c=0
Rk20 (\5\:mout \9\:mout) resistor r=0.2341 c=0
Rk32 (\9\:CKbb \11\:CKbb) resistor r=0.5732 c=0
Rk33 (\11\:CKbb \12\:CKbb) resistor r=0.4067 c=0
Rk34 (\12\:CKbb \13\:CKbb) resistor r=0.9967 c=0
Rk35 (\13\:CKbb \14\:CKbb) resistor r=0.4026 c=0
Rk36 (\12\:CKbb \15\:CKbb) resistor r=0.1203 c=0
Rk37 (\13\:CKbb \16\:CKbb) resistor r=0.2797 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.5638 c=0
Rk22 (\8\:n20 \9\:n20) resistor r=0.486 c=0
Rl38 (\2\:D \3\:D) resistor r=67.227 c=0
Rl37 (\1\:D \2\:D) resistor r=88.3096 c=0
Rl1 (\1\:CK \2\:CK) resistor r=43.3029 c=0
Rl2 (\2\:CK \3\:CK) resistor r=36.3335 c=0
Rl40 (\9\:CKb \10\:CKb) resistor r=93.4636 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=26.1559 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=30.0021 c=0
Rl25 (CKb \2\:CKb) resistor r=122.631 c=0
Rl26 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl23 (\16\:qbint \17\:qbint) resistor r=89.9037 c=0
Rl22 (\16\:qbint \15\:qbint) resistor r=42.0992 c=0
Rl31 (mout \2\:mout) resistor r=43.5097 c=0
Rl32 (\2\:mout \3\:mout) resistor r=88.2566 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl35 (\6\:CKbb \7\:CKbb) resistor r=95.3867 c=0
Rl27 (\3\:CKbb \4\:CKbb) resistor r=70.3867 c=0
Rl24 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl28 (n20 \2\:n20) resistor r=2.7713 c=0
Rl30 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl29 (\2\:n20 \3\:n20) resistor r=105.483 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=15 c=0
Rz16 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\23\:qbint \22\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry10 (\4\:VSS \1\:VSS) resistor r=12.4 c=0
Ry11 (\6\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry12 (\7\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry14 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry7 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\25\:qbint \24\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=31 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Rx11 (\2\:D D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx7 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (\7\:CKb \17\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \18\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx6 (n20 \9\:n20) resistor r=45 c=0
mn20 (\15\:CKb \3\:CK \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=2.755e-14 ps=1.65e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.46207e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.779e-14 ad=4.55e-14 ps=1.5875e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.72885e-07 sb=1.63231e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45_1__rcx (\22\:qbint n30 \7\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.42e-14 ad=4.51e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27817e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(2)
mn50 (net172 \15\:qbint \7\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.973e-14 ad=2.768e-14 ps=1.14e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82183e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn51 (\8\:n30 \3\:CKb net172 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=6.867e-14 ps=6.8e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.89146e-06 sb=1.96049e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn40 (\6\:mout \3\:CKbb \8\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.867e-14 ad=4.715e-14 ps=1.08e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9378e-06 sb=1.65829e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn30 (\6\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.238e-14 ad=4.715e-14 ps=1.17e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97134e-06 sb=1.38329e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn36 (\5\:n20 \7\:CKbb net192 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=4.305e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.33293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn35 (net192 mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=7.073e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.02329e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.78293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn25 (n21 \1\:D \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.73293e-07 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(1)
mn21 (\8\:CKbb \8\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.08e-14 ad=7.02e-14 ps=1.2325e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.75128e-06 sd=160n sca=31.7909 \
        scb=0.0210107 scc=0.00336206 m=(4)
mp45_1__rcx (\24\:qbint n30 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.076e-13 ad=6.82e-14 ps=1.36e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37524e-06 sb=2e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(2)
mp50 (net123 \17\:qbint \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.86e-14 ps=1.15e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=2e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\8\:mout \4\:n20 \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.612e-13 ps=1.38e-06 pd=1.66e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.34266e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp26 (\7\:n20 \5\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=8.06e-14 ps=1.04e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.92661e-07 sd=160n sca=19.2885 \
        scb=0.0175179 scc=0.00172295 m=(1)
mp51 (\12\:n30 CKbb net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96573e-06 sb=1.97395e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:mout CKb \12\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.612e-13 ps=9.4e-07 pd=1.66e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.90766e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net147 \3\:mout \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.185e-14 ps=1.38e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.07766e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\7\:n20 \4\:CKb net147 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=8.06e-14 ps=8.9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.97661e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (n22 \3\:D \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=6.51e-14 ps=1.1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.37661e-07 sd=160n sca=20.2256 \
        scb=0.0180795 scc=0.00172352 m=(1)
mp21 (\10\:CKbb \10\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=27.6463 scb=0.0278146 \
        scc=0.00252566 m=(1)
ends DFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:13:00 2012 )
// Library name: gsclib045
// Cell name: DFFHQX8
// View name: extracted

simulator lang=spectre

subckt DFFHQX8 CK D Q VDD VSS
mp55_1__rcx (Q qbint \7\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.91719e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (CK VSS) capacitor c=4.34448e-17
C2 (VDD VSS) capacitor c=2.42527e-16
C3 (D VSS) capacitor c=5.81711e-17
C4 (Q VSS) capacitor c=5.07234e-16
C5 (qbint VSS) capacitor c=3.54026e-16
C6 (n30 VSS) capacitor c=2.19225e-16
C7 (CKb VSS) capacitor c=7.12859e-17
C8 (CKbb VSS) capacitor c=4.45074e-17
C9 (net172 VSS) capacitor c=2.18678e-18
C10 (mout VSS) capacitor c=9.82138e-17
C11 (n20 VSS) capacitor c=2.05409e-17
C12 (net192 VSS) capacitor c=3.2229e-18
C13 (net123 VSS) capacitor c=1.92235e-18
C14 (net147 VSS) capacitor c=1.1106e-18
C15 (n22 VSS) capacitor c=8.95344e-18
C16 (\3\:CK VSS) capacitor c=3.30693e-17
C17 (\3\:D VSS) capacitor c=4.6698e-17
C18 (\5\:CKbb VSS) capacitor c=7.29127e-17
C19 (\8\:CKb VSS) capacitor c=7.01337e-17
C20 (\4\:n20 VSS) capacitor c=3.48655e-17
C21 (\7\:CKb VSS) capacitor c=2.44828e-17
C22 (\26\:qbint VSS) capacitor c=6.45216e-17
C23 (\2\:CKb VSS) capacitor c=4.32005e-17
C24 (\1\:CK VSS) capacitor c=2.77753e-17
C25 (\1\:D VSS) capacitor c=6.8468e-17
C26 (\10\:CKb VSS) capacitor c=6.14882e-17
C27 (\7\:CKbb VSS) capacitor c=3.06347e-17
C28 (\3\:mout VSS) capacitor c=4.1145e-17
C29 (\3\:n20 VSS) capacitor c=4.57521e-17
C30 (\3\:CKbb VSS) capacitor c=3.0189e-17
C31 (\6\:CKb VSS) capacitor c=6.37114e-17
C32 (\23\:qbint VSS) capacitor c=4.67044e-17
C33 (\2\:CK VSS) capacitor c=3.1676e-17
C34 (\2\:D VSS) capacitor c=5.05252e-17
C35 (\11\:CKb VSS) capacitor c=3.89668e-17
C36 (\6\:CKbb VSS) capacitor c=5.37323e-17
C37 (\9\:CKb VSS) capacitor c=3.18417e-17
C38 (\2\:mout VSS) capacitor c=5.30448e-17
C39 (\4\:CKb VSS) capacitor c=2.6147e-17
C40 (\4\:CKbb VSS) capacitor c=4.10243e-17
C41 (\2\:CKbb VSS) capacitor c=3.39631e-17
C42 (\25\:qbint VSS) capacitor c=2.42203e-17
C43 (\3\:CKb VSS) capacitor c=2.61802e-17
C44 (\11\:qbint VSS) capacitor c=2.32764e-17
C45 (\19\:CKb VSS) capacitor c=5.90025e-17
C46 (\13\:VDD VSS) capacitor c=6.03497e-17
C47 (\9\:n20 VSS) capacitor c=6.38984e-17
C48 (\15\:VDD VSS) capacitor c=3.96676e-17
C49 (\8\:mout VSS) capacitor c=7.43871e-17
C50 (\12\:n30 VSS) capacitor c=1.83532e-16
C51 (\17\:VDD VSS) capacitor c=2.14852e-17
C52 (\15\:CKbb VSS) capacitor c=8.77532e-17
C53 (\1\:VDD VSS) capacitor c=5.54733e-17
C54 (\12\:CKb VSS) capacitor c=7.052e-17
C55 (\5\:n20 VSS) capacitor c=6.79326e-17
C56 (\6\:mout VSS) capacitor c=5.53886e-17
C57 (\14\:n30 VSS) capacitor c=1.04977e-16
C58 (\13\:CKbb VSS) capacitor c=6.14634e-17
C59 (\24\:qbint VSS) capacitor c=3.87674e-17
C60 (\5\:CKb VSS) capacitor c=4.3095e-17
C61 (\2\:n20 VSS) capacitor c=2.53303e-17
C62 (\27\:qbint VSS) capacitor c=8.01985e-17
C63 (\28\:qbint VSS) capacitor c=2.60882e-16
C64 (\31\:qbint VSS) capacitor c=4.17642e-17
C65 (\11\:n30 VSS) capacitor c=1.35057e-16
C66 (\4\:mout VSS) capacitor c=5.58236e-17
C67 (\5\:mout VSS) capacitor c=7.84481e-17
C68 (\8\:CKbb VSS) capacitor c=1.24875e-16
C69 (\9\:CKbb VSS) capacitor c=1.49351e-16
C70 (\10\:CKbb VSS) capacitor c=1.06525e-16
C71 (\11\:CKbb VSS) capacitor c=6.73395e-17
C72 (\12\:CKbb VSS) capacitor c=6.20506e-17
C73 (\7\:n20 VSS) capacitor c=6.97582e-17
C74 (\8\:n20 VSS) capacitor c=4.41268e-17
C75 (\4\:D VSS) capacitor c=6.67312e-17
C76 (\5\:CK VSS) capacitor c=2.58876e-17
C77 (\14\:CKb VSS) capacitor c=1.15723e-16
C78 (\15\:CKb VSS) capacitor c=1.2446e-16
C79 (\16\:CKb VSS) capacitor c=1.11927e-16
C80 (\17\:CKb VSS) capacitor c=1.26386e-16
C81 (\18\:CKb VSS) capacitor c=1.15995e-16
C82 (\21\:CKb VSS) capacitor c=5.25132e-17
C83 (\3\:VDD VSS) capacitor c=1.88689e-17
C84 (\4\:VDD VSS) capacitor c=2.18695e-17
C85 (\6\:VDD VSS) capacitor c=3.57926e-17
C86 (\7\:VDD VSS) capacitor c=4.64409e-16
Rk34 (\4\:CK \5\:CK) resistor r=0.003538 c=0
Rk35 (\6\:CK CK) resistor r=0.003656 c=0
Rk36 (\5\:CK \6\:CK) resistor r=0.04834 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.1828 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.4384 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.1302 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.4411 c=0
Rk54 (\7\:VSS VSS) resistor r=0.1074 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.3832 c=0
Rk55 (\3\:VSS \14\:VSS) resistor r=0.2139 c=0
Rk56 (\4\:VSS \16\:VSS) resistor r=0.1889 c=0
Rk57 (\6\:VSS \18\:VSS) resistor r=0.2148 c=0
Rk63 (\2\:VDD \3\:VDD) resistor r=0.2004 c=0
Rk64 (\3\:VDD \4\:VDD) resistor r=0.3707 c=0
Rk65 (\4\:VDD \5\:VDD) resistor r=0.1803 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=0.4126 c=0
Rk73 (\7\:VDD VDD) resistor r=0.1074 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.3597 c=0
Rk74 (\3\:VDD \14\:VDD) resistor r=0.3079 c=0
Rk75 (\4\:VDD \16\:VDD) resistor r=0.1859 c=0
Rk76 (\6\:VDD \18\:VDD) resistor r=0.0433 c=0
Rk33 (D \4\:D) resistor r=0.1009 c=0
Rk11 (\27\:qbint \28\:qbint) resistor r=0.4437 c=0
Rk14 (\28\:qbint \31\:qbint) resistor r=0.1477 c=0
Rk19 (\11\:n30 \13\:n30) resistor r=1.0951 c=0
Rk20 (\13\:n30 \15\:n30) resistor r=0.4999 c=0
Rk37 (\13\:CKb \14\:CKb) resistor r=0.6524 c=0
Rk38 (\14\:CKb \15\:CKb) resistor r=0.2949 c=0
Rk39 (\15\:CKb \16\:CKb) resistor r=0.4758 c=0
Rk40 (\16\:CKb \17\:CKb) resistor r=0.5591 c=0
Rk41 (\17\:CKb \18\:CKb) resistor r=0.7952 c=0
Rk42 (\15\:CKb \20\:CKb) resistor r=0.4751 c=0
Rk43 (\17\:CKb \21\:CKb) resistor r=0.3051 c=0
Rk24 (\8\:CKbb \9\:CKbb) resistor r=0.8612 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.4501 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.2699 c=0
Rk27 (\9\:CKbb \12\:CKbb) resistor r=0.2854 c=0
Rk28 (\10\:CKbb \14\:CKbb) resistor r=0.3471 c=0
Rk29 (\11\:CKbb \16\:CKbb) resistor r=0.4396 c=0
Rk21 (\4\:mout \5\:mout) resistor r=0.2777 c=0
Rk22 (\5\:mout \7\:mout) resistor r=0.1804 c=0
Rk23 (\5\:mout \9\:mout) resistor r=0.2844 c=0
Rk30 (\6\:n20 \7\:n20) resistor r=0.4097 c=0
Rk31 (\7\:n20 \8\:n20) resistor r=0.2942 c=0
Rk32 (\7\:n20 \10\:n20) resistor r=0.1572 c=0
Rl53 (\2\:CK \3\:CK) resistor r=83.7912 c=0
Rl52 (\1\:CK \2\:CK) resistor r=101.923 c=0
Rl51 (\2\:D \3\:D) resistor r=65.3618 c=0
Rl50 (\1\:D \2\:D) resistor r=117.103 c=0
Rl10 (qbint \11\:qbint) resistor r=4.8851 c=0
Rl35 (\24\:qbint \26\:qbint) resistor r=101.385 c=0
Rl33 (\24\:qbint \23\:qbint) resistor r=62.9711 c=0
Rl34 (\24\:qbint \25\:qbint) resistor r=4.5402 c=0
Rl31 (CKb \2\:CKb) resistor r=197.643 c=0
Rl49 (\10\:CKb \11\:CKb) resistor r=52.6149 c=0
Rl46 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl32 (\2\:CKb \3\:CKb) resistor r=50.6918 c=0
Rl40 (\5\:CKb \7\:CKb) resistor r=47.4388 c=0
Rl39 (\5\:CKb \6\:CKb) resistor r=181.166 c=0
Rl38 (\4\:CKb \5\:CKb) resistor r=89.2399 c=0
Rl47 (\5\:CKbb \6\:CKbb) resistor r=156.882 c=0
Rl48 (\6\:CKbb \7\:CKbb) resistor r=30.0511 c=0
Rl37 (\3\:CKbb \4\:CKbb) resistor r=52.6149 c=0
Rl36 (CKbb \2\:CKbb) resistor r=35.3072 c=0
Rl44 (mout \2\:mout) resistor r=116.483 c=0
Rl45 (\2\:mout \3\:mout) resistor r=37.6365 c=0
Rl41 (n20 \2\:n20) resistor r=3.1216 c=0
Rl43 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=139.264 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz21 (\5\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz22 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\15\:n30 \14\:n30) resistor r=75 c=0
Rz11 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz9 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz8 (\6\:mout \7\:mout) resistor r=75 c=0
Rz10 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\13\:n30 \12\:n30) resistor r=31 c=0
Ry11 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry9 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\9\:n20 \10\:n20) resistor r=31 c=0
Rx10 (\2\:CK \4\:CK) resistor r=45 c=0
Rx9 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\27\:qbint \25\:qbint) resistor r=45 c=0
Rx2 (\31\:qbint \11\:qbint) resistor r=45 c=0
Rx3 (\11\:n30 n30) resistor r=45 c=0
Rx11 (\11\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\9\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \21\:CKb) resistor r=45 c=0
Rx5 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx6 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (n20 \8\:n20) resistor r=45 c=0
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90729e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\28\:qbint n30 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.277e-14 ad=3.987e-14 ps=8.6333e-07 pd=8.2667e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(3)
mn21 (\13\:CKbb CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn50 (net172 \23\:qbint \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=2.665e-14 ps=7.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.96488e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\14\:n30 \6\:CKb net172 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=5.433e-14 ps=6.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8122e-07 sb=1.91366e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn26 (\5\:n20 \10\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.638e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94585e-06 sb=5.62195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\6\:mout \3\:CKbb \14\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.432e-14 ad=7.688e-14 ps=9.4e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9122e-07 sb=1.7522e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\6\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.93e-14 ad=7.688e-14 ps=9.2e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21122e-06 sb=1.3322e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net192 \3\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.87e-14 ps=9.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47622e-06 sb=1.0672e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\5\:n20 \7\:CKbb net192 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=5.638e-14 ps=6.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66122e-06 sb=8.82195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (n21 \1\:D \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=1.23e-14 ps=1.25e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97659e-06 sb=4.57195e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn20 (\12\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.69e-14 ad=2.03e-14 ps=1.25e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mp45_1__rcx (\28\:qbint n30 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.583e-14 ad=5.98e-14 ps=1.31667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.1e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp21 (\15\:CKbb \2\:CKb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0425e-13 ad=3.01e-14 ps=1.74e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp50 (net123 \26\:qbint \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.0425e-13 ad=3.565e-14 ps=1.74e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=1.9571e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (\12\:n30 CKbb net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=5.89e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92984e-07 sb=1.90806e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp40 (\8\:mout \7\:CKb \12\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.581e-13 ps=1e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.27984e-07 sb=1.82218e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp30 (\8\:mout \4\:n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=1.581e-13 ps=1.39e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28298e-06 sb=1.26718e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp35 (net147 mout \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=1.86e-14 ps=1.39e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54798e-06 sb=1.00218e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp36 (\9\:n20 \8\:CKb net147 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.27e-14 ps=7.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65298e-06 sb=8.97177e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=5.27e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86798e-06 sb=6.82177e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp25 (n22 \3\:D \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1435e-13 ad=4.34e-14 ps=1.56e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96629e-06 sb=4.97177e-07 sd=160n sca=17.5841 \
        scb=0.016252 scc=0.00137566 m=(1)
mp20 (\19\:CKb \3\:CK \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1435e-13 ad=3.01e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=25.2301 scb=0.0262115 \
        scc=0.00203777 m=(1)
ends DFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:07:00 2012 )
// Library name: gsclib045
// Cell name: DFFNSRX1
// View name: extracted

simulator lang=spectre

subckt DFFNSRX1 CKN D Q QN RN SN VDD VSS
mp57 (\1\:QN qint \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.35064e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (QN VSS) capacitor c=4.05201e-17
C2 (RN VSS) capacitor c=3.37647e-17
C3 (CKN VSS) capacitor c=8.43838e-17
C4 (D VSS) capacitor c=1.16974e-16
C5 (VDD VSS) capacitor c=3.41194e-16
C6 (SN VSS) capacitor c=2.41244e-16
C7 (Q VSS) capacitor c=8.77761e-17
C8 (qint VSS) capacitor c=4.53851e-17
C9 (qbint VSS) capacitor c=5.19693e-17
C10 (RNb VSS) capacitor c=5.81253e-17
C11 (n35 VSS) capacitor c=3.37926e-17
C12 (n42 VSS) capacitor c=6.032e-17
C13 (n40 VSS) capacitor c=6.96667e-17
C14 (CKNbb VSS) capacitor c=3.62271e-17
C15 (mout VSS) capacitor c=5.7097e-17
C16 (CKNb VSS) capacitor c=7.67512e-17
C17 (n25 VSS) capacitor c=1.01681e-16
C18 (n20 VSS) capacitor c=4.44941e-17
C19 (n30 VSS) capacitor c=2.36337e-18
C20 (n21 VSS) capacitor c=1.26516e-20
C21 (n41 VSS) capacitor c=8.82208e-17
C22 (n43 VSS) capacitor c=9.19802e-19
C23 (n26 VSS) capacitor c=4.56963e-18
C24 (n31 VSS) capacitor c=1.09643e-18
C25 (n22 VSS) capacitor c=2.59562e-18
C26 (\1\:CKN VSS) capacitor c=2.37404e-17
C27 (\7\:CKNb VSS) capacitor c=6.15578e-17
C28 (\3\:D VSS) capacitor c=5.90951e-17
C29 (\4\:CKNb VSS) capacitor c=7.70432e-17
C30 (\7\:CKNbb VSS) capacitor c=4.77008e-17
C31 (\4\:SN VSS) capacitor c=5.46709e-17
C32 (\4\:RNb VSS) capacitor c=5.61618e-17
C33 (\3\:CKNbb VSS) capacitor c=3.60505e-17
C34 (\2\:RNb VSS) capacitor c=6.91745e-17
C35 (\8\:qbint VSS) capacitor c=7.72914e-17
C36 (\1\:SN VSS) capacitor c=3.68297e-17
C37 (\1\:RN VSS) capacitor c=4.52546e-17
C38 (\7\:qbint VSS) capacitor c=3.24855e-17
C39 (\3\:CKN VSS) capacitor c=1.98699e-17
C40 (\8\:CKNb VSS) capacitor c=4.4726e-17
C41 (\1\:D VSS) capacitor c=4.41165e-17
C42 (\8\:CKNbb VSS) capacitor c=5.61801e-17
C43 (\5\:CKNb VSS) capacitor c=6.41836e-17
C44 (\4\:mout VSS) capacitor c=4.64528e-17
C45 (\6\:SN VSS) capacitor c=6.30444e-17
C46 (\3\:n20 VSS) capacitor c=3.24375e-17
C47 (\5\:RNb VSS) capacitor c=4.7666e-17
C48 (\2\:CKNb VSS) capacitor c=7.36149e-17
C49 (\9\:qbint VSS) capacitor c=4.96686e-17
C50 (\3\:SN VSS) capacitor c=4.36654e-17
C51 (\3\:n35 VSS) capacitor c=3.77354e-17
C52 (\3\:RN VSS) capacitor c=4.94149e-17
C53 (\6\:qbint VSS) capacitor c=3.47241e-17
C54 (\4\:qbint VSS) capacitor c=2.37027e-17
C55 (\3\:qint VSS) capacitor c=3.67169e-17
C56 (\2\:CKN VSS) capacitor c=2.07305e-17
C57 (\9\:CKNb VSS) capacitor c=1.85645e-17
C58 (\2\:D VSS) capacitor c=6.49813e-17
C59 (\9\:CKNbb VSS) capacitor c=5.35224e-17
C60 (\6\:CKNb VSS) capacitor c=2.15475e-17
C61 (\6\:CKNbb VSS) capacitor c=5.16657e-17
C62 (\3\:mout VSS) capacitor c=1.91683e-17
C63 (\5\:SN VSS) capacitor c=2.82243e-17
C64 (\2\:n20 VSS) capacitor c=3.82016e-17
C65 (\6\:RNb VSS) capacitor c=2.68438e-17
C66 (\5\:CKNbb VSS) capacitor c=3.59652e-17
C67 (\3\:CKNb VSS) capacitor c=2.58149e-17
C68 (\4\:CKNbb VSS) capacitor c=3.66114e-17
C69 (\2\:CKNbb VSS) capacitor c=2.78441e-17
C70 (\3\:RNb VSS) capacitor c=2.82512e-17
C71 (\10\:qbint VSS) capacitor c=2.4275e-17
C72 (\2\:SN VSS) capacitor c=3.36762e-17
C73 (\2\:n35 VSS) capacitor c=2.86284e-17
C74 (\2\:RN VSS) capacitor c=4.309e-17
C75 (\5\:qbint VSS) capacitor c=3.8832e-17
C76 (\2\:qint VSS) capacitor c=2.63215e-17
C77 (\5\:VDD VSS) capacitor c=3.77313e-17
C78 (\10\:CKNb VSS) capacitor c=1.12159e-16
C79 (\12\:CKNbb VSS) capacitor c=2.01218e-17
C80 (\7\:VDD VSS) capacitor c=4.73732e-17
C81 (\8\:n20 VSS) capacitor c=7.36849e-17
C82 (\10\:VDD VSS) capacitor c=1.23002e-17
C83 (\11\:mout VSS) capacitor c=4.34281e-17
C84 (\13\:VDD VSS) capacitor c=3.10836e-17
C85 (\9\:mout VSS) capacitor c=7.44988e-17
C86 (\4\:n35 VSS) capacitor c=4.04616e-17
C87 (\16\:VDD VSS) capacitor c=2.92174e-17
C88 (\3\:n41 VSS) capacitor c=9.55133e-17
C89 (\20\:VDD VSS) capacitor c=1.48325e-17
C90 (\11\:qbint VSS) capacitor c=7.0619e-17
C91 (\9\:RNb VSS) capacitor c=1.31643e-16
C92 (\23\:VDD VSS) capacitor c=3.9142e-17
C93 (\3\:Q VSS) capacitor c=3.96476e-17
C94 (\4\:qint VSS) capacitor c=3.77773e-17
C95 (\27\:VDD VSS) capacitor c=6.35427e-17
C96 (\1\:QN VSS) capacitor c=6.98348e-17
C97 (\1\:VDD VSS) capacitor c=1.13784e-16
C98 (\12\:CKNb VSS) capacitor c=1.18938e-16
C99 (\17\:CKNbb VSS) capacitor c=7.35535e-17
C100 (\4\:n20 VSS) capacitor c=4.33684e-17
C101 (\13\:mout VSS) capacitor c=3.89027e-17
C102 (\3\:n25 VSS) capacitor c=9.06248e-17
C103 (\15\:mout VSS) capacitor c=4.23837e-17
C104 (\8\:n35 VSS) capacitor c=6.34736e-17
C105 (\3\:n40 VSS) capacitor c=8.45616e-17
C106 (\3\:n42 VSS) capacitor c=9.55357e-17
C107 (\13\:qbint VSS) capacitor c=5.84092e-17
C108 (\11\:RNb VSS) capacitor c=1.02635e-16
C109 (\1\:Q VSS) capacitor c=8.18605e-17
C110 (\8\:qint VSS) capacitor c=4.18495e-17
C111 (\3\:qbint VSS) capacitor c=2.94008e-17
C112 (\2\:mout VSS) capacitor c=3.34968e-17
C113 (\6\:qint VSS) capacitor c=3.3545e-17
C114 (\7\:qint VSS) capacitor c=3.87928e-17
C115 (\4\:RN VSS) capacitor c=7.3984e-17
C116 (\15\:qbint VSS) capacitor c=1.15907e-16
C117 (\16\:qbint VSS) capacitor c=1.29493e-16
C118 (\17\:qbint VSS) capacitor c=8.23459e-17
C119 (\6\:n35 VSS) capacitor c=1.70281e-16
C120 (\7\:n35 VSS) capacitor c=1.86687e-16
C121 (\10\:CKNbb VSS) capacitor c=7.31511e-17
C122 (\11\:CKNbb VSS) capacitor c=1.25119e-16
C123 (\7\:RNb VSS) capacitor c=1.58634e-16
C124 (\8\:RNb VSS) capacitor c=2.07813e-16
C125 (\7\:SN VSS) capacitor c=2.89907e-16
C126 (\8\:SN VSS) capacitor c=3.89756e-17
C127 (\5\:mout VSS) capacitor c=4.42942e-17
C128 (\6\:mout VSS) capacitor c=4.98375e-17
C129 (\7\:mout VSS) capacitor c=5.58145e-17
C130 (\8\:mout VSS) capacitor c=6.98683e-17
C131 (\6\:n20 VSS) capacitor c=9.597e-17
C132 (\7\:n20 VSS) capacitor c=7.07165e-17
C133 (\14\:CKNbb VSS) capacitor c=6.63619e-17
C134 (\15\:CKNbb VSS) capacitor c=1.46593e-16
C135 (\16\:CKNbb VSS) capacitor c=2.53295e-16
C136 (\19\:CKNbb VSS) capacitor c=3.09097e-17
C137 (\20\:CKNbb VSS) capacitor c=3.91483e-17
C138 (\14\:CKNb VSS) capacitor c=7.47423e-17
C139 (\15\:CKNb VSS) capacitor c=1.39309e-16
C140 (\16\:CKNb VSS) capacitor c=1.34048e-16
C141 (\3\:VDD VSS) capacitor c=1.3416e-17
C142 (\9\:VDD VSS) capacitor c=3.73062e-17
C143 (\15\:VDD VSS) capacitor c=1.62206e-17
C144 (\19\:VDD VSS) capacitor c=1.42298e-17
C145 (\22\:VDD VSS) capacitor c=1.34936e-17
C146 (\26\:VDD VSS) capacitor c=9.87272e-18
Rk1 (\2\:QN QN) resistor r=0.3779 c=0
Rk2 (QN \4\:QN) resistor r=0.002835 c=0
Rk8 (RN \4\:RN) resistor r=0.03453 c=0
Rk36 (D \4\:D) resistor r=0.007525 c=0
Rk48 (\2\:VDD \3\:VDD) resistor r=0.06006 c=0
Rk49 (\3\:VDD \4\:VDD) resistor r=0.3419 c=0
Rk50 (\3\:VDD \6\:VDD) resistor r=0.3564 c=0
Rk51 (\4\:VDD \8\:VDD) resistor r=0.3345 c=0
Rk52 (\4\:VDD \9\:VDD) resistor r=0.3764 c=0
Rk53 (\9\:VDD \11\:VDD) resistor r=0.07476 c=0
Rk54 (\9\:VDD \12\:VDD) resistor r=0.3775 c=0
Rk55 (\12\:VDD \14\:VDD) resistor r=0.07156 c=0
Rk56 (\12\:VDD \15\:VDD) resistor r=0.4141 c=0
Rk57 (\15\:VDD \17\:VDD) resistor r=0.1036 c=0
Rk58 (\15\:VDD \18\:VDD) resistor r=0.1379 c=0
Rk59 (\18\:VDD \19\:VDD) resistor r=0.1545 c=0
Rk60 (\19\:VDD \21\:VDD) resistor r=0.04338 c=0
Rk61 (\19\:VDD \22\:VDD) resistor r=0.3376 c=0
Rk62 (\22\:VDD \24\:VDD) resistor r=0.2746 c=0
Rk63 (\22\:VDD \25\:VDD) resistor r=0.05755 c=0
Rk66 (\26\:VDD VDD) resistor r=0.1025 c=0
Rk64 (\25\:VDD \26\:VDD) resistor r=0.2484 c=0
Rk65 (\26\:VDD \28\:VDD) resistor r=0.44 c=0
Rk24 (\7\:SN SN) resistor r=1.9301 c=0
Rk25 (SN \8\:SN) resistor r=0.04356 c=0
Rk6 (Q \2\:Q) resistor r=0.4289 c=0
Rk7 (Q \4\:Q) resistor r=0.07434 c=0
Rk67 (\2\:VSS \3\:VSS) resistor r=0.06006 c=0
Rk68 (\3\:VSS \4\:VSS) resistor r=0.1404 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.1806 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.1203 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.275 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.4759 c=0
Rk73 (\8\:VSS \9\:VSS) resistor r=0.6065 c=0
Rk74 (\9\:VSS \10\:VSS) resistor r=0.3376 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.05755 c=0
Rk77 (\12\:VSS VSS) resistor r=0.1025 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.2484 c=0
Rk78 (\3\:VSS \14\:VSS) resistor r=0.3665 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.07476 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.04338 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.04338 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.3419 c=0
Rk83 (\12\:VSS \24\:VSS) resistor r=0.3844 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1153 c=0
Rk4 (\6\:qint \7\:qint) resistor r=0.1291 c=0
Rk5 (\6\:qint \9\:qint) resistor r=0.1093 c=0
Rk9 (\12\:qbint \14\:qbint) resistor r=0.3691 c=0
Rk10 (\14\:qbint \15\:qbint) resistor r=0.1151 c=0
Rk11 (\15\:qbint \16\:qbint) resistor r=0.7243 c=0
Rk12 (\15\:qbint \17\:qbint) resistor r=0.3637 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=0.9657 c=0
Rk21 (\8\:RNb \10\:RNb) resistor r=0.7251 c=0
Rk22 (\10\:RNb \12\:RNb) resistor r=0.5107 c=0
Rk16 (\5\:n35 \6\:n35) resistor r=0.1257 c=0
Rk17 (\6\:n35 \7\:n35) resistor r=1.1889 c=0
Rk18 (\6\:n35 \9\:n35) resistor r=0.2867 c=0
Rk13 (\2\:n42 \4\:n42) resistor r=0.4286 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=0.5071 c=0
Rk19 (\10\:CKNbb \11\:CKNbb) resistor r=0.5711 c=0
Rk37 (\13\:CKNbb \14\:CKNbb) resistor r=0.07809 c=0
Rk38 (\14\:CKNbb \15\:CKNbb) resistor r=0.254 c=0
Rk39 (\15\:CKNbb \16\:CKNbb) resistor r=1.4769 c=0
Rk40 (\14\:CKNbb \18\:CKNbb) resistor r=0.3983 c=0
Rk41 (\15\:CKNbb \19\:CKNbb) resistor r=0.1667 c=0
Rk42 (\19\:CKNbb \20\:CKNbb) resistor r=0.1701 c=0
Rk26 (\5\:mout \6\:mout) resistor r=0.2543 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.2923 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.2401 c=0
Rk29 (\8\:mout \10\:mout) resistor r=0.2616 c=0
Rk30 (\6\:mout \12\:mout) resistor r=0.0876 c=0
Rk31 (\7\:mout \14\:mout) resistor r=0.1206 c=0
Rk32 (\8\:mout \16\:mout) resistor r=0.133 c=0
Rk43 (\11\:CKNb \13\:CKNb) resistor r=0.5735 c=0
Rk44 (\13\:CKNb \14\:CKNb) resistor r=0.3472 c=0
Rk45 (\14\:CKNb \15\:CKNb) resistor r=0.3974 c=0
Rk46 (\15\:CKNb \16\:CKNb) resistor r=0.9578 c=0
Rk23 (\2\:n25 \4\:n25) resistor r=0.5661 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.2999 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3682 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.4464 c=0
Rk15 (\2\:n41 \4\:n41) resistor r=0.502 c=0
Rl9 (\1\:RN \2\:RN) resistor r=96.8456 c=0
Rl10 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl41 (\1\:CKN \2\:CKN) resistor r=87.2302 c=0
Rl42 (\2\:CKN \3\:CKN) resistor r=39.1533 c=0
Rl38 (\2\:D \3\:D) resistor r=125.722 c=0
Rl37 (\1\:D \2\:D) resistor r=43.7849 c=0
Rl29 (\4\:SN \6\:SN) resistor r=140.385 c=0
Rl28 (\4\:SN \5\:SN) resistor r=73.7687 c=0
Rl13 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl14 (\2\:SN \3\:SN) resistor r=69.9225 c=0
Rl1 (qint \2\:qint) resistor r=37.6944 c=0
Rl2 (\2\:qint \3\:qint) resistor r=26.1559 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=125.584 c=0
Rl16 (\9\:qbint \10\:qbint) resistor r=56.9251 c=0
Rl7 (\5\:qbint \6\:qbint) resistor r=24.848 c=0
Rl3 (qbint \2\:qbint) resistor r=81.4873 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=11.259 c=0
Rl8 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=133.209 c=0
Rl17 (RNb \2\:RNb) resistor r=132.258 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=140.385 c=0
Rl25 (\4\:RNb \6\:RNb) resistor r=72.3097 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=94.48 c=0
Rl11 (n35 \2\:n35) resistor r=39.1533 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=71.8456 c=0
Rl36 (\8\:CKNbb \9\:CKNbb) resistor r=79.5379 c=0
Rl33 (\6\:CKNbb \7\:CKNbb) resistor r=61.4557 c=0
Rl22 (\3\:CKNbb \4\:CKNbb) resistor r=24.2328 c=0
Rl23 (\4\:CKNbb \5\:CKNbb) resistor r=67.7945 c=0
Rl19 (CKNbb \2\:CKNbb) resistor r=24.2328 c=0
Rl30 (mout \2\:mout) resistor r=78.5603 c=0
Rl32 (\2\:mout \4\:mout) resistor r=97.7911 c=0
Rl31 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl39 (\7\:CKNb \8\:CKNb) resistor r=187.381 c=0
Rl34 (\4\:CKNb \5\:CKNb) resistor r=202.895 c=0
Rl20 (CKNb \2\:CKNb) resistor r=170.285 c=0
Rl40 (\8\:CKNb \9\:CKNb) resistor r=46.8456 c=0
Rl35 (\5\:CKNb \6\:CKNb) resistor r=46.8456 c=0
Rl21 (\2\:CKNb \3\:CKNb) resistor r=126.436 c=0
Rl26 (n20 \2\:n20) resistor r=85.7713 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=9.375 c=0
Rz21 (\1\:VDD \18\:VDD) resistor r=25 c=0
Rz22 (\1\:VDD \25\:VDD) resistor r=9.375 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz23 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz24 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz25 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz26 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz27 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz28 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz16 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz14 (\15\:mout \16\:mout) resistor r=75 c=0
Rz17 (\12\:CKNb \13\:CKNb) resistor r=75 c=0
Rz11 (n25 \2\:n25) resistor r=75 c=0
Rz12 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz15 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry14 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry25 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \11\:VSS) resistor r=7.75 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\11\:mout \12\:mout) resistor r=62 c=0
Ry13 (\10\:CKNb \11\:CKNb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CKN CKN) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx3 (\5\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \17\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\4\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \19\:CKNbb) resistor r=45 c=0
Rx17 (\6\:CKNbb \20\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx18 (\9\:CKNb \14\:CKNb) resistor r=45 c=0
Rx19 (\6\:CKNb \15\:CKNb) resistor r=45 c=0
Rx20 (\3\:CKNb \16\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \7\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.36635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\8\:qint \4\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\1\:Q \6\:qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.56154e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn22 (\11\:RNb \3\:RN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.537e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn45 (\13\:qbint \3\:n35 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.39e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.2e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (\3\:n42 \3\:SN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=2.392e-14 ps=1.43e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn52 (\3\:n40 \9\:qbint \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\3\:n40 RNb n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn53 (n40 CKNbb \8\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn40 (\8\:n35 \2\:CKNb \15\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\3\:n25 \5\:RNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.625e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn26 (\4\:n20 \8\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=5e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn32 (\13\:mout \3\:n20 n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn30 (n25 \6\:SN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.195e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn35 (n30 \4\:mout \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.61e-14 ps=1.54e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=9.3e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn36 (\4\:n20 \5\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.32e-14 ps=6.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=7.05e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn25 (n21 \1\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.305e-14 ps=1.54e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=3.65e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn21 (\17\:CKNbb \8\:CKNb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.33e-14 ad=2.03e-14 ps=1.54e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn20 (\12\:CKNb \3\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mp56 (\4\:qint \7\:qbint \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=49.4198 \
        scb=0.0326741 scc=0.00592591 m=(1)
mp55 (\3\:Q qbint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.54359e-07 sd=160n sca=18.7372 \
        scb=0.0160946 scc=0.00159617 m=(1)
mp22 (\9\:RNb \1\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.762e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp45 (\11\:qbint n35 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.99186e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp50 (\3\:n41 \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=4.3e-14 ps=1.9e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.62442e-07 sb=5.2e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.07442e-07 sb=2.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n43 \2\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.835e-14 ad=1.29e-14 ps=1.8e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12442e-07 sb=1.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (n41 CKNb \4\:n35 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp40 (\4\:n35 \3\:CKNbb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp31 (n26 \4\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=3.87e-14 ps=1.63e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=1.02535e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp32 (\11\:mout n20 n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=8.00349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\11\:mout \4\:SN \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.965e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=5.95349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp35 (n31 mout \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.965e-14 ad=1.827e-14 ps=1.71e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.72326e-07 sb=9e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp36 (\8\:n20 \7\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.02326e-07 sb=7.7e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp26 (\8\:n20 \4\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.07326e-07 sb=5.65e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp25 (n22 \3\:D \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02733e-06 sb=3.45e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp21 (\12\:CKNbb \7\:CKNb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23233e-06 sb=1.4e-07 sd=160n sca=12.0329 \
        scb=0.00996522 scc=0.000239356 m=(1)
mp20 (\10\:CKNb \1\:CKN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5355 \
        scb=0.0237969 scc=0.00114597 m=(1)
ends DFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:14:14 2012 )
// Library name: gsclib045
// Cell name: DFFNSRX2
// View name: extracted

simulator lang=spectre

subckt DFFNSRX2 CKN D Q QN RN SN VDD VSS
mp20 (\21\:CKNb \3\:CKN \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.623e-14 ad=3.762e-14 ps=8.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=7.91512e-07 sd=160n sca=17.7347 \
        scb=0.018547 scc=0.000439635 m=(1)
C1 (Q VSS) capacitor c=8.03579e-17
C2 (CKN VSS) capacitor c=1.26367e-16
C3 (RN VSS) capacitor c=5.55314e-17
C4 (SN VSS) capacitor c=6.59385e-17
C5 (D VSS) capacitor c=1.30368e-16
C6 (VDD VSS) capacitor c=4.99834e-16
C7 (CKNb VSS) capacitor c=5.84931e-17
C8 (n21 VSS) capacitor c=1.43231e-18
C9 (n20 VSS) capacitor c=7.19385e-17
C10 (CKNbb VSS) capacitor c=3.83002e-17
C11 (n30 VSS) capacitor c=3.43925e-19
C12 (mout VSS) capacitor c=8.03545e-17
C13 (RNb VSS) capacitor c=8.98324e-17
C14 (n25 VSS) capacitor c=8.016e-17
C15 (n35 VSS) capacitor c=4.52636e-17
C16 (n40 VSS) capacitor c=1.44136e-16
C17 (n42 VSS) capacitor c=7.19206e-17
C18 (qbint VSS) capacitor c=3.8618e-17
C19 (qint VSS) capacitor c=1.65899e-16
C20 (n31 VSS) capacitor c=5.58704e-18
C21 (n26 VSS) capacitor c=8.08912e-19
C22 (n41 VSS) capacitor c=9.88419e-17
C23 (n43 VSS) capacitor c=6.39224e-19
C24 (\10\:qbint VSS) capacitor c=3.11133e-17
C25 (\4\:qbint VSS) capacitor c=4.27425e-16
C26 (\3\:n35 VSS) capacitor c=3.89687e-17
C27 (\6\:RNb VSS) capacitor c=7.54085e-17
C28 (\2\:qbint VSS) capacitor c=1.05983e-16
C29 (\1\:SN VSS) capacitor c=7.17374e-17
C30 (\12\:CKNb VSS) capacitor c=5.14862e-17
C31 (\5\:CKNbb VSS) capacitor c=6.82344e-17
C32 (\1\:RN VSS) capacitor c=3.20095e-17
C33 (\5\:SN VSS) capacitor c=3.55818e-17
C34 (\2\:n20 VSS) capacitor c=7.48662e-17
C35 (\5\:CKNb VSS) capacitor c=4.33642e-17
C36 (\1\:D VSS) capacitor c=6.07372e-17
C37 (\3\:CKN VSS) capacitor c=3.90706e-17
C38 (\12\:qbint VSS) capacitor c=3.67033e-17
C39 (\4\:RNb VSS) capacitor c=3.50489e-17
C40 (\3\:qbint VSS) capacitor c=7.08706e-17
C41 (\2\:SN VSS) capacitor c=1.36593e-16
C42 (\4\:CKNbb VSS) capacitor c=6.26973e-17
C43 (\10\:CKNb VSS) capacitor c=4.70766e-17
C44 (\3\:RN VSS) capacitor c=4.03985e-17
C45 (\3\:SN VSS) capacitor c=1.22684e-16
C46 (\2\:RNb VSS) capacitor c=6.23629e-17
C47 (\8\:CKNb VSS) capacitor c=3.12561e-17
C48 (\2\:mout VSS) capacitor c=6.57619e-17
C49 (\3\:CKNb VSS) capacitor c=3.96385e-17
C50 (\3\:CKNbb VSS) capacitor c=6.15155e-17
C51 (\3\:D VSS) capacitor c=5.49251e-17
C52 (\1\:CKN VSS) capacitor c=3.80883e-17
C53 (\11\:qbint VSS) capacitor c=4.49308e-17
C54 (\2\:n35 VSS) capacitor c=3.03882e-17
C55 (\5\:RNb VSS) capacitor c=5.71669e-17
C56 (\13\:CKNb VSS) capacitor c=2.45861e-17
C57 (\6\:CKNbb VSS) capacitor c=2.82519e-17
C58 (\11\:CKNb VSS) capacitor c=3.76492e-17
C59 (\2\:RN VSS) capacitor c=2.50148e-17
C60 (\4\:SN VSS) capacitor c=2.70435e-17
C61 (\3\:RNb VSS) capacitor c=4.94923e-17
C62 (\3\:n20 VSS) capacitor c=3.5696e-17
C63 (\9\:CKNb VSS) capacitor c=3.40662e-17
C64 (\7\:CKNb VSS) capacitor c=3.48781e-17
C65 (\3\:mout VSS) capacitor c=2.21992e-17
C66 (\2\:CKNbb VSS) capacitor c=7.01293e-17
C67 (\4\:CKNb VSS) capacitor c=4.33546e-17
C68 (\2\:CKNb VSS) capacitor c=4.75187e-17
C69 (\2\:D VSS) capacitor c=6.57439e-17
C70 (\2\:CKN VSS) capacitor c=4.88778e-17
C71 (\8\:qint VSS) capacitor c=3.91762e-17
C72 (\3\:QN VSS) capacitor c=7.8567e-17
C73 (\1\:Q VSS) capacitor c=8.43872e-18
C74 (\16\:qbint VSS) capacitor c=5.79188e-17
C75 (\26\:VDD VSS) capacitor c=6.02441e-17
C76 (\28\:VDD VSS) capacitor c=3.34541e-17
C77 (\3\:n41 VSS) capacitor c=7.58733e-17
C78 (\8\:n35 VSS) capacitor c=3.51734e-17
C79 (\4\:mout VSS) capacitor c=2.47702e-18
C80 (\11\:RNb VSS) capacitor c=9.72098e-17
C81 (\30\:VDD VSS) capacitor c=2.96192e-17
C82 (\8\:mout VSS) capacitor c=1.73234e-16
C83 (\32\:VDD VSS) capacitor c=1.62613e-17
C84 (\8\:CKNbb VSS) capacitor c=1.94121e-16
C85 (\34\:VDD VSS) capacitor c=1.86615e-17
C86 (\5\:n20 VSS) capacitor c=1.31815e-16
C87 (\36\:VDD VSS) capacitor c=2.10807e-17
C88 (\21\:CKNb VSS) capacitor c=6.0815e-17
C89 (\1\:VDD VSS) capacitor c=2.3962e-16
C90 (\12\:qint VSS) capacitor c=1.75491e-17
C91 (\1\:QN VSS) capacitor c=5.02179e-17
C92 (\3\:Q VSS) capacitor c=5.81372e-17
C93 (\20\:qbint VSS) capacitor c=4.16417e-17
C94 (\3\:n40 VSS) capacitor c=1.32975e-16
C95 (\3\:n42 VSS) capacitor c=1.02898e-16
C96 (\6\:n35 VSS) capacitor c=5.36373e-17
C97 (\6\:mout VSS) capacitor c=6.22302e-17
C98 (\8\:RNb VSS) capacitor c=2.20022e-16
C99 (\3\:n25 VSS) capacitor c=7.51058e-17
C100 (\11\:mout VSS) capacitor c=3.27514e-17
C101 (\11\:CKNbb VSS) capacitor c=4.43077e-17
C102 (\7\:n20 VSS) capacitor c=1.18608e-16
C103 (\18\:CKNb VSS) capacitor c=2.96775e-17
C104 (\14\:CKNb VSS) capacitor c=4.06418e-17
C105 (\15\:CKNb VSS) capacitor c=1.14364e-16
C106 (\16\:CKNb VSS) capacitor c=1.5615e-16
C107 (\17\:CKNb VSS) capacitor c=7.02202e-17
C108 (\20\:CKNb VSS) capacitor c=7.22654e-17
C109 (\4\:n20 VSS) capacitor c=9.15178e-17
C110 (\6\:SN VSS) capacitor c=3.97991e-17
C111 (\4\:RN VSS) capacitor c=5.42847e-17
C112 (\5\:mout VSS) capacitor c=1.68009e-16
C113 (\10\:mout VSS) capacitor c=1.48168e-16
C114 (\13\:mout VSS) capacitor c=1.08069e-16
C115 (\7\:CKNbb VSS) capacitor c=2.61473e-16
C116 (\10\:CKNbb VSS) capacitor c=4.75257e-17
C117 (\13\:CKNbb VSS) capacitor c=5.61094e-17
C118 (\23\:CKNb VSS) capacitor c=8.52596e-17
C119 (\24\:CKNb VSS) capacitor c=3.08839e-16
C120 (\25\:CKNb VSS) capacitor c=2.20531e-16
C121 (\26\:CKNb VSS) capacitor c=3.2962e-17
C122 (\7\:RNb VSS) capacitor c=2.89047e-16
C123 (\10\:RNb VSS) capacitor c=9.64621e-17
C124 (\4\:n35 VSS) capacitor c=1.43475e-16
C125 (\5\:n35 VSS) capacitor c=2.06211e-16
C126 (\13\:qbint VSS) capacitor c=9.78534e-17
C127 (\22\:qbint VSS) capacitor c=4.26982e-17
C128 (\10\:qint VSS) capacitor c=3.93868e-17
C129 (\11\:qint VSS) capacitor c=6.21164e-17
C130 (\3\:VDD VSS) capacitor c=8.63401e-17
C131 (\9\:VDD VSS) capacitor c=1.44164e-17
C132 (\10\:VDD VSS) capacitor c=1.50058e-17
C133 (\12\:VDD VSS) capacitor c=3.13563e-17
C134 (\14\:VDD VSS) capacitor c=5.71782e-19
C135 (\16\:VDD VSS) capacitor c=2.72274e-18
C136 (\18\:VDD VSS) capacitor c=3.36875e-18
Rk35 (Q \2\:Q) resistor r=0.003006 c=0
Rk36 (\2\:Q \4\:Q) resistor r=0.2645 c=0
Rk1 (\4\:CKN CKN) resistor r=0.002711 c=0
Rk13 (RN \4\:RN) resistor r=0.03585 c=0
Rk12 (SN \6\:SN) resistor r=0.1632 c=0
Rk38 (\4\:QN QN) resistor r=0.005081 c=0
Rk37 (\2\:QN \4\:QN) resistor r=0.2978 c=0
Rk2 (\4\:D D) resistor r=0.0029 c=0
Rk76 (\2\:VSS \3\:VSS) resistor r=0.09513 c=0
Rk80 (\3\:VSS \7\:VSS) resistor r=0.6594 c=0
Rk81 (\7\:VSS \8\:VSS) resistor r=0.1704 c=0
Rk82 (\8\:VSS \9\:VSS) resistor r=0.6144 c=0
Rk83 (\9\:VSS \10\:VSS) resistor r=0.08761 c=0
Rk84 (\10\:VSS \11\:VSS) resistor r=0.5909 c=0
Rk85 (\11\:VSS \12\:VSS) resistor r=0.1092 c=0
Rk87 (\13\:VSS VSS) resistor r=0.1727 c=0
Rk86 (\12\:VSS \13\:VSS) resistor r=0.3786 c=0
Rk91 (\7\:VSS \21\:VSS) resistor r=0.2722 c=0
Rk92 (\9\:VSS \23\:VSS) resistor r=0.1737 c=0
Rk93 (\11\:VSS \25\:VSS) resistor r=0.04333 c=0
Rk94 (\13\:VSS \27\:VSS) resistor r=0.2952 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.08761 c=0
Rk54 (\3\:VDD \8\:VDD) resistor r=0.1854 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.1905 c=0
Rk56 (\9\:VDD \10\:VDD) resistor r=0.1827 c=0
Rk57 (\10\:VDD \11\:VDD) resistor r=0.3786 c=0
Rk58 (\11\:VDD \12\:VDD) resistor r=0.5508 c=0
Rk59 (\12\:VDD \13\:VDD) resistor r=0.1995 c=0
Rk60 (\13\:VDD \14\:VDD) resistor r=0.2231 c=0
Rk61 (\14\:VDD \15\:VDD) resistor r=0.07757 c=0
Rk62 (\15\:VDD \16\:VDD) resistor r=0.1152 c=0
Rk63 (\16\:VDD \17\:VDD) resistor r=0.2356 c=0
Rk64 (\17\:VDD \18\:VDD) resistor r=0.2557 c=0
Rk66 (\19\:VDD VDD) resistor r=0.04992 c=0
Rk65 (\18\:VDD \19\:VDD) resistor r=0.09513 c=0
Rk70 (\9\:VDD \27\:VDD) resistor r=0.4015 c=0
Rk71 (\10\:VDD \29\:VDD) resistor r=0.2585 c=0
Rk72 (\12\:VDD \31\:VDD) resistor r=0.04333 c=0
Rk73 (\14\:VDD \33\:VDD) resistor r=0.07416 c=0
Rk74 (\16\:VDD \35\:VDD) resistor r=0.07416 c=0
Rk75 (\18\:VDD \37\:VDD) resistor r=0.1747 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.2532 c=0
Rk4 (\15\:CKNb \16\:CKNb) resistor r=0.8373 c=0
Rk5 (\16\:CKNb \17\:CKNb) resistor r=0.3708 c=0
Rk6 (\17\:CKNb \19\:CKNb) resistor r=0.1911 c=0
Rk7 (\16\:CKNb \20\:CKNb) resistor r=0.3358 c=0
Rk8 (\17\:CKNb \22\:CKNb) resistor r=0.5023 c=0
Rk23 (\23\:CKNb \24\:CKNb) resistor r=0.3797 c=0
Rk24 (\24\:CKNb \25\:CKNb) resistor r=1.8534 c=0
Rk25 (\24\:CKNb \26\:CKNb) resistor r=0.2116 c=0
Rk9 (\4\:n20 \6\:n20) resistor r=0.7465 c=0
Rk10 (\6\:n20 \8\:n20) resistor r=0.5912 c=0
Rk19 (\7\:CKNbb \9\:CKNbb) resistor r=1.8706 c=0
Rk20 (\9\:CKNbb \10\:CKNbb) resistor r=0.06271 c=0
Rk21 (\10\:CKNbb \12\:CKNbb) resistor r=0.2429 c=0
Rk22 (\10\:CKNbb \13\:CKNbb) resistor r=0.3536 c=0
Rk14 (\5\:mout \7\:mout) resistor r=0.3793 c=0
Rk15 (\5\:mout \9\:mout) resistor r=0.852 c=0
Rk16 (\9\:mout \10\:mout) resistor r=0.5887 c=0
Rk17 (\10\:mout \12\:mout) resistor r=0.09812 c=0
Rk18 (\10\:mout \13\:mout) resistor r=0.8499 c=0
Rk28 (\7\:RNb \9\:RNb) resistor r=1.8196 c=0
Rk29 (\9\:RNb \10\:RNb) resistor r=0.6065 c=0
Rk30 (\9\:RNb \12\:RNb) resistor r=0.5393 c=0
Rk11 (\2\:n25 \4\:n25) resistor r=0.4979 c=0
Rk32 (\4\:n35 \5\:n35) resistor r=1.189 c=0
Rk33 (\5\:n35 \7\:n35) resistor r=0.2576 c=0
Rk34 (\5\:n35 \9\:n35) resistor r=0.118 c=0
Rk27 (\2\:n40 \4\:n40) resistor r=0.8739 c=0
Rk31 (\2\:n42 \4\:n42) resistor r=0.3869 c=0
Rk39 (\13\:qbint \4\:qbint) resistor r=0.7617 c=0
Rk41 (\4\:qbint \17\:qbint) resistor r=0.2921 c=0
Rk44 (\4\:qbint \21\:qbint) resistor r=0.3257 c=0
Rk45 (\17\:qbint \22\:qbint) resistor r=0.343 c=0
Rk46 (\9\:qint \10\:qint) resistor r=0.2699 c=0
Rk47 (\10\:qint \11\:qint) resistor r=0.28 c=0
Rk48 (\10\:qint \13\:qint) resistor r=0.1152 c=0
Rk26 (\2\:n41 \4\:n41) resistor r=0.4249 c=0
Rl2 (\2\:CKN \3\:CKN) resistor r=147.253 c=0
Rl1 (\1\:CKN \2\:CKN) resistor r=105.769 c=0
Rl19 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl20 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl25 (\1\:SN \2\:SN) resistor r=242.308 c=0
Rl26 (\2\:SN \3\:SN) resistor r=899.566 c=0
Rl28 (\4\:SN \5\:SN) resistor r=87.6944 c=0
Rl27 (\3\:SN \4\:SN) resistor r=37.6944 c=0
Rl3 (\1\:D \2\:D) resistor r=73.7687 c=0
Rl4 (\2\:D \3\:D) resistor r=177.615 c=0
Rl22 (\12\:CKNb \13\:CKNb) resistor r=47.3097 c=0
Rl21 (\10\:CKNb \11\:CKNb) resistor r=31.9251 c=0
Rl8 (\3\:CKNb \4\:CKNb) resistor r=74.2328 c=0
Rl5 (CKNb \2\:CKNb) resistor r=66.5405 c=0
Rl11 (\5\:CKNb \6\:CKNb) resistor r=43.0526 c=0
Rl13 (\6\:CKNb \8\:CKNb) resistor r=39.2065 c=0
Rl14 (\6\:CKNb \9\:CKNb) resistor r=118.861 c=0
Rl12 (\6\:CKNb \7\:CKNb) resistor r=4.4327 c=0
Rl15 (n20 \2\:n20) resistor r=174.566 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=96.8466 c=0
Rl23 (\4\:CKNbb \5\:CKNbb) resistor r=183.747 c=0
Rl24 (\5\:CKNbb \6\:CKNbb) resistor r=68.4636 c=0
Rl6 (CKNbb \2\:CKNbb) resistor r=70.3867 c=0
Rl7 (\2\:CKNbb \3\:CKNbb) resistor r=232.246 c=0
Rl9 (mout \2\:mout) resistor r=240.385 c=0
Rl10 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl17 (RNb \2\:RNb) resistor r=153.846 c=0
Rl30 (\5\:RNb \6\:RNb) resistor r=93.4636 c=0
Rl29 (\4\:RNb \5\:RNb) resistor r=99.8423 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=228.823 c=0
Rl33 (n35 \2\:n35) resistor r=104.806 c=0
Rl34 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl31 (qbint \2\:qbint) resistor r=151.436 c=0
Rl32 (\3\:qbint \2\:qbint) resistor r=205.769 c=0
Rl45 (\11\:qbint \10\:qbint) resistor r=33.9954 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=95.9489 c=0
Rz14 (\4\:Q \3\:Q) resistor r=75 c=0
Rz15 (\2\:QN \1\:QN) resistor r=75 c=0
Rz30 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz31 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz32 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz33 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz19 (\3\:VDD \1\:VDD) resistor r=12.5 c=0
Rz21 (\8\:VDD \1\:VDD) resistor r=18.75 c=0
Rz22 (\11\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz23 (\13\:VDD \1\:VDD) resistor r=18.75 c=0
Rz24 (\15\:VDD \1\:VDD) resistor r=37.5 c=0
Rz25 (\17\:VDD \1\:VDD) resistor r=15 c=0
Rz26 (\19\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz7 (\11\:CKNbb \12\:CKNbb) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:mout \12\:mout) resistor r=75 c=0
Rz10 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz3 (n25 \2\:n25) resistor r=75 c=0
Rz4 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz8 (n40 \2\:n40) resistor r=75 c=0
Rz9 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (n42 \2\:n42) resistor r=75 c=0
Rz12 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz16 (\21\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\13\:qint \12\:qint) resistor r=75 c=0
Ry10 (\2\:Q \1\:Q) resistor r=62 c=0
Ry11 (\4\:QN \3\:QN) resistor r=62 c=0
Ry23 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry24 (\3\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry25 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\10\:VSS \1\:VSS) resistor r=31 c=0
Ry27 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry18 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry19 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry20 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry21 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry22 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry1 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry2 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry13 (\9\:qint \8\:qint) resistor r=62 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx1 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx7 (\4\:SN \6\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\7\:CKNb \14\:CKNb) resistor r=45 c=0
Rx4 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx5 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx12 (\11\:CKNb \23\:CKNb) resistor r=45 c=0
Rx13 (\9\:CKNb \25\:CKNb) resistor r=45 c=0
Rx14 (\13\:CKNb \26\:CKNb) resistor r=45 c=0
Rx6 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx11 (\2\:CKNbb \13\:CKNbb) resistor r=45 c=0
Rx9 (\3\:mout \13\:mout) resistor r=45 c=0
Rx15 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx16 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\2\:n35 \4\:n35) resistor r=45 c=0
Rx18 (\13\:qbint \11\:qbint) resistor r=45 c=0
Rx21 (\22\:qbint qbint) resistor r=45 c=0
Rx22 (\11\:qint qint) resistor r=45 c=0
mn20 (\18\:CKNb \1\:CKN \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04362e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn25 (n21 \3\:D \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.38621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn26 (\7\:n20 \3\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=6.38621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn36 (\7\:n20 \3\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=3.045e-14 ps=6.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=3.83621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn35 (n30 \2\:mout \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.79e-14 ad=2.755e-14 ps=1.7e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.48621e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn21 (\11\:CKNbb \8\:CKNb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.79e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.33793e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (n25 \2\:RNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.085e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn32 (\11\:mout n20 \3\:n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.8e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn30 (\3\:n25 \3\:SN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=4.857e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=5e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn22 (\8\:RNb \3\:RN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=2.03e-14 ps=1.18e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn40 (\6\:n35 \10\:CKNb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.407e-14 ad=2.61e-14 ps=7.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn53 (n40 \4\:CKNbb \6\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=3.697e-14 ps=6.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (\3\:n42 \2\:SN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.275e-14 ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.17586e-07 sb=5.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn52 (\3\:n40 \3\:qbint \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.22586e-07 sb=3.5e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn51 (\3\:n40 \4\:RNb n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.32586e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn45 (\20\:qbint n35 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18232e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55_1__rcx (\3\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.84e-14 ad=5.98e-14 ps=9.05e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.93173e-07 sb=1.01173e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.986e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.38173e-07 sb=4.66731e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:qint \12\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.122e-14 ad=2.03e-14 ps=9.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25207e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp25 (n22 \1\:D \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=1.29e-14 ps=8.6e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=5.31512e-07 sd=160n sca=12.132 \
        scb=0.00915419 scc=0.000101757 m=(1)
mp26 (\5\:n20 CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.56e-14 ps=5.5e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=4.26512e-07 sd=160n sca=11.3905 \
        scb=0.00832609 scc=9.89279e-05 m=(1)
mp36 (\5\:n20 CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=5.56e-14 ps=8.1e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.4093e-07 sb=3.35e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp35 (n31 mout \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=4.085e-14 ps=1.9e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7593e-07 sb=1e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\8\:CKNbb \5\:CKNb \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.64e-14 ad=2.63e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (n26 RNb \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=1.29e-14 ps=2.03e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26744e-07 sb=1.335e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\8\:mout \2\:n20 n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=9.352e-14 ps=5.5e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.31744e-07 sb=1.23e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout \5\:SN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0787e-13 ad=9.352e-14 ps=2.33e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.11744e-07 sb=7.5e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \1\:RN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0787e-13 ad=8.385e-14 ps=2.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07174e-06 sb=3.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\8\:n35 \5\:CKNbb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.16e-14 ad=3.762e-14 ps=9.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4e-07 sb=3.6e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp53 (\3\:n41 \12\:CKNb \8\:n35 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp50 (n41 \1\:SN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.82e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95349e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp52 (n41 \2\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.82e-14 ps=5.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36744e-07 sb=2.45e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp51 (n43 \6\:RNb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41744e-07 sb=1.4e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp45 (\16\:qbint \3\:n35 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.3095e-13 ad=4.34e-14 ps=2e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30629e-06 sd=160n sca=15.1875 \
        scb=0.0142433 scc=0.000935749 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.4243e-13 ad=8.97e-14 ps=2.035e-06 pd=1.24e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.67692e-07 sb=9.99936e-07 sd=160n \
        sca=28.7024 scb=0.0198217 scc=0.00315848 m=(2)
mp57 (\3\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1327e-13 ad=6.24e-14 ps=1.935e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.33077e-07 sb=4.34551e-07 sd=160n sca=20.2826 \
        scb=0.0171335 scc=0.00171662 m=(2)
mp56 (\8\:qint \10\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.265e-14 ad=3.01e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39791e-06 sb=1.4e-07 sd=160n sca=38.5216 \
        scb=0.0409143 scc=0.00421269 m=(1)
ends DFFNSRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:14:55 2012 )
// Library name: gsclib045
// Cell name: DFFNSRX4
// View name: extracted

simulator lang=spectre

subckt DFFNSRX4 CKN D Q QN RN SN VDD VSS
mp20 (\21\:CKNb \1\:CKN \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06058e-06 sd=160n sca=16.2774 \
        scb=0.0161284 scc=0.000285108 m=(1)
C1 (Q VSS) capacitor c=1.50327e-16
C2 (CKN VSS) capacitor c=1.29865e-16
C3 (RN VSS) capacitor c=5.25791e-17
C4 (SN VSS) capacitor c=6.95786e-17
C5 (QN VSS) capacitor c=3.0216e-17
C6 (VDD VSS) capacitor c=5.31763e-16
C7 (D VSS) capacitor c=6.85086e-17
C8 (CKNb VSS) capacitor c=5.58368e-17
C9 (n21 VSS) capacitor c=1.49022e-18
C10 (n20 VSS) capacitor c=4.07769e-17
C11 (CKNbb VSS) capacitor c=4.52692e-17
C12 (n30 VSS) capacitor c=2.25577e-18
C13 (mout VSS) capacitor c=2.14804e-17
C14 (RNb VSS) capacitor c=5.94577e-17
C15 (n25 VSS) capacitor c=7.84013e-17
C16 (n35 VSS) capacitor c=2.05827e-16
C17 (n40 VSS) capacitor c=8.78679e-17
C18 (n42 VSS) capacitor c=7.71182e-17
C19 (qbint VSS) capacitor c=8.27746e-17
C20 (qint VSS) capacitor c=2.8672e-16
C21 (n31 VSS) capacitor c=3.2412e-18
C22 (n26 VSS) capacitor c=3.76694e-18
C23 (n41 VSS) capacitor c=1.00445e-16
C24 (n43 VSS) capacitor c=3.5553e-18
C25 (\21\:qbint VSS) capacitor c=5.98946e-17
C26 (\1\:SN VSS) capacitor c=7.29391e-17
C27 (\4\:RNb VSS) capacitor c=7.69867e-17
C28 (\12\:CKNb VSS) capacitor c=3.76614e-17
C29 (\5\:CKNbb VSS) capacitor c=6.19672e-17
C30 (\3\:RN VSS) capacitor c=3.43936e-17
C31 (\6\:SN VSS) capacitor c=3.48296e-17
C32 (\8\:CKNb VSS) capacitor c=5.44638e-17
C33 (\3\:mout VSS) capacitor c=1.04284e-16
C34 (\1\:D VSS) capacitor c=8.47237e-17
C35 (\1\:CKN VSS) capacitor c=3.82652e-17
C36 (\19\:qbint VSS) capacitor c=2.22668e-17
C37 (\4\:qbint VSS) capacitor c=2.74509e-16
C38 (\2\:SN VSS) capacitor c=1.84289e-16
C39 (\3\:qbint VSS) capacitor c=3.97852e-17
C40 (\6\:RNb VSS) capacitor c=4.44759e-17
C41 (\4\:CKNbb VSS) capacitor c=5.7605e-17
C42 (\10\:CKNb VSS) capacitor c=4.52455e-17
C43 (\1\:RN VSS) capacitor c=3.42156e-17
C44 (\3\:SN VSS) capacitor c=1.19986e-16
C45 (\3\:n20 VSS) capacitor c=5.01539e-17
C46 (\2\:RNb VSS) capacitor c=5.39621e-17
C47 (\9\:CKNb VSS) capacitor c=2.60272e-17
C48 (\2\:mout VSS) capacitor c=5.90665e-17
C49 (\3\:CKNb VSS) capacitor c=4.21457e-17
C50 (\3\:CKNbb VSS) capacitor c=6.52418e-17
C51 (\3\:D VSS) capacitor c=4.20399e-17
C52 (\3\:CKN VSS) capacitor c=4.69896e-17
C53 (\20\:qbint VSS) capacitor c=3.76574e-17
C54 (\2\:qbint VSS) capacitor c=7.24221e-17
C55 (\5\:RNb VSS) capacitor c=5.9754e-17
C56 (\13\:CKNb VSS) capacitor c=2.07004e-17
C57 (\6\:CKNbb VSS) capacitor c=2.50356e-17
C58 (\11\:CKNb VSS) capacitor c=3.48727e-17
C59 (\2\:RN VSS) capacitor c=2.82543e-17
C60 (\5\:SN VSS) capacitor c=1.94044e-17
C61 (\3\:RNb VSS) capacitor c=4.6955e-17
C62 (\2\:n20 VSS) capacitor c=3.14556e-17
C63 (\5\:CKNb VSS) capacitor c=2.7511e-17
C64 (\7\:CKNb VSS) capacitor c=3.29537e-17
C65 (\2\:CKNbb VSS) capacitor c=7.32054e-17
C66 (\4\:CKNb VSS) capacitor c=3.42212e-17
C67 (\2\:CKNb VSS) capacitor c=4.70586e-17
C68 (\2\:D VSS) capacitor c=6.76787e-17
C69 (\2\:CKN VSS) capacitor c=5.18025e-17
C70 (\20\:qint VSS) capacitor c=3.89717e-17
C71 (\1\:VDD VSS) capacitor c=4.2376e-16
C72 (\27\:qbint VSS) capacitor c=7.59227e-17
C73 (\30\:VDD VSS) capacitor c=3.97363e-17
C74 (\3\:n41 VSS) capacitor c=8.44331e-17
C75 (\11\:n35 VSS) capacitor c=3.2564e-17
C76 (\9\:mout VSS) capacitor c=1.51272e-16
C77 (\11\:RNb VSS) capacitor c=6.06173e-17
C78 (\32\:VDD VSS) capacitor c=2.76298e-17
C79 (\7\:mout VSS) capacitor c=2.04297e-16
C80 (\34\:VDD VSS) capacitor c=2.20603e-17
C81 (\8\:CKNbb VSS) capacitor c=2.61714e-16
C82 (\36\:VDD VSS) capacitor c=1.98167e-17
C83 (\5\:n20 VSS) capacitor c=1.50027e-16
C84 (\38\:VDD VSS) capacitor c=2.49951e-17
C85 (\21\:CKNb VSS) capacitor c=8.20598e-17
C86 (\4\:VDD VSS) capacitor c=1.38418e-16
C87 (\16\:qint VSS) capacitor c=3.29362e-17
C88 (\1\:QN VSS) capacitor c=1.30831e-16
C89 (\1\:Q VSS) capacitor c=1.35245e-16
C90 (\29\:qbint VSS) capacitor c=2.04802e-17
C91 (\3\:n40 VSS) capacitor c=1.01727e-16
C92 (\3\:n42 VSS) capacitor c=8.1898e-17
C93 (\9\:n35 VSS) capacitor c=6.28715e-17
C94 (\4\:mout VSS) capacitor c=8.82787e-17
C95 (\8\:RNb VSS) capacitor c=2.09313e-16
C96 (\3\:n25 VSS) capacitor c=7.36231e-17
C97 (\12\:mout VSS) capacitor c=3.80836e-17
C98 (\12\:CKNbb VSS) capacitor c=5.72307e-17
C99 (\7\:n20 VSS) capacitor c=1.15555e-16
C100 (\18\:CKNb VSS) capacitor c=1.86069e-17
C101 (\6\:CKNb VSS) capacitor c=2.40266e-17
C102 (\4\:SN VSS) capacitor c=1.77885e-17
C103 (\4\:D VSS) capacitor c=5.50416e-17
C104 (\14\:CKNb VSS) capacitor c=6.5507e-17
C105 (\15\:CKNb VSS) capacitor c=1.22471e-16
C106 (\16\:CKNb VSS) capacitor c=1.39388e-16
C107 (\17\:CKNb VSS) capacitor c=8.65092e-17
C108 (\20\:CKNb VSS) capacitor c=7.51485e-17
C109 (\4\:n20 VSS) capacitor c=1.35118e-16
C110 (\7\:SN VSS) capacitor c=4.79401e-17
C111 (\4\:RN VSS) capacitor c=5.54908e-17
C112 (\11\:mout VSS) capacitor c=1.61419e-16
C113 (\14\:mout VSS) capacitor c=1.10893e-16
C114 (\7\:CKNbb VSS) capacitor c=2.45e-16
C115 (\10\:CKNbb VSS) capacitor c=6.83705e-17
C116 (\11\:CKNbb VSS) capacitor c=4.64581e-17
C117 (\23\:CKNb VSS) capacitor c=4.43193e-17
C118 (\24\:CKNb VSS) capacitor c=2.98332e-16
C119 (\25\:CKNb VSS) capacitor c=2.46191e-16
C120 (\26\:CKNb VSS) capacitor c=8.30755e-17
C121 (\7\:RNb VSS) capacitor c=2.15881e-16
C122 (\10\:RNb VSS) capacitor c=7.64289e-17
C123 (\7\:n35 VSS) capacitor c=1.34324e-16
C124 (\8\:n35 VSS) capacitor c=1.72366e-16
C125 (\5\:QN VSS) capacitor c=1.85149e-16
C126 (\22\:qbint VSS) capacitor c=2.5058e-16
C127 (\23\:qbint VSS) capacitor c=2.1166e-16
C128 (\24\:qbint VSS) capacitor c=3.00717e-17
C129 (\25\:qbint VSS) capacitor c=5.37153e-17
C130 (\26\:qbint VSS) capacitor c=2.56406e-17
C131 (\31\:qbint VSS) capacitor c=1.23477e-17
C132 (\18\:qint VSS) capacitor c=6.28569e-17
C133 (\19\:qint VSS) capacitor c=4.11864e-17
C134 (\11\:VDD VSS) capacitor c=1.02675e-17
C135 (\13\:VDD VSS) capacitor c=5.39712e-17
C136 (\15\:VDD VSS) capacitor c=2.24602e-17
C137 (\16\:VDD VSS) capacitor c=1.50772e-17
C138 (\18\:VDD VSS) capacitor c=3.92416e-18
Rk37 (\1\:Q Q) resistor r=0.332 c=0
Rk1 (\4\:CKN CKN) resistor r=0.003008 c=0
Rk13 (\4\:RN RN) resistor r=0.1685 c=0
Rk12 (\7\:SN SN) resistor r=0.2025 c=0
Rk44 (\5\:QN QN) resistor r=0.1661 c=0
Rk42 (\1\:QN \5\:QN) resistor r=0.2278 c=0
Rk86 (\1\:VDD \11\:VDD) resistor r=0.2731 c=0
Rk87 (\11\:VDD \12\:VDD) resistor r=0.07759 c=0
Rk88 (\12\:VDD \13\:VDD) resistor r=0.8921 c=0
Rk89 (\13\:VDD \14\:VDD) resistor r=0.05907 c=0
Rk90 (\14\:VDD \15\:VDD) resistor r=0.2573 c=0
Rk91 (\15\:VDD \16\:VDD) resistor r=0.3023 c=0
Rk92 (\16\:VDD \17\:VDD) resistor r=0.2407 c=0
Rk93 (\17\:VDD \18\:VDD) resistor r=0.188 c=0
Rk95 (\19\:VDD VDD) resistor r=0.04993 c=0
Rk94 (\18\:VDD \19\:VDD) resistor r=0.1127 c=0
Rk101 (\11\:VDD \31\:VDD) resistor r=0.2708 c=0
Rk102 (\13\:VDD \33\:VDD) resistor r=0.04334 c=0
Rk103 (\15\:VDD \35\:VDD) resistor r=0.04334 c=0
Rk104 (\16\:VDD \37\:VDD) resistor r=0.07428 c=0
Rk105 (\18\:VDD \39\:VDD) resistor r=0.1794 c=0
Rk2 (D \4\:D) resistor r=0.1354 c=0
Rk63 (\1\:VSS \10\:VSS) resistor r=0.1779 c=0
Rk64 (\10\:VSS \11\:VSS) resistor r=0.7801 c=0
Rk65 (\11\:VSS \12\:VSS) resistor r=0.2231 c=0
Rk66 (\12\:VSS \13\:VSS) resistor r=0.601 c=0
Rk67 (\13\:VSS \14\:VSS) resistor r=0.2498 c=0
Rk68 (\14\:VSS \15\:VSS) resistor r=0.2382 c=0
Rk70 (\16\:VSS VSS) resistor r=0.04993 c=0
Rk69 (\15\:VSS \16\:VSS) resistor r=0.1127 c=0
Rk76 (\11\:VSS \28\:VSS) resistor r=0.2116 c=0
Rk77 (\13\:VSS \30\:VSS) resistor r=0.04334 c=0
Rk78 (\15\:VSS \32\:VSS) resistor r=0.2803 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.371 c=0
Rk4 (\15\:CKNb \16\:CKNb) resistor r=0.7671 c=0
Rk5 (\16\:CKNb \17\:CKNb) resistor r=0.3137 c=0
Rk6 (\17\:CKNb \19\:CKNb) resistor r=0.09782 c=0
Rk7 (\16\:CKNb \20\:CKNb) resistor r=0.353 c=0
Rk8 (\17\:CKNb \22\:CKNb) resistor r=0.6738 c=0
Rk24 (\23\:CKNb \24\:CKNb) resistor r=0.2922 c=0
Rk25 (\24\:CKNb \25\:CKNb) resistor r=1.7181 c=0
Rk26 (\24\:CKNb \26\:CKNb) resistor r=0.3701 c=0
Rk9 (\4\:n20 \6\:n20) resistor r=0.9248 c=0
Rk10 (\6\:n20 \8\:n20) resistor r=0.6003 c=0
Rk20 (\7\:CKNbb \9\:CKNbb) resistor r=1.8527 c=0
Rk21 (\9\:CKNbb \10\:CKNbb) resistor r=0.1772 c=0
Rk22 (\10\:CKNbb \11\:CKNbb) resistor r=0.3419 c=0
Rk23 (\10\:CKNbb \13\:CKNbb) resistor r=0.2709 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.41 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.6898 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.03277 c=0
Rk17 (\8\:mout \11\:mout) resistor r=0.6101 c=0
Rk18 (\11\:mout \13\:mout) resistor r=0.1176 c=0
Rk19 (\11\:mout \14\:mout) resistor r=0.8773 c=0
Rk27 (\7\:RNb \9\:RNb) resistor r=1.2367 c=0
Rk28 (\9\:RNb \10\:RNb) resistor r=0.7235 c=0
Rk29 (\9\:RNb \12\:RNb) resistor r=0.3666 c=0
Rk11 (\2\:n25 \4\:n25) resistor r=0.3827 c=0
Rk33 (\7\:n35 \8\:n35) resistor r=0.9363 c=0
Rk34 (\8\:n35 \10\:n35) resistor r=0.2846 c=0
Rk35 (\8\:n35 \12\:n35) resistor r=0.06538 c=0
Rk30 (\2\:n40 \4\:n40) resistor r=0.3591 c=0
Rk31 (\2\:n42 \4\:n42) resistor r=0.3827 c=0
Rk47 (\22\:qbint \23\:qbint) resistor r=2.0554 c=0
Rk48 (\23\:qbint \24\:qbint) resistor r=0.07673 c=0
Rk49 (\24\:qbint \25\:qbint) resistor r=0.3144 c=0
Rk50 (\23\:qbint \26\:qbint) resistor r=0.0917 c=0
Rk51 (\26\:qbint \28\:qbint) resistor r=0.3273 c=0
Rk52 (\24\:qbint \30\:qbint) resistor r=0.06407 c=0
Rk53 (\26\:qbint \31\:qbint) resistor r=0.1321 c=0
Rk54 (\17\:qint \18\:qint) resistor r=0.4765 c=0
Rk55 (\18\:qint \19\:qint) resistor r=0.2199 c=0
Rk56 (\18\:qint \21\:qint) resistor r=0.1649 c=0
Rk32 (\2\:n41 \4\:n41) resistor r=0.611 c=0
Rl1 (\1\:CKN \2\:CKN) resistor r=73.7687 c=0
Rl2 (\2\:CKN \3\:CKN) resistor r=185.307 c=0
Rl20 (\2\:RN \3\:RN) resistor r=70.3867 c=0
Rl19 (\1\:RN \2\:RN) resistor r=44.3981 c=0
Rl29 (\1\:SN \2\:SN) resistor r=222.643 c=0
Rl30 (\2\:SN \3\:SN) resistor r=943.796 c=0
Rl33 (\4\:SN \6\:SN) resistor r=65.0871 c=0
Rl31 (\3\:SN \4\:SN) resistor r=49.842 c=0
Rl32 (\4\:SN \5\:SN) resistor r=13.0342 c=0
Rl3 (\1\:D \2\:D) resistor r=158.384 c=0
Rl4 (\2\:D \3\:D) resistor r=100.692 c=0
Rl24 (\12\:CKNb \13\:CKNb) resistor r=29.982 c=0
Rl21 (\10\:CKNb \11\:CKNb) resistor r=49.5131 c=0
Rl14 (\7\:CKNb \9\:CKNb) resistor r=24.2328 c=0
Rl6 (\3\:CKNb \4\:CKNb) resistor r=35.7713 c=0
Rl5 (CKNb \2\:CKNb) resistor r=66.5405 c=0
Rl13 (\6\:CKNb \8\:CKNb) resistor r=40.6312 c=0
Rl11 (\5\:CKNb \6\:CKNb) resistor r=82.7008 c=0
Rl12 (\6\:CKNb \7\:CKNb) resistor r=52.3304 c=0
Rl16 (n20 \3\:n20) resistor r=132.692 c=0
Rl15 (n20 \2\:n20) resistor r=95.9055 c=0
Rl22 (\4\:CKNbb \5\:CKNbb) resistor r=168.362 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=67.9995 c=0
Rl7 (CKNbb \2\:CKNbb) resistor r=106.925 c=0
Rl8 (\2\:CKNbb \3\:CKNbb) resistor r=239.939 c=0
Rl9 (mout \2\:mout) resistor r=24.2328 c=0
Rl10 (\2\:mout \3\:mout) resistor r=293.796 c=0
Rl17 (RNb \2\:RNb) resistor r=132.692 c=0
Rl25 (\4\:RNb \5\:RNb) resistor r=155.746 c=0
Rl26 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=249.513 c=0
Rl68 (\20\:qbint \21\:qbint) resistor r=131.708 c=0
Rl67 (\20\:qbint \19\:qbint) resistor r=44.2438 c=0
Rl27 (\2\:qbint qbint) resistor r=158.134 c=0
Rl28 (\2\:qbint \3\:qbint) resistor r=42.9964 c=0
Rz30 (\1\:VDD \4\:VDD) resistor r=5.3571 c=0
Rz31 (\12\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz32 (\14\:VDD \4\:VDD) resistor r=6.25 c=0
Rz33 (\17\:VDD \4\:VDD) resistor r=18.75 c=0
Rz34 (\19\:VDD \4\:VDD) resistor r=37.5 c=0
Rz26 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz27 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz28 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz1 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz7 (\12\:CKNbb \13\:CKNbb) resistor r=75 c=0
Rz5 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz3 (n25 \2\:n25) resistor r=75 c=0
Rz4 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz13 (\10\:n35 \9\:n35) resistor r=75 c=0
Rz9 (n40 \2\:n40) resistor r=75 c=0
Rz10 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz11 (n42 \2\:n42) resistor r=75 c=0
Rz12 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz19 (\17\:qint \16\:qint) resistor r=75 c=0
Ry27 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry28 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry29 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry30 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry31 (\39\:VDD \38\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\10\:VSS \4\:VSS) resistor r=7.75 c=0
Ry18 (\12\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry19 (\14\:VSS \4\:VSS) resistor r=12.4 c=0
Ry20 (\16\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry2 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry5 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry3 (\7\:mout \8\:mout) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry6 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\12\:n35 \11\:n35) resistor r=62 c=0
Ry14 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry15 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Ry7 (n41 \2\:n41) resistor r=62 c=0
Ry8 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx1 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx7 (\5\:SN \7\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx3 (\7\:CKNb \14\:CKNb) resistor r=45 c=0
Rx4 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx5 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx12 (\13\:CKNb \23\:CKNb) resistor r=45 c=0
Rx13 (\5\:CKNb \25\:CKNb) resistor r=45 c=0
Rx14 (\11\:CKNb \26\:CKNb) resistor r=45 c=0
Rx6 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx11 (\2\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (mout \14\:mout) resistor r=45 c=0
Rx15 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx16 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\7\:n35 n35) resistor r=45 c=0
Rx18 (\22\:qbint \20\:qbint) resistor r=45 c=0
Rx19 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx20 (\31\:qbint \4\:qbint) resistor r=45 c=0
Rx21 (\19\:qint qint) resistor r=45 c=0
mn20 (\18\:CKNb \3\:CKN \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04121e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn25 (n21 \3\:D \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.36207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn26 (\7\:n20 \3\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.61e-14 ps=6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=6.36207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn36 (\7\:n20 \3\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=4.11207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn35 (n30 \2\:mout \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.735e-14 ad=3.19e-14 ps=1.7e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.46207e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\12\:CKNbb \9\:CKNb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.735e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98621e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (n25 \2\:RNb \12\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.255e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn32 (\12\:mout \3\:n20 \3\:n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.177e-14 ad=2.32e-14 ps=1.28e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.05e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn30 (\3\:n25 \3\:SN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=7.177e-14 ps=1.2e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=5.1e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn22 (\8\:RNb \1\:RN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn40 (\9\:n35 \10\:CKNb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\3\:n40 \6\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.392e-14 ps=6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn53 (n40 \4\:CKNbb \9\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn52 (\3\:n40 \3\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn50 (n42 \2\:SN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2e-06 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn45_1__rcx (\29\:qbint n35 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.734e-14 ad=3.28e-14 ps=8.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.77439e-07 sb=2e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(2)
mn55_1__rcx (\1\:Q \4\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.722e-14 ad=5.59e-14 ps=1.33e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.27308e-07 sb=2e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.568e-14 ad=4.16e-14 ps=1.385e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72673e-06 sb=1.165e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mn56 (\16\:qint \19\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mp25 (n22 \1\:D \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.55581e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp26 (\5\:n20 CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.50581e-07 sd=160n sca=11.5061 \
        scb=0.00843398 scc=9.91415e-05 m=(1)
mp36 (\5\:n20 CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=6.558e-14 ps=6.7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=4.00581e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp35 (n31 \3\:mout \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.075e-14 ad=2.58e-14 ps=1.48e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=2.35581e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\8\:CKNbb \8\:CKNb \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.075e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.51163e-07 sb=1.4e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp31 (n26 RNb \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.717e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.225e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\7\:mout n20 n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=9.997e-14 ps=7.5e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.02e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\7\:mout \6\:SN \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.9633e-13 ad=9.997e-14 ps=2.79e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5.1e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \3\:RN \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.9633e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\11\:n35 \5\:CKNbb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.482e-14 ad=3.762e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.6e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp53 (\3\:n41 \12\:CKNb \11\:n35 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp51 (n43 \4\:RNb \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp52 (n41 qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp50 (n41 \1\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.605e-14 ad=3.44e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp45 (\27\:qbint n35 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.802e-14 ad=4.96e-14 ps=1.07e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.91855e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp55_1__rcx (Q \4\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.917e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.69167e-07 sb=1.83e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp57_1__rcx (\5\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.727e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61417e-06 sb=9.85e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp56 (\20\:qint \21\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95692e-06 sb=1.4e-07 sd=160n sca=22.2573 \
        scb=0.0184811 scc=0.00198102 m=(1)
ends DFFNSRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:15:38 2012 )
// Library name: gsclib045
// Cell name: DFFNSRXL
// View name: extracted

simulator lang=spectre

subckt DFFNSRXL CKN D Q QN RN SN VDD VSS
mp57 (\1\:QN \4\:qint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.323 \
        scb=0.0325052 scc=0.00592234 m=(1)
C1 (Q VSS) capacitor c=6.65984e-17
C2 (RN VSS) capacitor c=6.00194e-17
C3 (CKN VSS) capacitor c=4.34892e-17
C4 (D VSS) capacitor c=4.86689e-17
C5 (QN VSS) capacitor c=2.25233e-17
C6 (VDD VSS) capacitor c=4.23898e-16
C7 (SN VSS) capacitor c=2.15678e-17
C8 (qint VSS) capacitor c=2.07337e-17
C9 (qbint VSS) capacitor c=4.44265e-17
C10 (RNb VSS) capacitor c=4.84004e-17
C11 (n35 VSS) capacitor c=4.04354e-17
C12 (n42 VSS) capacitor c=7.68926e-17
C13 (n40 VSS) capacitor c=7.90193e-17
C14 (CKNbb VSS) capacitor c=4.457e-17
C15 (mout VSS) capacitor c=4.65253e-17
C16 (CKNb VSS) capacitor c=6.65841e-17
C17 (n25 VSS) capacitor c=7.06158e-17
C18 (n20 VSS) capacitor c=6.26277e-17
C19 (n30 VSS) capacitor c=2.49488e-18
C20 (n41 VSS) capacitor c=1.17405e-16
C21 (n43 VSS) capacitor c=1.48145e-18
C22 (n26 VSS) capacitor c=2.97535e-18
C23 (n31 VSS) capacitor c=3.71866e-18
C24 (n22 VSS) capacitor c=2.41226e-18
C25 (\1\:CKN VSS) capacitor c=2.66629e-17
C26 (\7\:CKNb VSS) capacitor c=6.18728e-17
C27 (\3\:D VSS) capacitor c=5.53251e-17
C28 (\4\:CKNb VSS) capacitor c=7.81057e-17
C29 (\7\:CKNbb VSS) capacitor c=3.46555e-17
C30 (\4\:mout VSS) capacitor c=4.56761e-17
C31 (\5\:SN VSS) capacitor c=5.15549e-17
C32 (\5\:RNb VSS) capacitor c=8.0405e-17
C33 (\3\:CKNbb VSS) capacitor c=3.77013e-17
C34 (\2\:RNb VSS) capacitor c=8.79916e-17
C35 (\8\:qbint VSS) capacitor c=8.98884e-17
C36 (\1\:SN VSS) capacitor c=3.62962e-17
C37 (\1\:RN VSS) capacitor c=3.33612e-17
C38 (\7\:qbint VSS) capacitor c=2.12325e-17
C39 (\4\:qint VSS) capacitor c=2.89774e-17
C40 (\3\:CKN VSS) capacitor c=2.44286e-17
C41 (\8\:CKNb VSS) capacitor c=4.42016e-17
C42 (\1\:D VSS) capacitor c=4.67112e-17
C43 (\8\:CKNbb VSS) capacitor c=6.29893e-17
C44 (\5\:CKNb VSS) capacitor c=6.03781e-17
C45 (\4\:SN VSS) capacitor c=6.63084e-17
C46 (\3\:n20 VSS) capacitor c=3.38404e-17
C47 (\4\:RNb VSS) capacitor c=6.6652e-17
C48 (\2\:CKNb VSS) capacitor c=9.19066e-17
C49 (\9\:qbint VSS) capacitor c=3.99563e-17
C50 (\3\:SN VSS) capacitor c=5.60322e-17
C51 (\3\:n35 VSS) capacitor c=3.35026e-17
C52 (\3\:RN VSS) capacitor c=5.53702e-17
C53 (\5\:qbint VSS) capacitor c=2.17907e-17
C54 (\4\:qbint VSS) capacitor c=3.42759e-17
C55 (\3\:qint VSS) capacitor c=3.01235e-17
C56 (\2\:CKN VSS) capacitor c=1.94453e-17
C57 (\9\:CKNb VSS) capacitor c=1.85861e-17
C58 (\4\:D VSS) capacitor c=2.64363e-17
C59 (\9\:CKNbb VSS) capacitor c=5.93901e-17
C60 (\6\:CKNb VSS) capacitor c=2.22649e-17
C61 (\6\:CKNbb VSS) capacitor c=4.7191e-17
C62 (\3\:mout VSS) capacitor c=1.51143e-17
C63 (\6\:SN VSS) capacitor c=2.83338e-17
C64 (\3\:CKNb VSS) capacitor c=6.31057e-17
C65 (\2\:n20 VSS) capacitor c=4.34056e-17
C66 (\5\:CKNbb VSS) capacitor c=3.1769e-17
C67 (\6\:RNb VSS) capacitor c=2.14967e-17
C68 (\4\:CKNbb VSS) capacitor c=3.34101e-17
C69 (\2\:CKNbb VSS) capacitor c=2.65411e-17
C70 (\3\:RNb VSS) capacitor c=2.20985e-17
C71 (\10\:qbint VSS) capacitor c=2.86165e-17
C72 (\2\:SN VSS) capacitor c=4.30641e-17
C73 (\2\:n35 VSS) capacitor c=3.10728e-17
C74 (\2\:RN VSS) capacitor c=4.25917e-17
C75 (\14\:VDD VSS) capacitor c=2.95975e-17
C76 (\15\:CKNb VSS) capacitor c=4.97873e-17
C77 (\12\:CKNbb VSS) capacitor c=1.63654e-17
C78 (\16\:VDD VSS) capacitor c=3.62666e-17
C79 (\7\:n20 VSS) capacitor c=8.31349e-17
C80 (\18\:VDD VSS) capacitor c=1.40059e-17
C81 (\10\:mout VSS) capacitor c=2.81197e-17
C82 (\20\:VDD VSS) capacitor c=2.68511e-17
C83 (\15\:mout VSS) capacitor c=5.26599e-17
C84 (\7\:n35 VSS) capacitor c=2.72925e-17
C85 (\22\:VDD VSS) capacitor c=3.22287e-17
C86 (\3\:n41 VSS) capacitor c=1.11272e-16
C87 (\24\:VDD VSS) capacitor c=3.03968e-17
C88 (\16\:qbint VSS) capacitor c=7.90823e-17
C89 (\10\:RNb VSS) capacitor c=2.50714e-17
C90 (\26\:VDD VSS) capacitor c=2.86059e-17
C91 (\1\:Q VSS) capacitor c=4.52867e-17
C92 (\5\:qint VSS) capacitor c=3.50362e-17
C93 (\28\:VDD VSS) capacitor c=4.22313e-17
C94 (\1\:QN VSS) capacitor c=1.99589e-17
C95 (\1\:VDD VSS) capacitor c=8.14952e-17
C96 (\13\:CKNb VSS) capacitor c=6.47609e-17
C97 (\17\:CKNbb VSS) capacitor c=6.39832e-17
C98 (\4\:n20 VSS) capacitor c=4.86476e-17
C99 (\3\:n25 VSS) capacitor c=8.4057e-17
C100 (\8\:mout VSS) capacitor c=4.31177e-17
C101 (\13\:mout VSS) capacitor c=5.10741e-17
C102 (\4\:n35 VSS) capacitor c=5.46697e-17
C103 (\3\:n40 VSS) capacitor c=8.87197e-17
C104 (\3\:n42 VSS) capacitor c=1.04154e-16
C105 (\13\:qbint VSS) capacitor c=5.7631e-17
C106 (\12\:RNb VSS) capacitor c=1.08001e-16
C107 (\3\:Q VSS) capacitor c=4.93379e-17
C108 (\9\:qint VSS) capacitor c=2.68122e-17
C109 (\3\:QN VSS) capacitor c=3.4793e-17
C110 (\2\:qint VSS) capacitor c=1.25949e-17
C111 (\2\:qbint VSS) capacitor c=5.61057e-17
C112 (\3\:qbint VSS) capacitor c=3.2131e-17
C113 (\2\:mout VSS) capacitor c=3.3536e-17
C114 (\2\:D VSS) capacitor c=4.43766e-17
C115 (\7\:qint VSS) capacitor c=2.66718e-17
C116 (\8\:qint VSS) capacitor c=3.02675e-17
C117 (\4\:RN VSS) capacitor c=6.4447e-17
C118 (\11\:qbint VSS) capacitor c=6.16128e-17
C119 (\12\:qbint VSS) capacitor c=9.00629e-17
C120 (\15\:qbint VSS) capacitor c=1.13719e-16
C121 (\6\:n35 VSS) capacitor c=1.66052e-16
C122 (\9\:n35 VSS) capacitor c=1.49373e-16
C123 (\10\:CKNbb VSS) capacitor c=7.83994e-17
C124 (\11\:CKNbb VSS) capacitor c=1.17875e-16
C125 (\7\:RNb VSS) capacitor c=1.52673e-16
C126 (\8\:RNb VSS) capacitor c=2.29376e-16
C127 (\9\:RNb VSS) capacitor c=1.31059e-16
C128 (\7\:SN VSS) capacitor c=2.88822e-16
C129 (\8\:SN VSS) capacitor c=3.04659e-16
C130 (\9\:SN VSS) capacitor c=2.81319e-17
C131 (\5\:mout VSS) capacitor c=5.06211e-17
C132 (\6\:mout VSS) capacitor c=6.29826e-17
C133 (\7\:mout VSS) capacitor c=7.1203e-17
C134 (\12\:mout VSS) capacitor c=4.85614e-17
C135 (\6\:n20 VSS) capacitor c=1.10545e-16
C136 (\9\:n20 VSS) capacitor c=8.67105e-17
C137 (\5\:D VSS) capacitor c=5.50603e-17
C138 (\14\:CKNbb VSS) capacitor c=6.05212e-17
C139 (\15\:CKNbb VSS) capacitor c=1.64021e-16
C140 (\16\:CKNbb VSS) capacitor c=2.16852e-16
C141 (\19\:CKNbb VSS) capacitor c=1.28694e-17
C142 (\20\:CKNbb VSS) capacitor c=2.26515e-17
C143 (\21\:CKNbb VSS) capacitor c=3.55344e-17
C144 (\10\:CKNb VSS) capacitor c=7.54358e-17
C145 (\11\:CKNb VSS) capacitor c=8.12676e-17
C146 (\12\:CKNb VSS) capacitor c=5.87364e-17
C147 (\4\:CKN VSS) capacitor c=3.28306e-17
C148 (\3\:VDD VSS) capacitor c=7.87161e-18
C149 (\4\:VDD VSS) capacitor c=1.01169e-17
C150 (\6\:VDD VSS) capacitor c=4.89925e-17
C151 (\7\:VDD VSS) capacitor c=3.04754e-17
C152 (\9\:VDD VSS) capacitor c=3.94838e-17
C153 (\10\:VDD VSS) capacitor c=3.27727e-17
C154 (\12\:VDD VSS) capacitor c=1.54747e-17
C155 (\13\:VDD VSS) capacitor c=1.26598e-17
Rk6 (\2\:Q Q) resistor r=0.3038 c=0
Rk7 (Q \4\:Q) resistor r=0.1889 c=0
Rk51 (\2\:VSS \4\:VSS) resistor r=0.07411 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.2006 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.1904 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.3924 c=0
Rk55 (\7\:VSS \8\:VSS) resistor r=0.1669 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=1.1525 c=0
Rk57 (\9\:VSS \10\:VSS) resistor r=0.04901 c=0
Rk58 (\10\:VSS \11\:VSS) resistor r=0.3384 c=0
Rk59 (\11\:VSS \12\:VSS) resistor r=0.2905 c=0
Rk61 (\13\:VSS VSS) resistor r=0.1001 c=0
Rk60 (\12\:VSS \13\:VSS) resistor r=0.1227 c=0
Rk62 (\6\:VSS \15\:VSS) resistor r=0.07393 c=0
Rk63 (\7\:VSS \17\:VSS) resistor r=0.04331 c=0
Rk64 (\9\:VSS \19\:VSS) resistor r=0.04331 c=0
Rk65 (\11\:VSS \21\:VSS) resistor r=0.379 c=0
Rk66 (\12\:VSS \23\:VSS) resistor r=0.07393 c=0
Rk8 (\4\:RN RN) resistor r=0.04551 c=0
Rk50 (\4\:CKN CKN) resistor r=0.07373 c=0
Rk38 (\5\:D D) resistor r=0.07439 c=0
Rk2 (\4\:QN QN) resistor r=0.08804 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk67 (\2\:VDD \3\:VDD) resistor r=0.03993 c=0
Rk68 (\3\:VDD \4\:VDD) resistor r=0.3357 c=0
Rk69 (\4\:VDD \5\:VDD) resistor r=0.07504 c=0
Rk70 (\5\:VDD \6\:VDD) resistor r=0.3685 c=0
Rk71 (\6\:VDD \7\:VDD) resistor r=0.4526 c=0
Rk72 (\7\:VDD \8\:VDD) resistor r=0.0791 c=0
Rk73 (\8\:VDD \9\:VDD) resistor r=0.4202 c=0
Rk74 (\9\:VDD \10\:VDD) resistor r=0.3287 c=0
Rk75 (\10\:VDD \11\:VDD) resistor r=0.35 c=0
Rk76 (\11\:VDD \12\:VDD) resistor r=0.03241 c=0
Rk78 (\13\:VDD VDD) resistor r=0.2077 c=0
Rk77 (\12\:VDD \13\:VDD) resistor r=0.3106 c=0
Rk79 (\3\:VDD \15\:VDD) resistor r=0.4181 c=0
Rk80 (\4\:VDD \17\:VDD) resistor r=0.2621 c=0
Rk81 (\6\:VDD \19\:VDD) resistor r=0.07393 c=0
Rk82 (\7\:VDD \21\:VDD) resistor r=0.04331 c=0
Rk83 (\9\:VDD \23\:VDD) resistor r=0.04331 c=0
Rk84 (\10\:VDD \25\:VDD) resistor r=0.04331 c=0
Rk85 (\12\:VDD \27\:VDD) resistor r=0.2054 c=0
Rk86 (\13\:VDD \29\:VDD) resistor r=0.4181 c=0
Rk26 (\8\:SN SN) resistor r=0.003077 c=0
Rk25 (\7\:SN \8\:SN) resistor r=2.1683 c=0
Rk27 (\8\:SN \9\:SN) resistor r=0.08618 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1178 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1194 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1058 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.3368 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.101 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.6754 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.4463 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=0.9732 c=0
Rk21 (\8\:RNb \9\:RNb) resistor r=0.669 c=0
Rk22 (\9\:RNb \11\:RNb) resistor r=0.05532 c=0
Rk23 (\9\:RNb \13\:RNb) resistor r=0.5816 c=0
Rk16 (\5\:n35 \6\:n35) resistor r=0.276 c=0
Rk17 (\6\:n35 \8\:n35) resistor r=0.076 c=0
Rk18 (\6\:n35 \9\:n35) resistor r=1.0707 c=0
Rk13 (\2\:n42 \4\:n42) resistor r=0.6107 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=0.5088 c=0
Rk19 (\10\:CKNbb \11\:CKNbb) resistor r=0.51 c=0
Rk39 (\13\:CKNbb \14\:CKNbb) resistor r=0.07429 c=0
Rk40 (\14\:CKNbb \15\:CKNbb) resistor r=0.2756 c=0
Rk41 (\15\:CKNbb \16\:CKNbb) resistor r=1.4921 c=0
Rk42 (\14\:CKNbb \18\:CKNbb) resistor r=0.3929 c=0
Rk43 (\15\:CKNbb \19\:CKNbb) resistor r=0.1018 c=0
Rk44 (\19\:CKNbb \20\:CKNbb) resistor r=0.06586 c=0
Rk45 (\19\:CKNbb \21\:CKNbb) resistor r=0.142 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.2852 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.3496 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.1396 c=0
Rk31 (\6\:mout \11\:mout) resistor r=0.08669 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.2373 c=0
Rk33 (\12\:mout \14\:mout) resistor r=0.1472 c=0
Rk34 (\12\:mout \16\:mout) resistor r=0.278 c=0
Rk46 (\10\:CKNb \11\:CKNb) resistor r=0.5205 c=0
Rk47 (\11\:CKNb \12\:CKNb) resistor r=0.3998 c=0
Rk48 (\12\:CKNb \14\:CKNb) resistor r=0.1977 c=0
Rk49 (\14\:CKNb \16\:CKNb) resistor r=0.4074 c=0
Rk24 (\2\:n25 \4\:n25) resistor r=0.5039 c=0
Rk35 (\5\:n20 \6\:n20) resistor r=0.3371 c=0
Rk36 (\6\:n20 \8\:n20) resistor r=0.4144 c=0
Rk37 (\6\:n20 \9\:n20) resistor r=0.4839 c=0
Rk15 (\2\:n41 \4\:n41) resistor r=0.6358 c=0
Rl10 (\1\:RN \2\:RN) resistor r=58.3841 c=0
Rl11 (\2\:RN \3\:RN) resistor r=135.307 c=0
Rl43 (\1\:CKN \2\:CKN) resistor r=85.3072 c=0
Rl44 (\2\:CKN \3\:CKN) resistor r=29.5379 c=0
Rl39 (\2\:D \3\:D) resistor r=122.865 c=0
Rl38 (\1\:D \2\:D) resistor r=50.4153 c=0
Rl40 (\2\:D \4\:D) resistor r=5.1011 c=0
Rl29 (\4\:SN \5\:SN) resistor r=161.104 c=0
Rl30 (\5\:SN \6\:SN) resistor r=73.7687 c=0
Rl14 (\1\:SN \2\:SN) resistor r=36.7742 c=0
Rl15 (\2\:SN \3\:SN) resistor r=91.8219 c=0
Rl1 (qint \2\:qint) resistor r=2.0213 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=142.308 c=0
Rl17 (\9\:qbint \10\:qbint) resistor r=42.0567 c=0
Rl4 (qbint \2\:qbint) resistor r=173.531 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=38.9161 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.7659 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=35.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=53.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=143.992 c=0
Rl18 (RNb \2\:RNb) resistor r=222.643 c=0
Rl23 (\4\:RNb \5\:RNb) resistor r=157.258 c=0
Rl24 (\5\:RNb \6\:RNb) resistor r=124.513 c=0
Rl19 (\2\:RNb \3\:RNb) resistor r=62.2302 c=0
Rl12 (n35 \2\:n35) resistor r=87.2302 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl37 (\8\:CKNbb \9\:CKNbb) resistor r=79.5379 c=0
Rl34 (\6\:CKNbb \7\:CKNbb) resistor r=61.4557 c=0
Rl21 (\3\:CKNbb \4\:CKNbb) resistor r=24.2328 c=0
Rl22 (\4\:CKNbb \5\:CKNbb) resistor r=114.412 c=0
Rl20 (CKNbb \2\:CKNbb) resistor r=93.4636 c=0
Rl31 (mout \2\:mout) resistor r=106.972 c=0
Rl33 (\2\:mout \4\:mout) resistor r=78.5603 c=0
Rl32 (\2\:mout \3\:mout) resistor r=2.0166 c=0
Rl41 (\7\:CKNb \8\:CKNb) resistor r=187.381 c=0
Rl35 (\4\:CKNb \5\:CKNb) resistor r=202.895 c=0
Rl27 (CKNb \2\:CKNb) resistor r=151.054 c=0
Rl42 (\8\:CKNb \9\:CKNb) resistor r=29.5379 c=0
Rl36 (\5\:CKNb \6\:CKNb) resistor r=29.5379 c=0
Rl28 (\2\:CKNb \3\:CKNb) resistor r=451.436 c=0
Rl25 (n20 \2\:n20) resistor r=85.7713 c=0
Rl26 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz18 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz24 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz25 (\1\:VDD \5\:VDD) resistor r=9.375 c=0
Rz26 (\1\:VDD \8\:VDD) resistor r=7.5 c=0
Rz27 (\1\:VDD \11\:VDD) resistor r=6.25 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz16 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz13 (\8\:mout \9\:mout) resistor r=75 c=0
Rz14 (\13\:mout \14\:mout) resistor r=75 c=0
Rz17 (\13\:CKNb \14\:CKNb) resistor r=75 c=0
Rz11 (n25 \2\:n25) resistor r=75 c=0
Rz12 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz15 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry15 (\3\:VSS \5\:VSS) resistor r=20.6667 c=0
Ry16 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry17 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \13\:VSS) resistor r=20.6667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry19 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry23 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry24 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry25 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry26 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\7\:n35 \8\:n35) resistor r=62 c=0
Ry12 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\10\:mout \11\:mout) resistor r=62 c=0
Ry10 (\15\:mout \16\:mout) resistor r=62 c=0
Ry13 (\15\:CKNb \16\:CKNb) resistor r=62 c=0
Ry11 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx14 (\4\:D \5\:D) resistor r=45 c=0
Rx10 (\6\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \9\:SN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \15\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \9\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\4\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \20\:CKNbb) resistor r=45 c=0
Rx17 (\6\:CKNbb \21\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx18 (\3\:CKNb \10\:CKNb) resistor r=45 c=0
Rx19 (\6\:CKNb \11\:CKNb) resistor r=45 c=0
Rx20 (\9\:CKNb \12\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn22 (\12\:RNb \3\:RN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.553e-14 ps=6.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=2.45e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn45 (\13\:qbint \3\:n35 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=2.03e-14 ps=1.68e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (\3\:n42 \3\:SN \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.755e-14 ps=1.68e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=7.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn52 (n40 \9\:qbint \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=4.568e-14 ps=6.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (n40 RNb n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=4.568e-14 ps=5.7e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn53 (\3\:n40 CKNbb \4\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\4\:n35 \2\:CKNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn31 (n25 \4\:RNb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.815e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn32 (\8\:mout \3\:n20 \3\:n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.393e-14 ps=9.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.605e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\3\:n25 \4\:SN \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=4.93e-14 ps=1.6e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n30 mout \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.973e-14 ps=1.6e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=9.55e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\4\:n20 \5\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=7.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\13\:CKNb \3\:CKN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.84e-14 ad=2.465e-14 ps=1.25e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1e-07 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn26 (\4\:n20 \8\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \1\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.625e-14 ad=1.305e-14 ps=1.66e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\17\:CKNbb \8\:CKNb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0147 \
        scb=0.0290717 scc=0.00588507 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp22 (\10\:RNb \1\:RN \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp45 (\16\:qbint n35 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (\3\:n41 \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.44e-14 ps=1.64e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.65e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (n43 \2\:RNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0103e-13 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.55e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp53 (n41 CKNb \7\:n35 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.115e-14 ad=3.118e-14 ps=8.7e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.36628e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n35 \3\:CKNbb \15\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=4.115e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4093e-07 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp31 (n26 \5\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=1.612e-14 ps=2.1e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63953e-07 sb=1.05849e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp32 (\10\:mout n20 n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=5.16e-14 ps=5.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.83953e-07 sb=9.38488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp30 (\10\:mout \5\:SN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.905e-14 ad=5.16e-14 ps=1.71e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.68953e-07 sb=6.53488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp35 (n31 \4\:mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.905e-14 ad=3.87e-14 ps=1.71e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.26977e-07 sb=9.95e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp36 (\7\:n20 \7\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.51977e-07 sb=7.7e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp26 (\7\:n20 \4\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.56977e-07 sb=5.65e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp25 (n22 \3\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17698e-06 sb=3.45e-07 sd=160n sca=10.8251 \
        scb=0.00858217 scc=0.000148871 m=(1)
mp21 (\12\:CKNbb \7\:CKNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38198e-06 sb=1.4e-07 sd=160n sca=11.384 \
        scb=0.00879424 scc=0.00014895 m=(1)
mp20 (\15\:CKNb \1\:CKN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
ends DFFNSRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:16:24 2012 )
// Library name: gsclib045
// Cell name: DFFQX1
// View name: extracted

simulator lang=spectre

subckt DFFQX1 CK D Q VDD VSS
mp55 (\1\:Q \4\:qbint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.70897e-07 sd=160n sca=21.8895 \
        scb=0.024842 scc=0.00105464 m=(1)
C1 (D VSS) capacitor c=1.31482e-16
C2 (VDD VSS) capacitor c=2.64831e-16
C3 (CK VSS) capacitor c=1.15578e-16
C4 (Q VSS) capacitor c=5.24883e-17
C5 (qbint VSS) capacitor c=1.93978e-17
C6 (CKb VSS) capacitor c=2.14114e-17
C7 (n30 VSS) capacitor c=3.38134e-17
C8 (n35 VSS) capacitor c=3.63289e-18
C9 (mout VSS) capacitor c=4.31791e-17
C10 (CKbb VSS) capacitor c=4.94666e-17
C11 (n20 VSS) capacitor c=3.17063e-17
C12 (n25 VSS) capacitor c=1.27446e-18
C13 (n21 VSS) capacitor c=1.25e-18
C14 (n36 VSS) capacitor c=1.26428e-18
C15 (n26 VSS) capacitor c=1.13617e-18
C16 (n22 VSS) capacitor c=3.43716e-18
C17 (\10\:CKb VSS) capacitor c=4.11811e-17
C18 (\3\:D VSS) capacitor c=3.06337e-17
C19 (\5\:CKbb VSS) capacitor c=6.68602e-17
C20 (\5\:CKb VSS) capacitor c=5.36028e-17
C21 (\4\:mout VSS) capacitor c=9.18291e-17
C22 (\4\:n20 VSS) capacitor c=3.9671e-17
C23 (\2\:CKbb VSS) capacitor c=4.63827e-17
C24 (\5\:qbint VSS) capacitor c=6.613e-17
C25 (\3\:n30 VSS) capacitor c=3.57253e-17
C26 (\3\:CK VSS) capacitor c=4.05613e-17
C27 (\4\:qbint VSS) capacitor c=6.04049e-17
C28 (\8\:CKb VSS) capacitor c=2.99003e-17
C29 (\1\:D VSS) capacitor c=6.88849e-17
C30 (\6\:CKb VSS) capacitor c=5.70442e-17
C31 (\6\:CKbb VSS) capacitor c=5.17265e-17
C32 (\3\:n20 VSS) capacitor c=5.07844e-17
C33 (\3\:CKbb VSS) capacitor c=3.46802e-17
C34 (\3\:CKb VSS) capacitor c=6.44912e-17
C35 (\8\:qbint VSS) capacitor c=3.64212e-17
C36 (\1\:CK VSS) capacitor c=5.75665e-17
C37 (\3\:qbint VSS) capacitor c=3.61688e-17
C38 (\9\:CKb VSS) capacitor c=4.90056e-17
C39 (\2\:D VSS) capacitor c=5.84233e-17
C40 (\7\:CKb VSS) capacitor c=5.51338e-17
C41 (\7\:CKbb VSS) capacitor c=2.50808e-17
C42 (\4\:CKb VSS) capacitor c=5.41985e-17
C43 (\3\:mout VSS) capacitor c=3.22378e-17
C44 (\4\:CKbb VSS) capacitor c=4.46851e-17
C45 (\2\:CKb VSS) capacitor c=6.50861e-17
C46 (\7\:qbint VSS) capacitor c=3.32248e-17
C47 (\4\:n30 VSS) capacitor c=3.23236e-17
C48 (\2\:CK VSS) capacitor c=4.12094e-17
C49 (\8\:CKbb VSS) capacitor c=4.50744e-17
C50 (\9\:VDD VSS) capacitor c=3.54451e-17
C51 (\9\:n20 VSS) capacitor c=6.56181e-17
C52 (\11\:VDD VSS) capacitor c=2.19349e-17
C53 (\9\:mout VSS) capacitor c=6.37102e-17
C54 (\9\:n30 VSS) capacitor c=6.41559e-17
C55 (\13\:VDD VSS) capacitor c=2.40564e-17
C56 (\14\:qbint VSS) capacitor c=5.56162e-17
C57 (\15\:CKb VSS) capacitor c=1.67306e-16
C58 (\15\:VDD VSS) capacitor c=3.31385e-17
C59 (\1\:Q VSS) capacitor c=5.20681e-17
C60 (\1\:VDD VSS) capacitor c=8.79713e-17
C61 (\14\:CKbb VSS) capacitor c=1.52351e-17
C62 (\5\:n20 VSS) capacitor c=7.63324e-17
C63 (\7\:mout VSS) capacitor c=3.34949e-17
C64 (\5\:n30 VSS) capacitor c=5.87975e-17
C65 (\11\:qbint VSS) capacitor c=9.48758e-17
C66 (\19\:CKb VSS) capacitor c=1.11432e-16
C67 (\3\:Q VSS) capacitor c=1.80893e-17
C68 (\2\:qbint VSS) capacitor c=2.32666e-17
C69 (\2\:n30 VSS) capacitor c=3.05532e-17
C70 (\6\:qbint VSS) capacitor c=3.60803e-17
C71 (\2\:n20 VSS) capacitor c=3.66057e-17
C72 (\2\:mout VSS) capacitor c=4.59938e-17
C73 (\9\:qbint VSS) capacitor c=4.21427e-17
C74 (\10\:qbint VSS) capacitor c=5.06052e-17
C75 (\13\:qbint VSS) capacitor c=1.36564e-16
C76 (\7\:n30 VSS) capacitor c=6.72671e-17
C77 (\8\:n30 VSS) capacitor c=4.13492e-17
C78 (\5\:mout VSS) capacitor c=4.07782e-17
C79 (\6\:mout VSS) capacitor c=6.17599e-17
C80 (\7\:n20 VSS) capacitor c=7.82952e-17
C81 (\8\:n20 VSS) capacitor c=3.19165e-17
C82 (\11\:CKb VSS) capacitor c=7.28318e-17
C83 (\12\:CKb VSS) capacitor c=6.88634e-17
C84 (\13\:CKb VSS) capacitor c=1.18894e-16
C85 (\14\:CKb VSS) capacitor c=1.8516e-16
C86 (\17\:CKb VSS) capacitor c=3.28926e-17
C87 (\18\:CKb VSS) capacitor c=5.00548e-17
C88 (\10\:CKbb VSS) capacitor c=1.21258e-16
C89 (\11\:CKbb VSS) capacitor c=1.78395e-16
C90 (\12\:CKbb VSS) capacitor c=1.28204e-16
C91 (\13\:CKbb VSS) capacitor c=5.89466e-17
C92 (\3\:VDD VSS) capacitor c=1.28311e-18
C93 (\5\:VDD VSS) capacitor c=3.23989e-17
C94 (\7\:VDD VSS) capacitor c=1.90719e-17
C95 (\8\:VDD VSS) capacitor c=2.30763e-17
Rk17 (D \4\:D) resistor r=0.006754 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.0826 c=0
Rk31 (\3\:VSS \4\:VSS) resistor r=0.1679 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2281 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.5242 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.06253 c=0
Rk36 (\8\:VSS VSS) resistor r=0.125 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.3634 c=0
Rk37 (\3\:VSS \10\:VSS) resistor r=0.3606 c=0
Rk38 (\5\:VSS \12\:VSS) resistor r=0.1299 c=0
Rk39 (\7\:VSS \14\:VSS) resistor r=0.3706 c=0
Rk40 (\8\:VSS \16\:VSS) resistor r=0.2547 c=0
Rk41 (\2\:VDD \3\:VDD) resistor r=0.1077 c=0
Rk42 (\3\:VDD \4\:VDD) resistor r=0.1428 c=0
Rk43 (\4\:VDD \5\:VDD) resistor r=0.2999 c=0
Rk44 (\5\:VDD \6\:VDD) resistor r=0.4505 c=0
Rk45 (\6\:VDD \7\:VDD) resistor r=0.05154 c=0
Rk47 (\8\:VDD VDD) resistor r=0.125 c=0
Rk46 (\7\:VDD \8\:VDD) resistor r=0.3725 c=0
Rk48 (\3\:VDD \10\:VDD) resistor r=0.232 c=0
Rk49 (\5\:VDD \12\:VDD) resistor r=0.04334 c=0
Rk50 (\7\:VDD \14\:VDD) resistor r=0.04334 c=0
Rk51 (\8\:VDD \16\:VDD) resistor r=0.2063 c=0
Rk3 (\4\:CK CK) resistor r=0.003008 c=0
Rk1 (\2\:Q Q) resistor r=0.3432 c=0
Rk2 (Q \4\:Q) resistor r=0.06947 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1472 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.2486 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.7919 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.2188 c=0
Rk18 (\11\:CKb \12\:CKb) resistor r=0.3178 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.179 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.9691 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.7408 c=0
Rk22 (\13\:CKb \17\:CKb) resistor r=0.1169 c=0
Rk23 (\14\:CKb \18\:CKb) resistor r=0.2253 c=0
Rk24 (\16\:CKb \20\:CKb) resistor r=0.6646 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.473 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.1426 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.235 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.1256 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1685 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3693 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.3743 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.7505 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=0.9062 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.2986 c=0
Rk29 (\10\:CKbb \15\:CKbb) resistor r=0.09559 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.5238 c=0
Rk15 (\7\:n20 \8\:n20) resistor r=0.09453 c=0
Rk16 (\7\:n20 \10\:n20) resistor r=0.3553 c=0
Rl27 (\2\:D \3\:D) resistor r=41.5405 c=0
Rl26 (\1\:D \2\:D) resistor r=137.694 c=0
Rl5 (\2\:CK \3\:CK) resistor r=54.9442 c=0
Rl4 (\1\:CK \2\:CK) resistor r=153.021 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=130.483 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=111.253 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=88.1757 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=9.8995 c=0
Rl29 (\9\:CKb \10\:CKb) resistor r=99.5316 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=82.9508 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=89.8977 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=53.733 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=213.278 c=0
Rl6 (n30 \2\:n30) resistor r=151.076 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=51.0755 c=0
Rl8 (\2\:n30 \4\:n30) resistor r=13.6663 c=0
Rl19 (mout \2\:mout) resistor r=82.6702 c=0
Rl21 (\2\:mout \4\:mout) resistor r=151.605 c=0
Rl20 (\2\:mout \3\:mout) resistor r=32.6176 c=0
Rl12 (CKbb \2\:CKbb) resistor r=68.7438 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=207.692 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=78.079 c=0
Rl16 (n20 \2\:n20) resistor r=10.9374 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=79.6488 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=118.11 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz11 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz14 (\1\:VDD \6\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry8 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry9 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry10 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry11 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry12 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx8 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx14 (CKbb \13\:CKbb) resistor r=45 c=0
Rx6 (n20 \8\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.18462e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mn20 (\19\:CKb \1\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn45 (\11\:qbint n30 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn50 (n35 \8\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.698e-14 ps=5.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.895e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\5\:n30 \3\:CKbb \7\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.595e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\7\:mout \3\:n20 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.758e-14 ad=3.045e-14 ps=1.61e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.34e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n25 mout \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.758e-14 ad=2.465e-14 ps=1.61e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=9.6e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (\5\:n20 \6\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.045e-14 ps=6.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=7.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.045e-14 ps=4.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=4.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn25 (n21 \1\:D \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.85e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn21 (\14\:CKbb \8\:CKb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mp20 (\15\:CKb \3\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=4.193e-14 ps=1.12e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.95e-07 sd=160n sca=12.8473 \
        scb=0.0101159 scc=8.80993e-05 m=(1)
mp45 (\14\:qbint \3\:n30 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.55e-14 ad=3.01e-14 ps=1.34e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.2815 scb=0.00760864 \
        scc=8.81378e-05 m=(1)
mp50 (n36 \5\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.55e-14 ad=1.935e-14 ps=1.34e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp51 (\9\:n30 \2\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.515e-14 ps=6.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.975e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp40 (\9\:n30 CKb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.515e-14 ps=1.04e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.72e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp30 (\9\:mout \4\:n20 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.55e-14 ad=6.558e-14 ps=1.34e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.37e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp35 (n26 \4\:mout \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.55e-14 ad=1.29e-14 ps=1.34e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.105e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp36 (\9\:n20 \5\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1e-06 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp21 (\8\:CKbb \10\:CKb \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.5e-07 sd=160n sca=16.5578 scb=0.0165885 \
        scc=0.000310105 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.87e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=7.75e-07 sd=160n sca=10.5668 \
        scb=0.00768563 scc=8.81513e-05 m=(1)
mp25 (n22 \3\:D \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.913e-14 ps=7.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.55e-07 sd=160n sca=12.3276 \
        scb=0.00937389 scc=9.38578e-05 m=(1)
ends DFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:17:02 2012 )
// Library name: gsclib045
// Cell name: DFFQX2
// View name: extracted

simulator lang=spectre

subckt DFFQX2 CK D Q VDD VSS
mp20 (\22\:CKb \3\:CK \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
C1 (VDD VSS) capacitor c=2.04641e-16
C2 (D VSS) capacitor c=3.80201e-17
C3 (CK VSS) capacitor c=3.44359e-17
C4 (Q VSS) capacitor c=4.5031e-17
C5 (CKb VSS) capacitor c=5.40445e-17
C6 (CKbb VSS) capacitor c=6.82351e-17
C7 (n20 VSS) capacitor c=3.18023e-17
C8 (n25 VSS) capacitor c=1.40643e-18
C9 (mout VSS) capacitor c=2.03142e-17
C10 (n30 VSS) capacitor c=2.40202e-17
C11 (qbint VSS) capacitor c=1.54248e-16
C12 (n22 VSS) capacitor c=2.69733e-19
C13 (n26 VSS) capacitor c=1.67182e-18
C14 (n36 VSS) capacitor c=3.16269e-18
C15 (\3\:n30 VSS) capacitor c=5.8176e-17
C16 (\10\:qbint VSS) capacitor c=4.4321e-17
C17 (\4\:CKbb VSS) capacitor c=3.27617e-17
C18 (\8\:CKb VSS) capacitor c=3.23945e-17
C19 (\4\:mout VSS) capacitor c=7.6512e-17
C20 (\6\:CKb VSS) capacitor c=6.13631e-17
C21 (\3\:CKbb VSS) capacitor c=3.09365e-17
C22 (\3\:D VSS) capacitor c=7.20972e-17
C23 (\3\:CK VSS) capacitor c=2.23646e-17
C24 (\5\:qbint VSS) capacitor c=5.31157e-17
C25 (\10\:CKb VSS) capacitor c=9.10489e-17
C26 (\6\:CKbb VSS) capacitor c=5.05921e-17
C27 (\3\:n20 VSS) capacitor c=3.96731e-17
C28 (\3\:mout VSS) capacitor c=3.4957e-17
C29 (\4\:CKb VSS) capacitor c=5.80615e-17
C30 (\1\:D VSS) capacitor c=4.0295e-17
C31 (\2\:CKb VSS) capacitor c=4.3372e-17
C32 (\1\:CK VSS) capacitor c=2.28838e-17
C33 (\2\:n30 VSS) capacitor c=3.8291e-17
C34 (\5\:CKbb VSS) capacitor c=8.1484e-17
C35 (\11\:CKb VSS) capacitor c=3.34767e-17
C36 (\9\:CKb VSS) capacitor c=2.96793e-17
C37 (\2\:n20 VSS) capacitor c=4.31767e-17
C38 (\7\:CKb VSS) capacitor c=3.5818e-17
C39 (\5\:CKb VSS) capacitor c=2.63703e-17
C40 (\2\:CKbb VSS) capacitor c=7.3507e-17
C41 (\2\:D VSS) capacitor c=5.30917e-17
C42 (\3\:CKb VSS) capacitor c=1.99774e-17
C43 (\2\:CK VSS) capacitor c=2.32902e-17
C44 (\15\:qbint VSS) capacitor c=3.21114e-17
C45 (\1\:VDD VSS) capacitor c=1.19769e-16
C46 (\1\:Q VSS) capacitor c=5.36575e-17
C47 (\8\:n30 VSS) capacitor c=8.8026e-17
C48 (\5\:mout VSS) capacitor c=6.67304e-17
C49 (\10\:VDD VSS) capacitor c=3.27592e-17
C50 (\5\:n20 VSS) capacitor c=1.3635e-16
C51 (\13\:VDD VSS) capacitor c=3.68375e-17
C52 (\13\:CKbb VSS) capacitor c=1.62336e-17
C53 (\22\:CKb VSS) capacitor c=6.01397e-17
C54 (\16\:VDD VSS) capacitor c=2.4992e-17
C55 (\3\:VDD VSS) capacitor c=1.0755e-16
C56 (\11\:qbint VSS) capacitor c=3.72753e-17
C57 (\3\:Q VSS) capacitor c=5.76015e-17
C58 (\6\:n30 VSS) capacitor c=3.48963e-17
C59 (\9\:mout VSS) capacitor c=6.45718e-17
C60 (\7\:n20 VSS) capacitor c=7.50349e-17
C61 (\10\:CKbb VSS) capacitor c=8.29046e-17
C62 (\20\:CKb VSS) capacitor c=7.624e-17
C63 (\2\:mout VSS) capacitor c=3.71468e-17
C64 (\4\:qbint VSS) capacitor c=4.90001e-17
C65 (\4\:CK VSS) capacitor c=5.74823e-17
C66 (\4\:D VSS) capacitor c=5.48994e-17
C67 (\4\:n20 VSS) capacitor c=7.94978e-17
C68 (\7\:mout VSS) capacitor c=7.26733e-17
C69 (\8\:mout VSS) capacitor c=5.26211e-17
C70 (\12\:CKb VSS) capacitor c=9.1329e-17
C71 (\13\:CKb VSS) capacitor c=1.34302e-16
C72 (\14\:CKb VSS) capacitor c=1.41608e-16
C73 (\15\:CKb VSS) capacitor c=8.48622e-17
C74 (\16\:CKb VSS) capacitor c=7.4831e-17
C75 (\17\:CKb VSS) capacitor c=4.10391e-17
C76 (\18\:CKb VSS) capacitor c=5.21779e-17
C77 (\7\:CKbb VSS) capacitor c=1.9348e-16
C78 (\8\:CKbb VSS) capacitor c=2.02161e-16
C79 (\9\:CKbb VSS) capacitor c=5.76623e-17
C80 (\12\:CKbb VSS) capacitor c=2.44782e-17
C81 (\4\:n30 VSS) capacitor c=1.54218e-16
C82 (\5\:n30 VSS) capacitor c=1.47766e-16
C83 (\13\:qbint VSS) capacitor c=4.29137e-17
C84 (\14\:qbint VSS) capacitor c=5.32646e-17
C85 (\9\:VDD VSS) capacitor c=2.08471e-17
C86 (\15\:VDD VSS) capacitor c=1.02427e-17
Rk49 (\1\:VDD \8\:VDD) resistor r=0.2631 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.2606 c=0
Rk51 (\9\:VDD \11\:VDD) resistor r=0.1025 c=0
Rk52 (\9\:VDD \12\:VDD) resistor r=0.391 c=0
Rk53 (\12\:VDD \14\:VDD) resistor r=0.307 c=0
Rk56 (\15\:VDD VDD) resistor r=0.03967 c=0
Rk54 (\12\:VDD \15\:VDD) resistor r=0.4116 c=0
Rk55 (\15\:VDD \17\:VDD) resistor r=0.4175 c=0
Rk2 (\4\:D D) resistor r=0.07782 c=0
Rk1 (\4\:CK CK) resistor r=0.1131 c=0
Rk22 (\2\:Q Q) resistor r=0.2095 c=0
Rk23 (Q \4\:Q) resistor r=0.181 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.08506 c=0
Rk33 (\3\:VSS \6\:VSS) resistor r=0.2455 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.2606 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.1904 c=0
Rk36 (\8\:VSS \9\:VSS) resistor r=0.1854 c=0
Rk37 (\9\:VSS \10\:VSS) resistor r=0.2154 c=0
Rk39 (\11\:VSS VSS) resistor r=0.06475 c=0
Rk38 (\10\:VSS \11\:VSS) resistor r=0.1854 c=0
Rk43 (\7\:VSS \18\:VSS) resistor r=0.3394 c=0
Rk44 (\9\:VSS \20\:VSS) resistor r=0.07381 c=0
Rk45 (\11\:VSS \22\:VSS) resistor r=0.274 c=0
Rk8 (\12\:CKb \13\:CKb) resistor r=0.4726 c=0
Rk9 (\13\:CKb \14\:CKb) resistor r=0.7688 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.4674 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.338 c=0
Rk12 (\13\:CKb \17\:CKb) resistor r=0.1955 c=0
Rk13 (\14\:CKb \18\:CKb) resistor r=0.2742 c=0
Rk14 (\15\:CKb \19\:CKb) resistor r=0.01531 c=0
Rk15 (\16\:CKb \21\:CKb) resistor r=0.3292 c=0
Rk16 (\21\:CKb \23\:CKb) resistor r=0.3733 c=0
Rk17 (\7\:CKbb \8\:CKbb) resistor r=1.5026 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.2767 c=0
Rk19 (\9\:CKbb \11\:CKbb) resistor r=0.4206 c=0
Rk20 (\8\:CKbb \12\:CKbb) resistor r=0.06418 c=0
Rk21 (\9\:CKbb \14\:CKbb) resistor r=0.06451 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.5397 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.4964 c=0
Rk5 (\6\:mout \7\:mout) resistor r=0.3384 c=0
Rk6 (\7\:mout \8\:mout) resistor r=0.2362 c=0
Rk7 (\7\:mout \10\:mout) resistor r=0.2676 c=0
Rk24 (\4\:n30 \5\:n30) resistor r=1.035 c=0
Rk25 (\5\:n30 \7\:n30) resistor r=0.07036 c=0
Rk26 (\5\:n30 \9\:n30) resistor r=0.392 c=0
Rk27 (\12\:qbint \13\:qbint) resistor r=0.3325 c=0
Rk28 (\13\:qbint \14\:qbint) resistor r=0.187 c=0
Rk29 (\13\:qbint \16\:qbint) resistor r=0.1416 c=0
Rl6 (\2\:D \3\:D) resistor r=147.872 c=0
Rl5 (\1\:D \2\:D) resistor r=42.5711 c=0
Rl2 (\2\:CK \3\:CK) resistor r=70.6044 c=0
Rl1 (\1\:CK \2\:CK) resistor r=49.2678 c=0
Rl3 (CKb \2\:CKb) resistor r=217.308 c=0
Rl17 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl16 (\8\:CKb \9\:CKb) resistor r=66.0643 c=0
Rl10 (\6\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=48.7687 c=0
Rl4 (\2\:CKb \3\:CKb) resistor r=33.7903 c=0
Rl18 (\4\:CKbb \5\:CKbb) resistor r=35.7713 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=202.028 c=0
Rl8 (CKbb \2\:CKbb) resistor r=246.411 c=0
Rl9 (\2\:CKbb \3\:CKbb) resistor r=29.5379 c=0
Rl14 (n20 \2\:n20) resistor r=29.5379 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=162.23 c=0
Rl11 (mout \2\:mout) resistor r=4.3192 c=0
Rl13 (\2\:mout \4\:mout) resistor r=111.253 c=0
Rl12 (\2\:mout \3\:mout) resistor r=97.7911 c=0
Rl29 (n30 \2\:n30) resistor r=30.2349 c=0
Rl30 (\2\:n30 \3\:n30) resistor r=110.031 c=0
Rl25 (\7\:qbint qbint) resistor r=4.7234 c=0
Rl22 (\4\:qbint qbint) resistor r=102.948 c=0
Rl28 (\4\:qbint \10\:qbint) resistor r=109.297 c=0
Rl23 (\4\:qbint \5\:qbint) resistor r=115.362 c=0
Rz16 (VDD \3\:VDD) resistor r=75 c=0
Rz13 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz14 (\8\:VDD \3\:VDD) resistor r=15 c=0
Rz15 (\12\:VDD \3\:VDD) resistor r=9.375 c=0
Rz5 (\4\:Q \3\:Q) resistor r=75 c=0
Rz10 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz11 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz12 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz3 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz4 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz7 (\12\:qbint \11\:qbint) resistor r=75 c=0
Ry16 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry5 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry13 (VSS \1\:VSS) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\6\:VSS \1\:VSS) resistor r=12.4 c=0
Ry11 (\8\:VSS \1\:VSS) resistor r=15.5 c=0
Ry12 (\10\:VSS \1\:VSS) resistor r=15.5 c=0
Ry3 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry4 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\16\:qbint \15\:qbint) resistor r=31 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx5 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\11\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\7\:CKb \18\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \19\:CKb) resistor r=45 c=0
Rx10 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx12 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx13 (\14\:qbint \7\:qbint) resistor r=45 c=0
mn20 (\20\:CKb \1\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\10\:CKbb \2\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.49e-14 ad=2.683e-14 ps=1.53e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn25 (n21 \1\:D \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=1.958e-14 ps=1.53e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn26 (\7\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\7\:n20 CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.248e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.995e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (\9\:mout \3\:n20 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.335e-14 ad=5.075e-14 ps=7.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.72e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn40 (\6\:n30 \6\:CKbb \9\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.32e-14 ps=9.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=1.325e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\6\:n30 \10\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=1.12e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn50 (n35 \5\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.038e-14 ad=8.7e-15 ps=1.13e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=1.015e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn55 (\3\:Q qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.113e-14 ad=4.16e-14 ps=1.1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1775e-06 sb=5.88846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\11\:qbint n30 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.188e-14 ad=2.87e-14 ps=1.07e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62024e-06 sb=1.4e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mp21 (\13\:CKbb CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.0642 scb=0.00864592 \
        scc=0.000148882 m=(1)
mp25 (n22 \3\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.472e-14 ps=7.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp35 (n26 \4\:mout \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.245e-14 ad=1.29e-14 ps=1.44e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.78384e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=6.773e-14 ps=6.6e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=2e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp36 (\5\:n20 \6\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.773e-14 ps=5.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.88884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp30 (\5\:mout n20 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.245e-14 ad=6.342e-14 ps=1.44e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.245e-06 sb=1.50884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp40 (\8\:n30 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.342e-14 ad=4.622e-14 ps=1.02e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.16884e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp51 (\8\:n30 \4\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.622e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=9.08837e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp50 (n36 \10\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=2.687e-14 ps=1.22e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.38837e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp55 (\1\:Q qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.12e-14 ad=6.825e-14 ps=1.16e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=5.14744e-07 sd=160n sca=17.596 \
        scb=0.015375 scc=0.00137895 m=(2)
mp45 (\15\:qbint \3\:n30 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16734e-06 sb=1.4e-07 sd=160n sca=23.2035 \
        scb=0.0225719 scc=0.00178254 m=(1)
ends DFFQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:17:40 2012 )
// Library name: gsclib045
// Cell name: DFFQX4
// View name: extracted

simulator lang=spectre

subckt DFFQX4 CK D Q VDD VSS
mp20 (\19\:CKb \1\:CK \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30209e-06 sd=160n sca=27.0129 \
        scb=0.0266904 scc=0.00248953 m=(1)
C1 (D VSS) capacitor c=4.78425e-17
C2 (Q VSS) capacitor c=3.02814e-16
C3 (VDD VSS) capacitor c=2.66668e-16
C4 (CK VSS) capacitor c=4.77691e-17
C5 (CKb VSS) capacitor c=7.57793e-17
C6 (qbint VSS) capacitor c=3.16538e-16
C7 (n30 VSS) capacitor c=2.21027e-16
C8 (n35 VSS) capacitor c=4.3239e-20
C9 (mout VSS) capacitor c=8.31252e-17
C10 (CKbb VSS) capacitor c=4.33082e-17
C11 (n20 VSS) capacitor c=3.21963e-17
C12 (n25 VSS) capacitor c=1.96538e-18
C13 (n21 VSS) capacitor c=2.31908e-18
C14 (n36 VSS) capacitor c=2.07421e-18
C15 (n26 VSS) capacitor c=3.20347e-18
C16 (n22 VSS) capacitor c=5.15806e-19
C17 (\10\:CKb VSS) capacitor c=4.91007e-17
C18 (\1\:D VSS) capacitor c=6.58053e-17
C19 (\5\:CKbb VSS) capacitor c=3.01795e-17
C20 (\4\:CKb VSS) capacitor c=4.4732e-17
C21 (\2\:CKbb VSS) capacitor c=3.83795e-17
C22 (\18\:qbint VSS) capacitor c=5.91253e-17
C23 (\1\:CK VSS) capacitor c=4.72818e-17
C24 (\8\:CKb VSS) capacitor c=2.25417e-17
C25 (\3\:D VSS) capacitor c=5.26343e-17
C26 (\6\:CKb VSS) capacitor c=5.59942e-17
C27 (\7\:CKbb VSS) capacitor c=7.57147e-17
C28 (\3\:mout VSS) capacitor c=3.67953e-17
C29 (\3\:n20 VSS) capacitor c=5.52572e-17
C30 (\3\:CKbb VSS) capacitor c=4.54378e-17
C31 (\2\:CKb VSS) capacitor c=6.85654e-17
C32 (\16\:qbint VSS) capacitor c=5.21346e-17
C33 (\3\:CK VSS) capacitor c=3.17903e-17
C34 (\9\:CKb VSS) capacitor c=4.48354e-17
C35 (\2\:D VSS) capacitor c=5.57945e-17
C36 (\7\:CKb VSS) capacitor c=4.88742e-17
C37 (\6\:CKbb VSS) capacitor c=7.0077e-17
C38 (\5\:CKb VSS) capacitor c=4.9093e-17
C39 (\2\:mout VSS) capacitor c=4.9332e-17
C40 (\4\:n20 VSS) capacitor c=2.89899e-17
C41 (\4\:CKbb VSS) capacitor c=5.11971e-17
C42 (\3\:CKb VSS) capacitor c=2.87362e-17
C43 (\17\:qbint VSS) capacitor c=6.00908e-17
C44 (\2\:CK VSS) capacitor c=3.53025e-17
C45 (\16\:CKbb VSS) capacitor c=2.23008e-17
C46 (\11\:VDD VSS) capacitor c=3.70716e-17
C47 (\7\:n20 VSS) capacitor c=1.06397e-16
C48 (\13\:VDD VSS) capacitor c=1.81289e-17
C49 (\8\:mout VSS) capacitor c=7.98496e-17
C50 (\12\:n30 VSS) capacitor c=4.19635e-17
C51 (\25\:qbint VSS) capacitor c=7.73592e-17
C52 (\19\:CKb VSS) capacitor c=7.00354e-17
C53 (\1\:VDD VSS) capacitor c=5.00826e-17
C54 (\13\:CKbb VSS) capacitor c=4.88245e-17
C55 (\5\:n20 VSS) capacitor c=1.00906e-16
C56 (\6\:mout VSS) capacitor c=3.41976e-17
C57 (\8\:n30 VSS) capacitor c=6.86589e-17
C58 (\19\:qbint VSS) capacitor c=2.91502e-17
C59 (\17\:CKb VSS) capacitor c=2.10784e-16
C60 (\2\:n20 VSS) capacitor c=3.00623e-17
C61 (\4\:CK VSS) capacitor c=6.67306e-17
C62 (\21\:qbint VSS) capacitor c=1.86044e-17
C63 (\22\:qbint VSS) capacitor c=2.6574e-17
C64 (\23\:qbint VSS) capacitor c=2.67524e-17
C65 (\24\:qbint VSS) capacitor c=3.51997e-17
C66 (\10\:n30 VSS) capacitor c=7.35022e-17
C67 (\11\:n30 VSS) capacitor c=4.81956e-17
C68 (\4\:mout VSS) capacitor c=4.0678e-17
C69 (\5\:mout VSS) capacitor c=5.09257e-17
C70 (\9\:n20 VSS) capacitor c=5.86857e-17
C71 (\4\:D VSS) capacitor c=6.93555e-17
C72 (\11\:CKb VSS) capacitor c=3.54731e-17
C73 (\12\:CKb VSS) capacitor c=5.89806e-17
C74 (\13\:CKb VSS) capacitor c=1.28764e-16
C75 (\14\:CKb VSS) capacitor c=2.20097e-16
C76 (\15\:CKb VSS) capacitor c=7.89122e-17
C77 (\16\:CKb VSS) capacitor c=7.97831e-17
C78 (\8\:CKbb VSS) capacitor c=2.1196e-17
C79 (\9\:CKbb VSS) capacitor c=1.52641e-16
C80 (\10\:CKbb VSS) capacitor c=1.3807e-16
C81 (\11\:CKbb VSS) capacitor c=3.95378e-17
C82 (\12\:CKbb VSS) capacitor c=6.51261e-17
C83 (\15\:CKbb VSS) capacitor c=3.66237e-17
C84 (\3\:VDD VSS) capacitor c=1.26429e-17
C85 (\5\:VDD VSS) capacitor c=2.74258e-17
C86 (\6\:VDD VSS) capacitor c=3.11405e-16
Rk21 (D \4\:D) resistor r=0.165 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.1527 c=0
Rk52 (\3\:VDD \4\:VDD) resistor r=0.2981 c=0
Rk53 (\4\:VDD \5\:VDD) resistor r=0.1167 c=0
Rk59 (\6\:VDD VDD) resistor r=0.1926 c=0
Rk54 (\5\:VDD \6\:VDD) resistor r=0.5251 c=0
Rk60 (\3\:VDD \12\:VDD) resistor r=0.2579 c=0
Rk61 (\5\:VDD \14\:VDD) resistor r=0.04329 c=0
Rk1 (CK \4\:CK) resistor r=0.1079 c=0
Rk36 (\2\:VSS \3\:VSS) resistor r=0.1377 c=0
Rk37 (\3\:VSS \4\:VSS) resistor r=0.4648 c=0
Rk38 (\3\:VSS \6\:VSS) resistor r=0.217 c=0
Rk39 (\4\:VSS \7\:VSS) resistor r=0.436 c=0
Rk45 (\12\:VSS VSS) resistor r=0.04989 c=0
Rk44 (\7\:VSS \12\:VSS) resistor r=0.1101 c=0
Rk46 (\4\:VSS \14\:VSS) resistor r=0.07145 c=0
Rk22 (\11\:CKb \12\:CKb) resistor r=0.1131 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.3928 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.6575 c=0
Rk25 (\12\:CKb \15\:CKb) resistor r=0.3152 c=0
Rk26 (\13\:CKb \16\:CKb) resistor r=0.4265 c=0
Rk27 (\14\:CKb \18\:CKb) resistor r=1.4894 c=0
Rk28 (\18\:CKb \20\:CKb) resistor r=0.5291 c=0
Rk8 (\20\:qbint \21\:qbint) resistor r=0.1331 c=0
Rk9 (\21\:qbint \22\:qbint) resistor r=0.1007 c=0
Rk10 (\22\:qbint \23\:qbint) resistor r=0.174 c=0
Rk11 (\21\:qbint \24\:qbint) resistor r=0.1535 c=0
Rk12 (\22\:qbint \26\:qbint) resistor r=0.308 c=0
Rk13 (\9\:n30 \10\:n30) resistor r=0.4949 c=0
Rk14 (\10\:n30 \11\:n30) resistor r=0.2049 c=0
Rk15 (\10\:n30 \13\:n30) resistor r=0.2732 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1764 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1545 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3156 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=0.05668 c=0
Rk30 (\9\:CKbb \10\:CKbb) resistor r=1.1163 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.1424 c=0
Rk32 (\9\:CKbb \12\:CKbb) resistor r=0.3008 c=0
Rk33 (\12\:CKbb \14\:CKbb) resistor r=0.3945 c=0
Rk34 (\10\:CKbb \15\:CKbb) resistor r=0.1848 c=0
Rk35 (\12\:CKbb \17\:CKbb) resistor r=0.0384 c=0
Rk19 (\6\:n20 \8\:n20) resistor r=0.5348 c=0
Rk20 (\8\:n20 \9\:n20) resistor r=0.3942 c=0
Rl38 (\1\:D \2\:D) resistor r=143 c=0
Rl39 (\2\:D \3\:D) resistor r=48.7687 c=0
Rl1 (\1\:CK \2\:CK) resistor r=112.07 c=0
Rl2 (\2\:CK \3\:CK) resistor r=25.2509 c=0
Rl26 (CKb \2\:CKb) resistor r=249.566 c=0
Rl41 (\9\:CKb \10\:CKb) resistor r=157.487 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=26.0911 c=0
Rl35 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=71.8456 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=26.1559 c=0
Rl24 (\17\:qbint \18\:qbint) resistor r=122.872 c=0
Rl23 (\17\:qbint \16\:qbint) resistor r=90.3618 c=0
Rl32 (mout \2\:mout) resistor r=152.615 c=0
Rl33 (\2\:mout \3\:mout) resistor r=39.1533 c=0
Rl25 (CKbb \2\:CKbb) resistor r=57.6695 c=0
Rl36 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl37 (\6\:CKbb \7\:CKbb) resistor r=226.043 c=0
Rl28 (\3\:CKbb \4\:CKbb) resistor r=98.7687 c=0
Rl29 (n20 \2\:n20) resistor r=55.0028 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=158.849 c=0
Rl31 (\2\:n20 \4\:n20) resistor r=29.6836 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz16 (\4\:VDD \1\:VDD) resistor r=12.5 c=0
Rz17 (\6\:VDD \1\:VDD) resistor r=6.25 c=0
Rz9 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry13 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\4\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry11 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry12 (\12\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry3 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\7\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \14\:CKb) resistor r=45 c=0
Rx10 (\9\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx2 (\23\:qbint qbint) resistor r=45 c=0
Rx3 (\24\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx13 (CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\4\:n20 \9\:n20) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.485e-14 ad=3.698e-14 ps=1.45e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn55_1__rcx (Q qbint \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.707e-14 ad=4.16e-14 ps=1.435e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.00769e-07 sb=1.58144e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn45_1__rcx (\19\:qbint n30 \7\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.172e-14 ad=3.28e-14 ps=1.5e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29463e-06 sb=1.5039e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(2)
mn50 (n35 \16\:qbint \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.102e-14 ps=1.57e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\5\:n20 \7\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=3.625e-14 ps=5.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.95e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 \2\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=2.755e-14 ps=5.8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.83e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \3\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.755e-14 ps=6.9e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.595e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\6\:mout \3\:n20 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.39e-14 ad=2.9e-14 ps=1.43e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.35e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=3.625e-14 ps=4.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn21 (\13\:CKbb \8\:CKb \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.81e-14 ad=3.262e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=2.102e-14 ps=1.43e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.085e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn25 (n21 \3\:D \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=9.42e-15 ps=1e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mp55_1__rcx (Q qbint \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.857e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=1.52327e-06 sd=160n sca=18.6696 \
        scb=0.0162362 scc=0.00138051 m=(4)
mp45_1__rcx (\25\:qbint n30 \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.505e-14 ad=4.96e-14 ps=1.06e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02669e-06 sb=1.48056e-06 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(2)
mp50 (n36 \18\:qbint \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=2.902e-14 ps=1.02e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41558e-06 sb=1.98e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp51 (\12\:n30 \2\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59558e-06 sb=1.8e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp40 (\12\:n30 CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.3e-14 ps=1.04e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83314e-06 sb=1.555e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp30 (\8\:mout n20 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=6.558e-14 ps=1.42e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.205e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp35 (n26 mout \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=2.472e-14 ps=1.42e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.4e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp36 (\7\:n20 \4\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.515e-14 ps=6.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.8e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp26 (\7\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.25e-07 sd=160n sca=10.9637 \
        scb=0.00861453 scc=0.000148875 m=(1)
mp25 (n22 \1\:D \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=11.5483 scb=0.0088999 \
        scc=0.00014904 m=(1)
mp21 (\16\:CKbb \10\:CKb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.0147 scb=0.0105811 \
        scc=0.000156391 m=(1)
ends DFFQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:18:17 2012 )
// Library name: gsclib045
// Cell name: DFFQXL
// View name: extracted

simulator lang=spectre

subckt DFFQXL CK D Q VDD VSS
mp55 (\3\:Q \4\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.01e-14 ps=8.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=23.8733 \
        scb=0.0264891 scc=0.00148688 m=(1)
C1 (D VSS) capacitor c=7.03142e-17
C2 (VDD VSS) capacitor c=2.54862e-16
C3 (CK VSS) capacitor c=5.87872e-17
C4 (Q VSS) capacitor c=4.57499e-17
C5 (qbint VSS) capacitor c=1.67145e-17
C6 (CKb VSS) capacitor c=2.36442e-17
C7 (n30 VSS) capacitor c=4.15457e-17
C8 (n35 VSS) capacitor c=1.49475e-18
C9 (mout VSS) capacitor c=3.40274e-17
C10 (CKbb VSS) capacitor c=5.06458e-17
C11 (n20 VSS) capacitor c=5.51364e-17
C12 (n25 VSS) capacitor c=1.70374e-18
C13 (n21 VSS) capacitor c=1.29587e-18
C14 (n36 VSS) capacitor c=1.59823e-18
C15 (n26 VSS) capacitor c=2.23864e-18
C16 (n22 VSS) capacitor c=3.46284e-18
C17 (\8\:CKb VSS) capacitor c=4.80723e-17
C18 (\1\:D VSS) capacitor c=3.96802e-17
C19 (\5\:CKbb VSS) capacitor c=7.85674e-17
C20 (\5\:CKb VSS) capacitor c=4.59493e-17
C21 (\4\:mout VSS) capacitor c=8.68203e-17
C22 (\2\:CKbb VSS) capacitor c=4.57589e-17
C23 (\5\:qbint VSS) capacitor c=8.08816e-17
C24 (\3\:n30 VSS) capacitor c=4.78027e-17
C25 (\1\:CK VSS) capacitor c=3.40828e-17
C26 (\4\:qbint VSS) capacitor c=4.37383e-17
C27 (\11\:CKb VSS) capacitor c=3.75686e-17
C28 (\3\:D VSS) capacitor c=8.91678e-17
C29 (\6\:CKb VSS) capacitor c=7.06883e-17
C30 (\6\:CKbb VSS) capacitor c=7.97825e-17
C31 (\3\:n20 VSS) capacitor c=5.22564e-17
C32 (\3\:CKbb VSS) capacitor c=2.36847e-17
C33 (\3\:CKb VSS) capacitor c=9.058e-17
C34 (\8\:qbint VSS) capacitor c=4.50983e-17
C35 (\3\:CK VSS) capacitor c=4.48974e-17
C36 (\3\:qbint VSS) capacitor c=2.32188e-17
C37 (\10\:CKb VSS) capacitor c=2.99305e-17
C38 (\2\:D VSS) capacitor c=7.55397e-17
C39 (\7\:CKb VSS) capacitor c=5.65684e-17
C40 (\7\:CKbb VSS) capacitor c=2.95597e-17
C41 (\4\:CKb VSS) capacitor c=4.7082e-17
C42 (\3\:mout VSS) capacitor c=3.16856e-17
C43 (\4\:n20 VSS) capacitor c=3.16652e-17
C44 (\4\:CKbb VSS) capacitor c=5.24526e-17
C45 (\2\:CKb VSS) capacitor c=8.39467e-17
C46 (\7\:qbint VSS) capacitor c=2.74598e-17
C47 (\4\:n30 VSS) capacitor c=1.76461e-17
C48 (\2\:CK VSS) capacitor c=3.74583e-17
C49 (\8\:CKbb VSS) capacitor c=6.55464e-17
C50 (\1\:VDD VSS) capacitor c=3.19213e-17
C51 (\5\:n20 VSS) capacitor c=7.63164e-17
C52 (\9\:VDD VSS) capacitor c=2.35617e-17
C53 (\9\:mout VSS) capacitor c=7.3312e-17
C54 (\9\:n30 VSS) capacitor c=7.61098e-17
C55 (\11\:VDD VSS) capacitor c=2.39581e-17
C56 (\13\:qbint VSS) capacitor c=6.50569e-17
C57 (\18\:CKb VSS) capacitor c=1.47758e-16
C58 (\13\:VDD VSS) capacitor c=3.36455e-17
C59 (\3\:Q VSS) capacitor c=6.26259e-17
C60 (\3\:VDD VSS) capacitor c=7.65753e-17
C61 (\14\:CKbb VSS) capacitor c=1.40969e-17
C62 (\8\:n20 VSS) capacitor c=7.66734e-17
C63 (\7\:mout VSS) capacitor c=5.86094e-17
C64 (\5\:n30 VSS) capacitor c=6.42463e-17
C65 (\11\:qbint VSS) capacitor c=8.32004e-17
C66 (\20\:CKb VSS) capacitor c=8.78913e-17
C67 (\1\:Q VSS) capacitor c=2.04579e-17
C68 (\2\:qbint VSS) capacitor c=2.81044e-17
C69 (\2\:n30 VSS) capacitor c=3.96779e-17
C70 (\6\:qbint VSS) capacitor c=5.7089e-17
C71 (\2\:n20 VSS) capacitor c=4.39341e-17
C72 (\2\:mout VSS) capacitor c=5.52855e-17
C73 (\9\:CKb VSS) capacitor c=4.10905e-17
C74 (\4\:CK VSS) capacitor c=6.35114e-17
C75 (\9\:qbint VSS) capacitor c=4.49375e-17
C76 (\10\:qbint VSS) capacitor c=6.30625e-17
C77 (\15\:qbint VSS) capacitor c=1.20672e-16
C78 (\7\:n30 VSS) capacitor c=8.16907e-17
C79 (\8\:n30 VSS) capacitor c=3.94976e-17
C80 (\5\:mout VSS) capacitor c=3.54535e-17
C81 (\6\:mout VSS) capacitor c=6.37406e-17
C82 (\7\:n20 VSS) capacitor c=8.56202e-17
C83 (\10\:n20 VSS) capacitor c=3.79946e-17
C84 (\4\:D VSS) capacitor c=5.8401e-17
C85 (\12\:CKb VSS) capacitor c=4.78107e-17
C86 (\13\:CKb VSS) capacitor c=6.30821e-17
C87 (\14\:CKb VSS) capacitor c=1.32863e-16
C88 (\15\:CKb VSS) capacitor c=3.99993e-17
C89 (\16\:CKb VSS) capacitor c=2.10147e-16
C90 (\17\:CKb VSS) capacitor c=4.82221e-17
C91 (\10\:CKbb VSS) capacitor c=1.19795e-16
C92 (\11\:CKbb VSS) capacitor c=2.22896e-16
C93 (\12\:CKbb VSS) capacitor c=1.41587e-16
C94 (\13\:CKbb VSS) capacitor c=6.04206e-17
C95 (\16\:CKbb VSS) capacitor c=2.32827e-17
C96 (\5\:VDD VSS) capacitor c=4.46373e-17
C97 (\7\:VDD VSS) capacitor c=1.95635e-17
C98 (\8\:VDD VSS) capacitor c=1.91147e-17
Rk17 (D \4\:D) resistor r=0.04824 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.09284 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.1079 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.2714 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.4323 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.07524 c=0
Rk46 (\8\:VSS VSS) resistor r=0.1026 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.3743 c=0
Rk47 (\3\:VSS \10\:VSS) resistor r=0.2119 c=0
Rk48 (\5\:VSS \12\:VSS) resistor r=0.1268 c=0
Rk49 (\7\:VSS \14\:VSS) resistor r=0.2338 c=0
Rk50 (\8\:VSS \16\:VSS) resistor r=0.357 c=0
Rk31 (\2\:VDD \4\:VDD) resistor r=0.2655 c=0
Rk32 (\4\:VDD \5\:VDD) resistor r=0.3861 c=0
Rk33 (\5\:VDD \6\:VDD) resistor r=0.4163 c=0
Rk34 (\6\:VDD \7\:VDD) resistor r=0.07429 c=0
Rk36 (\8\:VDD VDD) resistor r=0.1026 c=0
Rk35 (\7\:VDD \8\:VDD) resistor r=0.3733 c=0
Rk37 (\5\:VDD \10\:VDD) resistor r=0.04347 c=0
Rk38 (\7\:VDD \12\:VDD) resistor r=0.04347 c=0
Rk39 (\8\:VDD \14\:VDD) resistor r=0.2273 c=0
Rk3 (\4\:CK CK) resistor r=0.1139 c=0
Rk1 (Q \2\:Q) resistor r=0.06644 c=0
Rk2 (Q \4\:Q) resistor r=0.3533 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1556 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1738 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.4618 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.6677 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.2242 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2606 c=0
Rk20 (\14\:CKb \15\:CKb) resistor r=0.1471 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=1.0145 c=0
Rk22 (\16\:CKb \17\:CKb) resistor r=0.2321 c=0
Rk23 (\16\:CKb \19\:CKb) resistor r=0.9118 c=0
Rk24 (\19\:CKb \21\:CKb) resistor r=0.5318 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.4182 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.1518 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.4062 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.09664 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.2571 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.5103 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.5479 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.6888 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=1.2013 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.3686 c=0
Rk29 (\10\:CKbb \15\:CKbb) resistor r=0.06536 c=0
Rk30 (\12\:CKbb \16\:CKbb) resistor r=0.08203 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.4788 c=0
Rk15 (\7\:n20 \9\:n20) resistor r=0.4426 c=0
Rk16 (\7\:n20 \10\:n20) resistor r=0.1181 c=0
Rl26 (\1\:D \2\:D) resistor r=103.365 c=0
Rl27 (\2\:D \3\:D) resistor r=158.414 c=0
Rl4 (\1\:CK \2\:CK) resistor r=94.9225 c=0
Rl5 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl1 (qbint \2\:qbint) resistor r=2.4834 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=164.264 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=46.9565 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=226.637 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=47.791 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=6.708 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=64.0519 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=314.183 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=177.726 c=0
Rl30 (\9\:CKb \11\:CKb) resistor r=95.0334 c=0
Rl29 (\9\:CKb \10\:CKb) resistor r=2.4801 c=0
Rl6 (n30 \2\:n30) resistor r=121.99 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=151.431 c=0
Rl8 (\2\:n30 \4\:n30) resistor r=3.8588 c=0
Rl19 (mout \2\:mout) resistor r=50.3084 c=0
Rl21 (\2\:mout \4\:mout) resistor r=219.894 c=0
Rl20 (\2\:mout \3\:mout) resistor r=16.1277 c=0
Rl12 (CKbb \2\:CKbb) resistor r=65.2137 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=299.934 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=81.0266 c=0
Rl16 (n20 \2\:n20) resistor r=162.695 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=116.541 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=31.6066 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz1 (\1\:Q \2\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry12 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry13 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry14 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\3\:Q \4\:Q) resistor r=62 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry6 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\5\:n20 \6\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx8 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (CKbb \13\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx6 (\4\:n20 \10\:n20) resistor r=45 c=0
mn55 (\1\:Q \3\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn20 (\20\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.9e-14 ps=7.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn45 (\11\:qbint n30 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn50 (n35 \8\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=8.7e-15 ps=6.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.935e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.06e-14 ps=4.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.83e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn40 (\5\:n30 \3\:CKbb \7\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=4.06e-14 ps=7.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.505e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn30 (\7\:mout \3\:n20 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.86e-14 ad=3.48e-14 ps=1.15e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.22e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn35 (n25 mout \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.86e-14 ad=1.813e-14 ps=1.15e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=8.95e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn26 (\8\:n20 \6\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=5.2e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn36 (\8\:n20 \6\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.813e-14 ad=2.32e-14 ps=5.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=7.25e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn25 (n21 \3\:D \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.61e-14 ad=1.015e-14 ps=8e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=4.05e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn21 (\14\:CKbb \11\:CKb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.61e-14 ad=2.03e-14 ps=8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mp20 (\18\:CKb \1\:CK \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=4.085e-14 ps=8.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.9e-07 sd=160n sca=12.9231 scb=0.0102616 \
        scc=9.6055e-05 m=(1)
mp45 (\13\:qbint \3\:n30 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3005 scb=0.00749164 \
        scc=8.05168e-05 m=(1)
mp35 (n26 \4\:mout \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.538e-14 ad=2.043e-14 ps=1.33e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.7e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp50 (n36 \5\:qbint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.15e-14 ps=1.32e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.955e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\9\:n30 \2\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.81e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\9\:n30 CKb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.87e-14 ps=1.03e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.585e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp30 (\9\:mout n20 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.538e-14 ad=6.45e-14 ps=1.33e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.24e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.623e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=3.65e-07 sd=160n sca=13.4702 \
        scb=0.0111763 scc=0.0001097 m=(1)
mp36 (\5\:n20 \5\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.043e-14 ad=3.44e-14 ps=6.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=8.3e-07 sd=160n sca=10.3563 \
        scb=0.00750569 scc=8.05187e-05 m=(1)
mp26 (\5\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.44e-14 ps=8.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.735e-06 sb=6.25e-07 sd=160n sca=11.0447 \
        scb=0.00786221 scc=8.0761e-05 m=(1)
mp21 (\8\:CKbb \8\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=21.8638 scb=0.0242315 \
        scc=0.00109598 m=(1)
ends DFFQXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:07:48 2012 )
// Library name: gsclib045
// Cell name: DFFRHQX1
// View name: extracted

simulator lang=spectre

subckt DFFRHQX1 CK D Q RN VDD VSS
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.61346e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
C1 (CK VSS) capacitor c=5.00788e-17
C2 (Q VSS) capacitor c=4.50174e-17
C3 (D VSS) capacitor c=4.62092e-17
C4 (VDD VSS) capacitor c=2.31293e-16
C5 (qbint VSS) capacitor c=5.37814e-17
C6 (CKb VSS) capacitor c=4.96753e-17
C7 (n35 VSS) capacitor c=1.23531e-18
C8 (n30 VSS) capacitor c=5.82218e-17
C9 (n40 VSS) capacitor c=1.30342e-18
C10 (mout VSS) capacitor c=5.20369e-17
C11 (CKbb VSS) capacitor c=2.56084e-17
C12 (n20 VSS) capacitor c=4.81152e-17
C13 (n21 VSS) capacitor c=1.23445e-18
C14 (n41 VSS) capacitor c=1.08267e-18
C15 (n26 VSS) capacitor c=1.20453e-16
C16 (n22 VSS) capacitor c=9.87314e-20
C17 (\8\:CKb VSS) capacitor c=2.82409e-17
C18 (\1\:D VSS) capacitor c=1.1127e-16
C19 (\6\:CKbb VSS) capacitor c=6.99395e-17
C20 (\5\:CKb VSS) capacitor c=3.60193e-17
C21 (\1\:RN VSS) capacitor c=1.39482e-16
C22 (\3\:CKb VSS) capacitor c=3.7618e-17
C23 (\3\:CKbb VSS) capacitor c=9.26319e-17
C24 (\4\:qbint VSS) capacitor c=8.63522e-17
C25 (\2\:RN VSS) capacitor c=1.02731e-16
C26 (\3\:n30 VSS) capacitor c=5.7454e-17
C27 (\1\:CK VSS) capacitor c=3.33344e-17
C28 (\10\:CKb VSS) capacitor c=4.59354e-17
C29 (\3\:D VSS) capacitor c=7.18658e-17
C30 (\7\:CKb VSS) capacitor c=6.928e-17
C31 (\4\:CKbb VSS) capacitor c=4.19606e-17
C32 (\3\:mout VSS) capacitor c=5.36544e-17
C33 (\5\:RN VSS) capacitor c=7.05954e-17
C34 (\3\:n20 VSS) capacitor c=4.81143e-17
C35 (\6\:qbint VSS) capacitor c=5.82e-17
C36 (\4\:RN VSS) capacitor c=8.05408e-17
C37 (\3\:CK VSS) capacitor c=4.66865e-17
C38 (\3\:qbint VSS) capacitor c=3.22106e-17
C39 (\9\:CKb VSS) capacitor c=5.12877e-17
C40 (\2\:D VSS) capacitor c=6.76906e-17
C41 (\7\:CKbb VSS) capacitor c=5.18041e-17
C42 (\6\:CKb VSS) capacitor c=4.58332e-17
C43 (\5\:CKbb VSS) capacitor c=3.74601e-17
C44 (\2\:mout VSS) capacitor c=6.15925e-17
C45 (\2\:n20 VSS) capacitor c=4.59956e-17
C46 (\4\:CKb VSS) capacitor c=3.11607e-17
C47 (\2\:CKbb VSS) capacitor c=7.36418e-17
C48 (\2\:CKb VSS) capacitor c=5.63715e-17
C49 (\5\:qbint VSS) capacitor c=7.84089e-17
C50 (\3\:RN VSS) capacitor c=5.22729e-17
C51 (\2\:n30 VSS) capacitor c=4.21411e-17
C52 (\2\:CK VSS) capacitor c=4.75887e-17
C53 (\2\:qbint VSS) capacitor c=3.50794e-17
C54 (\12\:CKbb VSS) capacitor c=3.53547e-17
C55 (\1\:VDD VSS) capacitor c=8.2798e-17
C56 (\4\:n20 VSS) capacitor c=1.20316e-16
C57 (\11\:VDD VSS) capacitor c=5.90544e-17
C58 (\3\:n26 VSS) capacitor c=1.02851e-16
C59 (\13\:VDD VSS) capacitor c=6.82052e-17
C60 (\8\:mout VSS) capacitor c=1.12164e-16
C61 (\4\:n30 VSS) capacitor c=1.0467e-16
C62 (\15\:VDD VSS) capacitor c=9.08929e-17
C63 (\11\:qbint VSS) capacitor c=8.25328e-17
C64 (\17\:VDD VSS) capacitor c=7.45369e-17
C65 (\20\:CKb VSS) capacitor c=3.61536e-17
C66 (\19\:VDD VSS) capacitor c=7.39729e-17
C67 (\1\:Q VSS) capacitor c=3.36917e-17
C68 (\4\:VDD VSS) capacitor c=1.66356e-17
C69 (\15\:CKbb VSS) capacitor c=1.61405e-17
C70 (\8\:n20 VSS) capacitor c=6.08683e-17
C71 (\6\:mout VSS) capacitor c=6.02739e-17
C72 (\8\:n30 VSS) capacitor c=3.30765e-17
C73 (\13\:qbint VSS) capacitor c=3.8109e-17
C74 (\17\:CKb VSS) capacitor c=1.04744e-16
C75 (\3\:Q VSS) capacitor c=7.06652e-17
C76 (\4\:CK VSS) capacitor c=4.09023e-17
C77 (\7\:qbint VSS) capacitor c=7.02619e-17
C78 (\8\:qbint VSS) capacitor c=1.4894e-16
C79 (\9\:qbint VSS) capacitor c=1.80241e-16
C80 (\10\:qbint VSS) capacitor c=1.46145e-16
C81 (\6\:RN VSS) capacitor c=7.10306e-17
C82 (\8\:RN VSS) capacitor c=6.81756e-17
C83 (\6\:n30 VSS) capacitor c=1.41235e-16
C84 (\7\:n30 VSS) capacitor c=1.1151e-16
C85 (\4\:mout VSS) capacitor c=1.00302e-16
C86 (\5\:mout VSS) capacitor c=1.27681e-16
C87 (\6\:n20 VSS) capacitor c=1.68451e-16
C88 (\7\:n20 VSS) capacitor c=1.38975e-16
C89 (\4\:D VSS) capacitor c=7.24846e-17
C90 (\11\:CKb VSS) capacitor c=1.64179e-16
C91 (\12\:CKb VSS) capacitor c=3.4192e-16
C92 (\13\:CKb VSS) capacitor c=2.30396e-16
C93 (\14\:CKb VSS) capacitor c=8.59568e-17
C94 (\15\:CKb VSS) capacitor c=2.71408e-16
C95 (\16\:CKb VSS) capacitor c=2.38697e-16
C96 (\19\:CKb VSS) capacitor c=7.46957e-17
C97 (\8\:CKbb VSS) capacitor c=3.5925e-17
C98 (\9\:CKbb VSS) capacitor c=2.69675e-16
C99 (\10\:CKbb VSS) capacitor c=1.36761e-16
C100 (\11\:CKbb VSS) capacitor c=6.80065e-17
C101 (\14\:CKbb VSS) capacitor c=1.82136e-16
C102 (\17\:CKbb VSS) capacitor c=7.8511e-17
C103 (\3\:VDD VSS) capacitor c=3.44399e-17
C104 (\6\:VDD VSS) capacitor c=3.86422e-17
C105 (\7\:VDD VSS) capacitor c=4.50475e-17
C106 (\8\:VDD VSS) capacitor c=1.45096e-17
C107 (\10\:VDD VSS) capacitor c=7.13081e-18
Rk3 (\4\:CK CK) resistor r=0.05341 c=0
Rk1 (Q \2\:Q) resistor r=0.07294 c=0
Rk2 (Q \4\:Q) resistor r=0.4479 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.2514 c=0
Rk39 (\3\:VSS \5\:VSS) resistor r=0.2052 c=0
Rk40 (\5\:VSS \6\:VSS) resistor r=0.2382 c=0
Rk41 (\6\:VSS \7\:VSS) resistor r=0.1678 c=0
Rk42 (\3\:VSS \8\:VSS) resistor r=0.2508 c=0
Rk43 (\8\:VSS \9\:VSS) resistor r=0.1976 c=0
Rk44 (\9\:VSS \10\:VSS) resistor r=0.3092 c=0
Rk46 (\11\:VSS VSS) resistor r=0.1035 c=0
Rk45 (\10\:VSS \11\:VSS) resistor r=0.1494 c=0
Rk47 (\6\:VSS \13\:VSS) resistor r=0.2097 c=0
Rk48 (\7\:VSS \15\:VSS) resistor r=0.2281 c=0
Rk49 (\9\:VSS \17\:VSS) resistor r=0.2308 c=0
Rk50 (\11\:VSS \19\:VSS) resistor r=0.309 c=0
Rk22 (D \4\:D) resistor r=0.1047 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.7586 c=0
Rk52 (\3\:VDD \5\:VDD) resistor r=0.05305 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.1545 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.4383 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.243 c=0
Rk56 (\8\:VDD \9\:VDD) resistor r=0.07588 c=0
Rk58 (\10\:VDD VDD) resistor r=0.1035 c=0
Rk57 (\9\:VDD \10\:VDD) resistor r=0.1494 c=0
Rk59 (\3\:VDD \12\:VDD) resistor r=0.3115 c=0
Rk60 (\6\:VDD \14\:VDD) resistor r=0.3676 c=0
Rk61 (\7\:VDD \16\:VDD) resistor r=0.4013 c=0
Rk62 (\8\:VDD \18\:VDD) resistor r=0.3386 c=0
Rk63 (\10\:VDD \20\:VDD) resistor r=0.3605 c=0
Rk9 (\6\:RN \7\:RN) resistor r=0.00567 c=0
Rk10 (RN \8\:RN) resistor r=0.00567 c=0
Rk11 (\6\:RN \8\:RN) resistor r=0.06642 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.3386 c=0
Rk5 (\8\:qbint \9\:qbint) resistor r=0.5369 c=0
Rk6 (\9\:qbint \10\:qbint) resistor r=0.9141 c=0
Rk7 (\8\:qbint \12\:qbint) resistor r=0.3894 c=0
Rk8 (\9\:qbint \14\:qbint) resistor r=0.1112 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=1.1591 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=1.3824 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=0.3979 c=0
Rk26 (\13\:CKb \15\:CKb) resistor r=0.5539 c=0
Rk27 (\15\:CKb \16\:CKb) resistor r=1.3763 c=0
Rk28 (\16\:CKb \18\:CKb) resistor r=0.461 c=0
Rk29 (\15\:CKb \19\:CKb) resistor r=0.4123 c=0
Rk30 (\16\:CKb \21\:CKb) resistor r=0.1996 c=0
Rk12 (\5\:n30 \6\:n30) resistor r=0.6402 c=0
Rk13 (\6\:n30 \7\:n30) resistor r=0.6152 c=0
Rk14 (\6\:n30 \9\:n30) resistor r=0.08583 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.5031 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2002 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.4231 c=0
Rk31 (\8\:CKbb \9\:CKbb) resistor r=0.06918 c=0
Rk32 (\9\:CKbb \10\:CKbb) resistor r=1.0875 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.252 c=0
Rk34 (\11\:CKbb \13\:CKbb) resistor r=0.2478 c=0
Rk35 (\9\:CKbb \14\:CKbb) resistor r=1.1807 c=0
Rk36 (\10\:CKbb \16\:CKbb) resistor r=0.07674 c=0
Rk37 (\11\:CKbb \17\:CKbb) resistor r=0.3146 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.676 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.7869 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2139 c=0
Rk18 (\2\:n26 \4\:n26) resistor r=0.5797 c=0
Rl3 (\1\:CK \2\:CK) resistor r=96.8456 c=0
Rl4 (\2\:CK \3\:CK) resistor r=154.538 c=0
Rl25 (\1\:D \2\:D) resistor r=168.257 c=0
Rl26 (\2\:D \3\:D) resistor r=111.459 c=0
Rl15 (\1\:RN \2\:RN) resistor r=367.561 c=0
Rl18 (\1\:RN \5\:RN) resistor r=207.692 c=0
Rl16 (\2\:RN \3\:RN) resistor r=40.8576 c=0
Rl17 (\3\:RN \4\:RN) resistor r=138.31 c=0
Rl7 (\4\:qbint \5\:qbint) resistor r=127.926 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=53.079 c=0
Rl1 (qbint \2\:qbint) resistor r=106.867 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=26.098 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=187.694 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=42.3077 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=141.209 c=0
Rl12 (\3\:CKb \4\:CKb) resistor r=35.3072 c=0
Rl9 (CKb \2\:CKb) resistor r=51.098 c=0
Rl5 (n30 \2\:n30) resistor r=60.6757 c=0
Rl6 (\2\:n30 \3\:n30) resistor r=149.175 c=0
Rl19 (mout \2\:mout) resistor r=133.848 c=0
Rl20 (\2\:mout \3\:mout) resistor r=45.3867 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=71.8456 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=29.5379 c=0
Rl10 (CKbb \2\:CKbb) resistor r=55.3008 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=174.543 c=0
Rl13 (n20 \2\:n20) resistor r=56.4615 c=0
Rl14 (\2\:n20 \3\:n20) resistor r=124.527 c=0
Rz1 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\18\:VSS \19\:VSS) resistor r=37.5 c=0
Rz13 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz14 (\4\:VDD \9\:VDD) resistor r=12.5 c=0
Rz2 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz6 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry10 (\4\:VSS \5\:VSS) resistor r=12.4 c=0
Ry11 (\4\:VSS \7\:VSS) resistor r=20.6667 c=0
Ry12 (\4\:VSS \8\:VSS) resistor r=15.5 c=0
Ry13 (\4\:VSS \10\:VSS) resistor r=10.3333 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\11\:VDD \12\:VDD) resistor r=31 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=31 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=20.6667 c=0
Ry2 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry5 (n26 \2\:n26) resistor r=31 c=0
Ry6 (\3\:n26 \4\:n26) resistor r=31 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:RN \7\:RN) resistor r=45 c=0
Rx2 (\5\:qbint \7\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \10\:qbint) resistor r=45 c=0
Rx9 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx15 (\7\:CKbb \17\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.85e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn20 (\17\:CKb \3\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.393e-14 ps=9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.65e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn46 (\13\:qbint n30 n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=1.98037e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn45 (n35 \4\:RN \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.28415e-07 sb=1.89073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (n40 \6\:qbint \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.38415e-07 sb=1.68073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\8\:n30 CKb n40 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.715e-14 ps=5.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43415e-07 sb=1.57573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\8\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.715e-14 ps=8.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18415e-07 sb=1.30073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (\6\:mout \3\:n20 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=4.51e-14 ps=1.24e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08341e-06 sb=1.03573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (n27 \5\:RN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=3.28e-14 ps=1.24e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31841e-06 sb=8.00732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52341e-06 sb=5.95732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62841e-06 sb=4.90732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn26 (\8\:n20 \7\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.88341e-06 sb=2.35732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (n21 \3\:D \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=1.23e-14 ps=8.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98549e-06 sb=1.30732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp20 (\20\:CKb \1\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.69e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.25116e-07 sd=160n sca=13.8096 \
        scb=0.0118363 scc=0.000162518 m=(1)
mp46 (\11\:qbint \3\:n30 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=5.735e-14 ps=9.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50323e-07 sb=1.65597e-06 sd=160n sca=12.8747 \
        scb=0.0114137 scc=0.000458937 m=(1)
mp45 (\11\:qbint \2\:RN \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=5.735e-14 ps=1.01e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.80323e-07 sb=1.42597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp50 (n41 \4\:qbint \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=2.015e-14 ps=1.01e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.20323e-07 sb=1.18597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp51 (\4\:n30 \3\:CKbb n41 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.015e-14 ad=6.355e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30323e-07 sb=1.07597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=6.355e-14 ps=1.04e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.80323e-07 sb=8.25968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp30 (\8\:mout n20 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.51e-14 ps=1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23532e-06 sb=5.70968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp35 (\3\:n26 \1\:RN \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47032e-06 sb=3.35968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp36 (\3\:n26 mout \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67532e-06 sb=1.30968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp37 (\4\:n20 \5\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=4.96e-14 ps=9.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65968e-07 sb=6.00726e-07 sd=160n sca=13.271 \
        scb=0.0115865 scc=0.00045901 m=(1)
mp26 (\4\:n20 \6\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.70968e-07 sb=3.95726e-07 sd=160n sca=14.4949 \
        scb=0.0127984 scc=0.000462551 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=1.86e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75968e-07 sb=2.90726e-07 sd=160n sca=15.7848 \
        scb=0.014788 scc=0.000483319 m=(1)
mp21 (\12\:CKbb \8\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.415e-14 ad=2.63e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.22326e-07 sd=160n sca=27.6163 \
        scb=0.0324392 scc=0.00204694 m=(1)
ends DFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:19:32 2012 )
// Library name: gsclib045
// Cell name: DFFRHQX2
// View name: extracted

simulator lang=spectre

subckt DFFRHQX2 CK D Q RN VDD VSS
mp55 (\3\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.379e-14 ad=6.24e-14 ps=1.085e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.42821e-07 sd=160n sca=38.817 \
        scb=0.037485 scc=0.00407535 m=(2)
C1 (CK VSS) capacitor c=6.04638e-17
C2 (Q VSS) capacitor c=2.6461e-17
C3 (D VSS) capacitor c=7.35698e-17
C4 (VDD VSS) capacitor c=3.68533e-16
C5 (RN VSS) capacitor c=5.32805e-17
C6 (qbint VSS) capacitor c=1.31085e-16
C7 (CKb VSS) capacitor c=4.57083e-17
C8 (n35 VSS) capacitor c=1.75003e-18
C9 (n30 VSS) capacitor c=3.72673e-17
C10 (n40 VSS) capacitor c=3.50006e-18
C11 (mout VSS) capacitor c=4.30618e-17
C12 (CKbb VSS) capacitor c=2.66496e-17
C13 (n20 VSS) capacitor c=4.13338e-17
C14 (n27 VSS) capacitor c=5.20645e-18
C15 (n25 VSS) capacitor c=4.78744e-18
C16 (n21 VSS) capacitor c=1.56139e-18
C17 (n41 VSS) capacitor c=3.90841e-18
C18 (n26 VSS) capacitor c=7.61708e-17
C19 (n22 VSS) capacitor c=1.67153e-18
C20 (\8\:CKb VSS) capacitor c=3.30566e-17
C21 (\1\:D VSS) capacitor c=9.5455e-17
C22 (\6\:CKbb VSS) capacitor c=6.10413e-17
C23 (\7\:CKb VSS) capacitor c=2.97055e-17
C24 (\2\:RN VSS) capacitor c=1.23389e-16
C25 (\3\:n20 VSS) capacitor c=5.28946e-17
C26 (\3\:CKb VSS) capacitor c=3.3522e-17
C27 (\3\:CKbb VSS) capacitor c=6.86869e-17
C28 (\8\:qbint VSS) capacitor c=7.7691e-17
C29 (\3\:RN VSS) capacitor c=8.23186e-17
C30 (\3\:n30 VSS) capacitor c=4.73617e-17
C31 (\3\:CK VSS) capacitor c=4.06759e-17
C32 (\9\:CKb VSS) capacitor c=2.92086e-17
C33 (\3\:D VSS) capacitor c=5.55081e-17
C34 (\5\:CKb VSS) capacitor c=6.48601e-17
C35 (\4\:CKbb VSS) capacitor c=3.88532e-17
C36 (\3\:mout VSS) capacitor c=3.31681e-17
C37 (\1\:RN VSS) capacitor c=7.35264e-17
C38 (\10\:qbint VSS) capacitor c=3.86254e-17
C39 (\5\:RN VSS) capacitor c=9.49284e-17
C40 (\1\:CK VSS) capacitor c=2.96565e-17
C41 (\10\:CKb VSS) capacitor c=2.76481e-17
C42 (\2\:D VSS) capacitor c=4.60069e-17
C43 (\7\:CKbb VSS) capacitor c=3.39292e-17
C44 (\6\:CKb VSS) capacitor c=3.38485e-17
C45 (\5\:CKbb VSS) capacitor c=3.20852e-17
C46 (\2\:mout VSS) capacitor c=3.48851e-17
C47 (\2\:n20 VSS) capacitor c=4.81606e-17
C48 (\4\:CKb VSS) capacitor c=3.47629e-17
C49 (\2\:CKbb VSS) capacitor c=5.03378e-17
C50 (\2\:CKb VSS) capacitor c=4.41387e-17
C51 (\9\:qbint VSS) capacitor c=6.7569e-17
C52 (\4\:RN VSS) capacitor c=4.26752e-17
C53 (\2\:n30 VSS) capacitor c=4.68094e-17
C54 (\2\:CK VSS) capacitor c=4.88824e-17
C55 (\6\:qbint VSS) capacitor c=1.92385e-17
C56 (\10\:CKbb VSS) capacitor c=2.81033e-17
C57 (\11\:VDD VSS) capacitor c=1.34744e-17
C58 (\4\:n20 VSS) capacitor c=7.72716e-17
C59 (\13\:VDD VSS) capacitor c=2.79912e-17
C60 (\3\:n26 VSS) capacitor c=6.46455e-17
C61 (\15\:VDD VSS) capacitor c=4.28264e-17
C62 (\8\:mout VSS) capacitor c=5.72858e-17
C63 (\8\:n30 VSS) capacitor c=9.83439e-17
C64 (\17\:VDD VSS) capacitor c=3.69623e-17
C65 (\16\:qbint VSS) capacitor c=6.86602e-17
C66 (\19\:VDD VSS) capacitor c=3.71857e-17
C67 (\16\:CKb VSS) capacitor c=4.28807e-17
C68 (\3\:Q VSS) capacitor c=9.61376e-17
C69 (\1\:VDD VSS) capacitor c=1.03817e-16
C70 (\8\:CKbb VSS) capacitor c=1.23951e-17
C71 (\8\:n20 VSS) capacitor c=5.57356e-17
C72 (\6\:mout VSS) capacitor c=4.28187e-17
C73 (\4\:n30 VSS) capacitor c=2.44983e-17
C74 (\13\:qbint VSS) capacitor c=1.4518e-16
C75 (\21\:CKb VSS) capacitor c=1.07336e-16
C76 (\1\:Q VSS) capacitor c=1.91426e-17
C77 (\4\:CK VSS) capacitor c=5.23052e-17
C78 (\11\:qbint VSS) capacitor c=4.49529e-17
C79 (\12\:qbint VSS) capacitor c=8.88475e-17
C80 (\15\:qbint VSS) capacitor c=1.43192e-16
C81 (\6\:RN VSS) capacitor c=6.07895e-17
C82 (\6\:n30 VSS) capacitor c=9.06948e-17
C83 (\7\:n30 VSS) capacitor c=1.03489e-16
C84 (\4\:mout VSS) capacitor c=1.11164e-16
C85 (\5\:mout VSS) capacitor c=8.94941e-17
C86 (\6\:n20 VSS) capacitor c=1.28236e-16
C87 (\7\:n20 VSS) capacitor c=1.05344e-16
C88 (\4\:D VSS) capacitor c=4.12554e-17
C89 (\12\:CKbb VSS) capacitor c=1.19482e-16
C90 (\13\:CKbb VSS) capacitor c=2.7086e-16
C91 (\14\:CKbb VSS) capacitor c=1.44294e-16
C92 (\15\:CKbb VSS) capacitor c=4.24921e-17
C93 (\16\:CKbb VSS) capacitor c=4.07672e-17
C94 (\11\:CKb VSS) capacitor c=5.64309e-17
C95 (\12\:CKb VSS) capacitor c=1.9459e-16
C96 (\13\:CKb VSS) capacitor c=1.59549e-16
C97 (\14\:CKb VSS) capacitor c=1.533e-16
C98 (\15\:CKb VSS) capacitor c=1.43168e-16
C99 (\18\:CKb VSS) capacitor c=8.98806e-17
C100 (\19\:CKb VSS) capacitor c=5.94622e-17
C101 (\20\:CKb VSS) capacitor c=8.65663e-17
C102 (\5\:VDD VSS) capacitor c=1.58268e-17
C103 (\6\:VDD VSS) capacitor c=2.6082e-17
C104 (\8\:VDD VSS) capacitor c=3.09943e-17
C105 (\9\:VDD VSS) capacitor c=2.6139e-17
Rk3 (\4\:CK CK) resistor r=0.09453 c=0
Rk1 (Q \2\:Q) resistor r=0.04515 c=0
Rk2 (Q \4\:Q) resistor r=0.2679 c=0
Rk19 (\4\:D D) resistor r=0.06815 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.1007 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.2513 c=0
Rk37 (\4\:VDD \5\:VDD) resistor r=0.2423 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.3224 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.2357 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.2332 c=0
Rk42 (\9\:VDD VDD) resistor r=0.2688 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.3509 c=0
Rk43 (\3\:VDD \12\:VDD) resistor r=0.121 c=0
Rk44 (\5\:VDD \14\:VDD) resistor r=0.04335 c=0
Rk45 (\6\:VDD \16\:VDD) resistor r=0.2096 c=0
Rk46 (\8\:VDD \18\:VDD) resistor r=0.1805 c=0
Rk47 (\9\:VDD \20\:VDD) resistor r=0.1875 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.08513 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.06505 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.07509 c=0
Rk54 (\5\:VSS \6\:VSS) resistor r=0.5392 c=0
Rk55 (\6\:VSS \7\:VSS) resistor r=0.03745 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.5946 c=0
Rk58 (\9\:VSS VSS) resistor r=0.1579 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=0.4089 c=0
Rk61 (\3\:VSS \14\:VSS) resistor r=0.0744 c=0
Rk62 (\5\:VSS \16\:VSS) resistor r=0.1267 c=0
Rk63 (\6\:VSS \18\:VSS) resistor r=0.2275 c=0
Rk64 (\8\:VSS \20\:VSS) resistor r=0.2208 c=0
Rk8 (\6\:RN RN) resistor r=0.1845 c=0
Rk4 (\11\:qbint \12\:qbint) resistor r=0.2714 c=0
Rk5 (\12\:qbint \14\:qbint) resistor r=0.5122 c=0
Rk6 (\14\:qbint \15\:qbint) resistor r=0.9016 c=0
Rk7 (\12\:qbint \17\:qbint) resistor r=0.2925 c=0
Rk26 (\11\:CKb \12\:CKb) resistor r=0.2599 c=0
Rk27 (\12\:CKb \13\:CKb) resistor r=1.1332 c=0
Rk28 (\13\:CKb \14\:CKb) resistor r=0.33 c=0
Rk29 (\14\:CKb \15\:CKb) resistor r=0.9125 c=0
Rk30 (\15\:CKb \17\:CKb) resistor r=0.1733 c=0
Rk31 (\12\:CKb \18\:CKb) resistor r=0.671 c=0
Rk32 (\13\:CKb \19\:CKb) resistor r=0.2443 c=0
Rk33 (\14\:CKb \20\:CKb) resistor r=0.4177 c=0
Rk34 (\15\:CKb \22\:CKb) resistor r=0.5405 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.06464 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.5524 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.4387 c=0
Rk12 (\4\:mout \5\:mout) resistor r=0.5666 c=0
Rk13 (\5\:mout \7\:mout) resistor r=0.1136 c=0
Rk14 (\5\:mout \9\:mout) resistor r=0.2503 c=0
Rk20 (\9\:CKbb \11\:CKbb) resistor r=0.3278 c=0
Rk21 (\11\:CKbb \12\:CKbb) resistor r=0.1211 c=0
Rk22 (\12\:CKbb \13\:CKbb) resistor r=1.2314 c=0
Rk23 (\13\:CKbb \14\:CKbb) resistor r=1.1897 c=0
Rk24 (\12\:CKbb \15\:CKbb) resistor r=0.2186 c=0
Rk25 (\13\:CKbb \16\:CKbb) resistor r=0.1211 c=0
Rk16 (\5\:n20 \6\:n20) resistor r=0.3851 c=0
Rk17 (\6\:n20 \7\:n20) resistor r=0.6748 c=0
Rk18 (\6\:n20 \9\:n20) resistor r=0.2067 c=0
Rk15 (\2\:n26 \4\:n26) resistor r=0.2574 c=0
Rl8 (\2\:CK \3\:CK) resistor r=110.989 c=0
Rl7 (\1\:CK \2\:CK) resistor r=78.8462 c=0
Rl29 (\1\:D \2\:D) resistor r=122.31 c=0
Rl30 (\2\:D \3\:D) resistor r=135.155 c=0
Rl20 (\2\:RN \3\:RN) resistor r=639.95 c=0
Rl19 (\1\:RN \2\:RN) resistor r=180.335 c=0
Rl21 (\3\:RN \4\:RN) resistor r=24.2328 c=0
Rl22 (\4\:RN \5\:RN) resistor r=198.905 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=139.125 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=51.098 c=0
Rl5 (qbint \6\:qbint) resistor r=4.3693 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=101.923 c=0
Rl32 (\8\:CKb \10\:CKb) resistor r=57.2054 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=143.832 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl13 (CKb \2\:CKb) resistor r=53.079 c=0
Rl9 (n30 \2\:n30) resistor r=24.2328 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=219.646 c=0
Rl23 (mout \2\:mout) resistor r=97.3098 c=0
Rl24 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl25 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=147.197 c=0
Rl17 (n20 \2\:n20) resistor r=97.3098 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=78.4003 c=0
Rz1 (\2\:Q \1\:Q) resistor r=75 c=0
Rz12 (VDD \1\:VDD) resistor r=15 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=75 c=0
Rz10 (\4\:VDD \1\:VDD) resistor r=18.75 c=0
Rz11 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz14 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz7 (\21\:CKb \22\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry10 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry17 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry18 (\4\:VSS \1\:VSS) resistor r=62 c=0
Ry19 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\9\:VSS \1\:VSS) resistor r=7.75 c=0
Ry2 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry9 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry5 (n26 \2\:n26) resistor r=62 c=0
Ry6 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\4\:RN \6\:RN) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\15\:qbint \6\:qbint) resistor r=45 c=0
Rx12 (\6\:CKb \11\:CKb) resistor r=45 c=0
Rx13 (\10\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx15 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\7\:CKbb \15\:CKbb) resistor r=45 c=0
Rx11 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\1\:Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.135e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.78269e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mn20 (\21\:CKb \1\:CK VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=4.422e-14 ps=1e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.3e-07 sb=3.05e-07 sd=160n sca=10.9472 scb=0.0104991 \
        scc=0.000356047 m=(1)
mn46 (\13\:qbint n30 n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.743e-14 ad=4.202e-14 ps=5.8e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.44024e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn45 (n35 \5\:RN \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.743e-14 ps=7.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.38634e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (n40 \10\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.485e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.30134e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\4\:n30 CKb n40 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=4.82e-14 ps=7.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.2122e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\4\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.61e-14 ad=4.82e-14 ps=1.25e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.61951e-07 sb=1.81e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn30 (\6\:mout n20 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=8.61e-14 ps=1.08e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12695e-06 sb=1.345e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn35 (n27 \1\:RN \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43195e-06 sb=1.04e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.588e-14 ps=7.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61646e-06 sb=8.35e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn37 (\8\:n20 \4\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=5.228e-14 ps=7.6e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70768e-06 sb=6.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn26 (\8\:n20 \5\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=5.228e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83207e-06 sb=3.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn25 (n21 \3\:D \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.185e-14 ad=2.05e-14 ps=1.2e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8922e-06 sb=1.7e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn21 (\8\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.685e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp20 (\16\:CKb \3\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.297e-14 ad=3.01e-14 ps=1.11e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=13.3166 \
        scb=0.0115053 scc=0.000332937 m=(1)
mp46 (\16\:qbint \3\:n30 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.905e-14 ad=6.51e-14 ps=1.13e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.17194e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp45 (\16\:qbint \3\:RN \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.685e-14 ad=6.51e-14 ps=1.53e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=9.62097e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp50 (n41 \8\:qbint \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.685e-14 ad=4.03e-14 ps=1.53e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.34194e-07 sb=1.515e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\8\:n30 \3\:CKbb n41 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=6.975e-14 ps=8.8e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.09194e-07 sb=1.34e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\8\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.44e-14 ad=6.975e-14 ps=1.1e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.79194e-07 sb=1.07e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\8\:mout \3\:n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=7.44e-14 ps=1.36e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16419e-06 sb=7.85e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (\3\:n26 \2\:RN \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=8.835e-14 ps=1.36e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.44919e-06 sb=5e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\3\:n26 mout \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.29e-14 ad=8.835e-14 ps=1.63e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.69565e-06 sb=1.7e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp37 (\4\:n20 \7\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.355e-14 ad=1.0385e-13 ps=1.03e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=6.03952e-07 sd=160n sca=11.0604 \
        scb=0.00885796 scc=0.000174054 m=(1)
mp26 (\4\:n20 \6\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=1.0385e-13 ps=7.4e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=2.23952e-07 sd=160n sca=12.8183 \
        scb=0.0103291 scc=0.000178019 m=(1)
mp25 (n22 \1\:D \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.99e-14 ad=1.86e-14 ps=1.85e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.18952e-07 sd=160n sca=14.1447 \
        scb=0.0123968 scc=0.000200733 m=(1)
mp21 (\10\:CKbb \8\:CKb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.99e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91279e-07 sb=1.4e-07 sd=160n sca=43.6839 \
        scb=0.0409846 scc=0.00506402 m=(1)
ends DFFRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:20:10 2012 )
// Library name: gsclib045
// Cell name: DFFRHQX4
// View name: extracted

simulator lang=spectre

subckt DFFRHQX4 CK D Q RN VDD VSS
mp20 (\13\:CKb \3\:CK \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.335e-14 ad=3.01e-14 ps=1.36e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.81395e-07 sd=160n sca=16.1121 \
        scb=0.0158148 scc=0.000267169 m=(1)
C1 (CK VSS) capacitor c=4.53988e-17
C2 (Q VSS) capacitor c=2.17365e-16
C3 (D VSS) capacitor c=1.25233e-16
C4 (VDD VSS) capacitor c=3.94988e-16
C5 (RN VSS) capacitor c=6.32866e-16
C6 (CKb VSS) capacitor c=5.91066e-17
C7 (qbint VSS) capacitor c=2.94753e-16
C8 (16 VSS) capacitor c=1.38261e-18
C9 (n30 VSS) capacitor c=1.07249e-16
C10 (17 VSS) capacitor c=2.73804e-18
C11 (n40 VSS) capacitor c=5.97173e-18
C12 (mout VSS) capacitor c=3.56618e-17
C13 (CKbb VSS) capacitor c=5.38803e-17
C14 (n20 VSS) capacitor c=2.30156e-17
C15 (n41 VSS) capacitor c=9.2476e-18
C16 (n26 VSS) capacitor c=6.75546e-17
C17 (n22 VSS) capacitor c=2.11974e-18
C18 (\4\:CKb VSS) capacitor c=8.33754e-17
C19 (\1\:D VSS) capacitor c=9.76283e-17
C20 (\7\:CKbb VSS) capacitor c=6.87675e-17
C21 (\8\:CKb VSS) capacitor c=4.589e-17
C22 (\9\:RN VSS) capacitor c=4.171e-17
C23 (\4\:n20 VSS) capacitor c=4.97532e-17
C24 (\2\:CKb VSS) capacitor c=7.19377e-17
C25 (\16\:qbint VSS) capacitor c=3.88308e-17
C26 (\3\:CK VSS) capacitor c=5.53166e-17
C27 (\7\:CKb VSS) capacitor c=5.93106e-17
C28 (\3\:D VSS) capacitor c=3.4499e-17
C29 (\9\:CKb VSS) capacitor c=4.93525e-17
C30 (\5\:CKbb VSS) capacitor c=3.7974e-17
C31 (\3\:mout VSS) capacitor c=3.57244e-17
C32 (\7\:RN VSS) capacitor c=3.44874e-17
C33 (\3\:n20 VSS) capacitor c=2.27707e-17
C34 (\3\:CKbb VSS) capacitor c=4.14304e-17
C35 (\18\:qbint VSS) capacitor c=4.45276e-17
C36 (\6\:RN VSS) capacitor c=3.06188e-17
C37 (\5\:n30 VSS) capacitor c=3.3084e-17
C38 (\4\:n30 VSS) capacitor c=3.66823e-17
C39 (\1\:RN VSS) capacitor c=3.81812e-17
C40 (\1\:CK VSS) capacitor c=2.97943e-17
C41 (\2\:D VSS) capacitor c=4.17423e-17
C42 (\8\:CKbb VSS) capacitor c=3.2924e-17
C43 (\6\:CKbb VSS) capacitor c=3.79967e-17
C44 (\6\:CKb VSS) capacitor c=2.65129e-17
C45 (\2\:mout VSS) capacitor c=3.44452e-17
C46 (\8\:RN VSS) capacitor c=3.89127e-17
C47 (\4\:CKbb VSS) capacitor c=3.13638e-17
C48 (\3\:CKb VSS) capacitor c=1.99807e-17
C49 (\2\:CKbb VSS) capacitor c=4.63722e-17
C50 (\17\:qbint VSS) capacitor c=4.91168e-17
C51 (\2\:CK VSS) capacitor c=4.10494e-17
C52 (\15\:CKbb VSS) capacitor c=2.05199e-17
C53 (\13\:VDD VSS) capacitor c=3.9024e-17
C54 (\5\:n20 VSS) capacitor c=1.01767e-16
C55 (\15\:VDD VSS) capacitor c=2.69712e-17
C56 (\3\:n26 VSS) capacitor c=8.87342e-17
C57 (\17\:VDD VSS) capacitor c=3.04171e-17
C58 (\5\:mout VSS) capacitor c=1.75047e-16
C59 (\11\:n30 VSS) capacitor c=8.50039e-17
C60 (\21\:VDD VSS) capacitor c=1.56839e-17
C61 (\13\:CKb VSS) capacitor c=2.16142e-17
C62 (\1\:VDD VSS) capacitor c=1.0678e-16
C63 (\9\:CKbb VSS) capacitor c=4.58187e-17
C64 (\9\:n20 VSS) capacitor c=1.17057e-17
C65 (\7\:mout VSS) capacitor c=8.01107e-17
C66 (\7\:n30 VSS) capacitor c=6.43646e-17
C67 (\27\:qbint VSS) capacitor c=8.1526e-17
C68 (\15\:CKb VSS) capacitor c=7.87086e-17
C69 (\2\:n20 VSS) capacitor c=2.08283e-17
C70 (\5\:CKb VSS) capacitor c=4.48742e-17
C71 (\4\:CK VSS) capacitor c=7.47074e-17
C72 (\19\:qbint VSS) capacitor c=6.12926e-17
C73 (\20\:qbint VSS) capacitor c=1.67813e-16
C74 (\24\:qbint VSS) capacitor c=4.94415e-17
C75 (\9\:n30 VSS) capacitor c=1.43772e-16
C76 (\10\:n30 VSS) capacitor c=1.07121e-16
C77 (\10\:RN VSS) capacitor c=2.46259e-16
C78 (\4\:mout VSS) capacitor c=1.17467e-16
C79 (\10\:CKb VSS) capacitor c=1.51082e-16
C80 (\11\:CKb VSS) capacitor c=3.77515e-16
C81 (\12\:CKb VSS) capacitor c=2.80485e-16
C82 (\7\:n20 VSS) capacitor c=9.46774e-17
C83 (\8\:n20 VSS) capacitor c=1.11559e-16
C84 (\11\:CKbb VSS) capacitor c=6.94255e-17
C85 (\12\:CKbb VSS) capacitor c=6.59845e-17
C86 (\13\:CKbb VSS) capacitor c=2.33151e-16
C87 (\14\:CKbb VSS) capacitor c=7.81038e-17
C88 (\17\:CKbb VSS) capacitor c=4.10152e-17
C89 (\18\:CKbb VSS) capacitor c=1.91537e-16
C90 (\19\:CKbb VSS) capacitor c=2.76073e-17
C91 (\20\:CKbb VSS) capacitor c=4.3505e-17
C92 (\3\:VDD VSS) capacitor c=1.19602e-17
C93 (\5\:VDD VSS) capacitor c=2.64621e-17
C94 (\6\:VDD VSS) capacitor c=2.70428e-17
C95 (\8\:VDD VSS) capacitor c=1.88504e-16
Rk1 (CK \4\:CK) resistor r=0.0258 c=0
Rk61 (\2\:VSS \3\:VSS) resistor r=0.1177 c=0
Rk62 (\3\:VSS \4\:VSS) resistor r=0.08259 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.7024 c=0
Rk64 (\5\:VSS \6\:VSS) resistor r=0.05499 c=0
Rk65 (\6\:VSS \7\:VSS) resistor r=0.682 c=0
Rk70 (\8\:VSS VSS) resistor r=0.1902 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.401 c=0
Rk71 (\3\:VSS \13\:VSS) resistor r=0.2551 c=0
Rk72 (\6\:VSS \15\:VSS) resistor r=0.2629 c=0
Rk73 (\7\:VSS \17\:VSS) resistor r=0.2224 c=0
Rk30 (D \4\:D) resistor r=0.006018 c=0
Rk40 (\2\:VDD \3\:VDD) resistor r=0.1177 c=0
Rk41 (\3\:VDD \4\:VDD) resistor r=0.2331 c=0
Rk42 (\4\:VDD \5\:VDD) resistor r=0.2372 c=0
Rk43 (\5\:VDD \6\:VDD) resistor r=0.3564 c=0
Rk44 (\6\:VDD \7\:VDD) resistor r=0.2547 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.341 c=0
Rk50 (\3\:VDD \14\:VDD) resistor r=0.3211 c=0
Rk51 (\5\:VDD \16\:VDD) resistor r=0.04333 c=0
Rk52 (\6\:VDD \18\:VDD) resistor r=0.04333 c=0
Rk54 (\8\:VDD \22\:VDD) resistor r=0.07416 c=0
Rk60 (\30\:VDD VDD) resistor r=0.04992 c=0
Rk59 (\8\:VDD \30\:VDD) resistor r=0.09764 c=0
Rk16 (\10\:RN RN) resistor r=1.7073 c=0
Rk23 (\10\:CKb \11\:CKb) resistor r=1.0979 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=2.2583 c=0
Rk25 (\12\:CKb \14\:CKb) resistor r=0.02105 c=0
Rk26 (\12\:CKb \16\:CKb) resistor r=0.5817 c=0
Rk7 (\19\:qbint \20\:qbint) resistor r=0.2999 c=0
Rk10 (\20\:qbint \24\:qbint) resistor r=0.3086 c=0
Rk12 (\20\:qbint \28\:qbint) resistor r=0.4197 c=0
Rk13 (\8\:n30 \9\:n30) resistor r=0.3868 c=0
Rk14 (\9\:n30 \10\:n30) resistor r=0.6042 c=0
Rk15 (\9\:n30 \12\:n30) resistor r=0.5374 c=0
Rk20 (\4\:mout \6\:mout) resistor r=0.8324 c=0
Rk21 (\6\:mout \8\:mout) resistor r=0.3792 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.4033 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=0.3044 c=0
Rk33 (\12\:CKbb \13\:CKbb) resistor r=0.4052 c=0
Rk34 (\13\:CKbb \14\:CKbb) resistor r=0.3692 c=0
Rk35 (\11\:CKbb \16\:CKbb) resistor r=0.04182 c=0
Rk36 (\12\:CKbb \17\:CKbb) resistor r=0.1515 c=0
Rk37 (\13\:CKbb \18\:CKbb) resistor r=1.6215 c=0
Rk38 (\18\:CKbb \19\:CKbb) resistor r=0.1091 c=0
Rk39 (\18\:CKbb \20\:CKbb) resistor r=0.1758 c=0
Rk27 (\6\:n20 \7\:n20) resistor r=0.4954 c=0
Rk28 (\7\:n20 \8\:n20) resistor r=0.7269 c=0
Rk29 (\7\:n20 \10\:n20) resistor r=0.05483 c=0
Rk22 (\2\:n26 \4\:n26) resistor r=0.23 c=0
Rl2 (\2\:CK \3\:CK) resistor r=168.407 c=0
Rl1 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl41 (\1\:D \2\:D) resistor r=89.1533 c=0
Rl42 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl25 (RN \6\:RN) resistor r=26.3736 c=0
Rl17 (RN \1\:RN) resistor r=30.7692 c=0
Rl36 (\8\:RN \9\:RN) resistor r=45.3867 c=0
Rl35 (\8\:RN \7\:RN) resistor r=130.323 c=0
Rl29 (CKb \2\:CKb) resistor r=176.122 c=0
Rl45 (\4\:CKb \7\:CKb) resistor r=213.462 c=0
Rl47 (\8\:CKb \9\:CKb) resistor r=153.846 c=0
Rl30 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl43 (\4\:CKb \5\:CKb) resistor r=298.055 c=0
Rl46 (\5\:CKb \8\:CKb) resistor r=70.8353 c=0
Rl44 (\5\:CKb \6\:CKb) resistor r=85.2376 c=0
Rl26 (\17\:qbint \16\:qbint) resistor r=35.7713 c=0
Rl27 (\17\:qbint \18\:qbint) resistor r=147.31 c=0
Rl22 (n30 \5\:n30) resistor r=76.1559 c=0
Rl21 (n30 \4\:n30) resistor r=75.6397 c=0
Rl37 (mout \2\:mout) resistor r=28.079 c=0
Rl38 (\2\:mout \3\:mout) resistor r=93.4636 c=0
Rl40 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=75.6918 c=0
Rl31 (\3\:CKbb \4\:CKbb) resistor r=46.8456 c=0
