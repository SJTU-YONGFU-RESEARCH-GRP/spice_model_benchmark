C38 (\1\:Q VSS) capacitor c=1.5735e-17
C39 (\10\:VDD VSS) capacitor c=3.844e-17
C40 (\7\:Qbint VSS) capacitor c=2.96608e-17
C41 (\3\:QN VSS) capacitor c=2.34106e-17
C42 (\12\:VDD VSS) capacitor c=3.13845e-17
C43 (\14\:Gb VSS) capacitor c=1.11159e-16
C44 (\17\:Qint VSS) capacitor c=4.35603e-17
C45 (\14\:VDD VSS) capacitor c=2.53317e-17
C46 (\6\:n0 VSS) capacitor c=7.94953e-17
C47 (\16\:VDD VSS) capacitor c=3.67418e-17
C48 (\8\:Gbb VSS) capacitor c=6.21438e-17
C49 (\1\:VDD VSS) capacitor c=7.34538e-17
C50 (\3\:Q VSS) capacitor c=3.00545e-17
C51 (\9\:Qbint VSS) capacitor c=3.53847e-17
C52 (\1\:QN VSS) capacitor c=8.37821e-17
C53 (\8\:Gb VSS) capacitor c=8.26942e-17
C54 (\11\:Qint VSS) capacitor c=2.742e-17
C55 (\8\:n0 VSS) capacitor c=4.14649e-17
C56 (\6\:Gbb VSS) capacitor c=6.6214e-17
C57 (\2\:Gbb VSS) capacitor c=3.86594e-17
C58 (\5\:Qint VSS) capacitor c=3.42345e-17
C59 (\6\:Qint VSS) capacitor c=1.68227e-17
C60 (\2\:Qbint VSS) capacitor c=1.495e-17
C61 (\5\:Gbb VSS) capacitor c=8.93664e-17
C62 (\4\:n0 VSS) capacitor c=3.84242e-17
C63 (\5\:n0 VSS) capacitor c=7.62989e-17
C64 (\10\:Gb VSS) capacitor c=1.61955e-16
C65 (\11\:Gb VSS) capacitor c=1.03402e-16
C66 (\12\:Gb VSS) capacitor c=1.28841e-16
C67 (\13\:Gb VSS) capacitor c=6.78033e-17
C68 (\4\:G VSS) capacitor c=3.49073e-17
C69 (\13\:Qint VSS) capacitor c=4.40705e-17
C70 (\14\:Qint VSS) capacitor c=4.95393e-17
C71 (\15\:Qint VSS) capacitor c=2.764e-17
C72 (\16\:Qint VSS) capacitor c=6.1343e-17
C73 (\5\:Qbint VSS) capacitor c=3.05011e-17
C74 (\6\:Qbint VSS) capacitor c=2.20561e-17
C75 (\3\:VDD VSS) capacitor c=6.11638e-18
C76 (\5\:VDD VSS) capacitor c=1.83757e-17
C77 (\6\:VDD VSS) capacitor c=1.82408e-17
C78 (\8\:VDD VSS) capacitor c=1.98583e-17
Rk12 (G \4\:G) resistor r=0.1856 c=0
Rk18 (\2\:QN QN) resistor r=0.5789 c=0
Rk19 (QN \4\:QN) resistor r=0.05589 c=0
Rk1 (\4\:D D) resistor r=0.001683 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.09252 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.2078 c=0
Rk37 (\4\:VDD \5\:VDD) resistor r=0.2128 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.3369 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.04897 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.3982 c=0
Rk42 (\9\:VDD VDD) resistor r=0.04986 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.1025 c=0
Rk43 (\3\:VDD \11\:VDD) resistor r=0.3985 c=0
Rk44 (\5\:VDD \13\:VDD) resistor r=0.1789 c=0
Rk45 (\6\:VDD \15\:VDD) resistor r=0.04326 c=0
Rk46 (\8\:VDD \17\:VDD) resistor r=0.2226 c=0
Rk23 (Q \2\:Q) resistor r=0.07781 c=0
Rk24 (Q \4\:Q) resistor r=0.1915 c=0
Rk25 (\2\:VSS \4\:VSS) resistor r=0.606 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.1101 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.3629 c=0
Rk28 (\6\:VSS \7\:VSS) resistor r=0.2278 c=0
Rk29 (\7\:VSS \8\:VSS) resistor r=0.2328 c=0
Rk31 (\9\:VSS VSS) resistor r=0.04986 c=0
Rk30 (\8\:VSS \9\:VSS) resistor r=0.1176 c=0
Rk32 (\5\:VSS \11\:VSS) resistor r=0.2882 c=0
Rk33 (\6\:VSS \13\:VSS) resistor r=0.07334 c=0
Rk34 (\8\:VSS \15\:VSS) resistor r=0.07334 c=0
Rk7 (\9\:Gb \10\:Gb) resistor r=0.6321 c=0
Rk8 (\10\:Gb \11\:Gb) resistor r=0.7103 c=0
Rk9 (\11\:Gb \12\:Gb) resistor r=0.1302 c=0
Rk10 (\12\:Gb \13\:Gb) resistor r=0.3464 c=0
Rk11 (\12\:Gb \15\:Gb) resistor r=0.9488 c=0
Rk2 (\5\:Gbb \7\:Gbb) resistor r=0.4931 c=0
Rk3 (\7\:Gbb \9\:Gbb) resistor r=0.5303 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.2377 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.5164 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.1271 c=0
Rk13 (\12\:Qint \13\:Qint) resistor r=0.1044 c=0
Rk14 (\13\:Qint \14\:Qint) resistor r=0.3093 c=0
Rk15 (\14\:Qint \15\:Qint) resistor r=0.1899 c=0
Rk16 (\13\:Qint \16\:Qint) resistor r=0.2829 c=0
Rk17 (\14\:Qint \18\:Qint) resistor r=0.1856 c=0
Rk20 (\5\:Qbint \6\:Qbint) resistor r=0.1209 c=0
Rk21 (\6\:Qbint \8\:Qbint) resistor r=0.1268 c=0
Rk22 (\6\:Qbint \10\:Qbint) resistor r=0.2057 c=0
Rl15 (\2\:G \3\:G) resistor r=26.3736 c=0
Rl14 (\1\:G \2\:G) resistor r=239.129 c=0
Rl3 (\1\:D \2\:D) resistor r=117.999 c=0
Rl4 (\2\:D \3\:D) resistor r=102.615 c=0
Rl9 (\6\:Gb \7\:Gb) resistor r=31.0185 c=0
Rl5 (\4\:Gb \5\:Gb) resistor r=66.5405 c=0
Rl1 (Gb \2\:Gb) resistor r=29.5379 c=0
Rl2 (\2\:Gb \3\:Gb) resistor r=191.076 c=0
Rl6 (Gbb \2\:Gbb) resistor r=196.221 c=0
Rl8 (\2\:Gbb \4\:Gbb) resistor r=50.349 c=0
Rl7 (\2\:Gbb \3\:Gbb) resistor r=80.5242 c=0
Rl12 (n0 \2\:n0) resistor r=30.5087 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=191.483 c=0
Rl21 (\7\:Qint \10\:Qint) resistor r=222.253 c=0
Rl10 (Qint \2\:Qint) resistor r=132.487 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=109.593 c=0
Rl19 (\5\:Qint \8\:Qint) resistor r=82.3738 c=0
Rl16 (\4\:Qint \5\:Qint) resistor r=44.2087 c=0
Rl20 (\6\:Qint \9\:Qint) resistor r=32.1542 c=0
Rl18 (\6\:Qint \7\:Qint) resistor r=6.0041 c=0
Rl17 (\5\:Qint \6\:Qint) resistor r=203.768 c=0
Rl22 (Qbint \2\:Qbint) resistor r=100.308 c=0
Rl24 (\2\:Qbint \4\:Qbint) resistor r=23.7402 c=0
Rl23 (\2\:Qbint \3\:Qbint) resistor r=5.8511 c=0
Rz5 (\1\:QN \2\:QN) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz14 (\1\:VDD \7\:VDD) resistor r=9.375 c=0
Rz15 (\1\:VDD \9\:VDD) resistor r=37.5 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz10 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz11 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz3 (\8\:Gb \9\:Gb) resistor r=75 c=0
Rz1 (\6\:Gbb \7\:Gbb) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (\11\:Qint \12\:Qint) resistor r=75 c=0
Rz6 (\9\:Qbint \10\:Qbint) resistor r=75 c=0
Ry5 (\3\:QN \4\:QN) resistor r=62 c=0
Ry11 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry14 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\1\:Q \2\:Q) resistor r=62 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry9 (\3\:VSS \7\:VSS) resistor r=12.4 c=0
Ry10 (\3\:VSS \9\:VSS) resistor r=31 c=0
Ry3 (\14\:Gb \15\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\7\:Qbint \8\:Qbint) resistor r=62 c=0
Rx7 (\2\:G \4\:G) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx5 (\5\:Gb \11\:Gb) resistor r=45 c=0
Rx6 (\2\:Gb \13\:Gb) resistor r=45 c=0
Rx2 (\3\:Gbb \5\:Gbb) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Qint \15\:Qint) resistor r=45 c=0
Rx9 (\7\:Qint \16\:Qint) resistor r=45 c=0
Rx10 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
mn1 (\6\:Gbb \3\:Gb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=1.42e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (net257 \3\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=6.598e-14 ps=1.42e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.195e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn6 (\8\:n0 \4\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.598e-14 ad=2.32e-14 ps=1.2e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.95e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn16 (\8\:n0 \6\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn15 (net245 Qint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=8.7e-15 ps=1.45e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\11\:Qint n0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=2.755e-14 ps=1.45e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=1.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\8\:Gb \1\:G \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn22 (\1\:QN \9\:Qint \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn20 (\9\:Qbint \4\:Qint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\3\:Q Qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mp5 (net220 \1\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.655e-14 ps=7.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.06e-06 sd=160n sca=12.2564 \
        scb=0.00923826 scc=8.62349e-05 m=(1)
mp6 (\6\:n0 \4\:Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.483e-14 ps=7.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=8.45e-07 sd=160n sca=10.8469 \
        scb=0.00772406 scc=8.06202e-05 m=(1)
mp16 (\6\:n0 Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=5.483e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=5.45e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp15 (net212 \3\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.537e-14 ad=1.935e-14 ps=1.33e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.1e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp10 (\17\:Qint \3\:n0 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.537e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp0 (\14\:Gb \3\:G \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.5e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp22 (\3\:QN \10\:Qint \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.547e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\7\:Qbint \8\:Qint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.15e-07 sd=160n sca=35.6619 \
        scb=0.0280625 scc=0.00428121 m=(1)
mp21 (\1\:Q \4\:Qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.1e-07 sd=160n sca=40.8819 \
        scb=0.0369433 scc=0.00464292 m=(1)
ends TLATXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:33:11 2012 )
// Library name: gsclib045
// Cell name: XNOR2X1
// View name: extracted

simulator lang=spectre

subckt XNOR2X1 A B VDD VSS Y
mp5 (\1\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=5.46e-14 ps=1.84e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=33.3935 \
        scb=0.0357498 scc=0.00324908 m=(1)
C1 (A VSS) capacitor c=6.11438e-17
C2 (Y VSS) capacitor c=1.71652e-17
C3 (VDD VSS) capacitor c=1.07384e-16
C4 (n0 VSS) capacitor c=4.0102e-17
C5 (n1 VSS) capacitor c=1.07239e-16
C6 (n2 VSS) capacitor c=4.47272e-17
C7 (\4\:B VSS) capacitor c=3.75175e-17
C8 (\1\:B VSS) capacitor c=5.60507e-17
C9 (\1\:A VSS) capacitor c=4.10192e-17
C10 (\6\:B VSS) capacitor c=3.64948e-17
C11 (\2\:n1 VSS) capacitor c=6.69076e-17
C12 (\3\:n2 VSS) capacitor c=4.87453e-17
C13 (\3\:B VSS) capacitor c=4.97573e-17
C14 (\3\:A VSS) capacitor c=4.19523e-17
C15 (\3\:n0 VSS) capacitor c=4.11916e-17
C16 (\5\:B VSS) capacitor c=3.64294e-17
C17 (\3\:n1 VSS) capacitor c=3.09785e-17
C18 (\2\:B VSS) capacitor c=7.75677e-17
C19 (\4\:n2 VSS) capacitor c=4.81e-17
C20 (\2\:n2 VSS) capacitor c=2.66676e-17
C21 (\2\:A VSS) capacitor c=3.9633e-17
C22 (\2\:n0 VSS) capacitor c=2.6583e-17
C23 (\8\:n2 VSS) capacitor c=7.05858e-17
C24 (\7\:VDD VSS) capacitor c=3.2284e-17
C25 (\6\:n0 VSS) capacitor c=1.50756e-16
C26 (\4\:n1 VSS) capacitor c=9.73074e-17
C27 (\9\:VDD VSS) capacitor c=7.90217e-18
C28 (\1\:Y VSS) capacitor c=8.01002e-17
C29 (\1\:VDD VSS) capacitor c=3.14598e-17
C30 (\5\:n2 VSS) capacitor c=1.99647e-17
C31 (\4\:n0 VSS) capacitor c=1.00133e-16
C32 (\6\:n1 VSS) capacitor c=1.21043e-16
C33 (\3\:Y VSS) capacitor c=4.93172e-17
C34 (\4\:A VSS) capacitor c=4.81728e-17
C35 (\8\:n0 VSS) capacitor c=1.25666e-16
C36 (\8\:n1 VSS) capacitor c=8.54141e-17
C37 (\7\:B VSS) capacitor c=3.6053e-17
C38 (\8\:B VSS) capacitor c=7.21869e-17
C39 (\7\:n2 VSS) capacitor c=4.88624e-17
C40 (\10\:n2 VSS) capacitor c=1.05678e-16
C41 (\11\:n2 VSS) capacitor c=8.22381e-17
C42 (\3\:VDD VSS) capacitor c=6.66368e-18
C43 (\5\:VDD VSS) capacitor c=5.22727e-18
Rk3 (\4\:A A) resistor r=0.1344 c=0
Rk2 (\4\:Y Y) resistor r=0.02554 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.4604 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.08523 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.1656 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1983 c=0
Rk18 (\6\:VSS VSS) resistor r=0.05 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.05256 c=0
Rk19 (\3\:VSS \8\:VSS) resistor r=0.2983 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.3051 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1044 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1948 c=0
Rk24 (\5\:VDD VDD) resistor r=0.07995 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1707 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.1037 c=0
Rk27 (\5\:VDD \10\:VDD) resistor r=0.07488 c=0
Rk8 (\7\:B B) resistor r=0.105 c=0
Rk9 (B \8\:B) resistor r=0.04993 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.5904 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.738 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4858 c=0
Rk7 (\7\:n1 \8\:n1) resistor r=0.4295 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1354 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2777 c=0
Rk12 (\9\:n2 \10\:n2) resistor r=0.6504 c=0
Rk13 (\7\:n2 \11\:n2) resistor r=0.2288 c=0
Rl3 (\1\:A \2\:A) resistor r=29.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=104.538 c=0
Rl11 (\4\:B \5\:B) resistor r=24.2328 c=0
Rl12 (\5\:B \6\:B) resistor r=106.925 c=0
Rl6 (\1\:B \2\:B) resistor r=26.098 c=0
Rl7 (\2\:B \3\:B) resistor r=138.45 c=0
Rl1 (n0 \2\:n0) resistor r=26.098 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=56.8672 c=0
Rl9 (n1 \2\:n1) resistor r=159.615 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=66.5405 c=0
Rl8 (\3\:n2 \4\:n2) resistor r=24.2328 c=0
Rl5 (n2 \2\:n2) resistor r=52.6149 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\1\:VDD VDD) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry7 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.40962e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(1)
mn0 (\6\:n1 \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.65e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn4 (\4\:n0 \3\:B \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn3 (\4\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net145 \2\:n1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.45e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\5\:n2 \6\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp0 (\4\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=3.44e-14 ps=1.84e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.47326e-07 sd=160n sca=30.7589 \
        scb=0.0279464 scc=0.00328165 m=(1)
mp4 (\4\:n1 n2 \6\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.42326e-07 sd=160n sca=28.8228 \
        scb=0.0245184 scc=0.00324094 m=(1)
mp3 (\6\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.548e-14 ps=5.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.32326e-07 sd=160n sca=28.9644 \
        scb=0.0247513 scc=0.00324182 m=(1)
mp2 (net112 n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.27326e-07 sd=160n sca=29.7748 \
        scb=0.0261855 scc=0.00325287 m=(1)
mp1 (\8\:n2 \4\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=2.63e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.22326e-07 sd=160n sca=35.5405 \
        scb=0.0359913 scc=0.00371931 m=(1)
ends XNOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:33:59 2012 )
// Library name: gsclib045
// Cell name: XNOR2X2
// View name: extracted

simulator lang=spectre

subckt XNOR2X2 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.095e-14 \
        ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.53654e-07 sd=160n sca=26.5621 scb=0.0304693 \
        scc=0.00192189 m=(2)
C1 (A VSS) capacitor c=4.41192e-17
C2 (Y VSS) capacitor c=5.32654e-17
C3 (VDD VSS) capacitor c=2.54699e-16
C4 (B VSS) capacitor c=8.4326e-17
C5 (n0 VSS) capacitor c=1.62566e-16
C6 (n1 VSS) capacitor c=7.13602e-17
C7 (n2 VSS) capacitor c=4.16924e-17
C8 (net112 VSS) capacitor c=2.2804e-18
C9 (\4\:B VSS) capacitor c=3.17976e-17
C10 (\1\:B VSS) capacitor c=4.36825e-17
C11 (\1\:A VSS) capacitor c=4.69734e-17
C12 (\6\:B VSS) capacitor c=3.58334e-17
C13 (\2\:n1 VSS) capacitor c=4.88415e-17
C14 (\3\:n2 VSS) capacitor c=4.17189e-17
C15 (\3\:B VSS) capacitor c=5.44142e-17
C16 (\3\:A VSS) capacitor c=2.79798e-17
C17 (\5\:B VSS) capacitor c=3.32121e-17
C18 (\3\:n1 VSS) capacitor c=3.08564e-17
C19 (\2\:B VSS) capacitor c=7.2017e-17
C20 (\4\:n2 VSS) capacitor c=4.39871e-17
C21 (\2\:n2 VSS) capacitor c=2.48373e-17
C22 (\2\:A VSS) capacitor c=3.73386e-17
C23 (\6\:n2 VSS) capacitor c=1.27059e-16
C24 (\8\:VDD VSS) capacitor c=6.4106e-17
C25 (\7\:n0 VSS) capacitor c=1.41783e-16
C26 (\7\:n1 VSS) capacitor c=8.87859e-17
C27 (\1\:Y VSS) capacitor c=9.30756e-17
C28 (\1\:VDD VSS) capacitor c=3.5561e-17
C29 (\10\:n2 VSS) capacitor c=1.92086e-17
C30 (\10\:n0 VSS) capacitor c=7.95358e-17
C31 (\5\:n1 VSS) capacitor c=1.06814e-16
C32 (\3\:Y VSS) capacitor c=6.70233e-17
C33 (\5\:A VSS) capacitor c=5.02697e-17
C34 (\9\:n0 VSS) capacitor c=1.39681e-16
C35 (\4\:n1 VSS) capacitor c=5.91681e-17
C36 (\8\:B VSS) capacitor c=7.56672e-17
C37 (\5\:n2 VSS) capacitor c=1.1007e-16
C38 (\8\:n2 VSS) capacitor c=6.42876e-17
C39 (\9\:n2 VSS) capacitor c=9.23344e-17
C40 (\3\:VDD VSS) capacitor c=1.96694e-17
Rk3 (\4\:A \5\:A) resistor r=0.002857 c=0
Rk4 (\6\:A A) resistor r=0.002971 c=0
Rk5 (\5\:A \6\:A) resistor r=0.06502 c=0
Rk1 (\2\:Y Y) resistor r=0.2399 c=0
Rk2 (Y \4\:Y) resistor r=0.1958 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1128 c=0
Rk23 (\4\:VDD VDD) resistor r=0.09518 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.3386 c=0
Rk26 (\3\:VDD \9\:VDD) resistor r=0.3456 c=0
Rk17 (\4\:VSS VSS) resistor r=0.1956 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.6113 c=0
Rk10 (B \7\:B) resistor r=0.0075 c=0
Rk11 (\7\:B \8\:B) resistor r=0.1907 c=0
Rk6 (\8\:n0 \9\:n0) resistor r=0.7954 c=0
Rk7 (\8\:n0 \11\:n0) resistor r=0.4367 c=0
Rk8 (\4\:n1 \6\:n1) resistor r=0.4285 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.4717 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.7606 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.2667 c=0
Rk14 (\8\:n2 \9\:n2) resistor r=0.3421 c=0
Rk15 (\8\:n2 \11\:n2) resistor r=0.09346 c=0
Rl6 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl7 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl14 (\4\:B \5\:B) resistor r=48.7687 c=0
Rl15 (\5\:B \6\:B) resistor r=87.2302 c=0
Rl10 (\1\:B \2\:B) resistor r=30.6172 c=0
Rl11 (\2\:B \3\:B) resistor r=155.254 c=0
Rl12 (n1 \2\:n1) resistor r=161.538 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl9 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl8 (n2 \2\:n2) resistor r=50.6918 c=0
Rz1 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz9 (\4\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz5 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\10\:n2 \11\:n2) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry7 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \5\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \9\:n2) resistor r=45 c=0
mn5 (\3\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.039e-14 \
        ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.6125e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mn0 (\5\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.263e-14 ps=9.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.005e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\10\:n0 \3\:B \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.393e-14 ps=7.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (\10\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.393e-14 ps=5.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=5.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.885e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.5e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (\10\:n2 \6\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.45e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mp0 (\7\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=4.837e-14 ps=1.17e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1e-06 sd=160n sca=16.298 scb=0.01559 \
        scc=0.000885958 m=(1)
mp4 (\7\:n1 n2 \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.3e-07 sd=160n sca=15.5147 \
        scb=0.015083 scc=0.000885445 m=(1)
mp3 (\7\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=5.25e-07 sd=160n sca=16.1384 \
        scb=0.0154529 scc=0.000885735 m=(1)
mp2 (net112 n1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.45e-07 sd=160n sca=17.5209 \
        scb=0.017113 scc=0.000893675 m=(1)
mp1 (\6\:n2 \4\:B \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=22.379 \
        scb=0.0254075 scc=0.00119864 m=(1)
ends XNOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:34:46 2012 )
// Library name: gsclib045
// Cell name: XNOR2X4
// View name: extracted

simulator lang=spectre

subckt XNOR2X4 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.119e-14 \
        ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.38346e-06 sd=160n sca=25.2855 scb=0.0288799 \
        scc=0.00168046 m=(4)
C1 (A VSS) capacitor c=3.95837e-17
C2 (Y VSS) capacitor c=3.50158e-17
C3 (VDD VSS) capacitor c=3.28777e-16
C4 (B VSS) capacitor c=3.04594e-17
C5 (n0 VSS) capacitor c=2.78982e-16
C6 (n1 VSS) capacitor c=7.4897e-17
C7 (n2 VSS) capacitor c=4.89088e-17
C8 (\5\:B VSS) capacitor c=4.29698e-17
C9 (\3\:B VSS) capacitor c=9.02236e-17
C10 (\3\:n2 VSS) capacitor c=5.79358e-17
C11 (\1\:A VSS) capacitor c=4.74841e-17
C12 (\7\:B VSS) capacitor c=3.27055e-17
C13 (\3\:n1 VSS) capacitor c=8.69951e-17
C14 (\1\:B VSS) capacitor c=4.71432e-17
C15 (\3\:A VSS) capacitor c=4.68975e-17
C16 (\6\:B VSS) capacitor c=5.52281e-17
C17 (\2\:n1 VSS) capacitor c=7.64792e-17
C18 (\4\:B VSS) capacitor c=6.06321e-17
C19 (\2\:n2 VSS) capacitor c=7.15177e-17
C20 (\2\:B VSS) capacitor c=4.43249e-17
C21 (\2\:A VSS) capacitor c=4.36359e-17
C22 (\4\:n2 VSS) capacitor c=4.50864e-17
C23 (\5\:VDD VSS) capacitor c=4.74424e-17
C24 (\13\:n0 VSS) capacitor c=1.31716e-16
C25 (\4\:n1 VSS) capacitor c=3.62893e-17
C26 (\1\:Y VSS) capacitor c=2.28788e-16
C27 (\1\:VDD VSS) capacitor c=4.04351e-17
C28 (\8\:n2 VSS) capacitor c=3.08266e-17
C29 (\16\:n0 VSS) capacitor c=1.33286e-16
C30 (\7\:n1 VSS) capacitor c=9.65013e-17
C31 (\4\:Y VSS) capacitor c=1.62826e-16
C32 (\4\:A VSS) capacitor c=5.53456e-17
C33 (\15\:n0 VSS) capacitor c=2.60313e-16
C34 (\6\:n1 VSS) capacitor c=9.83439e-17
C35 (\9\:n1 VSS) capacitor c=6.96053e-17
C36 (\8\:B VSS) capacitor c=7.69056e-17
C37 (\9\:B VSS) capacitor c=5.12502e-17
C38 (\10\:B VSS) capacitor c=7.3825e-17
C39 (\6\:n2 VSS) capacitor c=8.9246e-17
C40 (\7\:n2 VSS) capacitor c=7.20778e-17
C41 (\3\:VDD VSS) capacitor c=2.8249e-17
Rk7 (A \4\:A) resistor r=0.05291 c=0
Rk28 (\4\:VSS VSS) resistor r=0.1011 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.5025 c=0
Rk2 (\1\:Y Y) resistor r=0.2077 c=0
Rk3 (Y \4\:Y) resistor r=0.103 c=0
Rk20 (\3\:VDD VDD) resistor r=0.4663 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.08796 c=0
Rk21 (\3\:VDD \6\:VDD) resistor r=0.2687 c=0
Rk13 (B \8\:B) resistor r=0.05065 c=0
Rk14 (\8\:B \9\:B) resistor r=0.1995 c=0
Rk15 (\9\:B \10\:B) resistor r=0.3157 c=0
Rk8 (\14\:n0 \15\:n0) resistor r=1.1557 c=0
Rk9 (\15\:n0 \17\:n0) resistor r=0.9928 c=0
Rk10 (\5\:n1 \6\:n1) resistor r=0.06323 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.4893 c=0
Rk12 (\6\:n1 \9\:n1) resistor r=0.341 c=0
Rk16 (\5\:n2 \6\:n2) resistor r=0.369 c=0
Rk17 (\6\:n2 \7\:n2) resistor r=0.4101 c=0
Rk18 (\6\:n2 \9\:n2) resistor r=0.0803 c=0
Rl12 (\1\:A \2\:A) resistor r=123.769 c=0
Rl13 (\2\:A \3\:A) resistor r=57.2589 c=0
Rl20 (\5\:B \6\:B) resistor r=105.746 c=0
Rl21 (\6\:B \7\:B) resistor r=86.3335 c=0
Rl17 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl14 (\1\:B \2\:B) resistor r=51.903 c=0
Rl18 (n1 \2\:n1) resistor r=24.2328 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=177.645 c=0
Rl15 (n2 \2\:n2) resistor r=26.9231 c=0
Rl16 (\2\:n2 \3\:n2) resistor r=157.143 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz7 (VDD \1\:VDD) resistor r=8.3333 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz3 (\17\:n0 \16\:n0) resistor r=37.5 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry6 (\6\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=31 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\15\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \7\:n2) resistor r=45 c=0
mn5 (\4\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.081e-14 \
        ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.34894e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.833e-14 ps=9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=9.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\16\:n0 \1\:B \7\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.833e-14 ad=4.16e-14 ps=8.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.24615e-07 sb=6.36058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\16\:n0 n2 net145 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.16e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.29615e-07 sb=4.31058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (net145 \3\:n1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.21e-14 ps=9.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05962e-06 sb=3.01058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\8\:n2 \7\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp0 (\4\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=8.523e-14 ps=1.16e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.045e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\4\:n1 \3\:n2 \13\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.523e-14 ps=1.1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.89103e-07 sb=5.79551e-07 sd=160n sca=12.0589 \
        scb=0.0100044 scc=0.000274129 m=(1)
mp3 (\13\:n0 \3\:B net112 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.94103e-07 sb=3.74551e-07 sd=160n sca=13.0911 \
        scb=0.0108737 scc=0.000275827 m=(1)
mp2 (net112 n1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0991e-06 sb=2.69551e-07 sd=160n sca=14.1331 \
        scb=0.0123288 scc=0.000285937 m=(1)
mp1 (\4\:n2 \5\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=1.4e-07 sd=160n sca=22.7425 \
        scb=0.0263845 scc=0.00115464 m=(1)
ends XNOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:35:33 2012 )
// Library name: gsclib045
// Cell name: XNOR2XL
// View name: extracted

simulator lang=spectre

subckt XNOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.17e-14 ps=1.74e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47442e-07 sb=1.15733e-06 sd=160n sca=27.5082 \
        scb=0.031157 scc=0.00214164 m=(1)
C1 (A VSS) capacitor c=6.40372e-17
C2 (Y VSS) capacitor c=3.98833e-17
C3 (B VSS) capacitor c=2.74316e-17
C4 (VDD VSS) capacitor c=1.35166e-16
C5 (n0 VSS) capacitor c=3.29803e-17
C6 (n1 VSS) capacitor c=7.80705e-17
C7 (n2 VSS) capacitor c=5.26022e-17
C8 (net112 VSS) capacitor c=4.45915e-18
C9 (\5\:B VSS) capacitor c=3.66455e-17
C10 (\1\:B VSS) capacitor c=3.88835e-17
C11 (\1\:A VSS) capacitor c=5.14892e-17
C12 (\7\:B VSS) capacitor c=3.33979e-17
C13 (\2\:n1 VSS) capacitor c=4.29962e-17
C14 (\3\:n2 VSS) capacitor c=3.85041e-17
C15 (\3\:B VSS) capacitor c=6.0252e-17
C16 (\3\:A VSS) capacitor c=2.99841e-17
C17 (\3\:n0 VSS) capacitor c=3.51391e-17
C18 (\6\:B VSS) capacitor c=3.88171e-17
C19 (\3\:n1 VSS) capacitor c=2.99281e-17
C20 (\4\:B VSS) capacitor c=2.97005e-17
C21 (\4\:n2 VSS) capacitor c=4.22246e-17
C22 (\2\:n2 VSS) capacitor c=2.36728e-17
C23 (\2\:A VSS) capacitor c=3.99061e-17
C24 (\2\:n0 VSS) capacitor c=3.25749e-17
C25 (\8\:n2 VSS) capacitor c=9.32988e-17
C26 (\1\:VDD VSS) capacitor c=2.71754e-17
C27 (\4\:n0 VSS) capacitor c=1.6329e-16
C28 (\7\:n1 VSS) capacitor c=8.93955e-17
C29 (\7\:VDD VSS) capacitor c=2.86661e-17
C30 (\1\:Y VSS) capacitor c=5.87429e-17
C31 (\3\:VDD VSS) capacitor c=3.17065e-17
C32 (\5\:n2 VSS) capacitor c=1.93873e-17
C33 (\7\:n0 VSS) capacitor c=7.82499e-17
C34 (\5\:n1 VSS) capacitor c=1.24078e-16
C35 (\3\:Y VSS) capacitor c=2.59791e-17
C36 (\2\:B VSS) capacitor c=4.37565e-17
C37 (\4\:A VSS) capacitor c=3.5715e-17
C38 (\6\:n0 VSS) capacitor c=1.22079e-16
C39 (\4\:n1 VSS) capacitor c=6.4193e-17
C40 (\8\:B VSS) capacitor c=5.19334e-17
C41 (\9\:B VSS) capacitor c=4.89112e-17
C42 (\7\:n2 VSS) capacitor c=5.78438e-17
C43 (\10\:n2 VSS) capacitor c=7.76696e-17
C44 (\11\:n2 VSS) capacitor c=1.06336e-16
C45 (\5\:VDD VSS) capacitor c=1.41661e-17
Rk3 (A \4\:A) resistor r=0.08017 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4507 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.3158 c=0
Rk17 (\6\:VSS VSS) resistor r=0.04991 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.08507 c=0
Rk18 (\5\:VSS \8\:VSS) resistor r=0.3456 c=0
Rk1 (\2\:Y Y) resistor r=0.2937 c=0
Rk2 (Y \4\:Y) resistor r=0.08433 c=0
Rk8 (\8\:B B) resistor r=0.07907 c=0
Rk9 (B \9\:B) resistor r=0.0911 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.1918 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.3007 c=0
Rk22 (\6\:VDD VDD) resistor r=0.04991 c=0
Rk21 (\5\:VDD \6\:VDD) resistor r=0.1001 c=0
Rk23 (\5\:VDD \8\:VDD) resistor r=0.1608 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8388 c=0
Rk5 (\5\:n0 \8\:n0) resistor r=0.3989 c=0
Rk6 (\4\:n1 \6\:n1) resistor r=0.4559 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.5094 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1047 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2748 c=0
Rk12 (\7\:n2 \10\:n2) resistor r=0.3435 c=0
Rk13 (\9\:n2 \11\:n2) resistor r=0.7396 c=0
Rl3 (\1\:A \2\:A) resistor r=83.3841 c=0
Rl4 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl12 (\5\:B \6\:B) resistor r=39.5596 c=0
Rl13 (\6\:B \7\:B) resistor r=76.098 c=0
Rl7 (\1\:B \2\:B) resistor r=25.7494 c=0
Rl8 (\2\:B \3\:B) resistor r=146.518 c=0
Rl9 (\2\:B \4\:B) resistor r=5.783 c=0
Rl1 (n0 \2\:n0) resistor r=33.3841 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.1533 c=0
Rl10 (n1 \2\:n1) resistor r=148.077 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl6 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl5 (n2 \2\:n2) resistor r=69.9225 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz8 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\4\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\2\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn3 (\7\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.392e-14 ps=6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn0 (\5\:n1 \3\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.7e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn4 (\7\:n0 \3\:B \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.392e-14 ps=6.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.6e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.247e-14 ps=6.2e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=3.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (\5\:n2 \7\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mp0 (\7\:n1 \1\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.548e-14 ps=1.74e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52442e-07 sb=9.52326e-07 sd=160n sca=21.6735 \
        scb=0.0213374 scc=0.00167521 m=(1)
mp4 (\7\:n1 n2 \4\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.62442e-07 sb=7.42326e-07 sd=160n sca=20.0463 \
        scb=0.0191953 scc=0.00166251 m=(1)
mp3 (\4\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.67442e-07 sb=5.37326e-07 sd=160n sca=19.9753 \
        scb=0.0191105 scc=0.0016624 m=(1)
mp2 (net112 n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.75e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.72442e-07 sb=3.32326e-07 sd=160n sca=21.2505 \
        scb=0.0206889 scc=0.0016691 m=(1)
mp1 (\8\:n2 \5\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=2.63e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18244e-06 sb=1.22326e-07 sd=160n sca=25.996 \
        scb=0.028784 scc=0.00194969 m=(1)
ends XNOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:44:00 2012 )
// Library name: gsclib045
// Cell name: XNOR3X1
// View name: extracted

simulator lang=spectre

subckt XNOR3X1 A B C VDD VSS Y
mp3 (\14\:n62 \1\:A \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.184e-13 ad=5.46e-14 ps=1.83e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.48205e-07 sd=160n sca=32.1464 \
        scb=0.0331985 scc=0.00298203 m=(1)
C1 (B VSS) capacitor c=6.08073e-17
C2 (A VSS) capacitor c=7.25875e-17
C3 (Y VSS) capacitor c=4.34855e-17
C4 (VDD VSS) capacitor c=3.3828e-16
C5 (C VSS) capacitor c=4.25338e-17
C6 (n62 VSS) capacitor c=7.10962e-17
C7 (n61 VSS) capacitor c=6.24514e-17
C8 (n8 VSS) capacitor c=6.84962e-17
C9 (n9 VSS) capacitor c=3.22225e-16
C10 (n12 VSS) capacitor c=8.38856e-17
C11 (n11 VSS) capacitor c=2.9493e-17
C12 (n60 VSS) capacitor c=4.57166e-17
C13 (\3\:C VSS) capacitor c=3.26248e-17
C14 (\7\:C VSS) capacitor c=3.63376e-17
C15 (\3\:n60 VSS) capacitor c=6.6296e-17
C16 (\2\:B VSS) capacitor c=1.03255e-16
C17 (\4\:n61 VSS) capacitor c=7.7742e-17
C18 (\3\:B VSS) capacitor c=1.37532e-16
C19 (\3\:n62 VSS) capacitor c=4.53709e-17
C20 (\8\:B VSS) capacitor c=5.1581e-17
C21 (\1\:A VSS) capacitor c=4.93747e-17
C22 (\3\:n11 VSS) capacitor c=2.43752e-17
C23 (\6\:C VSS) capacitor c=4.525e-17
C24 (\4\:n60 VSS) capacitor c=3.64e-17
C25 (\1\:C VSS) capacitor c=3.95215e-17
C26 (\10\:n61 VSS) capacitor c=4.39928e-17
C27 (\1\:B VSS) capacitor c=8.42928e-17
C28 (\9\:n61 VSS) capacitor c=2.4674e-17
C29 (\6\:B VSS) capacitor c=3.79869e-17
C30 (\7\:B VSS) capacitor c=4.00275e-17
C31 (\4\:A VSS) capacitor c=3.38554e-17
C32 (\2\:n11 VSS) capacitor c=1.68316e-17
C33 (\5\:C VSS) capacitor c=5.49127e-17
C34 (\2\:C VSS) capacitor c=2.24828e-17
C35 (\2\:n8 VSS) capacitor c=6.5037e-17
C36 (\11\:n61 VSS) capacitor c=3.34359e-17
C37 (\7\:n61 VSS) capacitor c=2.82076e-17
C38 (\2\:n61 VSS) capacitor c=8.05051e-17
C39 (\4\:n62 VSS) capacitor c=3.0215e-17
C40 (\3\:n61 VSS) capacitor c=6.35986e-17
C41 (\2\:n62 VSS) capacitor c=5.42016e-17
C42 (\5\:B VSS) capacitor c=8.05733e-17
C43 (\3\:A VSS) capacitor c=1.30862e-17
C44 (\3\:Y VSS) capacitor c=4.07424e-17
C45 (\9\:VDD VSS) capacitor c=6.17507e-17
C46 (\5\:n60 VSS) capacitor c=6.34648e-17
C47 (\3\:n12 VSS) capacitor c=1.5406e-16
C48 (\8\:n11 VSS) capacitor c=1.06037e-16
C49 (\5\:n9 VSS) capacitor c=2.52176e-16
C50 (\4\:n8 VSS) capacitor c=1.43846e-16
C51 (\8\:n12 VSS) capacitor c=6.72538e-17
C52 (\7\:n62 VSS) capacitor c=1.54445e-16
C53 (\6\:n8 VSS) capacitor c=1.1622e-16
C54 (\11\:VDD VSS) capacitor c=2.76779e-17
C55 (\16\:n61 VSS) capacitor c=5.84925e-17
C56 (\13\:VDD VSS) capacitor c=3.15908e-17
C57 (\14\:n62 VSS) capacitor c=2.97121e-17
C58 (\1\:VDD VSS) capacitor c=2.23052e-16
C59 (\8\:n60 VSS) capacitor c=4.82071e-17
C60 (\6\:n11 VSS) capacitor c=9.14466e-17
C61 (\7\:n9 VSS) capacitor c=6.18148e-17
C62 (\9\:n8 VSS) capacitor c=1.37768e-16
C63 (\6\:n12 VSS) capacitor c=1.04628e-16
C64 (\5\:n62 VSS) capacitor c=8.3638e-17
C65 (\3\:n9 VSS) capacitor c=1.1575e-16
C66 (\11\:n8 VSS) capacitor c=1.34396e-16
C67 (\14\:n61 VSS) capacitor c=5.78843e-17
C68 (\11\:n62 VSS) capacitor c=1.16196e-16
C69 (\2\:A VSS) capacitor c=1.90604e-17
C70 (\5\:n61 VSS) capacitor c=4.37543e-17
C71 (\6\:n61 VSS) capacitor c=2.13893e-17
C72 (\4\:B VSS) capacitor c=1.33877e-16
C73 (\2\:n60 VSS) capacitor c=5.37432e-17
C74 (\4\:C VSS) capacitor c=3.80391e-17
C75 (\5\:A VSS) capacitor c=3.23177e-17
C76 (\9\:B VSS) capacitor c=5.32076e-17
C77 (\12\:n61 VSS) capacitor c=1.33774e-17
C78 (\13\:n61 VSS) capacitor c=4.65354e-17
C79 (\18\:n61 VSS) capacitor c=6.03818e-17
C80 (\19\:n61 VSS) capacitor c=5.76527e-17
C81 (\9\:n62 VSS) capacitor c=1.19653e-16
C82 (\10\:n62 VSS) capacitor c=1.45084e-16
C83 (\13\:n62 VSS) capacitor c=8.69722e-17
C84 (\20\:n61 VSS) capacitor c=4.04999e-17
C85 (\21\:n61 VSS) capacitor c=5.84598e-17
C86 (\3\:n8 VSS) capacitor c=5.84038e-17
C87 (\8\:n8 VSS) capacitor c=2.17526e-17
C88 (\8\:C VSS) capacitor c=4.78309e-17
C89 (\9\:C VSS) capacitor c=2.53302e-17
C90 (\5\:n12 VSS) capacitor c=1.67984e-16
C91 (\7\:n60 VSS) capacitor c=4.30278e-17
C92 (\4\:n11 VSS) capacitor c=3.99403e-17
C93 (\5\:n11 VSS) capacitor c=1.92756e-16
C94 (\3\:VDD VSS) capacitor c=5.14035e-19
C95 (\7\:VDD VSS) capacitor c=1.40688e-17
Rk44 (\2\:VSS \3\:VSS) resistor r=0.08271 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.4194 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=1.005 c=0
Rk48 (\7\:VSS VSS) resistor r=0.1533 c=0
Rk47 (\5\:VSS \7\:VSS) resistor r=0.09704 c=0
Rk49 (VSS \9\:VSS) resistor r=0.04124 c=0
Rk50 (\3\:VSS \11\:VSS) resistor r=0.2236 c=0
Rk2 (B \9\:B) resistor r=0.09811 c=0
Rk1 (\5\:A A) resistor r=0.09363 c=0
Rk33 (Y \4\:Y) resistor r=0.3303 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.08271 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.2215 c=0
Rk37 (\5\:VDD VDD) resistor r=0.09756 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.5863 c=0
Rk38 (VDD \6\:VDD) resistor r=0.08096 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.3522 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.08271 c=0
Rk41 (\3\:VDD \10\:VDD) resistor r=0.2565 c=0
Rk42 (\6\:VDD \12\:VDD) resistor r=0.04903 c=0
Rk43 (\7\:VDD \14\:VDD) resistor r=0.1239 c=0
Rk21 (C \8\:C) resistor r=0.3082 c=0
Rk22 (C \9\:C) resistor r=0.02421 c=0
Rk8 (\6\:n62 \8\:n62) resistor r=0.537 c=0
Rk9 (\8\:n62 \9\:n62) resistor r=0.6857 c=0
Rk10 (\9\:n62 \10\:n62) resistor r=0.7105 c=0
Rk11 (\10\:n62 \12\:n62) resistor r=0.7098 c=0
Rk12 (\12\:n62 \13\:n62) resistor r=0.6063 c=0
Rk13 (\10\:n62 \15\:n62) resistor r=0.1074 c=0
Rk3 (\12\:n61 \13\:n61) resistor r=0.0477 c=0
Rk4 (\13\:n61 \15\:n61) resistor r=0.2173 c=0
Rk5 (\13\:n61 \17\:n61) resistor r=0.2062 c=0
Rk7 (\18\:n61 \19\:n61) resistor r=0.2415 c=0
Rk14 (\20\:n61 \21\:n61) resistor r=0.2153 c=0
Rk15 (\3\:n8 \5\:n8) resistor r=0.2704 c=0
Rk16 (\5\:n8 \7\:n8) resistor r=0.8102 c=0
Rk17 (\8\:n8 \10\:n8) resistor r=0.12 c=0
Rk18 (\10\:n8 \12\:n8) resistor r=0.9717 c=0
Rk6 (\2\:n9 \4\:n9) resistor r=0.8306 c=0
Rk19 (\6\:n9 \8\:n9) resistor r=0.5375 c=0
Rk20 (\9\:n9 \10\:n9) resistor r=1.105 c=0
Rk23 (\2\:n12 \4\:n12) resistor r=0.3949 c=0
Rk24 (\4\:n12 \5\:n12) resistor r=0.753 c=0
Rk25 (\5\:n12 \7\:n12) resistor r=0.6441 c=0
Rk26 (\5\:n12 \9\:n12) resistor r=0.3429 c=0
Rk29 (\4\:n11 \5\:n11) resistor r=0.1621 c=0
Rk30 (\5\:n11 \7\:n11) resistor r=0.7721 c=0
Rk31 (\5\:n11 \9\:n11) resistor r=0.7957 c=0
Rk27 (\6\:n60 \7\:n60) resistor r=0.1826 c=0
Rk28 (\7\:n60 \9\:n60) resistor r=0.09203 c=0
Rl14 (\2\:B \3\:B) resistor r=278.412 c=0
Rl13 (\1\:B \2\:B) resistor r=215.425 c=0
Rl19 (\5\:B \8\:B) resistor r=80.6172 c=0
Rl18 (\5\:B \7\:B) resistor r=22.5951 c=0
Rl15 (\3\:B \4\:B) resistor r=222.62 c=0
Rl17 (\4\:B \6\:B) resistor r=63.143 c=0
Rl16 (\4\:B \5\:B) resistor r=332.076 c=0
Rl1 (\1\:A \2\:A) resistor r=90.0987 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=9.8995 c=0
Rl29 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl22 (\1\:C \2\:C) resistor r=47.59 c=0
Rl26 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl28 (\4\:C \6\:C) resistor r=103.08 c=0
Rl27 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=124.029 c=0
Rl4 (n62 \2\:n62) resistor r=223.334 c=0
Rl20 (\10\:n61 \11\:n61) resistor r=53.079 c=0
Rl6 (n61 \2\:n61) resistor r=135.771 c=0
Rl7 (\2\:n61 \3\:n61) resistor r=213.948 c=0
Rl8 (\4\:n61 \5\:n61) resistor r=33.3918 c=0
Rl11 (\5\:n61 \8\:n61) resistor r=17.233 c=0
Rl12 (\6\:n61 \9\:n61) resistor r=37.3411 c=0
Rl10 (\6\:n61 \7\:n61) resistor r=10.9341 c=0
Rl9 (\5\:n61 \6\:n61) resistor r=108.473 c=0
Rl21 (n8 \2\:n8) resistor r=420.614 c=0
Rl30 (n11 \2\:n11) resistor r=24.2328 c=0
Rl31 (\2\:n11 \3\:n11) resistor r=39.6174 c=0
Rl23 (n60 \2\:n60) resistor r=106.101 c=0
Rl24 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl25 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rz17 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz18 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz19 (\10\:VSS \11\:VSS) resistor r=18.75 c=0
Rz12 (\1\:Y Y) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\14\:n61 \15\:n61) resistor r=75 c=0
Rz5 (\9\:n8 \10\:n8) resistor r=75 c=0
Rz6 (\11\:n8 \12\:n8) resistor r=75 c=0
Rz2 (\3\:n9 \4\:n9) resistor r=75 c=0
Rz7 (\7\:n9 \8\:n9) resistor r=75 c=0
Rz8 (n12 \2\:n12) resistor r=75 c=0
Rz9 (\6\:n12 \7\:n12) resistor r=75 c=0
Rz11 (\6\:n11 \7\:n11) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry20 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry14 (\3\:Y \4\:Y) resistor r=62 c=0
Ry15 (\9\:VDD \10\:VDD) resistor r=12.4 c=0
Ry16 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\16\:n61 \17\:n61) resistor r=62 c=0
Ry5 (\4\:n8 \5\:n8) resistor r=62 c=0
Ry6 (\6\:n8 \7\:n8) resistor r=62 c=0
Ry2 (n9 \2\:n9) resistor r=62 c=0
Ry7 (\5\:n9 \6\:n9) resistor r=62 c=0
Ry8 (\5\:n9 \9\:n9) resistor r=62 c=0
Ry9 (n9 \10\:n9) resistor r=62 c=0
Ry10 (\3\:n12 \4\:n12) resistor r=62 c=0
Ry11 (\8\:n12 \9\:n12) resistor r=62 c=0
Ry13 (\8\:n11 \9\:n11) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\5\:B \9\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\3\:n61 \12\:n61) resistor r=45 c=0
Rx4 (\2\:n61 \18\:n61) resistor r=45 c=0
Rx5 (\7\:n61 \19\:n61) resistor r=45 c=0
Rx8 (\11\:n61 \20\:n61) resistor r=45 c=0
Rx9 (\8\:n61 \21\:n61) resistor r=45 c=0
Rx10 (n8 \3\:n8) resistor r=45 c=0
Rx11 (\2\:n8 \8\:n8) resistor r=45 c=0
Rx15 (\2\:n11 \4\:n11) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn3 (\11\:n62 \4\:A \8\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.095e-14 ad=3.485e-14 ps=1.46e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.1561e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn4 (\14\:n61 \7\:B \8\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.095e-14 ad=3.23e-14 ps=1.46e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=13.1062 \
        scb=0.0134056 scc=0.000712852 m=(1)
mn9 (\11\:n8 n62 \6\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.57e-14 ad=5.08e-14 ps=1.11e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn1 (\3\:n9 \6\:B \11\:n8 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.08e-14 ad=8.74e-14 ps=9.7e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn2 (\3\:n9 \9\:n61 \5\:n62 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=8.74e-14 ps=9.3e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.7122e-07 sb=6.8e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn11 (\6\:n12 \1\:B \5\:n62 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17622e-06 sb=3.75e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn10 (\6\:n12 \10\:n61 \9\:n8 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.385e-14 ad=3.28e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38122e-06 sb=1.7e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn6 (\6\:n11 \1\:C \7\:n9 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=4.18e-14 ps=7.2e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn5 (\6\:n11 \4\:n60 n12 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn7 (\8\:n60 \6\:C \10\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mn8 (\1\:Y \3\:n11 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.845e-14 ps=1.77e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp4 (\16\:n61 \8\:B \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.184e-13 ad=7.905e-14 ps=1.83e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.55e-07 sd=160n sca=26.5499 \
        scb=0.0223018 scc=0.00266168 m=(1)
mp9 (\6\:n8 \3\:n62 \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=6.96452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (\6\:n8 n61 n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=9.58e-14 \
        ad=6.82e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.7629e-07 sb=4.31452e-07 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp2 (\7\:n62 \3\:B n9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.58e-14 ad=6.9e-14 ps=1.64e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46923e-07 sb=4.9859e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp11 (\7\:n62 \4\:n61 \8\:n12 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=6.9e-14 ps=1.28e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.09231e-07 sb=2.95513e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp10 (\4\:n8 \2\:B \8\:n12 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=6.83e-14 ps=1.28e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.01452e-07 sb=1.7e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp6 (\5\:n9 \3\:n60 \8\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.83e-14 ps=9.4e-07 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\3\:n12 \7\:C \8\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.27e-14 ps=9.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp7 (\5\:n60 \3\:C \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4125e-13 ad=5.27e-14 ps=2.07e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.94355e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
mp8 (\3\:Y n11 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4125e-13 ad=6.63e-14 ps=2.07e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.01538e-07 sb=1.7e-07 sd=160n sca=41.3017 \
        scb=0.035902 scc=0.00422214 m=(1)
ends XNOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:44:40 2012 )
// Library name: gsclib045
// Cell name: XNOR3XL
// View name: extracted

simulator lang=spectre

subckt XNOR3XL A B C VDD VSS Y
mp3 (\14\:n62 \1\:A \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.085e-13 ad=4.34e-14 ps=1.7e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=24.5071 \
        scb=0.0280884 scc=0.00153635 m=(1)
C1 (B VSS) capacitor c=6.8168e-17
C2 (A VSS) capacitor c=7.43874e-17
C3 (Y VSS) capacitor c=5.09975e-17
C4 (VDD VSS) capacitor c=3.2182e-16
C5 (C VSS) capacitor c=4.18049e-17
C6 (n62 VSS) capacitor c=7.04604e-17
C7 (n61 VSS) capacitor c=6.31099e-17
C8 (n8 VSS) capacitor c=7.46811e-17
C9 (n9 VSS) capacitor c=3.15755e-16
C10 (n12 VSS) capacitor c=7.4579e-17
C11 (n11 VSS) capacitor c=2.44734e-17
C12 (n60 VSS) capacitor c=4.55752e-17
C13 (\3\:C VSS) capacitor c=2.8798e-17
C14 (\7\:C VSS) capacitor c=3.46597e-17
C15 (\3\:n60 VSS) capacitor c=6.79944e-17
C16 (\2\:B VSS) capacitor c=1.00125e-16
C17 (\4\:n61 VSS) capacitor c=6.98535e-17
C18 (\3\:B VSS) capacitor c=9.38738e-17
C19 (\3\:n62 VSS) capacitor c=4.32351e-17
C20 (\8\:B VSS) capacitor c=4.99502e-17
C21 (\1\:A VSS) capacitor c=3.89262e-17
C22 (\3\:n11 VSS) capacitor c=2.77657e-17
C23 (\6\:C VSS) capacitor c=4.48077e-17
C24 (\4\:n60 VSS) capacitor c=3.69419e-17
C25 (\1\:C VSS) capacitor c=4.04835e-17
C26 (\10\:n61 VSS) capacitor c=5.47518e-17
C27 (\1\:B VSS) capacitor c=1.03154e-16
C28 (\9\:n61 VSS) capacitor c=2.3508e-17
C29 (\6\:B VSS) capacitor c=3.7933e-17
C30 (\7\:B VSS) capacitor c=3.57549e-17
C31 (\4\:A VSS) capacitor c=2.90367e-17
C32 (\2\:n11 VSS) capacitor c=2.10272e-17
C33 (\5\:C VSS) capacitor c=5.7436e-17
C34 (\2\:C VSS) capacitor c=2.4221e-17
C35 (\2\:n8 VSS) capacitor c=7.95603e-17
C36 (\11\:n61 VSS) capacitor c=3.84217e-17
C37 (\7\:n61 VSS) capacitor c=2.51989e-17
C38 (\2\:n61 VSS) capacitor c=8.15174e-17
C39 (\4\:n62 VSS) capacitor c=2.90063e-17
C40 (\2\:n62 VSS) capacitor c=5.0723e-17
C41 (\3\:n61 VSS) capacitor c=6.8609e-17
C42 (\5\:B VSS) capacitor c=8.38575e-17
C43 (\3\:A VSS) capacitor c=1.31466e-17
C44 (\1\:Y VSS) capacitor c=3.59234e-17
C45 (\9\:VDD VSS) capacitor c=6.82768e-17
C46 (\5\:n60 VSS) capacitor c=6.50923e-17
C47 (\3\:n12 VSS) capacitor c=1.45466e-16
C48 (\8\:n11 VSS) capacitor c=9.5961e-17
C49 (\5\:n9 VSS) capacitor c=2.37202e-16
C50 (\4\:n8 VSS) capacitor c=1.27998e-16
C51 (\8\:n12 VSS) capacitor c=6.82853e-17
C52 (\7\:n62 VSS) capacitor c=1.5607e-16
C53 (\6\:n8 VSS) capacitor c=1.04611e-16
C54 (\11\:VDD VSS) capacitor c=1.08408e-17
C55 (\16\:n61 VSS) capacitor c=6.90543e-17
C56 (\13\:VDD VSS) capacitor c=4.05064e-17
C57 (\14\:n62 VSS) capacitor c=2.69388e-17
C58 (\1\:VDD VSS) capacitor c=1.7542e-16
C59 (\8\:n60 VSS) capacitor c=4.83745e-17
C60 (\6\:n11 VSS) capacitor c=9.14729e-17
C61 (\8\:n9 VSS) capacitor c=5.51077e-17
C62 (\9\:n8 VSS) capacitor c=1.27875e-16
C63 (\6\:n12 VSS) capacitor c=1.00866e-16
C64 (\5\:n62 VSS) capacitor c=9.31017e-17
C65 (\3\:n9 VSS) capacitor c=1.14837e-16
C66 (\11\:n8 VSS) capacitor c=1.40723e-16
C67 (\14\:n61 VSS) capacitor c=5.7455e-17
C68 (\11\:n62 VSS) capacitor c=1.16552e-16
C69 (\2\:A VSS) capacitor c=2.00682e-17
C70 (\5\:n61 VSS) capacitor c=4.78853e-17
C71 (\6\:n61 VSS) capacitor c=2.53963e-17
C72 (\4\:B VSS) capacitor c=1.55293e-16
C73 (\2\:n60 VSS) capacitor c=4.87572e-17
C74 (\4\:C VSS) capacitor c=3.82778e-17
C75 (\5\:A VSS) capacitor c=3.66254e-17
C76 (\9\:B VSS) capacitor c=4.7638e-17
C77 (\12\:n61 VSS) capacitor c=1.30488e-17
C78 (\13\:n61 VSS) capacitor c=4.20344e-17
C79 (\18\:n61 VSS) capacitor c=6.45262e-17
C80 (\19\:n61 VSS) capacitor c=6.62042e-17
C81 (\9\:n62 VSS) capacitor c=1.32559e-16
C82 (\10\:n62 VSS) capacitor c=1.6379e-16
C83 (\13\:n62 VSS) capacitor c=7.3726e-17
C84 (\20\:n61 VSS) capacitor c=4.17572e-17
C85 (\21\:n61 VSS) capacitor c=5.84546e-17
C86 (\3\:n8 VSS) capacitor c=5.22341e-17
C87 (\8\:n8 VSS) capacitor c=2.14868e-17
C88 (\8\:C VSS) capacitor c=3.06236e-17
C89 (\9\:C VSS) capacitor c=3.65988e-17
C90 (\5\:n12 VSS) capacitor c=1.6652e-16
C91 (\7\:n60 VSS) capacitor c=4.3197e-17
C92 (\4\:n11 VSS) capacitor c=3.91563e-17
C93 (\5\:n11 VSS) capacitor c=1.91536e-16
C94 (\3\:VDD VSS) capacitor c=2.88806e-19
C95 (\6\:VDD VSS) capacitor c=2.45046e-17
Rk2 (B \9\:B) resistor r=0.07476 c=0
Rk1 (\5\:A A) resistor r=0.08124 c=0
Rk32 (\2\:Y Y) resistor r=0.2806 c=0
Rk33 (Y \4\:Y) resistor r=0.03227 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.08256 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.3183 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.9028 c=0
Rk38 (\6\:VDD VDD) resistor r=0.2895 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.2597 c=0
Rk39 (VDD \7\:VDD) resistor r=0.06024 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.09009 c=0
Rk41 (\3\:VDD \10\:VDD) resistor r=0.236 c=0
Rk42 (\6\:VDD \12\:VDD) resistor r=0.04331 c=0
Rk43 (\7\:VDD \14\:VDD) resistor r=0.124 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.08256 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.1678 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.7524 c=0
Rk48 (\6\:VSS VSS) resistor r=0.2519 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.5982 c=0
Rk50 (VSS \9\:VSS) resistor r=0.1218 c=0
Rk51 (\3\:VSS \11\:VSS) resistor r=0.2276 c=0
Rk52 (\6\:VSS \13\:VSS) resistor r=0.04331 c=0
Rk21 (\8\:C C) resistor r=0.1487 c=0
Rk22 (C \9\:C) resistor r=0.1626 c=0
Rk8 (\6\:n62 \8\:n62) resistor r=0.5309 c=0
Rk9 (\8\:n62 \9\:n62) resistor r=0.7002 c=0
Rk10 (\9\:n62 \10\:n62) resistor r=0.7521 c=0
Rk11 (\10\:n62 \12\:n62) resistor r=0.6936 c=0
Rk12 (\12\:n62 \13\:n62) resistor r=0.5851 c=0
Rk13 (\10\:n62 \15\:n62) resistor r=0.113 c=0
Rk3 (\12\:n61 \13\:n61) resistor r=0.03536 c=0
Rk4 (\13\:n61 \15\:n61) resistor r=0.2047 c=0
Rk5 (\13\:n61 \17\:n61) resistor r=0.2322 c=0
Rk7 (\18\:n61 \19\:n61) resistor r=0.2584 c=0
Rk14 (\20\:n61 \21\:n61) resistor r=0.1661 c=0
Rk15 (\3\:n8 \5\:n8) resistor r=0.2376 c=0
Rk16 (\5\:n8 \7\:n8) resistor r=0.7362 c=0
Rk17 (\8\:n8 \10\:n8) resistor r=0.1186 c=0
Rk18 (\10\:n8 \12\:n8) resistor r=0.9606 c=0
Rk6 (\2\:n9 \4\:n9) resistor r=0.8462 c=0
Rk19 (\6\:n9 \7\:n9) resistor r=1.0098 c=0
Rk20 (\9\:n9 \10\:n9) resistor r=0.4429 c=0
Rk23 (\2\:n12 \4\:n12) resistor r=0.3763 c=0
Rk24 (\4\:n12 \5\:n12) resistor r=0.7219 c=0
Rk25 (\5\:n12 \7\:n12) resistor r=0.6327 c=0
Rk26 (\5\:n12 \9\:n12) resistor r=0.339 c=0
Rk29 (\4\:n11 \5\:n11) resistor r=0.1546 c=0
Rk30 (\5\:n11 \7\:n11) resistor r=0.8123 c=0
Rk31 (\5\:n11 \9\:n11) resistor r=0.7381 c=0
Rk27 (\6\:n60 \7\:n60) resistor r=0.1817 c=0
Rk28 (\7\:n60 \9\:n60) resistor r=0.09164 c=0
Rl14 (\2\:B \3\:B) resistor r=284.181 c=0
Rl13 (\1\:B \2\:B) resistor r=244.165 c=0
Rl19 (\5\:B \8\:B) resistor r=97.3098 c=0
Rl18 (\5\:B \7\:B) resistor r=30.0021 c=0
Rl15 (\3\:B \4\:B) resistor r=241.851 c=0
Rl17 (\4\:B \6\:B) resistor r=57.3738 c=0
Rl16 (\4\:B \5\:B) resistor r=336.808 c=0
Rl1 (\1\:A \2\:A) resistor r=107.406 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=8.3038 c=0
Rl29 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl22 (\1\:C \2\:C) resistor r=47.59 c=0
Rl26 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl28 (\4\:C \6\:C) resistor r=103.08 c=0
Rl27 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=132.902 c=0
Rl4 (n62 \2\:n62) resistor r=221.411 c=0
Rl20 (\10\:n61 \11\:n61) resistor r=47.3097 c=0
Rl6 (n61 \2\:n61) resistor r=135.771 c=0
Rl7 (\2\:n61 \3\:n61) resistor r=213.948 c=0
Rl8 (\4\:n61 \5\:n61) resistor r=98.7765 c=0
Rl11 (\5\:n61 \8\:n61) resistor r=17.233 c=0
Rl12 (\6\:n61 \9\:n61) resistor r=34.3295 c=0
Rl10 (\6\:n61 \7\:n61) resistor r=8.3038 c=0
Rl9 (\5\:n61 \6\:n61) resistor r=101.615 c=0
Rl21 (n8 \2\:n8) resistor r=176.032 c=0
Rl30 (n11 \2\:n11) resistor r=41.5405 c=0
Rl31 (\2\:n11 \3\:n11) resistor r=64.6174 c=0
Rl23 (n60 \2\:n60) resistor r=106.101 c=0
Rl24 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl25 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz17 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz18 (\10\:VSS \11\:VSS) resistor r=18.75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\14\:n61 \15\:n61) resistor r=75 c=0
Rz5 (\9\:n8 \10\:n8) resistor r=75 c=0
Rz6 (\11\:n8 \12\:n8) resistor r=75 c=0
Rz2 (\3\:n9 \4\:n9) resistor r=75 c=0
Rz7 (\8\:n9 \9\:n9) resistor r=75 c=0
Rz8 (n12 \2\:n12) resistor r=75 c=0
Rz9 (\6\:n12 \7\:n12) resistor r=75 c=0
Rz11 (\6\:n11 \7\:n11) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\9\:VDD \10\:VDD) resistor r=12.4 c=0
Ry16 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry21 (\1\:VSS VSS) resistor r=12.4 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry20 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\16\:n61 \17\:n61) resistor r=62 c=0
Ry5 (\4\:n8 \5\:n8) resistor r=62 c=0
Ry6 (\6\:n8 \7\:n8) resistor r=62 c=0
Ry2 (n9 \2\:n9) resistor r=62 c=0
Ry7 (\5\:n9 \6\:n9) resistor r=62 c=0
Ry8 (n9 \7\:n9) resistor r=62 c=0
Ry9 (\5\:n9 \10\:n9) resistor r=62 c=0
Ry10 (\3\:n12 \4\:n12) resistor r=62 c=0
Ry11 (\8\:n12 \9\:n12) resistor r=62 c=0
Ry13 (\8\:n11 \9\:n11) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\5\:B \9\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\5\:C \8\:C) resistor r=45 c=0
Rx13 (\2\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\3\:n61 \12\:n61) resistor r=45 c=0
Rx4 (\2\:n61 \18\:n61) resistor r=45 c=0
Rx5 (\7\:n61 \19\:n61) resistor r=45 c=0
Rx8 (\11\:n61 \20\:n61) resistor r=45 c=0
Rx9 (\8\:n61 \21\:n61) resistor r=45 c=0
Rx10 (n8 \3\:n8) resistor r=45 c=0
Rx11 (\2\:n8 \8\:n8) resistor r=45 c=0
Rx15 (\2\:n11 \4\:n11) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn3 (\11\:n62 \4\:A \8\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=3.485e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.19756e-07 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mn4 (\14\:n61 \7\:B \8\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=3.23e-14 ps=1.54e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.7e-07 sd=160n sca=14.2386 \
        scb=0.0147775 scc=0.000909887 m=(1)
mn9 (\11\:n8 n62 \12\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.75e-14 ad=5.26e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn1 (\3\:n9 \6\:B \11\:n8 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.26e-14 ad=7.6e-14 ps=1e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn2 (\3\:n9 \9\:n61 \5\:n62 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=7.6e-14 ps=9e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=7.1e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn11 (\6\:n12 \1\:B \5\:n62 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.82e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=4.05e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn10 (\6\:n12 \10\:n61 \9\:n8 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=3.82e-14 ps=9.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32634e-06 sb=1.7e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn6 (\6\:n11 \1\:C \8\:n9 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.23e-14 ad=4.18e-14 ps=7.2e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn5 (\6\:n11 \4\:n60 n12 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn7 (\8\:n60 \6\:C \10\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mn8 (\3\:Y \3\:n11 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.485e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp4 (\16\:n61 \8\:B \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.085e-13 ad=7.595e-14 ps=1.7e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2.45e-07 sd=160n sca=16.826 \
        scb=0.0155728 scc=0.000870508 m=(1)
mp9 (\6\:n8 \3\:n62 \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.07e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.61774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (\6\:n8 n61 n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=9.18e-14 \
        ad=6.82e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.35e-07 sb=4.96774e-07 sd=160n sca=10.5719 scb=0.0081746 \
        scc=0.000117241 m=(1)
mp2 (\7\:n62 \3\:B n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.18e-14 ad=6.355e-14 ps=1.64e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.26452e-07 sb=5.65242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp11 (\7\:n62 \4\:n61 \8\:n12 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=6.355e-14 ps=1.21e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.76452e-07 sb=3.15242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp10 (\4\:n8 \2\:B \8\:n12 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=5.93e-14 ps=1.21e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.23468e-07 sb=1.7e-07 sd=160n sca=10.9702 \
        scb=0.00883933 scc=0.000174052 m=(1)
mp6 (\5\:n9 \3\:n60 \8\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.055e-13 ps=9.4e-07 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\3\:n12 \7\:C \8\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.27e-14 ps=9.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp7 (\5\:n60 \3\:C \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=5.27e-14 ps=1.85e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.30242e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
mp8 (\1\:Y n11 \9\:VDD VDD) g45p1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=3.485e-14 ps=1.85e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=28.0221 scb=0.032906 \
        scc=0.00213116 m=(1)
ends XNOR3XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:36:21 2012 )
// Library name: gsclib045
// Cell name: XOR2X1
// View name: extracted

simulator lang=spectre

subckt XOR2X1 A B VDD VSS Y
mp5 (\3\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.87115e-07 sd=160n sca=38.6307 \
        scb=0.0321643 scc=0.00380145 m=(1)
C1 (A VSS) capacitor c=9.61838e-17
C2 (Y VSS) capacitor c=1.49768e-17
C3 (VDD VSS) capacitor c=1.22108e-16
C4 (n0 VSS) capacitor c=4.06128e-17
C5 (n1 VSS) capacitor c=4.71489e-17
C6 (n2 VSS) capacitor c=3.42433e-17
C7 (net130 VSS) capacitor c=3.2875e-18
C8 (\7\:B VSS) capacitor c=4.00746e-17
C9 (\3\:n1 VSS) capacitor c=7.16692e-17
C10 (\1\:B VSS) capacitor c=4.49761e-17
C11 (\1\:A VSS) capacitor c=4.63311e-17
C12 (\5\:B VSS) capacitor c=3.62522e-17
C13 (\3\:B VSS) capacitor c=6.45495e-17
C14 (\3\:n2 VSS) capacitor c=6.56065e-17
C15 (\3\:A VSS) capacitor c=3.68305e-17
C16 (\3\:n0 VSS) capacitor c=3.47041e-17
C17 (\6\:B VSS) capacitor c=4.98476e-17
C18 (\2\:n1 VSS) capacitor c=7.34484e-17
C19 (\4\:B VSS) capacitor c=6.14704e-17
C20 (\2\:n2 VSS) capacitor c=6.22106e-17
C21 (\2\:B VSS) capacitor c=5.56873e-17
C22 (\2\:A VSS) capacitor c=4.6988e-17
C23 (\2\:n0 VSS) capacitor c=2.75721e-17
C24 (\6\:n2 VSS) capacitor c=1.0206e-16
C25 (\7\:VDD VSS) capacitor c=4.42523e-17
C26 (\7\:n0 VSS) capacitor c=1.1658e-16
C27 (\6\:n1 VSS) capacitor c=6.42075e-17
C28 (\9\:VDD VSS) capacitor c=2.72283e-17
C29 (\3\:Y VSS) capacitor c=8.46711e-17
C30 (\1\:VDD VSS) capacitor c=4.35488e-17
C31 (\4\:n2 VSS) capacitor c=5.57801e-17
C32 (\4\:n0 VSS) capacitor c=1.26802e-16
C33 (\8\:n1 VSS) capacitor c=3.8519e-17
C34 (\1\:Y VSS) capacitor c=7.5761e-17
C35 (\4\:A VSS) capacitor c=7.37136e-17
C36 (\6\:n0 VSS) capacitor c=2.83532e-16
C37 (\4\:n1 VSS) capacitor c=7.23955e-17
C38 (\5\:n1 VSS) capacitor c=1.47277e-16
C39 (\8\:B VSS) capacitor c=4.73523e-17
C40 (\9\:B VSS) capacitor c=1.02833e-16
C41 (\10\:B VSS) capacitor c=7.17341e-17
C42 (\8\:n2 VSS) capacitor c=7.13372e-17
Rk3 (A \4\:A) resistor r=0.2026 c=0
Rk2 (\4\:Y Y) resistor r=0.03363 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.488 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1027 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1981 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1972 c=0
Rk25 (\6\:VDD VDD) resistor r=0.04996 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.1018 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.3038 c=0
Rk27 (\5\:VDD \10\:VDD) resistor r=0.06847 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.09269 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.2082 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1972 c=0
Rk18 (\6\:VSS VSS) resistor r=0.04996 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.1018 c=0
Rk19 (\3\:VSS \8\:VSS) resistor r=0.3132 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.0509 c=0
Rk9 (\8\:B B) resistor r=0.1378 c=0
Rk10 (B \9\:B) resistor r=0.03572 c=0
Rk11 (\9\:B \10\:B) resistor r=0.1734 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.9195 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8649 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4267 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.4706 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.09434 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.5146 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.4061 c=0
Rl3 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl4 (\2\:A \3\:A) resistor r=69.9225 c=0
Rl12 (\6\:B \7\:B) resistor r=91.5895 c=0
Rl11 (\5\:B \6\:B) resistor r=70.9489 c=0
Rl8 (\3\:B \4\:B) resistor r=74.2328 c=0
Rl5 (\1\:B \2\:B) resistor r=87.6365 c=0
Rl1 (n0 \2\:n0) resistor r=35.3072 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rl9 (n1 \2\:n1) resistor r=32.267 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=136.894 c=0
Rl6 (n2 \2\:n2) resistor r=24.2328 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=148.798 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry7 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \8\:n2) resistor r=45 c=0
mn5 (\1\:Y \3\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.64e-14 ps=1.56e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.08942e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\8\:n1 \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.915e-14 ps=1.56e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.7e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\4\:n0 \3\:n2 \8\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net131 n1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.5e-07 sd=160n sca=15.0952 \
        scb=0.0139603 scc=0.000435069 m=(1)
mp4 (\6\:n1 \1\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.45e-07 sd=160n sca=13.633 \
        scb=0.0120861 scc=0.000425416 m=(1)
mp3 (\7\:n0 n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=5.25e-07 sd=160n sca=13.6458 \
        scb=0.0121015 scc=0.000425438 m=(1)
mp2 (net130 \3\:n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=14.8634 \
        scb=0.0136114 scc=0.000432055 m=(1)
mp1 (\6\:n2 \7\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=19.3929 \
        scb=0.0213506 scc=0.000688958 m=(1)
ends XOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:45:58 2012 )
// Library name: gsclib045
// Cell name: XOR2X2
// View name: extracted

simulator lang=spectre

subckt XOR2X2 A B VDD VSS Y
mp5 (\3\:Y n0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.826e-14 ad=6.24e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.73526e-07 sd=160n sca=22.1173 \
        scb=0.0235828 scc=0.00128647 m=(2)
C1 (Y VSS) capacitor c=6.22403e-17
C2 (VDD VSS) capacitor c=1.19273e-16
C3 (B VSS) capacitor c=5.61544e-17
C4 (n0 VSS) capacitor c=1.31997e-16
C5 (n1 VSS) capacitor c=4.78161e-17
C6 (n2 VSS) capacitor c=2.97981e-17
C7 (net130 VSS) capacitor c=1.88405e-18
C8 (\7\:B VSS) capacitor c=3.75135e-17
C9 (\3\:n1 VSS) capacitor c=8.85616e-17
C10 (\2\:n2 VSS) capacitor c=7.84385e-17
C11 (\1\:B VSS) capacitor c=4.11561e-17
C12 (\1\:A VSS) capacitor c=3.64951e-17
C13 (\5\:B VSS) capacitor c=3.98244e-17
C14 (\3\:B VSS) capacitor c=6.95992e-17
C15 (\3\:n2 VSS) capacitor c=7.24839e-17
C16 (\3\:A VSS) capacitor c=3.97592e-17
C17 (\6\:B VSS) capacitor c=5.33522e-17
C18 (\2\:n1 VSS) capacitor c=7.82379e-17
C19 (\4\:B VSS) capacitor c=7.10654e-17
C20 (\2\:B VSS) capacitor c=4.43991e-17
C21 (\2\:A VSS) capacitor c=3.5925e-17
C22 (\8\:n2 VSS) capacitor c=1.08999e-17
C23 (\1\:VDD VSS) capacitor c=6.78298e-17
C24 (\10\:n0 VSS) capacitor c=1.13399e-16
C25 (\6\:n1 VSS) capacitor c=5.98114e-17
C26 (\3\:Y VSS) capacitor c=8.60307e-17
C27 (\4\:n2 VSS) capacitor c=5.56552e-17
C28 (\7\:n0 VSS) capacitor c=1.05194e-16
C29 (\8\:n1 VSS) capacitor c=3.78471e-17
C30 (\1\:Y VSS) capacitor c=4.48088e-17
C31 (\4\:A VSS) capacitor c=1.29509e-16
C32 (\9\:n0 VSS) capacitor c=2.55324e-16
C33 (\4\:n1 VSS) capacitor c=8.9777e-17
C34 (\5\:n1 VSS) capacitor c=9.09507e-17
C35 (\8\:B VSS) capacitor c=2.95882e-17
C36 (\9\:B VSS) capacitor c=3.35638e-17
C37 (\10\:B VSS) capacitor c=4.60794e-17
C38 (\6\:n2 VSS) capacitor c=1.11553e-16
C39 (\7\:n2 VSS) capacitor c=8.167e-17
C40 (\4\:VDD VSS) capacitor c=3.70884e-17
C41 (\5\:VDD VSS) capacitor c=9.02123e-17
Rk3 (A \4\:A) resistor r=0.03171 c=0
Rk1 (\2\:Y Y) resistor r=0.1481 c=0
Rk2 (Y \4\:Y) resistor r=0.4376 c=0
Rk24 (\2\:VDD \4\:VDD) resistor r=0.5922 c=0
Rk27 (\5\:VDD VDD) resistor r=0.02463 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.1794 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.1026 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.248 c=0
Rk20 (\5\:VSS VSS) resistor r=0.02463 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.2455 c=0
Rk21 (\3\:VSS \9\:VSS) resistor r=0.31 c=0
Rk9 (\8\:B B) resistor r=0.1668 c=0
Rk10 (B \9\:B) resistor r=0.06849 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2021 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.9513 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.9572 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4557 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.3155 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.1277 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.524 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.6001 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04786 c=0
Rl6 (\1\:A \2\:A) resistor r=60.7134 c=0
Rl7 (\2\:A \3\:A) resistor r=99.1749 c=0
Rl15 (\6\:B \7\:B) resistor r=78.8233 c=0
Rl14 (\5\:B \6\:B) resistor r=86.3335 c=0
Rl11 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl8 (\1\:B \2\:B) resistor r=71.8456 c=0
Rl12 (n1 \2\:n1) resistor r=31.791 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=149.361 c=0
Rl9 (n2 \2\:n2) resistor r=24.2328 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=208.747 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz5 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\4\:Y \3\:Y) resistor r=62 c=0
Ry8 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\4\:VSS \1\:VSS) resistor r=12.4 c=0
Ry7 (\5\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry2 (\11\:n0 \10\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (n2 \7\:n2) resistor r=45 c=0
mn5 (\1\:Y n0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.483e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.95577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\8\:n1 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=5.728e-14 ps=9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.095e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net131 n1 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\7\:n0 \3\:n2 \8\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.32e-14 ps=1.08e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\7\:n0 \3\:B net131 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0243e-13 ad=5.805e-14 ps=1.74e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.015e-06 sd=160n sca=13.1802 \
        scb=0.0118482 scc=0.000425234 m=(1)
mp4 (\6\:n1 \1\:B \10\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=5.805e-14 ps=7.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=7e-07 sd=160n sca=12.8224 scb=0.011715 \
        scc=0.000425192 m=(1)
mp3 (\10\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.87e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=4.75e-07 sd=160n sca=13.569 \
        scb=0.0120992 scc=0.00042546 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=3.45e-07 sd=160n sca=14.4226 \
        scb=0.0130013 scc=0.000428203 m=(1)
mp1 (\8\:n2 \7\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=17.794 \
        scb=0.0186079 scc=0.000545865 m=(1)
ends XOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:46:38 2012 )
// Library name: gsclib045
// Cell name: XOR2X4
// View name: extracted

simulator lang=spectre

subckt XOR2X4 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.119e-14 \
        ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.42346e-06 sd=160n sca=25.2855 scb=0.0288799 \
        scc=0.00168046 m=(4)
C1 (A VSS) capacitor c=7.37488e-17
C2 (Y VSS) capacitor c=1.89651e-17
C3 (VDD VSS) capacitor c=3.11805e-16
C4 (B VSS) capacitor c=3.6488e-17
C5 (n0 VSS) capacitor c=2.60333e-16
C6 (n1 VSS) capacitor c=6.3182e-17
C7 (n2 VSS) capacitor c=3.95223e-17
C8 (net131 VSS) capacitor c=3.62849e-18
C9 (net130 VSS) capacitor c=2.74008e-18
C10 (\4\:B VSS) capacitor c=5.02646e-17
C11 (\3\:n2 VSS) capacitor c=5.95517e-17
C12 (\3\:B VSS) capacitor c=5.68969e-17
C13 (\1\:A VSS) capacitor c=4.40839e-17
C14 (\6\:B VSS) capacitor c=4.05134e-17
C15 (\3\:n1 VSS) capacitor c=6.96245e-17
C16 (\1\:B VSS) capacitor c=3.98424e-17
C17 (\3\:A VSS) capacitor c=3.65486e-17
C18 (\5\:B VSS) capacitor c=4.51338e-17
C19 (\2\:n1 VSS) capacitor c=5.18504e-17
C20 (\2\:B VSS) capacitor c=6.62274e-17
C21 (\4\:n2 VSS) capacitor c=4.54071e-17
C22 (\2\:n2 VSS) capacitor c=2.82929e-17
C23 (\2\:A VSS) capacitor c=3.87991e-17
C24 (\5\:n2 VSS) capacitor c=4.70201e-17
C25 (\1\:VDD VSS) capacitor c=5.69045e-17
C26 (\13\:n0 VSS) capacitor c=1.20004e-16
C27 (\4\:n1 VSS) capacitor c=3.83433e-17
C28 (\1\:Y VSS) capacitor c=1.77087e-16
C29 (\10\:n2 VSS) capacitor c=1.87363e-17
C30 (\17\:n0 VSS) capacitor c=1.1262e-16
C31 (\7\:n1 VSS) capacitor c=8.77474e-17
C32 (\4\:Y VSS) capacitor c=1.23893e-16
C33 (\4\:A VSS) capacitor c=7.05318e-17
C34 (\15\:n0 VSS) capacitor c=2.0701e-16
C35 (\16\:n0 VSS) capacitor c=2.50916e-17
C36 (\6\:n1 VSS) capacitor c=8.19057e-17
C37 (\9\:n1 VSS) capacitor c=8.44882e-17
C38 (\7\:B VSS) capacitor c=5.48536e-17
C39 (\8\:B VSS) capacitor c=3.14318e-17
C40 (\7\:n2 VSS) capacitor c=1.10734e-16
C41 (\8\:n2 VSS) capacitor c=7.49964e-17
C42 (\9\:n2 VSS) capacitor c=3.18732e-17
C43 (\12\:n2 VSS) capacitor c=5.54011e-17
C44 (\4\:VDD VSS) capacitor c=4.02044e-17
Rk6 (\4\:A \5\:A) resistor r=0.006435 c=0
Rk7 (\6\:A A) resistor r=0.006521 c=0
Rk8 (\5\:A \6\:A) resistor r=0.0943 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.09013 c=0
Rk31 (\4\:VSS VSS) resistor r=0.03995 c=0
Rk30 (\3\:VSS \4\:VSS) resistor r=0.5117 c=0
Rk35 (\3\:VSS \10\:VSS) resistor r=0.2006 c=0
Rk2 (\1\:Y Y) resistor r=0.03962 c=0
Rk3 (Y \4\:Y) resistor r=0.3399 c=0
Rk23 (\4\:VDD VDD) resistor r=0.1554 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.7599 c=0
Rk15 (B \7\:B) resistor r=0.1778 c=0
Rk16 (B \8\:B) resistor r=0.0301 c=0
Rk9 (\14\:n0 \15\:n0) resistor r=1.0357 c=0
Rk10 (\15\:n0 \16\:n0) resistor r=0.109 c=0
Rk11 (\15\:n0 \18\:n0) resistor r=0.8439 c=0
Rk12 (\5\:n1 \6\:n1) resistor r=0.1048 c=0
Rk13 (\6\:n1 \8\:n1) resistor r=0.364 c=0
Rk14 (\6\:n1 \9\:n1) resistor r=0.5203 c=0
Rk17 (\6\:n2 \7\:n2) resistor r=0.5264 c=0
Rk18 (\7\:n2 \8\:n2) resistor r=0.5889 c=0
Rk19 (\8\:n2 \9\:n2) resistor r=0.08708 c=0
Rk20 (\7\:n2 \11\:n2) resistor r=0.07544 c=0
Rk21 (\8\:n2 \12\:n2) resistor r=0.2588 c=0
Rl12 (\1\:A \2\:A) resistor r=116.076 c=0
Rl13 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl20 (\4\:B \5\:B) resistor r=117.288 c=0
Rl21 (\5\:B \6\:B) resistor r=86.5184 c=0
Rl17 (\2\:B \3\:B) resistor r=166.862 c=0
Rl16 (\1\:B \2\:B) resistor r=31.9251 c=0
Rl18 (n1 \2\:n1) resistor r=24.2328 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=116.54 c=0
Rl15 (\3\:n2 \4\:n2) resistor r=39.6174 c=0
Rl14 (n2 \2\:n2) resistor r=37.2302 c=0
Rz8 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\18\:n0 \17\:n0) resistor r=75 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\10\:n2 \11\:n2) resistor r=75 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry11 (\4\:VSS \1\:VSS) resistor r=6.2 c=0
Ry6 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\5\:n2 \6\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:B \7\:B) resistor r=45 c=0
Rx5 (\5\:B \8\:B) resistor r=45 c=0
Rx2 (\16\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \9\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \12\:n2) resistor r=45 c=0
mn5 (\4\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.026e-14 \
        ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.37231e-06 sd=160n sca=11.5806 scb=0.0111274 \
        scc=0.000535497 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.145e-14 ad=6.733e-14 ps=9e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.04569e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\17\:n0 n2 \7\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.733e-14 ad=6.24e-14 ps=1.29e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.36154e-07 sb=7.01635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\17\:n0 \1\:B net131 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=6.24e-14 ps=7.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12115e-06 sb=4.16635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (net131 \3\:n1 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.51e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.30115e-06 sb=2.36635e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\10\:n2 \6\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02448e-06 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp0 (\4\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.25e-13 ps=1.16e-06 pd=1.78e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.18872e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\4\:n1 \3\:B \13\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.25e-13 ps=1.1e-06 pd=1.78e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.9109e-07 sb=5.85064e-07 sd=160n sca=16.6552 \
        scb=0.0146982 scc=0.00118864 m=(1)
mp3 (\13\:n0 \3\:n2 net130 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09609e-06 sb=3.80064e-07 sd=160n sca=17.6259 \
        scb=0.0154648 scc=0.00118993 m=(1)
mp2 (net130 n1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.9e-14 ps=1.1e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24109e-06 sb=2.35064e-07 sd=160n sca=19.1246 \
        scb=0.0176055 scc=0.00120723 m=(1)
mp1 (\5\:n2 \4\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71849e-06 sb=1.4e-07 sd=160n sca=24.9308 \
        scb=0.0292329 scc=0.0015565 m=(1)
ends XOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:37:09 2012 )
// Library name: gsclib045
// Cell name: XOR2XL
// View name: extracted

simulator lang=spectre

subckt XOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=3.01e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=25.0648 \
        scb=0.0294525 scc=0.00155947 m=(1)
C1 (A VSS) capacitor c=1.18154e-16
C2 (Y VSS) capacitor c=6.78553e-17
C3 (VDD VSS) capacitor c=1.28579e-16
C4 (B VSS) capacitor c=2.47732e-17
C5 (n0 VSS) capacitor c=4.19608e-17
C6 (n1 VSS) capacitor c=2.6303e-17
C7 (n2 VSS) capacitor c=6.4662e-17
C8 (net130 VSS) capacitor c=5.21894e-19
C9 (\7\:B VSS) capacitor c=3.65474e-17
C10 (\3\:n1 VSS) capacitor c=8.52312e-17
C11 (\2\:n2 VSS) capacitor c=5.84681e-17
C12 (\2\:B VSS) capacitor c=3.6827e-17
C13 (\1\:A VSS) capacitor c=4.00592e-17
C14 (\5\:B VSS) capacitor c=4.23866e-17
C15 (\4\:n1 VSS) capacitor c=4.24271e-17
C16 (\3\:B VSS) capacitor c=6.07595e-17
C17 (\3\:A VSS) capacitor c=4.29329e-17
C18 (\3\:n0 VSS) capacitor c=3.04869e-17
C19 (\6\:B VSS) capacitor c=5.98265e-17
C20 (\4\:B VSS) capacitor c=6.40614e-17
C21 (\3\:n2 VSS) capacitor c=3.31186e-17
C22 (\1\:B VSS) capacitor c=3.84951e-17
C23 (\2\:A VSS) capacitor c=3.9677e-17
C24 (\2\:n0 VSS) capacitor c=3.9628e-17
C25 (\8\:n2 VSS) capacitor c=1.07795e-17
C26 (\7\:VDD VSS) capacitor c=4.32719e-17
C27 (\7\:n0 VSS) capacitor c=1.24285e-16
C28 (\7\:n1 VSS) capacitor c=7.46724e-17
C29 (\9\:VDD VSS) capacitor c=1.40752e-17
C30 (\1\:Y VSS) capacitor c=5.51624e-17
C31 (\1\:VDD VSS) capacitor c=5.89447e-17
C32 (\4\:n2 VSS) capacitor c=3.99849e-17
C33 (\4\:n0 VSS) capacitor c=1.1781e-16
C34 (\9\:n1 VSS) capacitor c=4.03226e-17
C35 (\3\:Y VSS) capacitor c=2.85194e-17
C36 (\2\:n1 VSS) capacitor c=5.31009e-17
C37 (\4\:A VSS) capacitor c=7.48347e-17
C38 (\6\:n0 VSS) capacitor c=2.79883e-16
C39 (\5\:n1 VSS) capacitor c=6.98327e-17
C40 (\6\:n1 VSS) capacitor c=1.00633e-16
C41 (\8\:B VSS) capacitor c=6.33711e-17
C42 (\9\:B VSS) capacitor c=4.7616e-17
C43 (\10\:B VSS) capacitor c=6.27484e-17
C44 (\6\:n2 VSS) capacitor c=1.09292e-16
C45 (\7\:n2 VSS) capacitor c=9.4099e-17
C46 (\5\:VDD VSS) capacitor c=4.91091e-19
Rk3 (A \4\:A) resistor r=0.2701 c=0
Rk1 (\2\:Y Y) resistor r=0.2725 c=0
Rk2 (Y \4\:Y) resistor r=0.0976 c=0
Rk20 (\2\:VDD \3\:VDD) resistor r=0.1102 c=0
Rk21 (\3\:VDD \4\:VDD) resistor r=0.1906 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk24 (\6\:VDD VDD) resistor r=0.04995 c=0
Rk23 (\5\:VDD \6\:VDD) resistor r=0.07761 c=0
Rk25 (\3\:VDD \8\:VDD) resistor r=0.3135 c=0
Rk26 (\5\:VDD \10\:VDD) resistor r=0.1048 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.4443 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.3386 c=0
Rk18 (\6\:VSS VSS) resistor r=0.04995 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.06255 c=0
Rk19 (\5\:VSS \8\:VSS) resistor r=0.09135 c=0
Rk10 (\9\:B B) resistor r=0.06653 c=0
Rk9 (\8\:B \9\:B) resistor r=0.1615 c=0
Rk11 (B \10\:B) resistor r=0.1661 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8935 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8779 c=0
Rk6 (\5\:n1 \6\:n1) resistor r=0.4181 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.4325 c=0
Rk8 (\6\:n1 \10\:n1) resistor r=0.09515 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.445 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5898 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04841 c=0
Rl3 (\1\:A \2\:A) resistor r=54.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=112.23 c=0
Rl13 (\6\:B \7\:B) resistor r=70.3297 c=0
Rl12 (\5\:B \6\:B) resistor r=99.7901 c=0
Rl8 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl5 (\1\:B \2\:B) resistor r=30.3481 c=0
Rl1 (n0 \2\:n0) resistor r=126.156 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=37.6944 c=0
Rl9 (n1 \2\:n1) resistor r=2.0213 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=170.434 c=0
Rl11 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl6 (n2 \2\:n2) resistor r=195.27 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\9\:n1 \10\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\1\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (n1 \5\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.3e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn0 (\9\:n1 \3\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=5.51e-14 ps=1.4e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.095e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn4 (\4\:n0 n2 \9\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=6.7e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=2.32e-14 ps=4.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=4.65e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (net131 \4\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.087e-14 ps=6.1e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp0 (\7\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=4.515e-14 ps=1.58e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.95e-07 sd=160n sca=16.6712 \
        scb=0.0163973 scc=0.000573191 m=(1)
mp4 (\7\:n1 \2\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=7.4e-07 sd=160n sca=14.3602 scb=0.0131207 \
        scc=0.000544277 m=(1)
mp3 (\7\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.35e-07 sd=160n sca=14.2892 \
        scb=0.0130359 scc=0.000544163 m=(1)
mp2 (net130 \3\:n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.45e-07 sd=160n sca=15.406 \
        scb=0.0143862 scc=0.000549226 m=(1)
mp1 (\8\:n2 \7\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=19.4967 \
        scb=0.0213498 scc=0.00074757 m=(1)
ends XOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:47:56 2012 )
// Library name: gsclib045
// Cell name: XOR3X1
// View name: extracted

simulator lang=spectre

subckt XOR3X1 A B C VDD VSS Y
mp10 (\14\:n62 \1\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.27e-13 ad=6.435e-14 ps=1.91e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=4.48205e-07 sd=160n sca=36.5002 \
        scb=0.0347521 scc=0.00363944 m=(1)
C1 (B VSS) capacitor c=5.51301e-17
C2 (A VSS) capacitor c=7.65797e-17
C3 (VDD VSS) capacitor c=3.16669e-16
C4 (C VSS) capacitor c=4.27814e-17
C5 (n62 VSS) capacitor c=6.81644e-17
C6 (n61 VSS) capacitor c=1.00169e-16
C7 (n11 VSS) capacitor c=6.70586e-17
C8 (n44 VSS) capacitor c=3.10487e-16
C9 (n56 VSS) capacitor c=8.40226e-17
C10 (n50 VSS) capacitor c=3.12931e-17
C11 (n60 VSS) capacitor c=4.5644e-17
C12 (\3\:C VSS) capacitor c=3.03447e-17
C13 (\7\:C VSS) capacitor c=3.43187e-17
C14 (\3\:n60 VSS) capacitor c=6.59512e-17
C15 (\2\:n61 VSS) capacitor c=9.1241e-17
C16 (\11\:B VSS) capacitor c=8.09163e-17
C17 (\3\:n61 VSS) capacitor c=1.32986e-16
C18 (\1\:B VSS) capacitor c=6.28229e-17
C19 (\3\:n62 VSS) capacitor c=4.71464e-17
C20 (\5\:B VSS) capacitor c=4.38794e-17
C21 (\1\:A VSS) capacitor c=4.33883e-17
C22 (\3\:n50 VSS) capacitor c=2.77595e-17
C23 (\6\:C VSS) capacitor c=4.48388e-17
C24 (\4\:n60 VSS) capacitor c=3.64925e-17
C25 (\1\:C VSS) capacitor c=4.2306e-17
C26 (\13\:B VSS) capacitor c=4.91488e-17
C27 (\12\:B VSS) capacitor c=2.54759e-17
C28 (\6\:n61 VSS) capacitor c=3.77569e-17
C29 (\6\:B VSS) capacitor c=3.70043e-17
C30 (\4\:A VSS) capacitor c=3.12023e-17
C31 (\2\:n50 VSS) capacitor c=2.04642e-17
C32 (\5\:C VSS) capacitor c=5.52866e-17
C33 (\2\:C VSS) capacitor c=2.48532e-17
C34 (\2\:n11 VSS) capacitor c=7.21119e-17
C35 (\14\:B VSS) capacitor c=3.70962e-17
C36 (\7\:B VSS) capacitor c=2.64739e-17
C37 (\10\:B VSS) capacitor c=3.04611e-17
C38 (\2\:B VSS) capacitor c=1.10977e-16
C39 (\4\:n62 VSS) capacitor c=3.37617e-17
C40 (\2\:n62 VSS) capacitor c=5.15526e-17
C41 (\5\:n61 VSS) capacitor c=9.12333e-17
C42 (\4\:B VSS) capacitor c=2.44131e-17
C43 (\3\:A VSS) capacitor c=1.26091e-17
C44 (\1\:Y VSS) capacitor c=3.28802e-17
C45 (\8\:VDD VSS) capacitor c=7.09603e-17
C46 (\5\:n60 VSS) capacitor c=6.4871e-17
C47 (\3\:n56 VSS) capacitor c=1.43567e-16
C48 (\8\:n50 VSS) capacitor c=9.74007e-17
C49 (\5\:n44 VSS) capacitor c=2.54489e-16
C50 (\4\:n11 VSS) capacitor c=1.27026e-16
C51 (\8\:n56 VSS) capacitor c=6.80737e-17
C52 (\7\:n62 VSS) capacitor c=1.54563e-16
C53 (\6\:n11 VSS) capacitor c=9.57985e-17
C54 (\10\:VDD VSS) capacitor c=1.0655e-17
C55 (\10\:n61 VSS) capacitor c=5.94418e-17
C56 (\12\:VDD VSS) capacitor c=4.17943e-17
C57 (\14\:n62 VSS) capacitor c=3.68803e-17
C58 (\1\:VDD VSS) capacitor c=1.68843e-16
C59 (\3\:Y VSS) capacitor c=5.0013e-17
C60 (\8\:n60 VSS) capacitor c=4.83164e-17
C61 (\6\:n50 VSS) capacitor c=9.78081e-17
C62 (\7\:n44 VSS) capacitor c=7.43477e-17
C63 (\9\:n11 VSS) capacitor c=1.40171e-16
C64 (\6\:n56 VSS) capacitor c=1.14877e-16
C65 (\5\:n62 VSS) capacitor c=8.40088e-17
C66 (\3\:n44 VSS) capacitor c=1.15249e-16
C67 (\11\:n11 VSS) capacitor c=1.37137e-16
C68 (\7\:n61 VSS) capacitor c=3.78595e-17
C69 (\11\:n62 VSS) capacitor c=1.29351e-16
C70 (\2\:A VSS) capacitor c=1.72747e-17
C71 (\3\:B VSS) capacitor c=6.19397e-17
C72 (\8\:B VSS) capacitor c=2.47215e-17
C73 (\9\:B VSS) capacitor c=1.33109e-17
C74 (\4\:n61 VSS) capacitor c=1.08144e-16
C75 (\2\:n60 VSS) capacitor c=5.42375e-17
C76 (\4\:C VSS) capacitor c=3.82682e-17
C77 (\5\:A VSS) capacitor c=3.59365e-17
C78 (\15\:B VSS) capacitor c=5.527e-17
C79 (\9\:n61 VSS) capacitor c=3.6527e-17
C80 (\16\:B VSS) capacitor c=6.0517e-17
C81 (\17\:B VSS) capacitor c=5.76992e-17
C82 (\9\:n62 VSS) capacitor c=1.02178e-16
C83 (\10\:n62 VSS) capacitor c=1.33892e-16
C84 (\13\:n62 VSS) capacitor c=8.76922e-17
C85 (\18\:B VSS) capacitor c=3.66512e-17
C86 (\19\:B VSS) capacitor c=6.31334e-17
C87 (\3\:n11 VSS) capacitor c=5.2876e-17
C88 (\8\:n11 VSS) capacitor c=2.68584e-17
C89 (\8\:C VSS) capacitor c=4.88454e-17
C90 (\9\:C VSS) capacitor c=2.4711e-17
C91 (\5\:n56 VSS) capacitor c=1.79322e-16
C92 (\7\:n60 VSS) capacitor c=4.3136e-17
C93 (\4\:n50 VSS) capacitor c=4.20075e-17
C94 (\5\:n50 VSS) capacitor c=1.90432e-16
C95 (\3\:VDD VSS) capacitor c=2.88444e-19
C96 (\6\:VDD VSS) capacitor c=2.23529e-17
Rk42 (\2\:VSS \3\:VSS) resistor r=0.08259 c=0
Rk43 (\3\:VSS \4\:VSS) resistor r=0.4188 c=0
Rk44 (\4\:VSS \5\:VSS) resistor r=1.0035 c=0
Rk46 (\7\:VSS VSS) resistor r=0.1851 c=0
Rk45 (\5\:VSS \7\:VSS) resistor r=0.04668 c=0
Rk47 (VSS \9\:VSS) resistor r=0.04107 c=0
Rk48 (\3\:VSS \11\:VSS) resistor r=0.2283 c=0
Rk2 (\15\:B B) resistor r=0.1059 c=0
Rk6 (\16\:B \17\:B) resistor r=0.2407 c=0
Rk13 (\18\:B \19\:B) resistor r=0.1663 c=0
Rk1 (\5\:A A) resistor r=0.1078 c=0
Rk31 (\2\:Y Y) resistor r=0.2712 c=0
Rk32 (Y \4\:Y) resistor r=0.03227 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.08259 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.3184 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.9031 c=0
Rk37 (\6\:VDD VDD) resistor r=0.4436 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.2071 c=0
Rk38 (VDD \7\:VDD) resistor r=0.05109 c=0
Rk39 (\3\:VDD \9\:VDD) resistor r=0.2367 c=0
Rk40 (\6\:VDD \11\:VDD) resistor r=0.04333 c=0
Rk41 (VDD \13\:VDD) resistor r=0.08079 c=0
Rk20 (C \8\:C) resistor r=0.3097 c=0
Rk21 (C \9\:C) resistor r=0.02032 c=0
Rk7 (\6\:n62 \8\:n62) resistor r=0.5324 c=0
Rk8 (\8\:n62 \9\:n62) resistor r=0.6798 c=0
Rk9 (\9\:n62 \10\:n62) resistor r=0.5712 c=0
Rk10 (\10\:n62 \12\:n62) resistor r=0.6965 c=0
Rk11 (\12\:n62 \13\:n62) resistor r=0.6679 c=0
Rk12 (\10\:n62 \15\:n62) resistor r=0.142 c=0
Rk3 (\8\:n61 \9\:n61) resistor r=0.1097 c=0
Rk4 (\9\:n61 \11\:n61) resistor r=0.2038 c=0
Rk14 (\3\:n11 \5\:n11) resistor r=0.2383 c=0
Rk15 (\5\:n11 \7\:n11) resistor r=0.716 c=0
Rk16 (\8\:n11 \10\:n11) resistor r=0.119 c=0
Rk17 (\10\:n11 \12\:n11) resistor r=0.9659 c=0
Rk5 (\2\:n44 \4\:n44) resistor r=0.8235 c=0
Rk18 (\6\:n44 \8\:n44) resistor r=0.5607 c=0
Rk19 (\9\:n44 \10\:n44) resistor r=1.0211 c=0
Rk22 (\2\:n56 \4\:n56) resistor r=0.3916 c=0
Rk23 (\4\:n56 \5\:n56) resistor r=0.6721 c=0
Rk24 (\5\:n56 \7\:n56) resistor r=0.6991 c=0
Rk25 (\5\:n56 \9\:n56) resistor r=0.34 c=0
Rk28 (\4\:n50 \5\:n50) resistor r=0.1551 c=0
Rk29 (\5\:n50 \7\:n50) resistor r=0.8146 c=0
Rk30 (\5\:n50 \9\:n50) resistor r=0.7402 c=0
Rk26 (\6\:n60 \7\:n60) resistor r=0.1819 c=0
Rk27 (\7\:n60 \9\:n60) resistor r=0.09174 c=0
Rl21 (\13\:B \14\:B) resistor r=58.8482 c=0
Rl6 (\1\:B \2\:B) resistor r=135.771 c=0
Rl10 (\4\:B \6\:B) resistor r=24.2328 c=0
Rl9 (\3\:B \5\:B) resistor r=39.6181 c=0
Rl7 (\2\:B \3\:B) resistor r=370.63 c=0
Rl8 (\3\:B \4\:B) resistor r=35.0048 c=0
Rl14 (\8\:B \11\:B) resistor r=55.4507 c=0
Rl11 (\7\:B \8\:B) resistor r=19.1561 c=0
Rl15 (\9\:B \12\:B) resistor r=37.3411 c=0
Rl13 (\9\:B \10\:B) resistor r=10.9341 c=0
Rl12 (\8\:B \9\:B) resistor r=79.6267 c=0
Rl1 (\1\:A \2\:A) resistor r=88.1757 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=6.708 c=0
Rl30 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl23 (\1\:C \2\:C) resistor r=47.59 c=0
Rl27 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl29 (\4\:C \6\:C) resistor r=103.08 c=0
Rl28 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=124.029 c=0
Rl4 (n62 \2\:n62) resistor r=214.575 c=0
Rl16 (n61 \2\:n61) resistor r=215.318 c=0
Rl17 (\2\:n61 \3\:n61) resistor r=278.412 c=0
Rl18 (\3\:n61 \4\:n61) resistor r=222.62 c=0
Rl20 (\4\:n61 \6\:n61) resistor r=63.143 c=0
Rl19 (\4\:n61 \5\:n61) resistor r=239.768 c=0
Rl22 (n11 \2\:n11) resistor r=420.614 c=0
Rl31 (n50 \2\:n50) resistor r=35.7713 c=0
Rl32 (\2\:n50 \3\:n50) resistor r=64.6174 c=0
Rl24 (n60 \2\:n60) resistor r=106.101 c=0
Rl25 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl26 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rz17 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz18 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz19 (\10\:VSS \11\:VSS) resistor r=18.75 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VDD \7\:VDD) resistor r=37.5 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\7\:n61 \8\:n61) resistor r=75 c=0
Rz5 (\9\:n11 \10\:n11) resistor r=75 c=0
Rz6 (\11\:n11 \12\:n11) resistor r=75 c=0
Rz2 (\3\:n44 \4\:n44) resistor r=75 c=0
Rz7 (\7\:n44 \8\:n44) resistor r=75 c=0
Rz8 (n56 \2\:n56) resistor r=75 c=0
Rz9 (\6\:n56 \7\:n56) resistor r=75 c=0
Rz11 (\6\:n50 \7\:n50) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry20 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\8\:VDD \9\:VDD) resistor r=12.4 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\10\:n61 \11\:n61) resistor r=62 c=0
Ry5 (\4\:n11 \5\:n11) resistor r=62 c=0
Ry6 (\6\:n11 \7\:n11) resistor r=62 c=0
Ry2 (n44 \2\:n44) resistor r=62 c=0
Ry7 (\5\:n44 \6\:n44) resistor r=62 c=0
Ry8 (\5\:n44 \9\:n44) resistor r=62 c=0
Ry9 (n44 \10\:n44) resistor r=62 c=0
Ry10 (\3\:n56 \4\:n56) resistor r=62 c=0
Ry11 (\8\:n56 \9\:n56) resistor r=62 c=0
Ry13 (\8\:n50 \9\:n50) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\4\:B \15\:B) resistor r=45 c=0
Rx4 (\2\:B \16\:B) resistor r=45 c=0
Rx5 (\10\:B \17\:B) resistor r=45 c=0
Rx8 (\14\:B \18\:B) resistor r=45 c=0
Rx9 (\7\:B \19\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\5\:n61 \9\:n61) resistor r=45 c=0
Rx10 (n11 \3\:n11) resistor r=45 c=0
Rx11 (\2\:n11 \8\:n11) resistor r=45 c=0
Rx15 (\2\:n50 \4\:n50) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn10 (\11\:n62 \4\:A \8\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.295e-14 ad=3.485e-14 ps=1.47e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.08293e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn9 (\7\:n61 \6\:B \8\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.295e-14 ad=4.75e-14 ps=1.47e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=2.5e-07 sd=160n sca=12.1373 \
        scb=0.0121311 scc=0.000556832 m=(1)
mn0 (\11\:n11 n62 \6\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.57e-14 ad=5.08e-14 ps=1.11e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn6 (\6\:n56 \13\:B \9\:n11 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=3.82e-14 ps=8.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.7e-07 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn2 (\11\:n11 \6\:n61 \3\:n44 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=5.08e-14 ps=1.27e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(1)
mn1 (\5\:n62 \12\:B \3\:n44 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.715e-14 ps=1.27e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7122e-07 sb=6.6061e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn5 (\5\:n62 n61 \6\:n56 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.82e-14 ad=4.715e-14 ps=7.9e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14622e-06 sb=3.8561e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn4 (\7\:n44 \1\:C \6\:n50 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=3.23e-14 ps=8.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn3 (n56 \4\:n60 \6\:n50 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.31e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn8 (\8\:n60 \6\:C \10\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mn7 (\3\:Y \3\:n50 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=3.485e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9439e-07 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mp9 (\10\:n61 \5\:B \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.27e-13 ad=7.285e-14 ps=1.91e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.35e-07 sd=160n sca=31.7573 \
        scb=0.0238304 scc=0.00348201 m=(1)
mp0 (\6\:n11 \3\:n62 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=6.96452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp2 (n44 \1\:B \6\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=9.58e-14 ps=1.06e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7629e-07 sb=4.31452e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (n44 \3\:n61 \7\:n62 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=9.58e-14 ps=1.16e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46923e-07 sb=4.94359e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp5 (\8\:n56 \11\:B \7\:n62 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=7.125e-14 ps=1.16e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95385e-07 sb=3.05128e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp6 (\4\:n11 \2\:n61 \8\:n56 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=6.83e-14 ps=1.31e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.01452e-07 sb=1.7e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp4 (\8\:n50 \3\:n60 \5\:n44 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp3 (\8\:n50 \7\:C \3\:n56 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=4.96e-14 ps=9.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp8 (\5\:n60 \3\:C \8\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.365e-13 ad=5.27e-14 ps=1.88e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
mp7 (\1\:Y n50 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.365e-13 ad=6.63e-14 ps=1.88e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45513e-07 sb=1.7e-07 sd=160n sca=25.5198 \
        scb=0.0290048 scc=0.00173993 m=(1)
ends XOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:48:40 2012 )
// Library name: gsclib045
// Cell name: XOR3XL
// View name: extracted

simulator lang=spectre

subckt XOR3XL A B C VDD VSS Y
mp10 (\14\:n62 \1\:A \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=4.34e-14 ps=1.67e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=23.5711 \
        scb=0.0270642 scc=0.00135402 m=(1)
C1 (B VSS) capacitor c=6.96691e-17
C2 (A VSS) capacitor c=7.72876e-17
C3 (VDD VSS) capacitor c=3.31045e-16
C4 (C VSS) capacitor c=4.29288e-17
C5 (n62 VSS) capacitor c=6.63643e-17
C6 (n61 VSS) capacitor c=1.00282e-16
C7 (n11 VSS) capacitor c=7.43374e-17
C8 (n44 VSS) capacitor c=3.31305e-16
C9 (n56 VSS) capacitor c=8.41507e-17
C10 (n50 VSS) capacitor c=2.44734e-17
C11 (n60 VSS) capacitor c=4.5644e-17
C12 (\3\:C VSS) capacitor c=2.8798e-17
C13 (\7\:C VSS) capacitor c=3.43505e-17
C14 (\3\:n60 VSS) capacitor c=6.56229e-17
C15 (\2\:n61 VSS) capacitor c=1.00921e-16
C16 (\12\:B VSS) capacitor c=7.00349e-17
C17 (\3\:n61 VSS) capacitor c=9.45272e-17
C18 (\1\:B VSS) capacitor c=6.23652e-17
C19 (\3\:n62 VSS) capacitor c=4.53452e-17
C20 (\6\:B VSS) capacitor c=4.76654e-17
C21 (\1\:A VSS) capacitor c=4.01256e-17
C22 (\3\:n50 VSS) capacitor c=2.67209e-17
C23 (\6\:C VSS) capacitor c=4.42569e-17
C24 (\4\:n60 VSS) capacitor c=3.62959e-17
C25 (\1\:C VSS) capacitor c=4.04697e-17
C26 (\14\:B VSS) capacitor c=4.57687e-17
C27 (\13\:B VSS) capacitor c=2.43542e-17
C28 (\6\:n61 VSS) capacitor c=3.77635e-17
C29 (\7\:B VSS) capacitor c=3.61372e-17
C30 (\4\:A VSS) capacitor c=2.94013e-17
C31 (\2\:n50 VSS) capacitor c=2.10272e-17
C32 (\5\:C VSS) capacitor c=5.54336e-17
C33 (\2\:C VSS) capacitor c=2.45806e-17
C34 (\2\:n11 VSS) capacitor c=7.97619e-17
C35 (\15\:B VSS) capacitor c=3.89731e-17
C36 (\8\:B VSS) capacitor c=2.99644e-17
C37 (\11\:B VSS) capacitor c=2.51989e-17
C38 (\4\:n62 VSS) capacitor c=3.18083e-17
C39 (\2\:n62 VSS) capacitor c=4.76938e-17
C40 (\5\:n61 VSS) capacitor c=8.63179e-17
C41 (\4\:B VSS) capacitor c=2.67619e-17
C42 (\3\:A VSS) capacitor c=1.27416e-17
C43 (\1\:Y VSS) capacitor c=3.59234e-17
C44 (\9\:VDD VSS) capacitor c=6.8666e-17
C45 (\5\:n60 VSS) capacitor c=6.50923e-17
C46 (\3\:n56 VSS) capacitor c=1.52933e-16
C47 (\8\:n50 VSS) capacitor c=9.76566e-17
C48 (\5\:n44 VSS) capacitor c=2.55062e-16
C49 (\4\:n11 VSS) capacitor c=1.27941e-16
C50 (\8\:n56 VSS) capacitor c=6.84952e-17
C51 (\7\:n62 VSS) capacitor c=1.55663e-16
C52 (\6\:n11 VSS) capacitor c=1.04609e-16
C53 (\11\:VDD VSS) capacitor c=1.08408e-17
C54 (\10\:n61 VSS) capacitor c=8.30806e-17
C55 (\13\:VDD VSS) capacitor c=3.74631e-17
C56 (\14\:n62 VSS) capacitor c=2.71148e-17
C57 (\1\:VDD VSS) capacitor c=1.77481e-16
C58 (\3\:Y VSS) capacitor c=5.09975e-17
C59 (\8\:n60 VSS) capacitor c=4.83745e-17
C60 (\6\:n50 VSS) capacitor c=9.74603e-17
C61 (\7\:n44 VSS) capacitor c=6.43663e-17
C62 (\9\:n11 VSS) capacitor c=1.38137e-16
C63 (\6\:n56 VSS) capacitor c=1.11529e-16
C64 (\5\:n62 VSS) capacitor c=9.44749e-17
C65 (\3\:n44 VSS) capacitor c=1.13289e-16
C66 (\11\:n11 VSS) capacitor c=1.3926e-16
C67 (\7\:n61 VSS) capacitor c=3.74086e-17
C68 (\11\:n62 VSS) capacitor c=1.12575e-16
C69 (\2\:A VSS) capacitor c=2.1811e-17
C70 (\2\:B VSS) capacitor c=1.07365e-16
C71 (\3\:B VSS) capacitor c=6.10164e-17
C72 (\9\:B VSS) capacitor c=2.11321e-17
C73 (\10\:B VSS) capacitor c=2.38151e-17
C74 (\4\:n61 VSS) capacitor c=1.25231e-16
C75 (\2\:n60 VSS) capacitor c=5.41728e-17
C76 (\4\:C VSS) capacitor c=3.82676e-17
C77 (\5\:A VSS) capacitor c=3.36273e-17
C78 (\16\:B VSS) capacitor c=5.96542e-17
C79 (\9\:n61 VSS) capacitor c=5.8512e-17
C80 (\17\:B VSS) capacitor c=6.62882e-17
C81 (\18\:B VSS) capacitor c=6.62113e-17
C82 (\9\:n62 VSS) capacitor c=1.27475e-16
C83 (\10\:n62 VSS) capacitor c=1.63453e-16
C84 (\13\:n62 VSS) capacitor c=6.7335e-17
C85 (\19\:B VSS) capacitor c=3.76837e-17
C86 (\20\:B VSS) capacitor c=6.34825e-17
C87 (\3\:n11 VSS) capacitor c=5.22341e-17
C88 (\8\:n11 VSS) capacitor c=2.14868e-17
C89 (\8\:C VSS) capacitor c=4.90261e-17
C90 (\9\:C VSS) capacitor c=2.4832e-17
C91 (\5\:n56 VSS) capacitor c=1.71738e-16
C92 (\7\:n60 VSS) capacitor c=4.3197e-17
C93 (\4\:n50 VSS) capacitor c=3.91588e-17
C94 (\5\:n50 VSS) capacitor c=1.91536e-16
C95 (\3\:VDD VSS) capacitor c=2.88806e-19
C96 (\6\:VDD VSS) capacitor c=2.40027e-17
Rk2 (\16\:B B) resistor r=0.2075 c=0
Rk6 (\17\:B \18\:B) resistor r=0.2584 c=0
Rk13 (\19\:B \20\:B) resistor r=0.1661 c=0
Rk1 (\5\:A A) resistor r=0.08725 c=0
Rk31 (\2\:Y Y) resistor r=0.2806 c=0
Rk32 (Y \4\:Y) resistor r=0.03227 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.08256 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.3183 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.9028 c=0
Rk37 (\6\:VDD VDD) resistor r=0.2895 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.2597 c=0
Rk38 (VDD \7\:VDD) resistor r=0.06024 c=0
Rk39 (\7\:VDD \8\:VDD) resistor r=0.09009 c=0
Rk40 (\3\:VDD \10\:VDD) resistor r=0.236 c=0
Rk41 (\6\:VDD \12\:VDD) resistor r=0.04331 c=0
Rk42 (\7\:VDD \14\:VDD) resistor r=0.119 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.08256 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.1678 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.7524 c=0
Rk47 (\6\:VSS VSS) resistor r=0.2519 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.5982 c=0
Rk49 (VSS \9\:VSS) resistor r=0.1218 c=0
Rk50 (\3\:VSS \11\:VSS) resistor r=0.2276 c=0
Rk51 (\6\:VSS \13\:VSS) resistor r=0.04331 c=0
Rk20 (C \8\:C) resistor r=0.3089 c=0
Rk21 (C \9\:C) resistor r=0.02032 c=0
Rk7 (\6\:n62 \8\:n62) resistor r=0.5309 c=0
Rk8 (\8\:n62 \9\:n62) resistor r=0.7002 c=0
Rk9 (\9\:n62 \10\:n62) resistor r=0.7198 c=0
Rk10 (\10\:n62 \12\:n62) resistor r=0.6908 c=0
Rk11 (\12\:n62 \13\:n62) resistor r=0.5692 c=0
Rk12 (\10\:n62 \15\:n62) resistor r=0.113 c=0
Rk3 (\8\:n61 \9\:n61) resistor r=0.1048 c=0
Rk4 (\9\:n61 \11\:n61) resistor r=0.2997 c=0
Rk14 (\3\:n11 \5\:n11) resistor r=0.2376 c=0
Rk15 (\5\:n11 \7\:n11) resistor r=0.7362 c=0
Rk16 (\8\:n11 \10\:n11) resistor r=0.1186 c=0
Rk17 (\10\:n11 \12\:n11) resistor r=0.9632 c=0
Rk5 (\2\:n44 \4\:n44) resistor r=0.8462 c=0
Rk18 (\6\:n44 \8\:n44) resistor r=0.5314 c=0
Rk19 (\9\:n44 \10\:n44) resistor r=1.0989 c=0
Rk22 (\2\:n56 \4\:n56) resistor r=0.3905 c=0
Rk23 (\4\:n56 \5\:n56) resistor r=0.7258 c=0
Rk24 (\5\:n56 \7\:n56) resistor r=0.6678 c=0
Rk25 (\5\:n56 \9\:n56) resistor r=0.339 c=0
Rk28 (\4\:n50 \5\:n50) resistor r=0.1546 c=0
Rk29 (\5\:n50 \7\:n50) resistor r=0.8123 c=0
Rk30 (\5\:n50 \9\:n50) resistor r=0.7381 c=0
Rk26 (\6\:n60 \7\:n60) resistor r=0.1817 c=0
Rk27 (\7\:n60 \9\:n60) resistor r=0.09164 c=0
Rl22 (\14\:B \15\:B) resistor r=53.079 c=0
Rl11 (\4\:B \7\:B) resistor r=24.2328 c=0
Rl6 (\1\:B \2\:B) resistor r=131.458 c=0
Rl9 (\2\:B \5\:B) resistor r=3.9152 c=0
Rl10 (\3\:B \6\:B) resistor r=72.3105 c=0
Rl8 (\3\:B \4\:B) resistor r=35.0048 c=0
Rl7 (\2\:B \3\:B) resistor r=327.99 c=0
Rl15 (\9\:B \12\:B) resistor r=97.7584 c=0
Rl12 (\8\:B \9\:B) resistor r=19.1561 c=0
Rl16 (\10\:B \13\:B) resistor r=34.3295 c=0
Rl14 (\10\:B \11\:B) resistor r=8.3038 c=0
Rl13 (\9\:B \10\:B) resistor r=95.8459 c=0
Rl1 (\1\:A \2\:A) resistor r=117.022 c=0
Rl3 (\2\:A \4\:A) resistor r=38.1757 c=0
Rl2 (\2\:A \3\:A) resistor r=8.3038 c=0
Rl31 (\5\:C \7\:C) resistor r=26.1559 c=0
Rl24 (\1\:C \2\:C) resistor r=47.59 c=0
Rl28 (\3\:C \4\:C) resistor r=28.0797 c=0
Rl30 (\4\:C \6\:C) resistor r=103.08 c=0
Rl29 (\4\:C \5\:C) resistor r=172.554 c=0
Rl5 (\3\:n62 \4\:n62) resistor r=132.902 c=0
Rl4 (n62 \2\:n62) resistor r=205.584 c=0
Rl17 (n61 \2\:n61) resistor r=255.703 c=0
Rl18 (\2\:n61 \3\:n61) resistor r=284.181 c=0
Rl19 (\3\:n61 \4\:n61) resistor r=241.851 c=0
Rl21 (\4\:n61 \6\:n61) resistor r=57.3738 c=0
Rl20 (\4\:n61 \5\:n61) resistor r=241.764 c=0
Rl23 (n11 \2\:n11) resistor r=176.032 c=0
Rl32 (n50 \2\:n50) resistor r=41.5405 c=0
Rl33 (\2\:n50 \3\:n50) resistor r=64.6174 c=0
Rl25 (n60 \2\:n60) resistor r=106.101 c=0
Rl26 (\2\:n60 \3\:n60) resistor r=159.593 c=0
Rl27 (\2\:n60 \4\:n60) resistor r=70.8353 c=0
Rz12 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz16 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz17 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz18 (\10\:VSS \11\:VSS) resistor r=18.75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz3 (\5\:n62 \6\:n62) resistor r=75 c=0
Rz4 (\11\:n62 \12\:n62) resistor r=75 c=0
Rz1 (\7\:n61 \8\:n61) resistor r=75 c=0
Rz5 (\9\:n11 \10\:n11) resistor r=75 c=0
Rz6 (\11\:n11 \12\:n11) resistor r=75 c=0
Rz2 (\3\:n44 \4\:n44) resistor r=75 c=0
Rz7 (\7\:n44 \8\:n44) resistor r=75 c=0
Rz8 (n56 \2\:n56) resistor r=75 c=0
Rz9 (\6\:n56 \7\:n56) resistor r=75 c=0
Rz11 (\6\:n50 \7\:n50) resistor r=75 c=0
Rz10 (\8\:n60 \9\:n60) resistor r=75 c=0
Ry14 (\1\:Y \2\:Y) resistor r=62 c=0
Ry15 (\9\:VDD \10\:VDD) resistor r=12.4 c=0
Ry16 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry21 (\1\:VSS VSS) resistor r=12.4 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry20 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry3 (\7\:n62 \8\:n62) resistor r=62 c=0
Ry4 (\14\:n62 \15\:n62) resistor r=62 c=0
Ry1 (\10\:n61 \11\:n61) resistor r=62 c=0
Ry5 (\4\:n11 \5\:n11) resistor r=62 c=0
Ry6 (\6\:n11 \7\:n11) resistor r=62 c=0
Ry2 (n44 \2\:n44) resistor r=62 c=0
Ry7 (\5\:n44 \6\:n44) resistor r=62 c=0
Ry8 (\5\:n44 \9\:n44) resistor r=62 c=0
Ry9 (n44 \10\:n44) resistor r=62 c=0
Ry10 (\3\:n56 \4\:n56) resistor r=62 c=0
Ry11 (\8\:n56 \9\:n56) resistor r=62 c=0
Ry13 (\8\:n50 \9\:n50) resistor r=62 c=0
Ry12 (\5\:n60 \6\:n60) resistor r=62 c=0
Rx2 (\4\:B \16\:B) resistor r=45 c=0
Rx4 (\5\:B \17\:B) resistor r=45 c=0
Rx5 (\11\:B \18\:B) resistor r=45 c=0
Rx8 (\15\:B \19\:B) resistor r=45 c=0
Rx9 (\8\:B \20\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx12 (\2\:C \8\:C) resistor r=45 c=0
Rx13 (\5\:C \9\:C) resistor r=45 c=0
Rx6 (\4\:n62 \9\:n62) resistor r=45 c=0
Rx7 (\2\:n62 \13\:n62) resistor r=45 c=0
Rx3 (\5\:n61 \9\:n61) resistor r=45 c=0
Rx10 (n11 \3\:n11) resistor r=45 c=0
Rx11 (\2\:n11 \8\:n11) resistor r=45 c=0
Rx15 (\2\:n50 \4\:n50) resistor r=45 c=0
Rx14 (n60 \7\:n60) resistor r=45 c=0
mn10 (\11\:n62 \4\:A \8\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.23e-14 ps=1.5e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.45e-07 sd=160n sca=13.8407 \
        scb=0.0143094 scc=0.000839093 m=(1)
mn9 (\7\:n61 \7\:B \8\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.23e-14 ps=1.5e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.7e-07 sd=160n sca=13.8407 \
        scb=0.0143094 scc=0.000839093 m=(1)
mn0 (\11\:n11 n62 \12\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=5.75e-14 ad=5.26e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.42e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn2 (\11\:n11 \6\:n61 \3\:n44 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=5.26e-14 ps=1.18e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.155e-06 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn1 (\5\:n62 \13\:B \3\:n44 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=4.37e-14 ps=1.18e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=7.1e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn5 (\5\:n62 n61 \6\:n56 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.37e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=4.35e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn6 (\6\:n56 \14\:B \9\:n11 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.31e-14 ad=4.18e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.7e-07 sd=160n sca=8.3036 \
        scb=0.00616975 scc=0.000110509 m=(1)
mn4 (\7\:n44 \1\:C \6\:n50 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=3.23e-14 ps=8.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn3 (n56 \4\:n60 \6\:n50 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=4.18e-14 ad=4.31e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.7e-07 sd=160n sca=11.8451 \
        scb=0.0117279 scc=0.00051251 m=(1)
mn8 (\8\:n60 \6\:C \10\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.0475e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.2e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mn7 (\3\:Y \3\:n50 \10\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.0475e-13 ad=3.23e-14 ps=1.77e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=20.6114 \
        scb=0.0205722 scc=0.00215666 m=(1)
mp9 (\10\:n61 \6\:B \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=7.595e-14 ps=1.67e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2.45e-07 sd=160n sca=15.89 \
        scb=0.0145486 scc=0.000688173 m=(1)
mp0 (\6\:n11 \3\:n62 \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=6.82e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1129e-07 sb=7.61774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp2 (n44 \1\:B \6\:n11 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=9.18e-14 ps=1.06e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7629e-07 sb=4.96774e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp1 (n44 \3\:n61 \7\:n62 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=9.18e-14 ps=1e-06 pd=1.64e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.92581e-07 sb=5.65242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp5 (\8\:n56 \12\:B \7\:n62 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.88e-14 ps=1e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.27581e-07 sb=3.30242e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp6 (\4\:n11 \2\:n61 \8\:n56 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=5.93e-14 ps=1.24e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.89597e-07 sb=1.7e-07 sd=160n sca=10.9702 \
        scb=0.00883933 scc=0.000174052 m=(1)
mp4 (\8\:n50 \3\:n60 \5\:n44 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp3 (\8\:n50 \7\:C \3\:n56 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=4.96e-14 ps=9.6e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.7e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp8 (\5\:n60 \3\:C \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=5.27e-14 ps=1.85e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.30242e-07 sd=160n sca=16.2999 \
        scb=0.0148905 scc=0.000867022 m=(1)
mp7 (\1\:Y n50 \9\:VDD VDD) g45p1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.265e-13 ad=3.485e-14 ps=1.85e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.7e-07 sd=160n sca=28.0221 scb=0.032906 \
        scc=0.00213116 m=(1)
ends XOR3XL
// End of subcircuit definition.

