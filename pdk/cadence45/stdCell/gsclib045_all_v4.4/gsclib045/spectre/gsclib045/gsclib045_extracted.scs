Rl40 (\2\:CK \4\:CK) resistor r=80.4877 c=0
Rl39 (\2\:CK \3\:CK) resistor r=3.3229 c=0
Rl51 (\6\:SE \7\:SE) resistor r=261.796 c=0
Rl50 (\5\:SE \6\:SE) resistor r=39.1533 c=0
Rl47 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl44 (\1\:SE \2\:SE) resistor r=33.7903 c=0
Rl27 (\4\:SN \5\:SN) resistor r=174.566 c=0
Rl28 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl11 (\1\:SN \2\:SN) resistor r=60.7713 c=0
Rl12 (\2\:SN \3\:SN) resistor r=89.6174 c=0
Rl49 (\2\:SI \3\:SI) resistor r=50.7887 c=0
Rl48 (\1\:SI \2\:SI) resistor r=101.156 c=0
Rl14 (\10\:qbint \8\:qbint) resistor r=178.846 c=0
Rl13 (\9\:qbint \8\:qbint) resistor r=301.835 c=0
Rl7 (n35 \2\:n35) resistor r=59.6154 c=0
Rl8 (\2\:n35 \3\:n35) resistor r=29.9451 c=0
Rl20 (RNb \2\:RNb) resistor r=155.335 c=0
Rl23 (\4\:RNb \5\:RNb) resistor r=199.566 c=0
Rl21 (\2\:RNb \3\:RNb) resistor r=927.462 c=0
Rl22 (\3\:RNb \4\:RNb) resistor r=24.2328 c=0
Rl33 (\5\:CKb \6\:CKb) resistor r=120.387 c=0
Rl36 (\6\:CKb \9\:CKb) resistor r=32.9432 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl15 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=144.953 c=0
Rl37 (\7\:CKb \10\:CKb) resistor r=64.6181 c=0
Rl34 (\6\:CKb \7\:CKb) resistor r=258.107 c=0
Rl29 (mout \2\:mout) resistor r=28.079 c=0
Rl30 (\2\:mout \3\:mout) resistor r=131.925 c=0
Rl32 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl31 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl17 (CKbb \2\:CKbb) resistor r=34.2969 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=136.082 c=0
Rl19 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl24 (n20 \2\:n20) resistor r=56.6776 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=174.456 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=2.8623 c=0
Rl45 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl46 (\2\:SEb \3\:SEb) resistor r=123.799 c=0
Rz19 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz23 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz26 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz27 (\7\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz28 (\9\:VDD \3\:VDD) resistor r=75 c=0
Rz29 (\11\:VDD \3\:VDD) resistor r=6.25 c=0
Rz30 (\13\:VDD \3\:VDD) resistor r=18.75 c=0
Rz31 (\15\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (net486 \2\:net486) resistor r=75 c=0
Rz5 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz6 (net490 \2\:net490) resistor r=75 c=0
Rz7 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz15 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz11 (\7\:mout \8\:mout) resistor r=75 c=0
Rz12 (\11\:mout \12\:mout) resistor r=75 c=0
Rz14 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz9 (net469 \2\:net469) resistor r=75 c=0
Rz10 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz13 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz16 (\4\:Db \5\:Db) resistor r=75 c=0
Rz17 (\6\:Db \7\:Db) resistor r=75 c=0
Rz18 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry22 (VSS \1\:VSS) resistor r=62 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry16 (\4\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\9\:VSS \1\:VSS) resistor r=15.5 c=0
Ry19 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\12\:VSS \1\:VSS) resistor r=12.4 c=0
Ry21 (\13\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\2\:Q \1\:Q) resistor r=31 c=0
Ry23 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry24 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry25 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry26 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry27 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry28 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry29 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=31 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=31 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry7 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=20.6667 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net394 \2\:net394) resistor r=62 c=0
Ry5 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx17 (\3\:D \6\:D) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx16 (\3\:CK \5\:CK) resistor r=45 c=0
Rx19 (\2\:SE \8\:SE) resistor r=45 c=0
Rx20 (\4\:SE \9\:SE) resistor r=45 c=0
Rx21 (\6\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx2 (\15\:qbint qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\3\:RNb \6\:RNb) resistor r=45 c=0
Rx13 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx14 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55_1__rcx (\3\:Q qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.043e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.88846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\16\:qbint \3\:n35 \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.445e-14 ad=4.612e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.25e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn22 (\9\:RNb \3\:RN \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.15e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn50 (\3\:net486 \3\:SN \25\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.205e-14 ad=3.28e-14 ps=1.15e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33537e-07 sb=6.05e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn52 (net490 \10\:qbint \3\:net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38537e-07 sb=4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.997e-14 ad=3.28e-14 ps=8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.43537e-07 sb=1.95e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn53 (\8\:n35 CKb \3\:net490 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.92e-14 ps=8.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.7e-07 sd=160n sca=10.541 \
        scb=0.00979836 scc=0.000342932 m=(1)
mn40 (\8\:n35 CKbb \7\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=4.92e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.541 \
        scb=0.00979836 scc=0.000342932 m=(1)
mn31 (\11\:mout RNb \3\:net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.588e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.265e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn32 (\11\:mout n20 net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.588e-14 ps=7.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.045e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (net469 \4\:SN \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.612e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=8.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=2.05e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=3.28e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\4\:Db \10\:CKb \9\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.51e-14 ps=7.3e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2.2e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\15\:CKbb \9\:CKb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.845e-14 ad=2.03e-14 ps=1.36e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn20 (\11\:CKb \4\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=2.03e-14 ps=1.56e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37914e-06 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn11 (net522 \4\:D \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.87e-14 ad=4.29e-14 ps=1.56e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.28942e-07 sb=9.17212e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn12 (\6\:Db \3\:SEb net522 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=6.075e-14 ps=8.5e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.38942e-07 sb=7.07212e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn14 (\6\:Db \3\:SE net534 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.075e-14 ps=6.4e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.86442e-07 sb=4.42019e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn13 (net534 \1\:SI \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=1.56e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91442e-07 sb=3.37019e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn10 (\4\:SEb \5\:SE \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41534e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp45 (\12\:qbint n35 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.27e-14 ps=1.1e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.7e-07 sd=160n sca=36.1524 \
        scb=0.0235548 scc=0.00420472 m=(1)
mp22 (\7\:RNb \1\:RN \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1695e-13 ad=3.762e-14 ps=1.64e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=4.2093e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (\3\:net394 \1\:SN \26\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.1695e-13 ad=4.96e-14 ps=1.64e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85323e-07 sb=6.05e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp52 (\3\:net394 \8\:qbint net437 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.90323e-07 sb=4e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp51 (net437 \4\:RNb \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.145e-14 ad=1.86e-14 ps=1.21e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95323e-07 sb=2.95e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp53 (\4\:n35 \3\:CKbb net394 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=7.595e-14 ps=1.13e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=31.4735 \
        scb=0.0225197 scc=0.00370874 m=(1)
mp40 (\4\:n35 \3\:CKb \4\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=7.595e-14 ps=9.6e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.7e-07 sd=160n sca=31.4735 \
        scb=0.0225197 scc=0.00370874 m=(1)
mp31 (net417 \2\:RNb \22\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.97e-13 ad=1.86e-14 ps=2.13e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.17952e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout \5\:SN \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.975e-14 ps=1.49e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.04516e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\9\:mout \3\:n20 net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.975e-14 ps=7.4e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.07452e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 mout \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.045e-14 ps=1.49e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.66613e-07 sb=6.71935e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\5\:n20 \8\:CKb net425 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=8.038e-14 ps=1.01e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20661e-06 sb=4.31935e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp25 (\5\:n20 \7\:CKbb \8\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=8.038e-14 ps=1.02e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38089e-06 sb=2e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp21 (\13\:CKbb \5\:CKb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.35e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp20 (\17\:CKb \1\:CK \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.20581e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp11 (net445 \1\:D \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=2.34e-14 ps=1.28e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.84679e-07 sb=7.15064e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.89679e-07 sb=6.10064e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp13 (net453 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.64679e-07 sb=2.35064e-07 sd=160n sca=14.3864 \
        scb=0.0127998 scc=0.000754431 m=(1)
mp14 (Db SEb net453 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.875e-14 \
        ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.94679e-07 sb=4.05064e-07 sd=160n sca=14.1011 scb=0.0127228 \
        scc=0.000754417 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47326e-07 sb=1.4e-07 sd=160n sca=11.412 \
        scb=0.00825607 scc=8.8825e-05 m=(1)
ends SDFFSRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:39:41 2012 )
// Library name: gsclib045
// Cell name: SDFFSRHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX4 CK D Q RN SE SI SN VDD VSS
mp55_1__rcx (Q qbint \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28949e-06 sd=160n sca=35.1619 \
        scb=0.02637 scc=0.00345369 m=(4)
C1 (D VSS) capacitor c=5.23181e-17
C2 (RN VSS) capacitor c=5.96939e-17
C3 (CK VSS) capacitor c=4.26635e-17
C4 (Q VSS) capacitor c=2.48597e-16
C5 (SE VSS) capacitor c=1.03813e-16
C6 (VDD VSS) capacitor c=4.86449e-16
C7 (SN VSS) capacitor c=2.34895e-16
C8 (SI VSS) capacitor c=9.87728e-17
C9 (qbint VSS) capacitor c=2.23366e-16
C10 (n35 VSS) capacitor c=1.52261e-17
C11 (RNb VSS) capacitor c=2.41357e-17
C12 (net490 VSS) capacitor c=8.64301e-17
C13 (net486 VSS) capacitor c=1.45982e-16
C14 (CKb VSS) capacitor c=3.71679e-17
C15 (mout VSS) capacitor c=9.64038e-17
C16 (CKbb VSS) capacitor c=2.9794e-17
C17 (net469 VSS) capacitor c=5.48742e-17
C18 (n20 VSS) capacitor c=3.6203e-17
C19 (Db VSS) capacitor c=4.41275e-17
C20 (net522 VSS) capacitor c=1.37142e-18
C21 (SEb VSS) capacitor c=6.32517e-17
C22 (net534 VSS) capacitor c=1.71309e-18
C23 (net437 VSS) capacitor c=1.29793e-18
C24 (net394 VSS) capacitor c=9.6092e-17
C25 (net417 VSS) capacitor c=6.36445e-18
C26 (net425 VSS) capacitor c=1.44616e-18
C27 (net445 VSS) capacitor c=1.43883e-18
C28 (net453 VSS) capacitor c=1.71168e-18
C29 (\4\:SE VSS) capacitor c=2.86119e-17
C30 (\1\:SI VSS) capacitor c=6.88194e-17
C31 (\3\:SEb VSS) capacitor c=7.05659e-17
C32 (\3\:SE VSS) capacitor c=9.14249e-17
C33 (\1\:D VSS) capacitor c=1.02431e-16
C34 (\1\:CK VSS) capacitor c=6.95286e-17
C35 (\10\:CKb VSS) capacitor c=2.94564e-17
C36 (\8\:CKbb VSS) capacitor c=4.1265e-17
C37 (\5\:CKb VSS) capacitor c=6.16946e-17
C38 (\4\:mout VSS) capacitor c=6.95889e-17
C39 (\6\:SN VSS) capacitor c=8.06701e-17
C40 (\3\:n20 VSS) capacitor c=6.2085e-17
C41 (\6\:RNb VSS) capacitor c=1.15857e-16
C42 (\3\:CKb VSS) capacitor c=4.36049e-17
C43 (\3\:CKbb VSS) capacitor c=5.16893e-17
C44 (\3\:SN VSS) capacitor c=4.80234e-17
C45 (\16\:qbint VSS) capacitor c=9.90159e-17
C46 (\2\:RNb VSS) capacitor c=5.04887e-17
C47 (\3\:RN VSS) capacitor c=3.13387e-17
C48 (\6\:SE VSS) capacitor c=2.12425e-17
C49 (\3\:SI VSS) capacitor c=7.25013e-17
C50 (\1\:SE VSS) capacitor c=5.77599e-17
C51 (\4\:D VSS) capacitor c=8.78188e-17
C52 (\3\:CK VSS) capacitor c=3.26513e-17
C53 (\7\:CKb VSS) capacitor c=2.83501e-17
C54 (\9\:CKb VSS) capacitor c=5.74136e-17
C55 (\9\:CKbb VSS) capacitor c=6.64117e-17
C56 (\5\:SN VSS) capacitor c=7.45153e-17
C57 (\4\:n20 VSS) capacitor c=3.33468e-17
C58 (\8\:RNb VSS) capacitor c=4.2936e-17
C59 (\1\:SN VSS) capacitor c=4.6623e-17
C60 (\13\:qbint VSS) capacitor c=2.92166e-17
C61 (\5\:RNb VSS) capacitor c=4.10532e-17
C62 (\1\:RN VSS) capacitor c=3.62848e-17
C63 (\5\:SE VSS) capacitor c=1.75214e-17
C64 (\2\:SI VSS) capacitor c=5.20882e-17
C65 (\4\:SEb VSS) capacitor c=4.31397e-17
C66 (\2\:SE VSS) capacitor c=6.81021e-17
C67 (\2\:SEb VSS) capacitor c=4.54954e-17
C68 (\3\:D VSS) capacitor c=4.15567e-17
C69 (\2\:CK VSS) capacitor c=5.80205e-17
C70 (\8\:CKb VSS) capacitor c=5.30349e-17
C71 (\5\:CKbb VSS) capacitor c=4.60187e-17
C72 (\6\:CKb VSS) capacitor c=4.32095e-17
C73 (\7\:CKbb VSS) capacitor c=5.53883e-17
C74 (\3\:mout VSS) capacitor c=2.02168e-17
C75 (\7\:SN VSS) capacitor c=2.51954e-17
C76 (\4\:CKbb VSS) capacitor c=3.09272e-17
C77 (\4\:CKb VSS) capacitor c=3.91064e-17
C78 (\2\:CKb VSS) capacitor c=2.61398e-17
C79 (\7\:RNb VSS) capacitor c=7.86835e-17
C80 (\4\:SN VSS) capacitor c=2.13624e-17
C81 (\15\:qbint VSS) capacitor c=3.20604e-17
C82 (\4\:RNb VSS) capacitor c=3.06531e-17
C83 (\2\:RN VSS) capacitor c=3.78737e-17
C84 (\1\:VDD VSS) capacitor c=2.60649e-17
C85 (\9\:SEb VSS) capacitor c=1.00835e-16
C86 (\22\:VDD VSS) capacitor c=2.99377e-17
C87 (\8\:Db VSS) capacitor c=1.30735e-16
C88 (\24\:VDD VSS) capacitor c=3.7227e-17
C89 (\11\:CKb VSS) capacitor c=7.78049e-17
C90 (\26\:VDD VSS) capacitor c=3.16002e-17
C91 (\13\:CKbb VSS) capacitor c=4.2271e-17
C92 (\6\:Db VSS) capacitor c=1.05092e-16
C93 (\7\:n20 VSS) capacitor c=9.80087e-17
C94 (\28\:VDD VSS) capacitor c=5.7545e-17
C95 (\6\:mout VSS) capacitor c=1.93224e-16
C96 (\30\:VDD VSS) capacitor c=5.13169e-17
C97 (\11\:mout VSS) capacitor c=3.55812e-17
C98 (\9\:n35 VSS) capacitor c=7.63817e-17
C99 (\32\:VDD VSS) capacitor c=3.07559e-17
C100 (\3\:net394 VSS) capacitor c=8.06929e-17
C101 (\34\:VDD VSS) capacitor c=1.95622e-17
C102 (\9\:RNb VSS) capacitor c=4.38356e-17
C103 (\23\:qbint VSS) capacitor c=8.40883e-17
C104 (\3\:VDD VSS) capacitor c=1.82521e-16
C105 (\5\:SEb VSS) capacitor c=1.13468e-16
C106 (\17\:CKb VSS) capacitor c=6.28418e-17
C107 (\15\:CKbb VSS) capacitor c=6.01124e-17
C108 (\4\:Db VSS) capacitor c=1.92381e-16
C109 (\9\:n20 VSS) capacitor c=3.61718e-17
C110 (\13\:mout VSS) capacitor c=1.43378e-16
C111 (\3\:net469 VSS) capacitor c=6.83314e-17
C112 (\9\:mout VSS) capacitor c=1.21681e-16
C113 (\13\:n35 VSS) capacitor c=6.65418e-17
C114 (\3\:net490 VSS) capacitor c=8.09993e-17
C115 (\3\:net486 VSS) capacitor c=1.24278e-16
C116 (\12\:RNb VSS) capacitor c=5.63386e-17
C117 (\21\:qbint VSS) capacitor c=2.20427e-17
C118 (\2\:n35 VSS) capacitor c=1.6188e-16
C119 (\3\:RNb VSS) capacitor c=4.88095e-17
C120 (\14\:qbint VSS) capacitor c=2.92978e-17
C121 (\2\:SN VSS) capacitor c=3.33937e-17
C122 (\2\:CKbb VSS) capacitor c=5.89972e-17
C123 (\2\:n20 VSS) capacitor c=2.5307e-17
C124 (\2\:mout VSS) capacitor c=5.24655e-17
C125 (\6\:CKbb VSS) capacitor c=2.9646e-17
C126 (\4\:RN VSS) capacitor c=5.72309e-17
C127 (\11\:RNb VSS) capacitor c=5.49423e-17
C128 (\2\:D VSS) capacitor c=3.44012e-17
C129 (\17\:qbint VSS) capacitor c=1.62167e-16
C130 (\18\:qbint VSS) capacitor c=1.31191e-16
C131 (\19\:qbint VSS) capacitor c=2.8806e-17
C132 (\20\:qbint VSS) capacitor c=3.26355e-17
C133 (\14\:RNb VSS) capacitor c=1.12602e-16
C134 (\15\:RNb VSS) capacitor c=7.93601e-17
C135 (\11\:n35 VSS) capacitor c=3.10539e-16
C136 (\12\:n35 VSS) capacitor c=2.32473e-16
C137 (\8\:SN VSS) capacitor c=2.26168e-16
C138 (\9\:SN VSS) capacitor c=3.35975e-17
C139 (\5\:mout VSS) capacitor c=5.95624e-17
C140 (\8\:mout VSS) capacitor c=1.48499e-16
C141 (\10\:CKbb VSS) capacitor c=2.19286e-16
C142 (\11\:CKbb VSS) capacitor c=1.93537e-16
C143 (\5\:n20 VSS) capacitor c=6.71324e-17
C144 (\6\:n20 VSS) capacitor c=9.41009e-17
C145 (\12\:CKbb VSS) capacitor c=6.06753e-17
C146 (\4\:CK VSS) capacitor c=6.73989e-17
C147 (\5\:D VSS) capacitor c=7.70185e-17
C148 (\13\:CKb VSS) capacitor c=1.42419e-16
C149 (\14\:CKb VSS) capacitor c=9.69986e-17
C150 (\15\:CKb VSS) capacitor c=3.06659e-16
C151 (\16\:CKb VSS) capacitor c=4.43157e-17
C152 (\19\:CKb VSS) capacitor c=3.63997e-16
C153 (\20\:CKb VSS) capacitor c=1.17429e-16
C154 (\3\:Db VSS) capacitor c=1.93807e-16
C155 (\4\:SI VSS) capacitor c=3.7257e-17
C156 (\7\:SEb VSS) capacitor c=1.50779e-16
C157 (\8\:SEb VSS) capacitor c=1.20598e-16
C158 (\7\:SE VSS) capacitor c=9.08436e-17
C159 (\8\:SE VSS) capacitor c=2.96438e-17
C160 (\5\:VDD VSS) capacitor c=2.85042e-18
C161 (\7\:VDD VSS) capacitor c=1.07392e-19
C162 (\9\:VDD VSS) capacitor c=2.14936e-17
C163 (\11\:VDD VSS) capacitor c=3.62697e-17
C164 (\12\:VDD VSS) capacitor c=5.15463e-17
C165 (\14\:VDD VSS) capacitor c=3.70385e-17
C166 (\15\:VDD VSS) capacitor c=1.77194e-17
C167 (\17\:VDD VSS) capacitor c=2.64291e-16
Rk36 (D \5\:D) resistor r=0.02137 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.4563 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.2331 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.3549 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.2121 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.04903 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.5631 c=0
Rk90 (\9\:VSS \10\:VSS) resistor r=0.5893 c=0
Rk91 (\10\:VSS \11\:VSS) resistor r=0.5818 c=0
Rk92 (\11\:VSS \12\:VSS) resistor r=0.1704 c=0
Rk98 (\13\:VSS VSS) resistor r=0.07983 c=0
Rk93 (\12\:VSS \13\:VSS) resistor r=0.5919 c=0
Rk99 (\5\:VSS \19\:VSS) resistor r=0.2001 c=0
Rk100 (\6\:VSS \21\:VSS) resistor r=0.04333 c=0
Rk101 (\8\:VSS \23\:VSS) resistor r=0.04333 c=0
Rk102 (\9\:VSS \25\:VSS) resistor r=0.2403 c=0
Rk103 (\11\:VSS \27\:VSS) resistor r=0.07416 c=0
Rk6 (RN \4\:RN) resistor r=0.09921 c=0
Rk35 (CK \4\:CK) resistor r=0.1413 c=0
Rk52 (SE \7\:SE) resistor r=0.349 c=0
Rk53 (SE \8\:SE) resistor r=0.1576 c=0
Rk54 (\2\:VDD \4\:VDD) resistor r=0.5736 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.1854 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.1654 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.1453 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.05499 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.3761 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.2758 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.2557 c=0
Rk62 (\11\:VDD \12\:VDD) resistor r=0.5114 c=0
Rk63 (\12\:VDD \13\:VDD) resistor r=0.4363 c=0
Rk64 (\13\:VDD \14\:VDD) resistor r=0.2748 c=0
Rk65 (\14\:VDD \15\:VDD) resistor r=0.3348 c=0
Rk66 (\15\:VDD \16\:VDD) resistor r=0.1403 c=0
Rk72 (\17\:VDD VDD) resistor r=0.07983 c=0
Rk67 (\16\:VDD \17\:VDD) resistor r=0.1905 c=0
Rk73 (\5\:VDD \23\:VDD) resistor r=0.2585 c=0
Rk74 (\7\:VDD \25\:VDD) resistor r=0.2689 c=0
Rk75 (\9\:VDD \27\:VDD) resistor r=0.1847 c=0
Rk76 (\11\:VDD \29\:VDD) resistor r=0.2667 c=0
Rk77 (\12\:VDD \31\:VDD) resistor r=0.1733 c=0
Rk78 (\14\:VDD \33\:VDD) resistor r=0.04333 c=0
Rk79 (\15\:VDD \35\:VDD) resistor r=0.07416 c=0
Rk22 (\8\:SN SN) resistor r=1.7734 c=0
Rk23 (SN \9\:SN) resistor r=0.1145 c=0
Rk48 (\4\:SI SI) resistor r=0.05445 c=0
Rk9 (\17\:qbint \18\:qbint) resistor r=1.1772 c=0
Rk10 (\18\:qbint \19\:qbint) resistor r=0.1222 c=0
Rk11 (\19\:qbint \20\:qbint) resistor r=0.1635 c=0
Rk12 (\18\:qbint \22\:qbint) resistor r=0.0611 c=0
Rk13 (\19\:qbint \24\:qbint) resistor r=0.2933 c=0
Rk18 (\10\:n35 \11\:n35) resistor r=0.1916 c=0
Rk19 (\11\:n35 \12\:n35) resistor r=2.0548 c=0
Rk20 (\11\:n35 \14\:n35) resistor r=0.1632 c=0
Rk7 (\10\:RNb \11\:RNb) resistor r=0.1366 c=0
Rk8 (\11\:RNb \13\:RNb) resistor r=0.1548 c=0
Rk16 (\14\:RNb \15\:RNb) resistor r=0.6213 c=0
Rk15 (\2\:net490 \4\:net490) resistor r=0.5427 c=0
Rk14 (\2\:net486 \4\:net486) resistor r=0.8494 c=0
Rk37 (\12\:CKb \13\:CKb) resistor r=0.4982 c=0
Rk38 (\13\:CKb \14\:CKb) resistor r=0.3656 c=0
Rk39 (\13\:CKb \15\:CKb) resistor r=0.7856 c=0
Rk40 (\15\:CKb \16\:CKb) resistor r=0.1208 c=0
Rk41 (\14\:CKb \18\:CKb) resistor r=0.3804 c=0
Rk42 (\15\:CKb \19\:CKb) resistor r=1.8482 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.8559 c=0
Rk24 (\5\:mout \7\:mout) resistor r=0.2806 c=0
Rk25 (\7\:mout \8\:mout) resistor r=0.9773 c=0
Rk26 (\8\:mout \10\:mout) resistor r=0.3084 c=0
Rk27 (\8\:mout \12\:mout) resistor r=0.07562 c=0
Rk28 (\10\:mout \14\:mout) resistor r=0.7891 c=0
Rk29 (\10\:CKbb \11\:CKbb) resistor r=1.3392 c=0
Rk33 (\12\:CKbb \14\:CKbb) resistor r=0.1467 c=0
Rk34 (\12\:CKbb \16\:CKbb) resistor r=0.241 c=0
Rk21 (\2\:net469 \4\:net469) resistor r=0.3101 c=0
Rk30 (\5\:n20 \6\:n20) resistor r=0.4012 c=0
Rk31 (\6\:n20 \8\:n20) resistor r=0.4213 c=0
Rk32 (\6\:n20 \10\:n20) resistor r=0.09071 c=0
Rk44 (\2\:Db \3\:Db) resistor r=0.1866 c=0
Rk45 (\3\:Db \5\:Db) resistor r=0.9072 c=0
Rk46 (\5\:Db \7\:Db) resistor r=0.5864 c=0
Rk47 (\3\:Db \9\:Db) resistor r=0.9208 c=0
Rk49 (\6\:SEb \7\:SEb) resistor r=0.7847 c=0
Rk50 (\7\:SEb \8\:SEb) resistor r=0.3186 c=0
Rk51 (\8\:SEb \10\:SEb) resistor r=0.7019 c=0
Rk17 (\2\:net394 \4\:net394) resistor r=0.2992 c=0
Rl56 (\1\:D \2\:D) resistor r=86.5164 c=0
Rl58 (\2\:D \4\:D) resistor r=120.835 c=0
Rl57 (\2\:D \3\:D) resistor r=76.8484 c=0
Rl20 (\2\:RN \3\:RN) resistor r=26.3736 c=0
Rl19 (\1\:RN \2\:RN) resistor r=94.2308 c=0
Rl54 (\1\:CK \2\:CK) resistor r=200.257 c=0
Rl55 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl65 (\4\:SE \5\:SE) resistor r=69.9225 c=0
Rl66 (\5\:SE \6\:SE) resistor r=31.461 c=0
Rl61 (\2\:SE \3\:SE) resistor r=120.067 c=0
Rl60 (\1\:SE \2\:SE) resistor r=34.6154 c=0
Rl41 (\5\:SN \6\:SN) resistor r=193.796 c=0
Rl42 (\6\:SN \7\:SN) resistor r=24.2328 c=0
Rl29 (\2\:SN \3\:SN) resistor r=57.6702 c=0
Rl28 (\1\:SN \2\:SN) resistor r=145.835 c=0
Rl30 (\2\:SN \4\:SN) resistor r=44.1561 c=0
Rl63 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl64 (\2\:SI \3\:SI) resistor r=119.952 c=0
Rl27 (\14\:qbint \16\:qbint) resistor r=95.7383 c=0
Rl25 (\14\:qbint \13\:qbint) resistor r=50.725 c=0
Rl26 (\14\:qbint \15\:qbint) resistor r=15.3358 c=0
Rl12 (\2\:n35 n35) resistor r=1.2713 c=0
Rl21 (RNb \2\:RNb) resistor r=24.2328 c=0
Rl37 (\6\:RNb \8\:RNb) resistor r=119.231 c=0
Rl36 (\6\:RNb \7\:RNb) resistor r=718.744 c=0
Rl22 (\2\:RNb \3\:RNb) resistor r=103.824 c=0
Rl24 (\3\:RNb \5\:RNb) resistor r=82.3738 c=0
Rl23 (\3\:RNb \4\:RNb) resistor r=115.31 c=0
Rl53 (\8\:CKb \10\:CKb) resistor r=78.1713 c=0
Rl51 (\7\:CKb \8\:CKb) resistor r=26.7711 c=0
Rl52 (\8\:CKb \9\:CKb) resistor r=188.381 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl31 (CKb \2\:CKb) resistor r=34.0806 c=0
Rl43 (mout \2\:mout) resistor r=172.357 c=0
Rl45 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl44 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl50 (\7\:CKbb \9\:CKbb) resistor r=85.7713 c=0
Rl33 (CKbb \2\:CKbb) resistor r=38.143 c=0
Rl34 (\2\:CKbb \3\:CKbb) resistor r=128.39 c=0
Rl35 (\2\:CKbb \4\:CKbb) resistor r=150.332 c=0
Rl49 (\6\:CKbb \8\:CKbb) resistor r=82.3738 c=0
Rl47 (\5\:CKbb \6\:CKbb) resistor r=86.4638 c=0
Rl48 (\6\:CKbb \7\:CKbb) resistor r=74.5433 c=0
Rl38 (n20 \2\:n20) resistor r=68.8799 c=0
Rl39 (\2\:n20 \3\:n20) resistor r=88.1101 c=0
Rl40 (\2\:n20 \4\:n20) resistor r=30.5714 c=0
Rl62 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl59 (SEb \2\:SEb) resistor r=31.9251 c=0
Rz27 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz28 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz31 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz32 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz20 (\4\:VDD \3\:VDD) resistor r=18.75 c=0
Rz21 (\6\:VDD \3\:VDD) resistor r=25 c=0
Rz22 (\8\:VDD \3\:VDD) resistor r=75 c=0
Rz23 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\13\:VDD \3\:VDD) resistor r=6.25 c=0
Rz25 (\16\:VDD \3\:VDD) resistor r=25 c=0
Rz26 (\17\:VDD \3\:VDD) resistor r=9.375 c=0
Rz4 (\22\:qbint \21\:qbint) resistor r=75 c=0
Rz9 (\14\:n35 \13\:n35) resistor r=75 c=0
Rz3 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz7 (net490 \2\:net490) resistor r=75 c=0
Rz8 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz5 (net486 \2\:net486) resistor r=75 c=0
Rz6 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz16 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz12 (\9\:mout \10\:mout) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz15 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (net469 \2\:net469) resistor r=75 c=0
Rz11 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz14 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz17 (Db \2\:Db) resistor r=75 c=0
Rz18 (\4\:Db \5\:Db) resistor r=75 c=0
Rz19 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry28 (\4\:VSS \3\:VSS) resistor r=15.5 c=0
Ry29 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry30 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry31 (\12\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry32 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry18 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry19 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry20 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry21 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry22 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry23 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry4 (\24\:qbint \23\:qbint) resistor r=31 c=0
Ry7 (\10\:n35 \9\:n35) resistor r=31 c=0
Ry3 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry11 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry10 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry13 (\6\:Db \7\:Db) resistor r=62 c=0
Ry14 (\8\:Db \9\:Db) resistor r=62 c=0
Ry15 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (net394 \2\:net394) resistor r=62 c=0
Ry6 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:RN \4\:RN) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx24 (\2\:SE \7\:SE) resistor r=45 c=0
Rx25 (\5\:SE \8\:SE) resistor r=45 c=0
Rx8 (\7\:SN \8\:SN) resistor r=45 c=0
Rx9 (\4\:SN \9\:SN) resistor r=45 c=0
Rx21 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\17\:qbint \15\:qbint) resistor r=45 c=0
Rx4 (\20\:qbint qbint) resistor r=45 c=0
Rx7 (\12\:n35 n35) resistor r=45 c=0
Rx2 (\4\:RNb \11\:RNb) resistor r=45 c=0
Rx5 (\7\:RNb \14\:RNb) resistor r=45 c=0
Rx6 (RNb \15\:RNb) resistor r=45 c=0
Rx17 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx18 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx19 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx20 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\5\:CKbb \12\:CKbb) resistor r=45 c=0
Rx13 (n20 \5\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.947e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28173e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\21\:qbint \2\:n35 \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.474e-14 ad=3.28e-14 ps=9.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=6.1378e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn22 (\12\:RNb \1\:RN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.117e-14 ad=2.61e-14 ps=1e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.8e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn51 (\3\:net490 \5\:RNb \3\:net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.407e-14 ad=5.33e-14 ps=8.4e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=6.3e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn52 (\3\:net490 \13\:qbint net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.69e-14 ad=5.33e-14 ps=7.7e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.25e-07 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn50 (net486 \1\:SN \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=3.69e-14 ps=1.62e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1e-07 sd=160n sca=14.2182 scb=0.0146528 \
        scc=0.000922757 m=(1)
mn53 (\13\:n35 CKb net490 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.21e-14 ad=3.997e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05366e-07 sb=5.25e-07 sd=160n sca=14.6414 \
        scb=0.0151256 scc=0.000999928 m=(1)
mn40 (\13\:n35 CKbb \9\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=3.997e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45366e-07 sb=2.85e-07 sd=160n sca=14.6414 \
        scb=0.0151256 scc=0.000999928 m=(1)
mn31 (\13\:mout \8\:RNb \3\:net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.587e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02317e-06 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn32 (\13\:mout \4\:n20 net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.115e-14 ad=3.587e-14 ps=1.17e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=8.03171e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn30 (net469 \5\:SN \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=6.115e-14 ps=7.3e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.80122e-07 sb=6.55e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn35 (net514 mout \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85122e-07 sb=4.5e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn36 (\9\:n20 \9\:CKbb net514 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.90122e-07 sb=3.45e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn25 (\4\:Db \9\:CKb \9\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09512e-06 sb=1.4e-07 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn21 (\15\:CKbb \7\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.152e-14 ad=3.045e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.75e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn20 (\17\:CKb \3\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.415e-14 ad=2.03e-14 ps=1.85e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.51724e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn11 (net522 \4\:D \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.415e-14 ad=1.56e-14 ps=1.85e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69231e-07 sb=6.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (Db SEb net522 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=6.5e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.74231e-07 sb=5.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn14 (Db \1\:SE net534 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.5e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.69231e-07 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net534 \3\:SI \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74231e-07 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mp45_1__rcx (\23\:qbint \2\:n35 \17\:VDD VDD) g45p1svt w=(3.1e-07) \
        l=4.5e-08 nf=1 as=8.093e-14 ad=4.96e-14 ps=1.42e-06 pd=9.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=9.6e-07 sb=6.17742e-07 sd=160n \
        sca=17.3904 scb=0.0162056 scc=0.00137566 m=(2)
mp22 (\9\:RNb \3\:RN \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0425e-13 ad=5.482e-14 ps=1.74e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2.55e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp51 (net437 \2\:RNb \34\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2055e-13 ad=1.86e-14 ps=1.79e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=3.40565e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp52 (\3\:net394 \16\:qbint net437 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=5.38e-14 ps=7.4e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2.35565e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp50 (\3\:net394 \3\:SN \32\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.03e-14 ad=5.38e-14 ps=1.39e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.14113e-07 sb=1.1129e-07 sd=160n sca=11.1346 \
        scb=0.00910425 scc=0.000198662 m=(1)
mp53 (\9\:n35 \3\:CKbb net394 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.835e-14 ad=5.58e-14 ps=1.19e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.6e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\9\:n35 \3\:CKb \11\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp31 (net417 \6\:RNb \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.6975e-13 ad=4.805e-14 ps=2.04e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=8.63065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\6\:mout \3\:n20 net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=6.63065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\6\:mout \6\:SN \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=4.58065e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 \4\:mout \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=1.86e-14 ps=1.47e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.29677e-07 sb=5.3e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp36 (\7\:n20 \5\:CKb net425 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=7.44e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.34677e-07 sb=4.25e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp25 (\7\:n20 \8\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=7.44e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01968e-06 sb=1.4e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp21 (\13\:CKbb \10\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.495e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp20 (\11\:CKb \1\:CK \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.39535e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp11 (net445 \1\:D \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=5.27308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\8\:Db \3\:SE net445 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=4.22308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\8\:Db \3\:SEb net453 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45064e-07 sb=2.17308e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp13 (net453 \1\:SI \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.50064e-07 sb=1.12308e-07 sd=160n sca=17.4322 \
        scb=0.015316 scc=0.00137893 m=(1)
mp10 (\9\:SEb \4\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=7.525e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
ends SDFFSRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:40:20 2012 )
// Library name: gsclib045
// Cell name: SDFFSRHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX8 CK D Q RN SE SI SN VDD VSS
mp55_1__rcx (Q qbint \14\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90404e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (D VSS) capacitor c=5.88114e-17
C2 (RN VSS) capacitor c=6.82021e-17
C3 (CK VSS) capacitor c=4.48444e-17
C4 (Q VSS) capacitor c=5.07191e-16
C5 (VDD VSS) capacitor c=5.29374e-16
C6 (SN VSS) capacitor c=3.75269e-16
C7 (SI VSS) capacitor c=8.61712e-17
C8 (qbint VSS) capacitor c=3.5992e-16
C9 (n35 VSS) capacitor c=2.03852e-16
C10 (RNb VSS) capacitor c=1.66102e-16
C11 (net486 VSS) capacitor c=7.35105e-17
C12 (net490 VSS) capacitor c=8.21845e-17
C13 (CKb VSS) capacitor c=3.81617e-17
C14 (mout VSS) capacitor c=4.36633e-17
C15 (CKbb VSS) capacitor c=2.72268e-17
C16 (net469 VSS) capacitor c=6.31587e-17
C17 (n20 VSS) capacitor c=3.04162e-17
C18 (Db VSS) capacitor c=1.21794e-16
C19 (net522 VSS) capacitor c=2.73138e-18
C20 (SEb VSS) capacitor c=4.60667e-17
C21 (net394 VSS) capacitor c=1.04392e-16
C22 (net437 VSS) capacitor c=1.85622e-18
C23 (net417 VSS) capacitor c=2.55223e-18
C24 (net425 VSS) capacitor c=3.3732e-18
C25 (net445 VSS) capacitor c=2.5644e-18
C26 (net453 VSS) capacitor c=4.5356e-18
C27 (\7\:SE VSS) capacitor c=7.0688e-17
C28 (\3\:SI VSS) capacitor c=6.36139e-17
C29 (\1\:SE VSS) capacitor c=7.49221e-17
C30 (\1\:D VSS) capacitor c=9.124e-17
C31 (\1\:CK VSS) capacitor c=3.00382e-17
C32 (\5\:CKb VSS) capacitor c=3.91359e-17
C33 (\7\:CKbb VSS) capacitor c=3.59127e-17
C34 (\9\:CKb VSS) capacitor c=6.96639e-17
C35 (\5\:SN VSS) capacitor c=6.53003e-17
C36 (\3\:n20 VSS) capacitor c=9.83149e-17
C37 (\3\:CKb VSS) capacitor c=4.12655e-17
C38 (\3\:CKbb VSS) capacitor c=5.40051e-17
C39 (\3\:RNb VSS) capacitor c=7.07998e-17
C40 (\22\:qbint VSS) capacitor c=1.22401e-16
C41 (\1\:SN VSS) capacitor c=5.03712e-17
C42 (\1\:RN VSS) capacitor c=3.79513e-17
C43 (\5\:SE VSS) capacitor c=2.57884e-17
C44 (\1\:SI VSS) capacitor c=7.89868e-17
C45 (\3\:SE VSS) capacitor c=6.76894e-17
C46 (\3\:SEb VSS) capacitor c=7.70463e-17
C47 (\4\:D VSS) capacitor c=4.6881e-17
C48 (\3\:CK VSS) capacitor c=2.80436e-17
C49 (\10\:CKb VSS) capacitor c=2.72823e-17
C50 (\11\:CKb VSS) capacitor c=2.66839e-17
C51 (\5\:CKbb VSS) capacitor c=4.5964e-17
C52 (\3\:mout VSS) capacitor c=5.7561e-17
C53 (\4\:SN VSS) capacitor c=6.12981e-17
C54 (\4\:RNb VSS) capacitor c=5.23045e-17
C55 (\5\:RNb VSS) capacitor c=6.37463e-17
C56 (\24\:qbint VSS) capacitor c=5.85398e-17
C57 (\3\:SN VSS) capacitor c=3.70192e-17
C58 (\3\:RN VSS) capacitor c=4.18873e-17
C59 (\6\:SE VSS) capacitor c=4.91109e-17
C60 (\2\:SI VSS) capacitor c=5.07161e-17
C61 (\4\:SE VSS) capacitor c=4.73056e-17
C62 (\2\:SEb VSS) capacitor c=5.404e-17
C63 (\2\:SE VSS) capacitor c=4.87473e-17
C64 (\3\:D VSS) capacitor c=2.67646e-17
C65 (\2\:CK VSS) capacitor c=4.07985e-17
C66 (\6\:CKb VSS) capacitor c=2.00609e-17
C67 (\8\:CKbb VSS) capacitor c=3.31507e-17
C68 (\6\:CKbb VSS) capacitor c=4.28449e-17
C69 (\2\:mout VSS) capacitor c=4.17848e-17
C70 (\6\:SN VSS) capacitor c=2.10287e-17
C71 (\4\:n20 VSS) capacitor c=3.02945e-17
C72 (\4\:CKbb VSS) capacitor c=3.12398e-17
C73 (\4\:CKb VSS) capacitor c=4.04151e-17
C74 (\2\:CKb VSS) capacitor c=2.2417e-17
C75 (\2\:RNb VSS) capacitor c=1.02674e-16
C76 (\2\:SN VSS) capacitor c=3.57751e-17
C77 (\2\:RN VSS) capacitor c=2.86922e-17
C78 (\23\:qbint VSS) capacitor c=4.38014e-17
C79 (\8\:SEb VSS) capacitor c=2.78843e-17
C80 (\1\:VDD VSS) capacitor c=4.23315e-17
C81 (\20\:VDD VSS) capacitor c=3.64781e-17
C82 (\12\:CKb VSS) capacitor c=4.32976e-17
C83 (\22\:VDD VSS) capacitor c=5.13008e-17
C84 (\11\:CKbb VSS) capacitor c=1.14296e-16
C85 (\8\:Db VSS) capacitor c=1.02741e-16
C86 (\5\:n20 VSS) capacitor c=9.22721e-17
C87 (\24\:VDD VSS) capacitor c=7.31708e-17
C88 (\11\:mout VSS) capacitor c=2.06958e-16
C89 (\26\:VDD VSS) capacitor c=6.98662e-17
C90 (\7\:mout VSS) capacitor c=4.33509e-17
C91 (\10\:n35 VSS) capacitor c=7.87545e-17
C92 (\28\:VDD VSS) capacitor c=5.71583e-17
C93 (\3\:net394 VSS) capacitor c=9.22601e-17
C94 (\30\:VDD VSS) capacitor c=5.70599e-17
C95 (\7\:RNb VSS) capacitor c=1.8078e-16
C96 (\26\:qbint VSS) capacitor c=3.58063e-16
C97 (\3\:VDD VSS) capacitor c=1.72249e-16
C98 (\4\:SEb VSS) capacitor c=6.49509e-17
C99 (\6\:Db VSS) capacitor c=4.43575e-17
C100 (\18\:CKb VSS) capacitor c=7.74578e-17
C101 (\9\:CKbb VSS) capacitor c=9.37198e-17
C102 (\4\:Db VSS) capacitor c=1.8913e-16
C103 (\9\:n20 VSS) capacitor c=1.99961e-17
C104 (\9\:mout VSS) capacitor c=1.41602e-16
C105 (\3\:net469 VSS) capacitor c=7.87791e-17
C106 (\4\:mout VSS) capacitor c=1.23769e-16
C107 (\14\:n35 VSS) capacitor c=6.2069e-17
C108 (\3\:net490 VSS) capacitor c=9.91479e-17
C109 (\3\:net486 VSS) capacitor c=6.32638e-17
C110 (\9\:RNb VSS) capacitor c=1.10145e-16
C111 (\2\:CKbb VSS) capacitor c=6.28891e-17
C112 (\2\:n20 VSS) capacitor c=3.90929e-17
C113 (\25\:qbint VSS) capacitor c=6.62875e-17
C114 (\31\:qbint VSS) capacitor c=3.20739e-17
C115 (\7\:CKb VSS) capacitor c=2.25541e-17
C116 (\8\:CKb VSS) capacitor c=5.75338e-17
C117 (\4\:RN VSS) capacitor c=5.04607e-17
C118 (\2\:D VSS) capacitor c=2.78923e-17
C119 (\6\:RNb VSS) capacitor c=9.59306e-17
C120 (\12\:n35 VSS) capacitor c=3.24099e-16
C121 (\13\:n35 VSS) capacitor c=2.69135e-16
C122 (\7\:SN VSS) capacitor c=3.29948e-16
C123 (\6\:mout VSS) capacitor c=1.57339e-16
C124 (\13\:mout VSS) capacitor c=9.14716e-17
C125 (\7\:n20 VSS) capacitor c=1.07541e-16
C126 (\8\:n20 VSS) capacitor c=8.88737e-17
C127 (\13\:CKbb VSS) capacitor c=1.36548e-16
C128 (\14\:CKbb VSS) capacitor c=2.7817e-16
C129 (\15\:CKbb VSS) capacitor c=2.08501e-16
C130 (\16\:CKbb VSS) capacitor c=7.00145e-17
C131 (\14\:CKb VSS) capacitor c=4.15264e-16
C132 (\15\:CKb VSS) capacitor c=5.78533e-16
C133 (\16\:CKb VSS) capacitor c=1.23073e-16
C134 (\17\:CKb VSS) capacitor c=7.87197e-17
C135 (\4\:CK VSS) capacitor c=8.2171e-17
C136 (\5\:D VSS) capacitor c=8.52243e-17
C137 (\3\:Db VSS) capacitor c=2.11311e-16
C138 (\4\:SI VSS) capacitor c=4.65584e-17
C139 (\8\:SE VSS) capacitor c=7.05828e-17
C140 (\9\:SE VSS) capacitor c=7.94776e-17
C141 (\10\:SE VSS) capacitor c=6.63995e-17
C142 (\6\:SEb VSS) capacitor c=9.46089e-17
C143 (\7\:SEb VSS) capacitor c=1.19246e-16
C144 (\5\:VDD VSS) capacitor c=1.46415e-17
C145 (\6\:VDD VSS) capacitor c=3.30692e-17
C146 (\8\:VDD VSS) capacitor c=2.46754e-17
C147 (\9\:VDD VSS) capacitor c=2.59357e-17
C148 (\11\:VDD VSS) capacitor c=3.1203e-17
C149 (\13\:VDD VSS) capacitor c=4.93867e-17
C150 (\14\:VDD VSS) capacitor c=5.40441e-16
Rk50 (D \5\:D) resistor r=0.1234 c=0
Rk62 (\2\:VSS \3\:VSS) resistor r=0.1604 c=0
Rk63 (\3\:VSS \4\:VSS) resistor r=0.09015 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.3251 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.3765 c=0
Rk66 (\3\:VSS \8\:VSS) resistor r=0.276 c=0
Rk67 (\5\:VSS \10\:VSS) resistor r=0.04335 c=0
Rk68 (\6\:VSS \11\:VSS) resistor r=0.6096 c=0
Rk69 (\11\:VSS \12\:VSS) resistor r=0.193 c=0
Rk70 (\12\:VSS \13\:VSS) resistor r=0.803 c=0
Rk71 (\13\:VSS \14\:VSS) resistor r=0.5971 c=0
Rk72 (\14\:VSS \15\:VSS) resistor r=0.1554 c=0
Rk79 (\16\:VSS VSS) resistor r=0.1075 c=0
Rk73 (\15\:VSS \16\:VSS) resistor r=0.3737 c=0
Rk80 (\6\:VSS \23\:VSS) resistor r=0.07152 c=0
Rk81 (\11\:VSS \25\:VSS) resistor r=0.235 c=0
Rk82 (\14\:VSS \27\:VSS) resistor r=0.3239 c=0
Rk19 (\4\:RN RN) resistor r=0.07561 c=0
Rk49 (CK \4\:CK) resistor r=0.1415 c=0
Rk56 (SE \8\:SE) resistor r=0.005081 c=0
Rk57 (\8\:SE \9\:SE) resistor r=0.4194 c=0
Rk58 (\9\:SE \10\:SE) resistor r=0.3461 c=0
Rk88 (\2\:VDD \4\:VDD) resistor r=0.4039 c=0
Rk89 (\4\:VDD \5\:VDD) resistor r=0.2558 c=0
Rk90 (\5\:VDD \6\:VDD) resistor r=0.2455 c=0
Rk91 (\6\:VDD \7\:VDD) resistor r=0.6021 c=0
Rk92 (\7\:VDD \8\:VDD) resistor r=0.1353 c=0
Rk93 (\8\:VDD \9\:VDD) resistor r=0.5115 c=0
Rk94 (\9\:VDD \10\:VDD) resistor r=0.05501 c=0
Rk95 (\10\:VDD \11\:VDD) resistor r=0.6523 c=0
Rk96 (\11\:VDD \12\:VDD) resistor r=0.04999 c=0
Rk97 (\12\:VDD \13\:VDD) resistor r=0.3587 c=0
Rk104 (\14\:VDD VDD) resistor r=0.1075 c=0
Rk98 (\13\:VDD \14\:VDD) resistor r=0.4664 c=0
Rk105 (\5\:VDD \21\:VDD) resistor r=0.3869 c=0
Rk106 (\6\:VDD \23\:VDD) resistor r=0.3388 c=0
Rk107 (\8\:VDD \25\:VDD) resistor r=0.2944 c=0
Rk108 (\9\:VDD \27\:VDD) resistor r=0.235 c=0
Rk109 (\11\:VDD \29\:VDD) resistor r=0.2477 c=0
Rk110 (\13\:VDD \31\:VDD) resistor r=0.2421 c=0
Rk29 (\8\:SN SN) resistor r=0.01255 c=0
Rk28 (\7\:SN \8\:SN) resistor r=2.6244 c=0
Rk55 (\4\:SI SI) resistor r=0.01944 c=0
Rk11 (\25\:qbint \26\:qbint) resistor r=0.5959 c=0
Rk15 (\26\:qbint \31\:qbint) resistor r=0.1671 c=0
Rk25 (\11\:n35 \12\:n35) resistor r=0.1981 c=0
Rk26 (\12\:n35 \13\:n35) resistor r=2.2074 c=0
Rk27 (\12\:n35 \15\:n35) resistor r=0.2639 c=0
Rk20 (\6\:RNb \8\:RNb) resistor r=0.7607 c=0
Rk21 (\8\:RNb \10\:RNb) resistor r=0.7313 c=0
Rk22 (\2\:net486 \4\:net486) resistor r=0.3453 c=0
Rk24 (\2\:net490 \4\:net490) resistor r=0.3602 c=0
Rk44 (\13\:CKb \14\:CKb) resistor r=0.2884 c=0
Rk45 (\14\:CKb \15\:CKb) resistor r=3.358 c=0
Rk46 (\15\:CKb \16\:CKb) resistor r=0.8883 c=0
Rk47 (\14\:CKb \17\:CKb) resistor r=0.2735 c=0
Rk48 (\17\:CKb \19\:CKb) resistor r=0.454 c=0
Rk31 (\5\:mout \6\:mout) resistor r=0.2545 c=0
Rk32 (\6\:mout \8\:mout) resistor r=0.1517 c=0
Rk33 (\5\:mout \10\:mout) resistor r=0.8346 c=0
Rk34 (\6\:mout \12\:mout) resistor r=1.0011 c=0
Rk35 (\12\:mout \13\:mout) resistor r=0.4052 c=0
Rk39 (\10\:CKbb \12\:CKbb) resistor r=0.4998 c=0
Rk40 (\12\:CKbb \13\:CKbb) resistor r=0.3917 c=0
Rk41 (\13\:CKbb \14\:CKbb) resistor r=0.6589 c=0
Rk42 (\14\:CKbb \15\:CKbb) resistor r=1.5174 c=0
Rk43 (\13\:CKbb \16\:CKbb) resistor r=0.2487 c=0
Rk30 (\2\:net469 \4\:net469) resistor r=0.3376 c=0
Rk36 (\6\:n20 \7\:n20) resistor r=0.4712 c=0
Rk37 (\7\:n20 \8\:n20) resistor r=0.5281 c=0
Rk38 (\7\:n20 \10\:n20) resistor r=0.06512 c=0
Rk51 (\2\:Db \3\:Db) resistor r=0.7142 c=0
Rk52 (\3\:Db \5\:Db) resistor r=1.0156 c=0
Rk53 (\3\:Db \7\:Db) resistor r=0.1796 c=0
Rk54 (\5\:Db \9\:Db) resistor r=0.6334 c=0
Rk59 (\5\:SEb \6\:SEb) resistor r=0.5034 c=0
Rk60 (\6\:SEb \7\:SEb) resistor r=0.7712 c=0
Rk61 (\6\:SEb \9\:SEb) resistor r=0.4152 c=0
Rk23 (\2\:net394 \4\:net394) resistor r=0.4937 c=0
Rl61 (\1\:D \2\:D) resistor r=103.08 c=0
Rl63 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl62 (\2\:D \3\:D) resistor r=46.5271 c=0
Rl29 (\1\:RN \2\:RN) resistor r=47.3097 c=0
Rl30 (\2\:RN \3\:RN) resistor r=76.1559 c=0
Rl59 (\1\:CK \2\:CK) resistor r=90.9234 c=0
Rl60 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl71 (\6\:SE \7\:SE) resistor r=261.796 c=0
Rl70 (\5\:SE \6\:SE) resistor r=39.1533 c=0
Rl67 (\3\:SE \4\:SE) resistor r=31.3807 c=0
Rl64 (\1\:SE \2\:SE) resistor r=33.7903 c=0
Rl47 (\4\:SN \5\:SN) resistor r=172.643 c=0
Rl48 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl31 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl32 (\2\:SN \3\:SN) resistor r=93.4636 c=0
Rl69 (\2\:SI \3\:SI) resistor r=37.4409 c=0
Rl68 (\1\:SI \2\:SI) resistor r=110.771 c=0
Rl34 (\24\:qbint \22\:qbint) resistor r=146.154 c=0
Rl33 (\23\:qbint \22\:qbint) resistor r=314.898 c=0
Rl42 (RNb \4\:RNb) resistor r=150 c=0
Rl43 (\3\:RNb \5\:RNb) resistor r=166.873 c=0
Rl40 (RNb \2\:RNb) resistor r=873.616 c=0
Rl41 (\2\:RNb \3\:RNb) resistor r=39.6174 c=0
Rl53 (\5\:CKb \6\:CKb) resistor r=133.848 c=0
Rl36 (\3\:CKb \4\:CKb) resistor r=35.3072 c=0
Rl35 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl57 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl54 (\6\:CKb \7\:CKb) resistor r=15.351 c=0
Rl56 (\8\:CKb \9\:CKb) resistor r=194.953 c=0
Rl58 (\8\:CKb \11\:CKb) resistor r=45.3874 c=0
Rl55 (\7\:CKb \8\:CKb) resistor r=208.53 c=0
Rl49 (mout \2\:mout) resistor r=28.079 c=0
Rl50 (\2\:mout \3\:mout) resistor r=131.925 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl37 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl38 (\2\:CKbb \3\:CKbb) resistor r=164.928 c=0
Rl39 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl44 (n20 \2\:n20) resistor r=23.7402 c=0
Rl45 (\2\:n20 \3\:n20) resistor r=156.078 c=0
Rl46 (\2\:n20 \4\:n20) resistor r=6.6011 c=0
Rl65 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl66 (\2\:SEb \3\:SEb) resistor r=121.875 c=0
Rz23 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz24 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz25 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz33 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz34 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz35 (\10\:VDD \3\:VDD) resistor r=37.5 c=0
Rz36 (\12\:VDD \3\:VDD) resistor r=6.25 c=0
Rz37 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\15\:n35 \14\:n35) resistor r=75 c=0
Rz7 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz8 (net486 \2\:net486) resistor r=75 c=0
Rz9 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz10 (net490 \2\:net490) resistor r=75 c=0
Rz11 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz19 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz15 (\4\:mout \5\:mout) resistor r=75 c=0
Rz16 (\9\:mout \10\:mout) resistor r=75 c=0
Rz18 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz13 (net469 \2\:net469) resistor r=75 c=0
Rz14 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz17 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz20 (\4\:Db \5\:Db) resistor r=75 c=0
Rz21 (\6\:Db \7\:Db) resistor r=75 c=0
Rz22 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry20 (\4\:VSS \1\:VSS) resistor r=31 c=0
Ry21 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\12\:VSS \1\:VSS) resistor r=15.5 c=0
Ry23 (\13\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry24 (\15\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry25 (\16\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry27 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry29 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry30 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry31 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry32 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry10 (\11\:n35 \10\:n35) resistor r=31 c=0
Ry7 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry15 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry11 (\7\:mout \8\:mout) resistor r=62 c=0
Ry12 (\11\:mout \12\:mout) resistor r=62 c=0
Ry14 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry13 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry16 (Db \2\:Db) resistor r=20.6667 c=0
Ry17 (\8\:Db \9\:Db) resistor r=62 c=0
Ry18 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry8 (net394 \2\:net394) resistor r=62 c=0
Ry9 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx17 (\3\:D \5\:D) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\6\:SE \8\:SE) resistor r=45 c=0
Rx20 (\4\:SE \9\:SE) resistor r=45 c=0
Rx21 (\2\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx2 (\31\:qbint qbint) resistor r=45 c=0
Rx5 (\13\:n35 n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx13 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx15 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \16\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\26\:qbint n35 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.623e-14 ad=4.81e-14 ps=8.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(3)
mn22 (\9\:RNb \3\:RN \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.297e-14 ad=2.755e-14 ps=9.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=9.3e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn50 (\3\:net486 \3\:SN \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.297e-14 ad=4.92e-14 ps=9.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75854e-07 sb=6.3e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn52 (net490 \24\:qbint \3\:net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.92e-14 ad=3.28e-14 ps=8.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.60854e-07 sb=3.45e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65854e-07 sb=1.4e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn53 (\14\:n35 CKb \3\:net490 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.612e-14 ad=5.125e-14 ps=8.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=5.8e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\14\:n35 CKbb \4\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.842e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\9\:mout \4\:RNb \3\:net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=4.612e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn32 (\9\:mout n20 net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.612e-14 ps=7.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.055e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (net469 \4\:SN \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=3.382e-14 ps=8.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=8.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.05e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.92e-14 ps=6.1e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\4\:Db \11\:CKb \9\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=2.87e-14 ps=8.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\9\:CKbb \10\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.185e-14 ad=2.03e-14 ps=1.25e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn20 (\18\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.535e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.30362e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net522 \4\:D \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.535e-14 ad=4.03e-14 ps=1.5e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.34519e-07 sb=8.94038e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn12 (\6\:Db \3\:SEb net522 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=6.257e-14 ps=8.3e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.34519e-07 sb=6.94038e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn14 (\6\:Db \3\:SE net534 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.257e-14 ps=6.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.42308e-07 sb=4.42019e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn13 (net534 \1\:SI \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=1.56e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47308e-07 sb=3.37019e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn10 (\4\:SEb \5\:SE \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.08e-14 ad=2.03e-14 ps=1.2e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39414e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45_1__rcx (\26\:qbint n35 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.98e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp22 (\7\:RNb \1\:RN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.85e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp50 (\3\:net394 \1\:SN \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.57e-14 ad=7.44e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.67984e-07 sb=6.85e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp52 (\3\:net394 \22\:qbint net437 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=7.44e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.52984e-07 sb=4e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (net437 \3\:RNb \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0045e-13 ad=1.86e-14 ps=1.36e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.57984e-07 sb=2.95e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp53 (\10\:n35 \3\:CKbb net394 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\10\:n35 \3\:CKb \7\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp31 (net417 RNb \26\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.946e-13 ad=1.86e-14 ps=2.09e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1.17952e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\11\:mout \5\:SN \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.975e-14 ps=1.49e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.04516e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp32 (\11\:mout \3\:n20 net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.975e-14 ps=7.4e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.07452e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net425 mout \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0385e-13 ad=6.045e-14 ps=1.49e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.66613e-07 sb=7.26129e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\5\:n20 \9\:CKb net425 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=9.193e-14 ps=1.01e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20661e-06 sb=4.86129e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp25 (\5\:n20 \7\:CKbb \8\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.193e-14 ps=9.6e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49815e-06 sb=1.7e-07 sd=160n sca=17.9343 \
        scb=0.0166254 scc=0.0014837 m=(1)
mp21 (\11\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.35e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp20 (\12\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.20581e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp11 (net445 \1\:D \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=2.34e-14 ps=1.28e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.84679e-07 sb=7.15064e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.89679e-07 sb=6.10064e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp13 (net453 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=4.875e-14 ps=1.1e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.64679e-07 sb=2.35064e-07 sd=160n sca=19.3112 \
        scb=0.0164357 scc=0.00171563 m=(1)
mp14 (Db SEb net453 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.875e-14 \
        ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.94679e-07 sb=4.05064e-07 sd=160n sca=19.0259 scb=0.0163587 \
        scc=0.00171562 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.47326e-07 sb=1.4e-07 sd=160n sca=12.2443 \
        scb=0.00977105 scc=0.000188654 m=(1)
ends SDFFSRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:40:58 2012 )
// Library name: gsclib045
// Cell name: SDFFSRX1
// View name: extracted

simulator lang=spectre

subckt SDFFSRX1 CK D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:net573 \32\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.4399 \
        scb=0.0250891 scc=0.0034155 m=(1)
C1 (CK VSS) capacitor c=5.62616e-17
C2 (Q VSS) capacitor c=9.11202e-17
C3 (SE VSS) capacitor c=4.01894e-17
C4 (SN VSS) capacitor c=3.21023e-16
C5 (SI VSS) capacitor c=6.81021e-17
C6 (QN VSS) capacitor c=2.27442e-17
C7 (VDD VSS) capacitor c=4.7433e-16
C8 (D VSS) capacitor c=9.35689e-17
C9 (RN VSS) capacitor c=1.13665e-16
C10 (net573 VSS) capacitor c=2.30725e-17
C11 (qbint VSS) capacitor c=5.59684e-17
C12 (RNb VSS) capacitor c=5.1736e-17
C13 (n35 VSS) capacitor c=1.49007e-17
C14 (n8 VSS) capacitor c=9.04725e-17
C15 (n10 VSS) capacitor c=6.83467e-17
C16 (CKb VSS) capacitor c=4.19677e-17
C17 (mout VSS) capacitor c=6.91458e-17
C18 (CKbb VSS) capacitor c=4.23872e-17
C19 (n4 VSS) capacitor c=7.29451e-17
C20 (n20 VSS) capacitor c=5.26641e-17
C21 (Db VSS) capacitor c=6.58365e-17
C22 (n0 VSS) capacitor c=3.56815e-18
C23 (SEb VSS) capacitor c=3.33161e-17
C24 (n11 VSS) capacitor c=1.17915e-16
C25 (n9 VSS) capacitor c=1.57959e-18
C26 (n5 VSS) capacitor c=2.63396e-18
C27 (n7 VSS) capacitor c=9.53981e-19
C28 (n1 VSS) capacitor c=4.40543e-18
C29 (\7\:SE VSS) capacitor c=4.0685e-17
C30 (\3\:SI VSS) capacitor c=4.40031e-17
C31 (\1\:SE VSS) capacitor c=3.89732e-17
C32 (\4\:D VSS) capacitor c=4.49053e-17
C33 (\1\:CK VSS) capacitor c=3.11559e-17
C34 (\8\:CKb VSS) capacitor c=2.63734e-17
C35 (\7\:CKb VSS) capacitor c=6.83471e-17
C36 (\5\:SN VSS) capacitor c=6.18702e-17
C37 (\5\:RNb VSS) capacitor c=6.74478e-17
C38 (\5\:CKb VSS) capacitor c=3.43027e-17
C39 (\5\:CKbb VSS) capacitor c=6.25602e-17
C40 (\2\:RNb VSS) capacitor c=8.86233e-17
C41 (\8\:qbint VSS) capacitor c=9.70956e-17
C42 (\1\:SN VSS) capacitor c=4.18519e-17
C43 (\4\:n35 VSS) capacitor c=4.35709e-17
C44 (\1\:RN VSS) capacitor c=3.51967e-17
C45 (\7\:qbint VSS) capacitor c=2.93541e-17
C46 (\4\:net573 VSS) capacitor c=4.37616e-17
C47 (\5\:SE VSS) capacitor c=2.35591e-17
C48 (\1\:SI VSS) capacitor c=6.39182e-17
C49 (\3\:SE VSS) capacitor c=6.62191e-17
C50 (\3\:SEb VSS) capacitor c=6.50894e-17
C51 (\1\:D VSS) capacitor c=4.27985e-17
C52 (\3\:CK VSS) capacitor c=3.81055e-17
C53 (\11\:CKb VSS) capacitor c=2.39751e-17
C54 (\10\:CKb VSS) capacitor c=5.80157e-17
C55 (\3\:CKbb VSS) capacitor c=1.50473e-16
C56 (\3\:mout VSS) capacitor c=6.90587e-17
C57 (\4\:SN VSS) capacitor c=6.88019e-17
C58 (\3\:n20 VSS) capacitor c=3.78615e-17
C59 (\4\:RNb VSS) capacitor c=5.41757e-17
C60 (\4\:CKbb VSS) capacitor c=1.12173e-16
C61 (\9\:qbint VSS) capacitor c=4.49932e-17
C62 (\3\:SN VSS) capacitor c=6.04666e-17
C63 (\3\:n35 VSS) capacitor c=3.88946e-17
C64 (\3\:RN VSS) capacitor c=6.22766e-17
C65 (\5\:qbint VSS) capacitor c=3.24305e-17
C66 (\4\:qbint VSS) capacitor c=2.14349e-17
C67 (\3\:net573 VSS) capacitor c=3.48881e-17
C68 (\6\:SE VSS) capacitor c=4.44457e-17
C69 (\2\:SI VSS) capacitor c=6.24228e-17
C70 (\4\:SE VSS) capacitor c=4.91872e-17
C71 (\2\:SEb VSS) capacitor c=6.26825e-17
C72 (\2\:SE VSS) capacitor c=3.90108e-17
C73 (\3\:D VSS) capacitor c=2.25263e-17
C74 (\2\:CK VSS) capacitor c=4.67534e-17
C75 (\9\:CKb VSS) capacitor c=5.58568e-17
C76 (\6\:CKbb VSS) capacitor c=5.02644e-17
C77 (\6\:CKb VSS) capacitor c=3.23379e-17
C78 (\2\:mout VSS) capacitor c=5.79277e-17
C79 (\6\:SN VSS) capacitor c=3.2311e-17
C80 (\3\:CKb VSS) capacitor c=3.71289e-17
C81 (\6\:RNb VSS) capacitor c=2.21838e-17
C82 (\4\:CKb VSS) capacitor c=4.23425e-17
C83 (\2\:CKb VSS) capacitor c=3.40528e-17
C84 (\3\:RNb VSS) capacitor c=2.47849e-17
C85 (\10\:qbint VSS) capacitor c=2.60486e-17
C86 (\2\:SN VSS) capacitor c=4.57472e-17
C87 (\2\:RN VSS) capacitor c=4.72921e-17
C88 (\6\:qbint VSS) capacitor c=2.01396e-17
C89 (\4\:SEb VSS) capacitor c=1.40323e-17
C90 (\1\:VDD VSS) capacitor c=2.83539e-17
C91 (\6\:Db VSS) capacitor c=8.41262e-17
C92 (\18\:VDD VSS) capacitor c=3.19458e-17
C93 (\14\:CKb VSS) capacitor c=6.19372e-17
C94 (\20\:VDD VSS) capacitor c=1.43795e-17
C95 (\7\:CKbb VSS) capacitor c=4.34296e-17
C96 (\8\:Db VSS) capacitor c=8.20181e-17
C97 (\9\:n20 VSS) capacitor c=5.12818e-17
C98 (\22\:VDD VSS) capacitor c=1.11847e-17
C99 (\10\:mout VSS) capacitor c=3.75557e-17
C100 (\24\:VDD VSS) capacitor c=1.94587e-17
C101 (\8\:mout VSS) capacitor c=7.45336e-17
C102 (\9\:n35 VSS) capacitor c=4.76061e-17
C103 (\26\:VDD VSS) capacitor c=3.40009e-17
C104 (\3\:n11 VSS) capacitor c=1.18424e-16
C105 (\28\:VDD VSS) capacitor c=1.21265e-17
C106 (\16\:qbint VSS) capacitor c=6.35782e-17
C107 (\10\:RNb VSS) capacitor c=2.60106e-17
C108 (\30\:VDD VSS) capacitor c=3.2556e-17
C109 (\1\:Q VSS) capacitor c=6.52761e-17
C110 (\5\:net573 VSS) capacitor c=3.20248e-17
C111 (\32\:VDD VSS) capacitor c=5.95067e-17
C112 (\1\:QN VSS) capacitor c=4.74395e-17
C113 (\3\:VDD VSS) capacitor c=1.59625e-16
C114 (\8\:SEb VSS) capacitor c=5.17763e-17
C115 (\22\:CKb VSS) capacitor c=6.41166e-17
C116 (\10\:CKbb VSS) capacitor c=5.55216e-17
C117 (\4\:Db VSS) capacitor c=1.62729e-16
C118 (\5\:n20 VSS) capacitor c=2.76072e-17
C119 (\12\:mout VSS) capacitor c=3.0197e-17
C120 (\3\:n4 VSS) capacitor c=7.40074e-17
C121 (\14\:mout VSS) capacitor c=4.23234e-17
C122 (\5\:n35 VSS) capacitor c=4.18647e-17
C123 (\3\:n8 VSS) capacitor c=8.32363e-17
C124 (\3\:n10 VSS) capacitor c=8.32187e-17
C125 (\13\:qbint VSS) capacitor c=6.47728e-17
C126 (\12\:RNb VSS) capacitor c=1.42206e-16
C127 (\3\:Q VSS) capacitor c=2.98488e-17
C128 (\9\:net573 VSS) capacitor c=3.84635e-17
C129 (\3\:QN VSS) capacitor c=3.62619e-17
C130 (\2\:net573 VSS) capacitor c=8.32516e-18
C131 (\2\:qbint VSS) capacitor c=2.1629e-17
C132 (\3\:qbint VSS) capacitor c=3.27302e-17
C133 (\2\:n35 VSS) capacitor c=2.04104e-17
C134 (\2\:n20 VSS) capacitor c=4.59082e-17
C135 (\2\:CKbb VSS) capacitor c=5.65117e-17
C136 (\7\:net573 VSS) capacitor c=2.95401e-17
C137 (\8\:net573 VSS) capacitor c=2.88691e-17
C138 (\2\:D VSS) capacitor c=4.79796e-17
C139 (\11\:qbint VSS) capacitor c=1.20337e-16
C140 (\12\:qbint VSS) capacitor c=1.16795e-16
C141 (\15\:qbint VSS) capacitor c=6.3923e-17
C142 (\7\:n35 VSS) capacitor c=1.63432e-16
C143 (\8\:n35 VSS) capacitor c=1.39451e-16
C144 (\12\:CKb VSS) capacitor c=1.11834e-16
C145 (\13\:CKb VSS) capacitor c=6.75954e-17
C146 (\7\:RNb VSS) capacitor c=1.36537e-16
C147 (\8\:RNb VSS) capacitor c=2.16032e-16
C148 (\9\:RNb VSS) capacitor c=1.31112e-16
C149 (\7\:SN VSS) capacitor c=2.72107e-16
C150 (\4\:mout VSS) capacitor c=4.35543e-17
C151 (\5\:mout VSS) capacitor c=4.5264e-17
C152 (\6\:mout VSS) capacitor c=6.41084e-17
C153 (\7\:mout VSS) capacitor c=5.87235e-17
C154 (\7\:n20 VSS) capacitor c=6.10524e-17
C155 (\8\:n20 VSS) capacitor c=7.56991e-17
C156 (\9\:CKbb VSS) capacitor c=4.99795e-17
C157 (\16\:CKb VSS) capacitor c=6.60522e-17
C158 (\17\:CKb VSS) capacitor c=1.40678e-16
C159 (\18\:CKb VSS) capacitor c=1.47366e-16
C160 (\20\:CKb VSS) capacitor c=8.6871e-17
C161 (\21\:CKb VSS) capacitor c=2.00827e-17
C162 (\4\:CK VSS) capacitor c=8.152e-17
C163 (\5\:D VSS) capacitor c=3.33282e-17
C164 (\3\:Db VSS) capacitor c=2.06935e-16
C165 (\4\:SI VSS) capacitor c=7.27861e-17
C166 (\8\:SE VSS) capacitor c=7.15773e-17
C167 (\9\:SE VSS) capacitor c=8.0097e-17
C168 (\10\:SE VSS) capacitor c=3.70356e-17
C169 (\6\:SEb VSS) capacitor c=7.96614e-17
C170 (\7\:SEb VSS) capacitor c=6.66833e-17
C171 (\5\:VDD VSS) capacitor c=9.76069e-18
C172 (\9\:VDD VSS) capacitor c=1.12853e-18
C173 (\11\:VDD VSS) capacitor c=2.98471e-17
C174 (\13\:VDD VSS) capacitor c=2.13946e-17
C175 (\14\:VDD VSS) capacitor c=3.32403e-17
C176 (\15\:VDD VSS) capacitor c=2.16673e-17
C177 (\17\:VDD VSS) capacitor c=1.79794e-17
Rk46 (\4\:CK CK) resistor r=0.09742 c=0
Rk6 (\2\:Q Q) resistor r=0.3961 c=0
Rk7 (Q \4\:Q) resistor r=0.1585 c=0
Rk54 (\8\:SE SE) resistor r=0.1336 c=0
Rk53 (\8\:SE \9\:SE) resistor r=0.4362 c=0
Rk55 (SE \10\:SE) resistor r=0.1164 c=0
Rk25 (\7\:SN SN) resistor r=2.0206 c=0
Rk26 (SN \8\:SN) resistor r=0.00358 c=0
Rk52 (\4\:SI SI) resistor r=0.05785 c=0
Rk2 (\4\:QN QN) resistor r=0.09048 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3061 c=0
Rk77 (\2\:VDD \4\:VDD) resistor r=0.3337 c=0
Rk78 (\4\:VDD \5\:VDD) resistor r=0.3685 c=0
Rk79 (\5\:VDD \6\:VDD) resistor r=0.1327 c=0
Rk80 (\6\:VDD \7\:VDD) resistor r=0.1443 c=0
Rk81 (\7\:VDD \8\:VDD) resistor r=0.2045 c=0
Rk82 (\8\:VDD \9\:VDD) resistor r=0.2356 c=0
Rk83 (\9\:VDD \10\:VDD) resistor r=0.06502 c=0
Rk84 (\10\:VDD \11\:VDD) resistor r=0.4227 c=0
Rk85 (\11\:VDD \12\:VDD) resistor r=0.2773 c=0
Rk86 (\12\:VDD \13\:VDD) resistor r=0.2331 c=0
Rk87 (\13\:VDD \14\:VDD) resistor r=0.3207 c=0
Rk88 (\14\:VDD \15\:VDD) resistor r=0.3834 c=0
Rk89 (\15\:VDD \16\:VDD) resistor r=0.1152 c=0
Rk91 (\17\:VDD VDD) resistor r=0.1977 c=0
Rk90 (\16\:VDD \17\:VDD) resistor r=0.203 c=0
Rk92 (\5\:VDD \19\:VDD) resistor r=0.24 c=0
Rk93 (\7\:VDD \21\:VDD) resistor r=0.04332 c=0
Rk94 (\9\:VDD \23\:VDD) resistor r=0.07405 c=0
Rk95 (\11\:VDD \25\:VDD) resistor r=0.04332 c=0
Rk96 (\13\:VDD \27\:VDD) resistor r=0.1463 c=0
Rk97 (\14\:VDD \29\:VDD) resistor r=0.07405 c=0
Rk98 (\15\:VDD \31\:VDD) resistor r=0.215 c=0
Rk99 (\17\:VDD \33\:VDD) resistor r=0.4362 c=0
Rk47 (\5\:D D) resistor r=0.08082 c=0
Rk59 (\2\:VSS \4\:VSS) resistor r=0.3477 c=0
Rk60 (\4\:VSS \5\:VSS) resistor r=0.3008 c=0
Rk61 (\5\:VSS \6\:VSS) resistor r=0.2005 c=0
Rk62 (\6\:VSS \7\:VSS) resistor r=0.1945 c=0
Rk63 (\7\:VSS \8\:VSS) resistor r=0.1544 c=0
Rk64 (\8\:VSS \9\:VSS) resistor r=0.3209 c=0
Rk65 (\9\:VSS \10\:VSS) resistor r=0.4312 c=0
Rk66 (\10\:VSS \11\:VSS) resistor r=0.8542 c=0
Rk67 (\11\:VSS \12\:VSS) resistor r=0.3475 c=0
Rk68 (\12\:VSS \13\:VSS) resistor r=0.03492 c=0
Rk70 (\14\:VSS VSS) resistor r=0.1977 c=0
Rk69 (\13\:VSS \14\:VSS) resistor r=0.3182 c=0
Rk71 (\5\:VSS \16\:VSS) resistor r=0.2199 c=0
Rk72 (\7\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk73 (\9\:VSS \20\:VSS) resistor r=0.3395 c=0
Rk74 (\11\:VSS \22\:VSS) resistor r=0.04332 c=0
Rk75 (\13\:VSS \24\:VSS) resistor r=0.2582 c=0
Rk76 (\14\:VSS \26\:VSS) resistor r=0.371 c=0
Rk8 (\4\:RN RN) resistor r=0.003004 c=0
Rk3 (\6\:net573 \7\:net573) resistor r=0.1149 c=0
Rk4 (\7\:net573 \8\:net573) resistor r=0.1195 c=0
Rk5 (\7\:net573 \10\:net573) resistor r=0.1089 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.7739 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.1162 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.3429 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.4197 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=1.0444 c=0
Rk21 (\8\:RNb \9\:RNb) resistor r=0.6935 c=0
Rk22 (\9\:RNb \11\:RNb) resistor r=0.04766 c=0
Rk23 (\9\:RNb \13\:RNb) resistor r=0.7351 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=0.1596 c=0
Rk17 (\7\:n35 \8\:n35) resistor r=1.0844 c=0
Rk18 (\7\:n35 \10\:n35) resistor r=0.1645 c=0
Rk13 (\2\:n8 \4\:n8) resistor r=0.613 c=0
Rk15 (\2\:n10 \4\:n10) resistor r=0.3049 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.6601 c=0
Rk39 (\15\:CKb \16\:CKb) resistor r=0.302 c=0
Rk40 (\16\:CKb \17\:CKb) resistor r=0.4743 c=0
Rk41 (\17\:CKb \18\:CKb) resistor r=0.9474 c=0
Rk42 (\16\:CKb \19\:CKb) resistor r=0.3363 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.03275 c=0
Rk44 (\17\:CKb \21\:CKb) resistor r=0.05544 c=0
Rk45 (\19\:CKb \23\:CKb) resistor r=0.4207 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2298 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.2759 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.3131 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.3646 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.08682 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1233 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1374 c=0
Rk37 (\8\:CKbb \9\:CKbb) resistor r=0.1548 c=0
Rk38 (\9\:CKbb \11\:CKbb) resistor r=0.2173 c=0
Rk24 (\2\:n4 \4\:n4) resistor r=0.5012 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.1221 c=0
Rk35 (\7\:n20 \8\:n20) resistor r=0.3813 c=0
Rk36 (\7\:n20 \10\:n20) resistor r=0.2062 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.3369 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.0737 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.627 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.409 c=0
Rk56 (\5\:SEb \6\:SEb) resistor r=0.09154 c=0
Rk57 (\6\:SEb \7\:SEb) resistor r=0.4471 c=0
Rk58 (\6\:SEb \9\:SEb) resistor r=0.4716 c=0
Rk14 (\2\:n11 \4\:n11) resistor r=0.4176 c=0
Rl42 (\1\:CK \2\:CK) resistor r=39.1533 c=0
Rl43 (\2\:CK \3\:CK) resistor r=144.923 c=0
Rl54 (\6\:SE \7\:SE) resistor r=170.604 c=0
Rl53 (\5\:SE \6\:SE) resistor r=51.9231 c=0
Rl50 (\3\:SE \4\:SE) resistor r=35.7134 c=0
Rl47 (\1\:SE \2\:SE) resistor r=71.8456 c=0
Rl29 (\4\:SN \5\:SN) resistor r=138.487 c=0
Rl30 (\5\:SN \6\:SN) resistor r=50.6918 c=0
Rl15 (\1\:SN \2\:SN) resistor r=31.461 c=0
Rl16 (\2\:SN \3\:SN) resistor r=104.538 c=0
Rl52 (\2\:SI \3\:SI) resistor r=109.066 c=0
Rl51 (\1\:SI \2\:SI) resistor r=113.462 c=0
Rl46 (\2\:D \4\:D) resistor r=106.794 c=0
Rl44 (\1\:D \2\:D) resistor r=178.614 c=0
Rl45 (\2\:D \3\:D) resistor r=5.487 c=0
Rl10 (\1\:RN \2\:RN) resistor r=54.5379 c=0
Rl11 (\2\:RN \3\:RN) resistor r=204.538 c=0
Rl1 (net573 \2\:net573) resistor r=5.915 c=0
Rl3 (\2\:net573 \4\:net573) resistor r=47.791 c=0
Rl2 (\2\:net573 \3\:net573) resistor r=36.2526 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=161.538 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=38.5707 c=0
Rl4 (qbint \2\:qbint) resistor r=124.847 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=36.3849 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=6.2575 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=150.199 c=0
Rl19 (RNb \2\:RNb) resistor r=264.95 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=136.906 c=0
Rl25 (\5\:RNb \6\:RNb) resistor r=114.898 c=0
Rl20 (\2\:RNb \3\:RNb) resistor r=43.4636 c=0
Rl12 (n35 \2\:n35) resistor r=1.2334 c=0
Rl14 (\2\:n35 \4\:n35) resistor r=100.803 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=50.8027 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=74.7951 c=0
Rl41 (\9\:CKb \11\:CKb) resistor r=33.4251 c=0
Rl40 (\9\:CKb \10\:CKb) resistor r=180.746 c=0
Rl33 (\6\:CKb \7\:CKb) resistor r=66.8866 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=53.3592 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=117.979 c=0
Rl21 (CKb \2\:CKb) resistor r=93.4636 c=0
Rl31 (mout \2\:mout) resistor r=39.6174 c=0
Rl32 (\2\:mout \3\:mout) resistor r=87.6944 c=0
Rl37 (\4\:CKbb \5\:CKbb) resistor r=147.208 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=695.72 c=0
Rl34 (CKbb \2\:CKbb) resistor r=70.8353 c=0
Rl35 (\2\:CKbb \3\:CKbb) resistor r=146.132 c=0
Rl38 (\2\:CKbb \6\:CKbb) resistor r=86.4638 c=0
Rl26 (n20 \2\:n20) resistor r=97.2294 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=37.614 c=0
Rl28 (\2\:n20 \4\:n20) resistor r=4.7568 c=0
Rl48 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=193.464 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz28 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz29 (\3\:VDD \6\:VDD) resistor r=25 c=0
Rz30 (\3\:VDD \8\:VDD) resistor r=18.75 c=0
Rz31 (\3\:VDD \10\:VDD) resistor r=37.5 c=0
Rz32 (\3\:VDD \12\:VDD) resistor r=6.25 c=0
Rz33 (\3\:VDD \16\:VDD) resistor r=8.3333 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz2 (\9\:net573 \10\:net573) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\5\:n35 \6\:n35) resistor r=75 c=0
Rz5 (n8 \2\:n8) resistor r=75 c=0
Rz6 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz7 (n10 \2\:n10) resistor r=75 c=0
Rz8 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz17 (\22\:CKb \23\:CKb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz16 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (n4 \2\:n4) resistor r=75 c=0
Rz12 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry26 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry27 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry28 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry29 (\30\:VDD \31\:VDD) resistor r=62 c=0
Ry30 (\32\:VDD \33\:VDD) resistor r=62 c=0
Ry17 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry18 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry19 (\3\:VSS \8\:VSS) resistor r=20.6667 c=0
Ry20 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry21 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net573 \6\:net573) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry13 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry12 (\7\:CKbb \8\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry5 (n11 \2\:n11) resistor r=62 c=0
Ry6 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx21 (\4\:SE \8\:SE) resistor r=45 c=0
Rx22 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\6\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx20 (\2\:SI \4\:SI) resistor r=45 c=0
Rx19 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (net573 \8\:net573) resistor r=45 c=0
Rx3 (\6\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \15\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (n35 \8\:n35) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx15 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx14 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx13 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net573 \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:net573 \4\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=2.03e-14 ps=8.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.00769e-07 sd=160n sca=11.5806 scb=0.0111274 \
        scc=0.000535497 m=(1)
mn22 (\12\:RNb \3\:RN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn45 (\13\:qbint \3\:n35 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.97e-14 ad=2.03e-14 ps=1.36e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn50 (n8 \3\:SN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=2.32e-14 ps=1.36e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.8e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=5.438e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.55e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn52 (\3\:n10 \9\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.438e-14 ps=6.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.75e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn53 (\5\:n35 CKb n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:n35 \4\:CKbb \14\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \4\:RNb \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.682e-14 ps=5.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn32 (\12\:mout \3\:n20 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=8.6e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn30 (n4 \4\:SN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (n6 \3\:mout \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=4.5e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn25 (\4\:Db \10\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn21 (\10\:CKbb \11\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.025e-14 ad=2.03e-14 ps=1.39e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn20 (\22\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.63793e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn11 (n0 \1\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.755e-14 ps=1.35e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01034e-07 sb=1.035e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.36034e-07 sb=8e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn14 (Db \3\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.41034e-07 sb=5.95e-07 sd=160n sca=10.2779 scb=0.00944477 \
        scc=0.000275883 m=(1)
mn13 (n2 \1\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=8.7e-15 ps=8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.46034e-07 sb=4.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\8\:SEb \5\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.755e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14603e-06 sb=1.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp56 (\5\:net573 \7\:qbint \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9828 \
        scb=0.0290392 scc=0.00588499 m=(1)
mp55 (\1\:Q qbint \30\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.51603e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp22 (\10\:RNb \1\:RN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp45 (\16\:qbint \4\:n35 \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp50 (\3\:n11 \1\:SN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=3.44e-14 ps=1.78e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.75e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp52 (\3\:n11 \8\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.7e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp51 (n9 \2\:RNb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.777e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.65e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp53 (\9\:n35 \5\:CKbb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.762e-14 ps=1.06e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.6e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\9\:n35 \5\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (n5 \5\:RNb \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=3.762e-14 ps=2.18e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59302e-07 sb=9.68605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp32 (\10\:mout n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.79302e-07 sb=7.48605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp30 (\10\:mout \5\:SN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.84302e-07 sb=5.43605e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp35 (n7 mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.675e-14 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.63953e-07 sb=4.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp36 (\9\:n20 \7\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.68953e-07 sb=3.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp25 (\9\:n20 CKbb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.73953e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp21 (\7\:CKbb \8\:CKb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.65e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp20 (\14\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.73e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26977e-07 sb=1.32e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp11 (n1 \4\:D \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.623e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.31977e-07 sb=1.115e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp12 (\6\:Db \1\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.44e-14 ps=8.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91977e-07 sb=8.55e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp14 (\6\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.96977e-07 sb=6.5e-07 sd=160n sca=10.7789 \
        scb=0.00808417 scc=0.000111767 m=(1)
mp13 (n3 \3\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.548e-14 ps=9.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00698e-06 sb=4.4e-07 sd=160n sca=11.6546 \
        scb=0.0086845 scc=0.000112508 m=(1)
mp10 (\4\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.30698e-06 sb=1.4e-07 sd=160n sca=16.2189 \
        scb=0.016045 scc=0.000282872 m=(1)
ends SDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:41:37 2012 )
// Library name: gsclib045
// Cell name: SDFFSRX2
// View name: extracted

simulator lang=spectre

subckt SDFFSRX2 CK D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.33372e-06 sd=160n sca=15.5538 \
        scb=0.0148381 scc=0.000219117 m=(1)
C1 (D VSS) capacitor c=3.73993e-17
C2 (Q VSS) capacitor c=1.71757e-17
C3 (RN VSS) capacitor c=8.4191e-17
C4 (SN VSS) capacitor c=7.3758e-17
C5 (QN VSS) capacitor c=3.66255e-17
C6 (CK VSS) capacitor c=5.19298e-17
C7 (SI VSS) capacitor c=1.15713e-16
C8 (VDD VSS) capacitor c=6.23204e-16
C9 (SEb VSS) capacitor c=5.327e-17
C10 (n2 VSS) capacitor c=1.45178e-18
C11 (Db VSS) capacitor c=9.67902e-17
C12 (n0 VSS) capacitor c=2.62602e-18
C13 (CKb VSS) capacitor c=5.98536e-17
C14 (CKbb VSS) capacitor c=3.43327e-17
C15 (n20 VSS) capacitor c=4.77704e-17
C16 (n6 VSS) capacitor c=2.27529e-18
C17 (mout VSS) capacitor c=5.70342e-17
C18 (n4 VSS) capacitor c=6.36092e-17
C19 (RNb VSS) capacitor c=1.02046e-16
C20 (n35 VSS) capacitor c=4.259e-17
C21 (n10 VSS) capacitor c=1.1598e-16
C22 (n8 VSS) capacitor c=8.5953e-17
C23 (qbint VSS) capacitor c=3.15112e-17
C24 (net573 VSS) capacitor c=1.63945e-16
C25 (n7 VSS) capacitor c=1.61783e-18
C26 (n5 VSS) capacitor c=8.79766e-19
C27 (n11 VSS) capacitor c=2.27545e-16
C28 (n9 VSS) capacitor c=3.4793e-17
C29 (\11\:qbint VSS) capacitor c=5.98915e-17
C30 (\5\:qbint VSS) capacitor c=4.13625e-16
C31 (\1\:RN VSS) capacitor c=3.41859e-17
C32 (\3\:n35 VSS) capacitor c=3.62457e-17
C33 (\6\:SN VSS) capacitor c=6.04821e-17
C34 (\3\:qbint VSS) capacitor c=6.0013e-17
C35 (\2\:RNb VSS) capacitor c=1.00168e-16
C36 (\5\:CKbb VSS) capacitor c=6.99516e-17
C37 (\8\:CKb VSS) capacitor c=3.61972e-17
C38 (\4\:RNb VSS) capacitor c=1.48623e-16
C39 (\3\:n20 VSS) capacitor c=7.21398e-17
C40 (\3\:SN VSS) capacitor c=3.54231e-17
C41 (\3\:mout VSS) capacitor c=5.95703e-17
C42 (\7\:CKb VSS) capacitor c=2.17352e-17
C43 (\1\:CK VSS) capacitor c=4.38249e-17
C44 (\1\:D VSS) capacitor c=7.98939e-17
C45 (\6\:SE VSS) capacitor c=6.34029e-17
C46 (\3\:SEb VSS) capacitor c=4.29563e-17
C47 (\1\:SI VSS) capacitor c=4.55402e-17
C48 (\1\:SE VSS) capacitor c=5.69556e-17
C49 (\12\:qbint VSS) capacitor c=2.34827e-17
C50 (\3\:RN VSS) capacitor c=4.65362e-17
C51 (\5\:SN VSS) capacitor c=8.42031e-17
C52 (\10\:CKb VSS) capacitor c=4.60905e-17
C53 (\6\:CKbb VSS) capacitor c=9.6545e-17
C54 (\6\:RNb VSS) capacitor c=6.47444e-17
C55 (\1\:SN VSS) capacitor c=2.74005e-17
C56 (\3\:CKbb VSS) capacitor c=5.19382e-17
C57 (\5\:CKb VSS) capacitor c=3.50896e-17
C58 (\6\:CKb VSS) capacitor c=1.15532e-17
C59 (\3\:CK VSS) capacitor c=1.90374e-17
C60 (\3\:D VSS) capacitor c=2.37634e-17
C61 (\4\:SE VSS) capacitor c=4.11813e-17
C62 (\3\:SI VSS) capacitor c=4.44822e-17
C63 (\3\:SE VSS) capacitor c=2.23696e-17
C64 (\13\:qbint VSS) capacitor c=1.88704e-17
C65 (\2\:RN VSS) capacitor c=3.08549e-17
C66 (\2\:n35 VSS) capacitor c=3.42505e-17
C67 (\4\:qbint VSS) capacitor c=2.79948e-17
C68 (\7\:SN VSS) capacitor c=2.95672e-17
C69 (\5\:RNb VSS) capacitor c=3.41256e-17
C70 (\11\:CKb VSS) capacitor c=3.34585e-17
C71 (\9\:CKb VSS) capacitor c=3.59203e-17
C72 (\2\:n20 VSS) capacitor c=4.65334e-17
C73 (\7\:CKbb VSS) capacitor c=6.5158e-17
C74 (\4\:SN VSS) capacitor c=2.33141e-17
C75 (\2\:SN VSS) capacitor c=3.59081e-17
C76 (\2\:mout VSS) capacitor c=6.24843e-17
C77 (\2\:CKb VSS) capacitor c=5.52801e-17
C78 (\4\:CKbb VSS) capacitor c=2.29833e-17
C79 (\2\:CKbb VSS) capacitor c=3.45275e-17
C80 (\4\:CKb VSS) capacitor c=2.22619e-17
C81 (\2\:CK VSS) capacitor c=3.87209e-17
C82 (\2\:D VSS) capacitor c=4.60246e-17
C83 (\7\:SE VSS) capacitor c=4.38716e-17
C84 (\2\:SEb VSS) capacitor c=6.67658e-17
C85 (\5\:SE VSS) capacitor c=5.05234e-17
C86 (\2\:SI VSS) capacitor c=5.73916e-17
C87 (\2\:SE VSS) capacitor c=5.18415e-17
C88 (\11\:net573 VSS) capacitor c=1.75278e-17
C89 (\1\:VDD VSS) capacitor c=2.13733e-16
C90 (\1\:QN VSS) capacitor c=7.95414e-17
C91 (\3\:Q VSS) capacitor c=7.75052e-17
C92 (\9\:RNb VSS) capacitor c=2.95669e-16
C93 (\23\:qbint VSS) capacitor c=8.6248e-17
C94 (\23\:VDD VSS) capacitor c=1.7024e-17
C95 (\25\:VDD VSS) capacitor c=3.34638e-17
C96 (\3\:n11 VSS) capacitor c=2.01047e-16
C97 (\8\:n35 VSS) capacitor c=4.0204e-17
C98 (\6\:mout VSS) capacitor c=7.44719e-17
C99 (\27\:VDD VSS) capacitor c=3.60098e-17
C100 (\13\:mout VSS) capacitor c=3.85392e-17
C101 (\29\:VDD VSS) capacitor c=1.22648e-17
C102 (\7\:n20 VSS) capacitor c=8.76533e-17
C103 (\7\:Db VSS) capacitor c=3.00114e-17
C104 (\12\:CKbb VSS) capacitor c=5.65851e-17
C105 (\31\:VDD VSS) capacitor c=2.15243e-17
C106 (\16\:CKb VSS) capacitor c=6.35419e-17
C107 (\33\:VDD VSS) capacitor c=4.57376e-17
C108 (\9\:Db VSS) capacitor c=1.99032e-17
C109 (\35\:VDD VSS) capacitor c=2.97879e-17
C110 (\8\:SEb VSS) capacitor c=1.39904e-17
C111 (\4\:VDD VSS) capacitor c=2.0462e-16
C112 (\7\:net573 VSS) capacitor c=1.89186e-17
C113 (\4\:QN VSS) capacitor c=2.88604e-17
C114 (\1\:Q VSS) capacitor c=8.04283e-17
C115 (\7\:RNb VSS) capacitor c=1.23182e-16
C116 (\17\:qbint VSS) capacitor c=6.2023e-17
C117 (\3\:n10 VSS) capacitor c=1.82759e-16
C118 (\3\:n8 VSS) capacitor c=7.89896e-17
C119 (\6\:n35 VSS) capacitor c=4.77462e-17
C120 (\4\:mout VSS) capacitor c=5.92606e-17
C121 (\11\:mout VSS) capacitor c=4.71259e-17
C122 (\3\:n4 VSS) capacitor c=8.10747e-17
C123 (\5\:n20 VSS) capacitor c=1.55085e-16
C124 (\10\:CKbb VSS) capacitor c=9.59326e-17
C125 (\14\:CKb VSS) capacitor c=5.70465e-17
C126 (\5\:Db VSS) capacitor c=1.15906e-16
C127 (\6\:SEb VSS) capacitor c=7.05261e-17
C128 (\3\:CKb VSS) capacitor c=4.29229e-17
C129 (\4\:SEb VSS) capacitor c=1.06507e-16
C130 (\5\:SEb VSS) capacitor c=9.7421e-17
C131 (\8\:SE VSS) capacitor c=1.62902e-16
C132 (\9\:SE VSS) capacitor c=1.32626e-16
C133 (\10\:SE VSS) capacitor c=2.53749e-17
C134 (\11\:SE VSS) capacitor c=6.70813e-17
C135 (\4\:D VSS) capacitor c=6.73796e-17
C136 (\3\:RNb VSS) capacitor c=8.11531e-17
C137 (\4\:CK VSS) capacitor c=6.34149e-17
C138 (\2\:qbint VSS) capacitor c=4.03071e-17
C139 (\12\:CKb VSS) capacitor c=3.34407e-17
C140 (\13\:CKb VSS) capacitor c=7.73009e-17
C141 (\3\:Db VSS) capacitor c=1.85824e-16
C142 (\4\:Db VSS) capacitor c=2.18928e-16
C143 (\8\:SN VSS) capacitor c=5.14444e-17
C144 (\8\:CKbb VSS) capacitor c=9.67881e-17
C145 (\9\:CKbb VSS) capacitor c=6.98304e-17
C146 (\14\:CKbb VSS) capacitor c=7.35329e-17
C147 (\15\:CKbb VSS) capacitor c=1.06033e-16
C148 (\4\:n20 VSS) capacitor c=1.12692e-16
C149 (\8\:mout VSS) capacitor c=8.12716e-17
C150 (\9\:mout VSS) capacitor c=6.06445e-17
C151 (\10\:mout VSS) capacitor c=6.17736e-17
C152 (\18\:CKb VSS) capacitor c=7.89317e-17
C153 (\19\:CKb VSS) capacitor c=3.3579e-16
C154 (\20\:CKb VSS) capacitor c=2.62054e-16
C155 (\9\:SN VSS) capacitor c=3.15902e-16
C156 (\10\:SN VSS) capacitor c=3.10106e-16
C157 (\4\:n35 VSS) capacitor c=2.5951e-16
C158 (\5\:n35 VSS) capacitor c=2.18577e-16
C159 (\11\:RNb VSS) capacitor c=3.35608e-16
C160 (\4\:RN VSS) capacitor c=3.33139e-17
C161 (\3\:QN VSS) capacitor c=2.88391e-17
C162 (\14\:qbint VSS) capacitor c=8.23725e-17
C163 (\19\:qbint VSS) capacitor c=7.26782e-17
C164 (\20\:qbint VSS) capacitor c=7.77246e-17
C165 (\9\:net573 VSS) capacitor c=3.34041e-17
C166 (\10\:net573 VSS) capacitor c=3.4313e-17
C167 (\9\:VDD VSS) capacitor c=3.17696e-17
C168 (\11\:VDD VSS) capacitor c=2.72288e-17
C169 (\12\:VDD VSS) capacitor c=2.55727e-17
C170 (\14\:VDD VSS) capacitor c=1.71067e-17
C171 (\15\:VDD VSS) capacitor c=2.09245e-17
C172 (\17\:VDD VSS) capacitor c=1.95075e-17
Rk9 (D \4\:D) resistor r=0.113 c=0
Rk47 (\4\:Q Q) resistor r=0.02395 c=0
Rk46 (\2\:Q \4\:Q) resistor r=0.3149 c=0
Rk45 (\4\:RN RN) resistor r=0.04718 c=0
Rk19 (\8\:SN SN) resistor r=0.09513 c=0
Rk38 (\9\:SN \10\:SN) resistor r=2.4258 c=0
Rk49 (\3\:QN QN) resistor r=0.1123 c=0
Rk48 (\2\:QN \3\:QN) resistor r=0.313 c=0
Rk50 (\3\:QN \5\:QN) resistor r=0.07591 c=0
Rk65 (\1\:VSS \7\:VSS) resistor r=0.2496 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.1428 c=0
Rk67 (\8\:VSS \9\:VSS) resistor r=1.0606 c=0
Rk68 (\9\:VSS \10\:VSS) resistor r=0.8214 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.38 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.238 c=0
Rk71 (\12\:VSS \13\:VSS) resistor r=0.3758 c=0
Rk72 (\13\:VSS \14\:VSS) resistor r=0.238 c=0
Rk73 (\14\:VSS \15\:VSS) resistor r=0.2581 c=0
Rk75 (\16\:VSS VSS) resistor r=0.04991 c=0
Rk74 (\15\:VSS \16\:VSS) resistor r=0.09259 c=0
Rk78 (\8\:VSS \22\:VSS) resistor r=0.3207 c=0
Rk79 (\10\:VSS \24\:VSS) resistor r=0.04331 c=0
Rk80 (\12\:VSS \26\:VSS) resistor r=0.3646 c=0
Rk81 (\13\:VSS \28\:VSS) resistor r=0.2546 c=0
Rk82 (\15\:VSS \30\:VSS) resistor r=0.2456 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.1035 c=0
Rk6 (\9\:SE \10\:SE) resistor r=0.08682 c=0
Rk8 (\11\:SE SE) resistor r=0.003332 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.2808 c=0
Rk10 (CK \4\:CK) resistor r=0.1441 c=0
Rk1 (SI \4\:SI) resistor r=0.004474 c=0
Rk86 (\1\:VDD \7\:VDD) resistor r=0.4861 c=0
Rk87 (\7\:VDD \8\:VDD) resistor r=0.3308 c=0
Rk88 (\8\:VDD \9\:VDD) resistor r=0.4036 c=0
Rk89 (\9\:VDD \10\:VDD) resistor r=0.549 c=0
Rk90 (\10\:VDD \11\:VDD) resistor r=0.1453 c=0
Rk91 (\11\:VDD \12\:VDD) resistor r=0.4184 c=0
Rk92 (\12\:VDD \13\:VDD) resistor r=0.2882 c=0
Rk93 (\13\:VDD \14\:VDD) resistor r=0.2446 c=0
Rk94 (\14\:VDD \15\:VDD) resistor r=0.3698 c=0
Rk95 (\15\:VDD \16\:VDD) resistor r=0.08507 c=0
Rk96 (\16\:VDD \17\:VDD) resistor r=0.4312 c=0
Rk98 (\18\:VDD VDD) resistor r=0.04991 c=0
Rk97 (\17\:VDD \18\:VDD) resistor r=0.1202 c=0
Rk101 (\7\:VDD \24\:VDD) resistor r=0.1026 c=0
Rk102 (\9\:VDD \26\:VDD) resistor r=0.1528 c=0
Rk103 (\11\:VDD \28\:VDD) resistor r=0.1528 c=0
Rk104 (\12\:VDD \30\:VDD) resistor r=0.07393 c=0
Rk105 (\14\:VDD \32\:VDD) resistor r=0.04331 c=0
Rk106 (\15\:VDD \34\:VDD) resistor r=0.2313 c=0
Rk107 (\17\:VDD \36\:VDD) resistor r=0.1942 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.6909 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.6223 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04795 c=0
Rk14 (\2\:Db \3\:Db) resistor r=0.4897 c=0
Rk15 (\3\:Db \4\:Db) resistor r=1.3038 c=0
Rk16 (\4\:Db \6\:Db) resistor r=0.659 c=0
Rk17 (\3\:Db \8\:Db) resistor r=0.02078 c=0
Rk18 (\4\:Db \10\:Db) resistor r=0.104 c=0
Rk11 (\12\:CKb \13\:CKb) resistor r=0.2395 c=0
Rk12 (\13\:CKb \15\:CKb) resistor r=0.3468 c=0
Rk13 (\13\:CKb \17\:CKb) resistor r=0.3414 c=0
Rk34 (\18\:CKb \19\:CKb) resistor r=0.5865 c=0
Rk35 (\19\:CKb \20\:CKb) resistor r=1.9267 c=0
Rk20 (\8\:CKbb \9\:CKbb) resistor r=0.4919 c=0
Rk21 (\9\:CKbb \11\:CKbb) resistor r=0.4177 c=0
Rk22 (\11\:CKbb \13\:CKbb) resistor r=0.2974 c=0
Rk23 (\9\:CKbb \14\:CKbb) resistor r=0.09434 c=0
Rk24 (\14\:CKbb \15\:CKbb) resistor r=0.6992 c=0
Rk25 (\4\:n20 \6\:n20) resistor r=0.866 c=0
Rk26 (\6\:n20 \8\:n20) resistor r=0.4885 c=0
Rk28 (\5\:mout \7\:mout) resistor r=0.3297 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3395 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.4478 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.2513 c=0
Rk32 (\8\:mout \12\:mout) resistor r=0.2652 c=0
Rk33 (\9\:mout \14\:mout) resistor r=0.08669 c=0
Rk27 (\2\:n4 \4\:n4) resistor r=0.4641 c=0
Rk43 (\8\:RNb \10\:RNb) resistor r=0.7754 c=0
Rk44 (\10\:RNb \11\:RNb) resistor r=2.0913 c=0
Rk40 (\4\:n35 \5\:n35) resistor r=1.7333 c=0
Rk41 (\5\:n35 \7\:n35) resistor r=0.2304 c=0
Rk42 (\5\:n35 \9\:n35) resistor r=0.126 c=0
Rk37 (\2\:n10 \4\:n10) resistor r=1.2491 c=0
Rk39 (\2\:n8 \4\:n8) resistor r=0.382 c=0
Rk51 (\14\:qbint \5\:qbint) resistor r=0.6163 c=0
Rk53 (\5\:qbint \18\:qbint) resistor r=0.5127 c=0
Rk54 (\18\:qbint \19\:qbint) resistor r=0.1495 c=0
Rk55 (\19\:qbint \20\:qbint) resistor r=0.3442 c=0
Rk58 (\19\:qbint \24\:qbint) resistor r=0.3679 c=0
Rk59 (\8\:net573 \9\:net573) resistor r=0.2324 c=0
Rk60 (\9\:net573 \10\:net573) resistor r=0.1482 c=0
Rk61 (\9\:net573 \12\:net573) resistor r=0.1545 c=0
Rk36 (\2\:n11 \4\:n11) resistor r=1.2651 c=0
Rl9 (\1\:D \2\:D) resistor r=189.617 c=0
Rl10 (\2\:D \3\:D) resistor r=55.0021 c=0
Rl44 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl45 (\2\:RN \3\:RN) resistor r=110.307 c=0
Rl40 (\5\:SN \6\:SN) resistor r=207.258 c=0
Rl41 (\6\:SN \7\:SN) resistor r=59.5926 c=0
Rl25 (\3\:SN \4\:SN) resistor r=50.6918 c=0
Rl24 (\2\:SN \3\:SN) resistor r=112.333 c=0
Rl23 (\1\:SN \2\:SN) resistor r=36.5385 c=0
Rl8 (\6\:SE \7\:SE) resistor r=71.8456 c=0
Rl5 (\4\:SE \5\:SE) resistor r=29.5379 c=0
Rl1 (\1\:SE \2\:SE) resistor r=226.923 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl11 (\1\:CK \2\:CK) resistor r=209.615 c=0
Rl12 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl3 (\1\:SI \2\:SI) resistor r=131.461 c=0
Rl4 (\2\:SI \3\:SI) resistor r=133.384 c=0
Rl6 (SEb \2\:SEb) resistor r=164.939 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=131.925 c=0
Rl31 (\10\:CKb \11\:CKb) resistor r=81.408 c=0
Rl28 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl15 (CKb \2\:CKb) resistor r=74.2328 c=0
Rl20 (\4\:CKb \7\:CKb) resistor r=32.4874 c=0
Rl19 (\4\:CKb \6\:CKb) resistor r=24.7951 c=0
Rl18 (\3\:CKb \5\:CKb) resistor r=76.6046 c=0
Rl16 (\2\:CKb \3\:CKb) resistor r=111.505 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=173.466 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=170.285 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=445.667 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=61.106 c=0
Rl13 (CKbb \2\:CKbb) resistor r=31.461 c=0
Rl26 (n20 \2\:n20) resistor r=69.7702 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=110.771 c=0
Rl21 (mout \2\:mout) resistor r=120.387 c=0
Rl22 (\2\:mout \3\:mout) resistor r=59.1695 c=0
Rl32 (RNb \2\:RNb) resistor r=505.335 c=0
Rl36 (\4\:RNb \6\:RNb) resistor r=266.873 c=0
Rl33 (\2\:RNb \3\:RNb) resistor r=255.747 c=0
Rl34 (\3\:RNb \4\:RNb) resistor r=649.978 c=0
Rl35 (\3\:RNb \5\:RNb) resistor r=154.219 c=0
Rl42 (n35 \2\:n35) resistor r=84.3311 c=0
Rl43 (\2\:n35 \3\:n35) resistor r=24.2328 c=0
Rl55 (\12\:qbint \11\:qbint) resistor r=141.873 c=0
Rl56 (\13\:qbint \12\:qbint) resistor r=29.5379 c=0
Rl37 (\2\:qbint qbint) resistor r=24.4619 c=0
Rl38 (\2\:qbint \3\:qbint) resistor r=149.075 c=0
Rl39 (\2\:qbint \4\:qbint) resistor r=4.5402 c=0
Rz17 (\2\:Q \1\:Q) resistor r=75 c=0
Rz18 (\5\:QN \4\:QN) resistor r=75 c=0
Rz24 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz25 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz26 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz27 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz28 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz29 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz30 (\8\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz31 (\10\:VDD \4\:VDD) resistor r=6.25 c=0
Rz32 (\13\:VDD \4\:VDD) resistor r=15 c=0
Rz33 (\16\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz34 (\18\:VDD \4\:VDD) resistor r=37.5 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\5\:Db \6\:Db) resistor r=75 c=0
Rz2 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz5 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz9 (\4\:mout \5\:mout) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz7 (n4 \2\:n4) resistor r=75 c=0
Rz8 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz16 (\7\:RNb \8\:RNb) resistor r=75 c=0
Rz15 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz11 (n10 \2\:n10) resistor r=75 c=0
Rz12 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz13 (n8 \2\:n8) resistor r=75 c=0
Rz14 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz19 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz20 (\8\:net573 \7\:net573) resistor r=75 c=0
Ry13 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry14 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry18 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry21 (\14\:VSS \3\:VSS) resistor r=12.4 c=0
Ry22 (\16\:VSS \3\:VSS) resistor r=31 c=0
Ry26 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry27 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry28 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry30 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry31 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry32 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry4 (\9\:Db \10\:Db) resistor r=62 c=0
Ry2 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry5 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry6 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry7 (\6\:mout \7\:mout) resistor r=62 c=0
Ry8 (\13\:mout \14\:mout) resistor r=62 c=0
Ry12 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry11 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry15 (\24\:qbint \23\:qbint) resistor r=31 c=0
Ry16 (\12\:net573 \11\:net573) resistor r=62 c=0
Ry9 (n11 \2\:n11) resistor r=62 c=0
Ry10 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx22 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\2\:SN \8\:SN) resistor r=45 c=0
Rx18 (\7\:SN \9\:SN) resistor r=45 c=0
Rx19 (\4\:SN \10\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SE \11\:SE) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\11\:CKb \18\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\2\:CKbb \8\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\7\:CKbb \15\:CKbb) resistor r=45 c=0
Rx13 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx14 (\2\:mout \10\:mout) resistor r=45 c=0
Rx21 (\5\:RNb \11\:RNb) resistor r=45 c=0
Rx20 (\2\:n35 \4\:n35) resistor r=45 c=0
Rx23 (\14\:qbint \13\:qbint) resistor r=45 c=0
Rx24 (\20\:qbint \4\:qbint) resistor r=45 c=0
Rx27 (\10\:net573 net573) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.465e-14 ps=7.2e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.52e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn13 (n2 \3\:SI \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.682e-14 ps=7.2e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.26e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn14 (\5\:Db \4\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.03e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn11 (n0 \3\:D \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=3.625e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=5.3e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn12 (\5\:Db SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=8.25e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn20 (\14\:CKb \3\:CK \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn21 (\10\:CKbb \6\:CKb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.683e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (Db \5\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=2.61e-14 ps=8.2e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.64e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.843e-14 ps=5.6e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.33e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n6 mout \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=1.958e-14 ps=1.44e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.15e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\3\:n4 \1\:SN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=7.177e-14 ps=1.44e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=8.85e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn32 (\11\:mout n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.177e-14 ad=2.32e-14 ps=1.28e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\6\:n35 \6\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn53 (\6\:n35 \10\:CKb n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.538e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.538e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=5.75e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n8 \5\:SN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.7e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn45 (\17\:qbint n35 \21\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=3.383e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.73902e-07 sb=1.65e-07 sd=160n sca=15.5643 \
        scb=0.0161016 scc=0.00117276 m=(1)
mn22 (\7\:RNb \3\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.91e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (\1\:Q \5\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.735e-14 ad=5.85e-14 ps=1.61e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.16606e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\4\:QN net573 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.273e-14 ad=7.41e-14 ps=1.6e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.71635e-07 sb=6.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\7\:net573 \12\:qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp13 (n3 \1\:SI \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.02e-14 ps=7.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.12872e-06 sd=160n sca=11.9632 \
        scb=0.00880681 scc=7.89905e-05 m=(1)
mp14 (\9\:Db \3\:SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=5.405e-14 ps=9.9e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.03721e-07 sd=160n sca=10.3677 \
        scb=0.00742953 scc=7.53776e-05 m=(1)
mp12 (\9\:Db \6\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.405e-14 ps=5.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.95814e-07 sb=6.8e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (n1 \1\:D \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=1.29e-14 ps=1.21e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.00814e-07 sb=5.75e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp20 (\16\:CKb \1\:CK \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33581e-06 sb=1.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp21 (\12\:CKbb \7\:CKb \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.565e-14 ad=2.63e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\7\:n20 CKbb \7\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.63e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.2414e-06 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp36 (\7\:n20 CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.77326e-07 sb=9.86395e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp35 (n7 \3\:mout \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.745e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.82326e-07 sb=8.81395e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp30 (\13\:mout \3\:SN \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.745e-14 ad=7.74e-14 ps=1.7e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.96512e-07 sb=6.8e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp32 (\13\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.74e-14 ps=5.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10151e-06 sb=2.75e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp31 (n5 \4\:RNb \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.775e-14 ad=1.29e-14 ps=1.29e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20651e-06 sb=1.7e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\8\:n35 \8\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (\8\:n35 \5\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n9 \2\:RNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.765e-14 ad=2.0102e-13 ps=1.48e-06 pd=2.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.72e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp52 (n11 \3\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.0102e-13 ad=3.763e-14 ps=2.3e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=7.4e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n11 \6\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.267e-13 ad=3.763e-14 ps=1.94e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=5.2e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp45 (\23\:qbint \3\:n35 \23\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.267e-13 ad=6.2e-14 ps=1.94e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1925e-06 sb=2e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp22 (\9\:RNb \1\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09523e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.885e-14 ad=8.775e-14 ps=1.16e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=9.88846e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp57 (\1\:QN net573 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.154e-14 ad=6.24e-14 ps=1.185e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.70064e-07 sb=4.53846e-07 sd=160n sca=25.9986 \
        scb=0.0191329 scc=0.00277829 m=(2)
mp56 (\11\:net573 \11\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.11558e-06 sb=1.4e-07 sd=160n \
        sca=41.2633 scb=0.0315497 scc=0.00492372 m=(1)
ends SDFFSRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:42:14 2012 )
// Library name: gsclib045
// Cell name: SDFFSRX4
// View name: extracted

simulator lang=spectre

subckt SDFFSRX4 CK D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=15.5148 \
        scb=0.0148294 scc=0.000239375 m=(1)
C1 (D VSS) capacitor c=6.47211e-17
C2 (Q VSS) capacitor c=2.28643e-17
C3 (RN VSS) capacitor c=8.00946e-17
C4 (SN VSS) capacitor c=7.48731e-17
C5 (QN VSS) capacitor c=2.03516e-17
C6 (VDD VSS) capacitor c=5.69616e-16
C7 (CK VSS) capacitor c=4.61859e-17
C8 (SI VSS) capacitor c=7.84467e-17
C9 (SEb VSS) capacitor c=6.05881e-17
C10 (n2 VSS) capacitor c=8.64555e-20
C11 (Db VSS) capacitor c=7.14162e-17
C12 (n0 VSS) capacitor c=1.50135e-18
C13 (CKb VSS) capacitor c=2.59944e-17
C14 (n20 VSS) capacitor c=8.93015e-17
C15 (n6 VSS) capacitor c=1.8925e-18
C16 (CKbb VSS) capacitor c=3.23137e-17
C17 (mout VSS) capacitor c=8.54384e-17
C18 (RNb VSS) capacitor c=8.16429e-17
C19 (n4 VSS) capacitor c=9.5306e-17
C20 (n35 VSS) capacitor c=2.0706e-16
C21 (n10 VSS) capacitor c=8.26157e-17
C22 (n8 VSS) capacitor c=7.58589e-17
C23 (qbint VSS) capacitor c=8.56309e-17
C24 (net573 VSS) capacitor c=2.77381e-16
C25 (n1 VSS) capacitor c=1.86763e-18
C26 (n5 VSS) capacitor c=1.10865e-18
C27 (n11 VSS) capacitor c=9.0371e-17
C28 (\21\:qbint VSS) capacitor c=5.10664e-17
C29 (\4\:qbint VSS) capacitor c=2.45193e-16
C30 (\1\:SN VSS) capacitor c=8.69455e-17
C31 (\4\:RNb VSS) capacitor c=8.37661e-17
C32 (\6\:CKbb VSS) capacitor c=5.83312e-17
C33 (\9\:CKb VSS) capacitor c=1.20674e-16
C34 (\1\:RN VSS) capacitor c=4.6487e-17
C35 (\5\:SN VSS) capacitor c=4.71547e-17
C36 (\2\:n20 VSS) capacitor c=9.76454e-17
C37 (\5\:CKb VSS) capacitor c=2.76183e-17
C38 (\3\:CKb VSS) capacitor c=6.71575e-17
C39 (\3\:CKbb VSS) capacitor c=4.47979e-17
C40 (\1\:CK VSS) capacitor c=4.98119e-17
C41 (\1\:D VSS) capacitor c=7.51335e-17
C42 (\6\:SE VSS) capacitor c=4.6964e-17
C43 (\3\:SEb VSS) capacitor c=2.79677e-17
C44 (\1\:SI VSS) capacitor c=4.32431e-17
C45 (\1\:SE VSS) capacitor c=5.24581e-17
C46 (\19\:qbint VSS) capacitor c=3.46157e-17
C47 (\2\:SN VSS) capacitor c=1.96538e-16
C48 (\3\:qbint VSS) capacitor c=3.82657e-17
C49 (\6\:RNb VSS) capacitor c=3.9397e-17
C50 (\8\:CKb VSS) capacitor c=6.56013e-17
C51 (\4\:CKbb VSS) capacitor c=4.8137e-17
C52 (\3\:RN VSS) capacitor c=3.48563e-17
C53 (\3\:SN VSS) capacitor c=1.21228e-16
C54 (\2\:RNb VSS) capacitor c=4.40791e-17
C55 (\7\:CKb VSS) capacitor c=3.38927e-17
C56 (\2\:mout VSS) capacitor c=5.09327e-17
C57 (\3\:CK VSS) capacitor c=2.68606e-17
C58 (\3\:D VSS) capacitor c=2.70749e-17
C59 (\4\:SE VSS) capacitor c=6.07727e-17
C60 (\3\:SI VSS) capacitor c=7.77214e-17
C61 (\3\:SE VSS) capacitor c=2.78507e-17
C62 (\20\:qbint VSS) capacitor c=4.36094e-17
C63 (\2\:qbint VSS) capacitor c=7.1391e-17
C64 (\5\:RNb VSS) capacitor c=6.06721e-17
C65 (\7\:CKbb VSS) capacitor c=2.23884e-17
C66 (\5\:CKbb VSS) capacitor c=3.78776e-17
C67 (\2\:RN VSS) capacitor c=2.46507e-17
C68 (\4\:SN VSS) capacitor c=3.41326e-17
C69 (\10\:CKb VSS) capacitor c=7.80492e-17
C70 (\3\:RNb VSS) capacitor c=3.07495e-17
C71 (\3\:n20 VSS) capacitor c=4.08271e-17
C72 (\6\:CKb VSS) capacitor c=2.13743e-17
C73 (\3\:mout VSS) capacitor c=2.77928e-17
C74 (\2\:CKbb VSS) capacitor c=6.09895e-17
C75 (\4\:CKb VSS) capacitor c=4.66751e-17
C76 (\2\:CKb VSS) capacitor c=1.75975e-17
C77 (\2\:CK VSS) capacitor c=3.74786e-17
C78 (\2\:D VSS) capacitor c=5.19264e-17
C79 (\7\:SE VSS) capacitor c=4.92536e-17
C80 (\2\:SEb VSS) capacitor c=7.36379e-17
C81 (\5\:SE VSS) capacitor c=3.84573e-17
C82 (\2\:SI VSS) capacitor c=5.6181e-17
C83 (\2\:SE VSS) capacitor c=4.51569e-17
C84 (\18\:net573 VSS) capacitor c=4.09932e-17
C85 (\1\:Q VSS) capacitor c=1.3978e-16
C86 (\27\:qbint VSS) capacitor c=7.09261e-17
C87 (\3\:n11 VSS) capacitor c=1.05622e-16
C88 (\32\:VDD VSS) capacitor c=2.80012e-17
C89 (\12\:n35 VSS) capacitor c=3.83246e-17
C90 (\6\:mout VSS) capacitor c=1.83208e-16
C91 (\11\:RNb VSS) capacitor c=9.67403e-17
C92 (\34\:VDD VSS) capacitor c=5.65658e-17
C93 (\8\:mout VSS) capacitor c=2.31847e-16
C94 (\36\:VDD VSS) capacitor c=3.17354e-17
C95 (\10\:CKbb VSS) capacitor c=2.70865e-16
C96 (\38\:VDD VSS) capacitor c=1.89052e-17
C97 (\5\:n20 VSS) capacitor c=1.56779e-16
C98 (\3\:Db VSS) capacitor c=1.83919e-16
C99 (\18\:CKb VSS) capacitor c=1.13125e-16
C100 (\40\:VDD VSS) capacitor c=4.87837e-17
C101 (\8\:Db VSS) capacitor c=1.07923e-17
C102 (\42\:VDD VSS) capacitor c=3.36518e-17
C103 (\8\:SEb VSS) capacitor c=1.3122e-17
C104 (\1\:VDD VSS) capacitor c=1.55823e-16
C105 (\14\:net573 VSS) capacitor c=3.33941e-17
C106 (\1\:QN VSS) capacitor c=1.22721e-16
C107 (\30\:qbint VSS) capacitor c=2.03371e-17
C108 (\3\:n8 VSS) capacitor c=8.93363e-17
C109 (\3\:n10 VSS) capacitor c=8.22563e-17
C110 (\10\:n35 VSS) capacitor c=5.78596e-17
C111 (\4\:mout VSS) capacitor c=9.8782e-17
C112 (\8\:RNb VSS) capacitor c=2.22961e-16
C113 (\12\:mout VSS) capacitor c=1.12194e-16
C114 (\3\:n4 VSS) capacitor c=1.02422e-16
C115 (\12\:CKbb VSS) capacitor c=9.52932e-17
C116 (\7\:n20 VSS) capacitor c=1.09217e-16
C117 (\15\:CKb VSS) capacitor c=1.26835e-16
C118 (\6\:Db VSS) capacitor c=1.03462e-16
C119 (\6\:SEb VSS) capacitor c=6.91378e-17
C120 (\4\:SI VSS) capacitor c=4.89804e-17
C121 (\4\:SEb VSS) capacitor c=6.54551e-17
C122 (\5\:SEb VSS) capacitor c=1.10112e-16
C123 (\8\:SE VSS) capacitor c=1.59136e-16
C124 (\9\:SE VSS) capacitor c=1.31798e-16
C125 (\10\:SE VSS) capacitor c=4.02144e-17
C126 (\4\:D VSS) capacitor c=5.69164e-17
C127 (\4\:CK VSS) capacitor c=6.43667e-17
C128 (\5\:Db VSS) capacitor c=1.8252e-16
C129 (\4\:n20 VSS) capacitor c=1.2377e-16
C130 (\11\:CKb VSS) capacitor c=1.46779e-16
C131 (\12\:CKb VSS) capacitor c=1.79386e-16
C132 (\13\:CKb VSS) capacitor c=1.25567e-16
C133 (\14\:CKb VSS) capacitor c=9.26022e-17
C134 (\17\:CKb VSS) capacitor c=4.09438e-17
C135 (\6\:SN VSS) capacitor c=3.74393e-17
C136 (\4\:RN VSS) capacitor c=3.66143e-17
C137 (\10\:mout VSS) capacitor c=1.90152e-16
C138 (\11\:mout VSS) capacitor c=6.33349e-17
C139 (\8\:CKbb VSS) capacitor c=2.32861e-17
C140 (\9\:CKbb VSS) capacitor c=2.42823e-16
C141 (\14\:CKbb VSS) capacitor c=7.63129e-17
C142 (\15\:CKbb VSS) capacitor c=9.24275e-17
C143 (\7\:RNb VSS) capacitor c=2.1181e-16
C144 (\10\:RNb VSS) capacitor c=1.12599e-16
C145 (\8\:n35 VSS) capacitor c=1.42418e-16
C146 (\9\:n35 VSS) capacitor c=1.71026e-16
C147 (\4\:Q VSS) capacitor c=1.21356e-16
C148 (\5\:QN VSS) capacitor c=1.57208e-16
C149 (\22\:qbint VSS) capacitor c=2.16658e-17
C150 (\23\:qbint VSS) capacitor c=2.88311e-17
C151 (\24\:qbint VSS) capacitor c=2.02613e-16
C152 (\25\:qbint VSS) capacitor c=2.8118e-17
C153 (\26\:qbint VSS) capacitor c=5.52285e-17
C154 (\29\:qbint VSS) capacitor c=2.51856e-16
C155 (\16\:net573 VSS) capacitor c=4.90653e-17
C156 (\17\:net573 VSS) capacitor c=3.11415e-17
C157 (\3\:VDD VSS) capacitor c=4.32378e-16
C158 (\10\:VDD VSS) capacitor c=8.96882e-18
C159 (\12\:VDD VSS) capacitor c=3.26913e-17
C160 (\14\:VDD VSS) capacitor c=9.45433e-18
C161 (\15\:VDD VSS) capacitor c=4.60929e-17
C162 (\16\:VDD VSS) capacitor c=3.43992e-17
C163 (\18\:VDD VSS) capacitor c=1.96372e-17
Rk8 (D \4\:D) resistor r=0.1227 c=0
Rk45 (\1\:Q Q) resistor r=0.03643 c=0
Rk46 (Q \4\:Q) resistor r=0.2361 c=0
Rk24 (RN \4\:RN) resistor r=0.1816 c=0
Rk23 (\6\:SN SN) resistor r=0.1618 c=0
Rk51 (\1\:QN QN) resistor r=0.2277 c=0
Rk52 (QN \5\:QN) resistor r=0.001585 c=0
Rk6 (SE \9\:SE) resistor r=0.004389 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.0585 c=0
Rk7 (\9\:SE \10\:SE) resistor r=0.2531 c=0
Rk91 (\2\:VDD \3\:VDD) resistor r=0.0901 c=0
Rk98 (\3\:VDD \10\:VDD) resistor r=0.258 c=0
Rk99 (\10\:VDD \11\:VDD) resistor r=0.3384 c=0
Rk100 (\11\:VDD \12\:VDD) resistor r=0.519 c=0
Rk101 (\12\:VDD \13\:VDD) resistor r=0.4337 c=0
Rk102 (\13\:VDD \14\:VDD) resistor r=0.1167 c=0
Rk103 (\14\:VDD \15\:VDD) resistor r=0.241 c=0
Rk104 (\15\:VDD \16\:VDD) resistor r=0.7787 c=0
Rk105 (\16\:VDD \17\:VDD) resistor r=0.06251 c=0
Rk107 (\18\:VDD VDD) resistor r=0.1801 c=0
Rk106 (\17\:VDD \18\:VDD) resistor r=0.371 c=0
Rk115 (\10\:VDD \33\:VDD) resistor r=0.2915 c=0
Rk116 (\12\:VDD \35\:VDD) resistor r=0.2251 c=0
Rk117 (\14\:VDD \37\:VDD) resistor r=0.04332 c=0
Rk118 (\15\:VDD \39\:VDD) resistor r=0.04332 c=0
Rk119 (\16\:VDD \41\:VDD) resistor r=0.2548 c=0
Rk120 (\18\:VDD \43\:VDD) resistor r=0.2547 c=0
Rk9 (CK \4\:CK) resistor r=0.1328 c=0
Rk1 (\4\:SI SI) resistor r=0.154 c=0
Rk66 (\2\:VSS \3\:VSS) resistor r=0.09763 c=0
Rk73 (\3\:VSS \10\:VSS) resistor r=0.4488 c=0
Rk74 (\10\:VSS \11\:VSS) resistor r=0.6118 c=0
Rk75 (\11\:VSS \12\:VSS) resistor r=0.4413 c=0
Rk76 (\12\:VSS \13\:VSS) resistor r=0.335 c=0
Rk77 (\13\:VSS \14\:VSS) resistor r=0.8264 c=0
Rk78 (\14\:VSS \15\:VSS) resistor r=0.03994 c=0
Rk80 (\16\:VSS VSS) resistor r=0.1801 c=0
Rk79 (\15\:VSS \16\:VSS) resistor r=0.371 c=0
Rk87 (\11\:VSS \30\:VSS) resistor r=0.1556 c=0
Rk88 (\13\:VSS \32\:VSS) resistor r=0.04332 c=0
Rk89 (\14\:VSS \34\:VSS) resistor r=0.275 c=0
Rk90 (\16\:VSS \36\:VSS) resistor r=0.2826 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.4067 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.7053 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04804 c=0
Rk10 (\2\:Db \4\:Db) resistor r=0.3929 c=0
Rk11 (\4\:Db \5\:Db) resistor r=1.1804 c=0
Rk12 (\5\:Db \7\:Db) resistor r=0.5105 c=0
Rk13 (\5\:Db \9\:Db) resistor r=0.05432 c=0
Rk17 (\11\:CKb \12\:CKb) resistor r=1.2898 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.235 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.7351 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.526 c=0
Rk21 (\12\:CKb \17\:CKb) resistor r=0.1029 c=0
Rk22 (\16\:CKb \19\:CKb) resistor r=0.9206 c=0
Rk14 (\4\:n20 \6\:n20) resistor r=0.8652 c=0
Rk15 (\6\:n20 \8\:n20) resistor r=0.5988 c=0
Rk30 (\8\:CKbb \9\:CKbb) resistor r=0.1614 c=0
Rk31 (\9\:CKbb \11\:CKbb) resistor r=1.8079 c=0
Rk32 (\11\:CKbb \13\:CKbb) resistor r=0.308 c=0
Rk33 (\13\:CKbb \14\:CKbb) resistor r=0.4624 c=0
Rk34 (\9\:CKbb \15\:CKbb) resistor r=0.4432 c=0
Rk25 (\5\:mout \7\:mout) resistor r=0.5107 c=0
Rk26 (\7\:mout \9\:mout) resistor r=0.8841 c=0
Rk27 (\9\:mout \10\:mout) resistor r=0.8944 c=0
Rk28 (\10\:mout \11\:mout) resistor r=0.4681 c=0
Rk29 (\10\:mout \13\:mout) resistor r=0.6601 c=0
Rk35 (\7\:RNb \9\:RNb) resistor r=1.3897 c=0
Rk36 (\9\:RNb \10\:RNb) resistor r=0.7552 c=0
Rk37 (\9\:RNb \12\:RNb) resistor r=0.545 c=0
Rk16 (\2\:n4 \4\:n4) resistor r=0.6124 c=0
Rk41 (\8\:n35 \9\:n35) resistor r=0.9744 c=0
Rk42 (\9\:n35 \11\:n35) resistor r=0.2554 c=0
Rk43 (\9\:n35 \13\:n35) resistor r=0.1429 c=0
Rk38 (\2\:n10 \4\:n10) resistor r=0.3151 c=0
Rk39 (\2\:n8 \4\:n8) resistor r=0.53 c=0
Rk56 (\22\:qbint \23\:qbint) resistor r=0.2428 c=0
Rk57 (\23\:qbint \24\:qbint) resistor r=0.1091 c=0
Rk58 (\24\:qbint \25\:qbint) resistor r=0.08522 c=0
Rk59 (\25\:qbint \26\:qbint) resistor r=0.322 c=0
Rk60 (\23\:qbint \28\:qbint) resistor r=0.2748 c=0
Rk61 (\24\:qbint \29\:qbint) resistor r=1.9955 c=0
Rk62 (\25\:qbint \31\:qbint) resistor r=0.07481 c=0
Rk63 (\15\:net573 \16\:net573) resistor r=0.4161 c=0
Rk64 (\16\:net573 \17\:net573) resistor r=0.2032 c=0
Rk65 (\16\:net573 \19\:net573) resistor r=0.183 c=0
Rk40 (\2\:n11 \4\:n11) resistor r=0.6739 c=0
Rl9 (\1\:D \2\:D) resistor r=180.769 c=0
Rl10 (\2\:D \3\:D) resistor r=39.8352 c=0
Rl25 (\1\:RN \2\:RN) resistor r=95.3867 c=0
Rl26 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl35 (\1\:SN \2\:SN) resistor r=253.412 c=0
Rl36 (\2\:SN \3\:SN) resistor r=980.335 c=0
Rl38 (\4\:SN \5\:SN) resistor r=120.387 c=0
Rl37 (\3\:SN \4\:SN) resistor r=37.6944 c=0
Rl8 (\6\:SE \7\:SE) resistor r=66.5405 c=0
Rl5 (\4\:SE \5\:SE) resistor r=41.5405 c=0
Rl1 (\1\:SE \2\:SE) resistor r=179.538 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.1533 c=0
Rl11 (\1\:CK \2\:CK) resistor r=164.153 c=0
Rl12 (\2\:CK \3\:CK) resistor r=54.5379 c=0
Rl3 (\1\:SI \2\:SI) resistor r=69.9225 c=0
Rl4 (\2\:SI \3\:SI) resistor r=148.769 c=0
Rl6 (SEb \2\:SEb) resistor r=249.554 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=189.516 c=0
Rl30 (\9\:CKb \10\:CKb) resistor r=483.694 c=0
Rl19 (\5\:CKb \6\:CKb) resistor r=29.5379 c=0
Rl20 (\6\:CKb \7\:CKb) resistor r=58.3841 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=56.461 c=0
Rl23 (n20 \2\:n20) resistor r=201.489 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=224.513 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=41.5405 c=0
Rl27 (\4\:CKbb \5\:CKbb) resistor r=41.0764 c=0
Rl15 (CKbb \2\:CKbb) resistor r=26.098 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=137.708 c=0
Rl17 (mout \2\:mout) resistor r=153.846 c=0
Rl18 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl21 (RNb \2\:RNb) resistor r=186.538 c=0
Rl31 (\4\:RNb \5\:RNb) resistor r=192.285 c=0
Rl32 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl22 (\2\:RNb \3\:RNb) resistor r=40.8889 c=0
Rl72 (\20\:qbint \21\:qbint) resistor r=91.5405 c=0
Rl71 (\20\:qbint \19\:qbint) resistor r=94.5067 c=0
Rl33 (\2\:qbint qbint) resistor r=165.18 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=42.7285 c=0
Rz33 (\2\:VDD \1\:VDD) resistor r=15 c=0
Rz34 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz35 (\11\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz36 (\13\:VDD \1\:VDD) resistor r=6.25 c=0
Rz37 (\17\:VDD \1\:VDD) resistor r=6.25 c=0
Rz29 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\6\:Db \7\:Db) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz4 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\12\:mout \13\:mout) resistor r=75 c=0
Rz11 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz16 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz12 (n10 \2\:n10) resistor r=75 c=0
Rz13 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz14 (n8 \2\:n8) resistor r=75 c=0
Rz15 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz21 (\31\:qbint \30\:qbint) resistor r=75 c=0
Rz22 (\15\:net573 \14\:net573) resistor r=75 c=0
Ry33 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry34 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry35 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry36 (\39\:VDD \38\:VDD) resistor r=62 c=0
Ry37 (\41\:VDD \40\:VDD) resistor r=62 c=0
Ry38 (\43\:VDD \42\:VDD) resistor r=62 c=0
Ry20 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry22 (\3\:VSS \1\:VSS) resistor r=4.7692 c=0
Ry23 (\10\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry24 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry25 (\15\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\8\:Db \9\:Db) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry4 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry8 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry12 (\13\:n35 \12\:n35) resistor r=62 c=0
Ry18 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry19 (\19\:net573 \18\:net573) resistor r=20.6667 c=0
Ry10 (n11 \2\:n11) resistor r=62 c=0
Ry11 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:RN \4\:RN) resistor r=45 c=0
Rx13 (\4\:SN \6\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \9\:SE) resistor r=45 c=0
Rx5 (\2\:SE \10\:SE) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx9 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\3\:n20 \4\:n20) resistor r=45 c=0
Rx16 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx17 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx18 (\5\:CKbb \15\:CKbb) resistor r=45 c=0
Rx15 (\3\:mout \11\:mout) resistor r=45 c=0
Rx19 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx20 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx21 (\8\:n35 n35) resistor r=45 c=0
Rx22 (\22\:qbint \4\:qbint) resistor r=45 c=0
Rx23 (\26\:qbint \2\:qbint) resistor r=45 c=0
Rx24 (\29\:qbint \20\:qbint) resistor r=45 c=0
Rx25 (\17\:net573 net573) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (n2 \3\:SI \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.035e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (\6\:Db \4\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (\6\:Db SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=3.335e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (n0 \3\:D \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.755e-14 ps=7.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=4.2e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn20 (\15\:CKb \3\:CK \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.03e-14 ps=7.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn25 (Db CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=2.03e-14 ps=9.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=4.785e-14 ps=5.6e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n6 \2\:mout \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.135e-14 ad=1.957e-14 ps=1.7e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=4.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\12\:CKbb \7\:CKb \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.135e-14 ad=2.03e-14 ps=1.7e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \2\:RNb \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.712e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=9.3e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn32 (\12\:mout n20 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=7.25e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn30 (n4 \3\:SN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.837e-14 ad=2.9e-14 ps=1.14e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=4.8e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn22 (\8\:RNb \3\:RN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.837e-14 ad=2.03e-14 ps=1.14e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn40 (\10\:n35 \4\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn53 (\10\:n35 \8\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.697e-14 ad=2.755e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn51 (n10 \6\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.102e-14 ad=2.61e-14 ps=5.8e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn52 (n10 \3\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=2e-06 sd=160n sca=8.85152 scb=0.00706865 \
        scc=0.000138481 m=(1)
mn50 (n8 \2\:SN \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn45_1__rcx (\30\:qbint n35 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.169e-14 ad=3.28e-14 ps=9.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.80976e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(2)
mn55_1__rcx (\4\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.944e-14 ad=4.16e-14 ps=1.3175e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.40481e-07 sb=2e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mn57_1__rcx (\1\:QN net573 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.268e-14 ad=4.16e-14 ps=1.3175e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71038e-06 sb=1.195e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mn56 (\14\:net573 \19\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.71e-14 ad=3.64e-14 ps=1.19e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mp13 (n3 \1\:SI \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.21e-06 sd=160n sca=12.345 \
        scb=0.00962119 scc=0.000140637 m=(1)
mp14 (\8\:Db \3\:SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=6.558e-14 ps=7.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1e-06 sd=160n sca=11.205 scb=0.00858508 \
        scc=0.000138179 m=(1)
mp12 (\8\:Db \6\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=6.558e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=6.5e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp11 (n1 \1\:D \40\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=5.2e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp20 (\18\:CKb \1\:CK \40\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.773e-14 ps=7.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.15e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp25 (\5\:n20 \3\:CKbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=3.44e-14 ps=1.11e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=6.25814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\5\:n20 \3\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.20814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (n7 mout \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0065e-13 ad=1.29e-14 ps=1.89e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=3.15814e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp21 (\10\:CKbb \5\:CKb \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0065e-13 ad=3.01e-14 ps=1.89e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.42558e-07 sb=1.4e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp31 (n5 RNb \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6688e-13 ad=1.612e-14 ps=2.38e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=8.69767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp32 (\8\:mout \2\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=6.127e-14 ps=5.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=7.49767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp30 (\8\:mout \5\:SN \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.88e-14 ad=6.127e-14 ps=1.6e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=4.19767e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp22 (\11\:RNb \1\:RN \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.88e-14 ad=5.03e-14 ps=1.6e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.47674e-07 sb=2.33953e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\12\:n35 \9\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.01e-14 ad=3.5e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86512e-07 sb=3.27907e-07 sd=160n sca=16.925 \
        scb=0.0168124 scc=0.00121732 m=(1)
mp53 (\12\:n35 \6\:CKbb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.5e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.66395e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp51 (n9 \4\:RNb \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp52 (\3\:n11 qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (\3\:n11 \1\:SN \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp45 (\27\:qbint n35 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.245e-14 ad=4.96e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.84919e-07 sb=2e-06 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(2)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.595e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.43141e-07 sb=1.82e-06 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
mp57_1__rcx (\5\:QN net573 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66731e-06 sb=9.6e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
mp56 (\18\:net573 \21\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=27.206 \
        scb=0.0201058 scc=0.00278017 m=(1)
ends SDFFSRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:42:53 2012 )
// Library name: gsclib045
// Cell name: SDFFSRXL
// View name: extracted

simulator lang=spectre

subckt SDFFSRXL CK D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN net573 \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=49.954 \
        scb=0.0336165 scc=0.00594928 m=(1)
C1 (CK VSS) capacitor c=6.76626e-17
C2 (QN VSS) capacitor c=1.78866e-17
C3 (SN VSS) capacitor c=3.0011e-16
C4 (SI VSS) capacitor c=9.22973e-17
C5 (VDD VSS) capacitor c=4.91947e-16
C6 (D VSS) capacitor c=3.04205e-17
C7 (Q VSS) capacitor c=4.66216e-17
C8 (RN VSS) capacitor c=1.34859e-16
C9 (net573 VSS) capacitor c=2.88286e-17
C10 (qbint VSS) capacitor c=4.41634e-17
C11 (RNb VSS) capacitor c=5.11923e-17
C12 (n35 VSS) capacitor c=4.28767e-17
C13 (n8 VSS) capacitor c=9.42104e-17
C14 (n10 VSS) capacitor c=7.14345e-17
C15 (CKb VSS) capacitor c=4.3894e-17
C16 (mout VSS) capacitor c=6.38907e-17
C17 (CKbb VSS) capacitor c=4.41982e-17
C18 (n4 VSS) capacitor c=7.05984e-17
C19 (n20 VSS) capacitor c=2.51124e-17
C20 (Db VSS) capacitor c=5.309e-17
C21 (n0 VSS) capacitor c=5.49257e-18
C22 (SEb VSS) capacitor c=4.42647e-17
C23 (n11 VSS) capacitor c=1.1781e-16
C24 (n9 VSS) capacitor c=1.57439e-18
C25 (n5 VSS) capacitor c=2.74777e-18
C26 (n1 VSS) capacitor c=5.46877e-18
C27 (\5\:SE VSS) capacitor c=4.97088e-17
C28 (\1\:SI VSS) capacitor c=6.06147e-17
C29 (\1\:SE VSS) capacitor c=4.40058e-17
C30 (\1\:D VSS) capacitor c=4.40382e-17
C31 (\1\:CK VSS) capacitor c=2.52373e-17
C32 (\8\:CKb VSS) capacitor c=2.27424e-17
C33 (\6\:CKbb VSS) capacitor c=3.66907e-17
C34 (\6\:CKb VSS) capacitor c=6.93572e-17
C35 (\4\:SN VSS) capacitor c=5.1581e-17
C36 (\4\:n20 VSS) capacitor c=5.25223e-17
C37 (\4\:RNb VSS) capacitor c=6.62334e-17
C38 (\5\:CKb VSS) capacitor c=3.40324e-17
C39 (\5\:CKbb VSS) capacitor c=7.29209e-17
C40 (\2\:RNb VSS) capacitor c=8.72081e-17
C41 (\7\:qbint VSS) capacitor c=9.47417e-17
C42 (\1\:SN VSS) capacitor c=4.24755e-17
C43 (\3\:RN VSS) capacitor c=3.16293e-17
C44 (\6\:qbint VSS) capacitor c=2.45633e-17
C45 (\7\:SE VSS) capacitor c=2.60063e-17
C46 (\3\:SI VSS) capacitor c=6.81752e-17
C47 (\3\:SE VSS) capacitor c=6.64949e-17
C48 (\3\:SEb VSS) capacitor c=7.2752e-17
C49 (\3\:D VSS) capacitor c=4.16639e-17
C50 (\3\:CK VSS) capacitor c=4.73909e-17
C51 (\11\:CKb VSS) capacitor c=2.22194e-17
C52 (\10\:CKb VSS) capacitor c=5.31575e-17
C53 (\3\:CKbb VSS) capacitor c=1.61678e-16
C54 (\3\:mout VSS) capacitor c=6.65653e-17
C55 (\6\:SN VSS) capacitor c=7.18318e-17
C56 (\3\:n20 VSS) capacitor c=3.80313e-17
C57 (\6\:RNb VSS) capacitor c=4.83087e-17
C58 (\4\:CKbb VSS) capacitor c=1.04621e-16
C59 (\8\:qbint VSS) capacitor c=4.44461e-17
C60 (\3\:SN VSS) capacitor c=5.91689e-17
C61 (\3\:n35 VSS) capacitor c=3.25603e-17
C62 (\1\:RN VSS) capacitor c=4.42976e-17
C63 (\5\:qbint VSS) capacitor c=1.64392e-17
C64 (\4\:qbint VSS) capacitor c=3.51253e-17
C65 (\3\:net573 VSS) capacitor c=3.82459e-17
C66 (\6\:SE VSS) capacitor c=4.48768e-17
C67 (\2\:SI VSS) capacitor c=6.57736e-17
C68 (\4\:SE VSS) capacitor c=4.86966e-17
C69 (\2\:SEb VSS) capacitor c=7.54358e-17
C70 (\2\:SE VSS) capacitor c=4.49832e-17
C71 (\2\:D VSS) capacitor c=4.62186e-17
C72 (\2\:CK VSS) capacitor c=3.58604e-17
C73 (\9\:CKb VSS) capacitor c=4.69925e-17
C74 (\7\:CKb VSS) capacitor c=2.84048e-17
C75 (\2\:mout VSS) capacitor c=5.47131e-17
C76 (\5\:SN VSS) capacitor c=3.20566e-17
C77 (\3\:CKb VSS) capacitor c=3.70856e-17
C78 (\5\:RNb VSS) capacitor c=2.15351e-17
C79 (\4\:CKb VSS) capacitor c=3.61929e-17
C80 (\2\:CKb VSS) capacitor c=3.32009e-17
C81 (\3\:RNb VSS) capacitor c=2.52123e-17
C82 (\9\:qbint VSS) capacitor c=2.69705e-17
C83 (\2\:SN VSS) capacitor c=4.03662e-17
C84 (\2\:n35 VSS) capacitor c=2.6499e-17
C85 (\2\:RN VSS) capacitor c=3.69779e-17
C86 (\2\:qbint VSS) capacitor c=3.96381e-17
C87 (\2\:net573 VSS) capacitor c=3.03972e-17
C88 (\4\:SEb VSS) capacitor c=1.22116e-17
C89 (\10\:VDD VSS) capacitor c=3.35202e-17
C90 (\6\:Db VSS) capacitor c=9.24151e-17
C91 (\12\:VDD VSS) capacitor c=4.1811e-17
C92 (\21\:CKb VSS) capacitor c=7.00154e-17
C93 (\14\:VDD VSS) capacitor c=3.80296e-17
C94 (\7\:CKbb VSS) capacitor c=5.00501e-17
C95 (\8\:Db VSS) capacitor c=8.12199e-17
C96 (\9\:n20 VSS) capacitor c=4.57994e-17
C97 (\16\:VDD VSS) capacitor c=1.38537e-17
C98 (\10\:mout VSS) capacitor c=3.63133e-17
C99 (\18\:VDD VSS) capacitor c=2.413e-17
C100 (\8\:mout VSS) capacitor c=7.27223e-17
C101 (\8\:n35 VSS) capacitor c=4.82856e-17
C102 (\21\:VDD VSS) capacitor c=2.44454e-17
C103 (\3\:n11 VSS) capacitor c=1.10114e-16
C104 (\25\:VDD VSS) capacitor c=1.30558e-17
C105 (\15\:qbint VSS) capacitor c=5.88381e-17
C106 (\10\:RNb VSS) capacitor c=3.25226e-17
C107 (\29\:VDD VSS) capacitor c=3.19775e-17
C108 (\1\:Q VSS) capacitor c=6.10655e-17
C109 (\4\:net573 VSS) capacitor c=3.0538e-17
C110 (\33\:VDD VSS) capacitor c=3.96408e-17
C111 (\1\:QN VSS) capacitor c=2.83686e-17
C112 (\1\:VDD VSS) capacitor c=2.24175e-16
C113 (\8\:SEb VSS) capacitor c=7.05741e-17
C114 (\14\:CKb VSS) capacitor c=4.60736e-17
C115 (\10\:CKbb VSS) capacitor c=6.00732e-17
C116 (\4\:Db VSS) capacitor c=1.75837e-16
C117 (\5\:n20 VSS) capacitor c=2.64689e-17
C118 (\12\:mout VSS) capacitor c=3.04994e-17
C119 (\3\:n4 VSS) capacitor c=7.69645e-17
C120 (\14\:mout VSS) capacitor c=4.46038e-17
C121 (\4\:n35 VSS) capacitor c=4.13576e-17
C122 (\3\:n8 VSS) capacitor c=8.17697e-17
C123 (\3\:n10 VSS) capacitor c=8.38387e-17
C124 (\12\:qbint VSS) capacitor c=4.99105e-17
C125 (\12\:RNb VSS) capacitor c=8.87207e-17
C126 (\3\:Q VSS) capacitor c=3.80341e-17
C127 (\8\:net573 VSS) capacitor c=3.17812e-17
C128 (\4\:QN VSS) capacitor c=2.07109e-17
C129 (\3\:qbint VSS) capacitor c=3.57434e-17
C130 (\2\:n20 VSS) capacitor c=2.43356e-17
C131 (\3\:QN VSS) capacitor c=3.49766e-17
C132 (\2\:CKbb VSS) capacitor c=4.30461e-17
C133 (\6\:net573 VSS) capacitor c=3.78255e-17
C134 (\7\:net573 VSS) capacitor c=3.10454e-17
C135 (\10\:qbint VSS) capacitor c=6.17453e-17
C136 (\11\:qbint VSS) capacitor c=9.93027e-17
C137 (\14\:qbint VSS) capacitor c=1.26688e-16
C138 (\6\:n35 VSS) capacitor c=1.7163e-16
C139 (\7\:n35 VSS) capacitor c=1.54569e-16
C140 (\12\:CKb VSS) capacitor c=1.13462e-16
C141 (\13\:CKb VSS) capacitor c=6.34512e-17
C142 (\7\:RNb VSS) capacitor c=1.43526e-16
C143 (\8\:RNb VSS) capacitor c=2.20154e-16
C144 (\9\:RNb VSS) capacitor c=1.08568e-16
C145 (\7\:SN VSS) capacitor c=2.60686e-16
C146 (\8\:SN VSS) capacitor c=3.00854e-17
C147 (\4\:mout VSS) capacitor c=4.49831e-17
C148 (\5\:mout VSS) capacitor c=4.91288e-17
C149 (\6\:mout VSS) capacitor c=5.97148e-17
C150 (\7\:mout VSS) capacitor c=5.5483e-17
C151 (\7\:n20 VSS) capacitor c=5.61679e-17
C152 (\8\:n20 VSS) capacitor c=8.53263e-17
C153 (\9\:CKbb VSS) capacitor c=4.56243e-17
C154 (\16\:CKb VSS) capacitor c=4.53473e-17
C155 (\17\:CKb VSS) capacitor c=1.2432e-16
C156 (\18\:CKb VSS) capacitor c=1.51086e-16
C157 (\19\:CKb VSS) capacitor c=1.51322e-16
C158 (\20\:CKb VSS) capacitor c=2.34832e-17
C159 (\23\:CKb VSS) capacitor c=1.89279e-17
C160 (\4\:CK VSS) capacitor c=5.17693e-17
C161 (\4\:D VSS) capacitor c=8.5807e-17
C162 (\3\:Db VSS) capacitor c=2.08239e-16
C163 (\8\:SE VSS) capacitor c=7.83198e-17
C164 (\9\:SE VSS) capacitor c=5.28703e-17
C165 (\10\:SE VSS) capacitor c=6.56466e-17
C166 (\6\:SEb VSS) capacitor c=7.99114e-17
C167 (\7\:SEb VSS) capacitor c=5.8955e-17
C168 (\3\:VDD VSS) capacitor c=1.88742e-17
C169 (\5\:VDD VSS) capacitor c=1.39553e-17
C170 (\6\:VDD VSS) capacitor c=8.79993e-18
C171 (\8\:VDD VSS) capacitor c=2.34599e-17
C172 (\20\:VDD VSS) capacitor c=1.91533e-17
C173 (\28\:VDD VSS) capacitor c=8.48363e-18
C174 (\32\:VDD VSS) capacitor c=5.32535e-18
Rk47 (\4\:CK CK) resistor r=0.1889 c=0
Rk2 (\3\:QN QN) resistor r=0.02903 c=0
Rk1 (\2\:QN \3\:QN) resistor r=0.2 c=0
Rk3 (\3\:QN \5\:QN) resistor r=0.1282 c=0
Rk55 (\8\:SE SE) resistor r=0.2644 c=0
Rk54 (\8\:SE \9\:SE) resistor r=0.3108 c=0
Rk56 (SE \10\:SE) resistor r=0.002257 c=0
Rk26 (\7\:SN SN) resistor r=1.978 c=0
Rk27 (SN \8\:SN) resistor r=0.09842 c=0
Rk53 (\4\:SI SI) resistor r=0.001898 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.1152 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.386 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.03491 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.3582 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.2581 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.2431 c=0
Rk66 (\8\:VDD \9\:VDD) resistor r=0.5101 c=0
Rk67 (\3\:VDD \11\:VDD) resistor r=0.251 c=0
Rk68 (\5\:VDD \13\:VDD) resistor r=0.2463 c=0
Rk69 (\6\:VDD \15\:VDD) resistor r=0.1999 c=0
Rk70 (\8\:VDD \17\:VDD) resistor r=0.07393 c=0
Rk71 (\9\:VDD \19\:VDD) resistor r=0.07147 c=0
Rk72 (\9\:VDD \20\:VDD) resistor r=0.4813 c=0
Rk73 (\20\:VDD \22\:VDD) resistor r=0.1026 c=0
Rk74 (\20\:VDD \23\:VDD) resistor r=0.1703 c=0
Rk75 (\23\:VDD \24\:VDD) resistor r=0.1503 c=0
Rk76 (\24\:VDD \26\:VDD) resistor r=0.07393 c=0
Rk77 (\24\:VDD \27\:VDD) resistor r=0.2004 c=0
Rk78 (\27\:VDD \28\:VDD) resistor r=0.213 c=0
Rk79 (\28\:VDD \30\:VDD) resistor r=0.2655 c=0
Rk80 (\28\:VDD \31\:VDD) resistor r=0.2882 c=0
Rk83 (\32\:VDD VDD) resistor r=0.1927 c=0
Rk81 (\31\:VDD \32\:VDD) resistor r=0.05748 c=0
Rk82 (\32\:VDD \34\:VDD) resistor r=0.4181 c=0
Rk48 (D \4\:D) resistor r=0.0781 c=0
Rk7 (\2\:Q Q) resistor r=0.3967 c=0
Rk8 (Q \4\:Q) resistor r=0.04807 c=0
Rk84 (\2\:VSS \3\:VSS) resistor r=0.1152 c=0
Rk85 (\3\:VSS \4\:VSS) resistor r=0.1854 c=0
Rk86 (\4\:VSS \5\:VSS) resistor r=0.2205 c=0
Rk87 (\5\:VSS \6\:VSS) resistor r=0.4324 c=0
Rk88 (\3\:VSS \8\:VSS) resistor r=0.2896 c=0
Rk89 (\5\:VSS \10\:VSS) resistor r=0.2196 c=0
Rk90 (\6\:VSS \11\:VSS) resistor r=0.4587 c=0
Rk91 (\11\:VSS \12\:VSS) resistor r=0.04244 c=0
Rk92 (\12\:VSS \13\:VSS) resistor r=0.652 c=0
Rk93 (\13\:VSS \14\:VSS) resistor r=0.6007 c=0
Rk94 (\14\:VSS \15\:VSS) resistor r=0.1995 c=0
Rk95 (\15\:VSS \16\:VSS) resistor r=0.213 c=0
Rk96 (\16\:VSS \17\:VSS) resistor r=0.1377 c=0
Rk97 (\17\:VSS \18\:VSS) resistor r=0.1929 c=0
Rk99 (\19\:VSS VSS) resistor r=0.1001 c=0
Rk98 (\18\:VSS \19\:VSS) resistor r=0.1076 c=0
Rk100 (\6\:VSS \21\:VSS) resistor r=0.07147 c=0
Rk101 (\11\:VSS \23\:VSS) resistor r=0.3557 c=0
Rk102 (\14\:VSS \25\:VSS) resistor r=0.04331 c=0
Rk103 (\16\:VSS \27\:VSS) resistor r=0.3913 c=0
Rk104 (\18\:VSS \29\:VSS) resistor r=0.07393 c=0
Rk9 (\4\:RN RN) resistor r=0.003663 c=0
Rk4 (\5\:net573 \6\:net573) resistor r=0.1238 c=0
Rk5 (\6\:net573 \7\:net573) resistor r=0.1344 c=0
Rk6 (\6\:net573 \9\:net573) resistor r=0.1959 c=0
Rk10 (\10\:qbint \11\:qbint) resistor r=0.368 c=0
Rk11 (\11\:qbint \13\:qbint) resistor r=0.09138 c=0
Rk12 (\11\:qbint \14\:qbint) resistor r=0.8183 c=0
Rk13 (\13\:qbint \16\:qbint) resistor r=0.4607 c=0
Rk21 (\7\:RNb \8\:RNb) resistor r=1.0519 c=0
Rk22 (\8\:RNb \9\:RNb) resistor r=0.6756 c=0
Rk23 (\9\:RNb \11\:RNb) resistor r=0.07287 c=0
Rk24 (\9\:RNb \13\:RNb) resistor r=0.4963 c=0
Rk17 (\5\:n35 \6\:n35) resistor r=0.1803 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=1.1324 c=0
Rk19 (\6\:n35 \9\:n35) resistor r=0.1634 c=0
Rk14 (\2\:n8 \4\:n8) resistor r=0.6111 c=0
Rk16 (\2\:n10 \4\:n10) resistor r=0.301 c=0
Rk20 (\12\:CKb \13\:CKb) resistor r=0.6571 c=0
Rk40 (\15\:CKb \16\:CKb) resistor r=0.3345 c=0
Rk41 (\16\:CKb \17\:CKb) resistor r=0.3365 c=0
Rk42 (\17\:CKb \18\:CKb) resistor r=0.6509 c=0
Rk43 (\18\:CKb \19\:CKb) resistor r=1.0248 c=0
Rk44 (\16\:CKb \20\:CKb) resistor r=0.08669 c=0
Rk45 (\17\:CKb \22\:CKb) resistor r=0.3751 c=0
Rk46 (\18\:CKb \23\:CKb) resistor r=0.02283 c=0
Rk28 (\4\:mout \5\:mout) resistor r=0.2592 c=0
Rk29 (\5\:mout \6\:mout) resistor r=0.2896 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.3064 c=0
Rk31 (\7\:mout \9\:mout) resistor r=0.3617 c=0
Rk32 (\5\:mout \11\:mout) resistor r=0.08669 c=0
Rk33 (\6\:mout \13\:mout) resistor r=0.1031 c=0
Rk34 (\7\:mout \15\:mout) resistor r=0.16 c=0
Rk38 (\8\:CKbb \9\:CKbb) resistor r=0.1237 c=0
Rk39 (\9\:CKbb \11\:CKbb) resistor r=0.183 c=0
Rk25 (\2\:n4 \4\:n4) resistor r=0.4889 c=0
Rk35 (\6\:n20 \7\:n20) resistor r=0.1311 c=0
Rk36 (\7\:n20 \8\:n20) resistor r=0.4162 c=0
Rk37 (\7\:n20 \10\:n20) resistor r=0.269 c=0
Rk49 (\2\:Db \3\:Db) resistor r=0.2394 c=0
Rk50 (\3\:Db \5\:Db) resistor r=1.2106 c=0
Rk51 (\3\:Db \7\:Db) resistor r=0.6628 c=0
Rk52 (\5\:Db \9\:Db) resistor r=0.4296 c=0
Rk57 (\5\:SEb \6\:SEb) resistor r=0.04795 c=0
Rk58 (\6\:SEb \7\:SEb) resistor r=0.3966 c=0
Rk59 (\6\:SEb \9\:SEb) resistor r=0.614 c=0
Rk15 (\2\:n11 \4\:n11) resistor r=0.4173 c=0
Rl39 (\1\:CK \2\:CK) resistor r=30.1196 c=0
Rl40 (\2\:CK \3\:CK) resistor r=134.41 c=0
Rl49 (\5\:SE \6\:SE) resistor r=176.156 c=0
Rl50 (\6\:SE \7\:SE) resistor r=28.079 c=0
Rl46 (\3\:SE \4\:SE) resistor r=26.098 c=0
Rl43 (\1\:SE \2\:SE) resistor r=67.9995 c=0
Rl27 (\4\:SN \6\:SN) resistor r=140.385 c=0
Rl26 (\4\:SN \5\:SN) resistor r=52.1723 c=0
Rl12 (\1\:SN \2\:SN) resistor r=33.3841 c=0
Rl13 (\2\:SN \3\:SN) resistor r=102.615 c=0
Rl47 (\1\:SI \2\:SI) resistor r=104.538 c=0
Rl48 (\2\:SI \3\:SI) resistor r=102.615 c=0
Rl41 (\1\:D \2\:D) resistor r=91.5405 c=0
Rl42 (\2\:D \3\:D) resistor r=112.694 c=0
Rl9 (\2\:RN \3\:RN) resistor r=29.9451 c=0
Rl8 (\1\:RN \2\:RN) resistor r=128.846 c=0
Rl1 (net573 \2\:net573) resistor r=35.7713 c=0
Rl2 (\2\:net573 \3\:net573) resistor r=80.0021 c=0
Rl14 (\7\:qbint \8\:qbint) resistor r=161.538 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=38.5707 c=0
Rl3 (qbint \2\:qbint) resistor r=122.872 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.4837 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=80.0028 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=175.837 c=0
Rl16 (RNb \2\:RNb) resistor r=264.95 c=0
Rl22 (\4\:RNb \6\:RNb) resistor r=140.385 c=0
Rl21 (\4\:RNb \5\:RNb) resistor r=111.052 c=0
Rl17 (\2\:RNb \3\:RNb) resistor r=43.4636 c=0
Rl10 (n35 \2\:n35) resistor r=102.615 c=0
Rl11 (\2\:n35 \3\:n35) resistor r=33.3841 c=0
Rl36 (\8\:CKb \9\:CKb) resistor r=57.4874 c=0
Rl38 (\9\:CKb \11\:CKb) resistor r=42.2956 c=0
Rl37 (\9\:CKb \10\:CKb) resistor r=184.593 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=66.5405 c=0
Rl20 (\4\:CKb \5\:CKb) resistor r=49.5131 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=117.979 c=0
Rl18 (CKb \2\:CKb) resistor r=83.8482 c=0
Rl28 (mout \2\:mout) resistor r=55.6115 c=0
Rl29 (\2\:mout \3\:mout) resistor r=89.8988 c=0
Rl34 (\4\:CKbb \5\:CKbb) resistor r=152.977 c=0
Rl33 (\3\:CKbb \4\:CKbb) resistor r=705.335 c=0
Rl31 (CKbb \2\:CKbb) resistor r=75.3733 c=0
Rl35 (\2\:CKbb \6\:CKbb) resistor r=55.0028 c=0
Rl32 (\2\:CKbb \3\:CKbb) resistor r=170.415 c=0
Rl23 (n20 \2\:n20) resistor r=2.0213 c=0
Rl25 (\2\:n20 \4\:n20) resistor r=95.868 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=36.2526 c=0
Rl44 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl45 (\2\:SEb \3\:SEb) resistor r=227.18 c=0
Rz1 (\4\:QN \5\:QN) resistor r=75 c=0
Rz21 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz22 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz23 (\1\:VDD \7\:VDD) resistor r=15 c=0
Rz24 (\1\:VDD \9\:VDD) resistor r=7.5 c=0
Rz25 (\1\:VDD \23\:VDD) resistor r=25 c=0
Rz26 (\1\:VDD \27\:VDD) resistor r=18.75 c=0
Rz27 (\1\:VDD \31\:VDD) resistor r=12.5 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz28 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz29 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz30 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz31 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz32 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz33 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz34 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz2 (\8\:net573 \9\:net573) resistor r=75 c=0
Rz4 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz10 (\12\:RNb \13\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (n8 \2\:n8) resistor r=75 c=0
Rz6 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz7 (n10 \2\:n10) resistor r=75 c=0
Rz8 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz17 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz16 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (n4 \2\:n4) resistor r=75 c=0
Rz12 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz15 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry17 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry19 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry23 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry24 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry25 (\33\:VDD \34\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry27 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry28 (\1\:VSS \6\:VSS) resistor r=6.8889 c=0
Ry29 (\1\:VSS \12\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \13\:VSS) resistor r=5.1667 c=0
Ry31 (\1\:VSS \15\:VSS) resistor r=15.5 c=0
Ry32 (\1\:VSS \17\:VSS) resistor r=20.6667 c=0
Ry33 (\1\:VSS \19\:VSS) resistor r=20.6667 c=0
Ry2 (\4\:net573 \5\:net573) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry8 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry13 (\21\:CKb \22\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry12 (\7\:CKbb \8\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry5 (n11 \2\:n11) resistor r=62 c=0
Ry6 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx18 (\2\:CK \4\:CK) resistor r=45 c=0
Rx21 (\4\:SE \8\:SE) resistor r=45 c=0
Rx22 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx20 (\2\:SI \4\:SI) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\2\:net573 \7\:net573) resistor r=45 c=0
Rx3 (\9\:qbint \10\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \14\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx15 (\3\:CKb \19\:CKb) resistor r=45 c=0
Rx16 (\9\:CKb \20\:CKb) resistor r=45 c=0
Rx17 (\7\:CKb \23\:CKb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx14 (CKbb \9\:CKbb) resistor r=45 c=0
Rx13 (n20 \8\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\4\:QN \3\:net573 \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn56 (\8\:net573 \4\:qbint \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=2.03e-14 ps=1.35e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn55 (\3\:Q \5\:qbint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=2.102e-14 ps=7.2e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=4.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn22 (\12\:RNb \1\:RN \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.262e-14 ps=7.2e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\12\:qbint \3\:n35 \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.27e-14 ad=2.03e-14 ps=1.41e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n8 \3\:SN \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.8e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (\3\:n10 RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=5.437e-14 ps=6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.55e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \8\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.437e-14 ps=6.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.75e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn53 (\4\:n35 CKb n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\4\:n35 \4\:CKbb \14\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.697e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\12\:mout \6\:RNb \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.682e-14 ps=5.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.135e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn32 (\12\:mout \3\:n20 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=9.05e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (n4 \6\:SN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=7e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn35 (n6 \3\:mout \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=8.7e-15 ps=6.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=4.65e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn36 (\5\:n20 \3\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.537e-14 ps=4.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=3.6e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn25 (\4\:Db \10\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn21 (\10\:CKbb \11\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.085e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn20 (\14\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.855e-14 ad=3.987e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.87931e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn11 (n0 \3\:D \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.855e-14 ad=3.625e-14 ps=1.13e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01034e-07 sb=9.5e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn14 (Db \3\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.01034e-07 sb=4.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.96034e-07 sb=6.55e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn13 (n2 \3\:SI \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.06034e-07 sb=3.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn10 (\8\:SEb \7\:SE \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11103e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp56 (\4\:net573 \6\:qbint \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\1\:Q qbint \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=3.45e-07 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp22 (\10\:RNb \3\:RN \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp45 (\15\:qbint n35 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.01e-14 ps=1.73e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.4e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp50 (\3\:n11 \1\:SN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.75e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp52 (\3\:n11 \7\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.7e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp51 (n9 \2\:RNb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0857e-13 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2.65e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp53 (\8\:n35 \5\:CKbb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.987e-14 ad=3.762e-14 ps=1.08e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=3.6e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp40 (\8\:n35 \5\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.4e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp31 (n5 \4\:RNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0383e-13 ad=3.977e-14 ps=2.11e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03558e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp32 (\10\:mout \4\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=3.44e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=8.05581e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp30 (\10\:mout \4\:SN \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.55e-14 ad=3.44e-14 ps=1.72e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=6.00581e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp35 (n7 mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.55e-14 ad=1.29e-14 ps=1.72e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.82209e-07 sb=4.5e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\9\:n20 \6\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.87209e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\9\:n20 \6\:CKbb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19221e-06 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\7\:CKbb \8\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.835e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp20 (\21\:CKb \1\:CK \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.155e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp11 (n1 \1\:D \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.5e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp12 (\6\:Db \1\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.655e-14 ps=8.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=6.95e-07 sd=160n sca=10.8061 \
        scb=0.00831024 scc=0.000128411 m=(1)
mp14 (\6\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=3.655e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=4.8e-07 sd=160n sca=11.5709 \
        scb=0.00874068 scc=0.000128764 m=(1)
mp13 (n3 \1\:SI \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.935e-14 ps=7.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=3.45e-07 sd=160n sca=12.5323 \
        scb=0.0098256 scc=0.000132754 m=(1)
mp10 (\4\:SEb \5\:SE \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.4e-07 sd=160n sca=16.3619 \
        scb=0.0163088 scc=0.000299525 m=(1)
ends SDFFSRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:43:31 2012 )
// Library name: gsclib045
// Cell name: SDFFSX1
// View name: extracted

simulator lang=spectre

subckt SDFFSX1 CK D Q QN SE SI SN VDD VSS
mp57 (\3\:QN net492 \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.5844 \
        scb=0.0271174 scc=0.00348165 m=(1)
C1 (QN VSS) capacitor c=4.87265e-17
C2 (SE VSS) capacitor c=2.75261e-17
C3 (SN VSS) capacitor c=2.46403e-17
C4 (SI VSS) capacitor c=5.35289e-17
C5 (VDD VSS) capacitor c=4.27389e-16
C6 (D VSS) capacitor c=6.74922e-17
C7 (Q VSS) capacitor c=4.41569e-17
C8 (net492 VSS) capacitor c=3.25785e-17
C9 (qbint VSS) capacitor c=2.68515e-17
C10 (n35 VSS) capacitor c=4.23196e-17
C11 (net518 VSS) capacitor c=2.03266e-18
C12 (CKb VSS) capacitor c=1.70623e-17
C13 (mout VSS) capacitor c=7.53418e-17
C14 (CKbb VSS) capacitor c=3.53697e-17
C15 (net442 VSS) capacitor c=2.03427e-18
C16 (n20 VSS) capacitor c=3.55371e-17
C17 (net478 VSS) capacitor c=3.30288e-18
C18 (Db VSS) capacitor c=9.32137e-17
C19 (net494 VSS) capacitor c=8.15958e-18
C20 (SEb VSS) capacitor c=3.39678e-17
C21 (net506 VSS) capacitor c=1.52608e-20
C22 (net405 VSS) capacitor c=7.18357e-17
C23 (\7\:SE VSS) capacitor c=5.1942e-17
C24 (\3\:SI VSS) capacitor c=4.87777e-17
C25 (\1\:SE VSS) capacitor c=4.39213e-17
C26 (\1\:D VSS) capacitor c=5.52651e-17
C27 (\1\:CK VSS) capacitor c=6.82366e-17
C28 (\5\:CKbb VSS) capacitor c=4.27356e-17
C29 (\7\:CKb VSS) capacitor c=7.33841e-17
C30 (\4\:SN VSS) capacitor c=7.9944e-17
C31 (\2\:CKb VSS) capacitor c=4.79266e-17
C32 (\4\:CKb VSS) capacitor c=1.10076e-16
C33 (\4\:CKbb VSS) capacitor c=6.53193e-17
C34 (\7\:qbint VSS) capacitor c=6.22375e-17
C35 (\3\:SN VSS) capacitor c=5.17134e-17
C36 (\3\:n35 VSS) capacitor c=3.62592e-17
C37 (\6\:qbint VSS) capacitor c=1.73213e-17
C38 (\5\:SE VSS) capacitor c=3.1911e-17
C39 (\1\:SI VSS) capacitor c=7.93755e-17
C40 (\3\:SE VSS) capacitor c=6.54903e-17
C41 (\3\:SEb VSS) capacitor c=6.35724e-17
C42 (\4\:D VSS) capacitor c=2.96861e-17
C43 (\3\:CK VSS) capacitor c=2.53639e-17
C44 (\9\:CKb VSS) capacitor c=3.95943e-17
C45 (\7\:CKbb VSS) capacitor c=2.94939e-17
C46 (\4\:mout VSS) capacitor c=2.98645e-17
C47 (\3\:n20 VSS) capacitor c=5.82198e-17
C48 (\5\:SN VSS) capacitor c=4.18631e-17
C49 (\6\:CKb VSS) capacitor c=3.39192e-17
C50 (\3\:CKbb VSS) capacitor c=3.0916e-17
C51 (\5\:CKb VSS) capacitor c=1.10716e-16
C52 (\9\:qbint VSS) capacitor c=3.87859e-17
C53 (\1\:SN VSS) capacitor c=5.9169e-17
C54 (\5\:qbint VSS) capacitor c=1.77149e-17
C55 (\4\:qbint VSS) capacitor c=1.68454e-17
C56 (\3\:net492 VSS) capacitor c=2.09913e-17
C57 (\6\:SE VSS) capacitor c=5.56237e-17
C58 (\2\:SI VSS) capacitor c=7.37657e-17
C59 (\4\:SE VSS) capacitor c=5.62074e-17
C60 (\2\:SEb VSS) capacitor c=6.87718e-17
C61 (\2\:SE VSS) capacitor c=4.51171e-17
C62 (\3\:D VSS) capacitor c=1.93081e-17
C63 (\2\:CK VSS) capacitor c=5.0739e-17
C64 (\10\:CKb VSS) capacitor c=2.02716e-17
C65 (\8\:CKb VSS) capacitor c=2.72834e-17
C66 (\6\:CKbb VSS) capacitor c=5.79649e-17
C67 (\3\:mout VSS) capacitor c=1.77241e-17
C68 (\2\:n20 VSS) capacitor c=4.29303e-17
C69 (\6\:SN VSS) capacitor c=2.35841e-17
C70 (\8\:qbint VSS) capacitor c=6.04623e-17
C71 (\2\:SN VSS) capacitor c=7.66516e-17
C72 (\2\:n35 VSS) capacitor c=5.29175e-17
C73 (\2\:qbint VSS) capacitor c=1.22234e-17
C74 (\2\:net492 VSS) capacitor c=1.80054e-17
C75 (\8\:SEb VSS) capacitor c=1.51924e-17
C76 (\13\:VDD VSS) capacitor c=2.86532e-17
C77 (\8\:Db VSS) capacitor c=4.23722e-17
C78 (\15\:VDD VSS) capacitor c=4.0778e-17
C79 (\11\:CKb VSS) capacitor c=8.16785e-17
C80 (\4\:Db VSS) capacitor c=1.33953e-16
C81 (\8\:n20 VSS) capacitor c=2.41477e-17
C82 (\17\:VDD VSS) capacitor c=1.21713e-17
C83 (\7\:mout VSS) capacitor c=1.10093e-16
C84 (\19\:VDD VSS) capacitor c=1.60665e-17
C85 (\8\:CKbb VSS) capacitor c=4.29403e-17
C86 (\11\:mout VSS) capacitor c=1.27525e-16
C87 (\4\:n35 VSS) capacitor c=4.211e-17
C88 (\21\:VDD VSS) capacitor c=3.2522e-17
C89 (\3\:net405 VSS) capacitor c=8.25228e-17
C90 (\23\:VDD VSS) capacitor c=1.53278e-17
C91 (\14\:qbint VSS) capacitor c=5.18933e-17
C92 (\3\:Q VSS) capacitor c=4.03586e-17
C93 (\25\:VDD VSS) capacitor c=8.14172e-17
C94 (\4\:net492 VSS) capacitor c=5.50622e-17
C95 (\3\:QN VSS) capacitor c=7.90409e-17
C96 (\28\:VDD VSS) capacitor c=5.40312e-17
C97 (\1\:VDD VSS) capacitor c=1.51625e-16
C98 (\4\:SEb VSS) capacitor c=5.86931e-17
C99 (\17\:CKb VSS) capacitor c=7.62469e-17
C100 (\6\:Db VSS) capacitor c=6.93462e-17
C101 (\4\:n20 VSS) capacitor c=6.14484e-17
C102 (\9\:mout VSS) capacitor c=3.41797e-17
C103 (\13\:CKbb VSS) capacitor c=3.06645e-17
C104 (\13\:mout VSS) capacitor c=1.07168e-16
C105 (\8\:n35 VSS) capacitor c=7.45193e-17
C106 (\12\:qbint VSS) capacitor c=7.70234e-17
C107 (\1\:Q VSS) capacitor c=6.8705e-17
C108 (\6\:net492 VSS) capacitor c=9.32882e-17
C109 (\1\:QN VSS) capacitor c=5.14246e-17
C110 (\3\:qbint VSS) capacitor c=6.98021e-18
C111 (\2\:CKbb VSS) capacitor c=2.7094e-17
C112 (\3\:CKb VSS) capacitor c=4.99334e-17
C113 (\2\:mout VSS) capacitor c=3.92702e-17
C114 (\2\:D VSS) capacitor c=3.94844e-17
C115 (\8\:net492 VSS) capacitor c=7.68136e-17
C116 (\10\:qbint VSS) capacitor c=7.29322e-17
C117 (\11\:qbint VSS) capacitor c=5.48251e-17
C118 (\16\:qbint VSS) capacitor c=1.12115e-16
C119 (\6\:n35 VSS) capacitor c=1.29897e-16
C120 (\7\:n35 VSS) capacitor c=1.01802e-16
C121 (\7\:SN VSS) capacitor c=7.00876e-17
C122 (\8\:SN VSS) capacitor c=1.56584e-16
C123 (\9\:SN VSS) capacitor c=1.51593e-16
C124 (\5\:mout VSS) capacitor c=6.89742e-17
C125 (\6\:mout VSS) capacitor c=4.85659e-17
C126 (\10\:CKbb VSS) capacitor c=1.39791e-16
C127 (\11\:CKbb VSS) capacitor c=6.1282e-17
C128 (\12\:CKbb VSS) capacitor c=1.64338e-16
C129 (\6\:n20 VSS) capacitor c=7.59175e-17
C130 (\7\:n20 VSS) capacitor c=6.47713e-17
C131 (\4\:CK VSS) capacitor c=3.66037e-17
C132 (\6\:CK VSS) capacitor c=7.09215e-17
C133 (\13\:CKb VSS) capacitor c=9.98821e-17
C134 (\14\:CKb VSS) capacitor c=8.31484e-17
C135 (\15\:CKb VSS) capacitor c=1.03158e-16
C136 (\16\:CKb VSS) capacitor c=1.24845e-16
C137 (\5\:D VSS) capacitor c=3.26656e-17
C138 (\3\:Db VSS) capacitor c=1.42331e-16
C139 (\4\:SI VSS) capacitor c=8.43702e-17
C140 (\8\:SE VSS) capacitor c=4.11457e-17
C141 (\9\:SE VSS) capacitor c=5.40596e-17
C142 (\10\:SE VSS) capacitor c=6.99942e-17
C143 (\6\:SEb VSS) capacitor c=8.7259e-17
C144 (\7\:SEb VSS) capacitor c=4.76827e-17
C145 (\3\:VDD VSS) capacitor c=1.79686e-17
C146 (\4\:VDD VSS) capacitor c=2.29135e-17
C147 (\7\:VDD VSS) capacitor c=1.91834e-17
C148 (\9\:VDD VSS) capacitor c=1.90844e-17
C149 (\11\:VDD VSS) capacitor c=1.36751e-17
C150 (\27\:VDD VSS) capacitor c=1.03751e-17
Rk30 (\4\:CK \5\:CK) resistor r=0.002015 c=0
Rk31 (CK \6\:CK) resistor r=0.001948 c=0
Rk32 (\4\:CK \6\:CK) resistor r=0.02971 c=0
Rk1 (\2\:QN QN) resistor r=0.03635 c=0
Rk2 (QN \4\:QN) resistor r=0.2589 c=0
Rk44 (\8\:SE SE) resistor r=0.1311 c=0
Rk45 (SE \9\:SE) resistor r=0.06361 c=0
Rk46 (\9\:SE \10\:SE) resistor r=0.3431 c=0
Rk16 (\8\:SN SN) resistor r=0.02617 c=0
Rk15 (\7\:SN \8\:SN) resistor r=0.283 c=0
Rk17 (\8\:SN \9\:SN) resistor r=1.1609 c=0
Rk43 (SI \4\:SI) resistor r=0.1108 c=0
Rk69 (\2\:VDD \3\:VDD) resistor r=0.1176 c=0
Rk70 (\3\:VDD \4\:VDD) resistor r=0.4156 c=0
Rk71 (\4\:VDD \5\:VDD) resistor r=0.1677 c=0
Rk72 (\5\:VDD \6\:VDD) resistor r=0.6518 c=0
Rk73 (\6\:VDD \7\:VDD) resistor r=0.2648 c=0
Rk74 (\7\:VDD \8\:VDD) resistor r=0.2344 c=0
Rk75 (\8\:VDD \9\:VDD) resistor r=0.4609 c=0
Rk76 (\9\:VDD \10\:VDD) resistor r=0.09001 c=0
Rk77 (\10\:VDD \11\:VDD) resistor r=0.1076 c=0
Rk78 (\11\:VDD \12\:VDD) resistor r=0.4437 c=0
Rk79 (\3\:VDD \14\:VDD) resistor r=0.2425 c=0
Rk80 (\4\:VDD \16\:VDD) resistor r=0.2448 c=0
Rk81 (\6\:VDD \18\:VDD) resistor r=0.1194 c=0
Rk82 (\7\:VDD \20\:VDD) resistor r=0.04326 c=0
Rk83 (\9\:VDD \22\:VDD) resistor r=0.2048 c=0
Rk84 (\11\:VDD \24\:VDD) resistor r=0.2094 c=0
Rk85 (\12\:VDD \26\:VDD) resistor r=0.449 c=0
Rk88 (\27\:VDD VDD) resistor r=0.07222 c=0
Rk86 (\12\:VDD \27\:VDD) resistor r=0.3281 c=0
Rk87 (\27\:VDD \29\:VDD) resistor r=0.3992 c=0
Rk38 (\5\:D D) resistor r=0.1597 c=0
Rk5 (\2\:Q Q) resistor r=0.2831 c=0
Rk6 (Q \4\:Q) resistor r=0.02993 c=0
Rk50 (\2\:VSS \3\:VSS) resistor r=0.09001 c=0
Rk51 (\3\:VSS \4\:VSS) resistor r=0.5659 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.04491 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.6388 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.4306 c=0
Rk55 (\7\:VSS \8\:VSS) resistor r=0.1326 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=0.5811 c=0
Rk57 (\9\:VSS \10\:VSS) resistor r=0.4208 c=0
Rk58 (\10\:VSS \11\:VSS) resistor r=0.04741 c=0
Rk60 (\12\:VSS VSS) resistor r=0.05719 c=0
Rk59 (\11\:VSS \12\:VSS) resistor r=0.3454 c=0
Rk62 (\3\:VSS \15\:VSS) resistor r=0.2172 c=0
Rk63 (\4\:VSS \17\:VSS) resistor r=0.2181 c=0
Rk64 (\6\:VSS \19\:VSS) resistor r=0.1895 c=0
Rk65 (\7\:VSS \21\:VSS) resistor r=0.1219 c=0
Rk66 (\9\:VSS \23\:VSS) resistor r=0.3303 c=0
Rk67 (\11\:VSS \25\:VSS) resistor r=0.2956 c=0
Rk68 (\12\:VSS \27\:VSS) resistor r=0.07334 c=0
Rk3 (\5\:net492 \7\:net492) resistor r=0.2864 c=0
Rk4 (\7\:net492 \8\:net492) resistor r=0.6045 c=0
Rk7 (\10\:qbint \11\:qbint) resistor r=0.3563 c=0
Rk8 (\11\:qbint \13\:qbint) resistor r=0.1822 c=0
Rk9 (\11\:qbint \15\:qbint) resistor r=0.3855 c=0
Rk10 (\13\:qbint \16\:qbint) resistor r=0.8134 c=0
Rk12 (\5\:n35 \6\:n35) resistor r=0.1972 c=0
Rk13 (\6\:n35 \7\:n35) resistor r=0.5928 c=0
Rk14 (\6\:n35 \9\:n35) resistor r=0.3511 c=0
Rk33 (\12\:CKb \13\:CKb) resistor r=0.5836 c=0
Rk34 (\13\:CKb \14\:CKb) resistor r=0.2416 c=0
Rk35 (\14\:CKb \15\:CKb) resistor r=0.6821 c=0
Rk36 (\13\:CKb \16\:CKb) resistor r=0.4519 c=0
Rk37 (\16\:CKb \18\:CKb) resistor r=0.5856 c=0
Rk18 (\5\:mout \6\:mout) resistor r=0.2656 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.2503 c=0
Rk20 (\6\:mout \10\:mout) resistor r=0.09662 c=0
Rk21 (\8\:mout \12\:mout) resistor r=0.7557 c=0
Rk22 (\12\:mout \14\:mout) resistor r=0.5767 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.1723 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.3743 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=1.1436 c=0
Rk26 (\11\:CKbb \14\:CKbb) resistor r=0.1073 c=0
Rk27 (\5\:n20 \6\:n20) resistor r=0.3448 c=0
Rk28 (\6\:n20 \7\:n20) resistor r=0.3477 c=0
Rk29 (\6\:n20 \9\:n20) resistor r=0.09725 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.7577 c=0
Rk40 (\3\:Db \5\:Db) resistor r=0.6966 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.4248 c=0
Rk42 (\3\:Db \9\:Db) resistor r=0.2444 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.5398 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.3964 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.0873 c=0
Rk11 (\2\:net405 \4\:net405) resistor r=0.3375 c=0
Rl33 (\1\:CK \2\:CK) resistor r=286.796 c=0
Rl34 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl45 (\6\:SE \7\:SE) resistor r=185.714 c=0
Rl44 (\5\:SE \6\:SE) resistor r=67.3077 c=0
Rl41 (\3\:SE \4\:SE) resistor r=66.0764 c=0
Rl38 (\1\:SE \2\:SE) resistor r=87.2302 c=0
Rl22 (\4\:SN \5\:SN) resistor r=170.72 c=0
Rl23 (\5\:SN \6\:SN) resistor r=35.6938 c=0
Rl11 (\2\:SN \3\:SN) resistor r=120.33 c=0
Rl10 (\1\:SN \2\:SN) resistor r=92.3077 c=0
Rl43 (\2\:SI \3\:SI) resistor r=97.2527 c=0
Rl42 (\1\:SI \2\:SI) resistor r=155.769 c=0
Rl35 (\1\:D \2\:D) resistor r=145.387 c=0
Rl37 (\2\:D \4\:D) resistor r=128.08 c=0
Rl36 (\2\:D \3\:D) resistor r=34.9887 c=0
Rl1 (net492 \2\:net492) resistor r=31.9251 c=0
Rl2 (\2\:net492 \3\:net492) resistor r=31.9251 c=0
Rl12 (\7\:qbint \8\:qbint) resistor r=178.021 c=0
Rl13 (\8\:qbint \9\:qbint) resistor r=26.098 c=0
Rl3 (qbint \2\:qbint) resistor r=39.6174 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.2328 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=51.1361 c=0
Rl8 (n35 \2\:n35) resistor r=151.156 c=0
Rl9 (\2\:n35 \3\:n35) resistor r=81.0888 c=0
Rl17 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl20 (\4\:CKb \5\:CKb) resistor r=557.258 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=29.5379 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=60.3072 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=155.747 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=178.824 c=0
Rl21 (\3\:CKb \6\:CKb) resistor r=82.3738 c=0
Rl26 (mout \2\:mout) resistor r=98.8796 c=0
Rl28 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl27 (\2\:mout \3\:mout) resistor r=5.013 c=0
Rl30 (\5\:CKbb \6\:CKbb) resistor r=134.593 c=0
Rl31 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl14 (CKbb \2\:CKbb) resistor r=80.5242 c=0
Rl16 (\2\:CKbb \4\:CKbb) resistor r=116.916 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=51.9908 c=0
Rl24 (n20 \2\:n20) resistor r=29.5379 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=156.027 c=0
Rl39 (SEb \2\:SEb) resistor r=26.9231 c=0
Rl40 (\2\:SEb \3\:SEb) resistor r=226.374 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz21 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz22 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz23 (\1\:VDD \6\:VDD) resistor r=75 c=0
Rz24 (\1\:VDD \8\:VDD) resistor r=8.3333 c=0
Rz25 (\1\:VDD \10\:VDD) resistor r=37.5 c=0
Rz26 (\1\:VDD \12\:VDD) resistor r=8.3333 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz19 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz20 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz2 (\6\:net492 \7\:net492) resistor r=75 c=0
Rz4 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz5 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\13\:mout \14\:mout) resistor r=75 c=0
Rz8 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz9 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\6\:Db \7\:Db) resistor r=75 c=0
Rz13 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry21 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry22 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry23 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry24 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry25 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry26 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry27 (\25\:VDD \26\:VDD) resistor r=20.6667 c=0
Ry28 (\28\:VDD \29\:VDD) resistor r=20.6667 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\1\:VSS VSS) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry17 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry18 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \10\:VSS) resistor r=7.75 c=0
Ry2 (\4\:net492 \5\:net492) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry7 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\8\:Db \9\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\2\:CK \5\:CK) resistor r=45 c=0
Rx17 (\6\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SN \7\:SN) resistor r=45 c=0
Rx6 (\6\:SN \9\:SN) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:net492 \8\:net492) resistor r=45 c=0
Rx2 (\8\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\6\:CKbb \12\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\1\:QN \3\:net492 \26\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.26e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\6\:net492 \4\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=6.63e-14 ps=9e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=2.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn45 (\12\:qbint n35 \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.85e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn50 (net521 \1\:SN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.8e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (net518 \9\:qbint net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.915e-14 ps=4.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.75e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn52 (\8\:n35 \5\:CKb net518 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.538e-14 ps=8.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.6e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\8\:n35 \3\:CKbb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.538e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\13\:CKbb \6\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.328e-14 ad=3.698e-14 ps=1.68e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (net442 \5\:SN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.328e-14 ad=1.668e-14 ps=1.68e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=3e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn31 (\9\:mout \3\:n20 net442 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net478 \4\:mout \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.325e-14 ad=1.668e-14 ps=9.4e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.1e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn36 (\4\:n20 \7\:CKbb net478 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=3.625e-14 ps=5.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=5.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn25 (\6\:Db \9\:CKb \4\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.698e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\17\:CKb \3\:CK \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.308e-14 ad=2.03e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.535e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (net494 \4\:D \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.308e-14 ad=4.713e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.055e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=6.85e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=4.8e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn13 (net506 \1\:SI \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=3.75e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\4\:SEb \5\:SE \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.7e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mp56 (\4\:net492 \6\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=46.2776 \
        scb=0.0284965 scc=0.00588421 m=(1)
mp55 (\3\:Q qbint \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp45 (\14\:qbint \3\:n35 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=5.65e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp50 (\3\:net405 \3\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=3.6e-07 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \7\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.333e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.55e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\4\:n35 \4\:CKbb net405 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n35 \4\:CKb \11\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\8\:CKbb \2\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.53e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\7\:mout \4\:SN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=4.73e-14 ps=1.83e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.265e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (\7\:mout n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1028e-13 ad=4.73e-14 ps=1.88e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp35 (net417 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1028e-13 ad=1.29e-14 ps=1.88e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\8\:n20 \7\:CKb net417 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=6.05e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp25 (\8\:n20 \5\:CKbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=3.44e-14 ps=1.23e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=4e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp20 (\11\:CKb \1\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp11 (net433 \1\:D \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.7e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp13 (net441 \3\:SI \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=3.45e-07 sd=160n sca=12.3417 \
        scb=0.00949694 scc=0.000115721 m=(1)
mp12 (\8\:Db \1\:SE net433 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=4.085e-14 ps=7.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.6e-07 sd=160n sca=10.5126 \
        scb=0.0080107 scc=0.000111754 m=(1)
mp14 (\8\:Db SEb net441 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.085e-14 ps=7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5.25e-07 sd=160n sca=11.1923 \
        scb=0.00829854 scc=0.000111894 m=(1)
mp10 (\8\:SEb \7\:SE \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=16.0492 \
        scb=0.0157507 scc=0.000268603 m=(1)
ends SDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:44:09 2012 )
// Library name: gsclib045
// Cell name: SDFFSX2
// View name: extracted

simulator lang=spectre

subckt SDFFSX2 CK D Q QN SE SI SN VDD VSS
mp57 (\1\:QN net492 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.17308e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (CK VSS) capacitor c=5.84284e-17
C2 (SE VSS) capacitor c=2.11547e-17
C3 (SN VSS) capacitor c=2.62398e-17
C4 (SI VSS) capacitor c=4.38522e-17
C5 (VDD VSS) capacitor c=5.1645e-16
C6 (D VSS) capacitor c=2.12489e-17
C7 (net492 VSS) capacitor c=1.09325e-16
C8 (qbint VSS) capacitor c=1.34392e-16
C9 (n35 VSS) capacitor c=4.80298e-17
C10 (net518 VSS) capacitor c=1.69034e-18
C11 (CKb VSS) capacitor c=1.72042e-17
C12 (mout VSS) capacitor c=7.26334e-17
C13 (CKbb VSS) capacitor c=6.74649e-17
C14 (net442 VSS) capacitor c=3.88814e-19
C15 (n20 VSS) capacitor c=3.44863e-17
C16 (net478 VSS) capacitor c=1.91044e-18
C17 (Db VSS) capacitor c=9.65691e-17
C18 (net494 VSS) capacitor c=5.9615e-18
C19 (SEb VSS) capacitor c=5.59279e-17
C20 (net405 VSS) capacitor c=7.17977e-17
C21 (net417 VSS) capacitor c=1.07651e-18
C22 (net433 VSS) capacitor c=5.52605e-18
C23 (\5\:SE VSS) capacitor c=6.11432e-17
C24 (\1\:SI VSS) capacitor c=5.73814e-17
C25 (\1\:SE VSS) capacitor c=3.68931e-17
C26 (\1\:D VSS) capacitor c=5.93994e-17
C27 (\1\:CK VSS) capacitor c=4.91129e-17
C28 (\5\:CKbb VSS) capacitor c=5.87599e-17
C29 (\7\:CKb VSS) capacitor c=8.79718e-17
C30 (\4\:SN VSS) capacitor c=7.34904e-17
C31 (\2\:CKb VSS) capacitor c=4.1484e-17
C32 (\4\:CKb VSS) capacitor c=1.13778e-16
C33 (\11\:qbint VSS) capacitor c=6.70001e-17
C34 (\3\:SN VSS) capacitor c=5.81291e-17
C35 (\10\:qbint VSS) capacitor c=2.6124e-17
C36 (\7\:SE VSS) capacitor c=3.04394e-17
C37 (\3\:SI VSS) capacitor c=1.01822e-16
C38 (\3\:SE VSS) capacitor c=6.5051e-17
C39 (\3\:SEb VSS) capacitor c=5.41549e-17
C40 (\3\:D VSS) capacitor c=2.14782e-17
C41 (\4\:CK VSS) capacitor c=2.71422e-17
C42 (\9\:CKb VSS) capacitor c=3.5637e-17
C43 (\7\:CKbb VSS) capacitor c=3.87324e-17
C44 (\4\:mout VSS) capacitor c=3.8234e-17
C45 (\3\:n20 VSS) capacitor c=7.296e-17
C46 (\5\:SN VSS) capacitor c=6.03465e-17
C47 (\6\:CKb VSS) capacitor c=2.79297e-17
C48 (\3\:CKbb VSS) capacitor c=2.65602e-17
C49 (\5\:CKb VSS) capacitor c=1.09941e-16
C50 (\13\:qbint VSS) capacitor c=4.07249e-17
C51 (\1\:SN VSS) capacitor c=4.91631e-17
C52 (\3\:n35 VSS) capacitor c=4.14903e-17
C53 (\5\:qbint VSS) capacitor c=2.10887e-17
C54 (\6\:SE VSS) capacitor c=5.546e-17
C55 (\2\:SI VSS) capacitor c=7.69442e-17
C56 (\4\:SE VSS) capacitor c=5.17184e-17
C57 (\2\:SEb VSS) capacitor c=7.89016e-17
C58 (\2\:SE VSS) capacitor c=3.32192e-17
C59 (\2\:D VSS) capacitor c=4.78521e-17
C60 (\3\:CK VSS) capacitor c=1.78896e-17
C61 (\10\:CKb VSS) capacitor c=2.4347e-17
C62 (\6\:CKbb VSS) capacitor c=5.35028e-17
C63 (\8\:CKb VSS) capacitor c=3.06212e-17
C64 (\3\:mout VSS) capacitor c=1.17646e-17
C65 (\2\:n20 VSS) capacitor c=3.91986e-17
C66 (\6\:SN VSS) capacitor c=1.78821e-17
C67 (\4\:CKbb VSS) capacitor c=4.33561e-17
C68 (\12\:qbint VSS) capacitor c=6.54864e-17
C69 (\2\:SN VSS) capacitor c=6.54519e-17
C70 (\4\:n35 VSS) capacitor c=3.01065e-17
C71 (\7\:qbint VSS) capacitor c=2.29144e-17
C72 (\6\:net492 VSS) capacitor c=1.10575e-17
C73 (\8\:SEb VSS) capacitor c=1.4145e-17
C74 (\18\:VDD VSS) capacitor c=2.8938e-17
C75 (\7\:Db VSS) capacitor c=4.60448e-17
C76 (\20\:VDD VSS) capacitor c=3.76333e-17
C77 (\11\:CKb VSS) capacitor c=8.38312e-17
C78 (\5\:Db VSS) capacitor c=2.63847e-17
C79 (\8\:n20 VSS) capacitor c=5.43249e-17
C80 (\22\:VDD VSS) capacitor c=9.02729e-17
C81 (\8\:mout VSS) capacitor c=1.23666e-16
C82 (\24\:VDD VSS) capacitor c=1.64595e-17
C83 (\12\:CKbb VSS) capacitor c=4.21516e-17
C84 (\10\:mout VSS) capacitor c=1.29018e-16
C85 (\5\:n35 VSS) capacitor c=3.69106e-17
C86 (\26\:VDD VSS) capacitor c=3.24625e-17
C87 (\3\:net405 VSS) capacitor c=8.11721e-17
C88 (\28\:VDD VSS) capacitor c=1.46927e-17
C89 (\14\:qbint VSS) capacitor c=3.4613e-17
C90 (\1\:Q VSS) capacitor c=5.28928e-17
C91 (\8\:net492 VSS) capacitor c=1.73509e-17
C92 (\1\:QN VSS) capacitor c=7.67567e-17
C93 (\1\:VDD VSS) capacitor c=1.26869e-16
C94 (\4\:SEb VSS) capacitor c=6.87009e-17
C95 (\17\:CKb VSS) capacitor c=9.16594e-17
C96 (\9\:Db VSS) capacitor c=9.38644e-17
C97 (\4\:n20 VSS) capacitor c=7.14773e-17
C98 (\6\:mout VSS) capacitor c=8.4901e-17
C99 (\8\:CKbb VSS) capacitor c=2.99823e-17
C100 (\12\:mout VSS) capacitor c=9.7175e-17
C101 (\9\:n35 VSS) capacitor c=7.86866e-17
C102 (\19\:qbint VSS) capacitor c=1.5387e-17
C103 (\3\:Q VSS) capacitor c=5.83322e-17
C104 (\12\:net492 VSS) capacitor c=1.87148e-17
C105 (\3\:QN VSS) capacitor c=3.22365e-17
C106 (\4\:qbint VSS) capacitor c=1.1996e-17
C107 (\2\:n35 VSS) capacitor c=2.54429e-17
C108 (\2\:CKbb VSS) capacitor c=2.85387e-17
C109 (\3\:CKb VSS) capacitor c=5.24702e-17
C110 (\2\:mout VSS) capacitor c=4.04154e-17
C111 (\2\:CK VSS) capacitor c=4.79975e-17
C112 (\10\:net492 VSS) capacitor c=1.39876e-17
C113 (\11\:net492 VSS) capacitor c=1.96417e-17
C114 (\16\:qbint VSS) capacitor c=2.30015e-17
C115 (\17\:qbint VSS) capacitor c=3.85106e-17
C116 (\18\:qbint VSS) capacitor c=3.25479e-17
C117 (\21\:qbint VSS) capacitor c=8.6354e-17
C118 (\7\:n35 VSS) capacitor c=1.35424e-16
C119 (\8\:n35 VSS) capacitor c=1.26868e-16
C120 (\7\:SN VSS) capacitor c=6.42852e-17
C121 (\8\:SN VSS) capacitor c=1.74551e-16
C122 (\9\:SN VSS) capacitor c=1.91077e-16
C123 (\5\:mout VSS) capacitor c=6.68344e-17
C124 (\10\:CKbb VSS) capacitor c=5.02415e-17
C125 (\11\:CKbb VSS) capacitor c=1.57834e-16
C126 (\14\:CKbb VSS) capacitor c=1.64454e-16
C127 (\6\:n20 VSS) capacitor c=7.99925e-17
C128 (\7\:n20 VSS) capacitor c=7.71747e-17
C129 (\5\:CK VSS) capacitor c=4.70367e-17
C130 (\13\:CKb VSS) capacitor c=8.61914e-17
C131 (\14\:CKb VSS) capacitor c=1.71678e-16
C132 (\15\:CKb VSS) capacitor c=1.6335e-16
C133 (\16\:CKb VSS) capacitor c=1.62936e-16
C134 (\4\:D VSS) capacitor c=7.14936e-17
C135 (\3\:Db VSS) capacitor c=1.50791e-16
C136 (\4\:Db VSS) capacitor c=1.52969e-16
C137 (\8\:SE VSS) capacitor c=6.51276e-17
C138 (\9\:SE VSS) capacitor c=7.59432e-17
C139 (\10\:SE VSS) capacitor c=3.06581e-17
C140 (\4\:SI VSS) capacitor c=7.76424e-17
C141 (\6\:SEb VSS) capacitor c=1.13525e-16
C142 (\7\:SEb VSS) capacitor c=7.50632e-17
C143 (\3\:VDD VSS) capacitor c=3.00603e-18
C144 (\5\:VDD VSS) capacitor c=2.20311e-17
C145 (\7\:VDD VSS) capacitor c=2.24909e-17
C146 (\8\:VDD VSS) capacitor c=2.9111e-17
C147 (\10\:VDD VSS) capacitor c=1.39542e-17
C148 (\11\:VDD VSS) capacitor c=1.2767e-17
C149 (\12\:VDD VSS) capacitor c=3.6772e-17
Rk31 (\5\:CK CK) resistor r=0.1901 c=0
Rk6 (\2\:Q Q) resistor r=0.2622 c=0
Rk7 (Q \4\:Q) resistor r=0.04331 c=0
Rk44 (\8\:SE SE) resistor r=0.09661 c=0
Rk43 (\8\:SE \9\:SE) resistor r=0.4184 c=0
Rk45 (SE \10\:SE) resistor r=0.09784 c=0
Rk18 (\8\:SN SN) resistor r=0.02622 c=0
Rk17 (\7\:SN \8\:SN) resistor r=0.2841 c=0
Rk19 (\8\:SN \9\:SN) resistor r=1.3825 c=0
Rk46 (SI \4\:SI) resistor r=0.1468 c=0
Rk74 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk75 (\3\:VSS \4\:VSS) resistor r=0.5369 c=0
Rk76 (\3\:VSS \6\:VSS) resistor r=0.2403 c=0
Rk77 (\4\:VSS \7\:VSS) resistor r=0.594 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.4308 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.1277 c=0
Rk80 (\9\:VSS \10\:VSS) resistor r=0.5965 c=0
Rk81 (\10\:VSS \11\:VSS) resistor r=0.2054 c=0
Rk82 (\11\:VSS \12\:VSS) resistor r=0.03992 c=0
Rk85 (\14\:VSS VSS) resistor r=0.1277 c=0
Rk84 (\12\:VSS \14\:VSS) resistor r=0.05496 c=0
Rk88 (\4\:VSS \18\:VSS) resistor r=0.2991 c=0
Rk89 (\7\:VSS \20\:VSS) resistor r=0.1337 c=0
Rk90 (\8\:VSS \22\:VSS) resistor r=0.2168 c=0
Rk91 (\10\:VSS \24\:VSS) resistor r=0.3156 c=0
Rk50 (\2\:VDD \3\:VDD) resistor r=0.1151 c=0
Rk51 (\3\:VDD \4\:VDD) resistor r=0.2355 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.243 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.4084 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.233 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.287 c=0
Rk56 (\8\:VDD \9\:VDD) resistor r=0.4802 c=0
Rk57 (\9\:VDD \10\:VDD) resistor r=0.233 c=0
Rk58 (\10\:VDD \11\:VDD) resistor r=0.1977 c=0
Rk59 (\11\:VDD \12\:VDD) resistor r=0.1952 c=0
Rk62 (\14\:VDD VDD) resistor r=0.09256 c=0
Rk61 (\12\:VDD \14\:VDD) resistor r=0.09006 c=0
Rk65 (\3\:VDD \19\:VDD) resistor r=0.2036 c=0
Rk66 (\5\:VDD \21\:VDD) resistor r=0.199 c=0
Rk67 (\7\:VDD \23\:VDD) resistor r=0.4309 c=0
Rk68 (\8\:VDD \25\:VDD) resistor r=0.04329 c=0
Rk69 (\10\:VDD \27\:VDD) resistor r=0.2057 c=0
Rk70 (\11\:VDD \29\:VDD) resistor r=0.2103 c=0
Rk37 (D \4\:D) resistor r=0.02026 c=0
Rk1 (\2\:QN QN) resistor r=0.3177 c=0
Rk2 (QN \4\:QN) resistor r=0.05414 c=0
Rk3 (\9\:net492 \10\:net492) resistor r=0.09366 c=0
Rk4 (\10\:net492 \11\:net492) resistor r=0.07727 c=0
Rk5 (\10\:net492 \13\:net492) resistor r=0.1296 c=0
Rk8 (\15\:qbint \16\:qbint) resistor r=0.2277 c=0
Rk9 (\16\:qbint \17\:qbint) resistor r=0.1497 c=0
Rk10 (\16\:qbint \18\:qbint) resistor r=0.06153 c=0
Rk11 (\18\:qbint \20\:qbint) resistor r=0.05742 c=0
Rk12 (\18\:qbint \21\:qbint) resistor r=0.4257 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=0.1625 c=0
Rk15 (\7\:n35 \8\:n35) resistor r=0.725 c=0
Rk16 (\7\:n35 \10\:n35) resistor r=0.3712 c=0
Rk32 (\12\:CKb \13\:CKb) resistor r=0.519 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.1432 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=1.286 c=0
Rk35 (\13\:CKb \16\:CKb) resistor r=0.5197 c=0
Rk36 (\16\:CKb \18\:CKb) resistor r=0.6929 c=0
Rk20 (\5\:mout \7\:mout) resistor r=0.2961 c=0
Rk21 (\7\:mout \9\:mout) resistor r=0.3404 c=0
Rk22 (\9\:mout \11\:mout) resistor r=0.8238 c=0
Rk23 (\11\:mout \13\:mout) resistor r=0.556 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.1124 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.3452 c=0
Rk26 (\11\:CKbb \13\:CKbb) resistor r=0.1731 c=0
Rk27 (\11\:CKbb \14\:CKbb) resistor r=1.1494 c=0
Rk28 (\5\:n20 \6\:n20) resistor r=0.3457 c=0
Rk29 (\6\:n20 \7\:n20) resistor r=0.3789 c=0
Rk30 (\6\:n20 \9\:n20) resistor r=0.1752 c=0
Rk38 (\2\:Db \3\:Db) resistor r=0.7655 c=0
Rk39 (\3\:Db \4\:Db) resistor r=0.6997 c=0
Rk40 (\4\:Db \6\:Db) resistor r=0.0511 c=0
Rk41 (\3\:Db \8\:Db) resistor r=0.2303 c=0
Rk42 (\4\:Db \10\:Db) resistor r=0.5108 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.7219 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.4893 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rk13 (\2\:net405 \4\:net405) resistor r=0.3382 c=0
Rl42 (\1\:CK \2\:CK) resistor r=226.203 c=0
Rl44 (\2\:CK \4\:CK) resistor r=68.9449 c=0
Rl43 (\2\:CK \3\:CK) resistor r=13.091 c=0
Rl53 (\5\:SE \6\:SE) resistor r=204.538 c=0
Rl54 (\6\:SE \7\:SE) resistor r=56.461 c=0
Rl50 (\3\:SE \4\:SE) resistor r=52.6149 c=0
Rl47 (\1\:SE \2\:SE) resistor r=47.2519 c=0
Rl31 (\4\:SN \5\:SN) resistor r=149.566 c=0
Rl32 (\5\:SN \6\:SN) resistor r=48.5844 c=0
Rl20 (\2\:SN \3\:SN) resistor r=119.895 c=0
Rl19 (\1\:SN \2\:SN) resistor r=92.3077 c=0
Rl51 (\1\:SI \2\:SI) resistor r=82.3533 c=0
Rl52 (\2\:SI \3\:SI) resistor r=193.136 c=0
Rl45 (\1\:D \2\:D) resistor r=220.387 c=0
Rl46 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl5 (net492 \6\:net492) resistor r=9.5287 c=0
Rl21 (\12\:qbint \11\:qbint) resistor r=181.461 c=0
Rl22 (\12\:qbint \13\:qbint) resistor r=29.5379 c=0
Rl12 (qbint \7\:qbint) resistor r=4.8851 c=0
Rl9 (\4\:qbint qbint) resistor r=82.084 c=0
Rl15 (\4\:qbint \10\:qbint) resistor r=53.0797 c=0
Rl10 (\4\:qbint \5\:qbint) resistor r=35.772 c=0
Rl16 (n35 \2\:n35) resistor r=28.0797 c=0
Rl17 (\2\:n35 \3\:n35) resistor r=60.772 c=0
Rl18 (\2\:n35 \4\:n35) resistor r=79.6836 c=0
Rl26 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=557.258 c=0
Rl41 (\9\:CKb \10\:CKb) resistor r=62.2302 c=0
Rl38 (\7\:CKb \8\:CKb) resistor r=29.5379 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=155.747 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=192.286 c=0
Rl30 (\3\:CKb \6\:CKb) resistor r=82.3738 c=0
Rl35 (mout \2\:mout) resistor r=131.572 c=0
Rl37 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl36 (\2\:mout \3\:mout) resistor r=3.1183 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=153.282 c=0
Rl40 (\6\:CKbb \7\:CKbb) resistor r=26.3736 c=0
Rl23 (CKbb \2\:CKbb) resistor r=128.08 c=0
Rl24 (\2\:CKbb \3\:CKbb) resistor r=35.772 c=0
Rl25 (\2\:CKbb \4\:CKbb) resistor r=89.2411 c=0
Rl33 (n20 \2\:n20) resistor r=57.4874 c=0
Rl34 (\2\:n20 \3\:n20) resistor r=126.9 c=0
Rl48 (SEb \2\:SEb) resistor r=93.4636 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=200.539 c=0
Rz3 (\4\:Q \3\:Q) resistor r=75 c=0
Rz19 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz15 (\4\:VDD \1\:VDD) resistor r=15 c=0
Rz16 (\6\:VDD \1\:VDD) resistor r=9.375 c=0
Rz17 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz18 (\14\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz1 (\4\:QN \3\:QN) resistor r=75 c=0
Rz2 (\13\:net492 \12\:net492) resistor r=75 c=0
Rz4 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz5 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz9 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\9\:Db \10\:Db) resistor r=75 c=0
Rz13 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry3 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry31 (VSS \1\:VSS) resistor r=20.6667 c=0
Ry26 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry27 (\4\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry28 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry29 (\11\:VSS \1\:VSS) resistor r=15.5 c=0
Ry30 (\14\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry19 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry20 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry22 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry1 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry2 (\9\:net492 \8\:net492) resistor r=62 c=0
Ry4 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry7 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\10\:mout \11\:mout) resistor r=62 c=0
Ry10 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry13 (\5\:Db \6\:Db) resistor r=62 c=0
Ry14 (\7\:Db \8\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\3\:CK \5\:CK) resistor r=45 c=0
Rx16 (\4\:SE \8\:SE) resistor r=45 c=0
Rx17 (\2\:SE \9\:SE) resistor r=45 c=0
Rx18 (\6\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SN \7\:SN) resistor r=45 c=0
Rx6 (\6\:SN \9\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\11\:net492 \6\:net492) resistor r=45 c=0
Rx2 (\17\:qbint \7\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\4\:n35 \8\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (\4\:CKbb \10\:CKbb) resistor r=45 c=0
Rx9 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57_1__rcx (\3\:QN net492 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.05e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:net492 \5\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=7.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\3\:Q qbint \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.098e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=4.98173e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\19\:qbint \3\:n35 \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1622e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net521 \1\:SN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.5e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (net518 \13\:qbint net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.263e-14 ps=4.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn52 (\9\:n35 \5\:CKb net518 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.755e-14 ps=7.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=3.75e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\9\:n35 \3\:CKbb \12\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\8\:CKbb \6\:CKb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.445e-14 ad=3.698e-14 ps=1.51e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (net442 \5\:SN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.445e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=2.45e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn31 (\6\:mout \3\:n20 net442 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net478 \4\:mout \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.325e-14 ad=9.42e-15 ps=9.4e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.25e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn36 (\4\:n20 \7\:CKbb net478 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.567e-14 ps=4.2e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=6.15e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn25 (\9\:Db \9\:CKb \4\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=3.698e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.55e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn20 (\17\:CKb \4\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn11 (net494 \3\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=5.292e-14 ps=8.2e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.125e-06 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.292e-14 ad=2.32e-14 ps=1.02e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=7.15e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=5.1e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn13 (net506 \3\:SI \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=4.05e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn10 (\4\:SEb \7\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=2e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mp56 (\8\:net492 \10\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=7.25e-14 ad=2.63e-14 ps=1.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.22326e-07 sb=7.67326e-07 sd=160n \
        sca=46.2604 scb=0.0284877 scc=0.00588421 m=(1)
mp55 (\1\:Q qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.775e-14 ad=6.24e-14 ps=1.725e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.42756e-07 sb=4.80256e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp45 (\14\:qbint n35 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.3e-14 ad=3.58e-14 ps=1.92e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.88468e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp50 (\3\:net405 \3\:SN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.63e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=3.6e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \11\:qbint \26\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.27326e-07 sb=1.55e-07 sd=160n \
        sca=10.1345 scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\5\:n35 CKbb net405 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\5\:n35 \4\:CKb \10\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\12\:CKbb \2\:CKb \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\8\:mout \4\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=4.73e-14 ps=1.83e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.15e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (\8\:mout n20 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=4.73e-14 ps=9.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.85e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (net417 mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=5.95e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\8\:n20 \7\:CKb net417 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=4.9e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp25 (\8\:n20 \5\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=2.85e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp20 (\11\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.285e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp11 (net433 \1\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=5.59e-14 ps=7.8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.065e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp12 (\7\:Db \1\:SE net433 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=5.375e-14 ps=9.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=7.6e-07 sd=160n sca=10.1579 \
        scb=0.00732238 scc=7.20014e-05 m=(1)
mp14 (\7\:Db SEb net441 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.612e-14 ad=5.375e-14 ps=5.8e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=4.65e-07 sd=160n sca=11.144 \
        scb=0.00785651 scc=7.24744e-05 m=(1)
mp13 (net441 \1\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.612e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=3.45e-07 sd=160n sca=12.0249 \
        scb=0.00887156 scc=7.63487e-05 m=(1)
mp10 (\8\:SEb \5\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.4e-07 sd=160n sca=15.8545 \
        scb=0.0153548 scc=0.000243119 m=(1)
ends SDFFSX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:44:47 2012 )
// Library name: gsclib045
// Cell name: SDFFSX4
// View name: extracted

simulator lang=spectre

subckt SDFFSX4 CK D Q QN SE SI SN VDD VSS
mp57_1__rcx (QN net492 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.27308e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(4)
C1 (CK VSS) capacitor c=1.07897e-16
C2 (SE VSS) capacitor c=4.28122e-17
C3 (SN VSS) capacitor c=1.91436e-16
C4 (SI VSS) capacitor c=4.08744e-17
C5 (QN VSS) capacitor c=2.12219e-16
C6 (VDD VSS) capacitor c=6.36787e-16
C7 (D VSS) capacitor c=4.07311e-17
C8 (Q VSS) capacitor c=2.84206e-16
C9 (net492 VSS) capacitor c=1.81435e-16
C10 (qbint VSS) capacitor c=2.25936e-16
C11 (n35 VSS) capacitor c=2.00069e-16
C12 (net518 VSS) capacitor c=3.18242e-18
C13 (CKb VSS) capacitor c=3.14608e-17
C14 (mout VSS) capacitor c=2.53797e-17
C15 (CKbb VSS) capacitor c=3.2253e-17
C16 (n20 VSS) capacitor c=2.52876e-17
C17 (Db VSS) capacitor c=4.95062e-17
C18 (net494 VSS) capacitor c=8.83234e-18
C19 (SEb VSS) capacitor c=3.16059e-17
C20 (net405 VSS) capacitor c=8.84634e-17
C21 (net417 VSS) capacitor c=1.10836e-18
C22 (net433 VSS) capacitor c=3.3673e-18
C23 (\7\:SE VSS) capacitor c=5.16962e-17
C24 (\3\:SI VSS) capacitor c=5.43405e-17
C25 (\2\:SE VSS) capacitor c=3.82346e-17
C26 (\3\:D VSS) capacitor c=4.76365e-17
C27 (\1\:CK VSS) capacitor c=3.2234e-17
C28 (\11\:CKb VSS) capacitor c=2.27367e-17
C29 (\5\:CKbb VSS) capacitor c=3.01266e-17
C30 (\5\:CKb VSS) capacitor c=6.92765e-17
C31 (\3\:mout VSS) capacitor c=9.13289e-17
C32 (\4\:n20 VSS) capacitor c=4.52523e-17
C33 (\4\:SN VSS) capacitor c=4.66164e-17
C34 (\3\:CKb VSS) capacitor c=5.23961e-17
C35 (\17\:qbint VSS) capacitor c=4.84791e-17
C36 (\1\:SN VSS) capacitor c=5.10147e-17
C37 (\16\:qbint VSS) capacitor c=3.39486e-17
C38 (\5\:SE VSS) capacitor c=2.72473e-17
C39 (\1\:SI VSS) capacitor c=6.32795e-17
C40 (\3\:SE VSS) capacitor c=6.80328e-17
C41 (\3\:SEb VSS) capacitor c=7.11705e-17
C42 (\1\:D VSS) capacitor c=3.83304e-17
C43 (\3\:CK VSS) capacitor c=4.83071e-17
C44 (\7\:CKb VSS) capacitor c=2.24096e-17
C45 (\9\:CKb VSS) capacitor c=4.81884e-17
C46 (\7\:CKbb VSS) capacitor c=3.91316e-17
C47 (\3\:n20 VSS) capacitor c=6.52637e-17
C48 (\6\:SN VSS) capacitor c=4.14056e-17
C49 (\3\:CKbb VSS) capacitor c=2.58667e-17
C50 (\19\:qbint VSS) capacitor c=2.1777e-17
C51 (\3\:SN VSS) capacitor c=4.35419e-17
C52 (\7\:qbint VSS) capacitor c=2.41776e-17
C53 (\6\:SE VSS) capacitor c=4.44425e-17
C54 (\2\:SI VSS) capacitor c=6.16765e-17
C55 (\4\:SE VSS) capacitor c=4.63733e-17
C56 (\2\:SEb VSS) capacitor c=6.4958e-17
C57 (\1\:SE VSS) capacitor c=4.24025e-17
C58 (\2\:D VSS) capacitor c=5.37235e-17
C59 (\2\:CK VSS) capacitor c=4.34401e-17
C60 (\6\:CKbb VSS) capacitor c=3.68352e-17
C61 (\6\:CKb VSS) capacitor c=2.697e-17
C62 (\2\:mout VSS) capacitor c=4.87037e-17
C63 (\5\:SN VSS) capacitor c=4.33772e-17
C64 (\4\:CKbb VSS) capacitor c=2.76806e-17
C65 (\4\:CKb VSS) capacitor c=2.69947e-17
C66 (\2\:CKb VSS) capacitor c=3.44443e-17
C67 (\18\:qbint VSS) capacitor c=4.38415e-17
C68 (\2\:SN VSS) capacitor c=6.10578e-17
C69 (\6\:n35 VSS) capacitor c=1.7363e-17
C70 (\9\:qbint VSS) capacitor c=2.28606e-17
C71 (\8\:net492 VSS) capacitor c=9.76281e-18
C72 (\8\:SEb VSS) capacitor c=1.40497e-17
C73 (\23\:VDD VSS) capacitor c=2.88936e-17
C74 (\8\:Db VSS) capacitor c=8.67738e-17
C75 (\25\:VDD VSS) capacitor c=1.8112e-17
C76 (\12\:CKb VSS) capacitor c=5.11594e-17
C77 (\27\:VDD VSS) capacitor c=1.41838e-17
C78 (\10\:CKbb VSS) capacitor c=1.02351e-16
C79 (\6\:Db VSS) capacitor c=8.98255e-17
C80 (\9\:n20 VSS) capacitor c=4.06099e-17
C81 (\29\:VDD VSS) capacitor c=1.49886e-17
C82 (\12\:mout VSS) capacitor c=3.04889e-17
C83 (\31\:VDD VSS) capacitor c=2.84519e-17
C84 (\14\:mout VSS) capacitor c=3.47413e-17
C85 (\10\:n35 VSS) capacitor c=8.59782e-17
C86 (\33\:VDD VSS) capacitor c=2.88405e-17
C87 (\3\:net405 VSS) capacitor c=9.82904e-17
C88 (\26\:qbint VSS) capacitor c=8.71294e-17
C89 (\14\:net492 VSS) capacitor c=3.24992e-17
C90 (\1\:VDD VSS) capacitor c=1.47395e-16
C91 (\4\:SEb VSS) capacitor c=7.52201e-17
C92 (\19\:CKb VSS) capacitor c=5.54035e-17
C93 (\8\:CKbb VSS) capacitor c=8.13697e-17
C94 (\4\:Db VSS) capacitor c=1.67562e-16
C95 (\5\:n20 VSS) capacitor c=5.14357e-17
C96 (\10\:mout VSS) capacitor c=2.97307e-17
C97 (\8\:mout VSS) capacitor c=9.51169e-17
C98 (\12\:n35 VSS) capacitor c=3.50758e-17
C99 (\24\:qbint VSS) capacitor c=2.33018e-17
C100 (\18\:net492 VSS) capacitor c=1.51392e-17
C101 (\6\:qbint VSS) capacitor c=1.36239e-17
C102 (\2\:CKbb VSS) capacitor c=2.25089e-17
C103 (\2\:n20 VSS) capacitor c=3.60134e-17
C104 (\16\:net492 VSS) capacitor c=2.07558e-17
C105 (\17\:net492 VSS) capacitor c=1.82328e-17
C106 (\8\:CKb VSS) capacitor c=3.19551e-17
C107 (\20\:qbint VSS) capacitor c=6.73486e-17
C108 (\21\:qbint VSS) capacitor c=6.32907e-17
C109 (\23\:qbint VSS) capacitor c=4.13606e-17
C110 (\8\:n35 VSS) capacitor c=1.6001e-16
C111 (\9\:n35 VSS) capacitor c=1.61436e-16
C112 (\7\:SN VSS) capacitor c=1.84111e-16
C113 (\8\:SN VSS) capacitor c=8.39011e-17
C114 (\4\:mout VSS) capacitor c=5.24454e-17
C115 (\5\:mout VSS) capacitor c=4.09218e-17
C116 (\6\:mout VSS) capacitor c=3.63502e-17
C117 (\7\:mout VSS) capacitor c=6.58506e-17
C118 (\7\:n20 VSS) capacitor c=6.37654e-17
C119 (\8\:n20 VSS) capacitor c=4.5633e-17
C120 (\12\:CKbb VSS) capacitor c=2.00944e-16
C121 (\13\:CKbb VSS) capacitor c=2.03956e-16
C122 (\14\:CKbb VSS) capacitor c=6.01167e-17
C123 (\14\:CKb VSS) capacitor c=1.2857e-16
C124 (\15\:CKb VSS) capacitor c=9.89509e-17
C125 (\16\:CKb VSS) capacitor c=1.44786e-16
C126 (\17\:CKb VSS) capacitor c=1.5904e-16
C127 (\18\:CKb VSS) capacitor c=8.99973e-17
C128 (\4\:D VSS) capacitor c=7.3527e-17
C129 (\3\:Db VSS) capacitor c=2.16673e-16
C130 (\4\:SI VSS) capacitor c=4.71633e-17
C131 (\8\:SE VSS) capacitor c=5.30492e-17
C132 (\9\:SE VSS) capacitor c=7.64093e-17
C133 (\10\:SE VSS) capacitor c=6.47426e-17
C134 (\6\:SEb VSS) capacitor c=9.67665e-17
C135 (\7\:SEb VSS) capacitor c=5.68198e-17
C136 (\3\:VDD VSS) capacitor c=1.63005e-17
C137 (\5\:VDD VSS) capacitor c=1.42298e-17
C138 (\6\:VDD VSS) capacitor c=2.86741e-17
C139 (\8\:VDD VSS) capacitor c=1.65619e-17
C140 (\9\:VDD VSS) capacitor c=1.14534e-17
C141 (\11\:VDD VSS) capacitor c=8.29281e-19
C142 (\13\:VDD VSS) capacitor c=2.89813e-16
Rk47 (\4\:CK CK) resistor r=0.00264 c=0
Rk60 (\2\:VSS \3\:VSS) resistor r=0.1402 c=0
Rk61 (\3\:VSS \4\:VSS) resistor r=0.4408 c=0
Rk62 (\4\:VSS \5\:VSS) resistor r=0.1703 c=0
Rk63 (\5\:VSS \6\:VSS) resistor r=0.06905 c=0
Rk64 (\6\:VSS \7\:VSS) resistor r=0.6003 c=0
Rk65 (\7\:VSS \8\:VSS) resistor r=0.2794 c=0
Rk66 (\8\:VSS \9\:VSS) resistor r=0.2496 c=0
Rk72 (\10\:VSS VSS) resistor r=0.1901 c=0
Rk67 (\9\:VSS \10\:VSS) resistor r=0.6065 c=0
Rk74 (\3\:VSS \18\:VSS) resistor r=0.3106 c=0
Rk75 (\4\:VSS \20\:VSS) resistor r=0.2632 c=0
Rk76 (\6\:VSS \22\:VSS) resistor r=0.04329 c=0
Rk77 (\7\:VSS \24\:VSS) resistor r=0.278 c=0
Rk78 (\8\:VSS \26\:VSS) resistor r=0.04329 c=0
Rk54 (SE \8\:SE) resistor r=0.1929 c=0
Rk55 (\8\:SE \9\:SE) resistor r=0.2622 c=0
Rk56 (\9\:SE \10\:SE) resistor r=0.4257 c=0
Rk25 (\7\:SN SN) resistor r=1.33 c=0
Rk26 (SN \8\:SN) resistor r=0.4257 c=0
Rk53 (SI \4\:SI) resistor r=0.01176 c=0
Rk87 (\2\:VDD \3\:VDD) resistor r=0.1477 c=0
Rk88 (\3\:VDD \4\:VDD) resistor r=0.3533 c=0
Rk89 (\4\:VDD \5\:VDD) resistor r=0.1001 c=0
Rk90 (\5\:VDD \6\:VDD) resistor r=0.2653 c=0
Rk91 (\6\:VDD \7\:VDD) resistor r=0.4862 c=0
Rk92 (\7\:VDD \8\:VDD) resistor r=0.1192 c=0
Rk93 (\8\:VDD \9\:VDD) resistor r=0.3672 c=0
Rk94 (\9\:VDD \10\:VDD) resistor r=0.263 c=0
Rk95 (\10\:VDD \11\:VDD) resistor r=0.238 c=0
Rk96 (\11\:VDD \12\:VDD) resistor r=0.1126 c=0
Rk97 (\12\:VDD \13\:VDD) resistor r=0.1201 c=0
Rk103 (\18\:VDD VDD) resistor r=0.1402 c=0
Rk102 (\13\:VDD \18\:VDD) resistor r=0.06499 c=0
Rk107 (\3\:VDD \24\:VDD) resistor r=0.2036 c=0
Rk108 (\5\:VDD \26\:VDD) resistor r=0.2036 c=0
Rk109 (\6\:VDD \28\:VDD) resistor r=0.07369 c=0
Rk110 (\8\:VDD \30\:VDD) resistor r=0.04329 c=0
Rk111 (\9\:VDD \32\:VDD) resistor r=0.1557 c=0
Rk112 (\11\:VDD \34\:VDD) resistor r=0.219 c=0
Rk48 (D \4\:D) resistor r=0.05101 c=0
Rk7 (\15\:net492 \16\:net492) resistor r=0.2251 c=0
Rk8 (\16\:net492 \17\:net492) resistor r=0.1311 c=0
Rk9 (\16\:net492 \19\:net492) resistor r=0.1174 c=0
Rk16 (\20\:qbint \21\:qbint) resistor r=0.3788 c=0
Rk17 (\21\:qbint \22\:qbint) resistor r=0.06153 c=0
Rk18 (\22\:qbint \23\:qbint) resistor r=0.1475 c=0
Rk19 (\21\:qbint \25\:qbint) resistor r=0.1041 c=0
Rk20 (\22\:qbint \27\:qbint) resistor r=0.3776 c=0
Rk22 (\8\:n35 \9\:n35) resistor r=1.0176 c=0
Rk23 (\9\:n35 \11\:n35) resistor r=0.4233 c=0
Rk24 (\9\:n35 \13\:n35) resistor r=0.08643 c=0
Rk41 (\13\:CKb \14\:CKb) resistor r=0.3463 c=0
Rk42 (\14\:CKb \15\:CKb) resistor r=0.4032 c=0
Rk43 (\14\:CKb \16\:CKb) resistor r=0.6196 c=0
Rk44 (\16\:CKb \17\:CKb) resistor r=0.9034 c=0
Rk45 (\17\:CKb \18\:CKb) resistor r=0.5308 c=0
Rk46 (\15\:CKb \20\:CKb) resistor r=0.3914 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2233 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.1867 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.2377 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.4579 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.1216 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1128 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1202 c=0
Rk37 (\9\:CKbb \11\:CKbb) resistor r=0.3652 c=0
Rk38 (\11\:CKbb \12\:CKbb) resistor r=0.4421 c=0
Rk39 (\12\:CKbb \13\:CKbb) resistor r=1.246 c=0
Rk40 (\12\:CKbb \14\:CKbb) resistor r=0.246 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3333 c=0
Rk35 (\7\:n20 \8\:n20) resistor r=0.2209 c=0
Rk36 (\7\:n20 \10\:n20) resistor r=0.0932 c=0
Rk49 (\2\:Db \3\:Db) resistor r=0.3001 c=0
Rk50 (\3\:Db \5\:Db) resistor r=1.1436 c=0
Rk51 (\5\:Db \7\:Db) resistor r=0.3956 c=0
Rk52 (\3\:Db \9\:Db) resistor r=0.6019 c=0
Rk57 (\5\:SEb \6\:SEb) resistor r=0.7996 c=0
Rk58 (\6\:SEb \7\:SEb) resistor r=0.4064 c=0
Rk59 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rk21 (\2\:net405 \4\:net405) resistor r=0.4518 c=0
Rl57 (\1\:CK \2\:CK) resistor r=62.2302 c=0
Rl58 (\2\:CK \3\:CK) resistor r=158.384 c=0
Rl68 (\6\:SE \7\:SE) resistor r=178.021 c=0
Rl67 (\5\:SE \6\:SE) resistor r=35.7134 c=0
Rl64 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl61 (\1\:SE \2\:SE) resistor r=62.7538 c=0
Rl43 (\4\:SN \5\:SN) resistor r=99.3524 c=0
Rl44 (\5\:SN \6\:SN) resistor r=29.5379 c=0
Rl34 (\1\:SN \2\:SN) resistor r=119.922 c=0
Rl35 (\2\:SN \3\:SN) resistor r=102.615 c=0
Rl66 (\2\:SI \3\:SI) resistor r=130.12 c=0
Rl65 (\1\:SI \2\:SI) resistor r=84.4104 c=0
Rl60 (\2\:D \3\:D) resistor r=118.464 c=0
Rl59 (\1\:D \2\:D) resistor r=113.016 c=0
Rl7 (net492 \8\:net492) resistor r=9.5287 c=0
Rl36 (\18\:qbint \17\:qbint) resistor r=193 c=0
Rl37 (\18\:qbint \19\:qbint) resistor r=29.5379 c=0
Rl20 (qbint \9\:qbint) resistor r=4.8851 c=0
Rl17 (\6\:qbint qbint) resistor r=68.5478 c=0
Rl27 (\6\:qbint \16\:qbint) resistor r=105.003 c=0
Rl18 (\6\:qbint \7\:qbint) resistor r=28.0797 c=0
Rl32 (n35 \6\:n35) resistor r=4.8851 c=0
Rl56 (\10\:CKb \11\:CKb) resistor r=65.0908 c=0
Rl50 (\5\:CKb \6\:CKb) resistor r=62.2302 c=0
Rl42 (\3\:CKb \4\:CKb) resistor r=105.746 c=0
Rl38 (CKb \2\:CKb) resistor r=97.3098 c=0
Rl53 (\7\:CKb \8\:CKb) resistor r=24.1336 c=0
Rl54 (\8\:CKb \9\:CKb) resistor r=179.653 c=0
Rl55 (\8\:CKb \10\:CKb) resistor r=3.3568 c=0
Rl48 (mout \2\:mout) resistor r=28.8462 c=0
Rl49 (\2\:mout \3\:mout) resistor r=91.2285 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl52 (\6\:CKbb \7\:CKbb) resistor r=100.257 c=0
Rl39 (CKbb \2\:CKbb) resistor r=74.2335 c=0
Rl40 (\2\:CKbb \3\:CKbb) resistor r=58.8489 c=0
Rl41 (\2\:CKbb \4\:CKbb) resistor r=62.3759 c=0
Rl45 (n20 \2\:n20) resistor r=1.2334 c=0
Rl47 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl46 (\2\:n20 \3\:n20) resistor r=150.368 c=0
Rl62 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl63 (\2\:SEb \3\:SEb) resistor r=210.285 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz18 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz20 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz28 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz29 (\4\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz30 (\7\:VDD \1\:VDD) resistor r=7.5 c=0
Rz31 (\10\:VDD \1\:VDD) resistor r=15 c=0
Rz32 (\12\:VDD \1\:VDD) resistor r=37.5 c=0
Rz33 (\13\:VDD \1\:VDD) resistor r=75 c=0
Rz34 (\18\:VDD \1\:VDD) resistor r=6.25 c=0
Rz3 (\19\:net492 \18\:net492) resistor r=75 c=0
Rz6 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz7 (\13\:n35 \12\:n35) resistor r=75 c=0
Rz12 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\10\:mout \11\:mout) resistor r=75 c=0
Rz11 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz10 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\4\:Db \5\:Db) resistor r=75 c=0
Rz15 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry22 (VSS \1\:VSS) resistor r=12.4 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry19 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry24 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry25 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry27 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry28 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry29 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry3 (\15\:net492 \14\:net492) resistor r=62 c=0
Ry6 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry9 (\11\:n35 \10\:n35) resistor r=62 c=0
Ry14 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry10 (\12\:mout \13\:mout) resistor r=62 c=0
Ry11 (\14\:mout \15\:mout) resistor r=62 c=0
Ry13 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry12 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry15 (\6\:Db \7\:Db) resistor r=62 c=0
Ry16 (\8\:Db \9\:Db) resistor r=62 c=0
Ry17 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry7 (net405 \2\:net405) resistor r=62 c=0
Ry8 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\6\:SE \8\:SE) resistor r=45 c=0
Rx19 (\4\:SE \9\:SE) resistor r=45 c=0
Rx20 (\1\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SN \7\:SN) resistor r=45 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx16 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\17\:net492 \8\:net492) resistor r=45 c=0
Rx2 (\20\:qbint \18\:qbint) resistor r=45 c=0
Rx3 (\23\:qbint \9\:qbint) resistor r=45 c=0
Rx4 (\8\:n35 \6\:n35) resistor r=45 c=0
Rx11 (\10\:CKb \15\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx7 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (n20 \8\:n20) resistor r=45 c=0
Rx21 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57_1__rcx (QN net492 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=4.16e-14 ps=9.95e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn56 (\18\:net492 \7\:qbint \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.08e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18462e-07 sb=1.61692e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn55_1__rcx (Q qbint \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.077e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.23462e-07 sb=1.52625e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\24\:qbint n35 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.882e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13768e-06 sb=1.24927e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn50 (net521 \3\:SN \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.935e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60638e-06 sb=1.16e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn52 (\12\:n35 CKb net518 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.25e-14 ad=3.262e-14 ps=1.29e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.1e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn51 (net518 \19\:qbint net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=7.25e-14 ps=6.1e-07 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.81138e-06 sb=9.55e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn40 (\12\:n35 \3\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=3.262e-14 ps=5.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn30 (net442 \6\:SN \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=8.7e-15 ps=1.18e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn31 (\10\:mout \3\:n20 net442 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn35 (net478 mout \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn36 (\5\:n20 \7\:CKbb net478 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn25 (\4\:Db \9\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\8\:CKbb \7\:CKb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.175e-14 ad=2.972e-14 ps=1.48e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.8e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn20 (\19\:CKb \3\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=3.552e-14 ps=9.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.265e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\4\:SEb \5\:SE \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn11 (net494 \1\:D \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=4.205e-14 ps=9.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=9.9e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.55e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.5e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn13 (net506 \1\:SI \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp56 (\14\:net492 \16\:qbint \13\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=4.38e-14 ps=1.1e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.12308e-07 sb=1.52744e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(1)
mp55 (Q qbint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.12e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17308e-07 sb=1.32244e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp45_1__rcx (\26\:qbint n35 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.827e-14 ad=4.96e-14 ps=1.09e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13016e-06 sb=6.59194e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(2)
mp50 (\3\:net405 \1\:SN \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.895e-14 ad=3.44e-14 ps=1.08e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=3.35698e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\3\:net405 \17\:qbint \33\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=2.81e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.81e-06 sb=1.30698e-07 sd=160n \
        sca=10.2104 scb=0.00747301 scc=8.05149e-05 m=(1)
mp52 (\10\:n35 CKbb net405 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.91e-14 ad=6.558e-14 ps=1.09e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.28372e-07 sb=4.72326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\10\:n35 \3\:CKb \14\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.63e-14 ad=6.558e-14 ps=7.1e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78372e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\12\:mout \4\:SN \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.842e-14 ad=3.977e-14 ps=2.24e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02791e-07 sb=1.02e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (\12\:mout \4\:n20 \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.64e-14 ad=3.977e-14 ps=1.9e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32791e-07 sb=7.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp35 (net417 \3\:mout \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=1.29e-14 ps=1.9e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.27791e-07 sb=5.95e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\9\:n20 \5\:CKb net417 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.407e-14 ps=5.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.32791e-07 sb=4.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\9\:n20 \5\:CKbb \6\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.407e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.82791e-07 sb=2.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\10\:CKbb \11\:CKb \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.99e-14 ad=3.01e-14 ps=1.97e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19767e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\12\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=2.63e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.25e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp11 (net433 \3\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.87e-14 ps=7.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42326e-07 sb=1.03e-06 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp12 (\8\:Db \2\:SE net433 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.87e-14 ps=7.9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.67326e-07 sb=8.05e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp14 (\8\:Db SEb net441 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.87e-14 ps=8.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.92326e-07 sb=5.8e-07 sd=160n sca=10.1879 \
        scb=0.00732855 scc=7.2002e-05 m=(1)
mp13 (net441 \3\:SI \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.085e-14 ps=7.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02733e-06 sb=3.45e-07 sd=160n sca=10.9165 \
        scb=0.00767076 scc=7.22049e-05 m=(1)
mp10 (\8\:SEb \7\:SE \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23233e-06 sb=1.4e-07 sd=160n sca=12.4536 \
        scb=0.00949372 scc=8.10217e-05 m=(1)
ends SDFFSX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:45:26 2012 )
// Library name: gsclib045
// Cell name: SDFFSXL
// View name: extracted

simulator lang=spectre

subckt SDFFSXL CK D Q QN SE SI SN VDD VSS
mp57 (\1\:QN net492 \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.65e-14 ps=9.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.69767e-07 sd=160n sca=23.1398 \
        scb=0.0253243 scc=0.00148794 m=(1)
C1 (CK VSS) capacitor c=5.18437e-17
C2 (Q VSS) capacitor c=2.19164e-17
C3 (SE VSS) capacitor c=5.04131e-17
C4 (SN VSS) capacitor c=1.85117e-16
C5 (SI VSS) capacitor c=5.06072e-17
C6 (QN VSS) capacitor c=4.92953e-17
C7 (VDD VSS) capacitor c=4.09186e-16
C8 (D VSS) capacitor c=7.78883e-17
C9 (net492 VSS) capacitor c=2.85379e-17
C10 (qbint VSS) capacitor c=1.33934e-17
C11 (n35 VSS) capacitor c=3.27562e-17
C12 (net518 VSS) capacitor c=1.75078e-18
C13 (CKb VSS) capacitor c=1.60144e-17
C14 (mout VSS) capacitor c=7.35231e-17
C15 (CKbb VSS) capacitor c=2.74511e-17
C16 (net442 VSS) capacitor c=2.18407e-18
C17 (n20 VSS) capacitor c=3.32858e-17
C18 (net478 VSS) capacitor c=1.42439e-18
C19 (Db VSS) capacitor c=9.04784e-17
C20 (net494 VSS) capacitor c=5.02687e-18
C21 (net405 VSS) capacitor c=7.36257e-17
C22 (\8\:SE VSS) capacitor c=5.1512e-17
C23 (\3\:SI VSS) capacitor c=5.28084e-17
C24 (\4\:SEb VSS) capacitor c=3.25819e-17
C25 (\1\:SE VSS) capacitor c=4.64499e-17
C26 (\1\:D VSS) capacitor c=7.11635e-17
C27 (\1\:CK VSS) capacitor c=4.21234e-17
C28 (\5\:CKbb VSS) capacitor c=4.52891e-17
C29 (\7\:CKb VSS) capacitor c=7.27664e-17
C30 (\4\:SN VSS) capacitor c=6.54936e-17
C31 (\2\:CKb VSS) capacitor c=4.03267e-17
C32 (\4\:CKb VSS) capacitor c=1.04004e-16
C33 (\4\:CKbb VSS) capacitor c=6.65152e-17
C34 (\8\:qbint VSS) capacitor c=6.87187e-17
C35 (\3\:SN VSS) capacitor c=4.70031e-17
C36 (\3\:n35 VSS) capacitor c=4.72895e-17
C37 (\5\:qbint VSS) capacitor c=1.80417e-17
C38 (\5\:SE VSS) capacitor c=2.82009e-17
C39 (\1\:SI VSS) capacitor c=7.62547e-17
C40 (\3\:SE VSS) capacitor c=6.44432e-17
C41 (\3\:SEb VSS) capacitor c=7.35591e-17
C42 (\3\:D VSS) capacitor c=2.35583e-17
C43 (\3\:CK VSS) capacitor c=3.5496e-17
C44 (\9\:CKb VSS) capacitor c=3.68131e-17
C45 (\7\:CKbb VSS) capacitor c=4.15858e-17
C46 (\4\:mout VSS) capacitor c=4.26748e-17
C47 (\3\:n20 VSS) capacitor c=5.31372e-17
C48 (\5\:SN VSS) capacitor c=5.0473e-17
C49 (\6\:CKb VSS) capacitor c=4.24489e-17
C50 (\3\:CKbb VSS) capacitor c=2.95756e-17
C51 (\5\:CKb VSS) capacitor c=1.09894e-16
C52 (\10\:qbint VSS) capacitor c=3.98005e-17
C53 (\1\:SN VSS) capacitor c=5.5653e-17
C54 (\6\:qbint VSS) capacitor c=1.27492e-17
C55 (\7\:qbint VSS) capacitor c=1.13831e-17
C56 (\3\:net492 VSS) capacitor c=1.66249e-17
C57 (\7\:SE VSS) capacitor c=6.02643e-17
C58 (\2\:SI VSS) capacitor c=7.33264e-17
C59 (\4\:SE VSS) capacitor c=5.39892e-17
C60 (\2\:SE VSS) capacitor c=4.47177e-17
C61 (\2\:D VSS) capacitor c=4.09913e-17
C62 (\2\:CK VSS) capacitor c=4.14279e-17
C63 (\10\:CKb VSS) capacitor c=2.69752e-17
C64 (\8\:CKb VSS) capacitor c=2.64695e-17
C65 (\6\:CKbb VSS) capacitor c=6.45229e-17
C66 (\3\:mout VSS) capacitor c=1.5963e-17
C67 (\2\:n20 VSS) capacitor c=4.16629e-17
C68 (\6\:SN VSS) capacitor c=2.70453e-17
C69 (\9\:qbint VSS) capacitor c=6.82625e-17
C70 (\2\:SN VSS) capacitor c=9.06967e-17
C71 (\3\:qbint VSS) capacitor c=4.28999e-18
C72 (\2\:net492 VSS) capacitor c=2.18126e-17
C73 (\9\:SEb VSS) capacitor c=1.37027e-17
C74 (\1\:VDD VSS) capacitor c=5.29302e-17
C75 (\6\:Db VSS) capacitor c=4.80189e-17
C76 (\15\:VDD VSS) capacitor c=3.61431e-17
C77 (\11\:CKb VSS) capacitor c=6.87092e-17
C78 (\4\:Db VSS) capacitor c=1.30972e-16
C79 (\4\:n20 VSS) capacitor c=2.78609e-17
C80 (\17\:VDD VSS) capacitor c=1.41557e-17
C81 (\7\:mout VSS) capacitor c=8.46079e-17
C82 (\19\:VDD VSS) capacitor c=1.89202e-17
C83 (\13\:CKbb VSS) capacitor c=5.30794e-17
C84 (\11\:mout VSS) capacitor c=1.40398e-16
C85 (\5\:n35 VSS) capacitor c=4.39265e-17
C86 (\21\:VDD VSS) capacitor c=3.35174e-17
C87 (\3\:net405 VSS) capacitor c=8.88852e-17
C88 (\23\:VDD VSS) capacitor c=1.2917e-17
C89 (\15\:qbint VSS) capacitor c=5.31997e-17
C90 (\3\:Q VSS) capacitor c=3.7267e-17
C91 (\25\:VDD VSS) capacitor c=5.10556e-17
C92 (\7\:net492 VSS) capacitor c=5.401e-17
C93 (\1\:QN VSS) capacitor c=4.47069e-17
C94 (\27\:VDD VSS) capacitor c=1.55673e-17
C95 (\4\:VDD VSS) capacitor c=1.08849e-16
C96 (\5\:SEb VSS) capacitor c=5.16465e-17
C97 (\17\:CKb VSS) capacitor c=7.89237e-17
C98 (\8\:Db VSS) capacitor c=8.08133e-17
C99 (\8\:n20 VSS) capacitor c=6.40021e-17
C100 (\9\:mout VSS) capacitor c=3.09559e-17
C101 (\10\:CKbb VSS) capacitor c=3.6161e-17
C102 (\13\:mout VSS) capacitor c=1.19629e-16
C103 (\9\:n35 VSS) capacitor c=8.93905e-17
C104 (\13\:qbint VSS) capacitor c=6.2601e-17
C105 (\1\:Q VSS) capacitor c=6.11221e-17
C106 (\5\:net492 VSS) capacitor c=8.85728e-17
C107 (\3\:QN VSS) capacitor c=3.81341e-17
C108 (\2\:qbint VSS) capacitor c=6.38025e-18
C109 (\4\:qbint VSS) capacitor c=5.52124e-18
C110 (\2\:n35 VSS) capacitor c=5.25713e-17
C111 (\2\:CKbb VSS) capacitor c=2.88677e-17
C112 (\3\:CKb VSS) capacitor c=2.86163e-17
C113 (\2\:mout VSS) capacitor c=3.91742e-17
C114 (\2\:SEb VSS) capacitor c=7.62051e-17
C115 (\4\:net492 VSS) capacitor c=7.18577e-17
C116 (\11\:qbint VSS) capacitor c=6.27733e-17
C117 (\12\:qbint VSS) capacitor c=8.48607e-17
C118 (\17\:qbint VSS) capacitor c=7.4612e-17
C119 (\7\:n35 VSS) capacitor c=1.38245e-16
C120 (\8\:n35 VSS) capacitor c=1.11046e-16
C121 (\7\:SN VSS) capacitor c=1.62795e-16
C122 (\8\:SN VSS) capacitor c=3.16847e-17
C123 (\5\:mout VSS) capacitor c=6.67515e-17
C124 (\6\:mout VSS) capacitor c=4.65889e-17
C125 (\8\:CKbb VSS) capacitor c=1.59511e-16
C126 (\9\:CKbb VSS) capacitor c=1.21261e-16
C127 (\12\:CKbb VSS) capacitor c=4.18913e-17
C128 (\6\:n20 VSS) capacitor c=7.06639e-17
C129 (\7\:n20 VSS) capacitor c=6.3775e-17
C130 (\4\:CK VSS) capacitor c=4.93909e-17
C131 (\13\:CKb VSS) capacitor c=8.73951e-17
C132 (\14\:CKb VSS) capacitor c=7.86788e-17
C133 (\15\:CKb VSS) capacitor c=1.08783e-16
C134 (\16\:CKb VSS) capacitor c=1.4315e-16
C135 (\4\:D VSS) capacitor c=2.14096e-17
C136 (\3\:Db VSS) capacitor c=1.56683e-16
C137 (\4\:SI VSS) capacitor c=7.33154e-17
C138 (\9\:SE VSS) capacitor c=7.0928e-17
C139 (\10\:SE VSS) capacitor c=7.07007e-17
C140 (\7\:SEb VSS) capacitor c=7.26632e-17
C141 (\8\:SEb VSS) capacitor c=5.69655e-17
C142 (\6\:VDD VSS) capacitor c=4.17799e-17
C143 (\7\:VDD VSS) capacitor c=1.41408e-17
C144 (\9\:VDD VSS) capacitor c=1.86211e-17
C145 (\11\:VDD VSS) capacitor c=9.47978e-18
C146 (\12\:VDD VSS) capacitor c=8.50535e-18
C147 (\14\:VDD VSS) capacitor c=5.03782e-18
Rk29 (\4\:CK CK) resistor r=0.1912 c=0
Rk6 (\4\:Q Q) resistor r=0.04195 c=0
Rk5 (\2\:Q \4\:Q) resistor r=0.219 c=0
Rk42 (\9\:SE SE) resistor r=0.1768 c=0
Rk41 (\9\:SE \10\:SE) resistor r=0.4141 c=0
Rk43 (SE \11\:SE) resistor r=0.005694 c=0
Rk15 (\7\:SN SN) resistor r=1.3139 c=0
Rk16 (SN \8\:SN) resistor r=0.09304 c=0
Rk40 (SI \4\:SI) resistor r=0.06453 c=0
Rk1 (\2\:QN QN) resistor r=0.3587 c=0
Rk2 (QN \4\:QN) resistor r=0.03632 c=0
Rk62 (\2\:VDD \3\:VDD) resistor r=0.6249 c=0
Rk63 (\3\:VDD \5\:VDD) resistor r=0.02988 c=0
Rk64 (\5\:VDD \6\:VDD) resistor r=0.639 c=0
Rk65 (\6\:VDD \7\:VDD) resistor r=0.2694 c=0
Rk66 (\7\:VDD \8\:VDD) resistor r=0.1417 c=0
Rk67 (\8\:VDD \9\:VDD) resistor r=0.461 c=0
Rk68 (\9\:VDD \10\:VDD) resistor r=0.09004 c=0
Rk69 (\10\:VDD \11\:VDD) resistor r=0.1076 c=0
Rk70 (\11\:VDD \12\:VDD) resistor r=0.353 c=0
Rk71 (\12\:VDD \13\:VDD) resistor r=0.03991 c=0
Rk73 (\14\:VDD VDD) resistor r=0.0171 c=0
Rk72 (\13\:VDD \14\:VDD) resistor r=0.3332 c=0
Rk74 (\3\:VDD \16\:VDD) resistor r=0.2233 c=0
Rk75 (\6\:VDD \18\:VDD) resistor r=0.07358 c=0
Rk76 (\7\:VDD \20\:VDD) resistor r=0.04328 c=0
Rk77 (\9\:VDD \22\:VDD) resistor r=0.2054 c=0
Rk78 (\11\:VDD \24\:VDD) resistor r=0.21 c=0
Rk79 (\12\:VDD \26\:VDD) resistor r=0.4203 c=0
Rk80 (\14\:VDD \28\:VDD) resistor r=0.3464 c=0
Rk35 (\4\:D D) resistor r=0.0173 c=0
Rk47 (\2\:VSS \4\:VSS) resistor r=0.7083 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.622 c=0
Rk49 (\5\:VSS \6\:VSS) resistor r=0.1803 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.2345 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.5152 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=0.1201 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.4057 c=0
Rk55 (\11\:VSS VSS) resistor r=0.1507 c=0
Rk54 (\10\:VSS \11\:VSS) resistor r=0.2254 c=0
Rk56 (\4\:VSS \13\:VSS) resistor r=0.3183 c=0
Rk57 (\5\:VSS \15\:VSS) resistor r=0.2133 c=0
Rk58 (\7\:VSS \17\:VSS) resistor r=0.04328 c=0
Rk59 (\9\:VSS \19\:VSS) resistor r=0.3058 c=0
Rk60 (\10\:VSS \21\:VSS) resistor r=0.07358 c=0
Rk61 (VSS \23\:VSS) resistor r=0.3828 c=0
Rk3 (\4\:net492 \6\:net492) resistor r=0.5929 c=0
Rk4 (\6\:net492 \8\:net492) resistor r=0.2882 c=0
Rk7 (\11\:qbint \12\:qbint) resistor r=0.3563 c=0
Rk8 (\12\:qbint \14\:qbint) resistor r=0.1393 c=0
Rk9 (\12\:qbint \16\:qbint) resistor r=0.4743 c=0
Rk10 (\14\:qbint \17\:qbint) resistor r=0.5678 c=0
Rk12 (\6\:n35 \7\:n35) resistor r=0.2222 c=0
Rk13 (\7\:n35 \8\:n35) resistor r=0.6787 c=0
Rk14 (\7\:n35 \10\:n35) resistor r=0.3893 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.3782 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.2191 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=0.7001 c=0
Rk33 (\13\:CKb \16\:CKb) resistor r=0.4406 c=0
Rk34 (\16\:CKb \18\:CKb) resistor r=0.587 c=0
Rk17 (\5\:mout \6\:mout) resistor r=0.2914 c=0
Rk18 (\6\:mout \8\:mout) resistor r=0.2281 c=0
Rk19 (\6\:mout \10\:mout) resistor r=0.08248 c=0
Rk20 (\8\:mout \12\:mout) resistor r=0.6494 c=0
Rk21 (\12\:mout \14\:mout) resistor r=0.6934 c=0
Rk22 (\8\:CKbb \9\:CKbb) resistor r=1.0828 c=0
Rk23 (\9\:CKbb \11\:CKbb) resistor r=0.1419 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.1094 c=0
Rk25 (\9\:CKbb \14\:CKbb) resistor r=0.2309 c=0
Rk26 (\5\:n20 \6\:n20) resistor r=0.1268 c=0
Rk27 (\6\:n20 \7\:n20) resistor r=0.3778 c=0
Rk28 (\6\:n20 \9\:n20) resistor r=0.295 c=0
Rk36 (\2\:Db \3\:Db) resistor r=0.7297 c=0
Rk37 (\3\:Db \5\:Db) resistor r=0.6165 c=0
Rk38 (\3\:Db \7\:Db) resistor r=0.2388 c=0
Rk39 (\5\:Db \9\:Db) resistor r=0.4123 c=0
Rk44 (\6\:SEb \7\:SEb) resistor r=0.5552 c=0
Rk45 (\7\:SEb \8\:SEb) resistor r=0.3713 c=0
Rk46 (\7\:SEb \10\:SEb) resistor r=0.04767 c=0
Rk11 (\2\:net405 \4\:net405) resistor r=0.3559 c=0
Rl35 (\1\:CK \2\:CK) resistor r=123.054 c=0
Rl36 (\2\:CK \3\:CK) resistor r=136.333 c=0
Rl43 (\3\:SE \4\:SE) resistor r=39.1533 c=0
Rl39 (\1\:SE \2\:SE) resistor r=74.4182 c=0
Rl48 (\6\:SE \8\:SE) resistor r=199.429 c=0
Rl46 (\5\:SE \6\:SE) resistor r=64.8131 c=0
Rl47 (\6\:SE \7\:SE) resistor r=5.0185 c=0
Rl24 (\4\:SN \5\:SN) resistor r=159.181 c=0
Rl25 (\5\:SN \6\:SN) resistor r=26.1559 c=0
Rl13 (\2\:SN \3\:SN) resistor r=111.916 c=0
Rl12 (\1\:SN \2\:SN) resistor r=92.9995 c=0
Rl45 (\2\:SI \3\:SI) resistor r=104.944 c=0
Rl44 (\1\:SI \2\:SI) resistor r=124.175 c=0
Rl37 (\1\:D \2\:D) resistor r=196.846 c=0
Rl38 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl1 (net492 \2\:net492) resistor r=80.0021 c=0
Rl2 (\2\:net492 \3\:net492) resistor r=24.2328 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=191.541 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=26.1559 c=0
Rl3 (qbint \2\:qbint) resistor r=40.0987 c=0
Rl7 (\2\:qbint \6\:qbint) resistor r=43.9449 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=2.0166 c=0
Rl6 (\4\:qbint \5\:qbint) resistor r=53.6427 c=0
Rl8 (\4\:qbint \7\:qbint) resistor r=37.353 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=34.566 c=0
Rl9 (n35 \2\:n35) resistor r=94.1936 c=0
Rl10 (\2\:n35 \3\:n35) resistor r=165.363 c=0
Rl11 (\2\:n35 \4\:n35) resistor r=16.9983 c=0
Rl19 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=566.873 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=35.3072 c=0
Rl31 (\7\:CKb \8\:CKb) resistor r=52.6149 c=0
Rl20 (\2\:CKb \3\:CKb) resistor r=90.3625 c=0
Rl21 (\3\:CKb \4\:CKb) resistor r=151.901 c=0
Rl23 (\3\:CKb \6\:CKb) resistor r=70.8353 c=0
Rl28 (mout \2\:mout) resistor r=95.0334 c=0
Rl30 (\2\:mout \4\:mout) resistor r=48.8796 c=0
Rl29 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl32 (\5\:CKbb \6\:CKbb) resistor r=157.235 c=0
Rl33 (\6\:CKbb \7\:CKbb) resistor r=24.7951 c=0
Rl16 (CKbb \2\:CKbb) resistor r=21.8724 c=0
Rl18 (\2\:CKbb \4\:CKbb) resistor r=132.406 c=0
Rl17 (\2\:CKbb \3\:CKbb) resistor r=36.2526 c=0
Rl26 (n20 \2\:n20) resistor r=24.2328 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=143.029 c=0
Rl40 (SEb \2\:SEb) resistor r=8.3086 c=0
Rl42 (\2\:SEb \4\:SEb) resistor r=42.7807 c=0
Rl41 (\2\:SEb \3\:SEb) resistor r=221.283 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz21 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz22 (\4\:VDD \8\:VDD) resistor r=8.3333 c=0
Rz23 (\4\:VDD \10\:VDD) resistor r=37.5 c=0
Rz24 (\4\:VDD \13\:VDD) resistor r=9.375 c=0
Rz14 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz19 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz20 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz2 (\5\:net492 \6\:net492) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz10 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\13\:mout \14\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz9 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz11 (Db \2\:Db) resistor r=75 c=0
Rz12 (\8\:Db \9\:Db) resistor r=75 c=0
Rz13 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry20 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry21 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry22 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry23 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry25 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry26 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry27 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry17 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry18 (\3\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry19 (\3\:VSS \11\:VSS) resistor r=15.5 c=0
Ry2 (\7\:net492 \8\:net492) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry12 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (net405 \2\:net405) resistor r=62 c=0
Ry6 (\3\:net405 \4\:net405) resistor r=62 c=0
Rx11 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\4\:SE \9\:SE) resistor r=45 c=0
Rx18 (\2\:SE \10\:SE) resistor r=45 c=0
Rx19 (\7\:SE \11\:SE) resistor r=45 c=0
Rx5 (\6\:SN \7\:SN) resistor r=45 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:net492 \4\:net492) resistor r=45 c=0
Rx2 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx3 (\3\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\4\:n35 \8\:n35) resistor r=45 c=0
Rx12 (\8\:CKb \14\:CKb) resistor r=45 c=0
Rx13 (CKb \15\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:mout \5\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (CKbb \12\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (SEb \8\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net492 \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.843e-14 ad=2.755e-14 ps=8.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\5\:net492 \7\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \6\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.828e-14 ps=1.6e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint n35 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.03e-14 ps=7.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn50 (net521 \1\:SN \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=8.7e-15 ps=7.5e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=7.65e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn51 (net518 \10\:qbint net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.48e-14 ps=4.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=6.6e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn52 (\9\:n35 \5\:CKb net518 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.755e-14 ps=7.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=3.75e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn40 (\9\:n35 \3\:CKbb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn21 (\10\:CKbb \6\:CKb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.517e-14 ad=2.03e-14 ps=1.79e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (net442 \5\:SN \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.517e-14 ad=1.958e-14 ps=1.79e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=3.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn31 (\9\:mout \3\:n20 net442 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net478 \4\:mout \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=8.7e-15 ps=8.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=6.8e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn36 (\8\:n20 \7\:CKbb net478 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.988e-14 ps=4.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=5.75e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\8\:Db \9\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.698e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKb \3\:CK \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.03e-14 ps=8.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net494 \3\:D \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=3.77e-14 ps=8.3e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=9.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net494 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=2.32e-14 ps=8.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net506 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=4.65e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net506 \1\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=3.6e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\5\:SEb \5\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp56 (\7\:net492 \5\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.63e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=3.33256e-07 sd=160n sca=46.2604 \
        scb=0.0284877 scc=0.00588421 m=(1)
mp55 (\3\:Q qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.758e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=1.28256e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\15\:qbint \3\:n35 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=3.01e-14 ps=8.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.95e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp50 (\3\:net405 \3\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=3.763e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.6e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp51 (\3\:net405 \8\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.763e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.4e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp52 (\5\:n35 \4\:CKbb net405 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\5\:n35 \4\:CKb \11\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\13\:CKbb \2\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.49e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp30 (\7\:mout \4\:SN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=4.945e-14 ps=1.78e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.225e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (\7\:mout n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0943e-13 ad=4.945e-14 ps=1.85e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=9.5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp35 (net417 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0943e-13 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=6.5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp36 (\4\:n20 \7\:CKb net417 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.268e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=5.45e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp25 (\4\:n20 \5\:CKbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=5.268e-14 ps=9.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=2.55e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp20 (\11\:CKb \1\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (net433 \1\:D \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.58e-14 ps=7.5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp12 (\6\:Db \1\:SE net433 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.75e-07 sd=160n sca=10.4041 \
        scb=0.00751939 scc=8.05211e-05 m=(1)
mp14 (\6\:Db \4\:SEb net441 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.7e-07 sd=160n sca=11.1447 \
        scb=0.00794267 scc=8.08728e-05 m=(1)
mp13 (net441 \3\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=13.2217 \
        scb=0.0107547 scc=0.000102805 m=(1)
mp10 (\9\:SEb \8\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=20.617 \
        scb=0.0226642 scc=0.000873207 m=(1)
ends SDFFSXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:46:04 2012 )
// Library name: gsclib045
// Cell name: SDFFTRX1
// View name: extracted

simulator lang=spectre

subckt SDFFTRX1 CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net436 \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
C1 (D VSS) capacitor c=7.92734e-17
C2 (SI VSS) capacitor c=8.64609e-17
C3 (QN VSS) capacitor c=2.29258e-17
C4 (CK VSS) capacitor c=6.99586e-17
C5 (RN VSS) capacitor c=6.31598e-17
C6 (VDD VSS) capacitor c=3.14012e-16
C7 (Q VSS) capacitor c=1.61919e-17
C8 (SE VSS) capacitor c=6.55244e-17
C9 (net436 VSS) capacitor c=2.22446e-17
C10 (qbint VSS) capacitor c=4.48206e-17
C11 (CKb VSS) capacitor c=5.24089e-17
C12 (n30 VSS) capacitor c=5.07126e-17
C13 (mout VSS) capacitor c=7.99829e-17
C14 (CKbb VSS) capacitor c=1.87504e-17
C15 (n20 VSS) capacitor c=1.94635e-17
C16 (Dbp VSS) capacitor c=4.55981e-17
C17 (Db VSS) capacitor c=1.1315e-16
C18 (SEb VSS) capacitor c=4.0147e-17
C19 (net395 VSS) capacitor c=2.89993e-18
C20 (net375 VSS) capacitor c=5.0133e-20
C21 (\1\:D VSS) capacitor c=3.31912e-17
C22 (\1\:RN VSS) capacitor c=4.97525e-17
C23 (\1\:SE VSS) capacitor c=2.63414e-17
C24 (\6\:SE VSS) capacitor c=3.47019e-17
C25 (\1\:SI VSS) capacitor c=4.26208e-17
C26 (\5\:CKb VSS) capacitor c=6.04569e-17
C27 (\6\:CKbb VSS) capacitor c=3.90412e-17
C28 (\8\:CKb VSS) capacitor c=5.78403e-17
C29 (\4\:n20 VSS) capacitor c=3.98154e-17
C30 (\3\:CKb VSS) capacitor c=5.59305e-17
C31 (\3\:CKbb VSS) capacitor c=4.38964e-17
C32 (\8\:qbint VSS) capacitor c=4.29569e-17
C33 (\1\:CK VSS) capacitor c=3.48126e-17
C34 (\7\:qbint VSS) capacitor c=2.95567e-17
C35 (\4\:net436 VSS) capacitor c=4.48263e-17
C36 (\3\:D VSS) capacitor c=3.45639e-17
C37 (\3\:RN VSS) capacitor c=2.54866e-17
C38 (\5\:SE VSS) capacitor c=3.65887e-17
C39 (\3\:SEb VSS) capacitor c=3.6745e-17
C40 (\4\:SE VSS) capacitor c=5.12544e-17
C41 (\3\:SI VSS) capacitor c=5.19238e-17
C42 (\9\:CKb VSS) capacitor c=2.19697e-17
C43 (\10\:CKb VSS) capacitor c=2.62293e-17
C44 (\4\:CKbb VSS) capacitor c=7.95445e-17
C45 (\3\:mout VSS) capacitor c=5.25619e-17
C46 (\3\:n20 VSS) capacitor c=4.06494e-17
C47 (\11\:qbint VSS) capacitor c=5.00212e-17
C48 (\2\:n30 VSS) capacitor c=4.30382e-17
C49 (\3\:CK VSS) capacitor c=4.18658e-17
C50 (\5\:qbint VSS) capacitor c=2.89038e-17
C51 (\4\:qbint VSS) capacitor c=2.62805e-17
C52 (\3\:net436 VSS) capacitor c=3.76387e-17
C53 (\2\:D VSS) capacitor c=3.68911e-17
C54 (\2\:RN VSS) capacitor c=4.04495e-17
C55 (\2\:SE VSS) capacitor c=4.95408e-17
C56 (\4\:SEb VSS) capacitor c=4.10642e-17
C57 (\2\:SEb VSS) capacitor c=4.6042e-17
C58 (\2\:SI VSS) capacitor c=5.694e-17
C59 (\7\:CKbb VSS) capacitor c=4.17266e-17
C60 (\11\:CKb VSS) capacitor c=2.88747e-17
C61 (\5\:CKbb VSS) capacitor c=2.91519e-17
C62 (\2\:mout VSS) capacitor c=5.11317e-17
C63 (\4\:CKb VSS) capacitor c=2.05823e-17
C64 (\2\:CKbb VSS) capacitor c=5.17214e-17
C65 (\2\:CKb VSS) capacitor c=3.1966e-17
C66 (\10\:qbint VSS) capacitor c=5.18994e-17
C67 (\3\:n30 VSS) capacitor c=2.257e-17
C68 (\2\:CK VSS) capacitor c=2.77273e-17
C69 (\6\:qbint VSS) capacitor c=2.02221e-17
C70 (\1\:VDD VSS) capacitor c=4.16805e-17
C71 (\3\:Db VSS) capacitor c=2.03009e-16
C72 (\15\:VDD VSS) capacitor c=2.07311e-17
C73 (\5\:SEb VSS) capacitor c=1.18709e-16
C74 (\5\:Db VSS) capacitor c=1.29535e-16
C75 (\17\:VDD VSS) capacitor c=4.09284e-17
C76 (\8\:CKbb VSS) capacitor c=8.49944e-17
C77 (\4\:Dbp VSS) capacitor c=1.21075e-16
C78 (\5\:n20 VSS) capacitor c=3.15761e-17
C79 (\19\:VDD VSS) capacitor c=9.05957e-18
C80 (\8\:mout VSS) capacitor c=4.16873e-17
C81 (\4\:n30 VSS) capacitor c=7.54977e-17
C82 (\21\:VDD VSS) capacitor c=3.18029e-17
C83 (\16\:qbint VSS) capacitor c=4.45702e-17
C84 (\15\:CKb VSS) capacitor c=9.38837e-17
C85 (\23\:VDD VSS) capacitor c=3.6606e-17
C86 (\1\:Q VSS) capacitor c=9.63618e-17
C87 (\5\:net436 VSS) capacitor c=2.74663e-17
C88 (\25\:VDD VSS) capacitor c=5.88783e-17
C89 (\1\:QN VSS) capacitor c=4.81629e-17
C90 (\3\:VDD VSS) capacitor c=1.20028e-16
C91 (\7\:SEb VSS) capacitor c=1.31494e-16
C92 (\7\:Db VSS) capacitor c=1.06041e-16
C93 (\8\:Dbp VSS) capacitor c=8.39148e-17
C94 (\14\:CKbb VSS) capacitor c=6.56475e-17
C95 (\6\:Dbp VSS) capacitor c=8.60098e-17
C96 (\9\:n20 VSS) capacitor c=5.55548e-17
C97 (\6\:mout VSS) capacitor c=3.7706e-17
C98 (\6\:n30 VSS) capacitor c=9.98433e-17
C99 (\14\:qbint VSS) capacitor c=8.00539e-17
C100 (\17\:CKb VSS) capacitor c=6.05752e-17
C101 (\3\:Q VSS) capacitor c=5.5678e-17
C102 (\9\:net436 VSS) capacitor c=1.95333e-17
C103 (\3\:QN VSS) capacitor c=2.74691e-17
C104 (\2\:net436 VSS) capacitor c=7.14124e-18
C105 (\2\:qbint VSS) capacitor c=2.28472e-17
C106 (\3\:qbint VSS) capacitor c=3.30282e-17
C107 (\2\:n20 VSS) capacitor c=2.56775e-17
C108 (\6\:CKb VSS) capacitor c=5.99312e-17
C109 (\7\:CKb VSS) capacitor c=7.29463e-17
C110 (\3\:SE VSS) capacitor c=8.82072e-17
C111 (\7\:net436 VSS) capacitor c=2.40092e-17
C112 (\8\:net436 VSS) capacitor c=2.26735e-17
C113 (\4\:CK VSS) capacitor c=4.31389e-17
C114 (\12\:qbint VSS) capacitor c=3.12102e-17
C115 (\13\:qbint VSS) capacitor c=3.18675e-17
C116 (\18\:qbint VSS) capacitor c=1.06385e-16
C117 (\8\:n30 VSS) capacitor c=6.0503e-17
C118 (\4\:mout VSS) capacitor c=5.19305e-17
C119 (\5\:mout VSS) capacitor c=5.10106e-17
C120 (\12\:CKb VSS) capacitor c=5.16055e-17
C121 (\13\:CKb VSS) capacitor c=6.81472e-17
C122 (\14\:CKb VSS) capacitor c=9.40313e-17
C123 (\19\:CKb VSS) capacitor c=1.17455e-17
C124 (\20\:CKb VSS) capacitor c=5.43197e-17
C125 (\7\:n20 VSS) capacitor c=5.52108e-17
C126 (\8\:n20 VSS) capacitor c=5.26946e-17
C127 (\10\:CKbb VSS) capacitor c=1.20003e-16
C128 (\11\:CKbb VSS) capacitor c=7.35184e-17
C129 (\12\:CKbb VSS) capacitor c=9.00276e-17
C130 (\13\:CKbb VSS) capacitor c=1.12236e-16
C131 (\16\:CKbb VSS) capacitor c=2.8494e-17
C132 (\4\:SI VSS) capacitor c=4.35788e-17
C133 (\3\:Dbp VSS) capacitor c=1.04999e-16
C134 (\9\:SEb VSS) capacitor c=1.11636e-16
C135 (\10\:SEb VSS) capacitor c=5.46091e-17
C136 (\7\:SE VSS) capacitor c=5.26998e-17
C137 (\4\:RN VSS) capacitor c=3.96344e-17
C138 (\4\:D VSS) capacitor c=4.2038e-17
C139 (\5\:VDD VSS) capacitor c=2.76886e-17
C140 (\7\:VDD VSS) capacitor c=1.94108e-17
C141 (\8\:VDD VSS) capacitor c=2.23256e-17
C142 (\12\:VDD VSS) capacitor c=1.09924e-17
C143 (\14\:VDD VSS) capacitor c=9.49243e-18
Rk43 (\4\:D D) resistor r=0.07299 c=0
Rk33 (\4\:SI SI) resistor r=0.09342 c=0
Rk2 (\4\:QN QN) resistor r=0.0928 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk8 (\4\:CK CK) resistor r=0.1143 c=0
Rk42 (\4\:RN RN) resistor r=0.1928 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.4936 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.2178 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.6338 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.04741 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.5484 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.2554 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.2579 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.1927 c=0
Rk55 (\11\:VDD \12\:VDD) resistor r=0.2128 c=0
Rk56 (\12\:VDD \13\:VDD) resistor r=0.288 c=0
Rk58 (\14\:VDD VDD) resistor r=0.2 c=0
Rk57 (\13\:VDD \14\:VDD) resistor r=0.04992 c=0
Rk59 (\5\:VDD \16\:VDD) resistor r=0.1762 c=0
Rk60 (\7\:VDD \18\:VDD) resistor r=0.2923 c=0
Rk61 (\8\:VDD \20\:VDD) resistor r=0.07334 c=0
Rk62 (\10\:VDD \22\:VDD) resistor r=0.2446 c=0
Rk63 (\12\:VDD \24\:VDD) resistor r=0.2768 c=0
Rk64 (\14\:VDD \26\:VDD) resistor r=0.4324 c=0
Rk7 (\4\:Q Q) resistor r=0.03363 c=0
Rk6 (\2\:Q \4\:Q) resistor r=0.491 c=0
Rk65 (\2\:VSS \3\:VSS) resistor r=0.2328 c=0
Rk66 (\3\:VSS \4\:VSS) resistor r=0.6187 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.04741 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.5474 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.4549 c=0
Rk70 (\3\:VSS \9\:VSS) resistor r=0.1821 c=0
Rk71 (\5\:VSS \11\:VSS) resistor r=0.303 c=0
Rk72 (\6\:VSS \13\:VSS) resistor r=0.04326 c=0
Rk73 (\7\:VSS \14\:VSS) resistor r=0.4646 c=0
Rk74 (\14\:VSS \15\:VSS) resistor r=0.1376 c=0
Rk75 (\15\:VSS \16\:VSS) resistor r=0.1852 c=0
Rk77 (\17\:VSS VSS) resistor r=0.09998 c=0
Rk76 (\16\:VSS \17\:VSS) resistor r=0.1151 c=0
Rk78 (\7\:VSS \19\:VSS) resistor r=0.07141 c=0
Rk79 (\14\:VSS \21\:VSS) resistor r=0.2886 c=0
Rk80 (\16\:VSS \23\:VSS) resistor r=0.07334 c=0
Rk41 (\7\:SE SE) resistor r=0.03494 c=0
Rk3 (\6\:net436 \7\:net436) resistor r=0.1174 c=0
Rk4 (\7\:net436 \8\:net436) resistor r=0.119 c=0
Rk5 (\7\:net436 \10\:net436) resistor r=0.1055 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.1669 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1202 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.2251 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.7137 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.4686 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.3611 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.5753 c=0
Rk21 (\16\:CKb \18\:CKb) resistor r=0.272 c=0
Rk22 (\13\:CKb \19\:CKb) resistor r=0.02031 c=0
Rk23 (\14\:CKb \20\:CKb) resistor r=0.3158 c=0
Rk13 (\5\:n30 \7\:n30) resistor r=0.5237 c=0
Rk14 (\7\:n30 \8\:n30) resistor r=0.4249 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2403 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.1339 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.229 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.5668 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.3502 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.2125 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.7325 c=0
Rk31 (\11\:CKbb \15\:CKbb) resistor r=0.3718 c=0
Rk32 (\12\:CKbb \16\:CKbb) resistor r=0.04286 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.1265 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.2701 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.2503 c=0
Rk34 (\2\:Dbp \3\:Dbp) resistor r=0.2771 c=0
Rk35 (\3\:Dbp \5\:Dbp) resistor r=0.4525 c=0
Rk36 (\5\:Dbp \7\:Dbp) resistor r=0.4277 c=0
Rk37 (\3\:Dbp \9\:Dbp) resistor r=0.5421 c=0
Rk44 (\2\:Db \4\:Db) resistor r=1.03 c=0
Rk45 (\4\:Db \6\:Db) resistor r=0.851 c=0
Rk46 (\6\:Db \8\:Db) resistor r=0.5915 c=0
Rk38 (\6\:SEb \8\:SEb) resistor r=0.7061 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.6569 c=0
Rk40 (\9\:SEb \10\:SEb) resistor r=0.2593 c=0
Rl45 (\1\:D \2\:D) resistor r=78.079 c=0
Rl46 (\2\:D \3\:D) resistor r=91.5405 c=0
Rl34 (\1\:SI \2\:SI) resistor r=86.7959 c=0
Rl35 (\2\:SI \3\:SI) resistor r=107.95 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl43 (\1\:RN \2\:RN) resistor r=131.925 c=0
Rl44 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl38 (\1\:SE \2\:SE) resistor r=31.5021 c=0
Rl41 (\2\:SE \5\:SE) resistor r=132.487 c=0
Rl42 (\3\:SE \6\:SE) resistor r=97.7584 c=0
Rl40 (\3\:SE \4\:SE) resistor r=168.774 c=0
Rl39 (\2\:SE \3\:SE) resistor r=229.236 c=0
Rl1 (net436 \2\:net436) resistor r=5.915 c=0
Rl3 (\2\:net436 \4\:net436) resistor r=49.7141 c=0
Rl2 (\2\:net436 \3\:net436) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=68.0527 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=4.8851 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=161.779 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=108.895 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=34.3295 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=0.5166 c=0
Rl33 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=51.1559 c=0
Rl17 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=162.128 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=40.6968 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=151.467 c=0
Rl32 (\7\:CKb \10\:CKb) resistor r=34.2969 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=202.903 c=0
Rl12 (n30 \2\:n30) resistor r=142.308 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl24 (mout \2\:mout) resistor r=87.2302 c=0
Rl25 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=35.7713 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=71.8456 c=0
Rl18 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl19 (\2\:CKbb \3\:CKbb) resistor r=110.337 c=0
Rl21 (n20 \2\:n20) resistor r=2.7713 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=99.7141 c=0
Rl37 (\3\:SEb \4\:SEb) resistor r=35.7713 c=0
Rl36 (SEb \2\:SEb) resistor r=79.5379 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz16 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \9\:VDD) resistor r=15 c=0
Rz18 (\3\:VDD \11\:VDD) resistor r=18.75 c=0
Rz19 (\3\:VDD \13\:VDD) resistor r=12.5 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz20 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz21 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz22 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz23 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz24 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz25 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz2 (\9\:net436 \10\:net436) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz5 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (\6\:Dbp \7\:Dbp) resistor r=75 c=0
Rz11 (\8\:Dbp \9\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry19 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \7\:VSS) resistor r=6.8889 c=0
Ry25 (\1\:VSS \15\:VSS) resistor r=20.6667 c=0
Ry26 (\1\:VSS \17\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:net436 \6\:net436) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (Dbp \2\:Dbp) resistor r=62 c=0
Ry11 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:RN \4\:RN) resistor r=45 c=0
Rx17 (\2\:SE \7\:SE) resistor r=45 c=0
Rx1 (net436 \8\:net436) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (n20 \8\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx16 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net436 \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:net436 \4\:qbint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn20 (\17\:CKb \3\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn45 (\14\:qbint \2\:n30 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.665e-14 ad=2.465e-14 ps=1.39e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.855e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn50 (net460 \11\:qbint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.665e-14 ad=1.233e-14 ps=1.39e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.66e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn25 (\6\:Dbp \10\:CKb \9\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.132e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=2.85e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn51 (\6\:n30 CKb net460 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=4.278e-14 ps=4.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.53e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=4.277e-14 ps=8.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.19e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn30 (\6\:mout \3\:n20 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.15e-14 ad=4.132e-14 ps=1.39e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=8.6e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn35 (net452 \3\:mout \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.95e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn36 (\9\:n20 \4\:CKbb net452 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.9e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn21 (\14\:CKbb \9\:CKb \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (net484 \3\:SI \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (\8\:Dbp \4\:SE net484 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.045e-14 ps=6.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\7\:Db \3\:SEb \8\:Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.972e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\7\:SEb \5\:SE \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.03e-14 ps=9.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mn0 (net476 \3\:RN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.32e-14 ps=9.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=3.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.4e-07 sd=160n sca=6.75077 scb=0.00344229 \
        scc=2.58723e-05 m=(1)
mp56 (\5\:net436 \7\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp20 (\15\:CKb \1\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp45 (\16\:qbint n30 \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp50 (net395 \8\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.43e-14 ad=5.483e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.59e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp51 (\4\:n30 \3\:CKbb net395 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.29e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.085e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp30 (\8\:mout \4\:n20 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.061e-13 ad=3.87e-14 ps=1.85e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.6e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp25 (\5\:n20 \6\:CKbb \4\:Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=4.515e-14 ps=9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=2.35e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp35 (net375 mout \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.95e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp36 (\5\:n20 \8\:CKb net375 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.9e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp21 (\8\:CKbb \5\:CKb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.05e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp12 (net411 \1\:SI \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6e-07 sd=160n sca=12.3081 scb=0.0110829 \
        scc=0.000360616 m=(1)
mp13 (Dbp SEb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.44e-14 ps=8.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=3.45e-07 sd=160n sca=12.3081 scb=0.0110829 \
        scc=0.000360616 m=(1)
mp11 (Dbp \6\:SE \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.4e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp10 (\5\:SEb \1\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0985e-13 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp0 (\3\:Db \1\:RN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0985e-13 ad=3.44e-14 ps=1.77e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=4.05e-07 sd=160n sca=46.5108 \
        scb=0.0286367 scc=0.00588432 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=2e-07 sd=160n sca=47.9436 scb=0.0302509 \
        scc=0.00589103 m=(1)
ends SDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:46:43 2012 )
// Library name: gsclib045
// Cell name: SDFFTRX2
// View name: extracted

simulator lang=spectre

subckt SDFFTRX2 CK D Q QN RN SE SI VDD VSS
mp56 (\12\:net436 qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.555e-06 sd=160n sca=50.7282 \
        scb=0.0349898 scc=0.00599471 m=(1)
C1 (D VSS) capacitor c=4.76918e-17
C2 (SI VSS) capacitor c=6.14264e-17
C3 (CK VSS) capacitor c=3.16312e-17
C4 (QN VSS) capacitor c=2.40197e-17
C5 (RN VSS) capacitor c=5.38732e-17
C6 (VDD VSS) capacitor c=3.59813e-16
C7 (Q VSS) capacitor c=1.76129e-17
C8 (SE VSS) capacitor c=8.28086e-17
C9 (qbint VSS) capacitor c=3.98372e-17
C10 (net436 VSS) capacitor c=1.34725e-16
C11 (CKb VSS) capacitor c=4.9138e-17
C12 (n30 VSS) capacitor c=3.48948e-17
C13 (net460 VSS) capacitor c=3.04253e-18
C14 (mout VSS) capacitor c=5.37126e-17
C15 (CKbb VSS) capacitor c=2.29971e-17
C16 (n20 VSS) capacitor c=4.19167e-17
C17 (Dbp VSS) capacitor c=8.70515e-17
C18 (Db VSS) capacitor c=5.8212e-17
C19 (SEb VSS) capacitor c=4.12578e-17
C20 (net395 VSS) capacitor c=6.78854e-18
C21 (\1\:D VSS) capacitor c=3.4738e-17
C22 (\1\:RN VSS) capacitor c=4.33939e-17
C23 (\1\:SE VSS) capacitor c=2.55565e-17
C24 (\6\:SE VSS) capacitor c=3.74318e-17
C25 (\4\:SI VSS) capacitor c=4.50388e-17
C26 (\9\:CKb VSS) capacitor c=4.71089e-17
C27 (\6\:CKbb VSS) capacitor c=4.44616e-17
C28 (\8\:CKb VSS) capacitor c=9.59465e-17
C29 (\3\:mout VSS) capacitor c=8.40656e-17
C30 (\3\:n20 VSS) capacitor c=4.52414e-17
C31 (\3\:CKb VSS) capacitor c=6.29291e-17
C32 (\3\:CKbb VSS) capacitor c=5.92213e-17
C33 (\11\:qbint VSS) capacitor c=3.09528e-17
C34 (\3\:n30 VSS) capacitor c=4.73143e-17
C35 (\1\:CK VSS) capacitor c=3.20881e-17
C36 (\4\:qbint VSS) capacitor c=3.67928e-16
C37 (\3\:D VSS) capacitor c=3.57995e-17
C38 (\3\:RN VSS) capacitor c=4.13068e-17
C39 (\5\:SE VSS) capacitor c=2.56282e-17
C40 (\3\:SEb VSS) capacitor c=3.93768e-17
C41 (\4\:SE VSS) capacitor c=4.80155e-17
C42 (\1\:SI VSS) capacitor c=3.38071e-17
C43 (\5\:CKb VSS) capacitor c=2.15042e-17
C44 (\10\:CKb VSS) capacitor c=1.92401e-17
C45 (\5\:CKbb VSS) capacitor c=8.45831e-17
C46 (\13\:qbint VSS) capacitor c=5.84171e-17
C47 (\3\:CK VSS) capacitor c=2.46429e-17
C48 (\2\:qbint VSS) capacitor c=3.08452e-17
C49 (\2\:D VSS) capacitor c=4.18251e-17
C50 (\2\:RN VSS) capacitor c=3.85691e-17
C51 (\2\:SE VSS) capacitor c=4.85149e-17
C52 (\4\:SEb VSS) capacitor c=3.77096e-17
C53 (\2\:SEb VSS) capacitor c=4.68779e-17
C54 (\3\:SI VSS) capacitor c=2.79099e-17
C55 (\7\:CKbb VSS) capacitor c=3.93444e-17
C56 (\4\:CKbb VSS) capacitor c=3.07632e-17
C57 (\11\:CKb VSS) capacitor c=3.22874e-17
C58 (\2\:mout VSS) capacitor c=5.41355e-17
C59 (\4\:CKb VSS) capacitor c=2.58708e-17
C60 (\2\:CKbb VSS) capacitor c=4.42594e-17
C61 (\2\:CKb VSS) capacitor c=3.70869e-17
C62 (\12\:qbint VSS) capacitor c=4.1942e-17
C63 (\2\:n30 VSS) capacitor c=2.56225e-17
C64 (\2\:CK VSS) capacitor c=2.38251e-17
C65 (\4\:net436 VSS) capacitor c=2.99156e-17
C66 (\3\:qbint VSS) capacitor c=1.95764e-17
C67 (\1\:VDD VSS) capacitor c=3.80723e-17
C68 (\3\:Db VSS) capacitor c=1.55279e-16
C69 (\16\:VDD VSS) capacitor c=1.19809e-17
C70 (\5\:SEb VSS) capacitor c=1.42169e-16
C71 (\6\:Db VSS) capacitor c=3.33733e-17
C72 (\7\:Dbp VSS) capacitor c=4.92344e-17
C73 (\18\:VDD VSS) capacitor c=4.32732e-17
C74 (\14\:CKbb VSS) capacitor c=7.06294e-17
C75 (\5\:Dbp VSS) capacitor c=1.15174e-16
C76 (\5\:n20 VSS) capacitor c=3.8009e-17
C77 (\20\:VDD VSS) capacitor c=1.69761e-17
C78 (\6\:mout VSS) capacitor c=4.31488e-17
C79 (\8\:n30 VSS) capacitor c=7.9085e-17
C80 (\22\:VDD VSS) capacitor c=4.1321e-17
C81 (\15\:qbint VSS) capacitor c=7.44124e-17
C82 (\15\:CKb VSS) capacitor c=1.06961e-16
C83 (\2\:Q VSS) capacitor c=5.39733e-17
C84 (\1\:QN VSS) capacitor c=8.94983e-17
C85 (\12\:net436 VSS) capacitor c=1.80165e-17
C86 (\3\:VDD VSS) capacitor c=1.35099e-16
C87 (\7\:SEb VSS) capacitor c=1.45081e-16
C88 (\8\:Db VSS) capacitor c=1.09076e-16
C89 (\8\:CKbb VSS) capacitor c=5.81636e-17
C90 (\9\:Dbp VSS) capacitor c=7.16769e-17
C91 (\9\:n20 VSS) capacitor c=5.62675e-17
C92 (\8\:mout VSS) capacitor c=3.59409e-17
C93 (\4\:n30 VSS) capacitor c=2.35542e-17
C94 (\17\:qbint VSS) capacitor c=9.2891e-17
C95 (\18\:CKb VSS) capacitor c=6.17031e-17
C96 (\4\:Q VSS) capacitor c=5.44148e-17
C97 (\3\:QN VSS) capacitor c=3.4913e-17
C98 (\10\:net436 VSS) capacitor c=2.71152e-17
C99 (\2\:n20 VSS) capacitor c=4.39812e-17
C100 (\6\:CKb VSS) capacitor c=5.45694e-17
C101 (\7\:CKb VSS) capacitor c=5.58656e-17
C102 (\2\:SI VSS) capacitor c=3.42805e-17
C103 (\8\:net436 VSS) capacitor c=3.06118e-17
C104 (\9\:net436 VSS) capacitor c=1.85796e-17
C105 (\3\:SE VSS) capacitor c=8.6316e-17
C106 (\1\:Q VSS) capacitor c=2.39051e-17
C107 (\4\:CK VSS) capacitor c=8.53197e-17
C108 (\14\:qbint VSS) capacitor c=5.33514e-17
C109 (\21\:qbint VSS) capacitor c=7.81146e-17
C110 (\6\:n30 VSS) capacitor c=8.04882e-17
C111 (\7\:n30 VSS) capacitor c=7.85541e-17
C112 (\4\:mout VSS) capacitor c=4.87119e-17
C113 (\5\:mout VSS) capacitor c=5.25563e-17
C114 (\12\:CKb VSS) capacitor c=5.03121e-17
C115 (\13\:CKb VSS) capacitor c=8.58225e-17
C116 (\14\:CKb VSS) capacitor c=1.33417e-16
C117 (\17\:CKb VSS) capacitor c=5.66475e-17
C118 (\7\:n20 VSS) capacitor c=6.01064e-17
C119 (\8\:n20 VSS) capacitor c=5.16226e-17
C120 (\10\:CKbb VSS) capacitor c=6.46832e-17
C121 (\11\:CKbb VSS) capacitor c=8.48625e-17
C122 (\12\:CKbb VSS) capacitor c=1.1605e-16
C123 (\13\:CKbb VSS) capacitor c=1.33862e-16
C124 (\5\:SI VSS) capacitor c=5.88715e-17
C125 (\3\:Dbp VSS) capacitor c=9.30114e-17
C126 (\9\:SEb VSS) capacitor c=1.40035e-16
C127 (\10\:SEb VSS) capacitor c=5.97085e-17
C128 (\7\:SE VSS) capacitor c=3.55123e-17
C129 (\4\:RN VSS) capacitor c=4.79843e-17
C130 (\4\:D VSS) capacitor c=6.85964e-17
C131 (\5\:Db VSS) capacitor c=1.23641e-16
C132 (\5\:VDD VSS) capacitor c=2.89502e-18
C133 (\8\:VDD VSS) capacitor c=2.22721e-17
C134 (\9\:VDD VSS) capacitor c=2.93387e-17
C135 (\11\:VDD VSS) capacitor c=1.20868e-17
C136 (\12\:VDD VSS) capacitor c=2.17051e-16
Rk47 (D \4\:D) resistor r=0.2296 c=0
Rk36 (\5\:SI SI) resistor r=0.1005 c=0
Rk9 (CK \4\:CK) resistor r=0.07487 c=0
Rk4 (\2\:QN QN) resistor r=0.2983 c=0
Rk5 (QN \4\:QN) resistor r=0.03631 c=0
Rk46 (\4\:RN RN) resistor r=0.2054 c=0
Rk52 (\2\:VDD \4\:VDD) resistor r=0.5144 c=0
Rk53 (\4\:VDD \5\:VDD) resistor r=0.1351 c=0
Rk54 (\5\:VDD \6\:VDD) resistor r=0.06496 c=0
Rk55 (\6\:VDD \7\:VDD) resistor r=0.6516 c=0
Rk56 (\7\:VDD \8\:VDD) resistor r=0.04993 c=0
Rk57 (\8\:VDD \9\:VDD) resistor r=0.5485 c=0
Rk58 (\9\:VDD \10\:VDD) resistor r=0.2529 c=0
Rk59 (\10\:VDD \11\:VDD) resistor r=0.2805 c=0
Rk64 (\12\:VDD VDD) resistor r=0.1925 c=0
Rk60 (\11\:VDD \12\:VDD) resistor r=0.4432 c=0
Rk65 (\5\:VDD \17\:VDD) resistor r=0.07346 c=0
Rk66 (\8\:VDD \19\:VDD) resistor r=0.265 c=0
Rk67 (\9\:VDD \21\:VDD) resistor r=0.07346 c=0
Rk68 (\11\:VDD \23\:VDD) resistor r=0.2616 c=0
Rk6 (Q \1\:Q) resistor r=0.01016 c=0
Rk7 (\1\:Q \3\:Q) resistor r=0.187 c=0
Rk8 (\1\:Q \5\:Q) resistor r=0.2035 c=0
Rk72 (\2\:VSS \3\:VSS) resistor r=0.1502 c=0
Rk73 (\3\:VSS \4\:VSS) resistor r=0.3005 c=0
Rk74 (\4\:VSS \5\:VSS) resistor r=0.4359 c=0
Rk75 (\5\:VSS \6\:VSS) resistor r=0.4659 c=0
Rk76 (\6\:VSS \7\:VSS) resistor r=0.08908 c=0
Rk77 (\7\:VSS \8\:VSS) resistor r=0.5099 c=0
Rk78 (\8\:VSS \9\:VSS) resistor r=0.4422 c=0
Rk83 (\13\:VSS VSS) resistor r=0.04987 c=0
Rk82 (\9\:VSS \13\:VSS) resistor r=0.1226 c=0
Rk84 (\3\:VSS \15\:VSS) resistor r=0.316 c=0
Rk85 (\5\:VSS \17\:VSS) resistor r=0.3429 c=0
Rk86 (\7\:VSS \19\:VSS) resistor r=0.04327 c=0
Rk87 (\8\:VSS \21\:VSS) resistor r=0.2915 c=0
Rk45 (\7\:SE SE) resistor r=0.09463 c=0
Rk10 (\14\:qbint \16\:qbint) resistor r=0.257 c=0
Rk12 (\18\:qbint \4\:qbint) resistor r=0.4724 c=0
Rk11 (\16\:qbint \18\:qbint) resistor r=0.3366 c=0
Rk14 (\4\:qbint \21\:qbint) resistor r=0.5476 c=0
Rk1 (\8\:net436 \9\:net436) resistor r=0.1539 c=0
Rk2 (\9\:net436 \11\:net436) resistor r=0.1116 c=0
Rk3 (\9\:net436 \13\:net436) resistor r=0.1457 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.4009 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.4646 c=0
Rk25 (\14\:CKb \16\:CKb) resistor r=0.6799 c=0
Rk26 (\14\:CKb \17\:CKb) resistor r=0.2472 c=0
Rk27 (\16\:CKb \19\:CKb) resistor r=0.2603 c=0
Rk17 (\5\:n30 \6\:n30) resistor r=0.0639 c=0
Rk18 (\6\:n30 \7\:n30) resistor r=0.427 c=0
Rk19 (\6\:n30 \9\:n30) resistor r=0.4183 c=0
Rk20 (\4\:mout \5\:mout) resistor r=0.2414 c=0
Rk21 (\5\:mout \7\:mout) resistor r=0.2614 c=0
Rk22 (\5\:mout \9\:mout) resistor r=0.1457 c=0
Rk31 (\9\:CKbb \10\:CKbb) resistor r=0.3681 c=0
Rk32 (\10\:CKbb \11\:CKbb) resistor r=0.1783 c=0
Rk33 (\11\:CKbb \12\:CKbb) resistor r=0.7534 c=0
Rk34 (\10\:CKbb \13\:CKbb) resistor r=0.4202 c=0
Rk35 (\13\:CKbb \15\:CKbb) resistor r=0.5448 c=0
Rk28 (\6\:n20 \7\:n20) resistor r=0.1636 c=0
Rk29 (\7\:n20 \8\:n20) resistor r=0.2669 c=0
Rk30 (\7\:n20 \10\:n20) resistor r=0.2638 c=0
Rk37 (\2\:Dbp \3\:Dbp) resistor r=0.5463 c=0
Rk38 (\3\:Dbp \4\:Dbp) resistor r=0.4314 c=0
Rk39 (\4\:Dbp \6\:Dbp) resistor r=0.04634 c=0
Rk40 (\3\:Dbp \8\:Dbp) resistor r=0.2374 c=0
Rk41 (\4\:Dbp \10\:Dbp) resistor r=0.4075 c=0
Rk48 (\2\:Db \4\:Db) resistor r=0.4562 c=0
Rk49 (\4\:Db \5\:Db) resistor r=0.8972 c=0
Rk50 (\5\:Db \7\:Db) resistor r=0.09538 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.5127 c=0
Rk42 (\6\:SEb \8\:SEb) resistor r=0.8779 c=0
Rk43 (\8\:SEb \9\:SEb) resistor r=0.8687 c=0
Rk44 (\9\:SEb \10\:SEb) resistor r=0.2797 c=0
Rl49 (\1\:D \2\:D) resistor r=97.3399 c=0
Rl50 (\2\:D \3\:D) resistor r=26.3736 c=0
Rl39 (\2\:SI \4\:SI) resistor r=102.726 c=0
Rl37 (\1\:SI \2\:SI) resistor r=89.1112 c=0
Rl38 (\2\:SI \3\:SI) resistor r=3.1183 c=0
Rl14 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl15 (\2\:CK \3\:CK) resistor r=37.2302 c=0
Rl47 (\1\:RN \2\:RN) resistor r=71.8456 c=0
Rl48 (\2\:RN \3\:RN) resistor r=39.1533 c=0
Rl42 (\1\:SE \2\:SE) resistor r=26.1559 c=0
Rl45 (\2\:SE \5\:SE) resistor r=81.9251 c=0
Rl46 (\3\:SE \6\:SE) resistor r=101.605 c=0
Rl44 (\3\:SE \4\:SE) resistor r=138.005 c=0
Rl43 (\2\:SE \3\:SE) resistor r=300.952 c=0
Rl1 (\2\:qbint qbint) resistor r=92.1596 c=0
Rl18 (\12\:qbint \11\:qbint) resistor r=29.5379 c=0
Rl19 (\12\:qbint \13\:qbint) resistor r=116.076 c=0
Rl2 (\3\:qbint \2\:qbint) resistor r=31.0185 c=0
Rl5 (net436 \4\:net436) resistor r=8.7569 c=0
Rl36 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl23 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl20 (CKb \2\:CKb) resistor r=53.079 c=0
Rl34 (\6\:CKb \9\:CKb) resistor r=160.475 c=0
Rl31 (\5\:CKb \6\:CKb) resistor r=35.2112 c=0
Rl33 (\7\:CKb \8\:CKb) resistor r=251.467 c=0
Rl35 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl32 (\6\:CKb \7\:CKb) resistor r=138.82 c=0
Rl16 (n30 \2\:n30) resistor r=24.7951 c=0
Rl17 (\2\:n30 \3\:n30) resistor r=58.9466 c=0
Rl27 (mout \2\:mout) resistor r=37.8119 c=0
Rl28 (\2\:mout \3\:mout) resistor r=101.718 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=45.3867 c=0
Rl29 (\4\:CKbb \5\:CKbb) resistor r=34.5212 c=0
Rl21 (CKbb \2\:CKbb) resistor r=27.9704 c=0
Rl22 (\2\:CKbb \3\:CKbb) resistor r=133.541 c=0
Rl24 (n20 \2\:n20) resistor r=111.99 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=56.2212 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=5.3317 c=0
Rl41 (\3\:SEb \4\:SEb) resistor r=26.1559 c=0
Rl40 (SEb \2\:SEb) resistor r=73.7687 c=0
Rz2 (\4\:QN \3\:QN) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=25 c=0
Rz16 (\6\:VDD \3\:VDD) resistor r=75 c=0
Rz17 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\10\:VDD \3\:VDD) resistor r=15 c=0
Rz19 (\12\:VDD \3\:VDD) resistor r=6.25 c=0
Rz3 (\5\:Q \4\:Q) resistor r=75 c=0
Rz20 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz4 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz1 (\11\:net436 \10\:net436) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (Dbp \2\:Dbp) resistor r=75 c=0
Rz11 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\8\:Db \9\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry2 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry19 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \2\:Q) resistor r=20.6667 c=0
Ry23 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry24 (\4\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry25 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \1\:VSS) resistor r=6.2 c=0
Ry27 (\13\:VSS \1\:VSS) resistor r=31 c=0
Ry4 (\16\:qbint \15\:qbint) resistor r=62 c=0
Ry1 (\13\:net436 \12\:net436) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry11 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx21 (\2\:D \4\:D) resistor r=45 c=0
Rx16 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\2\:RN \4\:RN) resistor r=45 c=0
Rx19 (\2\:SE \7\:SE) resistor r=45 c=0
Rx3 (\14\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\21\:qbint \3\:qbint) resistor r=45 c=0
Rx1 (\8\:net436 \4\:net436) resistor r=45 c=0
Rx9 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx7 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx18 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn56 (\10\:net436 \2\:qbint \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.625e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn57_1__rcx (\3\:QN net436 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.272e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=1.18971e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn55 (\4\:Q \4\:qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.78e-14 ad=7.54e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.71058e-07 sb=7.19712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\18\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1e-13 ad=3.19e-14 ps=1.74e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=2.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\17\:qbint n30 \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.485e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.38134e-06 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mn50 (net460 \13\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=1.958e-14 ps=7.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.66e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn51 (\4\:n30 CKb net460 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.48e-14 ps=5.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.48e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn40 (\4\:n30 CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.48e-14 ps=8.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.195e-06 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn30 (\8\:mout n20 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=3.988e-14 ps=1.52e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=8.75e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn35 (net452 mout \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=8.7e-15 ps=1.52e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=6.1e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn36 (\9\:n20 \5\:CKbb net452 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.64e-14 ps=4.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=5.05e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn25 (\9\:Dbp \10\:CKb \9\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.64e-14 ad=2.03e-14 ps=9.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=1.4e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn21 (\8\:CKbb \5\:CKb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn12 (net484 \1\:SI \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn13 (Dbp \4\:SE net484 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.972e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2.05e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn10 (\7\:SEb \5\:SE \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn0 (net476 \3\:RN \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.015e-14 ps=7.3e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.5e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=3.407e-14 ps=4.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.35e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mp57 (\1\:QN net436 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.362e-14 ad=6.24e-14 ps=1.18e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.13378e-06 sd=160n sca=31.932 \
        scb=0.0211673 scc=0.00336255 m=(2)
mp55 (\2\:Q \4\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.76e-14 ad=1.014e-13 ps=1.31e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.29551e-07 sb=6.73782e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp20 (\15\:CKb \1\:CK \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=4.085e-14 ps=1.42e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=1.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\15\:qbint \3\:n30 \22\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.75e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.39597e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp50 (net395 \11\:qbint \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.75e-14 ad=6.45e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.28488e-07 sb=1.63e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\8\:n30 \3\:CKbb net395 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.44e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.73488e-07 sb=1.285e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\8\:n30 \3\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.78488e-07 sb=1.08e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\6\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.93e-14 ad=3.762e-14 ps=1.57e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09849e-06 sb=8.6e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (net375 \3\:mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=1.29e-14 ps=1.57e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36349e-06 sb=5.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\5\:n20 \8\:CKb net375 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46849e-06 sb=4.9e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp25 (\5\:n20 \6\:CKbb \5\:Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69349e-06 sb=2.65e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp21 (\14\:CKbb \9\:CKb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp12 (net411 \4\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp13 (\7\:Dbp SEb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp11 (\7\:Dbp \6\:SE \6\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp10 (\5\:SEb \1\:SE \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.4e-07 sd=160n sca=34.0417 \
        scb=0.0261306 scc=0.00427152 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.4e-07 sd=160n sca=46.9401 \
        scb=0.0448095 scc=0.00567769 m=(1)
mp0 (\3\:Db \1\:RN \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.061e-13 ad=4.085e-14 ps=1.85e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.75e-07 sd=160n sca=36.3688 \
        scb=0.0292104 scc=0.00429572 m=(1)
ends SDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:47:21 2012 )
// Library name: gsclib045
// Cell name: SDFFTRX4
// View name: extracted

simulator lang=spectre

subckt SDFFTRX4 CK D Q QN RN SE SI VDD VSS
mp1 (\5\:Db \4\:D \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.4e-07 sd=160n sca=36.2105 \
        scb=0.0289447 scc=0.0042917 m=(1)
C1 (CK VSS) capacitor c=7.1313e-17
C2 (Q VSS) capacitor c=2.55875e-17
C3 (D VSS) capacitor c=2.84877e-17
C4 (SI VSS) capacitor c=6.60677e-17
C5 (QN VSS) capacitor c=1.66595e-17
C6 (VDD VSS) capacitor c=3.41687e-16
C7 (SE VSS) capacitor c=6.20436e-17
C8 (Db VSS) capacitor c=1.06098e-16
C9 (SEb VSS) capacitor c=4.53411e-17
C10 (Dbp VSS) capacitor c=2.13917e-17
C11 (net484 VSS) capacitor c=1.46245e-18
C12 (CKb VSS) capacitor c=7.71779e-17
C13 (CKbb VSS) capacitor c=3.43849e-17
C14 (n20 VSS) capacitor c=5.03224e-17
C15 (mout VSS) capacitor c=6.22068e-17
C16 (n30 VSS) capacitor c=2.14307e-16
C17 (qbint VSS) capacitor c=2.98922e-17
C18 (net436 VSS) capacitor c=2.75843e-16
C19 (net395 VSS) capacitor c=5.26647e-18
C20 (\22\:qbint VSS) capacitor c=4.66957e-17
C21 (\5\:qbint VSS) capacitor c=2.64987e-16
C22 (\4\:qbint VSS) capacitor c=3.83567e-17
C23 (\7\:CKbb VSS) capacitor c=5.03559e-17
C24 (\2\:CKb VSS) capacitor c=1.03583e-16
C25 (\3\:CKb VSS) capacitor c=1.19095e-16
C26 (\8\:CKb VSS) capacitor c=2.32753e-17
C27 (\1\:CK VSS) capacitor c=5.91679e-17
C28 (\1\:SI VSS) capacitor c=8.42597e-17
C29 (\3\:SEb VSS) capacitor c=5.53599e-17
C30 (\5\:SE VSS) capacitor c=3.37991e-17
C31 (\6\:SE VSS) capacitor c=2.56953e-17
C32 (\1\:RN VSS) capacitor c=4.00678e-17
C33 (\4\:D VSS) capacitor c=2.75365e-17
C34 (\20\:qbint VSS) capacitor c=3.37834e-17
C35 (\3\:qbint VSS) capacitor c=6.25291e-17
C36 (\5\:CKbb VSS) capacitor c=3.52461e-17
C37 (\3\:n20 VSS) capacitor c=3.29457e-17
C38 (\3\:mout VSS) capacitor c=6.89372e-17
C39 (\3\:CKbb VSS) capacitor c=8.13892e-17
C40 (\7\:CKb VSS) capacitor c=3.23373e-17
C41 (\9\:CKb VSS) capacitor c=1.38099e-17
C42 (\3\:CK VSS) capacitor c=2.44901e-17
C43 (\3\:SI VSS) capacitor c=2.95071e-17
C44 (\1\:SE VSS) capacitor c=6.54324e-17
C45 (\4\:SE VSS) capacitor c=2.35038e-17
C46 (\3\:RN VSS) capacitor c=4.46264e-17
C47 (\1\:D VSS) capacitor c=4.97956e-17
C48 (\21\:qbint VSS) capacitor c=4.05524e-17
C49 (\8\:CKbb VSS) capacitor c=4.02261e-17
C50 (\6\:CKbb VSS) capacitor c=3.39329e-17
C51 (\2\:n20 VSS) capacitor c=3.56721e-17
C52 (\2\:mout VSS) capacitor c=5.71427e-17
C53 (\4\:CKbb VSS) capacitor c=2.53239e-17
C54 (\2\:CKbb VSS) capacitor c=4.15301e-17
C55 (\6\:CKb VSS) capacitor c=9.29373e-18
C56 (\2\:CK VSS) capacitor c=4.22726e-17
C57 (\2\:SI VSS) capacitor c=5.3035e-17
C58 (\4\:SEb VSS) capacitor c=4.23095e-17
C59 (\2\:SEb VSS) capacitor c=2.34301e-17
C60 (\3\:SE VSS) capacitor c=4.56126e-17
C61 (\2\:RN VSS) capacitor c=4.33746e-17
C62 (\3\:D VSS) capacitor c=1.27384e-17
C63 (\19\:net436 VSS) capacitor c=3.50198e-17
C64 (\1\:VDD VSS) capacitor c=4.6526e-16
C65 (\1\:Q VSS) capacitor c=1.52391e-16
C66 (\30\:qbint VSS) capacitor c=5.97645e-17
C67 (\10\:n30 VSS) capacitor c=5.84428e-17
C68 (\4\:mout VSS) capacitor c=2.34013e-17
C69 (\22\:VDD VSS) capacitor c=3.44227e-17
C70 (\8\:n20 VSS) capacitor c=3.5425e-17
C71 (\17\:CKbb VSS) capacitor c=5.20867e-17
C72 (\26\:VDD VSS) capacitor c=3.26703e-17
C73 (\14\:CKb VSS) capacitor c=7.14679e-17
C74 (\29\:VDD VSS) capacitor c=4.21694e-17
C75 (\9\:Dbp VSS) capacitor c=1.86356e-17
C76 (\3\:Db VSS) capacitor c=1.64044e-16
C77 (\9\:SEb VSS) capacitor c=1.28707e-16
C78 (\33\:VDD VSS) capacitor c=2.28173e-17
C79 (\5\:Db VSS) capacitor c=1.51827e-16
C80 (\36\:VDD VSS) capacitor c=3.6202e-17
C81 (\3\:VDD VSS) capacitor c=1.02525e-16
C82 (\15\:net436 VSS) capacitor c=4.40671e-17
C83 (\1\:QN VSS) capacitor c=1.19317e-16
C84 (\24\:qbint VSS) capacitor c=2.13995e-16
C85 (\8\:n30 VSS) capacitor c=6.51029e-17
C86 (\8\:mout VSS) capacitor c=5.27667e-17
C87 (\6\:n20 VSS) capacitor c=3.7363e-17
C88 (\7\:Dbp VSS) capacitor c=1.0092e-16
C89 (\12\:CKbb VSS) capacitor c=8.59699e-17
C90 (\12\:CKb VSS) capacitor c=6.48015e-17
C91 (\5\:Dbp VSS) capacitor c=9.47147e-17
C92 (\7\:SEb VSS) capacitor c=1.35955e-16
C93 (\7\:Db VSS) capacitor c=5.2752e-17
C94 (\2\:D VSS) capacitor c=2.98486e-17
C95 (\2\:SE VSS) capacitor c=8.0372e-17
C96 (\4\:CKb VSS) capacitor c=7.19778e-17
C97 (\5\:CKb VSS) capacitor c=2.08142e-17
C98 (\2\:qbint VSS) capacitor c=3.38824e-17
C99 (\5\:D VSS) capacitor c=5.55329e-17
C100 (\4\:RN VSS) capacitor c=1.21762e-16
C101 (\7\:SE VSS) capacitor c=6.25849e-17
C102 (\5\:SEb VSS) capacitor c=1.22828e-16
C103 (\6\:SEb VSS) capacitor c=1.54148e-16
C104 (\4\:SI VSS) capacitor c=5.00629e-17
C105 (\4\:CK VSS) capacitor c=4.6136e-17
C106 (\10\:CKb VSS) capacitor c=3.04048e-17
C107 (\11\:CKb VSS) capacitor c=7.78548e-17
C108 (\3\:Dbp VSS) capacitor c=1.84517e-16
C109 (\4\:Dbp VSS) capacitor c=2.10336e-16
C110 (\4\:n20 VSS) capacitor c=5.86197e-17
C111 (\5\:n20 VSS) capacitor c=5.09506e-17
C112 (\6\:mout VSS) capacitor c=5.43514e-17
C113 (\7\:mout VSS) capacitor c=4.55691e-17
C114 (\9\:CKbb VSS) capacitor c=2.08888e-17
C115 (\10\:CKbb VSS) capacitor c=9.52596e-17
C116 (\11\:CKbb VSS) capacitor c=8.01711e-17
C117 (\14\:CKbb VSS) capacitor c=1.26743e-16
C118 (\15\:CKbb VSS) capacitor c=6.38716e-17
C119 (\16\:CKbb VSS) capacitor c=7.71549e-17
C120 (\6\:n30 VSS) capacitor c=5.19987e-17
C121 (\7\:n30 VSS) capacitor c=8.5579e-17
C122 (\4\:Q VSS) capacitor c=1.21519e-16
C123 (\5\:QN VSS) capacitor c=1.65408e-16
C124 (\23\:qbint VSS) capacitor c=2.44763e-16
C125 (\26\:qbint VSS) capacitor c=3.2372e-17
C126 (\27\:qbint VSS) capacitor c=2.28651e-17
C127 (\28\:qbint VSS) capacitor c=4.73133e-17
C128 (\29\:qbint VSS) capacitor c=3.12322e-17
C129 (\17\:net436 VSS) capacitor c=3.52176e-17
C130 (\18\:net436 VSS) capacitor c=3.79702e-17
C131 (\21\:VDD VSS) capacitor c=1.94258e-17
C132 (\25\:VDD VSS) capacitor c=1.42732e-17
C133 (\28\:VDD VSS) capacitor c=2.28157e-17
C134 (\32\:VDD VSS) capacitor c=2.15017e-17
Rk11 (CK \4\:CK) resistor r=0.1608 c=0
Rk37 (\1\:Q Q) resistor r=0.04991 c=0
Rk38 (Q \4\:Q) resistor r=0.2128 c=0
Rk2 (\4\:RN RN) resistor r=0.01002 c=0
Rk1 (\5\:D D) resistor r=0.1911 c=0
Rk10 (SI \4\:SI) resistor r=0.1745 c=0
Rk43 (\1\:QN QN) resistor r=0.217 c=0
Rk44 (QN \5\:QN) resistor r=0.04798 c=0
Rk90 (\1\:VDD \21\:VDD) resistor r=0.5361 c=0
Rk91 (\21\:VDD \23\:VDD) resistor r=0.3636 c=0
Rk92 (\21\:VDD \24\:VDD) resistor r=0.238 c=0
Rk93 (\24\:VDD \25\:VDD) resistor r=0.2555 c=0
Rk94 (\25\:VDD \27\:VDD) resistor r=0.2292 c=0
Rk95 (\25\:VDD \28\:VDD) resistor r=0.3506 c=0
Rk96 (\28\:VDD \30\:VDD) resistor r=0.244 c=0
Rk97 (\28\:VDD \31\:VDD) resistor r=0.1452 c=0
Rk98 (\31\:VDD \32\:VDD) resistor r=0.4937 c=0
Rk99 (\32\:VDD \34\:VDD) resistor r=0.1936 c=0
Rk102 (\35\:VDD VDD) resistor r=0.1508 c=0
Rk100 (\32\:VDD \35\:VDD) resistor r=0.2079 c=0
Rk101 (\35\:VDD \37\:VDD) resistor r=0.4576 c=0
Rk61 (\1\:VSS \9\:VSS) resistor r=0.1577 c=0
Rk62 (\9\:VSS \10\:VSS) resistor r=0.3197 c=0
Rk63 (\10\:VSS \11\:VSS) resistor r=0.5577 c=0
Rk64 (\11\:VSS \12\:VSS) resistor r=0.2779 c=0
Rk65 (\12\:VSS \13\:VSS) resistor r=0.04493 c=0
Rk66 (\13\:VSS \14\:VSS) resistor r=0.609 c=0
Rk68 (\15\:VSS VSS) resistor r=0.1502 c=0
Rk67 (\14\:VSS \15\:VSS) resistor r=0.1928 c=0
Rk74 (\10\:VSS \27\:VSS) resistor r=0.04329 c=0
Rk75 (\11\:VSS \29\:VSS) resistor r=0.3791 c=0
Rk76 (\12\:VSS \31\:VSS) resistor r=0.236 c=0
Rk77 (\14\:VSS \33\:VSS) resistor r=0.2903 c=0
Rk3 (\7\:SE SE) resistor r=0.02806 c=0
Rk4 (\2\:Db \4\:Db) resistor r=0.6735 c=0
Rk5 (\4\:Db \6\:Db) resistor r=0.8044 c=0
Rk6 (\6\:Db \8\:Db) resistor r=0.3895 c=0
Rk7 (\5\:SEb \6\:SEb) resistor r=0.8129 c=0
Rk8 (\6\:SEb \8\:SEb) resistor r=0.5887 c=0
Rk9 (\8\:SEb \10\:SEb) resistor r=0.7909 c=0
Rk15 (\2\:Dbp \3\:Dbp) resistor r=0.07204 c=0
Rk16 (\3\:Dbp \4\:Dbp) resistor r=1.3455 c=0
Rk17 (\4\:Dbp \6\:Dbp) resistor r=0.667 c=0
Rk18 (\3\:Dbp \8\:Dbp) resistor r=0.4975 c=0
Rk19 (\4\:Dbp \10\:Dbp) resistor r=0.05258 c=0
Rk12 (\10\:CKb \11\:CKb) resistor r=0.1655 c=0
Rk13 (\11\:CKb \13\:CKb) resistor r=0.3674 c=0
Rk14 (\11\:CKb \15\:CKb) resistor r=0.3375 c=0
Rk26 (\9\:CKbb \10\:CKbb) resistor r=0.02533 c=0
Rk27 (\10\:CKbb \11\:CKbb) resistor r=0.2134 c=0
Rk28 (\11\:CKbb \13\:CKbb) resistor r=0.3986 c=0
Rk29 (\10\:CKbb \14\:CKbb) resistor r=0.771 c=0
Rk30 (\14\:CKbb \15\:CKbb) resistor r=0.3035 c=0
Rk31 (\11\:CKbb \16\:CKbb) resistor r=0.404 c=0
Rk32 (\13\:CKbb \18\:CKbb) resistor r=0.2928 c=0
Rk20 (\4\:n20 \5\:n20) resistor r=0.2802 c=0
Rk21 (\5\:n20 \7\:n20) resistor r=0.1273 c=0
Rk22 (\5\:n20 \9\:n20) resistor r=0.2615 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.1407 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2414 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2584 c=0
Rk33 (\6\:n30 \7\:n30) resistor r=0.2587 c=0
Rk34 (\7\:n30 \9\:n30) resistor r=0.3143 c=0
Rk35 (\7\:n30 \11\:n30) resistor r=0.4203 c=0
Rk47 (\23\:qbint \25\:qbint) resistor r=1.8791 c=0
Rk48 (\25\:qbint \26\:qbint) resistor r=0.4293 c=0
Rk49 (\26\:qbint \27\:qbint) resistor r=0.1058 c=0
Rk50 (\27\:qbint \28\:qbint) resistor r=0.1785 c=0
Rk51 (\26\:qbint \29\:qbint) resistor r=0.06834 c=0
Rk52 (\27\:qbint \31\:qbint) resistor r=0.1976 c=0
Rk53 (\16\:net436 \17\:net436) resistor r=0.3545 c=0
Rk54 (\17\:net436 \18\:net436) resistor r=0.2072 c=0
Rk55 (\17\:net436 \20\:net436) resistor r=0.1266 c=0
Rl15 (\1\:CK \2\:CK) resistor r=212.23 c=0
Rl16 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl4 (\1\:RN \2\:RN) resistor r=78.079 c=0
Rl5 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl3 (\2\:D \4\:D) resistor r=66.0479 c=0
Rl1 (\1\:D \2\:D) resistor r=94.5391 c=0
Rl2 (\2\:D \3\:D) resistor r=12.1383 c=0
Rl13 (\1\:SI \2\:SI) resistor r=210.771 c=0
Rl14 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl11 (\3\:SE \6\:SE) resistor r=33.4251 c=0
Rl9 (\3\:SE \4\:SE) resistor r=76.7181 c=0
Rl10 (\2\:SE \5\:SE) resistor r=122.758 c=0
Rl7 (\1\:SE \2\:SE) resistor r=215.363 c=0
Rl8 (\2\:SE \3\:SE) resistor r=213.851 c=0
Rl12 (\3\:SEb \4\:SEb) resistor r=62.2302 c=0
Rl6 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl24 (CKb \2\:CKb) resistor r=187.593 c=0
Rl25 (\2\:CKb \3\:CKb) resistor r=408.747 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=143.774 c=0
Rl29 (\4\:CKb \7\:CKb) resistor r=55.4507 c=0
Rl30 (\5\:CKb \8\:CKb) resistor r=37.2017 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=9.8883 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=206.49 c=0
Rl32 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl18 (\3\:CKbb \4\:CKbb) resistor r=58.3841 c=0
Rl17 (CKbb \2\:CKbb) resistor r=28.079 c=0
Rl21 (n20 \2\:n20) resistor r=100.692 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl19 (mout \2\:mout) resistor r=37.6944 c=0
Rl20 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl68 (\21\:qbint \22\:qbint) resistor r=62.6944 c=0
Rl67 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl33 (\2\:qbint qbint) resistor r=6.99 c=0
Rl35 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rz28 (\1\:VDD \3\:VDD) resistor r=3.9474 c=0
Rz29 (\24\:VDD \3\:VDD) resistor r=15 c=0
Rz30 (\31\:VDD \3\:VDD) resistor r=7.5 c=0
Rz31 (\35\:VDD \3\:VDD) resistor r=18.75 c=0
Rz23 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz24 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz25 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz26 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz1 (Db \2\:Db) resistor r=75 c=0
Rz2 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz5 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz6 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz4 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz9 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz7 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz10 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz15 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz16 (\16\:net436 \15\:net436) resistor r=75 c=0
Ry27 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry28 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry29 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry30 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry31 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=6.2 c=0
Ry18 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry19 (\13\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\15\:VSS \3\:VSS) resistor r=15.5 c=0
Ry1 (\3\:Db \4\:Db) resistor r=62 c=0
Ry2 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry5 (Dbp \2\:Dbp) resistor r=62 c=0
Ry6 (\9\:Dbp \10\:Dbp) resistor r=62 c=0
Ry4 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry9 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry8 (\4\:mout \5\:mout) resistor r=62 c=0
Ry10 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry15 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry16 (\20\:net436 \19\:net436) resistor r=20.6667 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\3\:SE \7\:SE) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx8 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx11 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx15 (\6\:n30 n30) resistor r=45 c=0
Rx16 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx17 (\28\:qbint qbint) resistor r=45 c=0
Rx18 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx19 (\18\:net436 net436) resistor r=45 c=0
mn1 (\7\:Db \1\:D net476 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (net476 \3\:RN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\7\:SEb \4\:SE \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (Db SEb \5\:Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn13 (\5\:Dbp \1\:SE net484 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.05e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn12 (net484 \3\:SI \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.392e-14 ps=7.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.95e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn20 (\12\:CKb \3\:CK \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn21 (\12\:CKbb \9\:CKb \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\7\:Dbp \7\:CKb \6\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb net452 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (net452 \3\:mout \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.345e-14 ad=3.625e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.553e-14 ps=7.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb net460 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=3.553e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (net460 \3\:qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.088e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.593e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(2)
mn55_1__rcx (\4\:Q \5\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn57_1__rcx (\1\:QN net436 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.095e-14 ad=4.745e-14 ps=1.3325e-06 pd=8.85e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=10.79 scb=0.0100512 scc=0.000418069 m=(4)
mn56 (\15\:net436 \20\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp0 (\5\:Db \1\:RN \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=4.085e-14 ps=1.49e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=4.05e-07 sd=160n sca=34.1358 \
        scb=0.0262014 scc=0.0042716 m=(1)
mp10 (\9\:SEb \6\:SE \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.4e-07 sd=160n sca=33.3059 \
        scb=0.0257988 scc=0.00427133 m=(1)
mp11 (\9\:Dbp \5\:SE \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.268e-14 ps=7.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp13 (\9\:Dbp \3\:SEb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.268e-14 ps=5.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=6.15e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp12 (net411 \1\:SI \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=1.72e-14 ps=8.5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=4.9e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\14\:CKb \1\:CK \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=5.053e-14 ps=8.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.35e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\17\:CKbb \8\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp25 (\8\:n20 CKbb Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb net375 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.848e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp35 (net375 mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.848e-14 ps=8.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb net395 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp50 (net395 \4\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp45 (\30\:qbint n30 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27395e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57_1__rcx (\5\:QN net436 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp56 (\19\:net436 \22\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
ends SDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:47:59 2012 )
// Library name: gsclib045
// Cell name: SDFFTRXL
// View name: extracted

simulator lang=spectre

subckt SDFFTRXL CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net436 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.5197 \
        scb=0.0328493 scc=0.0059298 m=(1)
C1 (D VSS) capacitor c=8.99012e-17
C2 (SI VSS) capacitor c=2.65656e-17
C3 (QN VSS) capacitor c=2.20791e-17
C4 (CK VSS) capacitor c=7.33811e-17
C5 (RN VSS) capacitor c=2.88191e-17
C6 (VDD VSS) capacitor c=3.128e-16
C7 (Q VSS) capacitor c=4.70776e-17
C8 (SE VSS) capacitor c=2.63065e-17
C9 (net436 VSS) capacitor c=2.08137e-17
C10 (qbint VSS) capacitor c=3.91251e-17
C11 (CKb VSS) capacitor c=4.41918e-17
C12 (n30 VSS) capacitor c=4.91156e-17
C13 (net460 VSS) capacitor c=4.15614e-18
C14 (mout VSS) capacitor c=7.63246e-17
C15 (CKbb VSS) capacitor c=2.24187e-17
C16 (n20 VSS) capacitor c=4.19419e-17
C17 (Dbp VSS) capacitor c=1.04199e-16
C18 (Db VSS) capacitor c=1.25926e-16
C19 (SEb VSS) capacitor c=4.11157e-17
C20 (net395 VSS) capacitor c=4.07614e-18
C21 (net375 VSS) capacitor c=4.79292e-20
C22 (\4\:D VSS) capacitor c=3.3589e-17
C23 (\1\:RN VSS) capacitor c=4.36921e-17
C24 (\6\:SE VSS) capacitor c=2.67063e-17
C25 (\7\:SE VSS) capacitor c=3.65021e-17
C26 (\4\:SI VSS) capacitor c=4.55168e-17
C27 (\9\:CKb VSS) capacitor c=4.94449e-17
C28 (\6\:CKbb VSS) capacitor c=4.55324e-17
C29 (\8\:CKb VSS) capacitor c=5.82383e-17
C30 (\3\:n20 VSS) capacitor c=3.6957e-17
C31 (\3\:CKb VSS) capacitor c=5.29815e-17
C32 (\3\:CKbb VSS) capacitor c=4.3689e-17
C33 (\7\:qbint VSS) capacitor c=4.16463e-17
C34 (\1\:CK VSS) capacitor c=3.02892e-17
C35 (\6\:qbint VSS) capacitor c=2.60477e-17
C36 (\4\:net436 VSS) capacitor c=2.94269e-17
C37 (\3\:D VSS) capacitor c=2.93842e-17
C38 (\3\:RN VSS) capacitor c=3.15111e-17
C39 (\1\:SE VSS) capacitor c=2.74017e-17
C40 (\3\:SEb VSS) capacitor c=3.69645e-17
C41 (\5\:SE VSS) capacitor c=6.05178e-17
C42 (\1\:SI VSS) capacitor c=4.98339e-17
C43 (\5\:CKb VSS) capacitor c=3.28832e-17
C44 (\10\:CKb VSS) capacitor c=2.83872e-17
C45 (\4\:CKbb VSS) capacitor c=8.05423e-17
C46 (\3\:mout VSS) capacitor c=5.29029e-17
C47 (\10\:qbint VSS) capacitor c=3.75291e-17
C48 (\2\:n30 VSS) capacitor c=3.98916e-17
C49 (\3\:CK VSS) capacitor c=3.61453e-17
C50 (\5\:qbint VSS) capacitor c=2.06148e-17
C51 (\4\:qbint VSS) capacitor c=2.61407e-17
C52 (\3\:net436 VSS) capacitor c=3.01259e-17
C53 (\1\:D VSS) capacitor c=1.5712e-17
C54 (\2\:RN VSS) capacitor c=4.28685e-17
C55 (\2\:SE VSS) capacitor c=3.19643e-17
C56 (\4\:SEb VSS) capacitor c=4.71816e-17
C57 (\2\:SEb VSS) capacitor c=4.12527e-17
C58 (\3\:SI VSS) capacitor c=2.64657e-17
C59 (\7\:CKbb VSS) capacitor c=4.23743e-17
C60 (\11\:CKb VSS) capacitor c=3.15115e-17
C61 (\5\:CKbb VSS) capacitor c=2.98721e-17
C62 (\2\:mout VSS) capacitor c=5.23157e-17
C63 (\2\:n20 VSS) capacitor c=4.23485e-17
C64 (\4\:CKb VSS) capacitor c=2.11133e-17
C65 (\2\:CKbb VSS) capacitor c=4.55523e-17
C66 (\2\:CKb VSS) capacitor c=2.968e-17
C67 (\9\:qbint VSS) capacitor c=5.11821e-17
C68 (\3\:n30 VSS) capacitor c=2.22335e-17
C69 (\2\:CK VSS) capacitor c=3.50857e-17
C70 (\2\:qbint VSS) capacitor c=4.65743e-17
C71 (\1\:VDD VSS) capacitor c=3.68933e-17
C72 (\3\:Db VSS) capacitor c=2.03773e-16
C73 (\6\:VDD VSS) capacitor c=2.24003e-17
C74 (\5\:SEb VSS) capacitor c=1.01013e-16
C75 (\5\:Db VSS) capacitor c=1.32126e-16
C76 (\6\:Dbp VSS) capacitor c=4.53893e-17
C77 (\10\:VDD VSS) capacitor c=3.85343e-17
C78 (\8\:CKbb VSS) capacitor c=8.51202e-17
C79 (\4\:Dbp VSS) capacitor c=1.04777e-16
C80 (\4\:n20 VSS) capacitor c=3.20015e-17
C81 (\13\:VDD VSS) capacitor c=8.42046e-18
C82 (\8\:mout VSS) capacitor c=4.07385e-17
C83 (\7\:n30 VSS) capacitor c=6.97812e-17
C84 (\17\:VDD VSS) capacitor c=3.11883e-17
C85 (\15\:qbint VSS) capacitor c=4.4228e-17
C86 (\15\:CKb VSS) capacitor c=1.04782e-16
C87 (\21\:VDD VSS) capacitor c=2.61673e-17
C88 (\3\:Q VSS) capacitor c=4.90598e-17
C89 (\5\:net436 VSS) capacitor c=3.45954e-17
C90 (\25\:VDD VSS) capacitor c=3.90467e-17
C91 (\1\:QN VSS) capacitor c=1.98005e-17
C92 (\3\:VDD VSS) capacitor c=1.19087e-16
C93 (\7\:SEb VSS) capacitor c=1.62259e-16
C94 (\7\:Db VSS) capacitor c=1.33209e-16
C95 (\14\:CKbb VSS) capacitor c=4.14974e-17
C96 (\8\:Dbp VSS) capacitor c=6.88244e-17
C97 (\8\:n20 VSS) capacitor c=5.9772e-17
C98 (\6\:mout VSS) capacitor c=3.74018e-17
C99 (\5\:n30 VSS) capacitor c=9.12032e-17
C100 (\13\:qbint VSS) capacitor c=9.98592e-17
C101 (\19\:CKb VSS) capacitor c=6.41582e-17
C102 (\1\:Q VSS) capacitor c=7.19182e-17
C103 (\9\:net436 VSS) capacitor c=2.82612e-17
C104 (\3\:QN VSS) capacitor c=3.41862e-17
C105 (\2\:net436 VSS) capacitor c=1.24219e-17
C106 (\3\:qbint VSS) capacitor c=3.79632e-17
C107 (\6\:CKb VSS) capacitor c=6.33012e-17
C108 (\7\:CKb VSS) capacitor c=6.99934e-17
C109 (\2\:SI VSS) capacitor c=3.50743e-17
C110 (\3\:SE VSS) capacitor c=2.37813e-17
C111 (\4\:SE VSS) capacitor c=8.39838e-17
C112 (\7\:net436 VSS) capacitor c=2.94398e-17
C113 (\8\:net436 VSS) capacitor c=3.10705e-17
C114 (\2\:D VSS) capacitor c=2.4914e-17
C115 (\4\:CK VSS) capacitor c=3.04526e-17
C116 (\11\:qbint VSS) capacitor c=3.36563e-17
C117 (\12\:qbint VSS) capacitor c=2.94292e-17
C118 (\17\:qbint VSS) capacitor c=9.01607e-17
C119 (\4\:n30 VSS) capacitor c=7.92312e-17
C120 (\4\:mout VSS) capacitor c=5.39074e-17
C121 (\5\:mout VSS) capacitor c=5.14965e-17
C122 (\12\:CKb VSS) capacitor c=1.56591e-17
C123 (\13\:CKb VSS) capacitor c=6.20245e-17
C124 (\14\:CKb VSS) capacitor c=8.9555e-17
C125 (\17\:CKb VSS) capacitor c=6.14148e-17
C126 (\18\:CKb VSS) capacitor c=4.93998e-17
C127 (\6\:n20 VSS) capacitor c=6.02721e-17
C128 (\7\:n20 VSS) capacitor c=5.08193e-17
C129 (\10\:CKbb VSS) capacitor c=1.32575e-16
C130 (\11\:CKbb VSS) capacitor c=6.21795e-17
C131 (\12\:CKbb VSS) capacitor c=9.29196e-17
C132 (\13\:CKbb VSS) capacitor c=1.13372e-16
C133 (\16\:CKbb VSS) capacitor c=2.46062e-17
C134 (\5\:SI VSS) capacitor c=7.67731e-17
C135 (\3\:Dbp VSS) capacitor c=1.20425e-16
C136 (\9\:SEb VSS) capacitor c=1.61735e-16
C137 (\10\:SEb VSS) capacitor c=5.94133e-17
C138 (\8\:SE VSS) capacitor c=1.05646e-16
C139 (\4\:RN VSS) capacitor c=5.76671e-17
C140 (\5\:D VSS) capacitor c=3.83863e-17
C141 (\5\:VDD VSS) capacitor c=2.84797e-17
C142 (\9\:VDD VSS) capacitor c=2.0639e-17
C143 (\12\:VDD VSS) capacitor c=2.37789e-17
C144 (\20\:VDD VSS) capacitor c=8.5089e-18
C145 (\24\:VDD VSS) capacitor c=4.27868e-18
Rk43 (D \5\:D) resistor r=0.1291 c=0
Rk33 (\5\:SI SI) resistor r=0.03534 c=0
Rk2 (\4\:QN QN) resistor r=0.08313 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2241 c=0
Rk8 (CK \4\:CK) resistor r=0.08095 c=0
Rk42 (RN \4\:RN) resistor r=0.1263 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.4239 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.281 c=0
Rk49 (\5\:VDD \7\:VDD) resistor r=0.1795 c=0
Rk50 (\5\:VDD \8\:VDD) resistor r=0.5711 c=0
Rk51 (\8\:VDD \9\:VDD) resistor r=0.03488 c=0
Rk52 (\9\:VDD \11\:VDD) resistor r=0.2624 c=0
Rk53 (\9\:VDD \12\:VDD) resistor r=0.5333 c=0
Rk54 (\12\:VDD \14\:VDD) resistor r=0.07334 c=0
Rk55 (\12\:VDD \15\:VDD) resistor r=0.283 c=0
Rk56 (\15\:VDD \16\:VDD) resistor r=0.2303 c=0
Rk57 (\16\:VDD \18\:VDD) resistor r=0.2214 c=0
Rk58 (\16\:VDD \19\:VDD) resistor r=0.2203 c=0
Rk59 (\19\:VDD \20\:VDD) resistor r=0.2003 c=0
Rk60 (\20\:VDD \22\:VDD) resistor r=0.289 c=0
Rk61 (\20\:VDD \23\:VDD) resistor r=0.3005 c=0
Rk64 (\24\:VDD VDD) resistor r=0.2025 c=0
Rk62 (\23\:VDD \24\:VDD) resistor r=0.04741 c=0
Rk63 (\24\:VDD \26\:VDD) resistor r=0.4151 c=0
Rk6 (\2\:Q Q) resistor r=0.2325 c=0
Rk7 (Q \4\:Q) resistor r=0.1766 c=0
Rk65 (\2\:VSS \3\:VSS) resistor r=0.2378 c=0
Rk66 (\3\:VSS \4\:VSS) resistor r=0.313 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.3205 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.1301 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.4023 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=0.3472 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.1642 c=0
Rk72 (\9\:VSS \10\:VSS) resistor r=0.4547 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.1301 c=0
Rk74 (\11\:VSS \12\:VSS) resistor r=0.1827 c=0
Rk76 (\13\:VSS VSS) resistor r=0.09998 c=0
Rk75 (\12\:VSS \13\:VSS) resistor r=0.1176 c=0
Rk77 (\3\:VSS \15\:VSS) resistor r=0.293 c=0
Rk78 (\5\:VSS \17\:VSS) resistor r=0.2204 c=0
Rk79 (\7\:VSS \19\:VSS) resistor r=0.04326 c=0
Rk80 (\9\:VSS \21\:VSS) resistor r=0.04326 c=0
Rk81 (\10\:VSS \23\:VSS) resistor r=0.07334 c=0
Rk82 (\12\:VSS \25\:VSS) resistor r=0.07334 c=0
Rk41 (SE \8\:SE) resistor r=0.04113 c=0
Rk3 (\6\:net436 \7\:net436) resistor r=0.1174 c=0
Rk4 (\7\:net436 \8\:net436) resistor r=0.119 c=0
Rk5 (\7\:net436 \10\:net436) resistor r=0.1055 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.1776 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.1202 c=0
Rk11 (\12\:qbint \16\:qbint) resistor r=0.2251 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.7298 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.05038 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2996 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.5266 c=0
Rk21 (\13\:CKb \17\:CKb) resistor r=0.515 c=0
Rk22 (\14\:CKb \18\:CKb) resistor r=0.3162 c=0
Rk23 (\16\:CKb \20\:CKb) resistor r=0.4107 c=0
Rk13 (\4\:n30 \6\:n30) resistor r=0.4506 c=0
Rk14 (\6\:n30 \8\:n30) resistor r=0.4269 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2403 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.1339 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.2297 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.5477 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.4234 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.2125 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.7399 c=0
Rk31 (\11\:CKbb \15\:CKbb) resistor r=0.2495 c=0
Rk32 (\12\:CKbb \16\:CKbb) resistor r=0.04286 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.1244 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.257 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.1998 c=0
Rk34 (\2\:Dbp \3\:Dbp) resistor r=0.6709 c=0
Rk35 (\3\:Dbp \5\:Dbp) resistor r=0.4263 c=0
Rk36 (\3\:Dbp \7\:Dbp) resistor r=0.2392 c=0
Rk37 (\5\:Dbp \9\:Dbp) resistor r=0.395 c=0
Rk44 (\2\:Db \4\:Db) resistor r=1.1956 c=0
Rk45 (\4\:Db \6\:Db) resistor r=0.7797 c=0
Rk46 (\6\:Db \8\:Db) resistor r=0.7843 c=0
Rk38 (\6\:SEb \8\:SEb) resistor r=0.5275 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.8721 c=0
Rk40 (\9\:SEb \10\:SEb) resistor r=0.3236 c=0
Rl47 (\2\:D \4\:D) resistor r=78.5603 c=0
Rl46 (\2\:D \3\:D) resistor r=84.3295 c=0
Rl45 (\1\:D \2\:D) resistor r=15.4894 c=0
Rl34 (\2\:SI \4\:SI) resistor r=102.726 c=0
Rl32 (\1\:SI \2\:SI) resistor r=154.496 c=0
Rl33 (\2\:SI \3\:SI) resistor r=3.1183 c=0
Rl9 (\1\:CK \2\:CK) resistor r=68.4636 c=0
Rl10 (\2\:CK \3\:CK) resistor r=93.4636 c=0
Rl43 (\1\:RN \2\:RN) resistor r=95.3867 c=0
Rl44 (\2\:RN \3\:RN) resistor r=47.3097 c=0
Rl37 (\1\:SE \2\:SE) resistor r=69.0258 c=0
Rl41 (\3\:SE \6\:SE) resistor r=63.143 c=0
Rl38 (\2\:SE \3\:SE) resistor r=17.6971 c=0
Rl42 (\4\:SE \7\:SE) resistor r=124.681 c=0
Rl40 (\4\:SE \5\:SE) resistor r=180.313 c=0
Rl39 (\3\:SE \4\:SE) resistor r=208.082 c=0
Rl1 (net436 \2\:net436) resistor r=2.0213 c=0
Rl3 (\2\:net436 \4\:net436) resistor r=49.7141 c=0
Rl2 (\2\:net436 \3\:net436) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=131.502 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=58.8489 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=30.0028 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=177.761 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=108.895 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=34.3295 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=0.5166 c=0
Rl31 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=58.8482 c=0
Rl16 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl29 (\6\:CKb \9\:CKb) resistor r=160.998 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=99.845 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl30 (\7\:CKb \10\:CKb) resistor r=45.8353 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=193.595 c=0
Rl11 (n30 \2\:n30) resistor r=142.308 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl22 (mout \2\:mout) resistor r=87.2302 c=0
Rl23 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl24 (\4\:CKbb \5\:CKbb) resistor r=71.8456 c=0
Rl17 (CKbb \2\:CKbb) resistor r=27.9704 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=104.695 c=0
Rl20 (n20 \2\:n20) resistor r=89.6174 c=0
Rl21 (\2\:n20 \3\:n20) resistor r=38.085 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=68.4636 c=0
Rl35 (SEb \2\:SEb) resistor r=73.7687 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz17 (\3\:VDD \15\:VDD) resistor r=15 c=0
Rz18 (\3\:VDD \19\:VDD) resistor r=18.75 c=0
Rz19 (\3\:VDD \23\:VDD) resistor r=12.5 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz25 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz2 (\9\:net436 \10\:net436) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Dbp \2\:Dbp) resistor r=75 c=0
Rz11 (\8\:Dbp \9\:Dbp) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry19 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry25 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \11\:VSS) resistor r=20.6667 c=0
Ry27 (\1\:VSS \13\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:net436 \6\:net436) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry11 (\6\:Dbp \7\:Dbp) resistor r=62 c=0
Ry13 (\3\:Db \4\:Db) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx19 (\1\:D \5\:D) resistor r=45 c=0
Rx14 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:RN \4\:RN) resistor r=45 c=0
Rx17 (\2\:SE \8\:SE) resistor r=45 c=0
Rx1 (net436 \8\:net436) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx7 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\11\:CKb \17\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \4\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx16 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net436 \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net436 \4\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.663e-14 ad=2.103e-14 ps=1.58e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=4.7e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn20 (\19\:CKb \3\:CK \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.663e-14 ad=3.19e-14 ps=1.58e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.2e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn45 (\13\:qbint \2\:n30 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.765e-14 ad=2.465e-14 ps=1.43e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.855e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn50 (net460 \10\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.765e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.66e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (\8\:Dbp \10\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=2.85e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\5\:n30 CKb net460 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.48e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.455e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (\6\:mout n20 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=4.278e-14 ps=1.51e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=8.3e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn40 (\5\:n30 CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=3.48e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.17e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn35 (net452 \3\:mout \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.95e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn36 (\8\:n20 \4\:CKbb net452 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.9e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\14\:CKbb \5\:CKb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn12 (net484 \1\:SI \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn13 (Dbp \5\:SE net484 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=3.045e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=4.6e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (\7\:Db \3\:SEb Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.973e-14 ps=7.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=2.05e-07 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn10 (\7\:SEb \1\:SE \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.95e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (net476 \3\:RN \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.9e-14 ps=6.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.85e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (Db \3\:D net476 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.9e-14 \
        ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.95e-07 sb=1.4e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mp56 (\5\:net436 \6\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=4.837e-14 ps=8.4e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=4.35e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp20 (\15\:CKb \1\:CK \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=3.977e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=1.85e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp45 (\15\:qbint n30 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.825e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp50 (net395 \7\:qbint \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.61e-14 ad=5.483e-14 ps=1.35e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.56e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp51 (\7\:n30 \3\:CKbb net395 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.26e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp40 (\7\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.055e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp30 (\8\:mout \3\:n20 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.037e-13 ad=3.87e-14 ps=1.81e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.3e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp35 (net375 mout \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.037e-13 ad=1.29e-14 ps=1.81e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.65e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp36 (\4\:n20 \8\:CKb net375 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.6e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.87e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.35e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp21 (\8\:CKbb \9\:CKb \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp12 (net411 \4\:SI \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp13 (\6\:Dbp SEb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp11 (\6\:Dbp \7\:SE \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp10 (\5\:SEb \6\:SE \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.44e-14 ad=3.01e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp0 (\3\:Db \1\:RN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.44e-14 ad=4.3e-14 ps=1.56e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=3.85e-07 sd=160n sca=22.1877 \
        scb=0.0209143 scc=0.00225089 m=(1)
mp1 (\3\:Db \4\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.3e-14 ps=7.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.4e-07 sd=160n sca=23.1737 \
        scb=0.0215726 scc=0.00225171 m=(1)
ends SDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:48:37 2012 )
// Library name: gsclib045
// Cell name: SDFFX1
// View name: extracted

simulator lang=spectre

subckt SDFFX1 CK D Q QN SE SI VDD VSS
mp57 (\1\:QN \4\:net367 \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=35.4384 \
        scb=0.0268597 scc=0.00347151 m=(1)
C1 (CK VSS) capacitor c=6.52823e-17
C2 (QN VSS) capacitor c=2.09468e-17
C3 (SE VSS) capacitor c=4.45213e-17
C4 (VDD VSS) capacitor c=3.12622e-16
C5 (D VSS) capacitor c=3.22624e-17
C6 (Q VSS) capacitor c=6.73148e-17
C7 (net367 VSS) capacitor c=2.37288e-17
C8 (qbint VSS) capacitor c=4.02737e-17
C9 (CKb VSS) capacitor c=4.28157e-17
C10 (n30 VSS) capacitor c=5.15257e-17
C11 (net436 VSS) capacitor c=4.61273e-18
C12 (mout VSS) capacitor c=8.56549e-17
C13 (CKbb VSS) capacitor c=2.23996e-17
C14 (n20 VSS) capacitor c=5.02494e-17
C15 (Db VSS) capacitor c=8.43498e-17
C16 (net449 VSS) capacitor c=5.99301e-18
C17 (SEb VSS) capacitor c=3.75077e-17
C18 (net376 VSS) capacitor c=3.19507e-18
C19 (net384 VSS) capacitor c=3.1537e-18
C20 (\5\:SE VSS) capacitor c=4.9984e-17
C21 (\1\:SI VSS) capacitor c=3.918e-17
C22 (\2\:SE VSS) capacitor c=3.86513e-17
C23 (\4\:D VSS) capacitor c=5.23152e-17
C24 (\9\:CKb VSS) capacitor c=4.21298e-17
C25 (\6\:CKbb VSS) capacitor c=4.69213e-17
C26 (\8\:CKb VSS) capacitor c=6.72425e-17
C27 (\3\:n20 VSS) capacitor c=3.92091e-17
C28 (\3\:CKb VSS) capacitor c=5.44294e-17
C29 (\3\:CKbb VSS) capacitor c=6.60321e-17
C30 (\8\:qbint VSS) capacitor c=5.81939e-17
C31 (\1\:CK VSS) capacitor c=2.77575e-17
C32 (\7\:qbint VSS) capacitor c=2.64941e-17
C33 (\4\:net367 VSS) capacitor c=4.29362e-17
C34 (\7\:SE VSS) capacitor c=2.62021e-17
C35 (\3\:SI VSS) capacitor c=7.54659e-17
C36 (\3\:SE VSS) capacitor c=6.77199e-17
C37 (\3\:SEb VSS) capacitor c=4.63917e-17
C38 (\1\:D VSS) capacitor c=3.24415e-17
C39 (\5\:CKb VSS) capacitor c=3.97815e-17
C40 (\10\:CKb VSS) capacitor c=2.77377e-17
C41 (\4\:CKbb VSS) capacitor c=8.5418e-17
C42 (\3\:mout VSS) capacitor c=5.52069e-17
C43 (\11\:qbint VSS) capacitor c=3.70343e-17
C44 (\2\:n30 VSS) capacitor c=4.25694e-17
C45 (\3\:CK VSS) capacitor c=2.99634e-17
C46 (\5\:qbint VSS) capacitor c=3.26917e-17
C47 (\4\:qbint VSS) capacitor c=2.7729e-17
C48 (\3\:net367 VSS) capacitor c=3.65921e-17
C49 (\6\:SE VSS) capacitor c=4.44827e-17
C50 (\2\:SI VSS) capacitor c=6.51298e-17
C51 (\4\:SE VSS) capacitor c=5.16852e-17
C52 (\2\:SEb VSS) capacitor c=6.91241e-17
C53 (\1\:SE VSS) capacitor c=3.93385e-17
C54 (\3\:D VSS) capacitor c=2.85319e-17
C55 (\7\:CKbb VSS) capacitor c=3.86218e-17
C56 (\11\:CKb VSS) capacitor c=3.10012e-17
C57 (\5\:CKbb VSS) capacitor c=2.80672e-17
C58 (\2\:mout VSS) capacitor c=5.66623e-17
C59 (\4\:n20 VSS) capacitor c=4.92394e-17
C60 (\2\:CKbb VSS) capacitor c=5.34901e-17
C61 (\4\:CKb VSS) capacitor c=2.40369e-17
C62 (\2\:CKb VSS) capacitor c=3.54454e-17
C63 (\10\:qbint VSS) capacitor c=4.73947e-17
C64 (\3\:n30 VSS) capacitor c=2.10612e-17
C65 (\2\:CK VSS) capacitor c=3.29864e-17
C66 (\6\:qbint VSS) capacitor c=2.61668e-17
C67 (\8\:SEb VSS) capacitor c=1.26719e-17
C68 (\1\:VDD VSS) capacitor c=3.08444e-17
C69 (\6\:Db VSS) capacitor c=3.6844e-17
C70 (\13\:VDD VSS) capacitor c=4.87894e-17
C71 (\15\:CKbb VSS) capacitor c=9.49471e-17
C72 (\4\:Db VSS) capacitor c=1.0117e-16
C73 (\5\:n20 VSS) capacitor c=3.33173e-17
C74 (\15\:VDD VSS) capacitor c=1.3418e-17
C75 (\6\:mout VSS) capacitor c=3.76627e-17
C76 (\4\:n30 VSS) capacitor c=6.78387e-17
C77 (\17\:VDD VSS) capacitor c=1.37768e-17
C78 (\16\:qbint VSS) capacitor c=4.772e-17
C79 (\15\:CKb VSS) capacitor c=1.15226e-16
C80 (\19\:VDD VSS) capacitor c=4.16384e-17
C81 (\1\:Q VSS) capacitor c=7.74104e-17
C82 (\5\:net367 VSS) capacitor c=3.52149e-17
C83 (\21\:VDD VSS) capacitor c=8.17338e-17
C84 (\1\:QN VSS) capacitor c=5.14158e-17
C85 (\3\:VDD VSS) capacitor c=1.27679e-16
C86 (\4\:SEb VSS) capacitor c=7.81033e-17
C87 (\11\:CKbb VSS) capacitor c=4.81115e-17
C88 (\8\:Db VSS) capacitor c=6.6728e-17
C89 (\9\:n20 VSS) capacitor c=6.44253e-17
C90 (\8\:mout VSS) capacitor c=3.91339e-17
C91 (\6\:n30 VSS) capacitor c=9.16e-17
C92 (\14\:qbint VSS) capacitor c=8.8631e-17
C93 (\18\:CKb VSS) capacitor c=6.64604e-17
C94 (\9\:net367 VSS) capacitor c=2.09038e-17
C95 (\3\:QN VSS) capacitor c=2.61093e-17
C96 (\2\:net367 VSS) capacitor c=7.43638e-18
C97 (\2\:qbint VSS) capacitor c=1.42554e-17
C98 (\3\:qbint VSS) capacitor c=3.40203e-17
C99 (\6\:CKb VSS) capacitor c=4.98562e-17
C100 (\7\:CKb VSS) capacitor c=6.3115e-17
C101 (\2\:D VSS) capacitor c=2.99615e-17
C102 (\7\:net367 VSS) capacitor c=2.67848e-17
C103 (\8\:net367 VSS) capacitor c=2.56312e-17
C104 (\4\:CK VSS) capacitor c=4.63963e-17
C105 (\12\:qbint VSS) capacitor c=2.83706e-17
C106 (\13\:qbint VSS) capacitor c=3.27923e-17
C107 (\18\:qbint VSS) capacitor c=1.3498e-16
C108 (\8\:n30 VSS) capacitor c=7.96732e-17
C109 (\4\:mout VSS) capacitor c=4.45373e-17
C110 (\5\:mout VSS) capacitor c=4.26126e-17
C111 (\12\:CKb VSS) capacitor c=5.86314e-17
C112 (\13\:CKb VSS) capacitor c=7.00364e-17
C113 (\14\:CKb VSS) capacitor c=9.8976e-17
C114 (\17\:CKb VSS) capacitor c=4.99135e-17
C115 (\7\:n20 VSS) capacitor c=5.44141e-17
C116 (\8\:n20 VSS) capacitor c=4.14425e-17
C117 (\8\:CKbb VSS) capacitor c=1.51654e-17
C118 (\9\:CKbb VSS) capacitor c=8.89006e-17
C119 (\10\:CKbb VSS) capacitor c=5.97855e-17
C120 (\13\:CKbb VSS) capacitor c=1.08414e-16
C121 (\14\:CKbb VSS) capacitor c=1.28223e-16
C122 (\5\:D VSS) capacitor c=7.49191e-17
C123 (\3\:Db VSS) capacitor c=1.50011e-16
C124 (\8\:SE VSS) capacitor c=4.21776e-17
C125 (\9\:SE VSS) capacitor c=7.34325e-17
C126 (\10\:SE VSS) capacitor c=7.05036e-17
C127 (\4\:SI VSS) capacitor c=1.39352e-16
C128 (\6\:SEb VSS) capacitor c=1.19634e-16
C129 (\7\:SEb VSS) capacitor c=8.06853e-17
C130 (\5\:VDD VSS) capacitor c=1.04744e-17
C131 (\7\:VDD VSS) capacitor c=9.64495e-18
C132 (\9\:VDD VSS) capacitor c=2.36968e-17
C133 (\10\:VDD VSS) capacitor c=1.29339e-17
C134 (\12\:VDD VSS) capacitor c=1.00356e-17
Rk8 (CK \4\:CK) resistor r=0.203 c=0
Rk2 (\4\:QN QN) resistor r=0.07103 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk39 (\8\:SE SE) resistor r=0.08148 c=0
Rk37 (\8\:SE \9\:SE) resistor r=0.2273 c=0
Rk38 (\9\:SE \10\:SE) resistor r=0.3584 c=0
Rk40 (SI \4\:SI) resistor r=0.004727 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.3764 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.3581 c=0
Rk46 (\5\:VDD \6\:VDD) resistor r=0.2429 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.283 c=0
Rk48 (\7\:VDD \8\:VDD) resistor r=0.2178 c=0
Rk49 (\8\:VDD \9\:VDD) resistor r=0.2679 c=0
Rk50 (\9\:VDD \10\:VDD) resistor r=0.4356 c=0
Rk51 (\10\:VDD \11\:VDD) resistor r=0.04741 c=0
Rk53 (\12\:VDD VDD) resistor r=0.1775 c=0
Rk52 (\11\:VDD \12\:VDD) resistor r=0.2729 c=0
Rk54 (\5\:VDD \14\:VDD) resistor r=0.2778 c=0
Rk55 (\7\:VDD \16\:VDD) resistor r=0.07334 c=0
Rk56 (\9\:VDD \18\:VDD) resistor r=0.102 c=0
Rk57 (\10\:VDD \20\:VDD) resistor r=0.2868 c=0
Rk58 (\12\:VDD \22\:VDD) resistor r=0.4029 c=0
Rk32 (\5\:D D) resistor r=0.08015 c=0
Rk6 (\2\:Q Q) resistor r=0.3562 c=0
Rk7 (Q \4\:Q) resistor r=0.06161 c=0
Rk59 (\2\:VSS \4\:VSS) resistor r=0.3579 c=0
Rk60 (\4\:VSS \5\:VSS) resistor r=0.3356 c=0
Rk61 (\5\:VSS \6\:VSS) resistor r=0.516 c=0
Rk62 (\5\:VSS \8\:VSS) resistor r=0.265 c=0
Rk63 (\6\:VSS \9\:VSS) resistor r=0.5037 c=0
Rk64 (\9\:VSS \10\:VSS) resistor r=0.3973 c=0
Rk65 (\10\:VSS \11\:VSS) resistor r=0.06746 c=0
Rk66 (\11\:VSS \12\:VSS) resistor r=0.2903 c=0
Rk68 (\13\:VSS VSS) resistor r=0.04986 c=0
Rk67 (\12\:VSS \13\:VSS) resistor r=0.1426 c=0
Rk69 (\6\:VSS \15\:VSS) resistor r=0.07141 c=0
Rk70 (\9\:VSS \17\:VSS) resistor r=0.04326 c=0
Rk71 (\11\:VSS \19\:VSS) resistor r=0.2848 c=0
Rk72 (\12\:VSS \21\:VSS) resistor r=0.07334 c=0
Rk3 (\6\:net367 \7\:net367) resistor r=0.1294 c=0
Rk4 (\7\:net367 \8\:net367) resistor r=0.122 c=0
Rk5 (\7\:net367 \10\:net367) resistor r=0.09348 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.1776 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1202 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.2384 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.7902 c=0
Rk18 (\12\:CKb \13\:CKb) resistor r=0.4318 c=0
Rk19 (\13\:CKb \14\:CKb) resistor r=0.2686 c=0
Rk20 (\14\:CKb \16\:CKb) resistor r=0.676 c=0
Rk21 (\14\:CKb \17\:CKb) resistor r=0.3283 c=0
Rk22 (\16\:CKb \19\:CKb) resistor r=0.3818 c=0
Rk13 (\5\:n30 \7\:n30) resistor r=0.3972 c=0
Rk14 (\7\:n30 \8\:n30) resistor r=0.4496 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.19 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2225 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1418 c=0
Rk26 (\8\:CKbb \9\:CKbb) resistor r=0.02782 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.2051 c=0
Rk28 (\10\:CKbb \12\:CKbb) resistor r=0.2493 c=0
Rk29 (\9\:CKbb \13\:CKbb) resistor r=0.696 c=0
Rk30 (\10\:CKbb \14\:CKbb) resistor r=0.4278 c=0
Rk31 (\14\:CKbb \16\:CKbb) resistor r=0.5497 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.1244 c=0
Rk24 (\7\:n20 \8\:n20) resistor r=0.2135 c=0
Rk25 (\7\:n20 \10\:n20) resistor r=0.2139 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.6875 c=0
Rk34 (\3\:Db \5\:Db) resistor r=0.4405 c=0
Rk35 (\3\:Db \7\:Db) resistor r=0.1961 c=0
Rk36 (\5\:Db \9\:Db) resistor r=0.4154 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.7164 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.4988 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.04749 c=0
Rl10 (\1\:CK \2\:CK) resistor r=28.0211 c=0
Rl11 (\2\:CK \3\:CK) resistor r=41.4826 c=0
Rl43 (\5\:SE \6\:SE) resistor r=162.23 c=0
Rl44 (\6\:SE \7\:SE) resistor r=39.1533 c=0
Rl40 (\3\:SE \4\:SE) resistor r=47.3097 c=0
Rl37 (\1\:SE \2\:SE) resistor r=65.2137 c=0
Rl41 (\1\:SI \2\:SI) resistor r=68.4636 c=0
Rl42 (\2\:SI \3\:SI) resistor r=130.002 c=0
Rl36 (\2\:D \4\:D) resistor r=129.649 c=0
Rl34 (\1\:D \2\:D) resistor r=84.3071 c=0
Rl35 (\2\:D \3\:D) resistor r=5.013 c=0
Rl1 (net367 \2\:net367) resistor r=5.915 c=0
Rl3 (\2\:net367 \4\:net367) resistor r=49.7141 c=0
Rl2 (\2\:net367 \3\:net367) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=58.4373 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=7.9329 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=53.9066 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=36.0826 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=148.082 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=116.588 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=34.3295 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=0.5166 c=0
Rl33 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl18 (\3\:CKb \4\:CKb) resistor r=43.4636 c=0
Rl17 (CKb \2\:CKb) resistor r=47.3097 c=0
Rl31 (\6\:CKb \9\:CKb) resistor r=128.08 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=97.1574 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=153.39 c=0
Rl32 (\7\:CKb \10\:CKb) resistor r=40.0661 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=191.223 c=0
Rl12 (n30 \2\:n30) resistor r=150 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl24 (mout \2\:mout) resistor r=97.3098 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=35.3072 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=58.8482 c=0
Rl19 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl20 (\2\:CKbb \3\:CKbb) resistor r=158.735 c=0
Rl21 (n20 \2\:n20) resistor r=97.2848 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=39.4748 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=3.9946 c=0
Rl38 (SEb \2\:SEb) resistor r=89.6174 c=0
Rl39 (\2\:SEb \3\:SEb) resistor r=136.093 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz14 (\3\:VDD \6\:VDD) resistor r=15 c=0
Rz15 (\3\:VDD \8\:VDD) resistor r=15 c=0
Rz16 (\3\:VDD \11\:VDD) resistor r=7.5 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz18 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz19 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\9\:net367 \10\:net367) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\8\:Db \9\:Db) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \22\:VDD) resistor r=20.6667 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry19 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry20 (\3\:VSS \6\:VSS) resistor r=6.2 c=0
Ry21 (\3\:VSS \10\:VSS) resistor r=7.75 c=0
Ry22 (\3\:VSS \13\:VSS) resistor r=31 c=0
Ry2 (\5\:net367 \6\:net367) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry10 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\1\:SE \10\:SE) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx14 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (net367 \8\:net367) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\7\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net367 \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:net367 \4\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.35192e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn20 (\18\:CKb \3\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.698e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\14\:qbint \2\:n30 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.09e-14 ad=2.465e-14 ps=1.56e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.8e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn50 (net436 \11\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.09e-14 ad=2.32e-14 ps=1.56e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.605e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn51 (\6\:n30 CKb net436 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\6\:n30 CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=3.335e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.125e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\8\:mout n20 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.205e-14 ps=1.56e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (net429 \3\:mout \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=8.7e-15 ps=1.56e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=5.95e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (\9\:n20 \4\:CKbb net429 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=4.9e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn25 (\9\:n20 \10\:CKb \8\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=2.85e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\11\:CKbb \5\:CKb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net449 \1\:D \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.278e-14 ps=6.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.025e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net449 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=2.32e-14 ps=8.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=6.85e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net461 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=4.8e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net461 \3\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
