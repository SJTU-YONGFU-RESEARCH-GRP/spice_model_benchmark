C156 (\9\:n35g VSS) capacitor c=7.99627e-17
C157 (\4\:SEb VSS) capacitor c=3.93429e-17
C158 (\7\:n35 VSS) capacitor c=4.88653e-17
C159 (\11\:mout VSS) capacitor c=3.70935e-17
C160 (\13\:mout VSS) capacitor c=3.8164e-17
C161 (\3\:n4 VSS) capacitor c=1.00022e-16
C162 (\13\:CKb VSS) capacitor c=6.24114e-17
C163 (\15\:CKbb VSS) capacitor c=8.91749e-17
C164 (\17\:n20 VSS) capacitor c=8.56888e-17
C165 (\7\:Db VSS) capacitor c=7.7131e-17
C166 (\13\:RNb VSS) capacitor c=7.3362e-17
C167 (\8\:n20 VSS) capacitor c=5.86991e-17
C168 (VDD VSS) capacitor c=6.94204e-17
C169 (\2\:CKbb VSS) capacitor c=6.16866e-17
C170 (\2\:CK VSS) capacitor c=3.38152e-17
C171 (\2\:D VSS) capacitor c=3.55168e-17
C172 (\2\:SE VSS) capacitor c=2.5012e-17
C173 (\2\:CKb VSS) capacitor c=1.511e-16
C174 (\3\:CKb VSS) capacitor c=8.78376e-17
C175 (\2\:n35g VSS) capacitor c=2.91123e-17
C176 (\4\:RT VSS) capacitor c=7.42727e-17
C177 (\2\:qbint VSS) capacitor c=4.13305e-17
C178 (\6\:CKbb VSS) capacitor c=1.37045e-16
C179 (\7\:CKbb VSS) capacitor c=7.33584e-17
C180 (\4\:SN VSS) capacitor c=3.6098e-16
C181 (\2\:net573 VSS) capacitor c=1.5308e-17
C182 (\12\:n20 VSS) capacitor c=4.40581e-17
C183 (\5\:RNb VSS) capacitor c=3.89503e-16
C184 (\6\:RNb VSS) capacitor c=1.81254e-16
C185 (\12\:RNb VSS) capacitor c=1.12461e-16
C186 (\13\:CKbb VSS) capacitor c=1.5538e-16
C187 (\14\:CKbb VSS) capacitor c=1.3771e-16
C188 (\8\:qbint VSS) capacitor c=5.09063e-17
C189 (\9\:qbint VSS) capacitor c=7.54296e-17
C190 (\15\:n20 VSS) capacitor c=7.51695e-17
C191 (\16\:n20 VSS) capacitor c=9.23447e-17
C192 (\19\:CKbb VSS) capacitor c=4.27767e-17
C193 (\6\:CK VSS) capacitor c=4.1089e-17
C194 (\15\:CKb VSS) capacitor c=6.18223e-17
C195 (\16\:CKb VSS) capacitor c=4.2145e-17
C196 (\10\:SN VSS) capacitor c=4.01325e-17
C197 (\11\:SN VSS) capacitor c=4.61727e-17
C198 (\7\:D VSS) capacitor c=4.72535e-17
C199 (\19\:n20 VSS) capacitor c=8.0144e-17
C200 (\20\:n20 VSS) capacitor c=8.09807e-17
C201 (\15\:RNb VSS) capacitor c=7.07284e-17
C202 (\16\:RNb VSS) capacitor c=8.29616e-17
C203 (\7\:mout VSS) capacitor c=1.55818e-16
C204 (\8\:mout VSS) capacitor c=5.28652e-17
C205 (\9\:mout VSS) capacitor c=1.04266e-16
C206 (\10\:mout VSS) capacitor c=8.64662e-17
C207 (\15\:mout VSS) capacitor c=6.04063e-17
C208 (\18\:mout VSS) capacitor c=7.19626e-17
C209 (\6\:SEb VSS) capacitor c=8.34493e-17
C210 (\7\:SEb VSS) capacitor c=6.92775e-17
C211 (\6\:n35 VSS) capacitor c=1.06598e-16
C212 (\19\:CKb VSS) capacitor c=3.86002e-17
C213 (\20\:CKb VSS) capacitor c=4.1645e-17
C214 (\8\:n35g VSS) capacitor c=3.50411e-17
C215 (\11\:n35 VSS) capacitor c=7.53442e-17
C216 (\15\:qbint VSS) capacitor c=8.75403e-17
C217 (\16\:qbint VSS) capacitor c=1.11665e-16
C218 (\13\:n35g VSS) capacitor c=1.02467e-16
C219 (\14\:n35g VSS) capacitor c=1.15714e-16
C220 (\5\:RTb VSS) capacitor c=4.93559e-17
C221 (\8\:RTb VSS) capacitor c=1.00362e-16
C222 (\9\:RTb VSS) capacitor c=9.12712e-17
C223 (\12\:SN VSS) capacitor c=8.24211e-17
C224 (\13\:SN VSS) capacitor c=8.01901e-17
C225 (\20\:CKbb VSS) capacitor c=1.33803e-16
C226 (\21\:CKbb VSS) capacitor c=1.33492e-16
C227 (\21\:qbint VSS) capacitor c=2.40592e-17
C228 (\22\:qbint VSS) capacitor c=2.9991e-17
C229 (\9\:RT VSS) capacitor c=1.10679e-16
C230 (\10\:RT VSS) capacitor c=1.17695e-16
C231 (\11\:RT VSS) capacitor c=5.56594e-17
C232 (\3\:QN VSS) capacitor c=3.33685e-17
C233 (\16\:n35 VSS) capacitor c=5.05282e-17
C234 (\7\:net573 VSS) capacitor c=5.04197e-17
C235 (\8\:net573 VSS) capacitor c=3.48307e-17
C236 (\3\:VDD VSS) capacitor c=3.01355e-17
C237 (\4\:VDD VSS) capacitor c=3.07325e-17
C238 (\6\:VDD VSS) capacitor c=9.78486e-18
C239 (\7\:VDD VSS) capacitor c=2.27379e-16
C240 (\8\:VDD VSS) capacitor c=2.02744e-16
C241 (\9\:VDD VSS) capacitor c=2.90114e-17
C242 (\11\:VDD VSS) capacitor c=5.32489e-17
C243 (\22\:VDD VSS) capacitor c=6.10398e-17
Rk80 (\2\:Q Q) resistor r=0.1725 c=0
Rk81 (Q \4\:Q) resistor r=0.3385 c=0
Rk19 (\5\:D D) resistor r=0.007241 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01725 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007241 c=0
Rk72 (\3\:QN QN) resistor r=0.02836 c=0
Rk71 (\2\:QN \3\:QN) resistor r=0.1971 c=0
Rk73 (\3\:QN \5\:QN) resistor r=0.3615 c=0
Rk112 (VDD VDD) resistor r=0.2377 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.34 c=0
Rk97 (\3\:VDD \4\:VDD) resistor r=0.2193 c=0
Rk98 (\4\:VDD \6\:VDD) resistor r=0.0672 c=0
Rk99 (\6\:VDD \7\:VDD) resistor r=0.05222 c=0
Rk100 (\7\:VDD \8\:VDD) resistor r=1.5323 c=0
Rk101 (\8\:VDD \9\:VDD) resistor r=0.1194 c=0
Rk102 (\9\:VDD \11\:VDD) resistor r=0.2226 c=0
Rk103 (\3\:VDD \13\:VDD) resistor r=0.3605 c=0
Rk104 (\4\:VDD \15\:VDD) resistor r=0.2961 c=0
Rk105 (\7\:VDD \17\:VDD) resistor r=0.3784 c=0
Rk106 (\8\:VDD \19\:VDD) resistor r=0.3704 c=0
Rk107 (\9\:VDD \21\:VDD) resistor r=0.2039 c=0
Rk111 (\22\:VDD VDD) resistor r=0.1968 c=0
Rk108 (\11\:VDD \22\:VDD) resistor r=0.172 c=0
Rk109 (\22\:VDD \24\:VDD) resistor r=0.2093 c=0
Rk110 (\11\:VDD \26\:VDD) resistor r=0.2416 c=0
Rk113 (VDD \28\:VDD) resistor r=0.3818 c=0
Rk52 (ExtVDD ExtVDD) resistor r=0.002073 c=0
Rk50 (\2\:ExtVDD ExtVDD) resistor r=0.02227 c=0
Rk53 (ExtVDD \5\:ExtVDD) resistor r=0.02025 c=0
Rk54 (ExtVDD \6\:ExtVDD) resistor r=0.1504 c=0
Rk13 (CK \6\:CK) resistor r=0.01226 c=0
Rk12 (\5\:CK \6\:CK) resistor r=0.004824 c=0
Rk84 (\2\:VSS \3\:VSS) resistor r=0.03225 c=0
Rk85 (\3\:VSS \4\:VSS) resistor r=0.5165 c=0
Rk86 (\4\:VSS \5\:VSS) resistor r=0.5194 c=0
Rk88 (\6\:VSS VSS) resistor r=0.04967 c=0
Rk87 (\5\:VSS \6\:VSS) resistor r=0.3293 c=0
Rk90 (\7\:VSS VSS) resistor r=0.1221 c=0
Rk89 (VSS \7\:VSS) resistor r=0.8989 c=0
Rk91 (VSS \8\:VSS) resistor r=0.01753 c=0
Rk92 (\8\:VSS \10\:VSS) resistor r=0.6682 c=0
Rk93 (\3\:VSS \12\:VSS) resistor r=0.2514 c=0
Rk94 (\5\:VSS \14\:VSS) resistor r=0.2463 c=0
Rk95 (\8\:VSS \16\:VSS) resistor r=0.2539 c=0
Rk114 (\18\:VSS \20\:VSS) resistor r=0.3648 c=0
Rk115 (\20\:VSS \21\:VSS) resistor r=0.2394 c=0
Rk116 (\21\:VSS \22\:VSS) resistor r=0.05971 c=0
Rk117 (\22\:VSS \23\:VSS) resistor r=0.6164 c=0
Rk118 (\23\:VSS \24\:VSS) resistor r=0.03225 c=0
Rk120 (\25\:VSS VSS) resistor r=0.1219 c=0
Rk119 (\24\:VSS \25\:VSS) resistor r=0.177 c=0
Rk121 (VSS \26\:VSS) resistor r=0.5242 c=0
Rk122 (\26\:VSS \27\:VSS) resistor r=0.3091 c=0
Rk124 (\28\:VSS VSS) resistor r=0.1221 c=0
Rk123 (\27\:VSS \28\:VSS) resistor r=0.0647 c=0
Rk125 (VSS \30\:VSS) resistor r=0.3149 c=0
Rk126 (\21\:VSS \32\:VSS) resistor r=0.2698 c=0
Rk127 (\23\:VSS \34\:VSS) resistor r=0.1914 c=0
Rk128 (\25\:VSS \36\:VSS) resistor r=0.1965 c=0
Rk129 (\26\:VSS \38\:VSS) resistor r=0.2562 c=0
Rk130 (\27\:VSS \40\:VSS) resistor r=0.2517 c=0
Rk17 (SN \10\:SN) resistor r=0.01165 c=0
Rk18 (\10\:SN \11\:SN) resistor r=0.3167 c=0
Rk65 (\12\:SN \13\:SN) resistor r=0.5417 c=0
Rk1 (\5\:RN RN) resistor r=0.008217 c=0
Rk68 (RT \9\:RT) resistor r=0.1927 c=0
Rk69 (\9\:RT \10\:RT) resistor r=0.6534 c=0
Rk70 (RT \11\:RT) resistor r=0.008064 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5491 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2569 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3492 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.232 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.5019 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4664 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8583 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.5434 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.1435 c=0
Rk66 (\20\:CKbb \21\:CKbb) resistor r=0.8355 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.7703 c=0
Rk31 (\7\:mout \8\:mout) resistor r=0.3564 c=0
Rk32 (\8\:mout \9\:mout) resistor r=0.1729 c=0
Rk33 (\9\:mout \10\:mout) resistor r=0.3451 c=0
Rk34 (\7\:mout \12\:mout) resistor r=0.1244 c=0
Rk35 (\8\:mout \14\:mout) resistor r=0.1009 c=0
Rk36 (\9\:mout \15\:mout) resistor r=0.5302 c=0
Rk37 (\15\:mout \17\:mout) resistor r=0.04505 c=0
Rk38 (\10\:mout \18\:mout) resistor r=0.4297 c=0
Rk39 (\15\:mout \20\:mout) resistor r=0.03481 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1652 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3847 c=0
Rk27 (\15\:RNb \16\:RNb) resistor r=0.3502 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3366 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.1634 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.1787 c=0
Rk45 (\19\:CKb \20\:CKb) resistor r=0.3756 c=0
Rk40 (\5\:SEb \6\:SEb) resistor r=0.2186 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.3586 c=0
Rk42 (\6\:SEb \9\:SEb) resistor r=0.3131 c=0
Rk46 (\7\:n35g \8\:n35g) resistor r=0.2763 c=0
Rk47 (\7\:n35g \10\:n35g) resistor r=0.6991 c=0
Rk58 (\12\:n35g \13\:n35g) resistor r=0.2457 c=0
Rk59 (\13\:n35g \14\:n35g) resistor r=0.5719 c=0
Rk60 (\13\:n35g \16\:n35g) resistor r=0.4367 c=0
Rk55 (\15\:qbint \16\:qbint) resistor r=0.5002 c=0
Rk56 (\16\:qbint \18\:qbint) resistor r=0.5734 c=0
Rk57 (\16\:qbint \20\:qbint) resistor r=0.1479 c=0
Rk67 (\21\:qbint \22\:qbint) resistor r=0.2141 c=0
Rk61 (\5\:RTb \7\:RTb) resistor r=0.2186 c=0
Rk62 (\7\:RTb \8\:RTb) resistor r=0.4212 c=0
Rk63 (\8\:RTb \9\:RTb) resistor r=0.6964 c=0
Rk64 (\8\:RTb \11\:RTb) resistor r=0.31 c=0
Rk76 (\6\:net573 \7\:net573) resistor r=0.2387 c=0
Rk77 (\7\:net573 \8\:net573) resistor r=0.1669 c=0
Rk78 (\7\:net573 \10\:net573) resistor r=0.2869 c=0
Rk43 (\5\:n35 \6\:n35) resistor r=0.4337 c=0
Rk44 (\6\:n35 \8\:n35) resistor r=0.306 c=0
Rk48 (\10\:n35 \11\:n35) resistor r=0.4054 c=0
Rk49 (\11\:n35 \13\:n35) resistor r=0.3336 c=0
Rk74 (\15\:n35 \16\:n35) resistor r=0.3071 c=0
Rk75 (\16\:n35 \18\:n35) resistor r=0.2906 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6434 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.436 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5713 c=0
Rk82 (\2\:n11 \4\:n11) resistor r=0.7216 c=0
Rk83 (\2\:n8 \4\:n8) resistor r=0.536 c=0
Rk79 (\2\:n10 \4\:n10) resistor r=0.6325 c=0
Rk26 (\2\:n4 \4\:n4) resistor r=0.5583 c=0
Rl16 (\2\:D \4\:D) resistor r=115.099 c=0
Rl14 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl15 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl83 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl84 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl13 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl61 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl59 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl60 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl58 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl45 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl48 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl47 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl46 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl19 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl17 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl5 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl56 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl57 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl55 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl69 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl70 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl73 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl74 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl72 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl71 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl65 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl30 (CKb \2\:CKb) resistor r=349.798 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=63.8165 c=0
Rl37 (\5\:CKb \9\:CKb) resistor r=126.273 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=264.86 c=0
Rl38 (\5\:CKb \10\:CKb) resistor r=4.0236 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl41 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl39 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl40 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl42 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl75 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl80 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl82 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl52 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl49 (qbint \2\:qbint) resistor r=112.732 c=0
Rl51 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl50 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl76 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl79 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl81 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl78 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl77 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl43 (RTb \2\:RTb) resistor r=112.412 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl66 (net573 \2\:net573) resistor r=3.1216 c=0
Rl67 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl68 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl62 (n35 \2\:n35) resistor r=508.667 c=0
Rl63 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz25 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz20 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz28 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz29 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz30 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz31 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz34 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz35 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz36 (\31\:VSS \32\:VSS) resistor r=37.5 c=0
Rz37 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz38 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz39 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz40 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz22 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz21 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz26 (n8 \2\:n8) resistor r=75 c=0
Rz27 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz23 (n10 \2\:n10) resistor r=75 c=0
Rz24 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry21 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry31 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry32 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry33 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry34 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry35 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry36 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry37 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry38 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry39 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry27 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry28 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry30 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry41 (\19\:VSS \22\:VSS) resistor r=62 c=0
Ry42 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry43 (\19\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry23 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry22 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry25 (n11 \2\:n11) resistor r=62 c=0
Ry26 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx19 (\1\:SE SE) resistor r=45 c=0
Rx9 (\3\:CK \5\:CK) resistor r=45 c=0
Rx11 (\5\:SN \10\:SN) resistor r=45 c=0
Rx12 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx38 (\3\:RT \9\:RT) resistor r=45 c=0
Rx39 (\1\:RT \10\:RT) resistor r=45 c=0
Rx40 (\7\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx34 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx20 (\4\:mout \10\:mout) resistor r=45 c=0
Rx21 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx10 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx24 (CKb \19\:CKb) resistor r=45 c=0
Rx25 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx26 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx29 (n35g \14\:n35g) resistor r=45 c=0
Rx28 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx30 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (RTb \9\:RTb) resistor r=45 c=0
Rx42 (net573 \8\:net573) resistor r=45 c=0
Rx23 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx27 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx41 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \4\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:07:19 2012 )
// Library name: gsclib045
// Cell name: SRDFFSX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSX1 CK D ExtVDD Q QN RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=5.88779e-17
C2 (D VSS) capacitor c=7.95582e-17
C3 (QN VSS) capacitor c=1.89066e-17
C4 (CK VSS) capacitor c=7.48802e-17
C5 (SI VSS) capacitor c=8.73684e-17
C6 (RT VSS) capacitor c=6.46039e-17
C7 (ExtVDD VSS) capacitor c=2.26793e-16
C8 (SN VSS) capacitor c=5.16294e-17
C9 (VDD VSS) capacitor c=7.47013e-16
C10 (SE VSS) capacitor c=9.25495e-17
C11 (n20 VSS) capacitor c=3.84704e-17
C12 (CKbb VSS) capacitor c=2.98958e-17
C13 (mout VSS) capacitor c=5.41849e-17
C14 (CKb VSS) capacitor c=5.04575e-17
C15 (SEb VSS) capacitor c=7.75157e-17
C16 (n35g VSS) capacitor c=1.7772e-17
C17 (qbint VSS) capacitor c=4.57835e-17
C18 (RTb VSS) capacitor c=5.17974e-17
C19 (net573 VSS) capacitor c=2.25505e-17
C20 (n35 VSS) capacitor c=1.72515e-16
C21 (Db VSS) capacitor c=1.02659e-16
C22 (n11 VSS) capacitor c=7.99274e-17
C23 (n1 VSS) capacitor c=1.02126e-18
C24 (\7\:qbint VSS) capacitor c=3.28246e-17
C25 (\7\:SN VSS) capacitor c=8.60102e-17
C26 (\11\:qbint VSS) capacitor c=1.07191e-16
C27 (\13\:qbint VSS) capacitor c=4.38863e-17
C28 (\3\:net573 VSS) capacitor c=5.86658e-17
C29 (\11\:CKbb VSS) capacitor c=4.51636e-17
C30 (\4\:RTb VSS) capacitor c=9.88373e-17
C31 (\6\:RT VSS) capacitor c=2.23208e-17
C32 (\4\:qbint VSS) capacitor c=5.36612e-17
C33 (\3\:n35g VSS) capacitor c=5.1929e-17
C34 (\5\:RT VSS) capacitor c=6.48597e-17
C35 (\3\:SE VSS) capacitor c=7.72628e-17
C36 (\7\:CKb VSS) capacitor c=3.10427e-17
C37 (\3\:SI VSS) capacitor c=9.47876e-17
C38 (\4\:SE VSS) capacitor c=1.22542e-16
C39 (\3\:n20 VSS) capacitor c=2.47551e-17
C40 (\4\:D VSS) capacitor c=7.11031e-17
C41 (\1\:SN VSS) capacitor c=3.03251e-17
C42 (\4\:CK VSS) capacitor c=5.78548e-17
C43 (\4\:CKb VSS) capacitor c=4.5846e-17
C44 (\8\:CKb VSS) capacitor c=8.3611e-17
C45 (\3\:CKbb VSS) capacitor c=2.57688e-17
C46 (\6\:qbint VSS) capacitor c=3.83344e-17
C47 (\14\:qbint VSS) capacitor c=4.62185e-17
C48 (\8\:SN VSS) capacitor c=1.45704e-16
C49 (\12\:qbint VSS) capacitor c=1.48984e-16
C50 (\4\:net573 VSS) capacitor c=3.67878e-17
C51 (\11\:CKb VSS) capacitor c=2.53721e-16
C52 (\8\:RT VSS) capacitor c=1.21316e-16
C53 (\2\:RT VSS) capacitor c=6.21869e-17
C54 (\5\:qbint VSS) capacitor c=3.89021e-17
C55 (\5\:n35g VSS) capacitor c=3.28693e-17
C56 (\2\:RTb VSS) capacitor c=4.64921e-17
C57 (\5\:SE VSS) capacitor c=5.7365e-17
C58 (\5\:CKbb VSS) capacitor c=2.72722e-17
C59 (\1\:SI VSS) capacitor c=4.90982e-17
C60 (\6\:SE VSS) capacitor c=8.63749e-17
C61 (\3\:SEb VSS) capacitor c=6.59302e-17
C62 (\1\:D VSS) capacitor c=4.94494e-17
C63 (\6\:n20 VSS) capacitor c=8.23106e-17
C64 (\6\:SN VSS) capacitor c=7.01056e-17
C65 (\1\:CK VSS) capacitor c=2.87489e-17
C66 (\3\:mout VSS) capacitor c=4.47479e-17
C67 (\9\:CKb VSS) capacitor c=3.64392e-17
C68 (\10\:CKbb VSS) capacitor c=4.84288e-17
C69 (\6\:CKb VSS) capacitor c=4.93311e-17
C70 (\10\:qbint VSS) capacitor c=8.42187e-17
C71 (\12\:CKbb VSS) capacitor c=5.14498e-17
C72 (\3\:SN VSS) capacitor c=2.84633e-16
C73 (\9\:SN VSS) capacitor c=6.35258e-17
C74 (\7\:RT VSS) capacitor c=1.445e-16
C75 (\9\:CKbb VSS) capacitor c=1.67836e-16
C76 (\3\:RT VSS) capacitor c=3.94588e-17
C77 (\1\:RT VSS) capacitor c=5.29002e-17
C78 (\3\:RTb VSS) capacitor c=7.5942e-17
C79 (\3\:qbint VSS) capacitor c=4.44019e-17
C80 (\2\:n35 VSS) capacitor c=2.52896e-16
C81 (\4\:n35g VSS) capacitor c=6.67426e-17
C82 (\12\:CKb VSS) capacitor c=2.18493e-16
C83 (\3\:n35 VSS) capacitor c=1.16031e-16
C84 (\1\:SE VSS) capacitor c=2.47752e-17
C85 (\2\:SI VSS) capacitor c=7.74104e-17
C86 (\2\:SEb VSS) capacitor c=7.84364e-17
C87 (\7\:n20 VSS) capacitor c=4.70827e-17
C88 (\4\:n20 VSS) capacitor c=7.28737e-17
C89 (\3\:D VSS) capacitor c=1.51045e-17
C90 (\2\:SN VSS) capacitor c=4.20762e-17
C91 (\5\:SN VSS) capacitor c=2.65613e-17
C92 (\3\:CK VSS) capacitor c=2.31437e-17
C93 (\2\:mout VSS) capacitor c=4.66573e-17
C94 (\4\:mout VSS) capacitor c=2.82052e-17
C95 (\10\:CKb VSS) capacitor c=2.21463e-17
C96 (\5\:n20 VSS) capacitor c=7.87098e-17
C97 (\4\:CKbb VSS) capacitor c=6.32587e-17
C98 (\8\:CKbb VSS) capacitor c=2.44292e-17
C99 (\2\:n20 VSS) capacitor c=3.95634e-17
C100 (\1\:VDD VSS) capacitor c=4.33505e-17
C101 (\12\:VDD VSS) capacitor c=2.78404e-17
C102 (\3\:Q VSS) capacitor c=7.97765e-17
C103 (\14\:VDD VSS) capacitor c=5.29599e-17
C104 (\9\:net573 VSS) capacitor c=5.55504e-17
C105 (\16\:VDD VSS) capacitor c=7.97455e-17
C106 (\3\:n11 VSS) capacitor c=8.48924e-17
C107 (\4\:QN VSS) capacitor c=6.86594e-17
C108 (\14\:n35 VSS) capacitor c=5.21976e-17
C109 (\15\:n35g VSS) capacitor c=5.5909e-17
C110 (\6\:RTb VSS) capacitor c=7.27087e-17
C111 (\1\:ExtVDD VSS) capacitor c=2.77768e-16
C112 (\9\:n35 VSS) capacitor c=6.20489e-17
C113 (\17\:qbint VSS) capacitor c=6.81911e-17
C114 (\6\:n35g VSS) capacitor c=9.39178e-17
C115 (\8\:SEb VSS) capacitor c=5.06012e-17
C116 (\4\:n35 VSS) capacitor c=6.29062e-17
C117 (\18\:VDD VSS) capacitor c=6.10013e-17
C118 (\5\:mout VSS) capacitor c=8.78996e-17
C119 (\3\:Db VSS) capacitor c=1.94197e-16
C120 (\20\:VDD VSS) capacitor c=5.06609e-17
C121 (\19\:mout VSS) capacitor c=3.95742e-17
C122 (\25\:VDD VSS) capacitor c=3.45959e-17
C123 (\16\:mout VSS) capacitor c=4.39997e-17
C124 (\17\:CKb VSS) capacitor c=2.98518e-17
C125 (\23\:VDD VSS) capacitor c=4.83128e-17
C126 (\17\:CKbb VSS) capacitor c=6.82922e-17
C127 (\13\:n20 VSS) capacitor c=6.05939e-17
C128 (\5\:Db VSS) capacitor c=2.29715e-16
C129 (\10\:n20 VSS) capacitor c=6.36434e-17
C130 (\1\:Q VSS) capacitor c=5.32881e-17
C131 (\5\:net573 VSS) capacitor c=4.31107e-17
C132 (\1\:QN VSS) capacitor c=3.95495e-17
C133 (\17\:n35 VSS) capacitor c=3.9291e-17
C134 (\11\:n35g VSS) capacitor c=2.96827e-17
C135 (\10\:RTb VSS) capacitor c=5.81982e-17
C136 (\12\:n35 VSS) capacitor c=6.35981e-17
C137 (\19\:qbint VSS) capacitor c=2.43447e-17
C138 (\9\:n35g VSS) capacitor c=8.04088e-17
C139 (\4\:SEb VSS) capacitor c=3.94714e-17
C140 (\7\:n35 VSS) capacitor c=4.09459e-17
C141 (\11\:mout VSS) capacitor c=2.19228e-17
C142 (\13\:mout VSS) capacitor c=1.77684e-17
C143 (\13\:CKb VSS) capacitor c=5.69102e-17
C144 (\15\:CKbb VSS) capacitor c=8.68125e-17
C145 (\17\:n20 VSS) capacitor c=8.69141e-17
C146 (\7\:Db VSS) capacitor c=7.83291e-17
C147 (\8\:n20 VSS) capacitor c=5.88588e-17
C148 (VDD VSS) capacitor c=4.23916e-17
C149 (\2\:CKbb VSS) capacitor c=6.33399e-17
C150 (\2\:CK VSS) capacitor c=3.70344e-17
C151 (\2\:D VSS) capacitor c=3.58843e-17
C152 (\2\:SE VSS) capacitor c=2.5012e-17
C153 (\2\:CKb VSS) capacitor c=1.47509e-16
C154 (\3\:CKb VSS) capacitor c=8.67096e-17
C155 (\5\:CKb VSS) capacitor c=5.70483e-17
C156 (\2\:n35g VSS) capacitor c=2.91068e-17
C157 (\4\:RT VSS) capacitor c=4.60748e-17
C158 (\2\:qbint VSS) capacitor c=4.13305e-17
C159 (\6\:CKbb VSS) capacitor c=1.2768e-16
C160 (\7\:CKbb VSS) capacitor c=7.19841e-17
C161 (\4\:SN VSS) capacitor c=2.47908e-16
C162 (\2\:net573 VSS) capacitor c=1.5265e-17
C163 (\12\:n20 VSS) capacitor c=4.44175e-17
C164 (\13\:CKbb VSS) capacitor c=9.9031e-17
C165 (\14\:CKbb VSS) capacitor c=9.72819e-17
C166 (\15\:n20 VSS) capacitor c=5.20721e-17
C167 (\16\:n20 VSS) capacitor c=9.21474e-17
C168 (\8\:qbint VSS) capacitor c=4.48796e-17
C169 (\9\:qbint VSS) capacitor c=6.56685e-17
C170 (\19\:CKbb VSS) capacitor c=5.18124e-17
C171 (\15\:CKb VSS) capacitor c=6.00279e-17
C172 (\16\:CKb VSS) capacitor c=3.92201e-17
C173 (\10\:SN VSS) capacitor c=3.93965e-17
C174 (\11\:SN VSS) capacitor c=4.44027e-17
C175 (\19\:n20 VSS) capacitor c=6.57619e-17
C176 (\20\:n20 VSS) capacitor c=7.69525e-17
C177 (\7\:mout VSS) capacitor c=8.21686e-17
C178 (\8\:mout VSS) capacitor c=4.27767e-17
C179 (\9\:mout VSS) capacitor c=9.97875e-17
C180 (\10\:mout VSS) capacitor c=8.77644e-17
C181 (\15\:mout VSS) capacitor c=6.71878e-17
C182 (\18\:mout VSS) capacitor c=7.29698e-17
C183 (\6\:SEb VSS) capacitor c=8.36943e-17
C184 (\7\:SEb VSS) capacitor c=6.95574e-17
C185 (\6\:n35 VSS) capacitor c=7.82109e-17
C186 (\19\:CKb VSS) capacitor c=3.91478e-17
C187 (\20\:CKb VSS) capacitor c=4.23519e-17
C188 (\8\:n35g VSS) capacitor c=3.45284e-17
C189 (\11\:n35 VSS) capacitor c=7.50221e-17
C190 (\15\:qbint VSS) capacitor c=8.78471e-17
C191 (\16\:qbint VSS) capacitor c=1.11964e-16
C192 (\13\:n35g VSS) capacitor c=1.02391e-16
C193 (\14\:n35g VSS) capacitor c=1.1611e-16
C194 (\5\:RTb VSS) capacitor c=4.94791e-17
C195 (\8\:RTb VSS) capacitor c=9.93242e-17
C196 (\9\:RTb VSS) capacitor c=9.14752e-17
C197 (\10\:RT VSS) capacitor c=1.09503e-16
C198 (\11\:RT VSS) capacitor c=1.1814e-16
C199 (\12\:SN VSS) capacitor c=8.30194e-17
C200 (\13\:SN VSS) capacitor c=7.94276e-17
C201 (\20\:CKbb VSS) capacitor c=1.30835e-16
C202 (\21\:CKbb VSS) capacitor c=1.34343e-16
C203 (\21\:qbint VSS) capacitor c=2.41935e-17
C204 (\22\:qbint VSS) capacitor c=3.00163e-17
C205 (\3\:QN VSS) capacitor c=3.12928e-17
C206 (\16\:n35 VSS) capacitor c=4.52226e-17
C207 (\7\:net573 VSS) capacitor c=5.43172e-17
C208 (\8\:net573 VSS) capacitor c=3.52344e-17
C209 (\3\:VDD VSS) capacitor c=2.70942e-17
C210 (\4\:VDD VSS) capacitor c=2.45956e-17
C211 (\6\:VDD VSS) capacitor c=9.10299e-18
C212 (\7\:VDD VSS) capacitor c=2.13361e-16
C213 (\8\:VDD VSS) capacitor c=2.06955e-16
C214 (\9\:VDD VSS) capacitor c=2.63757e-17
C215 (\11\:VDD VSS) capacitor c=4.71375e-17
C216 (\22\:VDD VSS) capacitor c=6.14773e-17
Rk72 (\2\:Q Q) resistor r=0.1675 c=0
Rk73 (Q \4\:Q) resistor r=0.332 c=0
Rk64 (\3\:QN QN) resistor r=0.03624 c=0
Rk63 (\2\:QN \3\:QN) resistor r=0.1939 c=0
Rk65 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk74 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk75 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk76 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk77 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk80 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk81 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk82 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk84 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk83 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk85 (VSS \14\:VSS) resistor r=0.313 c=0
Rk86 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk87 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk88 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk89 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk90 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk108 (\26\:VSS \27\:VSS) resistor r=0.1813 c=0
Rk109 (\27\:VSS \28\:VSS) resistor r=0.3652 c=0
Rk110 (\28\:VSS \29\:VSS) resistor r=0.3681 c=0
Rk112 (\30\:VSS VSS) resistor r=0.04947 c=0
Rk111 (\29\:VSS \30\:VSS) resistor r=0.3279 c=0
Rk114 (\31\:VSS VSS) resistor r=0.1216 c=0
Rk113 (VSS \31\:VSS) resistor r=0.8951 c=0
Rk115 (VSS \33\:VSS) resistor r=0.3043 c=0
Rk116 (\27\:VSS \35\:VSS) resistor r=0.2357 c=0
Rk117 (\29\:VSS \37\:VSS) resistor r=0.2445 c=0
Rk118 (\33\:VSS \38\:VSS) resistor r=0.1028 c=0
Rk58 (RT \10\:RT) resistor r=0.1993 c=0
Rk59 (\10\:RT \11\:RT) resistor r=0.6488 c=0
Rk44 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk42 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk45 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk46 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk13 (SN \10\:SN) resistor r=0.0106 c=0
Rk14 (\10\:SN \11\:SN) resistor r=0.3153 c=0
Rk60 (\12\:SN \13\:SN) resistor r=0.538 c=0
Rk107 (VDD VDD) resistor r=0.2362 c=0
Rk91 (\2\:VDD \3\:VDD) resistor r=0.3819 c=0
Rk92 (\3\:VDD \4\:VDD) resistor r=0.1963 c=0
Rk93 (\4\:VDD \6\:VDD) resistor r=0.06692 c=0
Rk94 (\6\:VDD \7\:VDD) resistor r=0.05201 c=0
Rk95 (\7\:VDD \8\:VDD) resistor r=1.5259 c=0
Rk96 (\8\:VDD \9\:VDD) resistor r=0.1711 c=0
Rk97 (\9\:VDD \11\:VDD) resistor r=0.1695 c=0
Rk98 (\3\:VDD \13\:VDD) resistor r=0.32 c=0
Rk99 (\4\:VDD \15\:VDD) resistor r=0.3026 c=0
Rk100 (\7\:VDD \17\:VDD) resistor r=0.3757 c=0
Rk101 (\8\:VDD \19\:VDD) resistor r=0.3677 c=0
Rk102 (\9\:VDD \21\:VDD) resistor r=0.2078 c=0
Rk106 (\22\:VDD VDD) resistor r=0.1959 c=0
Rk103 (\11\:VDD \22\:VDD) resistor r=0.1713 c=0
Rk104 (\22\:VDD \24\:VDD) resistor r=0.2078 c=0
Rk105 (\11\:VDD \26\:VDD) resistor r=0.2399 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3416 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2303 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4984 c=0
Rk19 (\19\:n20 \20\:n20) resistor r=0.4375 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7542 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.532 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.2044 c=0
Rk61 (\20\:CKbb \21\:CKbb) resistor r=0.8279 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.6045 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.3058 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1684 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.3479 c=0
Rk24 (\7\:mout \12\:mout) resistor r=0.1284 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.09239 c=0
Rk26 (\9\:mout \15\:mout) resistor r=0.5264 c=0
Rk27 (\15\:mout \17\:mout) resistor r=0.0449 c=0
Rk28 (\10\:mout \18\:mout) resistor r=0.4268 c=0
Rk29 (\15\:mout \20\:mout) resistor r=0.03469 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.318 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1585 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1872 c=0
Rk37 (\19\:CKb \20\:CKb) resistor r=0.3729 c=0
Rk32 (\5\:SEb \6\:SEb) resistor r=0.217 c=0
Rk33 (\6\:SEb \7\:SEb) resistor r=0.3559 c=0
Rk34 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk38 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk39 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk50 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk51 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk52 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk47 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk48 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk49 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk62 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk53 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk54 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk55 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk56 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk68 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk69 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk70 (\7\:net573 \10\:net573) resistor r=0.2849 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk40 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk41 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk66 (\15\:n35 \16\:n35) resistor r=0.305 c=0
Rk67 (\16\:n35 \18\:n35) resistor r=0.2683 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk17 (\4\:Db \6\:Db) resistor r=1.4324 c=0
Rk18 (\6\:Db \8\:Db) resistor r=0.5673 c=0
Rk71 (\2\:n11 \4\:n11) resistor r=0.6555 c=0
Rl13 (\2\:D \4\:D) resistor r=115.099 c=0
Rl11 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl12 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl20 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl19 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl54 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl41 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl44 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl43 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl42 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl65 (\7\:SN \8\:SN) resistor r=367.487 c=0
Rl66 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl10 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl57 (\4\:SN \6\:SN) resistor r=115.884 c=0
Rl55 (\3\:SN \4\:SN) resistor r=1092.88 c=0
Rl56 (\4\:SN \5\:SN) resistor r=66.1252 c=0
Rl23 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl25 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl22 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl24 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl21 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl16 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl60 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl2 (CKbb \2\:CKbb) resistor r=38.8525 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl49 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl52 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl53 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl51 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl50 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl26 (CKb \2\:CKb) resistor r=349.798 c=0
Rl31 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl32 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl33 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=266.282 c=0
Rl34 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl17 (SEb \2\:SEb) resistor r=101.718 c=0
Rl18 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl37 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl35 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl36 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl38 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl67 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl74 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl72 (\11\:qbint \12\:qbint) resistor r=343.448 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl68 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl71 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl73 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl70 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl69 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl39 (RTb \2\:RTb) resistor r=112.412 c=0
Rl40 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl62 (net573 \2\:net573) resistor r=3.1216 c=0
Rl63 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl64 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl58 (n35 \2\:n35) resistor r=508.667 c=0
Rl59 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz33 (\32\:VSS \38\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry25 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=15.5 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry37 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry9 (\19\:mout \20\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx11 (\3\:D D) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx31 (\3\:SN \12\:SN) resistor r=45 c=0
Rx32 (\9\:SN \13\:SN) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx12 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (CKb \19\:CKb) resistor r=45 c=0
Rx21 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx35 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx36 (qbint \22\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx38 (net573 \8\:net573) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.307e-14 ad=8.7e-15 ps=1.16e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0119 \6\:SN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn52 (net0118 \12\:qbint net0116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0116 \8\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (n11 \11\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n11 \7\:SN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:08:11 2012 )
// Library name: gsclib045
// Cell name: SRDFFX1
// View name: extracted

simulator lang=spectre

subckt SRDFFX1 CK D ExtVDD Q QN RT SE SI VDD VSS
mp25 (\9\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (QN VSS) capacitor c=1.96753e-17
C2 (SI VSS) capacitor c=8.75259e-17
C3 (RT VSS) capacitor c=3.67638e-17
C4 (ExtVDD VSS) capacitor c=2.18919e-16
C5 (CK VSS) capacitor c=7.98675e-17
C6 (VDD VSS) capacitor c=7.1504e-16
C7 (SE VSS) capacitor c=3.96872e-17
C8 (Q VSS) capacitor c=6.17444e-17
C9 (D VSS) capacitor c=7.97214e-17
C10 (n20 VSS) capacitor c=3.84704e-17
C11 (CKbb VSS) capacitor c=3.32985e-17
C12 (mout VSS) capacitor c=5.37744e-17
C13 (CKb VSS) capacitor c=4.82614e-17
C14 (SEb VSS) capacitor c=7.75108e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.57835e-17
C17 (RTb VSS) capacitor c=5.18061e-17
C18 (net573 VSS) capacitor c=2.25505e-17
C19 (n35 VSS) capacitor c=1.45528e-16
C20 (Db VSS) capacitor c=1.02833e-16
C21 (net0110 VSS) capacitor c=6.33869e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:qbint VSS) capacitor c=3.39026e-17
C24 (\11\:qbint VSS) capacitor c=8.31359e-17
C25 (\13\:qbint VSS) capacitor c=4.3763e-17
C26 (\3\:net573 VSS) capacitor c=5.86679e-17
C27 (\11\:CKbb VSS) capacitor c=4.93916e-17
C28 (\4\:RTb VSS) capacitor c=9.88373e-17
C29 (\6\:RT VSS) capacitor c=2.22306e-17
C30 (\4\:qbint VSS) capacitor c=5.36612e-17
C31 (\3\:n35g VSS) capacitor c=5.22105e-17
C32 (\5\:RT VSS) capacitor c=5.86041e-17
C33 (\3\:SE VSS) capacitor c=7.73577e-17
C34 (\7\:CKb VSS) capacitor c=2.48722e-17
C35 (\3\:SI VSS) capacitor c=9.47876e-17
C36 (\4\:SE VSS) capacitor c=1.22829e-16
C37 (\4\:D VSS) capacitor c=7.17432e-17
C38 (\3\:n20 VSS) capacitor c=4.49327e-17
C39 (\4\:CK VSS) capacitor c=5.80043e-17
C40 (\4\:CKb VSS) capacitor c=4.923e-17
C41 (\8\:CKb VSS) capacitor c=8.26279e-17
C42 (\3\:CKbb VSS) capacitor c=2.60323e-17
C43 (\6\:qbint VSS) capacitor c=3.71807e-17
C44 (\14\:qbint VSS) capacitor c=4.56859e-17
C45 (\12\:qbint VSS) capacitor c=8.5727e-17
C46 (\4\:net573 VSS) capacitor c=3.6802e-17
C47 (\11\:CKb VSS) capacitor c=2.33773e-16
C48 (\8\:RT VSS) capacitor c=1.21363e-16
C49 (\2\:RT VSS) capacitor c=6.22925e-17
C50 (\5\:qbint VSS) capacitor c=3.89021e-17
C51 (\5\:n35g VSS) capacitor c=3.28693e-17
C52 (\2\:RTb VSS) capacitor c=4.65527e-17
C53 (\5\:SE VSS) capacitor c=5.7365e-17
C54 (\5\:CKbb VSS) capacitor c=2.45241e-17
C55 (\1\:SI VSS) capacitor c=4.90982e-17
C56 (\6\:SE VSS) capacitor c=8.63749e-17
C57 (\3\:SEb VSS) capacitor c=6.59302e-17
C58 (\1\:D VSS) capacitor c=4.94494e-17
C59 (\6\:n20 VSS) capacitor c=6.51408e-17
C60 (\1\:CK VSS) capacitor c=2.87489e-17
C61 (\3\:mout VSS) capacitor c=5.00546e-17
C62 (\9\:CKb VSS) capacitor c=3.64731e-17
C63 (\10\:CKbb VSS) capacitor c=4.86151e-17
C64 (\6\:CKb VSS) capacitor c=5.11913e-17
C65 (\10\:qbint VSS) capacitor c=8.4112e-17
C66 (\12\:CKbb VSS) capacitor c=3.97735e-17
C67 (\7\:RT VSS) capacitor c=1.4413e-16
C68 (\9\:CKbb VSS) capacitor c=1.55969e-16
C69 (\3\:RT VSS) capacitor c=3.3013e-17
C70 (\1\:RT VSS) capacitor c=5.2467e-17
C71 (\3\:RTb VSS) capacitor c=7.61997e-17
C72 (\3\:qbint VSS) capacitor c=4.44155e-17
C73 (\2\:n35 VSS) capacitor c=1.89205e-16
C74 (\4\:n35g VSS) capacitor c=6.64048e-17
C75 (\12\:CKb VSS) capacitor c=2.21201e-16
C76 (\3\:n35 VSS) capacitor c=7.66801e-17
C77 (\1\:SE VSS) capacitor c=2.47752e-17
C78 (\2\:SI VSS) capacitor c=7.74068e-17
C79 (\2\:SEb VSS) capacitor c=7.8411e-17
C80 (\3\:D VSS) capacitor c=1.51143e-17
C81 (\3\:CK VSS) capacitor c=2.31437e-17
C82 (\2\:mout VSS) capacitor c=3.80143e-17
C83 (\4\:mout VSS) capacitor c=3.80927e-17
C84 (\10\:CKb VSS) capacitor c=2.21463e-17
C85 (\5\:n20 VSS) capacitor c=3.73048e-17
C86 (\4\:CKbb VSS) capacitor c=6.31669e-17
C87 (\8\:CKbb VSS) capacitor c=2.45777e-17
C88 (\2\:n20 VSS) capacitor c=3.95838e-17
C89 (\1\:VDD VSS) capacitor c=4.94752e-17
C90 (\3\:Q VSS) capacitor c=7.27761e-17
C91 (\10\:VDD VSS) capacitor c=5.42941e-17
C92 (\9\:net573 VSS) capacitor c=5.56972e-17
C93 (\12\:VDD VSS) capacitor c=7.99107e-17
C94 (\3\:net0110 VSS) capacitor c=8.53421e-17
C95 (\4\:QN VSS) capacitor c=6.81951e-17
C96 (\14\:n35 VSS) capacitor c=5.41413e-17
C97 (\15\:n35g VSS) capacitor c=5.5988e-17
C98 (\6\:RTb VSS) capacitor c=7.31995e-17
C99 (\1\:ExtVDD VSS) capacitor c=2.78276e-16
C100 (\9\:n35 VSS) capacitor c=6.22363e-17
C101 (\17\:qbint VSS) capacitor c=6.84723e-17
C102 (\6\:n35g VSS) capacitor c=9.31897e-17
C103 (\8\:SEb VSS) capacitor c=5.08032e-17
C104 (\4\:n35 VSS) capacitor c=6.41853e-17
C105 (\14\:VDD VSS) capacitor c=6.09381e-17
C106 (\5\:mout VSS) capacitor c=6.55783e-17
C107 (\3\:Db VSS) capacitor c=1.93889e-16
C108 (\19\:VDD VSS) capacitor c=3.46338e-17
C109 (\14\:mout VSS) capacitor c=4.55773e-17
C110 (\17\:CKb VSS) capacitor c=2.99062e-17
C111 (\17\:VDD VSS) capacitor c=4.83231e-17
C112 (\17\:CKbb VSS) capacitor c=7.28685e-17
C113 (\12\:n20 VSS) capacitor c=6.7629e-17
C114 (\5\:Db VSS) capacitor c=2.22367e-16
C115 (\9\:n20 VSS) capacitor c=6.36354e-17
C116 (\1\:Q VSS) capacitor c=6.54344e-17
C117 (\5\:net573 VSS) capacitor c=4.31609e-17
C118 (\1\:QN VSS) capacitor c=3.92499e-17
C119 (\17\:n35 VSS) capacitor c=3.68796e-17
C120 (\11\:n35g VSS) capacitor c=2.97301e-17
C121 (\10\:RTb VSS) capacitor c=5.83059e-17
C122 (\12\:n35 VSS) capacitor c=6.37635e-17
C123 (\19\:qbint VSS) capacitor c=2.43869e-17
C124 (\9\:n35g VSS) capacitor c=8.1299e-17
C125 (\4\:SEb VSS) capacitor c=3.95357e-17
C126 (\7\:n35 VSS) capacitor c=4.17234e-17
C127 (\10\:mout VSS) capacitor c=2.32392e-17
C128 (\12\:mout VSS) capacitor c=2.62247e-17
C129 (\13\:CKb VSS) capacitor c=5.70233e-17
C130 (\15\:CKbb VSS) capacitor c=9.11333e-17
C131 (\16\:n20 VSS) capacitor c=8.2119e-17
C132 (\7\:Db VSS) capacitor c=7.8489e-17
C133 (\7\:n20 VSS) capacitor c=5.89516e-17
C134 (VDD VSS) capacitor c=4.24372e-17
C135 (\2\:CKbb VSS) capacitor c=6.47353e-17
C136 (\2\:CK VSS) capacitor c=3.70344e-17
C137 (\4\:n20 VSS) capacitor c=5.43891e-17
C138 (\2\:D VSS) capacitor c=3.58484e-17
C139 (\2\:SE VSS) capacitor c=2.50121e-17
C140 (\2\:CKb VSS) capacitor c=1.5308e-16
C141 (\3\:CKb VSS) capacitor c=8.93576e-17
C142 (\5\:CKb VSS) capacitor c=5.76797e-17
C143 (\2\:n35g VSS) capacitor c=2.90883e-17
C144 (\4\:RT VSS) capacitor c=3.78115e-17
C145 (\2\:qbint VSS) capacitor c=4.13305e-17
C146 (\6\:CKbb VSS) capacitor c=1.29582e-16
C147 (\7\:CKbb VSS) capacitor c=7.26353e-17
C148 (\2\:net573 VSS) capacitor c=1.52866e-17
C149 (\11\:n20 VSS) capacitor c=4.46389e-17
C150 (\13\:CKbb VSS) capacitor c=9.84345e-17
C151 (\14\:CKbb VSS) capacitor c=9.76079e-17
C152 (\8\:qbint VSS) capacitor c=4.58346e-17
C153 (\9\:qbint VSS) capacitor c=6.60997e-17
C154 (\14\:n20 VSS) capacitor c=5.19649e-17
C155 (\15\:n20 VSS) capacitor c=8.82111e-17
C156 (\19\:CKbb VSS) capacitor c=4.38948e-17
C157 (\15\:CKb VSS) capacitor c=6.01146e-17
C158 (\16\:CKb VSS) capacitor c=4.45341e-17
C159 (\7\:mout VSS) capacitor c=8.2704e-17
C160 (\8\:mout VSS) capacitor c=5.71549e-17
C161 (\9\:mout VSS) capacitor c=5.30418e-17
C162 (\16\:mout VSS) capacitor c=4.527e-17
C163 (\7\:SE VSS) capacitor c=5.26435e-17
C164 (\6\:SEb VSS) capacitor c=8.36785e-17
C165 (\7\:SEb VSS) capacitor c=6.96329e-17
C166 (\6\:n35 VSS) capacitor c=7.67648e-17
C167 (\19\:CKb VSS) capacitor c=3.8227e-17
C168 (\20\:CKb VSS) capacitor c=4.1869e-17
C169 (\8\:n35g VSS) capacitor c=3.40218e-17
C170 (\11\:n35 VSS) capacitor c=7.40109e-17
C171 (\15\:qbint VSS) capacitor c=8.80005e-17
C172 (\16\:qbint VSS) capacitor c=1.12149e-16
C173 (\13\:n35g VSS) capacitor c=1.02685e-16
C174 (\14\:n35g VSS) capacitor c=1.16309e-16
C175 (\5\:RTb VSS) capacitor c=4.94973e-17
C176 (\8\:RTb VSS) capacitor c=1.01992e-16
C177 (\9\:RTb VSS) capacitor c=9.17318e-17
C178 (\20\:CKbb VSS) capacitor c=9.48784e-17
C179 (\21\:CKbb VSS) capacitor c=1.00848e-16
C180 (\21\:qbint VSS) capacitor c=2.39372e-17
C181 (\22\:qbint VSS) capacitor c=3.00557e-17
C182 (\9\:RT VSS) capacitor c=1.04346e-16
C183 (\10\:RT VSS) capacitor c=1.18785e-16
C184 (\11\:RT VSS) capacitor c=5.89968e-17
C185 (\3\:QN VSS) capacitor c=3.18227e-17
C186 (\16\:n35 VSS) capacitor c=3.71648e-17
C187 (\7\:net573 VSS) capacitor c=5.7709e-17
C188 (\8\:net573 VSS) capacitor c=3.51646e-17
C189 (\3\:VDD VSS) capacitor c=4.42231e-17
C190 (\5\:VDD VSS) capacitor c=9.3079e-18
C191 (\6\:VDD VSS) capacitor c=2.25179e-16
C192 (\7\:VDD VSS) capacitor c=2.13236e-16
C193 (\9\:VDD VSS) capacitor c=3.80928e-17
C194 (\16\:VDD VSS) capacitor c=5.94309e-17
Rk57 (\3\:QN QN) resistor r=0.02948 c=0
Rk56 (\2\:QN \3\:QN) resistor r=0.1988 c=0
Rk58 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk53 (RT \9\:RT) resistor r=0.1932 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6407 c=0
Rk55 (RT \11\:RT) resistor r=0.006609 c=0
Rk38 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk96 (VDD VDD) resistor r=0.2356 c=0
Rk84 (\2\:VDD \3\:VDD) resistor r=0.5761 c=0
Rk85 (\3\:VDD \5\:VDD) resistor r=0.06676 c=0
Rk86 (\5\:VDD \6\:VDD) resistor r=0.05188 c=0
Rk87 (\6\:VDD \7\:VDD) resistor r=1.5221 c=0
Rk88 (\7\:VDD \9\:VDD) resistor r=0.3401 c=0
Rk89 (\3\:VDD \11\:VDD) resistor r=0.3013 c=0
Rk90 (\6\:VDD \13\:VDD) resistor r=0.3741 c=0
Rk91 (\7\:VDD \15\:VDD) resistor r=0.3661 c=0
Rk95 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk92 (\9\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk93 (\16\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk94 (\9\:VDD \20\:VDD) resistor r=0.2389 c=0
Rk25 (SE \7\:SE) resistor r=0.0432 c=0
Rk65 (\2\:Q Q) resistor r=0.2973 c=0
Rk66 (Q \4\:Q) resistor r=0.2044 c=0
Rk67 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk68 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk69 (\5\:VSS \6\:VSS) resistor r=0.05932 c=0
Rk70 (\6\:VSS \7\:VSS) resistor r=0.6123 c=0
Rk71 (\7\:VSS \8\:VSS) resistor r=0.03204 c=0
Rk73 (\9\:VSS VSS) resistor r=0.1211 c=0
Rk72 (\8\:VSS \9\:VSS) resistor r=0.1759 c=0
Rk74 (VSS \10\:VSS) resistor r=0.5208 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk77 (\12\:VSS VSS) resistor r=0.1213 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk78 (VSS \14\:VSS) resistor r=0.3119 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.2667 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.1891 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.1942 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.2532 c=0
Rk83 (\11\:VSS \24\:VSS) resistor r=0.2488 c=0
Rk97 (\26\:VSS \28\:VSS) resistor r=0.3487 c=0
Rk98 (\28\:VSS \29\:VSS) resistor r=0.5654 c=0
Rk100 (\30\:VSS VSS) resistor r=0.04935 c=0
Rk99 (\29\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk102 (\31\:VSS VSS) resistor r=0.1213 c=0
Rk101 (VSS \31\:VSS) resistor r=0.8929 c=0
Rk103 (VSS \33\:VSS) resistor r=0.2968 c=0
Rk104 (\29\:VSS \35\:VSS) resistor r=0.2434 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2662 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4595 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7511 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.5321 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.142 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.7115 c=0
Rk17 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk18 (\7\:mout \8\:mout) resistor r=0.5259 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.1904 c=0
Rk20 (\7\:mout \11\:mout) resistor r=0.1278 c=0
Rk21 (\8\:mout \13\:mout) resistor r=0.1169 c=0
Rk22 (\8\:mout \15\:mout) resistor r=0.5475 c=0
Rk23 (\9\:mout \16\:mout) resistor r=0.3936 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.3167 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1578 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1865 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.3714 c=0
Rk26 (\5\:SEb \6\:SEb) resistor r=0.2161 c=0
Rk27 (\6\:SEb \7\:SEb) resistor r=0.3544 c=0
Rk28 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk42 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk43 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk52 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk61 (\6\:net573 \7\:net573) resistor r=0.2307 c=0
Rk62 (\7\:net573 \8\:net573) resistor r=0.1648 c=0
Rk63 (\7\:net573 \10\:net573) resistor r=0.2901 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk59 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk60 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.42 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.5649 c=0
Rk64 (\2\:net0110 \4\:net0110) resistor r=0.6451 c=0
Rl19 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl18 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl53 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl40 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl43 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl42 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl41 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl22 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl24 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl21 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl23 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl20 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl10 (\3\:n20 \4\:n20) resistor r=100.163 c=0
Rl12 (\4\:n20 \6\:n20) resistor r=179.184 c=0
Rl11 (\4\:n20 \5\:n20) resistor r=123.391 c=0
Rl56 (\11\:CKbb \12\:CKbb) resistor r=163.284 c=0
Rl2 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl48 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl51 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl52 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl50 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl49 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl57 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl25 (CKb \2\:CKb) resistor r=349.798 c=0
Rl30 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl27 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl31 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl26 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl32 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=266.239 c=0
Rl33 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl16 (SEb \2\:SEb) resistor r=101.718 c=0
Rl17 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl36 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl37 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl61 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl68 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl66 (\11\:qbint \12\:qbint) resistor r=337.984 c=0
Rl47 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl44 (qbint \2\:qbint) resistor r=112.732 c=0
Rl46 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl45 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl62 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl65 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl67 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl64 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl63 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl38 (RTb \2\:RTb) resistor r=112.412 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl58 (net573 \2\:net573) resistor r=3.1216 c=0
Rl59 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl60 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl54 (n35 \2\:n35) resistor r=508.667 c=0
Rl55 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\12\:mout \13\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry19 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry30 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry35 (\27\:VSS \28\:VSS) resistor r=5.6364 c=0
Ry36 (\27\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry37 (\27\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry21 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry22 (net0110 \2\:net0110) resistor r=62 c=0
Ry23 (\3\:net0110 \4\:net0110) resistor r=62 c=0
Rx12 (\2\:SI SI) resistor r=45 c=0
Rx28 (\3\:RT \9\:RT) resistor r=45 c=0
Rx29 (\1\:RT \10\:RT) resistor r=45 c=0
Rx30 (\7\:RT \11\:RT) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx13 (\1\:SE \7\:SE) resistor r=45 c=0
Rx9 (\3\:D D) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx24 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx25 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx10 (\4\:mout \9\:mout) resistor r=45 c=0
Rx11 (\2\:mout \16\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (CKb \19\:CKb) resistor r=45 c=0
Rx17 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx26 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx27 (qbint \22\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx32 (net573 \8\:net573) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\12\:mout \6\:n20 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn52 (net0118 \12\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\14\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:net0110 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (net0110 \11\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:19:45 2012 )
// Library name: gsclib045
// Cell name: HSWDNX1
// View name: extracted

simulator lang=spectre

subckt HSWDNX1 ExtVDD PSO1n PSO1n_out PSO2n PSO2n_out VDD VSS
PM3 (\56\:VDD n2 \13\:ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.7101 \
        scb=0.0128174 scc=0.00128324 m=(1)
PM2 (\11\:n2 \4\:PSO2n \49\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=34.1613 \
        scb=0.0368451 scc=0.00393009 m=(1)
C1 (PSO1n_out VSS) capacitor c=4.36094e-17
C2 (PSO1n VSS) capacitor c=3.00601e-17
C3 (ExtVDD VSS) capacitor c=1.97963e-15
C4 (VDD VSS) capacitor c=2.52086e-16
C5 (PSO2n_out VSS) capacitor c=7.07038e-17
C6 (PSO2n VSS) capacitor c=9.27895e-17
C7 (n2 VSS) capacitor c=3.84845e-17
C8 (n1 VSS) capacitor c=1.10474e-15
C9 (\1\:PSO1n VSS) capacitor c=2.70014e-16
C10 (\4\:PSO2n VSS) capacitor c=3.93995e-17
C11 (\1\:PSO2n VSS) capacitor c=3.10568e-17
C12 (\15\:n1 VSS) capacitor c=1.22827e-16
C13 (\4\:n2 VSS) capacitor c=1.05296e-17
C14 (\3\:PSO2n VSS) capacitor c=1.00381e-17
C15 (\1\:ExtVDD VSS) capacitor c=1.46365e-17
C16 (\2\:ExtVDD VSS) capacitor c=1.27397e-17
C17 (\1\:PSO1n_out VSS) capacitor c=8.16108e-17
C18 (\56\:VDD VSS) capacitor c=8.67037e-17
C19 (\13\:ExtVDD VSS) capacitor c=9.60834e-17
C20 (\3\:PSO2n_out VSS) capacitor c=5.63427e-17
C21 (\11\:n2 VSS) capacitor c=8.5926e-17
C22 (\49\:ExtVDD VSS) capacitor c=6.03592e-17
C23 (\3\:PSO1n_out VSS) capacitor c=8.33652e-17
C24 (\1\:PSO2n_out VSS) capacitor c=8.07898e-17
C25 (\13\:n2 VSS) capacitor c=5.90114e-17
C26 (\2\:PSO2n VSS) capacitor c=1.21786e-17
C27 (\2\:n2 VSS) capacitor c=1.28276e-16
C28 (VDD VSS) capacitor c=2.64852e-15
C29 (ExtVDD VSS) capacitor c=8.84892e-16
C30 (ExtVDD VSS) capacitor c=8.60587e-16
C31 (\62\:n1 VSS) capacitor c=1.09005e-16
C32 (\14\:PSO1n VSS) capacitor c=1.38424e-17
C33 (\15\:PSO1n VSS) capacitor c=4.23846e-17
C34 (\9\:n2 VSS) capacitor c=2.81939e-17
C35 (\10\:n2 VSS) capacitor c=3.87556e-17
C36 (\69\:n1 VSS) capacitor c=1.10468e-16
C37 (\70\:n1 VSS) capacitor c=4.0904e-16
C38 (\12\:ExtVDD VSS) capacitor c=6.49737e-17
C39 (\15\:ExtVDD VSS) capacitor c=2.42427e-16
C40 (\18\:ExtVDD VSS) capacitor c=4.69319e-17
C41 (\64\:ExtVDD VSS) capacitor c=2.50055e-16
C42 (\66\:ExtVDD VSS) capacitor c=3.37653e-16
C43 (\69\:ExtVDD VSS) capacitor c=4.56028e-17
C44 (\11\:VDD VSS) capacitor c=1.64008e-16
Rk19 (\2\:PSO1n_out PSO1n_out) resistor r=0.2134 c=0
Rk20 (PSO1n_out \4\:PSO1n_out) resistor r=0.3308 c=0
Rk3 (\13\:PSO1n PSO1n) resistor r=0.005212 c=0
Rk4 (PSO1n \14\:PSO1n) resistor r=0.005054 c=0
Rk5 (\13\:PSO1n \14\:PSO1n) resistor r=0.0151 c=0
Rk7 (\14\:PSO1n \15\:PSO1n) resistor r=0.01661 c=0
Rk6 (\15\:PSO1n \16\:PSO1n) resistor r=0.005212 c=0
Rk29 (ExtVDD \12\:ExtVDD) resistor r=0.1574 c=0
Rk30 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.6617 c=0
Rk31 (\14\:ExtVDD \15\:ExtVDD) resistor r=0.426 c=0
Rk33 (\15\:ExtVDD \17\:ExtVDD) resistor r=0.3543 c=0
Rk34 (\17\:ExtVDD \18\:ExtVDD) resistor r=0.05305 c=0
Rk50 (\17\:ExtVDD \50\:ExtVDD) resistor r=0.2214 c=0
Rk61 (ExtVDD \64\:ExtVDD) resistor r=0.3296 c=0
Rk63 (\64\:ExtVDD \66\:ExtVDD) resistor r=0.259 c=0
Rk66 (\66\:ExtVDD \69\:ExtVDD) resistor r=0.05305 c=0
Rk91 (\11\:VDD VDD) resistor r=0.4233 c=0
Rk90 (VDD \11\:VDD) resistor r=0.4677 c=0
Rk114 (\11\:VDD \57\:VDD) resistor r=0.3808 c=0
Rk11 (\2\:PSO2n_out PSO2n_out) resistor r=0.4029 c=0
Rk12 (PSO2n_out \4\:PSO2n_out) resistor r=0.06067 c=0
Rk116 (\3\:VSS VSS) resistor r=0.2003 c=0
Rk115 (\2\:VSS \3\:VSS) resistor r=0.9528 c=0
Rk120 (\4\:VSS VSS) resistor r=0.12 c=0
Rk117 (VSS \4\:VSS) resistor r=0.4037 c=0
Rk129 (\21\:VSS VSS) resistor r=1.0027 c=0
Rk130 (VSS \22\:VSS) resistor r=0.1005 c=0
Rk134 (\23\:VSS VSS) resistor r=0.1425 c=0
Rk131 (\22\:VSS \23\:VSS) resistor r=0.6116 c=0
Rk135 (VSS \26\:VSS) resistor r=0.08029 c=0
Rk136 (\26\:VSS \27\:VSS) resistor r=0.06249 c=0
Rk139 (\26\:VSS \33\:VSS) resistor r=0.3085 c=0
Rk8 (\9\:n2 \10\:n2) resistor r=0.1621 c=0
Rk9 (\10\:n2 \12\:n2) resistor r=0.2722 c=0
Rk10 (\10\:n2 \14\:n2) resistor r=0.2146 c=0
Rk13 (\69\:n1 \70\:n1) resistor r=0.4476 c=0
Rl1 (\2\:ExtVDD \1\:ExtVDD) resistor r=52.0063 c=0
Rl4 (\2\:PSO2n \4\:PSO2n) resistor r=38.9859 c=0
Rl2 (\1\:PSO2n \2\:PSO2n) resistor r=59.6246 c=0
Rl3 (\2\:PSO2n \3\:PSO2n) resistor r=3.1183 c=0
Rl16 (\2\:n2 n2) resistor r=191.771 c=0
Rl18 (\2\:n2 \4\:n2) resistor r=9.0434 c=0
Rl36 (n1 \15\:n1) resistor r=314.651 c=0
Rl83 (\62\:n1 \15\:n1) resistor r=50.14 c=0
Rz5 (\4\:PSO1n_out \3\:PSO1n_out) resistor r=37.5 c=0
Rz2 (\2\:PSO2n_out \1\:PSO2n_out) resistor r=37.5 c=0
Rz14 (\33\:VSS \32\:VSS) resistor r=37.5 c=0
Rz1 (\14\:n2 \13\:n2) resistor r=37.5 c=0
Ry5 (\2\:PSO1n_out \1\:PSO1n_out) resistor r=20.6667 c=0
Ry8 (\14\:ExtVDD \13\:ExtVDD) resistor r=20.6667 c=0
Ry23 (\50\:ExtVDD \49\:ExtVDD) resistor r=20.6667 c=0
Ry67 (\57\:VDD \56\:VDD) resistor r=20.6667 c=0
Ry2 (\4\:PSO2n_out \3\:PSO2n_out) resistor r=20.6667 c=0
Ry71 (VSS \1\:VSS) resistor r=6.8889 c=0
Ry68 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry69 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry70 (\4\:VSS \1\:VSS) resistor r=31 c=0
Ry72 (\21\:VSS \20\:VSS) resistor r=6.2 c=0
Ry73 (\22\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry74 (\23\:VSS \20\:VSS) resistor r=31 c=0
Ry75 (\27\:VSS \20\:VSS) resistor r=10.3333 c=0
Ry1 (\12\:n2 \11\:n2) resistor r=20.6667 c=0
Rx2 (\16\:PSO1n \1\:PSO1n) resistor r=45 c=0
Rx5 (\18\:ExtVDD \1\:ExtVDD) resistor r=45 c=0
Rx6 (\69\:ExtVDD \2\:ExtVDD) resistor r=45 c=0
Rx1 (\3\:PSO2n PSO2n) resistor r=45 c=0
Rx3 (\9\:n2 \4\:n2) resistor r=45 c=0
Rx4 (\69\:n1 \15\:n1) resistor r=9 c=0
NM0_2__rcx (VSS \1\:PSO1n \70\:n1 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.5e-14 ad=4.8e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=10.637 scb=0.00973476 \
        scc=0.000429831 m=(4)
NM1 (\32\:VSS \1\:PSO2n \13\:n2 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.2e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2701 \
        scb=0.0157116 scc=0.00141809 m=(1)
NM3 (\23\:VSS \2\:n2 \1\:PSO2n_out VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.2701 \
        scb=0.0157116 scc=0.00141809 m=(2)
NM4 (\4\:VSS \62\:n1 \3\:PSO1n_out VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.667 \
        scb=0.0153545 scc=0.001049 m=(2)
PM1_2__rcx (\70\:n1 \1\:PSO1n \66\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=18.7693 \
        scb=0.0154144 scc=0.00171488 m=(4)
PM5 (\3\:PSO2n_out \2\:n2 \15\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.0001 \
        scb=0.0136275 scc=0.00128433 m=(2)
PM6 (\1\:PSO1n_out \62\:n1 \64\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.5166 \
        scb=0.0139334 scc=0.0015954 m=(2)
PM0_1__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.2e-14 ps=1.212e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=37.8738 scb=0.0220613 \
        scc=0.00371947 m=(20)
PM0_21__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n sca=35.2833 \
        scb=0.0187724 scc=0.00367895 m=(14)
PM0_23__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n sca=4.07325 \
        scb=0.000378105 scc=2.57733e-07 m=(14)
ends HSWDNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:22:44 2012 )
// Library name: gsclib045
// Cell name: HSWDX1
// View name: extracted

simulator lang=spectre

subckt HSWDX1 ExtVDD PSO1 PSO1_out PSO2 PSO2_out VDD VSS
PM3 (\56\:VDD n2 \13\:ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0912 \
        scb=0.0107219 scc=0.000815487 m=(1)
PM8 (\16\:pso1n \1\:PSO1 \67\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=38.4244 \
        scb=0.0401517 scc=0.00462137 m=(1)
C1 (PSO1_out VSS) capacitor c=3.02562e-17
C2 (ExtVDD VSS) capacitor c=1.93345e-15
C3 (PSO1 VSS) capacitor c=4.46461e-17
C4 (PSO2 VSS) capacitor c=8.05999e-17
C5 (PSO2_out VSS) capacitor c=4.31599e-17
C6 (VDD VSS) capacitor c=2.98672e-16
C7 (pso2n VSS) capacitor c=3.53116e-17
C8 (n2 VSS) capacitor c=8.55724e-17
C9 (pso1n VSS) capacitor c=5.07265e-17
C10 (n1 VSS) capacitor c=1.11268e-15
C11 (\5\:pso2n VSS) capacitor c=2.97877e-17
C12 (\6\:pso2n VSS) capacitor c=3.25236e-17
C13 (\3\:PSO2 VSS) capacitor c=4.17307e-17
C14 (\1\:PSO1 VSS) capacitor c=3.57456e-17
C15 (\7\:pso1n VSS) capacitor c=2.7165e-17
C16 (\7\:pso2n VSS) capacitor c=3.30591e-17
C17 (\1\:PSO2 VSS) capacitor c=2.81448e-17
C18 (\4\:PSO1 VSS) capacitor c=2.87625e-17
C19 (\15\:n1 VSS) capacitor c=1.10462e-16
C20 (\2\:n2 VSS) capacitor c=8.7023e-17
C21 (\4\:pso2n VSS) capacitor c=1.10444e-17
C22 (\1\:ExtVDD VSS) capacitor c=1.57425e-17
C23 (\2\:ExtVDD VSS) capacitor c=9.02237e-18
C24 (\2\:PSO2 VSS) capacitor c=2.90335e-17
C25 (\3\:PSO1 VSS) capacitor c=1.45477e-17
C26 (\1\:VDD VSS) capacitor c=2.52495e-15
C27 (\3\:PSO1_out VSS) capacitor c=7.85367e-17
C28 (\89\:ExtVDD VSS) capacitor c=6.29969e-17
C29 (\56\:VDD VSS) capacitor c=9.1347e-17
C30 (\13\:ExtVDD VSS) capacitor c=1.29541e-16
C31 (\1\:PSO2_out VSS) capacitor c=8.42581e-17
C32 (\62\:n1 VSS) capacitor c=4.02396e-16
C33 (\46\:ExtVDD VSS) capacitor c=6.99237e-17
C34 (\5\:n2 VSS) capacitor c=1.0361e-16
C35 (\48\:ExtVDD VSS) capacitor c=7.89803e-17
C36 (\10\:pso2n VSS) capacitor c=7.97223e-17
C37 (\16\:pso1n VSS) capacitor c=7.22933e-17
C38 (\18\:ExtVDD VSS) capacitor c=6.1596e-17
C39 (\67\:ExtVDD VSS) capacitor c=5.70596e-17
C40 (\1\:PSO1_out VSS) capacitor c=6.39624e-17
C41 (\3\:PSO2_out VSS) capacitor c=4.13035e-17
C42 (\3\:n2 VSS) capacitor c=6.89055e-17
C43 (\12\:pso2n VSS) capacitor c=5.1348e-17
C44 (\19\:pso1n VSS) capacitor c=5.23295e-17
C45 (\2\:PSO1 VSS) capacitor c=1.77622e-17
C46 (\2\:pso2n VSS) capacitor c=2.46604e-17
C47 (\3\:pso2n VSS) capacitor c=2.02984e-17
C48 (\2\:pso1n VSS) capacitor c=2.75273e-17
C49 (\3\:pso1n VSS) capacitor c=2.72842e-16
C50 (VDD VSS) capacitor c=6.41421e-17
C51 (ExtVDD VSS) capacitor c=8.76837e-16
C52 (ExtVDD VSS) capacitor c=9.03303e-16
C53 (\5\:PSO1 VSS) capacitor c=2.6388e-17
C54 (\8\:pso2n VSS) capacitor c=3.44771e-17
C55 (\9\:pso2n VSS) capacitor c=4.47443e-17
C56 (\18\:pso1n VSS) capacitor c=5.3465e-17
C57 (\21\:pso1n VSS) capacitor c=5.04598e-17
C58 (\7\:n2 VSS) capacitor c=4.93836e-17
C59 (\70\:n1 VSS) capacitor c=7.23116e-17
C60 (\12\:ExtVDD VSS) capacitor c=6.45047e-17
C61 (\15\:ExtVDD VSS) capacitor c=7.62511e-17
C62 (\16\:ExtVDD VSS) capacitor c=4.65118e-17
C63 (\17\:ExtVDD VSS) capacitor c=5.89687e-17
C64 (\62\:ExtVDD VSS) capacitor c=6.25694e-17
C65 (\63\:ExtVDD VSS) capacitor c=3.82735e-16
C66 (\66\:ExtVDD VSS) capacitor c=3.79501e-17
C67 (\11\:VDD VSS) capacitor c=1.90608e-16
Rk19 (PSO1_out \2\:PSO1_out) resistor r=0.2779 c=0
Rk20 (PSO1_out \4\:PSO1_out) resistor r=0.2761 c=0
Rk29 (ExtVDD \12\:ExtVDD) resistor r=0.2032 c=0
Rk30 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.5738 c=0
Rk31 (\14\:ExtVDD \15\:ExtVDD) resistor r=0.5917 c=0
Rk32 (\15\:ExtVDD \16\:ExtVDD) resistor r=0.3575 c=0
Rk33 (\16\:ExtVDD \17\:ExtVDD) resistor r=0.122 c=0
Rk34 (\17\:ExtVDD \19\:ExtVDD) resistor r=0.4259 c=0
Rk48 (\15\:ExtVDD \47\:ExtVDD) resistor r=0.244 c=0
Rk49 (\16\:ExtVDD \49\:ExtVDD) resistor r=0.233 c=0
Rk59 (ExtVDD \62\:ExtVDD) resistor r=0.4763 c=0
Rk60 (\62\:ExtVDD \63\:ExtVDD) resistor r=0.2821 c=0
Rk63 (\63\:ExtVDD \66\:ExtVDD) resistor r=0.1226 c=0
Rk64 (\66\:ExtVDD \68\:ExtVDD) resistor r=0.4894 c=0
Rk75 (\62\:ExtVDD \90\:ExtVDD) resistor r=0.2208 c=0
Rk2 (\5\:PSO1 PSO1) resistor r=0.01431 c=0
Rk113 (\3\:VSS VSS) resistor r=0.2001 c=0
Rk112 (\2\:VSS \3\:VSS) resistor r=1.0018 c=0
Rk114 (VSS \4\:VSS) resistor r=0.3557 c=0
Rk115 (\4\:VSS \5\:VSS) resistor r=0.1799 c=0
Rk118 (\5\:VSS \8\:VSS) resistor r=0.0549 c=0
Rk120 (\9\:VSS VSS) resistor r=0.225 c=0
Rk119 (\8\:VSS \9\:VSS) resistor r=0.1676 c=0
Rk121 (\4\:VSS \11\:VSS) resistor r=0.2253 c=0
Rk125 (\9\:VSS \19\:VSS) resistor r=0.2253 c=0
Rk126 (\21\:VSS VSS) resistor r=1.0516 c=0
Rk127 (VSS \22\:VSS) resistor r=0.1004 c=0
Rk129 (\23\:VSS VSS) resistor r=0.2365 c=0
Rk128 (\22\:VSS \23\:VSS) resistor r=0.6159 c=0
Rk131 (\23\:VSS \26\:VSS) resistor r=0.3103 c=0
Rk132 (VSS \28\:VSS) resistor r=0.3522 c=0
Rk133 (VSS \29\:VSS) resistor r=0.2177 c=0
Rk134 (\29\:VSS \31\:VSS) resistor r=0.3 c=0
Rk135 (\29\:VSS \32\:VSS) resistor r=0.2327 c=0
Rk11 (\2\:PSO2_out PSO2_out) resistor r=0.3878 c=0
Rk12 (PSO2_out \4\:PSO2_out) resistor r=0.02008 c=0
Rk86 (\1\:VDD VDD) resistor r=0.02132 c=0
Rk88 (\11\:VDD VDD) resistor r=0.6207 c=0
Rk87 (VDD \11\:VDD) resistor r=0.3908 c=0
Rk111 (\11\:VDD \57\:VDD) resistor r=0.3589 c=0
Rk3 (\8\:pso2n \9\:pso2n) resistor r=0.165 c=0
Rk4 (\9\:pso2n \11\:pso2n) resistor r=0.3003 c=0
Rk5 (\9\:pso2n \13\:pso2n) resistor r=0.2251 c=0
Rk9 (\4\:n2 \6\:n2) resistor r=0.4947 c=0
Rk10 (\4\:n2 \7\:n2) resistor r=0.1893 c=0
Rk6 (\17\:pso1n \18\:pso1n) resistor r=0.3047 c=0
Rk7 (\18\:pso1n \20\:pso1n) resistor r=0.2202 c=0
Rk8 (\18\:pso1n \21\:pso1n) resistor r=0.1554 c=0
Rk17 (\62\:n1 \70\:n1) resistor r=0.4316 c=0
Rl6 (\2\:ExtVDD \1\:ExtVDD) resistor r=52.7912 c=0
Rl1 (\1\:PSO1 \2\:PSO1) resistor r=80.5599 c=0
Rl3 (\2\:PSO1 \4\:PSO1) resistor r=61.6718 c=0
Rl2 (\2\:PSO1 \3\:PSO1) resistor r=3.1183 c=0
Rl5 (\2\:PSO2 \3\:PSO2) resistor r=72.3229 c=0
Rl4 (\1\:PSO2 \2\:PSO2) resistor r=53.4808 c=0
Rl7 (pso2n \2\:pso2n) resistor r=64.9794 c=0
Rl10 (\2\:pso2n \5\:pso2n) resistor r=58.7731 c=0
Rl11 (\3\:pso2n \6\:pso2n) resistor r=60.3603 c=0
Rl12 (\3\:pso2n \7\:pso2n) resistor r=66.1296 c=0
Rl9 (\3\:pso2n \4\:pso2n) resistor r=8.6686 c=0
Rl8 (\2\:pso2n \3\:pso2n) resistor r=147.121 c=0
Rl13 (n2 \2\:n2) resistor r=516.588 c=0
Rl14 (\2\:pso1n pso1n) resistor r=97.9777 c=0
Rl19 (\2\:pso1n \7\:pso1n) resistor r=67.7766 c=0
Rl15 (\3\:pso1n \2\:pso1n) resistor r=184.691 c=0
Rl41 (n1 \15\:n1) resistor r=286.043 c=0
Rz7 (\1\:PSO1_out \2\:PSO1_out) resistor r=37.5 c=0
Rz9 (\11\:VSS \10\:VSS) resistor r=37.5 c=0
Rz13 (\19\:VSS \18\:VSS) resistor r=37.5 c=0
Rz14 (\26\:VSS \25\:VSS) resistor r=37.5 c=0
Rz15 (\28\:VSS \27\:VSS) resistor r=37.5 c=0
Rz16 (\31\:VSS \30\:VSS) resistor r=37.5 c=0
Rz4 (\3\:PSO2_out \4\:PSO2_out) resistor r=37.5 c=0
Rz1 (\12\:pso2n \13\:pso2n) resistor r=37.5 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=37.5 c=0
Rz2 (\20\:pso1n \19\:pso1n) resistor r=37.5 c=0
Ry7 (\3\:PSO1_out \4\:PSO1_out) resistor r=20.6667 c=0
Ry10 (\14\:ExtVDD \13\:ExtVDD) resistor r=20.6667 c=0
Ry11 (\19\:ExtVDD \18\:ExtVDD) resistor r=20.6667 c=0
Ry24 (\47\:ExtVDD \46\:ExtVDD) resistor r=20.6667 c=0
Ry25 (\49\:ExtVDD \48\:ExtVDD) resistor r=20.6667 c=0
Ry30 (\68\:ExtVDD \67\:ExtVDD) resistor r=20.6667 c=0
Ry41 (\90\:ExtVDD \89\:ExtVDD) resistor r=20.6667 c=0
Ry75 (VSS \20\:VSS) resistor r=12.4 c=0
Ry70 (\2\:VSS \1\:VSS) resistor r=7.75 c=0
Ry71 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry72 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry73 (\21\:VSS \20\:VSS) resistor r=5.6364 c=0
Ry74 (\22\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry76 (\32\:VSS \20\:VSS) resistor r=15.5 c=0
Ry4 (\1\:PSO2_out \2\:PSO2_out) resistor r=20.6667 c=0
Ry69 (\57\:VDD \56\:VDD) resistor r=20.6667 c=0
Ry1 (\10\:pso2n \11\:pso2n) resistor r=20.6667 c=0
Ry3 (\5\:n2 \6\:n2) resistor r=20.6667 c=0
Ry2 (\17\:pso1n \16\:pso1n) resistor r=20.6667 c=0
Rx7 (\17\:ExtVDD \1\:ExtVDD) resistor r=45 c=0
Rx8 (\66\:ExtVDD \2\:ExtVDD) resistor r=45 c=0
Rx2 (\3\:PSO1 \5\:PSO1) resistor r=45 c=0
Rx1 (\2\:PSO2 PSO2) resistor r=45 c=0
Rx3 (\4\:pso2n \8\:pso2n) resistor r=45 c=0
Rx5 (\2\:n2 \7\:n2) resistor r=45 c=0
Rx4 (\21\:pso1n \3\:pso1n) resistor r=22.5 c=0
Rx6 (\70\:n1 \15\:n1) resistor r=22.5 c=0
NM5 (\19\:pso1n \4\:PSO1 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
NM2 (\12\:pso2n \1\:PSO2 \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
NM0 (\62\:n1 \3\:pso1n \5\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=4.5e-14 ps=9.2e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=9.749 scb=0.00848113 \
        scc=0.000308397 m=(4)
NM1 (\3\:n2 \7\:pso2n \27\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.2e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.8283 \
        scb=0.0135012 scc=0.000962877 m=(1)
NM3 (\3\:PSO2_out pso2n \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
NM4 (\1\:PSO1_out \7\:pso1n \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.271 \
        scb=0.00920849 scc=0.00026297 m=(1)
PM7 (\10\:pso2n \3\:PSO2 \18\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=28.2012 \
        scb=0.0315683 scc=0.00281009 m=(1)
PM1 (\62\:n1 \3\:pso1n \63\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=18.5134 \
        scb=0.0151225 scc=0.00171389 m=(4)
PM2 (\5\:n2 \6\:pso2n \48\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.3479 \
        scb=0.0114967 scc=0.000816483 m=(1)
PM5 (\1\:PSO2_out \5\:pso2n \46\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.1375 \
        scb=0.0121086 scc=0.000940231 m=(1)
PM6 (\3\:PSO1_out pso1n \89\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3799 \
        scb=0.0113799 scc=0.000804813 m=(1)
PM0_44__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.065e-14 ad=7.155e-14 ps=1.214e-06 pd=1.218e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=4.07325 \
        scb=0.000378105 scc=2.57733e-07 m=(20)
PM0_41__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.136e-14 ad=7.136e-14 ps=1.21714e-06 pd=1.21714e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n \
        sca=4.07325 scb=0.000378105 scc=2.57733e-07 m=(14)
PM0_20__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n \
        sca=4.07325 scb=0.000378105 scc=2.57733e-07 m=(14)
ends HSWDX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:23:34 2012 )
// Library name: gsclib045
// Cell name: HSWNX1
// View name: extracted

simulator lang=spectre

subckt HSWNX1 ExtVDD PSOn PSOn_out VDD VSS
PM0_76__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=7.125e-14 ps=1.21667e-06 pd=1.21667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=3.86017 \
        scb=0.000251977 scc=7.90668e-08 m=(24)
PM1_1__rcx (\117\:n0 \1\:PSOn ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.2885 \
        scb=0.039105 scc=0.00461576 m=(2)
C1 (PSOn_out VSS) capacitor c=3.8694e-16
C2 (ExtVDD VSS) capacitor c=3.01166e-15
C3 (VDD VSS) capacitor c=2.45724e-16
C4 (PSOn VSS) capacitor c=3.69461e-17
C5 (n0 VSS) capacitor c=1.68328e-15
C6 (\1\:PSOn VSS) capacitor c=1.48374e-16
C7 (\107\:n0 VSS) capacitor c=3.72923e-17
C8 (\117\:n0 VSS) capacitor c=9.10325e-17
C9 (\119\:n0 VSS) capacitor c=7.01374e-17
C10 (VDD VSS) capacitor c=4.33685e-15
C11 (ExtVDD VSS) capacitor c=1.2944e-15
C12 (ExtVDD VSS) capacitor c=2.47951e-15
C13 (\7\:PSOn VSS) capacitor c=3.92267e-17
C14 (\23\:n0 VSS) capacitor c=6.9834e-17
C15 (\24\:n0 VSS) capacitor c=2.72365e-16
C16 (\115\:n0 VSS) capacitor c=7.94877e-17
C17 (\116\:n0 VSS) capacitor c=6.33235e-17
Rk22 (ExtVDD ExtVDD) resistor r=0.3406 c=0
Rk140 (\3\:VSS VSS) resistor r=0.8533 c=0
Rk139 (\2\:VSS \3\:VSS) resistor r=0.7531 c=0
Rk141 (VSS \4\:VSS) resistor r=0.3517 c=0
Rk147 (\5\:VSS VSS) resistor r=0.02215 c=0
Rk142 (\4\:VSS \5\:VSS) resistor r=0.6098 c=0
Rk148 (VSS \10\:VSS) resistor r=0.1634 c=0
Rk153 (\19\:VSS VSS) resistor r=0.04996 c=0
Rk152 (\18\:VSS \19\:VSS) resistor r=1.1548 c=0
Rk157 (\20\:VSS VSS) resistor r=0.02215 c=0
Rk154 (VSS \20\:VSS) resistor r=1.1146 c=0
Rk100 (VDD VDD) resistor r=0.968 c=0
Rk1 (\7\:PSOn PSOn) resistor r=0.03836 c=0
Rk8 (\115\:n0 \116\:n0) resistor r=0.6439 c=0
Rk9 (\116\:n0 \118\:n0) resistor r=0.2962 c=0
Rk10 (\116\:n0 \120\:n0) resistor r=0.2367 c=0
Rl28 (\23\:n0 n0) resistor r=96.583 c=0
Rl112 (\23\:n0 \107\:n0) resistor r=64.081 c=0
Rl29 (\24\:n0 \23\:n0) resistor r=193.783 c=0
Rz3 (\120\:n0 \119\:n0) resistor r=37.5 c=0
Ry93 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry94 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry95 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry97 (\5\:VSS \1\:VSS) resistor r=15.5 c=0
Ry98 (\10\:VSS \1\:VSS) resistor r=15.5 c=0
Ry99 (\18\:VSS \17\:VSS) resistor r=5.6364 c=0
Ry100 (\19\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry101 (\20\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry3 (\118\:n0 \117\:n0) resistor r=20.6667 c=0
Rx1 (\7\:PSOn \1\:PSOn) resistor r=15 c=0
Rx2 (\115\:n0 \107\:n0) resistor r=9 c=0
NM4 (PSOn_out \24\:n0 \5\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.5e-14 ad=4.8e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.78238 scb=0.00700085 \
        scc=0.000201997 m=(4)
NM0_1__rcx (\20\:VSS \1\:PSOn \119\:n0 VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.5e-14 ad=4.5e-14 ps=9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.3599 \
        scb=0.0104786 scc=0.000506541 m=(2)
PM6_2__rcx (PSOn_out \24\:n0 ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=16.2559 \
        scb=0.0139194 scc=0.00128532 m=(4)
PM0_73__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.2e-14 ps=1.22e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=3.86017 \
        scb=0.000251977 scc=7.90668e-08 m=(20)
PM0_68__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.1e-14 ps=1.22e-06 pd=1.21556e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=16.9864 scb=0.0140904 \
        scc=0.00159544 m=(36)
ends HSWNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:24:25 2012 )
// Library name: gsclib045
// Cell name: HSWX1
// View name: extracted

simulator lang=spectre

subckt HSWX1 ExtVDD PSO PSO_out VDD VSS
PM0 (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.1e-14 ad=7.2e-14 ps=1.21556e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.5135 scb=0.0195852 \
        scc=0.00148685 m=(36)
PM2 (\13\:pson \1\:PSO \82\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=40.4286 \
        scb=0.040773 scc=0.00487953 m=(1)
C1 (ExtVDD VSS) capacitor c=3.06086e-15
C2 (PSO_out VSS) capacitor c=2.65288e-17
C3 (VDD VSS) capacitor c=2.41042e-16
C4 (PSO VSS) capacitor c=4.43469e-17
C5 (pson VSS) capacitor c=4.84997e-17
C6 (n0 VSS) capacitor c=1.7841e-15
C7 (\1\:PSO VSS) capacitor c=4.52078e-17
C8 (\6\:pson VSS) capacitor c=1.21273e-16
C9 (\4\:pson VSS) capacitor c=5.12988e-17
C10 (\3\:PSO VSS) capacitor c=3.64683e-17
C11 (\23\:n0 VSS) capacitor c=5.73678e-17
C12 (\2\:PSO VSS) capacitor c=3.72462e-17
C13 (\3\:pson VSS) capacitor c=2.90094e-17
C14 (\3\:PSO_out VSS) capacitor c=9.00113e-17
C15 (\82\:ExtVDD VSS) capacitor c=1.10562e-16
C16 (\104\:n0 VSS) capacitor c=9.65988e-17
C17 (\13\:pson VSS) capacitor c=6.90622e-17
C18 (\1\:PSO_out VSS) capacitor c=7.19417e-17
C19 (\106\:n0 VSS) capacitor c=6.82536e-17
C20 (\16\:pson VSS) capacitor c=6.92389e-17
C21 (\11\:pson VSS) capacitor c=1.30616e-17
C22 (\2\:pson VSS) capacitor c=4.25303e-17
C23 (\5\:pson VSS) capacitor c=3.0819e-17
C24 (VDD VSS) capacitor c=4.28984e-15
C25 (ExtVDD VSS) capacitor c=5.05846e-16
C26 (ExtVDD VSS) capacitor c=2.75355e-15
C27 (\15\:pson VSS) capacitor c=4.01871e-17
C28 (\7\:PSO VSS) capacitor c=3.11443e-17
C29 (\102\:n0 VSS) capacitor c=6.29955e-17
C30 (\103\:n0 VSS) capacitor c=3.06215e-17
C31 (\19\:ExtVDD VSS) capacitor c=1.71766e-16
Rk21 (ExtVDD ExtVDD) resistor r=0.1153 c=0
Rk27 (ExtVDD \19\:ExtVDD) resistor r=0.1456 c=0
Rk65 (ExtVDD \83\:ExtVDD) resistor r=0.5915 c=0
Rk139 (\3\:VSS VSS) resistor r=0.04994 c=0
Rk138 (\2\:VSS \3\:VSS) resistor r=1.1544 c=0
Rk141 (\4\:VSS VSS) resistor r=0.02992 c=0
Rk140 (VSS \4\:VSS) resistor r=1.1546 c=0
Rk146 (\12\:VSS VSS) resistor r=0.04994 c=0
Rk145 (\11\:VSS \12\:VSS) resistor r=1.1544 c=0
Rk147 (VSS \13\:VSS) resistor r=1.1546 c=0
Rk149 (\14\:VSS VSS) resistor r=0.125 c=0
Rk148 (\13\:VSS \14\:VSS) resistor r=0.1303 c=0
Rk150 (\14\:VSS \16\:VSS) resistor r=0.2743 c=0
Rk8 (PSO_out \2\:PSO_out) resistor r=0.07766 c=0
Rk9 (\2\:PSO_out \4\:PSO_out) resistor r=0.5387 c=0
Rk99 (VDD VDD) resistor r=0.6117 c=0
Rk3 (\4\:PSO PSO) resistor r=0.003499 c=0
Rk4 (\5\:PSO PSO) resistor r=0.003499 c=0
Rk5 (\4\:PSO \5\:PSO) resistor r=0.01452 c=0
Rk7 (\5\:PSO \7\:PSO) resistor r=0.01694 c=0
Rk6 (\6\:PSO \7\:PSO) resistor r=0.003332 c=0
Rk1 (\14\:pson \15\:pson) resistor r=0.2805 c=0
Rk2 (\14\:pson \17\:pson) resistor r=0.5341 c=0
Rk10 (\102\:n0 \103\:n0) resistor r=0.3552 c=0
Rk11 (\103\:n0 \105\:n0) resistor r=0.32 c=0
Rk12 (\103\:n0 \107\:n0) resistor r=0.2103 c=0
Rl1 (\1\:PSO \2\:PSO) resistor r=62.6365 c=0
Rl2 (\2\:PSO \3\:PSO) resistor r=58.7903 c=0
Rl5 (\4\:pson pson) resistor r=153.846 c=0
Rl12 (\11\:pson \6\:pson) resistor r=39.7092 c=0
Rl3 (\2\:pson pson) resistor r=93.5977 c=0
Rl4 (\2\:pson \3\:pson) resistor r=63.5319 c=0
Rl7 (\5\:pson \6\:pson) resistor r=57.3013 c=0
Rl14 (\5\:pson \11\:pson) resistor r=15.1758 c=0
Rl6 (\5\:pson \2\:pson) resistor r=132.706 c=0
Rl37 (n0 \23\:n0) resistor r=247.291 c=0
Rz10 (\16\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\1\:PSO_out \2\:PSO_out) resistor r=37.5 c=0
Rz1 (\17\:pson \16\:pson) resistor r=37.5 c=0
Rz3 (\107\:n0 \106\:n0) resistor r=37.5 c=0
Ry30 (\83\:ExtVDD \82\:ExtVDD) resistor r=20.6667 c=0
Ry91 (\2\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry92 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry93 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry94 (\11\:VSS \10\:VSS) resistor r=5.6364 c=0
Ry95 (\12\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry96 (\13\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry2 (\3\:PSO_out \4\:PSO_out) resistor r=20.6667 c=0
Ry1 (\14\:pson \13\:pson) resistor r=20.6667 c=0
Ry3 (\105\:n0 \104\:n0) resistor r=20.6667 c=0
Rx2 (\2\:PSO \6\:PSO) resistor r=45 c=0
Rx1 (\15\:pson \3\:pson) resistor r=45 c=0
Rx3 (\102\:n0 \23\:n0) resistor r=15 c=0
NM2 (\15\:VSS \3\:PSO \16\:pson VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.22468 \
        scb=0.0071987 scc=0.000180033 m=(1)
NM0 (VSS \6\:pson \106\:n0 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.6172 \
        scb=0.0114252 scc=0.000508261 m=(2)
NM4 (\1\:PSO_out \4\:pson \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1772 \
        scb=0.00801794 scc=0.000181716 m=(1)
PM1 (\104\:n0 \6\:pson \19\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.5241 \
        scb=0.0206307 scc=0.00192213 m=(2)
PM6 (\3\:PSO_out pson \82\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=26.2769 \
        scb=0.0231127 scc=0.00250765 m=(1)
PM0_30__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.2e-14 ps=1.22e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=3.55421 \
        scb=0.000138381 scc=9.64541e-09 m=(8)
PM0_44__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.1e-14 ad=7.2e-14 ps=1.21556e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78e-06 sd=160n sca=8.16604 \
        scb=0.00609017 scc=0.000206552 m=(36)
ends HSWX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:25:14 2012 )
// Library name: gsclib045
// Cell name: ISOHLDX1_OFF
// View name: extracted

simulator lang=spectre

subckt ISOHLDX1_OFF D ExtVDD ISO Q VDD VSS
mp10 (\9\:Qint \3\:n0 \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.06732 \
        scb=0.00478236 scc=5.37757e-05 m=(1)
C1 (VDD VSS) capacitor c=2.15254e-16
C2 (ISO VSS) capacitor c=2.34743e-17
C3 (D VSS) capacitor c=3.30725e-18
C4 (ExtVDD VSS) capacitor c=3.75175e-16
C5 (Q VSS) capacitor c=2.11001e-17
C6 (Qint VSS) capacitor c=6.26981e-17
C7 (n0 VSS) capacitor c=2.64569e-17
C8 (GNbb VSS) capacitor c=7.9914e-17
C9 (Qbint VSS) capacitor c=3.314e-17
C10 (GNb VSS) capacitor c=9.63083e-17
C11 (\3\:Qbint VSS) capacitor c=4.3306e-17
C12 (\1\:D VSS) capacitor c=6.68534e-17
C13 (\8\:Qint VSS) capacitor c=6.1435e-17
C14 (\5\:GNb VSS) capacitor c=1.0901e-16
C15 (\4\:GNb VSS) capacitor c=7.903e-17
C16 (\4\:Qint VSS) capacitor c=7.49526e-17
C17 (\1\:ISO VSS) capacitor c=4.25182e-17
C18 (\3\:n0 VSS) capacitor c=3.18646e-17
C19 (\3\:D VSS) capacitor c=5.47027e-17
C20 (\5\:Qint VSS) capacitor c=3.78299e-17
C21 (\3\:GNbb VSS) capacitor c=2.33529e-16
C22 (\3\:GNb VSS) capacitor c=2.60544e-17
C23 (\4\:ISO VSS) capacitor c=4.24677e-17
C24 (\2\:D VSS) capacitor c=5.27613e-17
C25 (\2\:Qbint VSS) capacitor c=4.05388e-17
C26 (\2\:GNbb VSS) capacitor c=1.70584e-16
C27 (\6\:n0 VSS) capacitor c=9.68848e-17
C28 (\5\:n0 VSS) capacitor c=9.62813e-17
C29 (\7\:Qint VSS) capacitor c=5.46151e-17
C30 (\2\:GNb VSS) capacitor c=7.89954e-17
C31 (\2\:Qint VSS) capacitor c=7.60215e-17
C32 (\2\:n0 VSS) capacitor c=3.147e-17
C33 (\4\:n0 VSS) capacitor c=3.34367e-17
C34 (\3\:Qint VSS) capacitor c=2.76694e-17
C35 (\1\:ExtVDD VSS) capacitor c=1.0357e-17
C36 (\2\:ExtVDD VSS) capacitor c=1.07465e-17
C37 (\3\:ISO VSS) capacitor c=2.6015e-17
C38 (\2\:Q VSS) capacitor c=4.98182e-17
C39 (\11\:ExtVDD VSS) capacitor c=9.65454e-17
C40 (\3\:ExtVDD VSS) capacitor c=1.64789e-16
C41 (\17\:n0 VSS) capacitor c=8.61026e-17
C42 (\6\:Qbint VSS) capacitor c=8.47478e-17
C43 (\13\:n0 VSS) capacitor c=3.87679e-17
C44 (\4\:GNbb VSS) capacitor c=6.24274e-17
C45 (\15\:ExtVDD VSS) capacitor c=5.3321e-17
C46 (\9\:ExtVDD VSS) capacitor c=4.11271e-17
C47 (\10\:GNb VSS) capacitor c=4.76774e-17
C48 (\9\:Qint VSS) capacitor c=6.29706e-17
C49 (\4\:Q VSS) capacitor c=4.3056e-17
C50 (\15\:n0 VSS) capacitor c=7.98742e-17
C51 (\8\:Qbint VSS) capacitor c=4.51732e-17
C52 (\7\:n0 VSS) capacitor c=2.35563e-17
C53 (\7\:GNbb VSS) capacitor c=7.1007e-17
C54 (\8\:GNb VSS) capacitor c=2.64431e-17
C55 (\12\:Qint VSS) capacitor c=4.67015e-17
C56 (ExtVDD VSS) capacitor c=4.32285e-17
C57 (\2\:ISO VSS) capacitor c=4.51571e-17
C58 (VDD VSS) capacitor c=3.36826e-16
C59 (\6\:Qint VSS) capacitor c=5.10475e-17
C60 (\5\:ISO VSS) capacitor c=1.98295e-17
C61 (\11\:Qint VSS) capacitor c=6.49894e-17
C62 (\6\:GNb VSS) capacitor c=2.13963e-17
C63 (\7\:GNb VSS) capacitor c=4.24553e-17
C64 (\14\:Qint VSS) capacitor c=5.62774e-17
C65 (\15\:Qint VSS) capacitor c=5.11953e-17
C66 (\9\:n0 VSS) capacitor c=1.06058e-16
C67 (\10\:n0 VSS) capacitor c=6.80734e-17
C68 (\11\:n0 VSS) capacitor c=4.62558e-17
C69 (\12\:n0 VSS) capacitor c=6.42384e-17
C70 (\6\:GNbb VSS) capacitor c=7.83962e-17
C71 (\19\:n0 VSS) capacitor c=4.7189e-17
C72 (\5\:ExtVDD VSS) capacitor c=1.249e-16
C73 (\6\:ExtVDD VSS) capacitor c=6.79658e-17
C74 (\4\:Qbint VSS) capacitor c=3.97851e-17
C75 (\5\:Qbint VSS) capacitor c=3.70431e-17
C76 (\13\:ExtVDD VSS) capacitor c=1.31109e-16
C77 (\14\:ExtVDD VSS) capacitor c=3.79995e-17
C78 (\4\:D VSS) capacitor c=2.6587e-17
C79 (\7\:D VSS) capacitor c=1.73667e-17
C80 (\1\:Q VSS) capacitor c=4.1449e-17
Rk48 (VSS VSS) resistor r=0.1315 c=0
Rk41 (\4\:VSS VSS) resistor r=0.4053 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.2955 c=0
Rk43 (\5\:VSS VSS) resistor r=0.05837 c=0
Rk42 (VSS \5\:VSS) resistor r=0.07233 c=0
Rk44 (VSS \6\:VSS) resistor r=0.3457 c=0
Rk45 (\5\:VSS \8\:VSS) resistor r=0.2443 c=0
Rk47 (\11\:VSS VSS) resistor r=0.3757 c=0
Rk46 (\10\:VSS \11\:VSS) resistor r=0.2252 c=0
Rk49 (VSS \12\:VSS) resistor r=0.1499 c=0
Rk50 (\11\:VSS \14\:VSS) resistor r=0.2532 c=0
Rk51 (VSS \16\:VSS) resistor r=0.3116 c=0
Rk52 (VDD VDD) resistor r=0.1825 c=0
Rk2 (\5\:ISO ISO) resistor r=0.01078 c=0
Rk1 (\5\:ISO \6\:ISO) resistor r=0.005784 c=0
Rk32 (\4\:D D) resistor r=0.005569 c=0
Rk33 (\5\:D D) resistor r=0.004796 c=0
Rk34 (\4\:D \5\:D) resistor r=0.01567 c=0
Rk36 (\5\:D \7\:D) resistor r=0.01791 c=0
Rk35 (\6\:D \7\:D) resistor r=0.005415 c=0
Rk24 (ExtVDD ExtVDD) resistor r=0.05871 c=0
Rk20 (\4\:ExtVDD \5\:ExtVDD) resistor r=1.009 c=0
Rk22 (\6\:ExtVDD ExtVDD) resistor r=0.6097 c=0
Rk21 (\5\:ExtVDD \6\:ExtVDD) resistor r=0.2428 c=0
Rk25 (\5\:ExtVDD \10\:ExtVDD) resistor r=0.195 c=0
Rk29 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.9962 c=0
Rk30 (\13\:ExtVDD \14\:ExtVDD) resistor r=0.3188 c=0
Rk31 (\13\:ExtVDD \16\:ExtVDD) resistor r=0.2012 c=0
Rk37 (Q \1\:Q) resistor r=0.05749 c=0
Rk38 (\1\:Q \3\:Q) resistor r=0.2148 c=0
Rk39 (\1\:Q \5\:Q) resistor r=0.3212 c=0
Rk5 (\10\:Qint \11\:Qint) resistor r=0.3479 c=0
Rk6 (\11\:Qint \13\:Qint) resistor r=0.2772 c=0
Rk10 (\14\:Qint \15\:Qint) resistor r=0.2335 c=0
Rk11 (\8\:n0 \9\:n0) resistor r=0.1166 c=0
Rk12 (\9\:n0 \10\:n0) resistor r=0.2977 c=0
Rk13 (\10\:n0 \11\:n0) resistor r=0.2581 c=0
Rk14 (\9\:n0 \12\:n0) resistor r=0.6381 c=0
Rk15 (\12\:n0 \14\:n0) resistor r=0.1712 c=0
Rk18 (\16\:n0 \18\:n0) resistor r=0.5626 c=0
Rk19 (\18\:n0 \19\:n0) resistor r=0.236 c=0
Rk16 (\5\:GNbb \6\:GNbb) resistor r=0.4153 c=0
Rk17 (\6\:GNbb \8\:GNbb) resistor r=0.5498 c=0
Rk26 (\4\:Qbint \5\:Qbint) resistor r=0.1531 c=0
Rk27 (\5\:Qbint \7\:Qbint) resistor r=0.3602 c=0
Rk28 (\5\:Qbint \9\:Qbint) resistor r=0.2124 c=0
Rk7 (\6\:GNb \7\:GNb) resistor r=0.1628 c=0
Rk8 (\7\:GNb \9\:GNb) resistor r=0.1798 c=0
Rk9 (\7\:GNb \11\:GNb) resistor r=0.3665 c=0
Rl4 (\1\:ISO \2\:ISO) resistor r=96.7539 c=0
Rl6 (\2\:ISO \4\:ISO) resistor r=118.913 c=0
Rl5 (\2\:ISO \3\:ISO) resistor r=111.027 c=0
Rl22 (\1\:D \2\:D) resistor r=111.527 c=0
Rl23 (\2\:D \3\:D) resistor r=89.3683 c=0
Rl1 (\1\:ExtVDD \2\:ExtVDD) resistor r=111.507 c=0
Rl7 (Qint \2\:Qint) resistor r=95.2927 c=0
Rl9 (\2\:Qint \4\:Qint) resistor r=102.111 c=0
Rl8 (\2\:Qint \3\:Qint) resistor r=88.5327 c=0
Rl13 (\6\:Qint \8\:Qint) resistor r=79.7084 c=0
Rl11 (\5\:Qint \6\:Qint) resistor r=76.2993 c=0
Rl12 (\6\:Qint \7\:Qint) resistor r=151.936 c=0
Rl10 (\5\:n0 \6\:n0) resistor r=348.872 c=0
Rl2 (n0 \2\:n0) resistor r=34.5953 c=0
Rl3 (\3\:n0 \4\:n0) resistor r=42.2876 c=0
Rl14 (GNbb \2\:GNbb) resistor r=157.41 c=0
Rl15 (\2\:GNbb \3\:GNbb) resistor r=831.867 c=0
Rl20 (Qbint \2\:Qbint) resistor r=45.3288 c=0
Rl21 (\2\:Qbint \3\:Qbint) resistor r=86.0157 c=0
Rl19 (\4\:GNb \5\:GNb) resistor r=288.747 c=0
Rl16 (GNb \2\:GNb) resistor r=327.66 c=0
Rl18 (\2\:GNb \4\:GNb) resistor r=138.8 c=0
Rl17 (\2\:GNb \3\:GNb) resistor r=55.2084 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz12 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz8 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz1 (\12\:Qint \13\:Qint) resistor r=75 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz5 (\15\:n0 \16\:n0) resistor r=75 c=0
Rz4 (\7\:GNbb \8\:GNbb) resistor r=75 c=0
Rz7 (\8\:Qbint \9\:Qbint) resistor r=37.5 c=0
Rz2 (\8\:GNb \9\:GNb) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry13 (\3\:VSS \6\:VSS) resistor r=7.75 c=0
Ry14 (\9\:VSS \10\:VSS) resistor r=10.3333 c=0
Ry15 (\9\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry6 (\3\:ExtVDD \4\:ExtVDD) resistor r=20.6667 c=0
Ry7 (\9\:ExtVDD \10\:ExtVDD) resistor r=62 c=0
Ry9 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry10 (\15\:ExtVDD \16\:ExtVDD) resistor r=62 c=0
Ry11 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry1 (\9\:Qint \10\:Qint) resistor r=62 c=0
Ry3 (\13\:n0 \14\:n0) resistor r=62 c=0
Ry5 (\17\:n0 \18\:n0) resistor r=62 c=0
Ry4 (\4\:GNbb \5\:GNbb) resistor r=62 c=0
Ry8 (\6\:Qbint \7\:Qbint) resistor r=20.6667 c=0
Ry2 (\10\:GNb \11\:GNb) resistor r=62 c=0
Rx1 (\3\:ISO \6\:ISO) resistor r=45 c=0
Rx14 (\2\:D \6\:D) resistor r=45 c=0
Rx11 (\1\:ExtVDD \6\:ExtVDD) resistor r=45 c=0
Rx13 (\2\:ExtVDD \14\:ExtVDD) resistor r=45 c=0
Rx2 (\3\:Qint \11\:Qint) resistor r=45 c=0
Rx4 (\7\:Qint \14\:Qint) resistor r=45 c=0
Rx5 (\2\:Qint \15\:Qint) resistor r=45 c=0
Rx6 (\2\:n0 \10\:n0) resistor r=45 c=0
Rx7 (\4\:n0 \11\:n0) resistor r=45 c=0
Rx8 (\5\:n0 \12\:n0) resistor r=45 c=0
Rx10 (\6\:n0 \19\:n0) resistor r=45 c=0
Rx9 (\2\:GNbb \6\:GNbb) resistor r=45 c=0
Rx12 (\2\:Qbint \4\:Qbint) resistor r=45 c=0
Rx3 (\2\:GNb \6\:GNb) resistor r=45 c=0
mn10 (\12\:Qint n0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn0 (\8\:GNb \4\:ISO \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn15 (net245 Qint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\7\:GNbb \3\:GNb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn16 (\7\:n0 \3\:GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\8\:Qbint \5\:Qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn6 (\15\:n0 GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn5 (net257 \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn21 (\4\:Q Qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mp0 (\10\:GNb \1\:ISO \15\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.562 \
        scb=0.00932696 scc=0.000301954 m=(1)
mp15 (net212 \4\:Qint \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=7.3911 \
        scb=0.00444086 scc=5.3555e-05 m=(1)
mp1 (\4\:GNbb \4\:GNb \15\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1581 \
        scb=0.00920136 scc=0.000301923 m=(1)
mp16 (\13\:n0 \5\:GNb net212 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=7.25669 \
        scb=0.00441124 scc=5.35516e-05 m=(1)
mp20 (\6\:Qbint \8\:Qint \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2584 \
        scb=0.0109338 scc=0.000327977 m=(1)
mp6 (\17\:n0 GNbb net220 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.362 \
        scb=0.0146821 scc=0.000335334 m=(1)
mp5 (net220 \1\:D \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.9016 \
        scb=0.0220066 scc=0.000851274 m=(1)
mp21 (\2\:Q \3\:Qbint \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=19.6538 \
        scb=0.0228433 scc=0.00109838 m=(1)
ends ISOHLDX1_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:26:01 2012 )
// Library name: gsclib045
// Cell name: ISOHX1_ON
// View name: extracted

simulator lang=spectre

subckt ISOHX1_ON A ISO VDD VSS Y
mp0 (n1 \3\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=17.4272 \
        scb=0.0179257 scc=0.000390864 m=(1)
C1 (VDD VSS) capacitor c=8.31332e-17
C2 (Y VSS) capacitor c=6.38547e-17
C3 (A VSS) capacitor c=4.47293e-17
C4 (ISO VSS) capacitor c=5.26595e-17
C5 (n0 VSS) capacitor c=3.78722e-17
C6 (\3\:ISO VSS) capacitor c=5.8064e-17
C7 (\3\:A VSS) capacitor c=7.65357e-17
C8 (\3\:n0 VSS) capacitor c=4.47641e-17
C9 (\1\:ISO VSS) capacitor c=5.86812e-17
C10 (\1\:A VSS) capacitor c=4.08935e-17
C11 (\2\:n0 VSS) capacitor c=3.13449e-17
C12 (\4\:ISO VSS) capacitor c=8.59707e-17
C13 (\2\:A VSS) capacitor c=6.85275e-17
C14 (\4\:Y VSS) capacitor c=3.27477e-17
C15 (\1\:VDD VSS) capacitor c=1.03828e-16
C16 (\6\:n0 VSS) capacitor c=8.17501e-17
C17 (\6\:VDD VSS) capacitor c=2.64794e-17
C18 (\3\:VDD VSS) capacitor c=7.58858e-19
C19 (\2\:Y VSS) capacitor c=5.03602e-17
C20 (\8\:n0 VSS) capacitor c=7.14362e-17
C21 (\4\:n0 VSS) capacitor c=3.19173e-17
C22 (\5\:n0 VSS) capacitor c=6.9275e-17
C23 (\1\:Y VSS) capacitor c=1.88029e-17
C24 (\5\:VDD VSS) capacitor c=1.95128e-17
Rk13 (VDD VDD) resistor r=0.04493 c=0
Rk12 (\4\:VDD VDD) resistor r=0.004743 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.3787 c=0
Rk14 (VDD \5\:VDD) resistor r=0.1973 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.2836 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.05222 c=0
Rk7 (Y \1\:Y) resistor r=0.01335 c=0
Rk9 (Y \3\:Y) resistor r=0.3142 c=0
Rk10 (\1\:Y \5\:Y) resistor r=0.1452 c=0
Rk2 (\4\:A A) resistor r=0.004654 c=0
Rk19 (VSS VSS) resistor r=0.01248 c=0
Rk18 (\4\:VSS VSS) resistor r=0.1002 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.2827 c=0
Rk20 (VSS \5\:VSS) resistor r=0.1299 c=0
Rk21 (\5\:VSS \6\:VSS) resistor r=0.05722 c=0
Rk22 (\5\:VSS \8\:VSS) resistor r=0.2331 c=0
Rk3 (ISO \5\:ISO) resistor r=0.002412 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.1025 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.3941 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.3877 c=0
Rl2 (\2\:A \3\:A) resistor r=153.685 c=0
Rl1 (\1\:A \2\:A) resistor r=89.8433 c=0
Rl4 (\2\:ISO \3\:ISO) resistor r=95.9008 c=0
Rl3 (\1\:ISO \2\:ISO) resistor r=196.188 c=0
Rl5 (\2\:ISO \4\:ISO) resistor r=0.6051 c=0
Rl6 (n0 \2\:n0) resistor r=58.6969 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=101.357 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz4 (\3\:VDD \8\:VDD) resistor r=75 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\4\:ISO \5\:ISO) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:n0 \1\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn1 (\8\:n0 \1\:ISO \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.75e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (\2\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.365e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.85385e-07 sb=1.4e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mp1 (\6\:n0 \3\:ISO n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=14.7748 \
        scb=0.0128938 scc=0.000187084 m=(1)
mp2 (\4\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.5723 \
        scb=0.0189272 scc=0.00068777 m=(1)
ends ISOHX1_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:26:45 2012 )
// Library name: gsclib045
// Cell name: ISOLX1_ON
// View name: extracted

simulator lang=spectre

subckt ISOLX1_ON A ISO VDD VSS Y
PM1 (\8\:ison \1\:ISO \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=20.0013 \
        scb=0.0219001 scc=0.000764007 m=(1)
C1 (ISO VSS) capacitor c=2.25055e-17
C2 (Y VSS) capacitor c=1.61876e-17
C3 (A VSS) capacitor c=5.89268e-17
C4 (VDD VSS) capacitor c=1.09486e-16
C5 (ison VSS) capacitor c=5.55444e-17
C6 (n0 VSS) capacitor c=4.26565e-17
C7 (\4\:A VSS) capacitor c=3.76437e-17
C8 (\1\:ISO VSS) capacitor c=4.98263e-17
C9 (\4\:n0 VSS) capacitor c=5.00825e-17
C10 (\3\:ison VSS) capacitor c=6.44757e-17
C11 (\1\:A VSS) capacitor c=8.1021e-17
C12 (\4\:ISO VSS) capacitor c=3.12891e-17
C13 (\3\:n0 VSS) capacitor c=1.72416e-17
C14 (\2\:ison VSS) capacitor c=8.04201e-17
C15 (\3\:A VSS) capacitor c=1.56668e-17
C16 (\3\:ISO VSS) capacitor c=1.64537e-17
C17 (\4\:Y VSS) capacitor c=4.90926e-17
C18 (\9\:VDD VSS) capacitor c=7.65461e-17
C19 (\5\:n0 VSS) capacitor c=7.0277e-17
C20 (\11\:VDD VSS) capacitor c=4.52305e-17
C21 (\8\:ison VSS) capacitor c=6.70895e-17
C22 (\7\:VDD VSS) capacitor c=2.9205e-17
C23 (\1\:VDD VSS) capacitor c=5.18885e-17
C24 (\2\:Y VSS) capacitor c=4.76602e-17
C25 (\8\:n0 VSS) capacitor c=8.79953e-17
C26 (\6\:ison VSS) capacitor c=4.58734e-17
C27 (\2\:ISO VSS) capacitor c=3.86685e-17
C28 (\2\:A VSS) capacitor c=4.77365e-17
C29 (\2\:n0 VSS) capacitor c=2.97591e-17
C30 (\5\:ISO VSS) capacitor c=3.79466e-17
C31 (\7\:A VSS) capacitor c=4.23264e-17
C32 (\4\:ison VSS) capacitor c=7.37181e-17
C33 (\5\:ison VSS) capacitor c=9.64092e-17
C34 (\7\:n0 VSS) capacitor c=1.37216e-16
C35 (\1\:Y VSS) capacitor c=6.21062e-17
C36 (\3\:VDD VSS) capacitor c=1.85195e-18
C37 (\5\:VDD VSS) capacitor c=3.41714e-18
Rk25 (VSS VSS) resistor r=0.02257 c=0
Rk24 (\3\:VSS VSS) resistor r=0.1475 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.08007 c=0
Rk26 (VSS \4\:VSS) resistor r=0.1006 c=0
Rk27 (\4\:VSS \6\:VSS) resistor r=0.3722 c=0
Rk28 (\3\:VSS \8\:VSS) resistor r=0.2343 c=0
Rk1 (ISO \5\:ISO) resistor r=0.01958 c=0
Rk11 (Y \1\:Y) resistor r=0.01258 c=0
Rk12 (\1\:Y \3\:Y) resistor r=0.3657 c=0
Rk13 (\1\:Y \5\:Y) resistor r=0.307 c=0
Rk5 (A \7\:A) resistor r=0.02394 c=0
Rk4 (\6\:A \7\:A) resistor r=0.00958 c=0
Rk15 (\3\:VDD VDD) resistor r=0.1074 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.08007 c=0
Rk16 (VDD \4\:VDD) resistor r=0.01279 c=0
Rk17 (\4\:VDD VDD) resistor r=0.04991 c=0
Rk18 (VDD \5\:VDD) resistor r=0.05022 c=0
Rk19 (\5\:VDD \6\:VDD) resistor r=0.1503 c=0
Rk20 (\6\:VDD \8\:VDD) resistor r=0.2942 c=0
Rk21 (\3\:VDD \10\:VDD) resistor r=0.2911 c=0
Rk22 (\5\:VDD \12\:VDD) resistor r=0.2157 c=0
Rk6 (\4\:ison \5\:ison) resistor r=0.3639 c=0
Rk7 (\5\:ison \7\:ison) resistor r=0.322 c=0
Rk8 (\5\:ison \9\:ison) resistor r=0.4231 c=0
Rk9 (\6\:n0 \7\:n0) resistor r=0.4908 c=0
Rk10 (\7\:n0 \9\:n0) resistor r=0.6663 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=207.409 c=0
Rl3 (\2\:ISO \4\:ISO) resistor r=94.9085 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl6 (\2\:A \4\:A) resistor r=94.4277 c=0
Rl4 (\1\:A \2\:A) resistor r=204.756 c=0
Rl5 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl7 (ison \2\:ison) resistor r=170.329 c=0
Rl8 (\2\:ison \3\:ison) resistor r=114.56 c=0
Rl9 (n0 \2\:n0) resistor r=45.1626 c=0
Rl11 (\2\:n0 \4\:n0) resistor r=158.537 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=1.2666 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz3 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz6 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz1 (\6\:ison \7\:ison) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry3 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\8\:ison \9\:ison) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx3 (\2\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \7\:n0) resistor r=45 c=0
NM1 (\5\:VSS \4\:ISO \6\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\8\:n0 \1\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn0 (net127 \3\:ison \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=8.7e-15 ps=9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn2 (\2\:Y \4\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.29615e-07 sb=1.4e-07 sd=160n sca=7.96722 scb=0.00567143 \
        scc=0.000107411 m=(1)
mp0 (\5\:n0 \4\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=11.8775 \
        scb=0.00838325 scc=9.33327e-05 m=(1)
mp1 (\5\:n0 ison \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.75e-07 sd=160n sca=12.762 \
        scb=0.00989291 scc=0.000101967 m=(1)
mp2 (\4\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.82564e-07 sb=1.4e-07 sd=160n sca=20.4693 \
        scb=0.0229089 scc=0.000811692 m=(1)
ends ISOLX1_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:27:35 2012 )
// Library name: gsclib045
// Cell name: ISONLX1_ON
// View name: extracted

simulator lang=spectre

subckt ISONLX1_ON A ISOn VDD VSS Y
mp1 (\6\:n0 \4\:ISOn \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.442 \
        scb=0.0195131 scc=0.00052448 m=(1)
C1 (VDD VSS) capacitor c=8.59345e-17
C2 (Y VSS) capacitor c=1.8098e-17
C3 (n0 VSS) capacitor c=4.68786e-17
C4 (\4\:A VSS) capacitor c=4.07149e-17
C5 (\4\:ISOn VSS) capacitor c=5.56152e-17
C6 (\3\:n0 VSS) capacitor c=2.83168e-17
C7 (\3\:A VSS) capacitor c=6.74632e-17
C8 (\1\:ISOn VSS) capacitor c=6.54775e-17
C9 (\2\:n0 VSS) capacitor c=3.03196e-17
C10 (\1\:A VSS) capacitor c=1.53915e-17
C11 (\3\:ISOn VSS) capacitor c=1.19539e-17
C12 (\4\:Y VSS) capacitor c=3.27176e-17
C13 (\8\:VDD VSS) capacitor c=5.16654e-17
C14 (\10\:VDD VSS) capacitor c=3.09973e-17
C15 (\6\:n0 VSS) capacitor c=7.45083e-17
C16 (\12\:VDD VSS) capacitor c=2.89264e-17
C17 (\1\:VDD VSS) capacitor c=3.29546e-17
C18 (\2\:Y VSS) capacitor c=6.65698e-17
C19 (\8\:n0 VSS) capacitor c=4.25045e-17
C20 (\2\:ISOn VSS) capacitor c=5.61053e-17
C21 (VDD VSS) capacitor c=1.30292e-18
C22 (\2\:A VSS) capacitor c=5.08772e-17
C23 (\5\:ISOn VSS) capacitor c=1.87889e-17
C24 (\6\:ISOn VSS) capacitor c=3.48269e-18
C25 (\7\:ISOn VSS) capacitor c=2.90504e-17
C26 (\5\:A VSS) capacitor c=3.57637e-17
C27 (\7\:A VSS) capacitor c=1.08192e-17
C28 (\8\:A VSS) capacitor c=2.99988e-17
C29 (\4\:n0 VSS) capacitor c=4.28728e-17
C30 (\5\:n0 VSS) capacitor c=1.03755e-16
C31 (\1\:Y VSS) capacitor c=4.24673e-17
C32 (\3\:VDD VSS) capacitor c=1.79024e-18
C33 (\6\:VDD VSS) capacitor c=1.44952e-18
Rk18 (\3\:VDD VDD) resistor r=0.04467 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.09004 c=0
Rk19 (VDD \4\:VDD) resistor r=0.01529 c=0
Rk20 (\4\:VDD VDD) resistor r=0.04998 c=0
Rk21 (VDD \5\:VDD) resistor r=0.101 c=0
Rk22 (\5\:VDD \6\:VDD) resistor r=0.1151 c=0
Rk23 (\6\:VDD \7\:VDD) resistor r=0.0349 c=0
Rk24 (\3\:VDD \9\:VDD) resistor r=0.2979 c=0
Rk25 (VDD \11\:VDD) resistor r=0.2749 c=0
Rk26 (\6\:VDD \13\:VDD) resistor r=0.2211 c=0
Rk1 (ISOn \5\:ISOn) resistor r=0.005145 c=0
Rk2 (ISOn \6\:ISOn) resistor r=0.002205 c=0
Rk3 (\5\:ISOn \6\:ISOn) resistor r=0.01642 c=0
Rk5 (\6\:ISOn \7\:ISOn) resistor r=0.01816 c=0
Rk4 (\7\:ISOn \8\:ISOn) resistor r=0.005145 c=0
Rk14 (Y \1\:Y) resistor r=0.02098 c=0
Rk15 (\1\:Y \3\:Y) resistor r=0.4671 c=0
Rk16 (\1\:Y \5\:Y) resistor r=0.1861 c=0
Rk29 (VSS VSS) resistor r=0.04011 c=0
Rk28 (\3\:VSS VSS) resistor r=0.06974 c=0
Rk27 (\2\:VSS \3\:VSS) resistor r=0.09004 c=0
Rk30 (VSS \4\:VSS) resistor r=0.1005 c=0
Rk31 (\4\:VSS \6\:VSS) resistor r=0.2665 c=0
Rk32 (\3\:VSS \8\:VSS) resistor r=0.2434 c=0
Rk6 (\5\:A \6\:A) resistor r=0.004889 c=0
Rk7 (A \7\:A) resistor r=0.001833 c=0
Rk8 (\5\:A \7\:A) resistor r=0.02582 c=0
Rk9 (A \8\:A) resistor r=0.004889 c=0
Rk10 (\7\:A \8\:A) resistor r=0.02381 c=0
Rk11 (\4\:n0 \5\:n0) resistor r=0.223 c=0
Rk12 (\5\:n0 \7\:n0) resistor r=0.6469 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.2085 c=0
Rl3 (\2\:ISOn \4\:ISOn) resistor r=188.659 c=0
Rl1 (\1\:ISOn \2\:ISOn) resistor r=123.156 c=0
Rl2 (\2\:ISOn \3\:ISOn) resistor r=5.1123 c=0
Rl6 (\2\:A \4\:A) resistor r=122.181 c=0
Rl5 (\2\:A \3\:A) resistor r=173.318 c=0
Rl4 (\1\:A \2\:A) resistor r=5.1171 c=0
Rl7 (n0 \2\:n0) resistor r=139.441 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=39.3066 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz5 (\1\:VDD \5\:VDD) resistor r=37.5 c=0
Rz6 (\1\:VDD \7\:VDD) resistor r=75 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry4 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry5 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\3\:ISOn \8\:ISOn) resistor r=45 c=0
Rx2 (\1\:A \6\:A) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (net127 \1\:ISOn \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\8\:n0 \3\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn2 (\2\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mp0 (\6\:n0 \4\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.4311 \
        scb=0.0102779 scc=9.59767e-05 m=(1)
mp2 (\4\:Y n0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.5636 \
        scb=0.0214309 scc=0.000678705 m=(1)
ends ISONLX1_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:28:25 2012 )
// Library name: gsclib045
// Cell name: LSHLX1_FROM
// View name: extracted

simulator lang=spectre

subckt LSHLX1_FROM A ExtVDD VDD VSS Y
mp0 (\7\:n0 \4\:A \5\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=85.3128 \
        scb=0.0561754 scc=0.010057 m=(1)
C1 (VDD VSS) capacitor c=9.25327e-17
C2 (Y VSS) capacitor c=2.40894e-17
C3 (ExtVDD VSS) capacitor c=1.61358e-16
C4 (A VSS) capacitor c=5.3285e-17
C5 (n0 VSS) capacitor c=2.72016e-17
C6 (\4\:n0 VSS) capacitor c=3.70727e-17
C7 (\4\:A VSS) capacitor c=2.74074e-17
C8 (\1\:A VSS) capacitor c=4.38676e-17
C9 (\3\:n0 VSS) capacitor c=1.34528e-17
C10 (\3\:A VSS) capacitor c=2.20652e-17
C11 (\2\:Y VSS) capacitor c=5.8772e-17
C12 (\1\:ExtVDD VSS) capacitor c=6.58343e-17
C13 (\5\:ExtVDD VSS) capacitor c=3.96505e-17
C14 (\7\:n0 VSS) capacitor c=7.11854e-17
C15 (\4\:Y VSS) capacitor c=3.42486e-17
C16 (\9\:n0 VSS) capacitor c=2.83587e-17
C17 (VDD VSS) capacitor c=1.43981e-16
C18 (\2\:A VSS) capacitor c=3.49094e-17
C19 (\2\:n0 VSS) capacitor c=1.47812e-17
C20 (\5\:n0 VSS) capacitor c=8.91639e-17
C21 (\6\:n0 VSS) capacitor c=9.34949e-17
C22 (\1\:Y VSS) capacitor c=3.66301e-17
Rk20 (VDD VDD) resistor r=0.3206 c=0
Rk14 (\3\:VSS VSS) resistor r=0.1177 c=0
Rk13 (\2\:VSS \3\:VSS) resistor r=0.4603 c=0
Rk15 (VSS \4\:VSS) resistor r=0.04845 c=0
Rk17 (\5\:VSS VSS) resistor r=0.2985 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1276 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2373 c=0
Rk19 (\5\:VSS \9\:VSS) resistor r=0.2236 c=0
Rk21 (\11\:VSS VSS) resistor r=0.5783 c=0
Rk23 (\12\:VSS VSS) resistor r=0.4265 c=0
Rk22 (VSS \12\:VSS) resistor r=0.04845 c=0
Rk10 (Y \1\:Y) resistor r=0.05657 c=0
Rk11 (\1\:Y \3\:Y) resistor r=0.3412 c=0
Rk12 (\1\:Y \5\:Y) resistor r=0.1954 c=0
Rk4 (ExtVDD ExtVDD) resistor r=0.002072 c=0
Rk3 (\2\:ExtVDD ExtVDD) resistor r=0.4254 c=0
Rk6 (ExtVDD \6\:ExtVDD) resistor r=0.4221 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.575 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.4339 c=0
Rk9 (\6\:n0 \10\:n0) resistor r=0.193 c=0
Rl3 (\2\:A \4\:A) resistor r=45.6656 c=0
Rl1 (\1\:A \2\:A) resistor r=206.123 c=0
Rl2 (\2\:A \3\:A) resistor r=83.5428 c=0
Rl4 (n0 \2\:n0) resistor r=67.093 c=0
Rl6 (\2\:n0 \4\:n0) resistor r=131.254 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=3.1183 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry7 (\10\:VSS \11\:VSS) resistor r=62 c=0
Ry8 (\10\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry4 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\5\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry3 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx1 (\3\:A A) resistor r=45 c=0
Rx2 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\9\:n0 \1\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
NM0 (\4\:Y n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.5771 scb=0.0135427 \
        scc=0.000870653 m=(1)
PM0 (\2\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=54.0408 \
        scb=0.0503169 scc=0.00624446 m=(1)
ends LSHLX1_FROM
// End of subcircuit definition.

// Generated for: spectre (May  3 15:29:14 2012 )
// Library name: gsclib045
// Cell name: LSHLX1_TO
// View name: extracted

simulator lang=spectre

subckt LSHLX1_TO A VDD VSS Y
mp0 (\9\:n0 \4\:A \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=21.3061 \
        scb=0.0229136 scc=0.00064882 m=(1)
C1 (VDD VSS) capacitor c=5.9193e-17
C2 (A VSS) capacitor c=8.50588e-17
C3 (Y VSS) capacitor c=1.93597e-17
C4 (n0 VSS) capacitor c=6.10013e-17
C5 (\4\:A VSS) capacitor c=3.7711e-17
C6 (\4\:n0 VSS) capacitor c=3.54221e-17
C7 (\3\:A VSS) capacitor c=4.25535e-17
C8 (\3\:n0 VSS) capacitor c=2.25053e-17
C9 (\1\:A VSS) capacitor c=2.51166e-17
C10 (\4\:Y VSS) capacitor c=6.17067e-17
C11 (\4\:VDD VSS) capacitor c=7.79231e-17
C12 (\9\:n0 VSS) capacitor c=4.43079e-17
C13 (\1\:VDD VSS) capacitor c=2.70819e-17
C14 (\2\:Y VSS) capacitor c=3.32465e-17
C15 (\7\:n0 VSS) capacitor c=2.47205e-17
C16 (\2\:A VSS) capacitor c=3.76276e-17
C17 (\2\:n0 VSS) capacitor c=2.77111e-17
C18 (\5\:n0 VSS) capacitor c=4.97038e-17
C19 (\6\:n0 VSS) capacitor c=6.52399e-17
C20 (\1\:Y VSS) capacitor c=4.75567e-17
Rk9 (VDD VDD) resistor r=0.0153 c=0
Rk8 (\2\:VDD VDD) resistor r=0.1004 c=0
Rk10 (VDD \3\:VDD) resistor r=0.08549 c=0
Rk11 (VDD \5\:VDD) resistor r=0.3691 c=0
Rk13 (VSS VSS) resistor r=0.02533 c=0
Rk12 (\2\:VSS VSS) resistor r=0.1004 c=0
Rk14 (VSS \3\:VSS) resistor r=0.07546 c=0
Rk15 (VSS \5\:VSS) resistor r=0.3057 c=0
Rk5 (Y \1\:Y) resistor r=0.0271 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.1987 c=0
Rk7 (\1\:Y \5\:Y) resistor r=0.3953 c=0
Rk2 (\5\:n0 \6\:n0) resistor r=0.1999 c=0
Rk3 (\6\:n0 \8\:n0) resistor r=0.171 c=0
Rk4 (\6\:n0 \10\:n0) resistor r=0.4249 c=0
Rl3 (\2\:A \4\:A) resistor r=92.4917 c=0
Rl2 (\2\:A \3\:A) resistor r=126.583 c=0
Rl1 (\1\:A \2\:A) resistor r=2.4834 c=0
Rl4 (n0 \2\:n0) resistor r=132.374 c=0
Rl6 (\2\:n0 \4\:n0) resistor r=38.1316 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=2.4801 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \3\:VSS) resistor r=31 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry1 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\1\:A A) resistor r=45 c=0
Rx2 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\4\:VSS \3\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
NM0 (\2\:Y \4\:n0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.365e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.4e-07 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(1)
PM0 (\4\:Y n0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=22.176 \
        scb=0.0237558 scc=0.000835591 m=(1)
ends LSHLX1_TO
// End of subcircuit definition.

// Generated for: spectre (May  3 15:29:59 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOH_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=84.9167 \
        scb=0.0555848 scc=0.0100504 m=(1)
C1 (VDD VSS) capacitor c=9.57045e-17
C2 (ExtVDD VSS) capacitor c=8.66072e-17
C3 (ISO VSS) capacitor c=3.82301e-17
C4 (Y VSS) capacitor c=2.3794e-17
C5 (A VSS) capacitor c=4.79012e-17
C6 (ison VSS) capacitor c=7.82698e-17
C7 (gatedVSS VSS) capacitor c=2.26976e-16
C8 (n0 VSS) capacitor c=3.16407e-17
C9 (\4\:n0 VSS) capacitor c=4.74742e-17
C10 (\1\:A VSS) capacitor c=6.13299e-17
C11 (\1\:ISO VSS) capacitor c=8.60095e-17
C12 (\4\:A VSS) capacitor c=3.39208e-17
C13 (\3\:ISO VSS) capacitor c=3.54098e-17
C14 (\3\:n0 VSS) capacitor c=2.53368e-17
C15 (\4\:ison VSS) capacitor c=1.71249e-17
C16 (\3\:A VSS) capacitor c=1.77976e-17
C17 (\2\:ISO VSS) capacitor c=6.8303e-17
C18 (\1\:Y VSS) capacitor c=4.77994e-17
C19 (\1\:ExtVDD VSS) capacitor c=1.66392e-16
C20 (\6\:Y VSS) capacitor c=1.3898e-16
C21 (\9\:n0 VSS) capacitor c=9.90951e-17
C22 (\3\:ExtVDD VSS) capacitor c=1.30141e-16
C23 (\9\:ison VSS) capacitor c=1.13018e-16
C24 (\4\:Y VSS) capacitor c=2.82834e-17
C25 (\7\:gatedVSS VSS) capacitor c=5.54084e-17
C26 (\7\:n0 VSS) capacitor c=1.39016e-16
C27 (\7\:ison VSS) capacitor c=1.53671e-16
C28 (\2\:A VSS) capacitor c=6.58204e-17
C29 (VDD VSS) capacitor c=2.23491e-16
C30 (\2\:ison VSS) capacitor c=1.14989e-16
C31 (\2\:n0 VSS) capacitor c=2.90081e-17
C32 (\5\:ISO VSS) capacitor c=1.64861e-17
C33 (\6\:A VSS) capacitor c=3.39674e-17
C34 (\6\:ison VSS) capacitor c=1.20796e-16
C35 (\6\:ExtVDD VSS) capacitor c=1.28335e-16
C36 (\5\:n0 VSS) capacitor c=5.89621e-17
C37 (\6\:n0 VSS) capacitor c=1.76395e-16
C38 (\3\:Y VSS) capacitor c=6.77032e-17
Rk33 (VDD VDD) resistor r=0.4002 c=0
Rk12 (\4\:ExtVDD ExtVDD) resistor r=0.2723 c=0
Rk11 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8374 c=0
Rk13 (ExtVDD \6\:ExtVDD) resistor r=0.001554 c=0
Rk14 (\6\:ExtVDD ExtVDD) resistor r=0.001554 c=0
Rk2 (\5\:ISO ISO) resistor r=0.007161 c=0
Rk1 (\4\:ISO \5\:ISO) resistor r=0.00331 c=0
Rk22 (\3\:Y Y) resistor r=0.3129 c=0
Rk21 (\2\:Y \3\:Y) resistor r=0.2076 c=0
Rk23 (Y \5\:Y) resistor r=0.0308 c=0
Rk24 (\3\:Y \7\:Y) resistor r=0.4964 c=0
Rk25 (\2\:VSS VSS) resistor r=0.6351 c=0
Rk28 (\4\:VSS VSS) resistor r=0.4003 c=0
Rk27 (VSS \4\:VSS) resistor r=0.06335 c=0
Rk29 (VSS \5\:VSS) resistor r=0.1345 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.03647 c=0
Rk31 (\4\:VSS \8\:VSS) resistor r=0.2096 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.2969 c=0
Rk34 (\12\:VSS VSS) resistor r=0.5863 c=0
Rk36 (\13\:VSS VSS) resistor r=0.3663 c=0
Rk35 (VSS \13\:VSS) resistor r=0.09799 c=0
Rk6 (\6\:A A) resistor r=0.008156 c=0
Rk5 (\5\:A \6\:A) resistor r=0.004287 c=0
Rk9 (\6\:ison \8\:ison) resistor r=0.6373 c=0
Rk10 (\8\:ison \10\:ison) resistor r=0.9102 c=0
Rk17 (gatedVSS \8\:gatedVSS) resistor r=0.08699 c=0
Rk18 (\5\:n0 \6\:n0) resistor r=0.2548 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.7794 c=0
Rk20 (\6\:n0 \10\:n0) resistor r=0.4514 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=264.957 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=171.342 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=208.445 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=78.8553 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=89.0826 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=1.2301 c=0
Rz8 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz9 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz6 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry2 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry3 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry8 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\6\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\12\:VSS \11\:VSS) resistor r=31 c=0
Ry11 (\13\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \4\:ISO) resistor r=45 c=0
Rx2 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\7\:ison \3\:ISO \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=3.6606 \
        scb=0.000125236 scc=4.16931e-09 m=(1)
mn0 (\7\:n0 \4\:A \7\:gatedVSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.4629 \
        scb=0.00240631 scc=0.000219187 m=(1)
NM3 (\7\:VSS \2\:ison gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
NM0 (\4\:Y n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp0 (\9\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=70.353 \
        scb=0.0375991 scc=0.00748848 m=(1)
PM4 (\6\:Y ison \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=48.4468 \
        scb=0.0316144 scc=0.0044182 m=(1)
PM0 (\1\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=63.0104 scb=0.0496 \
        scc=0.00698014 m=(1)
ends LSHL_ISOH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:31:01 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOH_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOH_X1_TO_ON A ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
C1 (VDD VSS) capacitor c=1.72914e-16
C2 (ISO VSS) capacitor c=5.18186e-17
C3 (A VSS) capacitor c=2.97217e-17
C4 (ison VSS) capacitor c=6.73914e-17
C5 (gatedVSS VSS) capacitor c=2.39759e-16
C6 (n0 VSS) capacitor c=5.32411e-17
C7 (\1\:A VSS) capacitor c=5.54774e-17
C8 (\1\:ISO VSS) capacitor c=8.47789e-17
C9 (\4\:n0 VSS) capacitor c=2.68128e-17
C10 (\4\:A VSS) capacitor c=3.41508e-17
C11 (\3\:ISO VSS) capacitor c=3.44895e-17
C12 (\3\:n0 VSS) capacitor c=4.53739e-17
C13 (\4\:ison VSS) capacitor c=1.74764e-17
C14 (\3\:A VSS) capacitor c=1.77336e-17
C15 (\2\:ISO VSS) capacitor c=6.03888e-17
C16 (\6\:Y VSS) capacitor c=5.88867e-17
C17 (\1\:VDD VSS) capacitor c=1.12455e-16
C18 (\4\:Y VSS) capacitor c=1.34245e-16
C19 (\9\:n0 VSS) capacitor c=1.02293e-16
C20 (\5\:VDD VSS) capacitor c=5.57611e-17
C21 (\9\:ison VSS) capacitor c=1.04345e-16
C22 (\1\:Y VSS) capacitor c=4.89906e-17
C23 (\7\:gatedVSS VSS) capacitor c=5.62487e-17
C24 (\7\:n0 VSS) capacitor c=1.30505e-16
C25 (\7\:ison VSS) capacitor c=1.51514e-16
C26 (VDD VSS) capacitor c=3.53193e-17
C27 (\2\:A VSS) capacitor c=6.3675e-17
C28 (\2\:ison VSS) capacitor c=1.13079e-16
C29 (\5\:A VSS) capacitor c=3.65733e-17
C30 (\6\:ison VSS) capacitor c=1.1813e-16
C31 (\5\:n0 VSS) capacitor c=6.28135e-17
C32 (\6\:n0 VSS) capacitor c=1.49366e-16
C33 (\3\:Y VSS) capacitor c=6.72831e-17
Rk23 (VDD VDD) resistor r=0.2687 c=0
Rk20 (\2\:VDD VDD) resistor r=0.6479 c=0
Rk22 (VDD \6\:VDD) resistor r=0.3124 c=0
Rk1 (ISO \4\:ISO) resistor r=0.003448 c=0
Rk16 (\2\:Y \3\:Y) resistor r=0.3039 c=0
Rk17 (\3\:Y \5\:Y) resistor r=0.5546 c=0
Rk19 (\7\:Y Y) resistor r=0.004839 c=0
Rk18 (\3\:Y \7\:Y) resistor r=0.1783 c=0
Rk26 (VSS VSS) resistor r=0.326 c=0
Rk25 (\4\:VSS VSS) resistor r=0.04991 c=0
Rk24 (\2\:VSS \4\:VSS) resistor r=0.2569 c=0
Rk27 (VSS \5\:VSS) resistor r=0.138 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.03742 c=0
Rk29 (\5\:VSS \8\:VSS) resistor r=0.3089 c=0
Rk5 (\5\:A A) resistor r=0.008783 c=0
Rk4 (\5\:A \6\:A) resistor r=0.005175 c=0
Rk8 (\6\:ison \8\:ison) resistor r=0.6624 c=0
Rk9 (\8\:ison \10\:ison) resistor r=0.9061 c=0
Rk12 (gatedVSS \8\:gatedVSS) resistor r=0.09023 c=0
Rk13 (\5\:n0 \6\:n0) resistor r=0.3375 c=0
Rk14 (\6\:n0 \8\:n0) resistor r=0.6842 c=0
Rk15 (\6\:n0 \10\:n0) resistor r=0.531 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=264.957 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=171.342 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=208.445 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=125.556 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=41.9777 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz3 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz5 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz6 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry4 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry7 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry8 (\6\:VSS \3\:VSS) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \4\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\7\:VSS \3\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\7\:gatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (gatedVSS \2\:ison \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\1\:Y \4\:n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mp0 (\9\:n0 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
PM4 (\4\:Y ison \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=14.3303 \
        scb=0.0124199 scc=0.00051711 m=(1)
PM0 (\6\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.0626 \
        scb=0.016739 scc=0.000580643 m=(1)
ends LSHL_ISOH_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:31:49 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOL_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=84.7214 \
        scb=0.0553128 scc=0.0100481 m=(1)
C1 (Y VSS) capacitor c=4.5268e-17
C2 (VDD VSS) capacitor c=1.02668e-16
C3 (ExtVDD VSS) capacitor c=8.18042e-17
C4 (ISO VSS) capacitor c=5.57712e-17
C5 (A VSS) capacitor c=4.45175e-17
C6 (n0 VSS) capacitor c=3.94972e-17
C7 (ison VSS) capacitor c=6.58594e-17
C8 (GatedVSS VSS) capacitor c=1.7713e-16
C9 (\4\:n0 VSS) capacitor c=4.58089e-17
C10 (\1\:A VSS) capacitor c=6.16855e-17
C11 (\1\:ISO VSS) capacitor c=8.84385e-17
C12 (\4\:A VSS) capacitor c=3.54709e-17
C13 (\4\:ISO VSS) capacitor c=3.96772e-17
C14 (\3\:n0 VSS) capacitor c=4.00355e-17
C15 (\4\:ison VSS) capacitor c=1.73926e-17
C16 (\3\:A VSS) capacitor c=8.39335e-17
C17 (\3\:ISO VSS) capacitor c=1.57201e-17
C18 (\3\:Y VSS) capacitor c=6.32063e-17
C19 (\1\:ExtVDD VSS) capacitor c=1.59951e-16
C20 (\12\:n0 VSS) capacitor c=3.34896e-17
C21 (\10\:n0 VSS) capacitor c=3.62127e-17
C22 (\3\:ExtVDD VSS) capacitor c=1.2867e-16
C23 (\9\:ison VSS) capacitor c=1.43283e-16
C24 (\1\:Y VSS) capacitor c=3.7335e-17
C25 (\5\:GatedVSS VSS) capacitor c=5.43649e-17
C26 (\7\:n0 VSS) capacitor c=1.39343e-16
C27 (\7\:ison VSS) capacitor c=1.38013e-16
C28 (ExtVDD VSS) capacitor c=1.19199e-16
C29 (\2\:ISO VSS) capacitor c=6.02772e-17
C30 (VDD VSS) capacitor c=2.23837e-16
C31 (\2\:ison VSS) capacitor c=1.12646e-16
C32 (\7\:A VSS) capacitor c=2.97603e-17
C33 (\6\:ison VSS) capacitor c=1.19187e-16
C34 (\5\:n0 VSS) capacitor c=4.64728e-17
C35 (\6\:n0 VSS) capacitor c=1.43461e-16
C36 (\9\:n0 VSS) capacitor c=3.11981e-17
Rk22 (\3\:VSS VSS) resistor r=0.1531 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.48 c=0
Rk25 (\5\:VSS VSS) resistor r=0.3993 c=0
Rk24 (VSS \5\:VSS) resistor r=0.06318 c=0
Rk26 (VSS \6\:VSS) resistor r=0.1341 c=0
Rk27 (\6\:VSS \7\:VSS) resistor r=0.03637 c=0
Rk28 (\3\:VSS \9\:VSS) resistor r=0.2567 c=0
Rk29 (\5\:VSS \11\:VSS) resistor r=0.209 c=0
Rk30 (\6\:VSS \13\:VSS) resistor r=0.2961 c=0
Rk32 (\15\:VSS VSS) resistor r=0.5847 c=0
Rk34 (\16\:VSS VSS) resistor r=0.3654 c=0
Rk33 (VSS \16\:VSS) resistor r=0.09774 c=0
Rk19 (\2\:Y Y) resistor r=0.1618 c=0
Rk20 (Y \4\:Y) resistor r=0.3688 c=0
Rk31 (VDD VDD) resistor r=0.3992 c=0
Rk12 (ExtVDD ExtVDD) resistor r=0.00388 c=0
Rk11 (\4\:ExtVDD ExtVDD) resistor r=0.2736 c=0
Rk10 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8519 c=0
Rk1 (\5\:ISO ISO) resistor r=0.01211 c=0
Rk5 (A \7\:A) resistor r=0.01179 c=0
Rk4 (\6\:A \7\:A) resistor r=0.006737 c=0
Rk14 (\5\:n0 \6\:n0) resistor r=0.242 c=0
Rk15 (\6\:n0 \8\:n0) resistor r=0.8405 c=0
Rk16 (\6\:n0 \9\:n0) resistor r=0.2588 c=0
Rk17 (\9\:n0 \11\:n0) resistor r=0.02663 c=0
Rk18 (\9\:n0 \13\:n0) resistor r=0.03226 c=0
Rk6 (\6\:ison \8\:ison) resistor r=0.6356 c=0
Rk7 (\8\:ison \10\:ison) resistor r=0.8662 c=0
Rk9 (GatedVSS \6\:GatedVSS) resistor r=0.08685 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=245.671 c=0
Rl3 (\2\:ISO \4\:ISO) resistor r=203.048 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=21.3506 c=0
Rl4 (\1\:A \2\:A) resistor r=213.712 c=0
Rl6 (\2\:A \4\:A) resistor r=145.474 c=0
Rl5 (\2\:A \3\:A) resistor r=5.8309 c=0
Rl11 (n0 \2\:n0) resistor r=113.624 c=0
Rl13 (\2\:n0 \4\:n0) resistor r=55.4393 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rl7 (\2\:ison ison) resistor r=257.877 c=0
Rl9 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rz8 (\9\:VSS \8\:VSS) resistor r=37.5 c=0
Rz9 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Ry8 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\7\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\15\:VSS \14\:VSS) resistor r=31 c=0
Ry11 (\16\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry6 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry3 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry4 (\10\:n0 \11\:n0) resistor r=62 c=0
Ry5 (\12\:n0 \13\:n0) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Rx1 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
NM1 (\12\:VSS \4\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=3.6606 \
        scb=0.000125236 scc=4.16931e-09 m=(1)
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.4629 \
        scb=0.00240631 scc=0.000219187 m=(1)
NM3 (GatedVSS \2\:ison \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
NM0 (\1\:Y n0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp0 (\10\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=70.1578 \
        scb=0.0373272 scc=0.00748621 m=(1)
PM2 (\12\:n0 ison \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=69.7507 \
        scb=0.0364058 scc=0.00745349 m=(1)
PM0 (\3\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=63.0104 \
        scb=0.0496 scc=0.00698014 m=(1)
ends LSHL_ISOL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:32:34 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOL_X1_TO_ON A ISO VDD VSS Y
PM2 (\9\:ison \1\:ISO \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
C1 (VDD VSS) capacitor c=1.53776e-16
C2 (ISO VSS) capacitor c=4.87202e-17
C3 (Y VSS) capacitor c=7.14055e-17
C4 (ison VSS) capacitor c=6.08964e-17
C5 (GatedVSS VSS) capacitor c=1.72185e-16
C6 (n0 VSS) capacitor c=5.47254e-17
C7 (\1\:A VSS) capacitor c=5.43107e-17
C8 (\1\:ISO VSS) capacitor c=1.01161e-16
C9 (\4\:n0 VSS) capacitor c=2.88079e-17
C10 (\4\:A VSS) capacitor c=3.23319e-17
C11 (\3\:ISO VSS) capacitor c=1.85264e-17
C12 (\3\:n0 VSS) capacitor c=4.06897e-17
C13 (\4\:ison VSS) capacitor c=1.76505e-17
C14 (\3\:A VSS) capacitor c=1.78489e-17
C15 (\2\:ISO VSS) capacitor c=6.16594e-17
C16 (\1\:Y VSS) capacitor c=3.26923e-17
C17 (\1\:VDD VSS) capacitor c=1.01143e-16
C18 (\12\:n0 VSS) capacitor c=2.97773e-17
C19 (\10\:n0 VSS) capacitor c=3.05082e-17
C20 (\5\:VDD VSS) capacitor c=5.34486e-17
C21 (\9\:ison VSS) capacitor c=9.3037e-17
C22 (\3\:Y VSS) capacitor c=4.19267e-17
C23 (\5\:GatedVSS VSS) capacitor c=5.01309e-17
C24 (\7\:n0 VSS) capacitor c=1.26768e-16
C25 (\7\:ison VSS) capacitor c=1.69077e-16
C26 (VDD VSS) capacitor c=3.8461e-17
C27 (\2\:A VSS) capacitor c=6.54861e-17
C28 (\2\:ison VSS) capacitor c=1.08081e-16
C29 (\4\:ISO VSS) capacitor c=1.06919e-17
C30 (\6\:A VSS) capacitor c=3.40825e-17
C31 (\7\:A VSS) capacitor c=4.17168e-18
C32 (\8\:A VSS) capacitor c=3.18532e-17
C33 (\6\:ison VSS) capacitor c=1.17866e-16
C34 (\5\:n0 VSS) capacitor c=4.29988e-17
C35 (\6\:n0 VSS) capacitor c=1.06556e-16
C36 (\9\:n0 VSS) capacitor c=2.81146e-17
Rk25 (VDD VDD) resistor r=0.2685 c=0
Rk22 (\2\:VDD VDD) resistor r=0.6358 c=0
Rk24 (VDD \6\:VDD) resistor r=0.3106 c=0
Rk2 (\4\:ISO ISO) resistor r=0.01055 c=0
Rk1 (\4\:ISO \5\:ISO) resistor r=0.007408 c=0
Rk20 (\2\:Y Y) resistor r=0.1256 c=0
Rk21 (Y \4\:Y) resistor r=0.4017 c=0
Rk29 (VSS VSS) resistor r=0.3258 c=0
Rk26 (\2\:VSS \3\:VSS) resistor r=0.4913 c=0
Rk28 (\5\:VSS VSS) resistor r=0.04987 c=0
Rk27 (\3\:VSS \5\:VSS) resistor r=0.03489 c=0
Rk30 (VSS \6\:VSS) resistor r=0.1379 c=0
Rk31 (\6\:VSS \7\:VSS) resistor r=0.0374 c=0
Rk32 (\3\:VSS \9\:VSS) resistor r=0.2169 c=0
Rk33 (\6\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk5 (A \5\:A) resistor r=0.008776 c=0
Rk6 (\6\:A \5\:A) resistor r=0.004301 c=0
Rk7 (A \7\:A) resistor r=0.002581 c=0
Rk8 (\6\:A \7\:A) resistor r=0.008776 c=0
Rk9 (A \8\:A) resistor r=0.004301 c=0
Rk10 (\7\:A \8\:A) resistor r=0.008562 c=0
Rk11 (\6\:ison \8\:ison) resistor r=0.6586 c=0
Rk12 (\8\:ison \10\:ison) resistor r=0.8928 c=0
Rk14 (GatedVSS \6\:GatedVSS) resistor r=0.08877 c=0
Rk15 (\5\:n0 \6\:n0) resistor r=0.2858 c=0
Rk16 (\6\:n0 \8\:n0) resistor r=0.7154 c=0
Rk17 (\6\:n0 \9\:n0) resistor r=0.3668 c=0
Rk18 (\9\:n0 \11\:n0) resistor r=0.0272 c=0
Rk19 (\9\:n0 \13\:n0) resistor r=0.03295 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=377.693 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=48.5227 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=257.877 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=120.442 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=47.7469 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz6 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz9 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry7 (\5\:VSS \4\:VSS) resistor r=6.2 c=0
Ry8 (\7\:VSS \4\:VSS) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry2 (\10\:n0 \11\:n0) resistor r=62 c=0
Ry3 (\12\:n0 \13\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\10\:VSS \3\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (GatedVSS \2\:ison \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mp0 (\10\:n0 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
PM1 (\12\:n0 ison \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=11.3694 \
        scb=0.00808912 scc=7.45876e-05 m=(1)
PM0 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=17.0626 \
        scb=0.016739 scc=0.000580643 m=(1)
ends LSHL_ISOL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:33:23 2012 )
// Library name: gsclib045
// Cell name: LSLHX1_FROM
// View name: extracted

simulator lang=spectre

subckt LSLHX1_FROM A ExtVDD VDD VSS Y
PM2 (\9\:Ab \8\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ExtVDD VSS) capacitor c=2.56905e-16
C2 (A VSS) capacitor c=4.11587e-17
C3 (Y VSS) capacitor c=7.2355e-17
C4 (VDD VSS) capacitor c=8.19008e-17
C5 (Yint VSS) capacitor c=3.22672e-17
C6 (Ab VSS) capacitor c=1.70767e-16
C7 (Ybint VSS) capacitor c=2.64223e-17
C8 (\6\:Ybint VSS) capacitor c=5.11536e-17
C9 (\4\:Yint VSS) capacitor c=2.54578e-17
C10 (\8\:A VSS) capacitor c=3.98623e-17
C11 (\3\:Ybint VSS) capacitor c=2.61807e-17
C12 (\1\:A VSS) capacitor c=2.28031e-16
C13 (\9\:A VSS) capacitor c=2.96624e-17
C14 (\5\:Ybint VSS) capacitor c=7.15196e-18
C15 (\2\:Ybint VSS) capacitor c=2.41466e-17
C16 (\3\:Yint VSS) capacitor c=2.01013e-17
C17 (\4\:Ab VSS) capacitor c=7.92137e-17
C18 (\5\:A VSS) capacitor c=1.68514e-17
C19 (\3\:Y VSS) capacitor c=3.55117e-17
C20 (\1\:ExtVDD VSS) capacitor c=6.17168e-17
C21 (\4\:ExtVDD VSS) capacitor c=1.17725e-16
C22 (\11\:Yint VSS) capacitor c=6.38643e-17
C23 (\15\:Ybint VSS) capacitor c=8.76534e-17
C24 (\6\:ExtVDD VSS) capacitor c=1.22389e-16
C25 (\9\:Ab VSS) capacitor c=5.3694e-17
C26 (\3\:VDD VSS) capacitor c=3.67148e-17
C27 (\1\:Y VSS) capacitor c=6.28567e-17
C28 (\5\:Yint VSS) capacitor c=1.65008e-16
C29 (\11\:Ab VSS) capacitor c=2.73533e-17
C30 (VDD VSS) capacitor c=2.86772e-16
C31 (\2\:Yint VSS) capacitor c=1.64661e-17
C32 (\4\:A VSS) capacitor c=1.52189e-16
C33 (\4\:Ybint VSS) capacitor c=1.92796e-17
C34 (\11\:A VSS) capacitor c=1.78551e-17
C35 (\7\:Ab VSS) capacitor c=6.6245e-18
C36 (\8\:Ab VSS) capacitor c=5.97011e-17
C37 (\8\:Yint VSS) capacitor c=4.05965e-17
C38 (\13\:Yint VSS) capacitor c=5.47695e-17
C39 (\3\:ExtVDD VSS) capacitor c=1.5466e-17
C40 (\9\:ExtVDD VSS) capacitor c=6.81915e-17
C41 (\7\:Ybint VSS) capacitor c=4.54417e-17
C42 (\8\:Ybint VSS) capacitor c=1.96517e-16
C43 (\10\:Ybint VSS) capacitor c=9.36469e-17
C44 (\2\:VDD VSS) capacitor c=1.29731e-17
Rk18 (ExtVDD ExtVDD) resistor r=0.003781 c=0
Rk13 (\2\:ExtVDD \3\:ExtVDD) resistor r=0.2441 c=0
Rk14 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2633 c=0
Rk15 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9774 c=0
Rk17 (\9\:ExtVDD ExtVDD) resistor r=0.001891 c=0
Rk16 (\3\:ExtVDD \9\:ExtVDD) resistor r=0.17 c=0
Rk35 (VSS VSS) resistor r=0.3618 c=0
Rk27 (\2\:VSS \3\:VSS) resistor r=0.09705 c=0
Rk29 (\4\:VSS VSS) resistor r=0.1457 c=0
Rk28 (\3\:VSS \4\:VSS) resistor r=0.1457 c=0
Rk36 (VSS \10\:VSS) resistor r=0.01726 c=0
Rk37 (\10\:VSS \12\:VSS) resistor r=0.4873 c=0
Rk38 (\3\:VSS \14\:VSS) resistor r=0.2239 c=0
Rk45 (\22\:VSS VSS) resistor r=0.5832 c=0
Rk47 (\23\:VSS VSS) resistor r=0.2161 c=0
Rk46 (VSS \23\:VSS) resistor r=0.2434 c=0
Rk1 (A \10\:A) resistor r=0.008124 c=0
Rk3 (\11\:A A) resistor r=0.005152 c=0
Rk2 (\10\:A \11\:A) resistor r=0.004002 c=0
Rk25 (\2\:Y Y) resistor r=0.4142 c=0
Rk26 (Y \4\:Y) resistor r=0.1588 c=0
Rk42 (VDD VDD) resistor r=0.4473 c=0
Rk43 (VDD \2\:VDD) resistor r=0.202 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.3266 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2597 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2923 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04195 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4612 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1382 c=0
Rk19 (\7\:Ybint \8\:Ybint) resistor r=0.2668 c=0
Rk21 (\8\:Ybint \10\:Ybint) resistor r=0.1974 c=0
Rk24 (\10\:Ybint \16\:Ybint) resistor r=0.5886 c=0
Rl16 (\4\:A \8\:A) resistor r=163.948 c=0
Rl12 (\4\:A \1\:A) resistor r=621.773 c=0
Rl17 (\4\:A \9\:A) resistor r=83.8346 c=0
Rl13 (\4\:A \5\:A) resistor r=9.0434 c=0
Rl6 (\2\:Yint Yint) resistor r=105.33 c=0
Rl8 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl7 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl3 (Ab \4\:Ab) resistor r=297.331 c=0
Rl9 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl20 (\4\:Ybint \6\:Ybint) resistor r=154.48 c=0
Rl18 (\4\:Ybint \3\:Ybint) resistor r=49.0088 c=0
Rl19 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Ry3 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry4 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry11 (VSS \1\:VSS) resistor r=15.5 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry14 (\22\:VSS \21\:VSS) resistor r=12.4 c=0
Ry15 (\23\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry7 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry13 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry6 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx1 (\10\:A \5\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
NM2 (\11\:VSS \9\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
NM0 (\8\:Ybint \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
mn0 (\1\:Y \3\:Ybint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\15\:Ybint \4\:Yint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
mp0 (\3\:Y \6\:Ybint \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.4979 \
        scb=0.0102291 scc=0.000163486 m=(1)
ends LSLHX1_FROM
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:10:29 2012 )
// Library name: gsclib045
// Cell name: LSLHX1_TO
// View name: extracted

simulator lang=spectre

subckt LSLHX1_TO A ExtVDD VDD VSS Y
PM2 (\7\:Ab \9\:A \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5924 \
        scb=0.0250741 scc=0.000917806 m=(1)
C1 (VDD VSS) capacitor c=2.69499e-16
C2 (A VSS) capacitor c=2.02317e-17
C3 (ExtVDD VSS) capacitor c=8.50868e-17
C4 (Y VSS) capacitor c=3.4521e-17
C5 (Yint VSS) capacitor c=3.45086e-17
C6 (Ab VSS) capacitor c=1.20243e-16
C7 (Ybint VSS) capacitor c=2.66646e-17
C8 (\6\:Ybint VSS) capacitor c=4.50885e-17
C9 (\4\:Yint VSS) capacitor c=2.69826e-17
C10 (\9\:A VSS) capacitor c=5.83468e-17
C11 (\3\:Ybint VSS) capacitor c=2.72431e-17
C12 (\1\:A VSS) capacitor c=1.7502e-16
C13 (\10\:A VSS) capacitor c=2.56553e-17
C14 (\5\:Ybint VSS) capacitor c=5.61545e-18
C15 (\2\:Ybint VSS) capacitor c=2.8773e-17
C16 (\3\:Yint VSS) capacitor c=2.37937e-17
C17 (\4\:Ab VSS) capacitor c=3.70506e-17
C18 (\6\:A VSS) capacitor c=2.29076e-17
C19 (\1\:Y VSS) capacitor c=5.7992e-17
C20 (\1\:VDD VSS) capacitor c=6.33227e-17
C21 (\7\:VDD VSS) capacitor c=3.46211e-17
C22 (\11\:Yint VSS) capacitor c=6.49308e-17
C23 (\15\:Ybint VSS) capacitor c=8.72788e-17
C24 (\9\:VDD VSS) capacitor c=4.97049e-17
C25 (\7\:Ab VSS) capacitor c=9.66802e-17
C26 (\4\:ExtVDD VSS) capacitor c=3.57298e-17
C27 (\3\:Y VSS) capacitor c=5.03998e-17
C28 (\5\:Yint VSS) capacitor c=1.8525e-16
C29 (\10\:Ab VSS) capacitor c=5.57334e-17
C30 (ExtVDD VSS) capacitor c=2.68281e-17
C31 (VDD VSS) capacitor c=1.82374e-17
C32 (\2\:Yint VSS) capacitor c=1.87315e-17
C33 (\4\:A VSS) capacitor c=1.56821e-16
C34 (\5\:A VSS) capacitor c=2.69321e-17
C35 (\4\:Ybint VSS) capacitor c=2.08122e-17
C36 (\11\:A VSS) capacitor c=2.75172e-17
C37 (\3\:ExtVDD VSS) capacitor c=1.56256e-17
C38 (\9\:Ab VSS) capacitor c=1.19555e-16
C39 (\8\:Yint VSS) capacitor c=4.56103e-17
C40 (\13\:Yint VSS) capacitor c=5.35801e-17
C41 (\7\:Ybint VSS) capacitor c=4.4113e-17
C42 (\8\:Ybint VSS) capacitor c=1.73383e-16
C43 (\10\:Ybint VSS) capacitor c=8.56149e-17
C44 (\4\:VDD VSS) capacitor c=2.1595e-18
C45 (\5\:VDD VSS) capacitor c=1.4209e-17
C46 (\6\:VDD VSS) capacitor c=2.26239e-17
Rk35 (\2\:VDD \4\:VDD) resistor r=0.4947 c=0
Rk37 (\5\:VDD VDD) resistor r=0.2913 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.1238 c=0
Rk39 (\6\:VDD VDD) resistor r=0.3107 c=0
Rk38 (VDD \6\:VDD) resistor r=0.1362 c=0
Rk40 (\5\:VDD \8\:VDD) resistor r=0.2764 c=0
Rk41 (\6\:VDD \10\:VDD) resistor r=0.2764 c=0
Rk28 (VSS VSS) resistor r=0.3618 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.09705 c=0
Rk22 (\4\:VSS VSS) resistor r=0.1457 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.1457 c=0
Rk29 (VSS \10\:VSS) resistor r=0.01726 c=0
Rk30 (\10\:VSS \12\:VSS) resistor r=0.4553 c=0
Rk31 (\3\:VSS \14\:VSS) resistor r=0.2235 c=0
Rk42 (\22\:VSS VSS) resistor r=0.5832 c=0
Rk44 (\23\:VSS VSS) resistor r=0.2161 c=0
Rk43 (VSS \23\:VSS) resistor r=0.2434 c=0
Rk1 (\11\:A A) resistor r=0.0265 c=0
Rk4 (\3\:ExtVDD ExtVDD) resistor r=0.02388 c=0
Rk3 (ExtVDD \3\:ExtVDD) resistor r=0.03385 c=0
Rk5 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2856 c=0
Rk18 (Y \2\:Y) resistor r=0.2952 c=0
Rk19 (Y \4\:Y) resistor r=0.3108 c=0
Rk9 (\5\:Yint \8\:Yint) resistor r=0.2597 c=0
Rk11 (\12\:Yint \13\:Yint) resistor r=0.2923 c=0
Rk6 (\8\:Ab \9\:Ab) resistor r=0.883 c=0
Rk7 (\9\:Ab \11\:Ab) resistor r=0.5135 c=0
Rk12 (\7\:Ybint \8\:Ybint) resistor r=0.2864 c=0
Rk14 (\8\:Ybint \10\:Ybint) resistor r=0.1782 c=0
Rk17 (\10\:Ybint \16\:Ybint) resistor r=0.5886 c=0
Rl17 (\4\:A \9\:A) resistor r=336.831 c=0
Rl12 (\4\:A \1\:A) resistor r=446.755 c=0
Rl18 (\5\:A \10\:A) resistor r=62.4311 c=0
Rl14 (\5\:A \6\:A) resistor r=44.7819 c=0
Rl13 (\5\:A \4\:A) resistor r=240.459 c=0
Rl6 (\2\:Yint Yint) resistor r=105.33 c=0
Rl8 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl7 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl3 (Ab \4\:Ab) resistor r=108.126 c=0
Rl9 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl21 (\4\:Ybint \6\:Ybint) resistor r=140.931 c=0
Rl19 (\4\:Ybint \3\:Ybint) resistor r=58.975 c=0
Rl20 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz7 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry12 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry13 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry14 (\22\:VSS \21\:VSS) resistor r=12.4 c=0
Ry15 (\23\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry5 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
NM2 (\11\:VSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
NM1 (\5\:Yint Ab VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
NM0 (\8\:Ybint \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
mn0 (\3\:Y \3\:Ybint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\15\:Ybint \4\:Yint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
mp0 (\1\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.8211 \
        scb=0.0185035 scc=0.000835503 m=(1)
ends LSLHX1_TO
// End of subcircuit definition.

// Generated for: spectre (May  3 21:50:58 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOH_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (Y VSS) capacitor c=3.57445e-17
C2 (ISO VSS) capacitor c=3.84367e-17
C3 (ExtVDD VSS) capacitor c=2.92877e-16
C4 (A VSS) capacitor c=4.11134e-17
C5 (VDD VSS) capacitor c=1.20565e-16
C6 (Yint VSS) capacitor c=3.45698e-17
C7 (Ab VSS) capacitor c=1.65388e-16
C8 (Ybint VSS) capacitor c=3.11581e-17
C9 (GatedVSS VSS) capacitor c=3.45138e-17
C10 (ison VSS) capacitor c=1.21436e-16
C11 (\6\:Ybint VSS) capacitor c=3.67116e-17
C12 (\8\:ison VSS) capacitor c=3.86426e-17
C13 (\1\:ISO VSS) capacitor c=4.19925e-17
C14 (\4\:Yint VSS) capacitor c=2.39409e-17
C15 (\9\:A VSS) capacitor c=3.93413e-17
C16 (\3\:Ybint VSS) capacitor c=2.95989e-17
C17 (\1\:A VSS) capacitor c=2.30376e-16
C18 (\4\:ISO VSS) capacitor c=2.63156e-17
C19 (\10\:A VSS) capacitor c=2.86142e-17
C20 (\5\:Ybint VSS) capacitor c=1.13303e-17
C21 (\1\:Y VSS) capacitor c=3.52058e-17
C22 (\2\:Y VSS) capacitor c=3.56976e-17
C23 (\2\:ExtVDD VSS) capacitor c=1.85472e-17
C24 (\1\:ExtVDD VSS) capacitor c=2.00619e-17
C25 (\2\:Ybint VSS) capacitor c=2.18635e-17
C26 (\12\:ison VSS) capacitor c=3.01791e-17
C27 (\7\:ison VSS) capacitor c=1.99454e-17
C28 (\3\:ISO VSS) capacitor c=1.56073e-17
C29 (\3\:Yint VSS) capacitor c=2.30664e-17
C30 (\2\:GatedVSS VSS) capacitor c=3.12543e-17
C31 (\4\:Ab VSS) capacitor c=7.73733e-17
C32 (\6\:A VSS) capacitor c=1.71946e-17
C33 (\8\:Y VSS) capacitor c=8.75896e-17
C34 (\10\:ExtVDD VSS) capacitor c=7.14611e-17
C35 (\4\:Y VSS) capacitor c=5.81649e-17
C36 (\3\:ExtVDD VSS) capacitor c=6.58076e-17
C37 (\12\:ExtVDD VSS) capacitor c=1.19045e-16
C38 (\11\:Yint VSS) capacitor c=6.32786e-17
C39 (\17\:ison VSS) capacitor c=7.04874e-17
C40 (\12\:Ybint VSS) capacitor c=9.04615e-17
C41 (\6\:ExtVDD VSS) capacitor c=1.18101e-16
C42 (\14\:ExtVDD VSS) capacitor c=1.32146e-16
C43 (\9\:Ab VSS) capacitor c=6.07014e-17
C44 (\3\:VDD VSS) capacitor c=3.74334e-17
C45 (\6\:Y VSS) capacitor c=7.44877e-17
C46 (\9\:GatedVSS VSS) capacitor c=9.93139e-17
C47 (\3\:GatedVSS VSS) capacitor c=3.65991e-16
C48 (\7\:Ybint VSS) capacitor c=2.16924e-16
C49 (\5\:Yint VSS) capacitor c=1.97823e-16
C50 (\14\:ison VSS) capacitor c=3.52448e-17
C51 (\11\:Ab VSS) capacitor c=3.98008e-17
C52 (\15\:GatedVSS VSS) capacitor c=9.94709e-17
C53 (\2\:ISO VSS) capacitor c=3.79544e-17
C54 (\2\:Yint VSS) capacitor c=1.89474e-17
C55 (VDD VSS) capacitor c=4.52391e-16
C56 (\4\:A VSS) capacitor c=1.29536e-16
C57 (\5\:A VSS) capacitor c=2.03136e-17
C58 (\6\:ison VSS) capacitor c=1.72068e-17
C59 (\4\:Ybint VSS) capacitor c=1.55291e-17
C60 (\12\:A VSS) capacitor c=1.99809e-17
C61 (\7\:Ab VSS) capacitor c=1.00133e-17
C62 (\8\:Ab VSS) capacitor c=6.19998e-17
C63 (\5\:ISO VSS) capacitor c=3.76723e-17
C64 (\8\:Yint VSS) capacitor c=3.96066e-17
C65 (\13\:ison VSS) capacitor c=4.30409e-17
C66 (\16\:ison VSS) capacitor c=7.06954e-17
C67 (\13\:Yint VSS) capacitor c=5.46163e-17
C68 (\5\:ExtVDD VSS) capacitor c=1.04763e-16
C69 (\6\:GatedVSS VSS) capacitor c=1.11973e-16
C70 (\3\:Y VSS) capacitor c=5.35243e-17
C71 (\11\:GatedVSS VSS) capacitor c=4.32902e-16
C72 (\14\:GatedVSS VSS) capacitor c=1.65193e-16
C73 (\23\:GatedVSS VSS) capacitor c=7.7721e-17
C74 (\8\:ExtVDD VSS) capacitor c=8.8348e-18
C75 (\9\:ExtVDD VSS) capacitor c=1.44395e-17
C76 (\17\:ExtVDD VSS) capacitor c=7.13957e-17
C77 (\11\:Ybint VSS) capacitor c=9.76604e-17
C78 (\14\:Ybint VSS) capacitor c=5.50099e-17
C79 (\10\:Y VSS) capacitor c=4.61279e-17
C80 (\2\:VDD VSS) capacitor c=1.53298e-17
Rk21 (\3\:Y \5\:Y) resistor r=0.3227 c=0
Rk46 (\9\:Y Y) resistor r=0.01673 c=0
Rk44 (\7\:Y \9\:Y) resistor r=0.5262 c=0
Rk45 (\9\:Y \10\:Y) resistor r=0.2619 c=0
Rk9 (\5\:ISO ISO) resistor r=0.04036 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.002861 c=0
Rk16 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.3119 c=0
Rk17 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9376 c=0
Rk31 (\8\:ExtVDD \9\:ExtVDD) resistor r=0.1174 c=0
Rk32 (\9\:ExtVDD \11\:ExtVDD) resistor r=0.3119 c=0
Rk33 (\9\:ExtVDD \13\:ExtVDD) resistor r=0.2247 c=0
Rk34 (\13\:ExtVDD \15\:ExtVDD) resistor r=0.9909 c=0
Rk36 (\17\:ExtVDD ExtVDD) resistor r=0.002861 c=0
Rk35 (\9\:ExtVDD \17\:ExtVDD) resistor r=0.1819 c=0
Rk1 (A \11\:A) resistor r=0.008212 c=0
Rk3 (\12\:A A) resistor r=0.005208 c=0
Rk2 (\11\:A \12\:A) resistor r=0.004045 c=0
Rk62 (VDD VDD) resistor r=0.6016 c=0
Rk63 (VDD \2\:VDD) resistor r=0.2049 c=0
Rk64 (\2\:VDD \4\:VDD) resistor r=0.3311 c=0
Rk54 (VSS VSS) resistor r=0.1479 c=0
Rk53 (VSS VSS) resistor r=0.001 c=0
Rk52 (\3\:VSS VSS) resistor r=0.08092 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.2537 c=0
Rk55 (VSS \8\:VSS) resistor r=0.1135 c=0
Rk57 (\9\:VSS VSS) resistor r=0.1699 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=0.1822 c=0
Rk61 (\8\:VSS \17\:VSS) resistor r=0.2098 c=0
Rk65 (\19\:VSS VSS) resistor r=0.5915 c=0
Rk67 (\20\:VSS VSS) resistor r=0.1797 c=0
Rk66 (VSS \20\:VSS) resistor r=0.3947 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2147 c=0
Rk15 (\12\:Yint \13\:Yint) resistor r=0.2964 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04277 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4592 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1596 c=0
Rk40 (\7\:Ybint \11\:Ybint) resistor r=0.1765 c=0
Rk41 (\11\:Ybint \13\:Ybint) resistor r=0.6333 c=0
Rk42 (\7\:Ybint \14\:Ybint) resistor r=0.2894 c=0
Rk19 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.4219 c=0
Rk22 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.5676 c=0
Rk25 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.4737 c=0
Rk26 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.6286 c=0
Rk30 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.7591 c=0
Rk13 (\13\:ison \15\:ison) resistor r=0.2856 c=0
Rk14 (\16\:ison \18\:ison) resistor r=0.4254 c=0
Rl35 (\1\:Y \2\:Y) resistor r=107.339 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=159.681 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=86.3858 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl23 (\1\:ExtVDD \2\:ExtVDD) resistor r=166.126 c=0
Rl21 (\4\:A \9\:A) resistor r=132.549 c=0
Rl16 (\4\:A \1\:A) resistor r=624.028 c=0
Rl22 (\5\:A \10\:A) resistor r=84.6812 c=0
Rl18 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl17 (\5\:A \4\:A) resistor r=29.0517 c=0
Rl10 (\2\:Yint Yint) resistor r=105.33 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=297.11 c=0
Rl13 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl38 (\4\:Ybint \6\:Ybint) resistor r=93.2039 c=0
Rl36 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl37 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rl30 (ison \8\:ison) resistor r=115.053 c=0
Rl28 (\6\:ison ison) resistor r=72.842 c=0
Rl34 (\6\:ison \12\:ison) resistor r=116.573 c=0
Rl29 (\6\:ison \7\:ison) resistor r=51.6001 c=0
Rz15 (\6\:Y \7\:Y) resistor r=37.5 c=0
Rz19 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz7 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz8 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Rz4 (\15\:ison \14\:ison) resistor r=75 c=0
Ry6 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry11 (\8\:Y \9\:Y) resistor r=20.6667 c=0
Ry4 (\3\:ExtVDD \4\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry7 (\10\:ExtVDD \11\:ExtVDD) resistor r=20.6667 c=0
Ry8 (\12\:ExtVDD \13\:ExtVDD) resistor r=62 c=0
Ry9 (\14\:ExtVDD \15\:ExtVDD) resistor r=62 c=0
Ry16 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry15 (\9\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry17 (\19\:VSS \18\:VSS) resistor r=7.75 c=0
Ry18 (\20\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry10 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Ry2 (\18\:ison \17\:ison) resistor r=62 c=0
Rx10 (\2\:Y \3\:Y) resistor r=45 c=0
Rx15 (\1\:Y \10\:Y) resistor r=45 c=0
Rx3 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx8 (\1\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx12 (\2\:ExtVDD \8\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx4 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx7 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx13 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx14 (\14\:Ybint \5\:Ybint) resistor r=45 c=0
Rx9 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx11 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
Rx5 (\13\:ison \7\:ison) resistor r=45 c=0
Rx6 (\16\:ison \12\:ison) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM4 (\16\:VSS \4\:ISO \14\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\7\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\3\:GatedVSS ison \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\6\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
PM0 (\12\:Ybint \4\:Yint \14\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.7248 \
        scb=0.0268097 scc=0.00266528 m=(1)
PM5 (\17\:ison \1\:ISO \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=20.8995 \
        scb=0.0240463 scc=0.00131353 m=(1)
PM1 (\11\:Yint Ybint \12\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.55891 \
        scb=0.00285886 scc=1.84381e-05 m=(1)
PM4 (\4\:Y \8\:ison \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2275 \
        scb=0.0146219 scc=0.00118588 m=(1)
mp0 (\8\:Y \6\:Ybint \10\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
ends LSLH_ISOH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:34:56 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOL_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (VDD VSS) capacitor c=1.19985e-16
C2 (ISO VSS) capacitor c=5.02994e-17
C3 (ExtVDD VSS) capacitor c=3.21139e-16
C4 (A VSS) capacitor c=3.56374e-17
C5 (Y VSS) capacitor c=2.82711e-17
C6 (Yint VSS) capacitor c=3.30193e-17
C7 (Ab VSS) capacitor c=1.80498e-16
C8 (Ybint VSS) capacitor c=2.96519e-17
C9 (GatedVSS VSS) capacitor c=3.415e-17
C10 (ison VSS) capacitor c=1.25689e-16
C11 (\6\:Ybint VSS) capacitor c=4.35956e-17
C12 (\8\:ison VSS) capacitor c=3.59119e-17
C13 (\1\:ISO VSS) capacitor c=4.7206e-17
C14 (\4\:Yint VSS) capacitor c=2.39721e-17
C15 (\9\:A VSS) capacitor c=4.07131e-17
C16 (\3\:Ybint VSS) capacitor c=2.89525e-17
C17 (\1\:A VSS) capacitor c=2.31435e-16
C18 (\4\:ISO VSS) capacitor c=2.32851e-17
C19 (\10\:A VSS) capacitor c=2.86029e-17
C20 (\7\:Ybint VSS) capacitor c=3.51273e-17
C21 (\5\:Ybint VSS) capacitor c=1.08786e-17
C22 (\1\:ExtVDD VSS) capacitor c=1.31781e-17
C23 (\2\:ExtVDD VSS) capacitor c=1.62965e-17
C24 (\2\:Ybint VSS) capacitor c=2.20258e-17
C25 (\12\:ison VSS) capacitor c=3.07911e-17
C26 (\7\:ison VSS) capacitor c=2.04814e-17
C27 (\3\:ISO VSS) capacitor c=1.57032e-17
C28 (\3\:Yint VSS) capacitor c=2.18969e-17
C29 (\2\:GatedVSS VSS) capacitor c=3.13977e-17
C30 (\4\:Ab VSS) capacitor c=8.793e-17
C31 (\6\:A VSS) capacitor c=1.71941e-17
C32 (\1\:Y VSS) capacitor c=7.6615e-17
C33 (\8\:ExtVDD VSS) capacitor c=5.84354e-17
C34 (\19\:Ybint VSS) capacitor c=5.2531e-17
C35 (\3\:ExtVDD VSS) capacitor c=3.9269e-17
C36 (\11\:ExtVDD VSS) capacitor c=1.16167e-16
C37 (\11\:Yint VSS) capacitor c=6.28448e-17
C38 (\17\:ison VSS) capacitor c=7.14438e-17
C39 (\13\:Ybint VSS) capacitor c=8.94932e-17
C40 (\6\:ExtVDD VSS) capacitor c=1.23141e-16
C41 (\13\:ExtVDD VSS) capacitor c=1.31953e-16
C42 (\9\:Ab VSS) capacitor c=6.05239e-17
C43 (\3\:VDD VSS) capacitor c=3.74334e-17
C44 (\3\:Y VSS) capacitor c=6.84677e-17
C45 (\15\:GatedVSS VSS) capacitor c=3.53273e-16
C46 (\8\:Ybint VSS) capacitor c=2.0644e-16
C47 (\3\:GatedVSS VSS) capacitor c=3.889e-16
C48 (\5\:Yint VSS) capacitor c=1.94884e-16
C49 (\14\:ison VSS) capacitor c=4.3387e-17
C50 (\11\:Ab VSS) capacitor c=3.993e-17
C51 (\8\:GatedVSS VSS) capacitor c=9.94193e-17
C52 (\2\:ISO VSS) capacitor c=3.41477e-17
C53 (\2\:Yint VSS) capacitor c=1.77081e-17
C54 (VDD VSS) capacitor c=4.49321e-16
C55 (\4\:A VSS) capacitor c=1.63953e-16
C56 (\6\:ison VSS) capacitor c=1.744e-17
C57 (\4\:Ybint VSS) capacitor c=1.88877e-17
C58 (\12\:A VSS) capacitor c=1.99809e-17
C59 (\7\:Ab VSS) capacitor c=1.00778e-17
C60 (\8\:Ab VSS) capacitor c=5.62182e-17
C61 (\7\:ISO VSS) capacitor c=4.21617e-17
C62 (\8\:Yint VSS) capacitor c=3.95666e-17
C63 (\13\:ison VSS) capacitor c=3.52373e-17
C64 (\16\:ison VSS) capacitor c=6.77462e-17
C65 (\13\:Yint VSS) capacitor c=5.45128e-17
C66 (\7\:GatedVSS VSS) capacitor c=1.65735e-16
C67 (\14\:GatedVSS VSS) capacitor c=7.69898e-17
C68 (\5\:ExtVDD VSS) capacitor c=1.17314e-16
C69 (\18\:GatedVSS VSS) capacitor c=1.1666e-16
C70 (\10\:ExtVDD VSS) capacitor c=1.63485e-17
C71 (\15\:ExtVDD VSS) capacitor c=7.97873e-18
C72 (\17\:ExtVDD VSS) capacitor c=7.35163e-17
C73 (\12\:Ybint VSS) capacitor c=9.66361e-17
C74 (\15\:Ybint VSS) capacitor c=5.25426e-17
C75 (\18\:Ybint VSS) capacitor c=7.30783e-17
C76 (\2\:VDD VSS) capacitor c=1.54487e-17
Rk68 (VDD VDD) resistor r=0.6016 c=0
Rk69 (VDD \2\:VDD) resistor r=0.2049 c=0
Rk70 (\2\:VDD \4\:VDD) resistor r=0.3311 c=0
Rk12 (ISO \7\:ISO) resistor r=0.03636 c=0
Rk11 (\6\:ISO \7\:ISO) resistor r=0.004571 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.003814 c=0
Rk26 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2489 c=0
Rk27 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9975 c=0
Rk31 (\9\:ExtVDD \10\:ExtVDD) resistor r=0.3122 c=0
Rk32 (\10\:ExtVDD \12\:ExtVDD) resistor r=0.2603 c=0
Rk33 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.9909 c=0
Rk34 (\10\:ExtVDD \15\:ExtVDD) resistor r=0.1174 c=0
Rk36 (\17\:ExtVDD ExtVDD) resistor r=0.001907 c=0
Rk35 (\10\:ExtVDD \17\:ExtVDD) resistor r=0.192 c=0
Rk60 (VSS VSS) resistor r=0.1479 c=0
Rk59 (VSS VSS) resistor r=0.001 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.2463 c=0
Rk49 (\4\:VSS VSS) resistor r=0.3449 c=0
Rk48 (\3\:VSS \4\:VSS) resistor r=0.1477 c=0
Rk51 (\5\:VSS VSS) resistor r=0.1797 c=0
Rk50 (VSS \5\:VSS) resistor r=0.3947 c=0
Rk52 (\3\:VSS \7\:VSS) resistor r=0.2267 c=0
Rk58 (\10\:VSS VSS) resistor r=0.08092 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.2537 c=0
Rk61 (VSS \15\:VSS) resistor r=0.1135 c=0
Rk63 (\16\:VSS VSS) resistor r=0.1699 c=0
Rk62 (\15\:VSS \16\:VSS) resistor r=0.1822 c=0
Rk67 (\15\:VSS \24\:VSS) resistor r=0.2098 c=0
Rk1 (A \11\:A) resistor r=0.008212 c=0
Rk3 (\12\:A A) resistor r=0.005208 c=0
Rk2 (\11\:A \12\:A) resistor r=0.004045 c=0
Rk45 (Y \2\:Y) resistor r=0.02239 c=0
Rk46 (\2\:Y \4\:Y) resistor r=0.6563 c=0
Rk14 (\5\:Yint \8\:Yint) resistor r=0.2147 c=0
Rk18 (\12\:Yint \13\:Yint) resistor r=0.2964 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04277 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4555 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1628 c=0
Rk40 (\8\:Ybint \12\:Ybint) resistor r=0.1765 c=0
Rk41 (\12\:Ybint \14\:Ybint) resistor r=0.6333 c=0
Rk42 (\8\:Ybint \15\:Ybint) resistor r=0.2894 c=0
Rk44 (\18\:Ybint \20\:Ybint) resistor r=0.4523 c=0
Rk21 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.4737 c=0
Rk22 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.6286 c=0
Rk25 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.7591 c=0
Rk29 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.4392 c=0
Rk16 (\13\:ison \15\:ison) resistor r=0.254 c=0
Rk17 (\16\:ison \18\:ison) resistor r=0.4254 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=178.431 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=67.6128 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl23 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl21 (\4\:A \9\:A) resistor r=144.481 c=0
Rl16 (\4\:A \1\:A) resistor r=617.212 c=0
Rl22 (\5\:A \10\:A) resistor r=84.6812 c=0
Rl18 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl17 (\5\:A \4\:A) resistor r=20.529 c=0
Rl10 (\2\:Yint Yint) resistor r=105.33 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=300.227 c=0
Rl38 (\7\:Ybint \6\:Ybint) resistor r=141.321 c=0
Rl13 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl37 (\4\:Ybint \6\:Ybint) resistor r=132.409 c=0
Rl35 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl36 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rl30 (ison \8\:ison) resistor r=150.846 c=0
Rl28 (\6\:ison ison) resistor r=72.842 c=0
Rl34 (\6\:ison \12\:ison) resistor r=116.573 c=0
Rl29 (\6\:ison \7\:ison) resistor r=51.6001 c=0
Rz15 (\7\:VSS \6\:VSS) resistor r=37.5 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz14 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz6 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Rz4 (\15\:ison \14\:ison) resistor r=75 c=0
Ry19 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry4 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry6 (\8\:ExtVDD \9\:ExtVDD) resistor r=20.6667 c=0
Ry7 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry8 (\13\:ExtVDD \14\:ExtVDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry13 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry14 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\9\:VSS \8\:VSS) resistor r=12.4 c=0
Ry16 (\10\:VSS \8\:VSS) resistor r=15.5 c=0
Ry18 (\16\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry11 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry9 (\14\:Ybint \13\:Ybint) resistor r=62 c=0
Ry10 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Ry2 (\18\:ison \17\:ison) resistor r=62 c=0
Rx3 (\3\:ISO \6\:ISO) resistor r=45 c=0
Rx9 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx11 (\1\:ExtVDD \15\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx4 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx7 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx12 (\12\:Ybint \2\:Ybint) resistor r=45 c=0
Rx13 (\15\:Ybint \5\:Ybint) resistor r=45 c=0
Rx14 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx10 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx5 (\13\:ison \7\:ison) resistor r=45 c=0
Rx6 (\16\:ison \12\:ison) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM4 (\23\:VSS \4\:ISO \14\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\8\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\15\:GatedVSS ison \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\3\:Y \3\:Ybint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\13\:Ybint \4\:Yint \13\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM5 (\17\:ison \1\:ISO \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.098 \
        scb=0.0218837 scc=0.000978838 m=(1)
PM1 (\11\:Yint Ybint \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM3 (\19\:Ybint \8\:ison \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.4753 \
        scb=0.0115009 scc=0.000423885 m=(1)
mp0 (\1\:Y \6\:Ybint \8\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.532 scb=0.0217466 \
        scc=0.00133989 m=(1)
ends LSLH_ISOL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:35:43 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOL_X1_TO_ON A ExtVDD ISO VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.1303 \
        scb=0.0290334 scc=0.0012433 m=(1)
C1 (VDD VSS) capacitor c=4.46449e-16
C2 (A VSS) capacitor c=2.183e-17
C3 (ISO VSS) capacitor c=3.21905e-17
C4 (ExtVDD VSS) capacitor c=1.45443e-16
C5 (Yint VSS) capacitor c=3.76828e-17
C6 (Ab VSS) capacitor c=1.51784e-16
C7 (ison VSS) capacitor c=3.68731e-17
C8 (Ybint VSS) capacitor c=2.67741e-17
C9 (GatedVSS VSS) capacitor c=3.41015e-17
C10 (\6\:Ybint VSS) capacitor c=4.27577e-17
C11 (\1\:ISO VSS) capacitor c=2.47254e-17
C12 (\4\:Yint VSS) capacitor c=2.69811e-17
C13 (\9\:A VSS) capacitor c=4.84255e-17
C14 (\3\:Ybint VSS) capacitor c=2.60416e-17
C15 (\1\:A VSS) capacitor c=2.04761e-16
C16 (\4\:ISO VSS) capacitor c=5.60413e-17
C17 (\10\:A VSS) capacitor c=2.4381e-17
C18 (\7\:Ybint VSS) capacitor c=3.76917e-17
C19 (\5\:Ybint VSS) capacitor c=6.58921e-18
C20 (\2\:Ybint VSS) capacitor c=2.57056e-17
C21 (\11\:ison VSS) capacitor c=3.39387e-17
C22 (\6\:ison VSS) capacitor c=1.87229e-17
C23 (\3\:ISO VSS) capacitor c=5.34582e-17
C24 (\3\:Yint VSS) capacitor c=2.38248e-17
C25 (\2\:GatedVSS VSS) capacitor c=2.73843e-17
C26 (\4\:Ab VSS) capacitor c=6.13072e-17
C27 (\6\:A VSS) capacitor c=2.2138e-17
C28 (\3\:Y VSS) capacitor c=1.15551e-16
C29 (\1\:VDD VSS) capacitor c=7.24739e-17
C30 (\19\:Ybint VSS) capacitor c=4.07411e-17
C31 (\8\:VDD VSS) capacitor c=4.40829e-17
C32 (\10\:VDD VSS) capacitor c=3.37893e-17
C33 (\11\:Yint VSS) capacitor c=5.49889e-17
C34 (\16\:ison VSS) capacitor c=3.87391e-17
C35 (\12\:VDD VSS) capacitor c=4.73106e-17
C36 (\12\:Ybint VSS) capacitor c=8.48956e-17
C37 (\14\:VDD VSS) capacitor c=5.21309e-17
C38 (\7\:Ab VSS) capacitor c=8.86566e-17
C39 (\3\:ExtVDD VSS) capacitor c=3.52654e-17
C40 (\1\:Y VSS) capacitor c=5.31053e-17
C41 (\15\:GatedVSS VSS) capacitor c=3.25999e-16
C42 (\3\:GatedVSS VSS) capacitor c=3.63234e-16
C43 (\5\:Yint VSS) capacitor c=1.88031e-16
C44 (\13\:ison VSS) capacitor c=5.13771e-17
C45 (\10\:Ab VSS) capacitor c=6.62522e-17
C46 (\8\:GatedVSS VSS) capacitor c=1.1072e-16
C47 (VDD VSS) capacitor c=4.62579e-17
C48 (\2\:Yint VSS) capacitor c=2.4569e-17
C49 (\4\:A VSS) capacitor c=1.62446e-16
C50 (\5\:A VSS) capacitor c=2.30364e-17
C51 (\2\:ison VSS) capacitor c=1.55321e-16
C52 (\4\:Ybint VSS) capacitor c=1.41669e-17
C53 (\12\:A VSS) capacitor c=4.13711e-17
C54 (\9\:Ab VSS) capacitor c=1.05527e-16
C55 (\8\:Yint VSS) capacitor c=3.85438e-17
C56 (\6\:ISO VSS) capacitor c=8.20041e-18
C57 (\8\:ISO VSS) capacitor c=2.44957e-17
C58 (\12\:ison VSS) capacitor c=5.89189e-17
C59 (\13\:Yint VSS) capacitor c=3.31167e-17
C60 (\15\:ison VSS) capacitor c=4.54437e-17
C61 (\7\:GatedVSS VSS) capacitor c=1.86961e-16
C62 (\14\:GatedVSS VSS) capacitor c=1.03735e-16
C63 (\18\:GatedVSS VSS) capacitor c=8.06668e-17
C64 (\8\:Ybint VSS) capacitor c=4.50395e-17
C65 (\9\:Ybint VSS) capacitor c=1.73325e-16
C66 (\11\:Ybint VSS) capacitor c=6.3548e-17
C67 (\18\:Ybint VSS) capacitor c=3.06398e-17
C68 (\3\:VDD VSS) capacitor c=6.45309e-17
C69 (\4\:VDD VSS) capacitor c=2.48979e-17
C70 (\6\:VDD VSS) capacitor c=2.84313e-17
C71 (\7\:VDD VSS) capacitor c=1.69236e-17
Rk49 (VDD VDD) resistor r=0.3048 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.4462 c=0
Rk45 (\3\:VDD \4\:VDD) resistor r=0.1593 c=0
Rk46 (\4\:VDD \6\:VDD) resistor r=0.2185 c=0
Rk48 (\7\:VDD VDD) resistor r=0.1844 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.03913 c=0
Rk50 (\3\:VDD \9\:VDD) resistor r=0.2979 c=0
Rk51 (\4\:VDD \11\:VDD) resistor r=0.2408 c=0
Rk52 (\7\:VDD \13\:VDD) resistor r=0.2566 c=0
Rk53 (VDD \15\:VDD) resistor r=0.2859 c=0
Rk61 (VSS VSS) resistor r=0.317 c=0
Rk42 (VSS VSS) resistor r=0.2777 c=0
Rk41 (\4\:VSS VSS) resistor r=0.5895 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.4817 c=0
Rk43 (VSS \5\:VSS) resistor r=0.1157 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.1325 c=0
Rk60 (\13\:VSS VSS) resistor r=0.2455 c=0
Rk59 (\8\:VSS \13\:VSS) resistor r=0.05387 c=0
Rk62 (VSS \14\:VSS) resistor r=0.07642 c=0
Rk4 (A \12\:A) resistor r=0.01985 c=0
Rk3 (\12\:A \13\:A) resistor r=0.002167 c=0
Rk13 (\5\:ISO ISO) resistor r=0.00414 c=0
Rk14 (ISO \6\:ISO) resistor r=0.00414 c=0
Rk15 (\5\:ISO \6\:ISO) resistor r=0.007372 c=0
Rk17 (\6\:ISO \8\:ISO) resistor r=0.02924 c=0
Rk16 (\7\:ISO \8\:ISO) resistor r=0.00414 c=0
Rk5 (ExtVDD ExtVDD) resistor r=0.01053 c=0
Rk6 (ExtVDD \2\:ExtVDD) resistor r=0.00653 c=0
Rk7 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.3218 c=0
Rk38 (\2\:Y Y) resistor r=0.3888 c=0
Rk39 (Y \4\:Y) resistor r=0.2155 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2012 c=0
Rk19 (\12\:Yint \13\:Yint) resistor r=0.2046 c=0
Rk8 (\8\:Ab \9\:Ab) resistor r=0.6832 c=0
Rk9 (\9\:Ab \11\:Ab) resistor r=0.4471 c=0
Rk18 (\12\:ison \14\:ison) resistor r=0.382 c=0
Rk20 (\15\:ison \17\:ison) resistor r=0.2456 c=0
Rk31 (\8\:Ybint \9\:Ybint) resistor r=0.2475 c=0
Rk33 (\9\:Ybint \11\:Ybint) resistor r=0.1519 c=0
Rk34 (\11\:Ybint \13\:Ybint) resistor r=0.5779 c=0
Rk37 (\18\:Ybint \20\:Ybint) resistor r=0.2764 c=0
Rk23 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.356 c=0
Rk24 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.7656 c=0
Rk27 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.8118 c=0
Rk29 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.1454 c=0
Rl21 (\4\:A \9\:A) resistor r=239.672 c=0
Rl16 (\4\:A \1\:A) resistor r=494.483 c=0
Rl22 (\5\:A \10\:A) resistor r=59.022 c=0
Rl18 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl17 (\5\:A \4\:A) resistor r=192.732 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=56.5719 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=193.396 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=0.6051 c=0
Rl10 (\2\:Yint Yint) resistor r=148.662 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=178.013 c=0
Rl23 (\2\:ison ison) resistor r=165.444 c=0
Rl32 (\2\:ison \11\:ison) resistor r=115.398 c=0
Rl27 (\2\:ison \6\:ison) resistor r=4.4574 c=0
Rl36 (\7\:Ybint \6\:Ybint) resistor r=173.707 c=0
Rl13 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl35 (\4\:Ybint \6\:Ybint) resistor r=90.3549 c=0
Rl33 (\4\:Ybint \3\:Ybint) resistor r=52.8549 c=0
Rl34 (\4\:Ybint \5\:Ybint) resistor r=1.2666 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz14 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz5 (\14\:ison \13\:ison) resistor r=75 c=0
Rz7 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry8 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry9 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\7\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry17 (\8\:VSS \6\:VSS) resistor r=15.5 c=0
Ry18 (\13\:VSS \6\:VSS) resistor r=62 c=0
Ry19 (\14\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry7 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\17\:ison \16\:ison) resistor r=62 c=0
Ry5 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Ry6 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Rx1 (\13\:A \6\:A) resistor r=45 c=0
Rx4 (\3\:ISO \7\:ISO) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx6 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\12\:ison \6\:ison) resistor r=45 c=0
Rx7 (\15\:ison \11\:ison) resistor r=45 c=0
Rx10 (\8\:Ybint \5\:Ybint) resistor r=45 c=0
Rx11 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx12 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx9 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM4 (\8\:VSS \4\:ISO \13\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\9\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\15\:GatedVSS \2\:ison \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.081e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\1\:Y \3\:Ybint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
PM0 (\12\:Ybint \4\:Yint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM5 (\16\:ison \1\:ISO \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.91404 \
        scb=0.00557767 scc=4.88511e-05 m=(1)
PM1 (\11\:Yint Ybint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM3 (\19\:Ybint ison \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.42101 \
        scb=0.00673238 scc=0.000108878 m=(1)
mp0 (\3\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.1596 \
        scb=0.0161183 scc=0.000480878 m=(1)
ends LSLH_ISOL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 21:53:23 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONH_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ISOn VSS) capacitor c=1.948e-17
C2 (ExtVDD VSS) capacitor c=2.61434e-16
C3 (VDD VSS) capacitor c=1.18746e-16
C4 (A VSS) capacitor c=3.3149e-17
C5 (Y VSS) capacitor c=4.68504e-17
C6 (Yint VSS) capacitor c=3.5255e-17
C7 (Ab VSS) capacitor c=1.65406e-16
C8 (Ybint VSS) capacitor c=3.08413e-17
C9 (GatedVSS VSS) capacitor c=3.4232e-17
C10 (\6\:Ybint VSS) capacitor c=4.08762e-17
C11 (\7\:ISOn VSS) capacitor c=2.94738e-17
C12 (\4\:Yint VSS) capacitor c=2.73734e-17
C13 (\9\:A VSS) capacitor c=3.93394e-17
C14 (\3\:Ybint VSS) capacitor c=2.96253e-17
C15 (\1\:A VSS) capacitor c=2.32018e-16
C16 (\10\:A VSS) capacitor c=2.8859e-17
C17 (\1\:ISOn VSS) capacitor c=1.92199e-17
C18 (\5\:Ybint VSS) capacitor c=1.09108e-17
C19 (\1\:Y VSS) capacitor c=4.27034e-17
C20 (\2\:Y VSS) capacitor c=4.39893e-17
C21 (\1\:ExtVDD VSS) capacitor c=2.43515e-17
C22 (\2\:ExtVDD VSS) capacitor c=3.20879e-17
C23 (\2\:Ybint VSS) capacitor c=2.18082e-17
C24 (\3\:Yint VSS) capacitor c=2.30619e-17
C25 (\2\:GatedVSS VSS) capacitor c=3.18112e-17
C26 (\4\:Ab VSS) capacitor c=7.76865e-17
C27 (\6\:A VSS) capacitor c=1.67241e-17
C28 (\6\:Y VSS) capacitor c=6.98497e-17
C29 (\6\:ExtVDD VSS) capacitor c=6.96862e-17
C30 (\4\:Y VSS) capacitor c=5.58185e-17
C31 (\4\:ExtVDD VSS) capacitor c=5.32054e-17
C32 (\10\:ExtVDD VSS) capacitor c=1.21411e-16
C33 (\11\:Yint VSS) capacitor c=6.27864e-17
C34 (\12\:Ybint VSS) capacitor c=9.05028e-17
C35 (\12\:ExtVDD VSS) capacitor c=1.32742e-16
C36 (\9\:Ab VSS) capacitor c=6.07479e-17
C37 (\3\:VDD VSS) capacitor c=3.70827e-17
C38 (\9\:Y VSS) capacitor c=7.15127e-17
C39 (\9\:GatedVSS VSS) capacitor c=9.94326e-17
C40 (\3\:GatedVSS VSS) capacitor c=2.59099e-16
C41 (\7\:Ybint VSS) capacitor c=2.167e-16
C42 (\5\:Yint VSS) capacitor c=1.9738e-16
C43 (\11\:Ab VSS) capacitor c=3.98405e-17
C44 (\15\:GatedVSS VSS) capacitor c=9.83233e-17
C45 (VDD VSS) capacitor c=3.76108e-16
C46 (\2\:Yint VSS) capacitor c=1.86518e-17
C47 (\4\:A VSS) capacitor c=1.29512e-16
C48 (\5\:A VSS) capacitor c=2.14757e-17
C49 (ExtVDD VSS) capacitor c=7.37762e-17
C50 (\4\:Ybint VSS) capacitor c=1.71421e-17
C51 (\2\:ISOn VSS) capacitor c=1.91979e-17
C52 (\3\:ISOn VSS) capacitor c=1.21393e-16
C53 (\12\:A VSS) capacitor c=2.46915e-17
C54 (\7\:Ab VSS) capacitor c=1.00258e-17
C55 (\8\:Ab VSS) capacitor c=6.13579e-17
C56 (\8\:Yint VSS) capacitor c=3.9648e-17
C57 (\13\:Yint VSS) capacitor c=5.45674e-17
C58 (\3\:ExtVDD VSS) capacitor c=3.73552e-17
C59 (\6\:GatedVSS VSS) capacitor c=9.65195e-17
C60 (\3\:Y VSS) capacitor c=3.34535e-17
C61 (\11\:GatedVSS VSS) capacitor c=4.33508e-16
C62 (\14\:GatedVSS VSS) capacitor c=1.65347e-16
C63 (\23\:GatedVSS VSS) capacitor c=7.77529e-17
C64 (\8\:ExtVDD VSS) capacitor c=1.79618e-17
C65 (\9\:ExtVDD VSS) capacitor c=9.27324e-18
C66 (\11\:Ybint VSS) capacitor c=9.88481e-17
C67 (\14\:Ybint VSS) capacitor c=5.3638e-17
C68 (\11\:ISOn VSS) capacitor c=1.20249e-17
C69 (\8\:Y VSS) capacitor c=8.21412e-17
C70 (\2\:VDD VSS) capacitor c=1.47933e-17
Rk40 (ISOn \11\:ISOn) resistor r=0.03448 c=0
Rk33 (ExtVDD ExtVDD) resistor r=0.00571 c=0
Rk13 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2983 c=0
Rk31 (\8\:ExtVDD ExtVDD) resistor r=0.1916 c=0
Rk27 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.2771 c=0
Rk28 (\8\:ExtVDD \9\:ExtVDD) resistor r=0.1171 c=0
Rk29 (\8\:ExtVDD \11\:ExtVDD) resistor r=0.2598 c=0
Rk30 (\11\:ExtVDD \13\:ExtVDD) resistor r=0.9888 c=0
Rk57 (VDD VDD) resistor r=0.6001 c=0
Rk58 (VDD \2\:VDD) resistor r=0.2044 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.3304 c=0
Rk51 (VSS VSS) resistor r=0.1476 c=0
Rk50 (VSS VSS) resistor r=0.001 c=0
Rk49 (\3\:VSS VSS) resistor r=0.08072 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.2531 c=0
Rk53 (\8\:VSS VSS) resistor r=0.1077 c=0
Rk60 (\16\:VSS VSS) resistor r=0.59 c=0
Rk62 (\17\:VSS VSS) resistor r=0.1793 c=0
Rk61 (VSS \17\:VSS) resistor r=0.3937 c=0
Rk1 (A \11\:A) resistor r=0.01009 c=0
Rk3 (\12\:A A) resistor r=0.006056 c=0
Rk2 (\11\:A \12\:A) resistor r=0.003802 c=0
Rk17 (\3\:Y \5\:Y) resistor r=0.2947 c=0
Rk41 (Y \7\:Y) resistor r=0.04964 c=0
Rk42 (\7\:Y \8\:Y) resistor r=0.4706 c=0
Rk43 (Y \10\:Y) resistor r=0.4465 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2143 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2958 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04264 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4587 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1593 c=0
Rk36 (\7\:Ybint \11\:Ybint) resistor r=0.1762 c=0
Rk37 (\11\:Ybint \13\:Ybint) resistor r=0.632 c=0
Rk38 (\7\:Ybint \14\:Ybint) resistor r=0.2887 c=0
Rk15 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.4211 c=0
Rk18 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.5664 c=0
Rk21 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.4727 c=0
Rk22 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.6273 c=0
Rk26 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.7575 c=0
Rl30 (\2\:ISOn \7\:ISOn) resistor r=45.8958 c=0
Rl25 (\2\:ISOn \1\:ISOn) resistor r=100.588 c=0
Rl26 (\3\:ISOn \2\:ISOn) resistor r=49.6935 c=0
Rl20 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl18 (\4\:A \9\:A) resistor r=132.549 c=0
Rl13 (\4\:A \1\:A) resistor r=624.028 c=0
Rl19 (\5\:A \10\:A) resistor r=86.3858 c=0
Rl15 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl14 (\5\:A \4\:A) resistor r=27.3472 c=0
Rl21 (\1\:Y \2\:Y) resistor r=107.339 c=0
Rl7 (\2\:Yint Yint) resistor r=105.33 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=297.11 c=0
Rl10 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl24 (\4\:Ybint \6\:Ybint) resistor r=110.249 c=0
Rl22 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl23 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rz14 (\9\:Y \10\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz6 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz7 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Ry3 (\4\:ExtVDD \5\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=20.6667 c=0
Ry6 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry7 (\12\:ExtVDD \13\:ExtVDD) resistor r=62 c=0
Ry14 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry13 (\8\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry15 (\16\:VSS \15\:VSS) resistor r=7.75 c=0
Ry16 (\17\:VSS \15\:VSS) resistor r=5.1667 c=0
Ry4 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry9 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry8 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Rx12 (\11\:ISOn \1\:ISOn) resistor r=45 c=0
Rx5 (\2\:ExtVDD \3\:ExtVDD) resistor r=45 c=0
Rx9 (\1\:ExtVDD \9\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx7 (\2\:Y \3\:Y) resistor r=45 c=0
Rx13 (\1\:Y \8\:Y) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx10 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx11 (\14\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx8 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\7\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\3\:GatedVSS \3\:ISOn \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\9\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
PM0 (\12\:Ybint \4\:Yint \12\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM4 (\4\:Y \7\:ISOn \4\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=23.3418 \
        scb=0.0184105 scc=0.00243166 m=(1)
mp0 (\6\:Y \6\:Ybint \6\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.9449 \
        scb=0.0249757 scc=0.00165614 m=(1)
ends LSLH_ISONH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:36:33 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONL_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ExtVDD VSS) capacitor c=2.72249e-16
C2 (ISOn VSS) capacitor c=2.01359e-17
C3 (Y VSS) capacitor c=4.93517e-17
C4 (A VSS) capacitor c=3.89629e-17
C5 (VDD VSS) capacitor c=1.19413e-16
C6 (Yint VSS) capacitor c=3.52641e-17
C7 (Ab VSS) capacitor c=1.65406e-16
C8 (Ybint VSS) capacitor c=3.09949e-17
C9 (GatedVSS VSS) capacitor c=3.4232e-17
C10 (\6\:Ybint VSS) capacitor c=4.46142e-17
C11 (\7\:ISOn VSS) capacitor c=2.4327e-17
C12 (\4\:Yint VSS) capacitor c=2.73734e-17
C13 (\9\:A VSS) capacitor c=3.93489e-17
C14 (\3\:Ybint VSS) capacitor c=2.89525e-17
C15 (\1\:ISOn VSS) capacitor c=1.26759e-16
C16 (\1\:A VSS) capacitor c=2.3019e-16
C17 (\10\:A VSS) capacitor c=2.84041e-17
C18 (\7\:Ybint VSS) capacitor c=3.50612e-17
C19 (\5\:Ybint VSS) capacitor c=1.0871e-17
C20 (\6\:ISOn VSS) capacitor c=2.10212e-17
C21 (\1\:ExtVDD VSS) capacitor c=1.33093e-17
C22 (\2\:ExtVDD VSS) capacitor c=1.72205e-17
C23 (\2\:Ybint VSS) capacitor c=2.21555e-17
C24 (\3\:Yint VSS) capacitor c=2.30619e-17
C25 (\2\:GatedVSS VSS) capacitor c=3.18112e-17
C26 (\4\:Ab VSS) capacitor c=7.73912e-17
C27 (\6\:A VSS) capacitor c=1.46443e-17
C28 (\1\:Y VSS) capacitor c=5.58689e-17
C29 (\6\:ExtVDD VSS) capacitor c=5.86837e-17
C30 (\19\:Ybint VSS) capacitor c=5.39341e-17
C31 (\4\:ExtVDD VSS) capacitor c=3.3987e-17
C32 (\9\:ExtVDD VSS) capacitor c=1.1654e-16
C33 (\11\:Yint VSS) capacitor c=6.28175e-17
C34 (\13\:Ybint VSS) capacitor c=9.04939e-17
C35 (\11\:ExtVDD VSS) capacitor c=1.32742e-16
C36 (\9\:Ab VSS) capacitor c=6.07479e-17
C37 (\3\:VDD VSS) capacitor c=3.7534e-17
C38 (\3\:Y VSS) capacitor c=7.13921e-17
C39 (\15\:GatedVSS VSS) capacitor c=2.76446e-16
C40 (\8\:Ybint VSS) capacitor c=2.08276e-16
C41 (\3\:GatedVSS VSS) capacitor c=3.89372e-16
C42 (\5\:Yint VSS) capacitor c=1.97378e-16
C43 (\11\:Ab VSS) capacitor c=3.98405e-17
C44 (\8\:GatedVSS VSS) capacitor c=9.9143e-17
C45 (VDD VSS) capacitor c=3.75931e-16
C46 (\2\:Yint VSS) capacitor c=1.86518e-17
C47 (\4\:A VSS) capacitor c=1.34986e-16
C48 (\5\:A VSS) capacitor c=2.0289e-17
C49 (ExtVDD VSS) capacitor c=7.48679e-17
C50 (\4\:Ybint VSS) capacitor c=1.91542e-17
C51 (\12\:A VSS) capacitor c=1.92402e-17
C52 (\7\:Ab VSS) capacitor c=1.00258e-17
C53 (\8\:Ab VSS) capacitor c=6.16615e-17
C54 (\8\:Yint VSS) capacitor c=3.96535e-17
C55 (\13\:Yint VSS) capacitor c=5.45674e-17
C56 (\7\:GatedVSS VSS) capacitor c=1.65325e-16
C57 (\14\:GatedVSS VSS) capacitor c=7.77839e-17
C58 (\3\:ExtVDD VSS) capacitor c=3.74223e-17
C59 (\18\:GatedVSS VSS) capacitor c=9.58871e-17
C60 (\10\:ISOn VSS) capacitor c=2.99614e-17
C61 (\12\:ISOn VSS) capacitor c=1.97083e-17
C62 (\8\:ExtVDD VSS) capacitor c=1.63715e-17
C63 (\13\:ExtVDD VSS) capacitor c=7.98939e-18
C64 (\12\:Ybint VSS) capacitor c=9.8845e-17
C65 (\15\:Ybint VSS) capacitor c=5.2598e-17
C66 (\18\:Ybint VSS) capacitor c=7.54285e-17
C67 (\2\:VDD VSS) capacitor c=1.52128e-17
Rk35 (ExtVDD ExtVDD) resistor r=0.005706 c=0
Rk20 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2586 c=0
Rk33 (\8\:ExtVDD ExtVDD) resistor r=0.1914 c=0
Rk29 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.3113 c=0
Rk30 (\8\:ExtVDD \10\:ExtVDD) resistor r=0.2596 c=0
Rk31 (\10\:ExtVDD \12\:ExtVDD) resistor r=0.9881 c=0
Rk32 (\8\:ExtVDD \13\:ExtVDD) resistor r=0.117 c=0
Rk58 (VSS VSS) resistor r=0.1474 c=0
Rk57 (VSS VSS) resistor r=0.001 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.2455 c=0
Rk47 (\4\:VSS VSS) resistor r=0.3438 c=0
Rk46 (\3\:VSS \4\:VSS) resistor r=0.1472 c=0
Rk49 (\5\:VSS VSS) resistor r=0.1791 c=0
Rk48 (VSS \5\:VSS) resistor r=0.3934 c=0
Rk50 (\3\:VSS \7\:VSS) resistor r=0.226 c=0
Rk56 (\10\:VSS VSS) resistor r=0.08065 c=0
Rk51 (\9\:VSS \10\:VSS) resistor r=0.2529 c=0
Rk59 (VSS \15\:VSS) resistor r=0.1076 c=0
Rk24 (\10\:ISOn \11\:ISOn) resistor r=0.003842 c=0
Rk25 (ISOn \12\:ISOn) resistor r=0.003842 c=0
Rk26 (\10\:ISOn \12\:ISOn) resistor r=0.03954 c=0
Rk27 (\13\:ISOn ISOn) resistor r=0.003842 c=0
Rk28 (\12\:ISOn \13\:ISOn) resistor r=0.02501 c=0
Rk43 (Y \2\:Y) resistor r=0.06961 c=0
Rk44 (Y \4\:Y) resistor r=0.4416 c=0
Rk1 (A \11\:A) resistor r=0.008637 c=0
Rk3 (\12\:A A) resistor r=0.005477 c=0
Rk2 (\11\:A \12\:A) resistor r=0.003026 c=0
Rk64 (VDD VDD) resistor r=0.5996 c=0
Rk65 (VDD \2\:VDD) resistor r=0.2042 c=0
Rk66 (\2\:VDD \4\:VDD) resistor r=0.3302 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2141 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2956 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.0426 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4575 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1592 c=0
Rk38 (\8\:Ybint \12\:Ybint) resistor r=0.176 c=0
Rk39 (\12\:Ybint \14\:Ybint) resistor r=0.6316 c=0
Rk40 (\8\:Ybint \15\:Ybint) resistor r=0.2885 c=0
Rk42 (\18\:Ybint \20\:Ybint) resistor r=0.4583 c=0
Rk15 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.4724 c=0
Rk16 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.6269 c=0
Rk19 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.757 c=0
Rk22 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.4202 c=0
Rl20 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl26 (\6\:ISOn \7\:ISOn) resistor r=44.2107 c=0
Rl25 (\1\:ISOn \6\:ISOn) resistor r=77.3687 c=0
Rl18 (\4\:A \9\:A) resistor r=126.472 c=0
Rl13 (\4\:A \1\:A) resistor r=624.028 c=0
Rl19 (\5\:A \10\:A) resistor r=82.9767 c=0
Rl15 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl14 (\5\:A \4\:A) resistor r=30.7563 c=0
Rl7 (\2\:Yint Yint) resistor r=105.33 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=297.11 c=0
Rl32 (\7\:Ybint \6\:Ybint) resistor r=141.321 c=0
Rl10 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl31 (\4\:Ybint \6\:Ybint) resistor r=132.409 c=0
Rl29 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl30 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rz14 (\7\:VSS \6\:VSS) resistor r=37.5 c=0
Rz13 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz5 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry3 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry4 (\6\:ExtVDD \7\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\9\:ExtVDD \10\:ExtVDD) resistor r=62 c=0
Ry6 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry11 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\9\:VSS \8\:VSS) resistor r=12.4 c=0
Ry14 (\10\:VSS \8\:VSS) resistor r=15.5 c=0
Ry16 (\15\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry9 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry17 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry7 (\14\:Ybint \13\:Ybint) resistor r=62 c=0
Ry8 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Rx6 (\2\:ExtVDD \3\:ExtVDD) resistor r=45 c=0
Rx9 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx8 (\11\:ISOn \6\:ISOn) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx10 (\12\:Ybint \2\:Ybint) resistor r=45 c=0
Rx11 (\15\:Ybint \5\:Ybint) resistor r=45 c=0
Rx12 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx5 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx7 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\8\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\15\:GatedVSS \1\:ISOn \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\3\:Y \3\:Ybint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\13\:Ybint \4\:Yint \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM3 (\19\:Ybint \7\:ISOn \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.0047 \
        scb=0.0122487 scc=0.000500332 m=(1)
mp0 (\1\:Y \6\:Ybint \6\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.532 scb=0.0217466 \
        scc=0.00133989 m=(1)
ends LSLH_ISONL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:37:19 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONL_X1_TO_ON A ExtVDD ISOn VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4762 \
        scb=0.0265201 scc=0.001017 m=(1)
C1 (ISOn VSS) capacitor c=3.29524e-17
C2 (ExtVDD VSS) capacitor c=1.08421e-16
C3 (Y VSS) capacitor c=2.58453e-17
C4 (A VSS) capacitor c=1.71904e-17
C5 (VDD VSS) capacitor c=3.92566e-16
C6 (Yint VSS) capacitor c=3.78068e-17
C7 (Ab VSS) capacitor c=1.51782e-16
C8 (Ybint VSS) capacitor c=2.67784e-17
C9 (GatedVSS VSS) capacitor c=3.34551e-17
C10 (\6\:Ybint VSS) capacitor c=3.24279e-17
C11 (\1\:ISOn VSS) capacitor c=3.04514e-17
C12 (\4\:Yint VSS) capacitor c=2.69335e-17
C13 (\9\:A VSS) capacitor c=4.79921e-17
C14 (\3\:Ybint VSS) capacitor c=3.90115e-17
C15 (\1\:A VSS) capacitor c=2.01838e-16
C16 (\10\:A VSS) capacitor c=2.4381e-17
C17 (\7\:Ybint VSS) capacitor c=3.95107e-17
C18 (\5\:Ybint VSS) capacitor c=7.45139e-18
C19 (\2\:ISOn VSS) capacitor c=2.52053e-17
C20 (\2\:Ybint VSS) capacitor c=2.62202e-17
C21 (\3\:Yint VSS) capacitor c=2.38248e-17
C22 (\2\:GatedVSS VSS) capacitor c=3.09364e-17
C23 (\4\:Ab VSS) capacitor c=6.1308e-17
C24 (\6\:A VSS) capacitor c=2.21142e-17
C25 (\2\:Y VSS) capacitor c=3.4033e-17
C26 (\1\:VDD VSS) capacitor c=5.55557e-17
C27 (\8\:Ybint VSS) capacitor c=3.86213e-17
C28 (\7\:VDD VSS) capacitor c=3.28732e-17
C29 (\9\:VDD VSS) capacitor c=3.56191e-17
C30 (\11\:Yint VSS) capacitor c=5.52764e-17
C31 (\15\:Ybint VSS) capacitor c=8.50244e-17
C32 (\11\:VDD VSS) capacitor c=5.21861e-17
C33 (\7\:Ab VSS) capacitor c=8.91235e-17
C34 (\3\:ExtVDD VSS) capacitor c=3.52759e-17
C35 (\4\:Y VSS) capacitor c=4.59043e-17
C36 (\15\:GatedVSS VSS) capacitor c=2.2705e-16
C37 (\3\:GatedVSS VSS) capacitor c=3.67812e-16
C38 (\5\:Yint VSS) capacitor c=1.88002e-16
C39 (\10\:Ab VSS) capacitor c=6.66614e-17
C40 (\8\:GatedVSS VSS) capacitor c=1.10818e-16
C41 (ExtVDD VSS) capacitor c=4.36338e-17
C42 (VDD VSS) capacitor c=4.14305e-17
C43 (\2\:Yint VSS) capacitor c=2.45022e-17
C44 (\4\:A VSS) capacitor c=1.63748e-16
C45 (\5\:A VSS) capacitor c=2.30476e-17
C46 (\3\:ISOn VSS) capacitor c=1.45038e-16
C47 (\4\:Ybint VSS) capacitor c=2.03968e-17
C48 (\12\:A VSS) capacitor c=4.36627e-18
C49 (\13\:A VSS) capacitor c=4.29675e-17
C50 (\9\:Ab VSS) capacitor c=1.06192e-16
C51 (\8\:Yint VSS) capacitor c=3.90312e-17
C52 (\13\:Yint VSS) capacitor c=3.2125e-17
C53 (\7\:GatedVSS VSS) capacitor c=1.87133e-16
C54 (\14\:GatedVSS VSS) capacitor c=1.03867e-16
C55 (\18\:GatedVSS VSS) capacitor c=7.32061e-17
C56 (\10\:Ybint VSS) capacitor c=4.76346e-17
C57 (\11\:Ybint VSS) capacitor c=3.9809e-17
C58 (\12\:Ybint VSS) capacitor c=1.8525e-16
C59 (\14\:Ybint VSS) capacitor c=5.99036e-17
C60 (\10\:ISOn VSS) capacitor c=2.25156e-17
C61 (\1\:Y VSS) capacitor c=5.55152e-17
C62 (\3\:VDD VSS) capacitor c=6.7534e-17
C63 (\4\:VDD VSS) capacitor c=1.69854e-17
C64 (\6\:VDD VSS) capacitor c=4.30207e-17
Rk31 (ISOn \10\:ISOn) resistor r=0.04068 c=0
Rk54 (VSS VSS) resistor r=0.3214 c=0
Rk37 (VSS VSS) resistor r=0.2821 c=0
Rk36 (\4\:VSS VSS) resistor r=0.5886 c=0
Rk35 (\2\:VSS \4\:VSS) resistor r=0.3532 c=0
Rk38 (VSS \5\:VSS) resistor r=0.1106 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.1372 c=0
Rk53 (\13\:VSS VSS) resistor r=0.2451 c=0
Rk52 (\8\:VSS \13\:VSS) resistor r=0.04887 c=0
Rk55 (VSS \14\:VSS) resistor r=0.07139 c=0
Rk5 (ExtVDD ExtVDD) resistor r=0.02314 c=0
Rk7 (ExtVDD \4\:ExtVDD) resistor r=0.321 c=0
Rk32 (Y \1\:Y) resistor r=0.002001 c=0
Rk33 (\1\:Y \3\:Y) resistor r=0.2712 c=0
Rk34 (\1\:Y \5\:Y) resistor r=0.4419 c=0
Rk1 (\11\:A A) resistor r=0.002027 c=0
Rk2 (A \12\:A) resistor r=0.002027 c=0
Rk3 (\11\:A \12\:A) resistor r=0.03576 c=0
Rk4 (\12\:A \13\:A) resistor r=0.02298 c=0
Rk43 (VDD VDD) resistor r=0.3093 c=0
Rk39 (\2\:VDD \3\:VDD) resistor r=0.3988 c=0
Rk40 (\3\:VDD \4\:VDD) resistor r=0.1591 c=0
Rk42 (\6\:VDD VDD) resistor r=0.2185 c=0
Rk41 (\4\:VDD \6\:VDD) resistor r=0.2182 c=0
Rk44 (\3\:VDD \8\:VDD) resistor r=0.2637 c=0
Rk45 (\4\:VDD \10\:VDD) resistor r=0.2404 c=0
Rk46 (VDD \12\:VDD) resistor r=0.2855 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2009 c=0
Rk13 (\12\:Yint \13\:Yint) resistor r=0.2043 c=0
Rk8 (\8\:Ab \9\:Ab) resistor r=0.6822 c=0
Rk9 (\9\:Ab \11\:Ab) resistor r=0.4465 c=0
Rk24 (\9\:Ybint \10\:Ybint) resistor r=0.1874 c=0
Rk25 (\11\:Ybint \12\:Ybint) resistor r=0.2117 c=0
Rk27 (\12\:Ybint \14\:Ybint) resistor r=0.06776 c=0
Rk28 (\14\:Ybint \16\:Ybint) resistor r=0.577 c=0
Rk16 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.3555 c=0
Rk17 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.7646 c=0
Rk20 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.8107 c=0
Rk22 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.1309 c=0
Rl20 (\2\:ISOn \1\:ISOn) resistor r=42.9995 c=0
Rl21 (\3\:ISOn \2\:ISOn) resistor r=106.578 c=0
Rl18 (\4\:A \9\:A) resistor r=239.672 c=0
Rl13 (\4\:A \1\:A) resistor r=494.483 c=0
Rl19 (\5\:A \10\:A) resistor r=59.022 c=0
Rl15 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl14 (\5\:A \4\:A) resistor r=192.732 c=0
Rl7 (\2\:Yint Yint) resistor r=148.662 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=178.013 c=0
Rl31 (\7\:Ybint \6\:Ybint) resistor r=138.8 c=0
Rl10 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl30 (\4\:Ybint \6\:Ybint) resistor r=53.7923 c=0
Rl28 (\4\:Ybint \3\:Ybint) resistor r=146.045 c=0
Rl29 (\4\:Ybint \5\:Ybint) resistor r=1.2666 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz14 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz13 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz6 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry7 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry8 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry13 (\7\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry15 (\8\:VSS \6\:VSS) resistor r=15.5 c=0
Ry16 (\13\:VSS \6\:VSS) resistor r=62 c=0
Ry17 (\14\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry6 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry10 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry11 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry12 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\9\:Ybint \8\:Ybint) resistor r=62 c=0
Ry5 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx10 (\10\:ISOn \2\:ISOn) resistor r=45 c=0
Rx1 (\13\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx7 (\10\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\11\:Ybint \5\:Ybint) resistor r=45 c=0
Rx9 (\14\:Ybint \2\:Ybint) resistor r=45 c=0
Rx5 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx6 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\12\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\15\:GatedVSS \3\:ISOn \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\4\:Y \3\:Ybint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.51051 scb=0.00656948 \
        scc=0.000151659 m=(1)
PM0 (\15\:Ybint \4\:Yint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM1 (\11\:Yint Ybint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM3 (\8\:Ybint \1\:ISOn \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.25814 \
        scb=0.0047964 scc=4.57111e-05 m=(1)
mp0 (\2\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2649 scb=0.011266 \
        scc=0.000235246 m=(1)
ends LSLH_ISONL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:38:09 2012 )
// Library name: gsclib045
// Cell name: PBUFX2
// View name: extracted

simulator lang=spectre

subckt PBUFX2 A ExtVDD VDD VSS Y
mp0 (\10\:n0 \4\:A \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=85.3128 \
        scb=0.0561754 scc=0.010057 m=(1)
C1 (VDD VSS) capacitor c=9.57335e-17
C2 (ExtVDD VSS) capacitor c=1.31257e-16
C3 (A VSS) capacitor c=1.89126e-17
C4 (Y VSS) capacitor c=1.62593e-17
C5 (n0 VSS) capacitor c=1.37654e-16
C6 (\4\:A VSS) capacitor c=3.22815e-17
C7 (\1\:A VSS) capacitor c=3.5083e-17
C8 (\4\:n0 VSS) capacitor c=1.05242e-17
C9 (\3\:A VSS) capacitor c=2.16453e-17
C10 (\1\:ExtVDD VSS) capacitor c=2.12981e-16
C11 (\4\:Y VSS) capacitor c=8.37634e-17
C12 (\6\:ExtVDD VSS) capacitor c=7.17234e-17
C13 (\10\:n0 VSS) capacitor c=5.3963e-17
C14 (\1\:Y VSS) capacitor c=6.87617e-17
C15 (\12\:n0 VSS) capacitor c=2.85007e-17
C16 (VDD VSS) capacitor c=2.04433e-16
C17 (\2\:A VSS) capacitor c=3.60981e-17
C18 (\6\:A VSS) capacitor c=3.20658e-17
C19 (\8\:n0 VSS) capacitor c=7.90877e-17
C20 (\9\:n0 VSS) capacitor c=1.13635e-16
C21 (\3\:Y VSS) capacitor c=2.05463e-17
Rk24 (VDD VDD) resistor r=0.3705 c=0
Rk10 (\1\:ExtVDD ExtVDD) resistor r=0.516 c=0
Rk11 (ExtVDD \5\:ExtVDD) resistor r=0.001069 c=0
Rk12 (\5\:ExtVDD ExtVDD) resistor r=0.008653 c=0
Rk13 (ExtVDD \7\:ExtVDD) resistor r=0.2111 c=0
Rk17 (\3\:VSS VSS) resistor r=0.07222 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.2129 c=0
Rk18 (VSS \5\:VSS) resistor r=0.194 c=0
Rk20 (\6\:VSS VSS) resistor r=0.2999 c=0
Rk19 (\5\:VSS \6\:VSS) resistor r=0.03129 c=0
Rk23 (\6\:VSS \12\:VSS) resistor r=0.2247 c=0
Rk25 (\14\:VSS VSS) resistor r=0.581 c=0
Rk27 (\15\:VSS VSS) resistor r=0.4284 c=0
Rk26 (VSS \15\:VSS) resistor r=0.09711 c=0
Rk2 (A \6\:A) resistor r=0.01067 c=0
Rk1 (\5\:A \6\:A) resistor r=0.003321 c=0
Rk7 (\3\:Y Y) resistor r=0.01174 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3422 c=0
Rk8 (\3\:Y \5\:Y) resistor r=0.2528 c=0
Rk3 (\8\:n0 \9\:n0) resistor r=0.5635 c=0
Rk4 (\9\:n0 \11\:n0) resistor r=0.4363 c=0
Rk5 (\9\:n0 \13\:n0) resistor r=0.1971 c=0
Rl3 (\2\:A \4\:A) resistor r=103.572 c=0
Rl1 (\1\:A \2\:A) resistor r=147.89 c=0
Rl2 (\2\:A \3\:A) resistor r=83.7545 c=0
Rl6 (\4\:n0 n0) resistor r=5.8986 c=0
Rz6 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz2 (\2\:Y \1\:Y) resistor r=37.5 c=0
Rz1 (\13\:n0 \12\:n0) resistor r=75 c=0
Ry4 (\7\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry7 (\5\:VSS \1\:VSS) resistor r=6.2 c=0
Ry8 (\14\:VSS \13\:VSS) resistor r=31 c=0
Ry9 (\15\:VSS \13\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry1 (\11\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx2 (\8\:n0 \4\:n0) resistor r=45 c=0
mn0 (\12\:n0 \1\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (\1\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(2)
mp1 (\4\:Y n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=39.1196 \
        scb=0.0322259 scc=0.0036825 m=(2)
ends PBUFX2
// End of subcircuit definition.

// Generated for: spectre (May  3 15:39:11 2012 )
// Library name: gsclib045
// Cell name: PINVX1
// View name: extracted

simulator lang=spectre

subckt PINVX1 A ExtVDD VDD VSS Y
mp0 (\1\:Y \4\:A \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=27.7406 \
        scb=0.0289382 scc=0.002705 m=(1)
C1 (A VSS) capacitor c=4.79013e-17
C2 (VDD VSS) capacitor c=9.72276e-17
C3 (Y VSS) capacitor c=4.5571e-17
C4 (ExtVDD VSS) capacitor c=1.54403e-16
C5 (\4\:A VSS) capacitor c=4.51715e-17
C6 (\1\:A VSS) capacitor c=2.93564e-17
C7 (\3\:A VSS) capacitor c=2.34586e-17
C8 (\3\:ExtVDD VSS) capacitor c=5.89013e-17
C9 (\1\:Y VSS) capacitor c=5.83401e-17
C10 (\3\:Y VSS) capacitor c=5.56273e-17
C11 (VDD VSS) capacitor c=1.06072e-16
C12 (\2\:A VSS) capacitor c=3.50508e-17
Rk2 (A \5\:A) resistor r=0.002585 c=0
Rk12 (VDD VDD) resistor r=0.1178 c=0
Rk10 (\3\:VSS VSS) resistor r=0.01641 c=0
Rk9 (VSS \3\:VSS) resistor r=0.08398 c=0
Rk11 (\3\:VSS \5\:VSS) resistor r=0.2432 c=0
Rk3 (Y \2\:Y) resistor r=0.2882 c=0
Rk4 (Y \4\:Y) resistor r=0.3411 c=0
Rk5 (ExtVDD ExtVDD) resistor r=0.03307 c=0
Rk6 (ExtVDD \2\:ExtVDD) resistor r=0.002274 c=0
Rk7 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.3705 c=0
Rl3 (\2\:A \4\:A) resistor r=144.875 c=0
Rl1 (\1\:A \2\:A) resistor r=49.397 c=0
Rl2 (\2\:A \3\:A) resistor r=90.5727 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\3\:ExtVDD \4\:ExtVDD) resistor r=20.6667 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
mn0 (\3\:Y \1\:A \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
ends PINVX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:40:03 2012 )
// Library name: gsclib045
// Cell name: RDFFNQX1
// View name: extracted

simulator lang=spectre

subckt RDFFNQX1 CKN D ExtVDD Q RT VDD VSS
mp25 (n22 \4\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.9347 \
        scb=0.0157363 scc=0.000368461 m=(1)
C1 (ExtVDD VSS) capacitor c=1.64554e-16
C2 (CKN VSS) capacitor c=5.51427e-17
C3 (D VSS) capacitor c=2.92226e-17
C4 (VDD VSS) capacitor c=4.56718e-16
C5 (RT VSS) capacitor c=3.58154e-17
C6 (Q VSS) capacitor c=3.59258e-17
C7 (CKNb VSS) capacitor c=2.3077e-17
C8 (n20 VSS) capacitor c=4.53919e-17
C9 (CKNbb VSS) capacitor c=5.0043e-17
C10 (mout VSS) capacitor c=5.65117e-17
C11 (n35 VSS) capacitor c=1.46074e-16
C12 (n35g VSS) capacitor c=1.77389e-17
C13 (qbint VSS) capacitor c=4.83353e-17
C14 (RTb VSS) capacitor c=3.93726e-17
C15 (\9\:qbint VSS) capacitor c=2.81469e-17
C16 (\10\:qbint VSS) capacitor c=1.99716e-16
C17 (\14\:CKNb VSS) capacitor c=8.7323e-17
C18 (\4\:RTb VSS) capacitor c=9.8215e-17
C19 (\8\:RT VSS) capacitor c=2.17453e-17
C20 (\4\:qbint VSS) capacitor c=6.83862e-17
C21 (\3\:n35g VSS) capacitor c=4.8225e-17
C22 (\6\:RT VSS) capacitor c=7.62256e-17
C23 (\8\:CKNbb VSS) capacitor c=2.84412e-17
C24 (\4\:CKN VSS) capacitor c=3.25645e-17
C25 (\3\:n20 VSS) capacitor c=5.75688e-17
C26 (\7\:CKNb VSS) capacitor c=2.91832e-17
C27 (\6\:CKNbb VSS) capacitor c=9.46442e-17
C28 (\4\:CKNb VSS) capacitor c=1.29146e-16
C29 (\4\:D VSS) capacitor c=4.85892e-17
C30 (\6\:qbint VSS) capacitor c=3.15278e-17
C31 (\11\:qbint VSS) capacitor c=9.13804e-17
C32 (\3\:CKNbb VSS) capacitor c=3.42421e-16
C33 (\7\:RT VSS) capacitor c=1.6733e-16
C34 (\1\:RT VSS) capacitor c=4.42713e-17
C35 (\5\:qbint VSS) capacitor c=3.91272e-17
C36 (\5\:n35g VSS) capacitor c=2.84973e-17
C37 (\12\:CKNb VSS) capacitor c=2.92085e-17
C38 (\1\:CKN VSS) capacitor c=4.01447e-17
C39 (\6\:n20 VSS) capacitor c=5.10978e-17
C40 (\6\:CKNb VSS) capacitor c=2.92284e-17
C41 (\3\:mout VSS) capacitor c=4.90535e-17
C42 (\13\:CKNb VSS) capacitor c=5.01877e-17
C43 (\2\:CKNbb VSS) capacitor c=7.79653e-17
C44 (\1\:D VSS) capacitor c=6.7744e-17
C45 (\15\:CKNb VSS) capacitor c=5.70506e-17
C46 (\8\:CKNb VSS) capacitor c=1.27472e-16
C47 (\8\:qbint VSS) capacitor c=1.06528e-16
C48 (\3\:RT VSS) capacitor c=1.65656e-16
C49 (\3\:RTb VSS) capacitor c=7.31992e-17
C50 (\4\:RT VSS) capacitor c=4.30708e-17
C51 (\2\:RT VSS) capacitor c=3.89013e-17
C52 (\3\:qbint VSS) capacitor c=3.54796e-17
C53 (\2\:RTb VSS) capacitor c=4.00519e-17
C54 (\2\:n35 VSS) capacitor c=1.65824e-16
C55 (\4\:n35g VSS) capacitor c=6.80084e-17
C56 (\3\:n35 VSS) capacitor c=4.35542e-17
C57 (\3\:CKN VSS) capacitor c=2.72466e-17
C58 (\2\:mout VSS) capacitor c=3.86121e-17
C59 (\4\:mout VSS) capacitor c=4.0206e-17
C60 (\7\:CKNbb VSS) capacitor c=4.24649e-17
C61 (\5\:n20 VSS) capacitor c=4.33896e-17
C62 (\2\:n20 VSS) capacitor c=4.50121e-17
C63 (\5\:CKNb VSS) capacitor c=6.09936e-17
C64 (\11\:CKNb VSS) capacitor c=3.01016e-17
C65 (\3\:D VSS) capacitor c=1.3671e-17
C66 (\1\:VDD VSS) capacitor c=4.45124e-17
C67 (\9\:VDD VSS) capacitor c=2.51715e-17
C68 (\3\:Q VSS) capacitor c=6.11303e-17
C69 (\15\:n35 VSS) capacitor c=4.31357e-17
C70 (\15\:n35g VSS) capacitor c=4.74764e-17
C71 (\6\:RTb VSS) capacitor c=5.77496e-17
C72 (\1\:ExtVDD VSS) capacitor c=2.89947e-16
C73 (\10\:n35 VSS) capacitor c=5.11249e-17
C74 (\14\:qbint VSS) capacitor c=6.76339e-17
C75 (\6\:n35g VSS) capacitor c=8.75619e-17
C76 (\4\:n35 VSS) capacitor c=4.00017e-17
C77 (\20\:CKNb VSS) capacitor c=6.24538e-17
C78 (\5\:mout VSS) capacitor c=5.94436e-17
C79 (\11\:VDD VSS) capacitor c=7.05635e-17
C80 (\13\:VDD VSS) capacitor c=5.98691e-17
C81 (\13\:CKNbb VSS) capacitor c=6.25593e-17
C82 (\13\:n20 VSS) capacitor c=4.6032e-17
C83 (\9\:n20 VSS) capacitor c=9.23953e-17
C84 (\16\:VDD VSS) capacitor c=4.59363e-17
C85 (\1\:Q VSS) capacitor c=4.01289e-17
C86 (\18\:n35 VSS) capacitor c=6.04504e-17
C87 (\11\:n35g VSS) capacitor c=2.95193e-17
C88 (\10\:RTb VSS) capacitor c=5.97655e-17
C89 (\13\:n35 VSS) capacitor c=5.58349e-17
C90 (\16\:qbint VSS) capacitor c=2.40684e-17
C91 (\9\:n35g VSS) capacitor c=7.65622e-17
C92 (\7\:n35 VSS) capacitor c=4.4942e-17
C93 (\22\:CKNb VSS) capacitor c=3.66078e-17
C94 (\10\:mout VSS) capacitor c=5.24732e-17
C95 (\9\:CKNbb VSS) capacitor c=3.74504e-17
C96 (\16\:n20 VSS) capacitor c=4.3754e-17
C97 (\7\:n20 VSS) capacitor c=6.81548e-17
C98 (VDD VSS) capacitor c=1.83754e-18
C99 (\2\:D VSS) capacitor c=4.1286e-17
C100 (\2\:CKNb VSS) capacitor c=2.80201e-17
C101 (\3\:CKNb VSS) capacitor c=5.82739e-17
C102 (\4\:n20 VSS) capacitor c=4.72351e-17
C103 (\2\:CKN VSS) capacitor c=3.45513e-17
C104 (\2\:n35g VSS) capacitor c=3.01722e-17
C105 (\2\:qbint VSS) capacitor c=4.00385e-17
C106 (\5\:RT VSS) capacitor c=5.09193e-17
C107 (\9\:CKNb VSS) capacitor c=1.09084e-16
C108 (\10\:CKNb VSS) capacitor c=4.17719e-17
C109 (\4\:CKNbb VSS) capacitor c=2.47096e-16
C110 (\5\:CKNbb VSS) capacitor c=4.15893e-17
C111 (\7\:qbint VSS) capacitor c=2.77874e-17
C112 (\16\:CKNb VSS) capacitor c=9.75357e-17
C113 (\17\:CKNb VSS) capacitor c=8.61806e-17
C114 (\6\:D VSS) capacitor c=4.15323e-17
C115 (\11\:n20 VSS) capacitor c=4.5579e-17
C116 (\12\:n20 VSS) capacitor c=5.21768e-17
C117 (\15\:n20 VSS) capacitor c=5.25715e-17
C118 (\12\:CKNbb VSS) capacitor c=8.01168e-17
C119 (\15\:CKNbb VSS) capacitor c=4.56355e-17
C120 (\7\:mout VSS) capacitor c=4.29073e-17
C121 (\8\:mout VSS) capacitor c=2.73157e-17
C122 (\9\:mout VSS) capacitor c=2.48939e-17
C123 (\12\:mout VSS) capacitor c=2.50574e-17
C124 (\7\:CKN VSS) capacitor c=4.45548e-17
C125 (\18\:CKNb VSS) capacitor c=5.72715e-17
C126 (\19\:CKNb VSS) capacitor c=4.41368e-17
C127 (\6\:n35 VSS) capacitor c=6.84178e-17
C128 (\9\:n35 VSS) capacitor c=6.21997e-17
C129 (\8\:n35g VSS) capacitor c=3.19866e-17
C130 (\12\:n35 VSS) capacitor c=6.04519e-17
C131 (\12\:qbint VSS) capacitor c=8.89171e-17
C132 (\13\:qbint VSS) capacitor c=1.10987e-16
C133 (\13\:n35g VSS) capacitor c=1.13671e-16
C134 (\14\:n35g VSS) capacitor c=1.16555e-16
C135 (\9\:RT VSS) capacitor c=6.21174e-17
C136 (\10\:RT VSS) capacitor c=6.14857e-17
C137 (\5\:RTb VSS) capacitor c=3.69873e-17
C138 (\8\:RTb VSS) capacitor c=1.11714e-16
C139 (\9\:RTb VSS) capacitor c=6.96605e-17
C140 (\11\:RT VSS) capacitor c=4.15295e-17
C141 (\18\:qbint VSS) capacitor c=1.82331e-17
C142 (\19\:qbint VSS) capacitor c=3.10309e-17
C143 (\24\:CKNb VSS) capacitor c=1.32727e-16
C144 (\25\:CKNb VSS) capacitor c=9.79989e-17
C145 (\17\:n35 VSS) capacitor c=6.15215e-17
C146 (\3\:VDD VSS) capacitor c=1.17749e-17
C147 (\5\:VDD VSS) capacitor c=2.25055e-16
C148 (\6\:VDD VSS) capacitor c=1.99263e-16
C149 (\8\:VDD VSS) capacitor c=3.40843e-17
C150 (\15\:VDD VSS) capacitor c=3.91862e-17
Rk35 (ExtVDD ExtVDD) resistor r=0.002059 c=0
Rk33 (\2\:ExtVDD ExtVDD) resistor r=0.02212 c=0
Rk36 (ExtVDD \5\:ExtVDD) resistor r=0.02011 c=0
Rk37 (ExtVDD \6\:ExtVDD) resistor r=0.1494 c=0
Rk38 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02873 c=0
Rk19 (CKN \5\:CKN) resistor r=0.002041 c=0
Rk20 (\5\:CKN \6\:CKN) resistor r=0.004083 c=0
Rk21 (CKN \7\:CKN) resistor r=0.004083 c=0
Rk22 (\5\:CKN \7\:CKN) resistor r=0.02231 c=0
Rk2 (\5\:D \6\:D) resistor r=0.006772 c=0
Rk3 (\7\:D D) resistor r=0.006772 c=0
Rk4 (\6\:D \7\:D) resistor r=0.01902 c=0
Rk71 (\2\:VDD \3\:VDD) resistor r=0.4107 c=0
Rk72 (\3\:VDD \5\:VDD) resistor r=0.07282 c=0
Rk73 (\5\:VDD \6\:VDD) resistor r=1.5668 c=0
Rk78 (\8\:VDD VDD) resistor r=0.1807 c=0
Rk74 (\6\:VDD \8\:VDD) resistor r=0.05488 c=0
Rk75 (\3\:VDD \10\:VDD) resistor r=0.2962 c=0
Rk76 (\6\:VDD \12\:VDD) resistor r=0.4008 c=0
Rk77 (\8\:VDD \14\:VDD) resistor r=0.356 c=0
Rk79 (VDD \15\:VDD) resistor r=0.1511 c=0
Rk80 (\15\:VDD VDD) resistor r=0.08373 c=0
Rk81 (\15\:VDD \17\:VDD) resistor r=0.358 c=0
Rk45 (\9\:RT \10\:RT) resistor r=0.4468 c=0
Rk50 (RT \11\:RT) resistor r=0.01698 c=0
Rk55 (\2\:Q Q) resistor r=0.1571 c=0
Rk56 (Q \4\:Q) resistor r=0.3179 c=0
Rk57 (\2\:VSS \4\:VSS) resistor r=0.4275 c=0
Rk58 (\4\:VSS \5\:VSS) resistor r=0.5593 c=0
Rk60 (\6\:VSS VSS) resistor r=0.07383 c=0
Rk59 (\5\:VSS \6\:VSS) resistor r=0.2076 c=0
Rk61 (VSS \7\:VSS) resistor r=0.04976 c=0
Rk63 (\8\:VSS VSS) resistor r=0.02184 c=0
Rk62 (\7\:VSS \8\:VSS) resistor r=0.5915 c=0
Rk64 (VSS \9\:VSS) resistor r=0.1785 c=0
Rk65 (\9\:VSS \10\:VSS) resistor r=0.1855 c=0
Rk66 (\10\:VSS \11\:VSS) resistor r=0.0617 c=0
Rk67 (\5\:VSS \13\:VSS) resistor r=0.1888 c=0
Rk68 (\6\:VSS \15\:VSS) resistor r=0.1939 c=0
Rk69 (\8\:VSS \17\:VSS) resistor r=0.2401 c=0
Rk70 (\10\:VSS \19\:VSS) resistor r=0.2279 c=0
Rk82 (\21\:VSS \23\:VSS) resistor r=0.4978 c=0
Rk83 (\23\:VSS \24\:VSS) resistor r=0.4132 c=0
Rk85 (\25\:VSS VSS) resistor r=0.1978 c=0
Rk84 (\24\:VSS \25\:VSS) resistor r=0.131 c=0
Rk87 (\26\:VSS VSS) resistor r=0.1186 c=0
Rk86 (VSS \26\:VSS) resistor r=0.5449 c=0
Rk88 (VSS \28\:VSS) resistor r=0.3453 c=0
Rk89 (\24\:VSS \30\:VSS) resistor r=0.3471 c=0
Rk1 (\16\:CKNb \17\:CKNb) resistor r=0.8341 c=0
Rk23 (\18\:CKNb \19\:CKNb) resistor r=0.2091 c=0
Rk24 (\19\:CKNb \21\:CKNb) resistor r=0.3157 c=0
Rk25 (\19\:CKNb \23\:CKNb) resistor r=0.1957 c=0
Rk52 (\24\:CKNb \25\:CKNb) resistor r=0.8714 c=0
Rk5 (\8\:n20 \10\:n20) resistor r=0.4922 c=0
Rk6 (\10\:n20 \11\:n20) resistor r=0.315 c=0
Rk7 (\12\:n20 \14\:n20) resistor r=0.2759 c=0
Rk8 (\14\:n20 \15\:n20) resistor r=0.2394 c=0
Rk9 (\12\:n20 \17\:n20) resistor r=0.2335 c=0
Rk10 (\10\:CKNbb \11\:CKNbb) resistor r=0.1981 c=0
Rk11 (\11\:CKNbb \12\:CKNbb) resistor r=0.02346 c=0
Rk12 (\11\:CKNbb \14\:CKNbb) resistor r=0.3343 c=0
Rk13 (\14\:CKNbb \15\:CKNbb) resistor r=0.272 c=0
Rk14 (\6\:mout \7\:mout) resistor r=0.3051 c=0
Rk15 (\7\:mout \8\:mout) resistor r=0.1494 c=0
Rk16 (\8\:mout \9\:mout) resistor r=0.1241 c=0
Rk17 (\7\:mout \11\:mout) resistor r=0.2735 c=0
Rk18 (\8\:mout \12\:mout) resistor r=0.1307 c=0
Rk26 (\5\:n35 \6\:n35) resistor r=0.2866 c=0
Rk27 (\6\:n35 \8\:n35) resistor r=0.2722 c=0
Rk28 (\6\:n35 \9\:n35) resistor r=0.5674 c=0
Rk31 (\11\:n35 \12\:n35) resistor r=0.2721 c=0
Rk32 (\12\:n35 \14\:n35) resistor r=0.3271 c=0
Rk53 (\16\:n35 \17\:n35) resistor r=0.1701 c=0
Rk54 (\17\:n35 \19\:n35) resistor r=0.4267 c=0
Rk29 (\7\:n35g \8\:n35g) resistor r=0.2291 c=0
Rk30 (\7\:n35g \10\:n35g) resistor r=0.6054 c=0
Rk42 (\12\:n35g \13\:n35g) resistor r=0.2425 c=0
Rk43 (\13\:n35g \14\:n35g) resistor r=0.5645 c=0
Rk44 (\13\:n35g \16\:n35g) resistor r=0.4312 c=0
Rk39 (\12\:qbint \13\:qbint) resistor r=0.4937 c=0
Rk40 (\13\:qbint \15\:qbint) resistor r=0.5662 c=0
Rk41 (\13\:qbint \17\:qbint) resistor r=0.146 c=0
Rk51 (\18\:qbint \19\:qbint) resistor r=0.2114 c=0
Rk46 (\5\:RTb \7\:RTb) resistor r=0.2262 c=0
Rk47 (\7\:RTb \8\:RTb) resistor r=0.2729 c=0
Rk48 (\8\:RTb \9\:RTb) resistor r=0.6695 c=0
Rk49 (\8\:RTb \11\:RTb) resistor r=0.3327 c=0
Rl19 (\2\:CKN \4\:CKN) resistor r=70.868 c=0
Rl17 (\1\:CKN \2\:CKN) resistor r=140.099 c=0
Rl18 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl3 (\2\:D \4\:D) resistor r=38.1757 c=0
Rl1 (\1\:D \2\:D) resistor r=172.791 c=0
Rl2 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl34 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl31 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl25 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl35 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl33 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl32 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl43 (\14\:CKNb \15\:CKNb) resistor r=115.79 c=0
Rl11 (\4\:CKNb \5\:CKNb) resistor r=246.721 c=0
Rl8 (CKNb \2\:CKNb) resistor r=0.6084 c=0
Rl12 (\2\:CKNb \6\:CKNb) resistor r=73.8796 c=0
Rl13 (\3\:CKNb \7\:CKNb) resistor r=64.6458 c=0
Rl10 (\3\:CKNb \4\:CKNb) resistor r=208.713 c=0
Rl9 (\2\:CKNb \3\:CKNb) resistor r=64.0061 c=0
Rl39 (\9\:CKNb \12\:CKNb) resistor r=64.1356 c=0
Rl36 (\8\:CKNb \9\:CKNb) resistor r=862.964 c=0
Rl40 (\10\:CKNb \13\:CKNb) resistor r=64.1356 c=0
Rl38 (\10\:CKNb \11\:CKNb) resistor r=113.909 c=0
Rl37 (\9\:CKNb \10\:CKNb) resistor r=172.374 c=0
Rl4 (n20 \2\:n20) resistor r=112.885 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=103.572 c=0
Rl16 (\4\:n20 \6\:n20) resistor r=96.5354 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=121.254 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=157.453 c=0
Rl44 (\3\:CKNbb \4\:CKNbb) resistor r=1441.22 c=0
Rl47 (\4\:CKNbb \7\:CKNbb) resistor r=140.831 c=0
Rl48 (\5\:CKNbb \8\:CKNbb) resistor r=66.684 c=0
Rl46 (\5\:CKNbb \6\:CKNbb) resistor r=229.379 c=0
Rl45 (\4\:CKNbb \5\:CKNbb) resistor r=112.483 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl41 (n35 \2\:n35) resistor r=499.328 c=0
Rl42 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl22 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl20 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl21 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl23 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl53 (\10\:qbint \11\:qbint) resistor r=235.906 c=0
Rl52 (\8\:qbint \10\:qbint) resistor r=601.135 c=0
Rl30 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl27 (qbint \2\:qbint) resistor r=112.732 c=0
Rl29 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl28 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl51 (\7\:qbint \9\:qbint) resistor r=68.607 c=0
Rl49 (\6\:qbint \7\:qbint) resistor r=78.0039 c=0
Rl50 (\7\:qbint \8\:qbint) resistor r=166.462 c=0
Rl26 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl24 (RTb \2\:RTb) resistor r=124.312 c=0
Rz14 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz16 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz17 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz19 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz24 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz5 (\22\:CKNb \23\:CKNb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz6 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz8 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz13 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz7 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz11 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz10 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz12 (\10\:RTb \11\:RTb) resistor r=75 c=0
Ry9 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry10 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry24 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry25 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry26 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry27 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry19 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry20 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry21 (\3\:VSS \9\:VSS) resistor r=15.5 c=0
Ry22 (\3\:VSS \11\:VSS) resistor r=62 c=0
Ry28 (\22\:VSS \23\:VSS) resistor r=7.75 c=0
Ry29 (\22\:VSS \25\:VSS) resistor r=20.6667 c=0
Ry30 (\22\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry8 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry17 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry7 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Rx11 (\3\:CKN \6\:CKN) resistor r=45 c=0
Rx3 (\3\:D \5\:D) resistor r=45 c=0
Rx18 (\4\:RT \9\:RT) resistor r=45 c=0
Rx19 (\2\:RT \10\:RT) resistor r=45 c=0
Rx22 (\3\:RT \11\:RT) resistor r=45 c=0
Rx1 (\5\:CKNb \16\:CKNb) resistor r=45 c=0
Rx2 (\11\:CKNb \17\:CKNb) resistor r=45 c=0
Rx12 (CKNb \18\:CKNb) resistor r=45 c=0
Rx25 (\15\:CKNb \24\:CKNb) resistor r=45 c=0
Rx26 (\8\:CKNb \25\:CKNb) resistor r=45 c=0
Rx4 (\2\:n20 \11\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \12\:n20) resistor r=45 c=0
Rx6 (n20 \15\:n20) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\7\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx9 (\4\:mout \9\:mout) resistor r=45 c=0
Rx10 (\2\:mout \12\:mout) resistor r=45 c=0
Rx13 (\3\:n35 \9\:n35) resistor r=45 c=0
Rx15 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx27 (n35 \17\:n35) resistor r=45 c=0
Rx14 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx17 (n35g \14\:n35g) resistor r=45 c=0
Rx16 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx23 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx24 (qbint \19\:qbint) resistor r=45 c=0
Rx20 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx21 (\2\:RTb \9\:RTb) resistor r=45 c=0
mn25 (n21 \1\:D \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\7\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \13\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n30 \3\:mout \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\9\:CKNbb \6\:CKNb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\10\:mout \6\:n20 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\22\:CKNb \1\:CKN \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \12\:CKNb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM1 (\16\:qbint \5\:n35g \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \1\:RT \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 \3\:CKNbb net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net095 \11\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\9\:n20 \4\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3839 \
        scb=0.011256 scc=0.000224024 m=(1)
mp36 (\13\:n20 \6\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=8.43833 \
        scb=0.00456328 scc=4.14083e-05 m=(1)
mp35 (n31 mout \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=8.66197 \
        scb=0.00491317 scc=4.24157e-05 m=(1)
mp21 (\13\:CKNbb \7\:CKNb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.3786 \
        scb=0.00949038 scc=0.000203066 m=(1)
mp32 (\5\:mout \3\:n20 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=10.9141 \
        scb=0.00882323 scc=9.56076e-05 m=(1)
mp20 (\20\:CKNb \4\:CKN \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.4857 \
        scb=0.0166783 scc=0.00041931 m=(1)
mp40 (\4\:n35 \8\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=22.4791 \
        scb=0.0247612 scc=0.0018296 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
mp45 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \14\:CKNb net082 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=28.6011 \
        scb=0.0298676 scc=0.0026875 m=(1)
mp52 (net082 \10\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=19.4537 \
        scb=0.0214753 scc=0.000585924 m=(1)
mp55 (\3\:Q \9\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.9069 \
        scb=0.0255526 scc=0.000831054 m=(1)
ends RDFFNQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:40:50 2012 )
// Library name: gsclib045
// Cell name: RDFFNRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFNRQX1 CKN D ExtVDD Q RN RT VDD VSS
mp25 (n22 \3\:D \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RT VSS) capacitor c=2.16535e-17
C2 (ExtVDD VSS) capacitor c=2.47127e-16
C3 (D VSS) capacitor c=5.11133e-17
C4 (RN VSS) capacitor c=4.58072e-17
C5 (VDD VSS) capacitor c=6.60218e-16
C6 (CKN VSS) capacitor c=3.97487e-17
C7 (Q VSS) capacitor c=1.46381e-17
C8 (CKNb VSS) capacitor c=4.72155e-17
C9 (mout VSS) capacitor c=4.98512e-17
C10 (CKNbb VSS) capacitor c=5.23932e-17
C11 (n20 VSS) capacitor c=8.27414e-17
C12 (RNb VSS) capacitor c=5.59904e-17
C13 (n35g VSS) capacitor c=1.77671e-17
C14 (qbint VSS) capacitor c=4.57382e-17
C15 (RTb VSS) capacitor c=4.52673e-17
C16 (n35 VSS) capacitor c=1.81499e-16
C17 (net098 VSS) capacitor c=6.14297e-17
C18 (n40 VSS) capacitor c=7.48681e-17
C19 (\7\:qbint VSS) capacitor c=1.25063e-16
C20 (\2\:RNb VSS) capacitor c=2.987e-16
C21 (\10\:qbint VSS) capacitor c=3.45607e-17
C22 (\13\:CKNb VSS) capacitor c=6.99757e-17
C23 (\4\:RTb VSS) capacitor c=9.85972e-17
C24 (\6\:RT VSS) capacitor c=2.23776e-17
C25 (\4\:qbint VSS) capacitor c=5.35139e-17
C26 (\3\:n35g VSS) capacitor c=6.24285e-17
C27 (\5\:RT VSS) capacitor c=8.45408e-17
C28 (\5\:CKNbb VSS) capacitor c=1.02117e-16
C29 (\4\:RN VSS) capacitor c=3.2145e-17
C30 (\5\:RNb VSS) capacitor c=6.41482e-17
C31 (\3\:n20 VSS) capacitor c=7.34077e-17
C32 (\4\:CKN VSS) capacitor c=5.42384e-17
C33 (\5\:CKNb VSS) capacitor c=2.95745e-17
C34 (\4\:CKNbb VSS) capacitor c=8.40157e-17
C35 (\3\:CKNb VSS) capacitor c=1.64383e-16
C36 (\3\:D VSS) capacitor c=5.61482e-17
C37 (\6\:qbint VSS) capacitor c=5.79729e-17
C38 (\11\:qbint VSS) capacitor c=4.14096e-17
C39 (\7\:CKNbb VSS) capacitor c=1.94152e-16
C40 (\8\:RT VSS) capacitor c=1.2103e-16
C41 (\2\:RT VSS) capacitor c=5.6984e-17
C42 (\5\:qbint VSS) capacitor c=3.87694e-17
C43 (\5\:n35g VSS) capacitor c=3.48637e-17
C44 (\2\:RTb VSS) capacitor c=4.91473e-17
C45 (\7\:CKNb VSS) capacitor c=3.23618e-17
C46 (\1\:RN VSS) capacitor c=3.41629e-17
C47 (\7\:RNb VSS) capacitor c=6.11841e-17
C48 (\1\:CKN VSS) capacitor c=2.8269e-17
C49 (\6\:n20 VSS) capacitor c=6.24185e-17
C50 (\3\:mout VSS) capacitor c=5.02446e-17
C51 (\12\:CKNb VSS) capacitor c=4.99683e-17
C52 (\2\:CKNbb VSS) capacitor c=8.20966e-17
C53 (\1\:D VSS) capacitor c=6.58183e-17
C54 (\9\:qbint VSS) capacitor c=8.35041e-17
C55 (\14\:CKNb VSS) capacitor c=7.11054e-17
C56 (\7\:RT VSS) capacitor c=1.54253e-16
C57 (\11\:CKNb VSS) capacitor c=1.43255e-16
C58 (\3\:RT VSS) capacitor c=5.78489e-17
C59 (\1\:RT VSS) capacitor c=4.85351e-17
C60 (\3\:RTb VSS) capacitor c=7.57807e-17
C61 (\3\:qbint VSS) capacitor c=4.42142e-17
C62 (\2\:n35 VSS) capacitor c=2.63216e-16
C63 (\4\:n35g VSS) capacitor c=7.15717e-17
C64 (\6\:CKNbb VSS) capacitor c=5.61043e-17
C65 (\8\:CKNbb VSS) capacitor c=2.28276e-16
C66 (\3\:n35 VSS) capacitor c=1.20797e-16
C67 (\6\:RNb VSS) capacitor c=7.97794e-17
C68 (\3\:RN VSS) capacitor c=4.97773e-17
C69 (\3\:CKN VSS) capacitor c=2.31414e-17
C70 (\6\:CKNb VSS) capacitor c=2.30969e-17
C71 (\3\:CKNbb VSS) capacitor c=1.06267e-16
C72 (\2\:mout VSS) capacitor c=4.01023e-17
C73 (\4\:mout VSS) capacitor c=3.90488e-17
C74 (\5\:n20 VSS) capacitor c=3.95232e-17
C75 (\2\:n20 VSS) capacitor c=7.1615e-17
C76 (\4\:CKNb VSS) capacitor c=8.28372e-17
C77 (\10\:CKNb VSS) capacitor c=3.16235e-17
C78 (\2\:D VSS) capacitor c=5.42815e-17
C79 (\1\:VDD VSS) capacitor c=4.75934e-17
C80 (\12\:VDD VSS) capacitor c=4.91532e-17
C81 (\1\:Q VSS) capacitor c=6.1682e-17
C82 (\3\:net098 VSS) capacitor c=9.84746e-17
C83 (\14\:n35 VSS) capacitor c=4.32074e-17
C84 (\15\:n35g VSS) capacitor c=5.80512e-17
C85 (\6\:RTb VSS) capacitor c=8.35247e-17
C86 (\1\:ExtVDD VSS) capacitor c=2.81313e-16
C87 (\9\:n35 VSS) capacitor c=5.4768e-17
C88 (\14\:qbint VSS) capacitor c=6.93529e-17
C89 (\6\:n35g VSS) capacitor c=9.1372e-17
C90 (\4\:n35 VSS) capacitor c=5.54247e-17
C91 (\11\:RNb VSS) capacitor c=2.80641e-17
C92 (\5\:mout VSS) capacitor c=7.05774e-17
C93 (\14\:VDD VSS) capacitor c=5.30535e-17
C94 (\16\:VDD VSS) capacitor c=4.40366e-17
C95 (\21\:CKNb VSS) capacitor c=4.74851e-17
C96 (\17\:mout VSS) capacitor c=3.51139e-17
C97 (\18\:VDD VSS) capacitor c=6.44243e-17
C98 (\20\:VDD VSS) capacitor c=4.60888e-17
C99 (\13\:CKNbb VSS) capacitor c=5.21642e-17
C100 (\7\:n20 VSS) capacitor c=4.09751e-17
C101 (\15\:n20 VSS) capacitor c=6.2982e-17
C102 (\23\:VDD VSS) capacitor c=4.0773e-17
C103 (\3\:Q VSS) capacitor c=4.25142e-17
C104 (\3\:n40 VSS) capacitor c=7.90524e-17
C105 (\17\:n35 VSS) capacitor c=4.8912e-17
C106 (\11\:n35g VSS) capacitor c=2.71993e-17
C107 (\10\:RTb VSS) capacitor c=4.83653e-17
C108 (\12\:n35 VSS) capacitor c=6.15791e-17
C109 (\16\:qbint VSS) capacitor c=2.32084e-17
C110 (\9\:n35g VSS) capacitor c=7.74366e-17
C111 (\7\:n35 VSS) capacitor c=4.51039e-17
C112 (\8\:RNb VSS) capacitor c=3.95412e-17
C113 (\8\:VDD VSS) capacitor c=5.37365e-17
C114 (\13\:mout VSS) capacitor c=5.50814e-17
C115 (\17\:CKNb VSS) capacitor c=6.04735e-17
C116 (\15\:mout VSS) capacitor c=3.62361e-17
C117 (\9\:CKNbb VSS) capacitor c=3.48248e-17
C118 (\11\:n20 VSS) capacitor c=6.1664e-17
C119 (\13\:n20 VSS) capacitor c=5.88843e-17
C120 (\2\:CKNb VSS) capacitor c=7.13597e-17
C121 (\2\:CKN VSS) capacitor c=3.37143e-17
C122 (\4\:n20 VSS) capacitor c=6.6185e-17
C123 (\2\:n35g VSS) capacitor c=3.24201e-17
C124 (\4\:RT VSS) capacitor c=7.41198e-17
C125 (\2\:qbint VSS) capacitor c=4.14953e-17
C126 (\8\:CKNb VSS) capacitor c=1.24521e-16
C127 (\9\:CKNb VSS) capacitor c=6.28227e-17
C128 (\3\:RNb VSS) capacitor c=4.94804e-16
C129 (\4\:RNb VSS) capacitor c=1.13129e-16
C130 (\15\:CKNb VSS) capacitor c=6.34123e-17
C131 (\16\:CKNb VSS) capacitor c=7.45499e-17
C132 (\8\:qbint VSS) capacitor c=9.90014e-17
C133 (\9\:n20 VSS) capacitor c=2.90276e-17
C134 (\10\:n20 VSS) capacitor c=4.9973e-17
C135 (\17\:n20 VSS) capacitor c=3.72237e-17
C136 (\12\:CKNbb VSS) capacitor c=7.85105e-17
C137 (\15\:CKNbb VSS) capacitor c=5.09428e-17
C138 (\5\:CKN VSS) capacitor c=5.97472e-18
C139 (\6\:CKN VSS) capacitor c=3.6841e-17
C140 (\19\:CKNb VSS) capacitor c=7.08037e-17
C141 (\20\:CKNb VSS) capacitor c=4.84619e-17
C142 (\5\:RN VSS) capacitor c=5.29406e-17
C143 (\7\:mout VSS) capacitor c=5.29264e-17
C144 (\8\:mout VSS) capacitor c=4.64473e-17
C145 (\9\:mout VSS) capacitor c=1.00843e-17
C146 (\10\:mout VSS) capacitor c=2.76665e-17
C147 (\11\:mout VSS) capacitor c=1.52201e-17
C148 (\12\:mout VSS) capacitor c=3.01153e-17
C149 (\10\:RNb VSS) capacitor c=6.48312e-17
C150 (\6\:n35 VSS) capacitor c=5.89856e-17
C151 (\16\:CKNbb VSS) capacitor c=3.24421e-17
C152 (\17\:CKNbb VSS) capacitor c=3.22711e-17
C153 (\8\:n35g VSS) capacitor c=3.24313e-17
C154 (\11\:n35 VSS) capacitor c=6.21676e-17
C155 (\12\:qbint VSS) capacitor c=8.82866e-17
C156 (\13\:qbint VSS) capacitor c=1.03557e-16
C157 (\13\:n35g VSS) capacitor c=1.06112e-16
C158 (\14\:n35g VSS) capacitor c=1.16408e-16
C159 (\5\:RTb VSS) capacitor c=4.96e-17
C160 (\8\:RTb VSS) capacitor c=8.74815e-17
C161 (\9\:RTb VSS) capacitor c=5.09192e-17
C162 (\9\:RT VSS) capacitor c=1.06563e-16
C163 (\10\:RT VSS) capacitor c=1.18671e-16
C164 (\11\:RT VSS) capacitor c=3.826e-17
C165 (\23\:CKNb VSS) capacitor c=9.71009e-17
C166 (\24\:CKNb VSS) capacitor c=9.4266e-17
C167 (\18\:qbint VSS) capacitor c=2.00599e-17
C168 (\19\:qbint VSS) capacitor c=3.01482e-17
C169 (\16\:n35 VSS) capacitor c=4.42287e-17
C170 (\3\:VDD VSS) capacitor c=3.85813e-17
C171 (\5\:VDD VSS) capacitor c=2.27827e-16
C172 (\6\:VDD VSS) capacitor c=1.91623e-16
C173 (\7\:VDD VSS) capacitor c=5.4939e-18
C174 (\10\:VDD VSS) capacitor c=3.15159e-17
C175 (\22\:VDD VSS) capacitor c=3.15031e-17
Rk53 (RT \9\:RT) resistor r=0.1834 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6402 c=0
Rk55 (RT \11\:RT) resistor r=0.01476 c=0
Rk40 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk38 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk41 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk42 (ExtVDD \6\:ExtVDD) resistor r=0.1493 c=0
Rk2 (\4\:D D) resistor r=0.006389 c=0
Rk19 (RN \5\:RN) resistor r=0.02713 c=0
Rk97 (\2\:VDD \3\:VDD) resistor r=0.4044 c=0
Rk98 (\3\:VDD \5\:VDD) resistor r=0.06659 c=0
Rk99 (\5\:VDD \6\:VDD) resistor r=1.6793 c=0
Rk100 (\6\:VDD \7\:VDD) resistor r=0.0293 c=0
Rk101 (\7\:VDD \9\:VDD) resistor r=0.04186 c=0
Rk102 (\9\:VDD \10\:VDD) resistor r=0.1482 c=0
Rk109 (\11\:VDD VDD) resistor r=0.218 c=0
Rk103 (\10\:VDD \11\:VDD) resistor r=0.05917 c=0
Rk104 (\3\:VDD \13\:VDD) resistor r=0.2921 c=0
Rk105 (\6\:VDD \15\:VDD) resistor r=0.3582 c=0
Rk106 (\7\:VDD \17\:VDD) resistor r=0.201 c=0
Rk107 (\10\:VDD \19\:VDD) resistor r=0.4023 c=0
Rk108 (\11\:VDD \21\:VDD) resistor r=0.2464 c=0
Rk110 (VDD \22\:VDD) resistor r=0.146 c=0
Rk111 (\22\:VDD VDD) resistor r=0.08861 c=0
Rk112 (\22\:VDD \24\:VDD) resistor r=0.3577 c=0
Rk12 (CKN \5\:CKN) resistor r=0.00199 c=0
Rk15 (\5\:CKN \6\:CKN) resistor r=0.01469 c=0
Rk14 (\6\:CKN \7\:CKN) resistor r=0.004525 c=0
Rk60 (Q \2\:Q) resistor r=0.2839 c=0
Rk61 (Q \4\:Q) resistor r=0.2207 c=0
Rk64 (\2\:VSS \3\:VSS) resistor r=0.03444 c=0
Rk65 (\3\:VSS \4\:VSS) resistor r=0.1136 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.08885 c=0
Rk67 (\5\:VSS \6\:VSS) resistor r=0.356 c=0
Rk69 (\7\:VSS VSS) resistor r=0.3755 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.3661 c=0
Rk70 (VSS \8\:VSS) resistor r=0.1487 c=0
Rk72 (\9\:VSS VSS) resistor r=0.2073 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.5564 c=0
Rk73 (VSS \10\:VSS) resistor r=0.01737 c=0
Rk74 (\10\:VSS \11\:VSS) resistor r=0.1086 c=0
Rk75 (\3\:VSS \13\:VSS) resistor r=0.2393 c=0
Rk76 (\5\:VSS \15\:VSS) resistor r=0.2456 c=0
Rk77 (\7\:VSS \17\:VSS) resistor r=0.2429 c=0
Rk78 (\9\:VSS \19\:VSS) resistor r=0.2393 c=0
Rk79 (\10\:VSS \21\:VSS) resistor r=0.2393 c=0
Rk80 (\23\:VSS \24\:VSS) resistor r=0.07154 c=0
Rk81 (\24\:VSS \25\:VSS) resistor r=0.6701 c=0
Rk82 (\25\:VSS \26\:VSS) resistor r=0.1655 c=0
Rk84 (\27\:VSS VSS) resistor r=0.1208 c=0
Rk83 (\26\:VSS \27\:VSS) resistor r=0.2074 c=0
Rk85 (VSS \28\:VSS) resistor r=0.6283 c=0
Rk87 (\29\:VSS VSS) resistor r=0.1185 c=0
Rk86 (\28\:VSS \29\:VSS) resistor r=0.06412 c=0
Rk88 (VSS \30\:VSS) resistor r=0.03716 c=0
Rk89 (\30\:VSS \31\:VSS) resistor r=0.4226 c=0
Rk90 (\31\:VSS \32\:VSS) resistor r=0.06412 c=0
Rk91 (\24\:VSS \34\:VSS) resistor r=0.2598 c=0
Rk92 (\26\:VSS \36\:VSS) resistor r=0.1887 c=0
Rk93 (\27\:VSS \38\:VSS) resistor r=0.1938 c=0
Rk94 (\28\:VSS \40\:VSS) resistor r=0.2353 c=0
Rk95 (\30\:VSS \42\:VSS) resistor r=0.2358 c=0
Rk96 (\31\:VSS \44\:VSS) resistor r=0.2277 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6826 c=0
Rk16 (\18\:CKNb \19\:CKNb) resistor r=0.3415 c=0
Rk17 (\19\:CKNb \20\:CKNb) resistor r=0.1628 c=0
Rk18 (\19\:CKNb \22\:CKNb) resistor r=0.2072 c=0
Rk56 (\23\:CKNb \24\:CKNb) resistor r=0.7171 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.4253 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.3621 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1413 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.1929 c=0
Rk24 (\7\:mout \11\:mout) resistor r=0.1185 c=0
Rk25 (\11\:mout \12\:mout) resistor r=0.2157 c=0
Rk26 (\8\:mout \14\:mout) resistor r=0.3227 c=0
Rk27 (\9\:mout \16\:mout) resistor r=0.1036 c=0
Rk28 (\11\:mout \18\:mout) resistor r=0.1202 c=0
Rk8 (\10\:CKNbb \11\:CKNbb) resistor r=0.2124 c=0
Rk9 (\11\:CKNbb \12\:CKNbb) resistor r=0.0151 c=0
Rk10 (\11\:CKNbb \14\:CKNbb) resistor r=0.3374 c=0
Rk11 (\14\:CKNbb \15\:CKNbb) resistor r=0.2709 c=0
Rk33 (\16\:CKNbb \17\:CKNbb) resistor r=0.2958 c=0
Rk3 (\8\:n20 \9\:n20) resistor r=0.2062 c=0
Rk4 (\8\:n20 \10\:n20) resistor r=0.2091 c=0
Rk5 (\10\:n20 \12\:n20) resistor r=0.4399 c=0
Rk6 (\14\:n20 \16\:n20) resistor r=0.4876 c=0
Rk7 (\16\:n20 \17\:n20) resistor r=0.1574 c=0
Rk29 (\9\:RNb \10\:RNb) resistor r=0.3424 c=0
Rk30 (\10\:RNb \12\:RNb) resistor r=0.1478 c=0
Rk34 (\7\:n35g \8\:n35g) resistor r=0.2401 c=0
Rk35 (\7\:n35g \10\:n35g) resistor r=0.6898 c=0
Rk46 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk47 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk48 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk43 (\12\:qbint \13\:qbint) resistor r=0.4933 c=0
Rk44 (\13\:qbint \15\:qbint) resistor r=0.5658 c=0
Rk45 (\13\:qbint \17\:qbint) resistor r=0.1459 c=0
Rk57 (\18\:qbint \19\:qbint) resistor r=0.2113 c=0
Rk49 (\5\:RTb \7\:RTb) resistor r=0.2157 c=0
Rk50 (\7\:RTb \8\:RTb) resistor r=0.5203 c=0
Rk51 (\8\:RTb \9\:RTb) resistor r=0.3878 c=0
Rk52 (\8\:RTb \11\:RTb) resistor r=0.2011 c=0
Rk31 (\5\:n35 \6\:n35) resistor r=0.3193 c=0
Rk32 (\6\:n35 \8\:n35) resistor r=0.4233 c=0
Rk36 (\10\:n35 \11\:n35) resistor r=0.3178 c=0
Rk37 (\11\:n35 \13\:n35) resistor r=0.3869 c=0
Rk58 (\15\:n35 \16\:n35) resistor r=0.2315 c=0
Rk59 (\16\:n35 \18\:n35) resistor r=0.3583 c=0
Rk63 (\2\:net098 \4\:net098) resistor r=0.7055 c=0
Rk62 (\2\:n40 \4\:n40) resistor r=0.6241 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl20 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl18 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl19 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl46 (\13\:CKNb \14\:CKNb) resistor r=159.438 c=0
Rl9 (\3\:CKNb \4\:CKNb) resistor r=349.426 c=0
Rl7 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl10 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl8 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl11 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl38 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl41 (\8\:CKNb \11\:CKNb) resistor r=820.277 c=0
Rl42 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl40 (\9\:CKNb \10\:CKNb) resistor r=132.647 c=0
Rl39 (\8\:CKNb \9\:CKNb) resistor r=339.792 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl4 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=177.372 c=0
Rl47 (\7\:CKNbb \8\:CKNbb) resistor r=908.226 c=0
Rl22 (\3\:CKNbb \5\:CKNbb) resistor r=446.949 c=0
Rl21 (\3\:CKNbb \4\:CKNbb) resistor r=188.95 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=154.568 c=0
Rl17 (\4\:n20 \6\:n20) resistor r=191.976 c=0
Rl16 (\4\:n20 \5\:n20) resistor r=128.737 c=0
Rl48 (RNb \2\:RNb) resistor r=234.8 c=0
Rl49 (\2\:RNb \3\:RNb) resistor r=1125.6 c=0
Rl52 (\3\:RNb \6\:RNb) resistor r=707.521 c=0
Rl51 (\4\:RNb \5\:RNb) resistor r=106.884 c=0
Rl53 (\4\:RNb \7\:RNb) resistor r=197.09 c=0
Rl50 (\3\:RNb \4\:RNb) resistor r=336.011 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl54 (\6\:qbint \7\:qbint) resistor r=237.758 c=0
Rl58 (\10\:qbint \11\:qbint) resistor r=149.805 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl55 (\7\:qbint \8\:qbint) resistor r=252.339 c=0
Rl57 (\8\:qbint \10\:qbint) resistor r=60.508 c=0
Rl56 (\8\:qbint \9\:qbint) resistor r=419.685 c=0
Rl28 (RTb \2\:RTb) resistor r=121.113 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl44 (n35 \2\:n35) resistor r=508.667 c=0
Rl45 (\2\:n35 \3\:n35) resistor r=358.667 c=0
Rz31 (\8\:VDD \9\:VDD) resistor r=15 c=0
Rz32 (\8\:VDD \11\:VDD) resistor r=37.5 c=0
Rz16 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\33\:VSS \34\:VSS) resistor r=37.5 c=0
Rz25 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz26 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz27 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz28 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz29 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz5 (\13\:mout \14\:mout) resistor r=75 c=0
Rz6 (\15\:mout \16\:mout) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz1 (\11\:n20 \12\:n20) resistor r=75 c=0
Rz2 (\13\:n20 \14\:n20) resistor r=75 c=0
Rz7 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz9 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz13 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz12 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz14 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz8 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz10 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (n40 \2\:n40) resistor r=75 c=0
Rz18 (\3\:n40 \4\:n40) resistor r=75 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry21 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry23 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry25 (\1\:VSS \11\:VSS) resistor r=8.8571 c=0
Ry26 (\22\:VSS \23\:VSS) resistor r=20.6667 c=0
Ry27 (\22\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry28 (\22\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry29 (\22\:VSS \32\:VSS) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\17\:mout \18\:mout) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\15\:n20 \16\:n20) resistor r=62 c=0
Ry7 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry17 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry19 (net098 \2\:net098) resistor r=62 c=0
Ry20 (\3\:net098 \4\:net098) resistor r=62 c=0
Rx24 (\3\:RT \9\:RT) resistor r=45 c=0
Rx25 (\1\:RT \10\:RT) resistor r=45 c=0
Rx26 (\7\:RT \11\:RT) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx11 (\3\:RN \5\:RN) resistor r=45 c=0
Rx9 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx10 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx27 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx28 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx12 (\4\:mout \10\:mout) resistor r=45 c=0
Rx13 (\2\:mout \12\:mout) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx16 (\6\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx17 (\8\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx4 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \10\:n20) resistor r=45 c=0
Rx6 (n20 \17\:n20) resistor r=45 c=0
Rx14 (\6\:RNb \10\:RNb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx29 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx30 (qbint \19\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\13\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\11\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\9\:CKNbb CKNb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \6\:n20 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKNb \1\:CKN \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\13\:mout \7\:RNb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\8\:RNb \1\:RN \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \7\:CKNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM3 (net0121 \5\:qbint \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\16\:qbint \5\:n35g \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \7\:CKNbb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\3\:Q \11\:qbint \33\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n40 RNb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \6\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\15\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\7\:n20 \4\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\13\:CKNbb \5\:CKNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\21\:CKNb \4\:CKN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\17\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.71023 \
        scb=0.00138809 scc=2.58214e-06 m=(1)
mp31 (net402 \5\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.19408 \
        scb=0.00174819 scc=3.02997e-06 m=(1)
mp22 (\11\:RNb \4\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.8901 \
        scb=0.0121892 scc=0.000217629 m=(1)
mp40 (\4\:n35 \5\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.8142 \
        scb=0.0201994 scc=0.00140887 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:net098 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp55 (\1\:Q \10\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2692 \
        scb=0.0111076 scc=0.000317226 m=(1)
mp51 (n43 \2\:RNb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp52 (net098 \7\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.9152 \
        scb=0.0114244 scc=0.000185803 m=(1)
ends RDFFNRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:41:43 2012 )
// Library name: gsclib045
// Cell name: RDFFNRX1
// View name: extracted

simulator lang=spectre

subckt RDFFNRX1 CKN D ExtVDD Q QN RN RT VDD VSS
mp25 (n22 \3\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RT VSS) capacitor c=2.16343e-17
C2 (Q VSS) capacitor c=5.03089e-17
C3 (D VSS) capacitor c=5.49024e-17
C4 (QN VSS) capacitor c=1.94378e-17
C5 (RN VSS) capacitor c=7.02607e-17
C6 (VDD VSS) capacitor c=6.83448e-16
C7 (CKN VSS) capacitor c=5.2737e-17
C8 (ExtVDD VSS) capacitor c=2.07247e-16
C9 (CKNb VSS) capacitor c=4.73073e-17
C10 (mout VSS) capacitor c=4.98512e-17
C11 (CKNbb VSS) capacitor c=5.2531e-17
C12 (n20 VSS) capacitor c=8.27414e-17
C13 (RNb VSS) capacitor c=5.59904e-17
C14 (n35g VSS) capacitor c=1.77583e-17
C15 (qbint VSS) capacitor c=4.54322e-17
C16 (RTb VSS) capacitor c=4.52686e-17
C17 (qint VSS) capacitor c=2.24057e-17
C18 (n35 VSS) capacitor c=1.81499e-16
C19 (net098 VSS) capacitor c=6.31866e-17
C20 (n40 VSS) capacitor c=7.4778e-17
C21 (\7\:qbint VSS) capacitor c=3.33465e-17
C22 (\11\:qbint VSS) capacitor c=1.20625e-16
C23 (\2\:RNb VSS) capacitor c=3.01684e-16
C24 (\13\:qbint VSS) capacitor c=4.56384e-17
C25 (\3\:qint VSS) capacitor c=6.09607e-17
C26 (\13\:CKNb VSS) capacitor c=6.99278e-17
C27 (\4\:RTb VSS) capacitor c=9.91427e-17
C28 (\6\:RT VSS) capacitor c=2.23776e-17
C29 (\4\:qbint VSS) capacitor c=5.36588e-17
C30 (\3\:n35g VSS) capacitor c=6.24243e-17
C31 (\5\:RT VSS) capacitor c=8.45437e-17
C32 (\5\:CKNbb VSS) capacitor c=1.01972e-16
C33 (\4\:RN VSS) capacitor c=3.208e-17
C34 (\5\:RNb VSS) capacitor c=6.41482e-17
C35 (\3\:n20 VSS) capacitor c=7.34077e-17
C36 (\4\:CKN VSS) capacitor c=5.42968e-17
C37 (\5\:CKNb VSS) capacitor c=2.95775e-17
C38 (\4\:CKNbb VSS) capacitor c=8.40157e-17
C39 (\3\:CKNb VSS) capacitor c=1.64337e-16
C40 (\3\:D VSS) capacitor c=5.78154e-17
C41 (\6\:qbint VSS) capacitor c=3.70282e-17
C42 (\12\:qbint VSS) capacitor c=5.80863e-17
C43 (\14\:qbint VSS) capacitor c=4.66269e-17
C44 (\4\:qint VSS) capacitor c=3.84237e-17
C45 (\7\:CKNbb VSS) capacitor c=1.94152e-16
C46 (\8\:RT VSS) capacitor c=1.21408e-16
C47 (\2\:RT VSS) capacitor c=5.6984e-17
C48 (\5\:qbint VSS) capacitor c=3.89215e-17
C49 (\5\:n35g VSS) capacitor c=3.48888e-17
C50 (\2\:RTb VSS) capacitor c=4.91473e-17
C51 (\7\:CKNb VSS) capacitor c=3.23618e-17
C52 (\1\:RN VSS) capacitor c=3.29987e-17
C53 (\7\:RNb VSS) capacitor c=6.11841e-17
C54 (\1\:CKN VSS) capacitor c=2.8269e-17
C55 (\6\:n20 VSS) capacitor c=6.24185e-17
C56 (\3\:mout VSS) capacitor c=5.02446e-17
C57 (\12\:CKNb VSS) capacitor c=4.99683e-17
C58 (\2\:CKNbb VSS) capacitor c=8.20861e-17
C59 (\1\:D VSS) capacitor c=6.41344e-17
C60 (\10\:qbint VSS) capacitor c=8.61963e-17
C61 (\14\:CKNb VSS) capacitor c=7.11054e-17
C62 (\7\:RT VSS) capacitor c=1.53748e-16
C63 (\11\:CKNb VSS) capacitor c=1.43231e-16
C64 (\3\:RT VSS) capacitor c=5.78489e-17
C65 (\1\:RT VSS) capacitor c=4.85351e-17
C66 (\3\:RTb VSS) capacitor c=7.59481e-17
C67 (\3\:qbint VSS) capacitor c=4.42884e-17
C68 (\2\:n35 VSS) capacitor c=2.6322e-16
C69 (\4\:n35g VSS) capacitor c=7.15717e-17
C70 (\6\:CKNbb VSS) capacitor c=5.61043e-17
C71 (\8\:CKNbb VSS) capacitor c=2.28294e-16
C72 (\3\:n35 VSS) capacitor c=1.20797e-16
C73 (\6\:RNb VSS) capacitor c=7.9128e-17
C74 (\3\:RN VSS) capacitor c=1.57772e-17
C75 (\3\:CKN VSS) capacitor c=2.27387e-17
C76 (\6\:CKNb VSS) capacitor c=2.31063e-17
C77 (\3\:CKNbb VSS) capacitor c=1.05896e-16
C78 (\2\:mout VSS) capacitor c=4.01023e-17
C79 (\4\:mout VSS) capacitor c=3.90488e-17
C80 (\5\:n20 VSS) capacitor c=3.95232e-17
C81 (\2\:n20 VSS) capacitor c=7.1615e-17
C82 (\4\:CKNb VSS) capacitor c=8.28107e-17
C83 (\10\:CKNb VSS) capacitor c=3.16235e-17
C84 (\2\:D VSS) capacitor c=5.58389e-17
C85 (\1\:VDD VSS) capacitor c=4.94682e-17
C86 (\3\:Q VSS) capacitor c=8.42137e-17
C87 (\13\:VDD VSS) capacitor c=4.9101e-17
C88 (\9\:qint VSS) capacitor c=5.45123e-17
C89 (\15\:VDD VSS) capacitor c=7.92013e-17
C90 (\3\:net098 VSS) capacitor c=9.93333e-17
C91 (\4\:QN VSS) capacitor c=6.24701e-17
C92 (\14\:n35 VSS) capacitor c=4.31654e-17
C93 (\15\:n35g VSS) capacitor c=5.61339e-17
C94 (\6\:RTb VSS) capacitor c=8.34453e-17
C95 (\1\:ExtVDD VSS) capacitor c=2.8119e-16
C96 (\9\:n35 VSS) capacitor c=5.47122e-17
C97 (\17\:qbint VSS) capacitor c=6.93047e-17
C98 (\6\:n35g VSS) capacitor c=9.12984e-17
C99 (\4\:n35 VSS) capacitor c=5.53723e-17
C100 (\11\:RNb VSS) capacitor c=2.80375e-17
C101 (\5\:mout VSS) capacitor c=7.04313e-17
C102 (\17\:VDD VSS) capacitor c=5.5847e-17
C103 (\19\:VDD VSS) capacitor c=4.3987e-17
C104 (\21\:CKNb VSS) capacitor c=4.74344e-17
C105 (\17\:mout VSS) capacitor c=3.50701e-17
C106 (\21\:VDD VSS) capacitor c=6.43642e-17
C107 (\23\:VDD VSS) capacitor c=4.60366e-17
C108 (\13\:CKNbb VSS) capacitor c=5.20892e-17
C109 (\7\:n20 VSS) capacitor c=4.09373e-17
C110 (\15\:n20 VSS) capacitor c=6.40648e-17
C111 (\26\:VDD VSS) capacitor c=4.0758e-17
C112 (\1\:Q VSS) capacitor c=5.33162e-17
C113 (\5\:qint VSS) capacitor c=4.88821e-17
C114 (\3\:n40 VSS) capacitor c=7.89738e-17
C115 (\1\:QN VSS) capacitor c=4.73393e-17
C116 (\17\:n35 VSS) capacitor c=4.88666e-17
C117 (\11\:n35g VSS) capacitor c=2.98389e-17
C118 (\10\:RTb VSS) capacitor c=4.8316e-17
C119 (\12\:n35 VSS) capacitor c=6.15223e-17
C120 (\19\:qbint VSS) capacitor c=2.31844e-17
C121 (\9\:n35g VSS) capacitor c=7.73799e-17
C122 (\7\:n35 VSS) capacitor c=4.50666e-17
C123 (\8\:RNb VSS) capacitor c=4.51031e-17
C124 (\9\:VDD VSS) capacitor c=5.36202e-17
C125 (\13\:mout VSS) capacitor c=5.50283e-17
C126 (\17\:CKNb VSS) capacitor c=6.59495e-17
C127 (\15\:mout VSS) capacitor c=3.61946e-17
C128 (\9\:CKNbb VSS) capacitor c=3.47839e-17
C129 (\11\:n20 VSS) capacitor c=6.16014e-17
C130 (\13\:n20 VSS) capacitor c=5.81236e-17
C131 (\2\:CKNb VSS) capacitor c=7.12688e-17
C132 (\2\:CKN VSS) capacitor c=3.30153e-17
C133 (\4\:n20 VSS) capacitor c=6.6185e-17
C134 (\2\:RN VSS) capacitor c=3.15147e-17
C135 (\2\:n35g VSS) capacitor c=3.24728e-17
C136 (ExtVDD VSS) capacitor c=3.93674e-17
C137 (\4\:RT VSS) capacitor c=7.41198e-17
C138 (\2\:qbint VSS) capacitor c=4.12006e-17
C139 (\8\:CKNb VSS) capacitor c=1.24521e-16
C140 (\9\:CKNb VSS) capacitor c=6.28227e-17
C141 (\2\:qint VSS) capacitor c=1.60038e-17
C142 (\3\:RNb VSS) capacitor c=4.94806e-16
C143 (\4\:RNb VSS) capacitor c=1.13129e-16
C144 (\15\:CKNb VSS) capacitor c=6.33677e-17
C145 (\16\:CKNb VSS) capacitor c=7.4503e-17
C146 (\8\:qbint VSS) capacitor c=5.11156e-17
C147 (\9\:qbint VSS) capacitor c=8.06912e-17
C148 (\9\:n20 VSS) capacitor c=2.90055e-17
C149 (\10\:n20 VSS) capacitor c=4.99215e-17
C150 (\17\:n20 VSS) capacitor c=3.71818e-17
C151 (\12\:CKNbb VSS) capacitor c=8.5583e-17
C152 (\15\:CKNbb VSS) capacitor c=5.08923e-17
C153 (\5\:CKN VSS) capacitor c=4.25603e-17
C154 (\19\:CKNb VSS) capacitor c=7.85443e-17
C155 (\20\:CKNb VSS) capacitor c=5.23628e-17
C156 (\5\:RN VSS) capacitor c=7.55813e-17
C157 (\7\:mout VSS) capacitor c=5.28952e-17
C158 (\8\:mout VSS) capacitor c=4.64134e-17
C159 (\9\:mout VSS) capacitor c=1.00799e-17
C160 (\10\:mout VSS) capacitor c=2.76379e-17
C161 (\11\:mout VSS) capacitor c=1.52135e-17
C162 (\12\:mout VSS) capacitor c=3.00854e-17
C163 (\10\:RNb VSS) capacitor c=6.39041e-17
C164 (\6\:n35 VSS) capacitor c=5.89405e-17
C165 (\16\:CKNbb VSS) capacitor c=3.24096e-17
C166 (\17\:CKNbb VSS) capacitor c=3.2244e-17
C167 (\8\:n35g VSS) capacitor c=3.24063e-17
C168 (\11\:n35 VSS) capacitor c=6.21139e-17
C169 (\15\:qbint VSS) capacitor c=8.81276e-17
C170 (\16\:qbint VSS) capacitor c=1.03417e-16
C171 (\13\:n35g VSS) capacitor c=1.0206e-16
C172 (\14\:n35g VSS) capacitor c=1.16302e-16
C173 (\5\:RTb VSS) capacitor c=4.95555e-17
C174 (\8\:RTb VSS) capacitor c=8.74147e-17
C175 (\9\:RTb VSS) capacitor c=5.09307e-17
C176 (\9\:RT VSS) capacitor c=1.0647e-16
C177 (\10\:RT VSS) capacitor c=1.18558e-16
C178 (\11\:RT VSS) capacitor c=3.8218e-17
C179 (\23\:CKNb VSS) capacitor c=9.70199e-17
C180 (\24\:CKNb VSS) capacitor c=9.41719e-17
C181 (\21\:qbint VSS) capacitor c=2.43444e-17
C182 (\22\:qbint VSS) capacitor c=3.01215e-17
C183 (\3\:QN VSS) capacitor c=3.16066e-17
C184 (\16\:n35 VSS) capacitor c=4.41949e-17
C185 (\7\:qint VSS) capacitor c=5.07803e-17
C186 (\8\:qint VSS) capacitor c=3.61469e-17
C187 (\3\:VDD VSS) capacitor c=5.02358e-17
C188 (\5\:VDD VSS) capacitor c=1.00153e-17
C189 (\6\:VDD VSS) capacitor c=2.35697e-16
C190 (\7\:VDD VSS) capacitor c=1.8677e-16
C191 (\8\:VDD VSS) capacitor c=5.5523e-18
C192 (\11\:VDD VSS) capacitor c=3.14884e-17
C193 (\25\:VDD VSS) capacitor c=3.15386e-17
Rk52 (RT \9\:RT) resistor r=0.1837 c=0
Rk53 (\9\:RT \10\:RT) resistor r=0.641 c=0
Rk54 (RT \11\:RT) resistor r=0.01478 c=0
Rk66 (\2\:Q Q) resistor r=0.1691 c=0
Rk67 (Q \4\:Q) resistor r=0.3374 c=0
Rk58 (\3\:QN QN) resistor r=0.04556 c=0
Rk57 (\2\:QN \3\:QN) resistor r=0.321 c=0
Rk59 (\3\:QN \5\:QN) resistor r=0.231 c=0
Rk18 (RN \5\:RN) resistor r=0.009391 c=0
Rk87 (\2\:VDD \3\:VDD) resistor r=0.5756 c=0
Rk88 (\3\:VDD \5\:VDD) resistor r=0.0667 c=0
Rk89 (\5\:VDD \6\:VDD) resistor r=0.05184 c=0
Rk90 (\6\:VDD \7\:VDD) resistor r=1.6299 c=0
Rk91 (\7\:VDD \8\:VDD) resistor r=0.02934 c=0
Rk92 (\8\:VDD \10\:VDD) resistor r=0.04193 c=0
Rk93 (\10\:VDD \11\:VDD) resistor r=0.1485 c=0
Rk101 (\12\:VDD VDD) resistor r=0.2184 c=0
Rk94 (\11\:VDD \12\:VDD) resistor r=0.05927 c=0
Rk95 (\3\:VDD \14\:VDD) resistor r=0.2925 c=0
Rk96 (\6\:VDD \16\:VDD) resistor r=0.3607 c=0
Rk97 (\7\:VDD \18\:VDD) resistor r=0.3587 c=0
Rk98 (\8\:VDD \20\:VDD) resistor r=0.2013 c=0
Rk99 (\11\:VDD \22\:VDD) resistor r=0.4029 c=0
Rk100 (\12\:VDD \24\:VDD) resistor r=0.2467 c=0
Rk102 (VDD \25\:VDD) resistor r=0.1462 c=0
Rk103 (\25\:VDD VDD) resistor r=0.08875 c=0
Rk104 (\25\:VDD \27\:VDD) resistor r=0.3582 c=0
Rk14 (CKN \5\:CKN) resistor r=0.0156 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.004531 c=0
Rk39 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk37 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk40 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk41 (ExtVDD \6\:ExtVDD) resistor r=0.1068 c=0
Rk69 (\2\:VSS \4\:VSS) resistor r=0.361 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.2377 c=0
Rk71 (\5\:VSS \6\:VSS) resistor r=0.5548 c=0
Rk72 (\6\:VSS \7\:VSS) resistor r=0.1163 c=0
Rk74 (\8\:VSS VSS) resistor r=0.07141 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.2077 c=0
Rk75 (VSS \9\:VSS) resistor r=0.6789 c=0
Rk77 (\10\:VSS VSS) resistor r=0.1187 c=0
Rk76 (\9\:VSS \10\:VSS) resistor r=0.06422 c=0
Rk78 (VSS \11\:VSS) resistor r=0.03722 c=0
Rk79 (\11\:VSS \12\:VSS) resistor r=0.4233 c=0
Rk80 (\12\:VSS \13\:VSS) resistor r=0.06422 c=0
Rk81 (\5\:VSS \15\:VSS) resistor r=0.2632 c=0
Rk82 (\7\:VSS \17\:VSS) resistor r=0.189 c=0
Rk83 (\8\:VSS \19\:VSS) resistor r=0.194 c=0
Rk84 (\9\:VSS \21\:VSS) resistor r=0.2356 c=0
Rk85 (\11\:VSS \23\:VSS) resistor r=0.2362 c=0
Rk86 (\12\:VSS \25\:VSS) resistor r=0.228 c=0
Rk105 (\27\:VSS \28\:VSS) resistor r=0.08405 c=0
Rk106 (\28\:VSS \29\:VSS) resistor r=0.1138 c=0
Rk107 (\29\:VSS \30\:VSS) resistor r=0.089 c=0
Rk108 (\30\:VSS \31\:VSS) resistor r=0.3566 c=0
Rk110 (\32\:VSS VSS) resistor r=0.3266 c=0
Rk109 (\31\:VSS \32\:VSS) resistor r=0.3667 c=0
Rk111 (VSS \33\:VSS) resistor r=0.1985 c=0
Rk113 (\34\:VSS VSS) resistor r=0.2077 c=0
Rk112 (\33\:VSS \34\:VSS) resistor r=0.5573 c=0
Rk114 (VSS \35\:VSS) resistor r=0.0174 c=0
Rk115 (\35\:VSS \36\:VSS) resistor r=0.1088 c=0
Rk116 (\28\:VSS \38\:VSS) resistor r=0.2396 c=0
Rk117 (\30\:VSS \40\:VSS) resistor r=0.2459 c=0
Rk118 (\32\:VSS \42\:VSS) resistor r=0.2432 c=0
Rk119 (\34\:VSS \44\:VSS) resistor r=0.2396 c=0
Rk120 (\35\:VSS \46\:VSS) resistor r=0.2396 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6835 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.3598 c=0
Rk16 (\19\:CKNb \20\:CKNb) resistor r=0.1631 c=0
Rk17 (\19\:CKNb \22\:CKNb) resistor r=0.2097 c=0
Rk55 (\23\:CKNb \24\:CKNb) resistor r=0.7181 c=0
Rk19 (\6\:mout \7\:mout) resistor r=0.4259 c=0
Rk20 (\7\:mout \8\:mout) resistor r=0.3627 c=0
Rk21 (\8\:mout \9\:mout) resistor r=0.1415 c=0
Rk22 (\9\:mout \10\:mout) resistor r=0.1932 c=0
Rk23 (\7\:mout \11\:mout) resistor r=0.1187 c=0
Rk24 (\11\:mout \12\:mout) resistor r=0.216 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.3231 c=0
Rk26 (\9\:mout \16\:mout) resistor r=0.1038 c=0
Rk27 (\11\:mout \18\:mout) resistor r=0.1204 c=0
Rk9 (\10\:CKNbb \11\:CKNbb) resistor r=0.2133 c=0
Rk10 (\11\:CKNbb \12\:CKNbb) resistor r=0.01512 c=0
Rk11 (\11\:CKNbb \14\:CKNbb) resistor r=0.3381 c=0
Rk12 (\14\:CKNbb \15\:CKNbb) resistor r=0.2712 c=0
Rk32 (\16\:CKNbb \17\:CKNbb) resistor r=0.2962 c=0
Rk4 (\8\:n20 \9\:n20) resistor r=0.2065 c=0
Rk5 (\8\:n20 \10\:n20) resistor r=0.2094 c=0
Rk6 (\10\:n20 \12\:n20) resistor r=0.4405 c=0
Rk7 (\14\:n20 \16\:n20) resistor r=0.4882 c=0
Rk8 (\16\:n20 \17\:n20) resistor r=0.1576 c=0
Rk28 (\9\:RNb \10\:RNb) resistor r=0.3415 c=0
Rk29 (\10\:RNb \12\:RNb) resistor r=0.1481 c=0
Rk33 (\7\:n35g \8\:n35g) resistor r=0.2405 c=0
Rk34 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk45 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk46 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk47 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk42 (\15\:qbint \16\:qbint) resistor r=0.494 c=0
Rk43 (\16\:qbint \18\:qbint) resistor r=0.5666 c=0
Rk44 (\16\:qbint \20\:qbint) resistor r=0.1462 c=0
Rk56 (\21\:qbint \22\:qbint) resistor r=0.2116 c=0
Rk48 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk49 (\7\:RTb \8\:RTb) resistor r=0.521 c=0
Rk50 (\8\:RTb \9\:RTb) resistor r=0.3884 c=0
Rk51 (\8\:RTb \11\:RTb) resistor r=0.2014 c=0
Rk62 (\6\:qint \7\:qint) resistor r=0.2581 c=0
Rk63 (\7\:qint \8\:qint) resistor r=0.1613 c=0
Rk64 (\7\:qint \10\:qint) resistor r=0.2803 c=0
Rk30 (\5\:n35 \6\:n35) resistor r=0.3197 c=0
Rk31 (\6\:n35 \8\:n35) resistor r=0.4238 c=0
Rk35 (\10\:n35 \11\:n35) resistor r=0.3183 c=0
Rk36 (\11\:n35 \13\:n35) resistor r=0.3874 c=0
Rk60 (\15\:n35 \16\:n35) resistor r=0.2318 c=0
Rk61 (\16\:n35 \18\:n35) resistor r=0.3588 c=0
Rk68 (\2\:net098 \4\:net098) resistor r=0.7065 c=0
Rk65 (\2\:n40 \4\:n40) resistor r=0.625 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl2 (\2\:D \3\:D) resistor r=50.0257 c=0
Rl1 (\1\:D \2\:D) resistor r=128.573 c=0
Rl20 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl18 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl19 (\2\:RN \3\:RN) resistor r=3.1183 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl46 (\13\:CKNb \14\:CKNb) resistor r=159.438 c=0
Rl9 (\3\:CKNb \4\:CKNb) resistor r=349.426 c=0
Rl7 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl10 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl8 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl11 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl38 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl41 (\8\:CKNb \11\:CKNb) resistor r=820.277 c=0
Rl42 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl40 (\9\:CKNb \10\:CKNb) resistor r=132.647 c=0
Rl39 (\8\:CKNb \9\:CKNb) resistor r=339.792 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl4 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=177.372 c=0
Rl47 (\7\:CKNbb \8\:CKNbb) resistor r=908.226 c=0
Rl22 (\3\:CKNbb \5\:CKNbb) resistor r=446.949 c=0
Rl21 (\3\:CKNbb \4\:CKNbb) resistor r=188.95 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=154.568 c=0
Rl17 (\4\:n20 \6\:n20) resistor r=191.976 c=0
Rl16 (\4\:n20 \5\:n20) resistor r=128.737 c=0
Rl51 (RNb \2\:RNb) resistor r=234.8 c=0
Rl52 (\2\:RNb \3\:RNb) resistor r=1125.6 c=0
Rl55 (\3\:RNb \6\:RNb) resistor r=707.521 c=0
Rl54 (\4\:RNb \5\:RNb) resistor r=106.884 c=0
Rl56 (\4\:RNb \7\:RNb) resistor r=197.09 c=0
Rl53 (\3\:RNb \4\:RNb) resistor r=336.011 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl57 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl62 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl64 (\13\:qbint \14\:qbint) resistor r=199.892 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl58 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl61 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl63 (\9\:qbint \13\:qbint) resistor r=88.6112 c=0
Rl60 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl59 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl28 (RTb \2\:RTb) resistor r=121.113 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl48 (qint \2\:qint) resistor r=3.1216 c=0
Rl49 (\2\:qint \3\:qint) resistor r=64.1263 c=0
Rl50 (\2\:qint \4\:qint) resistor r=77.1508 c=0
Rl44 (n35 \2\:n35) resistor r=508.667 c=0
Rl45 (\2\:n35 \3\:n35) resistor r=358.667 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz15 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz29 (\9\:VDD \10\:VDD) resistor r=15 c=0
Rz30 (\9\:VDD \12\:VDD) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz23 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz24 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz25 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz26 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz31 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz32 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz33 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz34 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz35 (\45\:VSS \46\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz5 (\13\:mout \14\:mout) resistor r=75 c=0
Rz6 (\15\:mout \16\:mout) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz1 (\11\:n20 \12\:n20) resistor r=75 c=0
Rz2 (\13\:n20 \14\:n20) resistor r=75 c=0
Rz7 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz9 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz13 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz12 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz14 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz17 (\5\:qint \6\:qint) resistor r=75 c=0
Rz8 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz10 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz16 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz18 (n40 \2\:n40) resistor r=75 c=0
Rz19 (\3\:n40 \4\:n40) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry28 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry29 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry32 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry33 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry34 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=5.6364 c=0
Ry25 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry26 (\3\:VSS \13\:VSS) resistor r=62 c=0
Ry35 (\26\:VSS \27\:VSS) resistor r=31 c=0
Ry36 (\26\:VSS \29\:VSS) resistor r=31 c=0
Ry37 (\26\:VSS \31\:VSS) resistor r=8.8571 c=0
Ry38 (\26\:VSS \33\:VSS) resistor r=5.6364 c=0
Ry39 (\26\:VSS \36\:VSS) resistor r=8.8571 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\17\:mout \18\:mout) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\15\:n20 \16\:n20) resistor r=62 c=0
Ry7 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry21 (net098 \2\:net098) resistor r=62 c=0
Ry22 (\3\:net098 \4\:net098) resistor r=62 c=0
Rx24 (\3\:RT \9\:RT) resistor r=45 c=0
Rx25 (\1\:RT \10\:RT) resistor r=45 c=0
Rx26 (\7\:RT \11\:RT) resistor r=45 c=0
Rx3 (\2\:D D) resistor r=45 c=0
Rx11 (\3\:RN \5\:RN) resistor r=45 c=0
Rx9 (\3\:CKN \6\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx10 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx27 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx28 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx12 (\4\:mout \10\:mout) resistor r=45 c=0
Rx13 (\2\:mout \12\:mout) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx16 (\6\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx17 (\8\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx4 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \10\:n20) resistor r=45 c=0
Rx6 (n20 \17\:n20) resistor r=45 c=0
Rx14 (\6\:RNb \10\:RNb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx29 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx30 (qbint \22\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx32 (qint \8\:qint) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\13\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\11\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\9\:CKNbb CKNb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \6\:n20 \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKNb \1\:CKN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\13\:mout \7\:RNb \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\8\:RNb \1\:RN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \7\:CKNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM3 (net0121 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \7\:CKNbb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn51 (n40 RNb \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \12\:qbint \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\15\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\7\:n20 \4\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\13\:CKNbb \5\:CKNb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\21\:CKNb \4\:CKN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\17\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.71023 \
        scb=0.00138809 scc=2.58214e-06 m=(1)
mp31 (net402 \5\:RNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.19408 \
        scb=0.00174819 scc=3.02997e-06 m=(1)
mp22 (\11\:RNb \4\:RN \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.8901 \
        scb=0.0121892 scc=0.000217629 m=(1)
mp40 (\4\:n35 \5\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.8142 \
        scb=0.0201994 scc=0.00140887 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:net098 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.3875 \
        scb=0.0109499 scc=0.000167564 m=(1)
mp51 (n43 \2\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (net098 \11\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends RDFFNRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:42:33 2012 )
// Library name: gsclib045
// Cell name: RDFFNSQX1
// View name: extracted

simulator lang=spectre

subckt RDFFNSQX1 CKN D ExtVDD Q RT SN VDD VSS
mp25 (n22 \3\:D \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (ExtVDD VSS) capacitor c=1.96739e-16
C2 (VDD VSS) capacitor c=5.91679e-16
C3 (Q VSS) capacitor c=1.79005e-17
C4 (SN VSS) capacitor c=2.99551e-17
C5 (D VSS) capacitor c=4.48698e-17
C6 (RT VSS) capacitor c=2.36568e-17
C7 (CKNb VSS) capacitor c=4.74426e-17
C8 (mout VSS) capacitor c=5.78803e-17
C9 (n20 VSS) capacitor c=9.36736e-17
C10 (CKNbb VSS) capacitor c=5.22865e-17
C11 (n35g VSS) capacitor c=1.7772e-17
C12 (qbint VSS) capacitor c=4.605e-17
C13 (RTb VSS) capacitor c=5.17974e-17
C14 (n35 VSS) capacitor c=1.71393e-16
C15 (n41 VSS) capacitor c=8.52477e-17
C16 (net095 VSS) capacitor c=3.65082e-17
C17 (\7\:SN VSS) capacitor c=6.8242e-17
C18 (\7\:qbint VSS) capacitor c=3.73134e-17
C19 (\10\:qbint VSS) capacitor c=7.48839e-17
C20 (\13\:CKNb VSS) capacitor c=4.45454e-17
C21 (\4\:RTb VSS) capacitor c=9.81917e-17
C22 (\6\:RT VSS) capacitor c=2.25809e-17
C23 (\4\:qbint VSS) capacitor c=5.35387e-17
C24 (\3\:n35g VSS) capacitor c=5.78049e-17
C25 (\5\:RT VSS) capacitor c=6.34845e-17
C26 (\6\:CKNbb VSS) capacitor c=1.08001e-16
C27 (\3\:n20 VSS) capacitor c=3.33207e-17
C28 (\4\:CKN VSS) capacitor c=4.88733e-17
C29 (\5\:CKNb VSS) capacitor c=2.58224e-17
C30 (\1\:SN VSS) capacitor c=3.80128e-17
C31 (\5\:CKNbb VSS) capacitor c=7.5352e-17
C32 (\3\:CKNb VSS) capacitor c=1.79695e-16
C33 (\3\:D VSS) capacitor c=7.31938e-17
C34 (\8\:SN VSS) capacitor c=1.32122e-16
C35 (\6\:qbint VSS) capacitor c=4.17418e-17
C36 (\11\:qbint VSS) capacitor c=1.03189e-16
C37 (\8\:CKNbb VSS) capacitor c=2.22966e-16
C38 (\7\:RT VSS) capacitor c=1.19339e-16
C39 (\2\:RT VSS) capacitor c=6.21796e-17
C40 (\5\:qbint VSS) capacitor c=3.87553e-17
C41 (\5\:n35g VSS) capacitor c=2.76764e-17
C42 (\2\:RTb VSS) capacitor c=4.64723e-17
C43 (\7\:CKNb VSS) capacitor c=2.68763e-17
C44 (\1\:CKN VSS) capacitor c=2.98642e-17
C45 (\6\:n20 VSS) capacitor c=6.25702e-17
C46 (\6\:SN VSS) capacitor c=6.49368e-17
C47 (\3\:mout VSS) capacitor c=4.54723e-17
C48 (\12\:CKNb VSS) capacitor c=5.02123e-17
C49 (\2\:CKNbb VSS) capacitor c=8.31957e-17
C50 (\1\:D VSS) capacitor c=4.89351e-17
C51 (\9\:qbint VSS) capacitor c=8.58809e-17
C52 (\14\:CKNb VSS) capacitor c=5.14501e-17
C53 (\3\:SN VSS) capacitor c=2.91732e-16
C54 (\9\:SN VSS) capacitor c=8.56458e-17
C55 (\8\:RT VSS) capacitor c=1.46027e-16
C56 (\11\:CKNb VSS) capacitor c=1.77358e-16
C57 (\3\:RT VSS) capacitor c=3.94579e-17
C58 (\1\:RT VSS) capacitor c=5.27398e-17
C59 (\3\:RTb VSS) capacitor c=7.49488e-17
C60 (\3\:qbint VSS) capacitor c=4.39473e-17
C61 (\2\:n35 VSS) capacitor c=2.61705e-16
C62 (\4\:n35g VSS) capacitor c=5.00701e-17
C63 (\7\:CKNbb VSS) capacitor c=5.81809e-17
C64 (\9\:CKNbb VSS) capacitor c=2.18386e-16
C65 (\3\:n35 VSS) capacitor c=1.21618e-16
C66 (\4\:n20 VSS) capacitor c=1.01132e-16
C67 (\7\:n20 VSS) capacitor c=5.44107e-17
C68 (\3\:CKN VSS) capacitor c=2.32665e-17
C69 (\6\:CKNb VSS) capacitor c=2.23336e-17
C70 (\3\:CKNbb VSS) capacitor c=4.70435e-17
C71 (\2\:SN VSS) capacitor c=4.35742e-17
C72 (\5\:SN VSS) capacitor c=2.91933e-17
C73 (\2\:mout VSS) capacitor c=4.85356e-17
C74 (\4\:mout VSS) capacitor c=3.16028e-17
C75 (\5\:n20 VSS) capacitor c=8.5158e-17
C76 (\2\:n20 VSS) capacitor c=6.49941e-17
C77 (\2\:D VSS) capacitor c=5.55605e-17
C78 (\4\:CKNb VSS) capacitor c=7.92929e-17
C79 (\10\:CKNb VSS) capacitor c=3.11267e-17
C80 (\1\:VDD VSS) capacitor c=2.92536e-17
C81 (\12\:VDD VSS) capacitor c=5.00752e-17
C82 (\4\:Q VSS) capacitor c=5.48076e-17
C83 (\14\:VDD VSS) capacitor c=5.29405e-17
C84 (\3\:n41 VSS) capacitor c=8.37796e-17
C85 (\14\:n35 VSS) capacitor c=5.17803e-17
C86 (\15\:n35g VSS) capacitor c=5.70424e-17
C87 (\6\:RTb VSS) capacitor c=7.29811e-17
C88 (\1\:ExtVDD VSS) capacitor c=2.77107e-16
C89 (\9\:n35 VSS) capacitor c=6.26057e-17
C90 (\14\:qbint VSS) capacitor c=6.58354e-17
C91 (\6\:n35g VSS) capacitor c=8.97533e-17
C92 (\4\:n35 VSS) capacitor c=4.99306e-17
C93 (\5\:mout VSS) capacitor c=7.98565e-17
C94 (\10\:VDD VSS) capacitor c=4.71057e-17
C95 (\21\:CKNb VSS) capacitor c=3.05448e-17
C96 (\19\:mout VSS) capacitor c=4.31004e-17
C97 (\20\:VDD VSS) capacitor c=6.56353e-17
C98 (\16\:mout VSS) capacitor c=4.41383e-17
C99 (\14\:CKNbb VSS) capacitor c=5.22316e-17
C100 (\18\:VDD VSS) capacitor c=5.40371e-17
C101 (\16\:n20 VSS) capacitor c=5.10191e-17
C102 (\8\:n20 VSS) capacitor c=2.51129e-17
C103 (\23\:VDD VSS) capacitor c=3.3561e-17
C104 (\1\:Q VSS) capacitor c=3.78982e-17
C105 (\3\:net095 VSS) capacitor c=4.63461e-17
C106 (\17\:n35 VSS) capacitor c=4.64849e-17
C107 (\11\:n35g VSS) capacitor c=2.63285e-17
C108 (\10\:RTb VSS) capacitor c=5.837e-17
C109 (\12\:n35 VSS) capacitor c=6.37319e-17
C110 (\16\:qbint VSS) capacitor c=2.28194e-17
C111 (\9\:n35g VSS) capacitor c=8.0367e-17
C112 (\7\:n35 VSS) capacitor c=4.06373e-17
C113 (\7\:VDD VSS) capacitor c=2.11838e-16
C114 (\11\:mout VSS) capacitor c=2.19046e-17
C115 (\17\:CKNb VSS) capacitor c=4.68446e-17
C116 (\13\:mout VSS) capacitor c=1.72408e-17
C117 (\10\:CKNbb VSS) capacitor c=3.4966e-17
C118 (\14\:n20 VSS) capacitor c=7.25498e-17
C119 (\12\:n20 VSS) capacitor c=5.95317e-17
C120 (VDD VSS) capacitor c=6.81622e-18
C121 (\2\:CKNb VSS) capacitor c=7.16974e-17
C122 (\2\:CKN VSS) capacitor c=3.34739e-17
C123 (\4\:CKNbb VSS) capacitor c=1.00394e-16
C124 (\2\:n35g VSS) capacitor c=3.38232e-17
C125 (ExtVDD VSS) capacitor c=3.9408e-17
C126 (\4\:RT VSS) capacitor c=4.60848e-17
C127 (\2\:qbint VSS) capacitor c=4.11548e-17
C128 (\8\:CKNb VSS) capacitor c=1.15856e-16
C129 (\9\:CKNb VSS) capacitor c=8.15716e-17
C130 (\4\:SN VSS) capacitor c=3.13373e-16
C131 (\15\:CKNb VSS) capacitor c=5.31729e-17
C132 (\16\:CKNb VSS) capacitor c=6.96531e-17
C133 (\8\:qbint VSS) capacitor c=9.27479e-17
C134 (\10\:n20 VSS) capacitor c=4.04663e-17
C135 (\11\:n20 VSS) capacitor c=6.27258e-17
C136 (\18\:n20 VSS) capacitor c=4.18669e-17
C137 (\13\:CKNbb VSS) capacitor c=7.85558e-17
C138 (\16\:CKNbb VSS) capacitor c=5.19996e-17
C139 (\10\:SN VSS) capacitor c=3.11797e-17
C140 (\11\:SN VSS) capacitor c=3.68193e-17
C141 (\5\:CKN VSS) capacitor c=4.65033e-17
C142 (\6\:CKN VSS) capacitor c=3.74964e-17
C143 (\19\:CKNb VSS) capacitor c=4.85872e-17
C144 (\20\:CKNb VSS) capacitor c=4.95557e-17
C145 (\19\:n20 VSS) capacitor c=5.20272e-17
C146 (\20\:n20 VSS) capacitor c=6.02032e-17
C147 (\7\:mout VSS) capacitor c=7.29124e-17
C148 (\8\:mout VSS) capacitor c=3.59705e-17
C149 (\9\:mout VSS) capacitor c=7.62999e-17
C150 (\10\:mout VSS) capacitor c=7.92571e-17
C151 (\15\:mout VSS) capacitor c=5.7913e-17
C152 (\18\:mout VSS) capacitor c=6.32126e-17
C153 (\6\:n35 VSS) capacitor c=6.5573e-17
C154 (\17\:CKNbb VSS) capacitor c=2.97131e-17
C155 (\18\:CKNbb VSS) capacitor c=3.26625e-17
C156 (\8\:n35g VSS) capacitor c=2.94235e-17
C157 (\11\:n35 VSS) capacitor c=7.54515e-17
C158 (\12\:qbint VSS) capacitor c=8.83084e-17
C159 (\13\:qbint VSS) capacitor c=1.09817e-16
C160 (\13\:n35g VSS) capacitor c=9.9692e-17
C161 (\14\:n35g VSS) capacitor c=1.16251e-16
C162 (\5\:RTb VSS) capacitor c=4.78848e-17
C163 (\8\:RTb VSS) capacitor c=9.96226e-17
C164 (\9\:RTb VSS) capacitor c=9.16058e-17
C165 (\9\:RT VSS) capacitor c=1.10152e-16
C166 (\10\:RT VSS) capacitor c=1.18489e-16
C167 (\11\:RT VSS) capacitor c=3.88157e-17
C168 (\12\:SN VSS) capacitor c=8.32135e-17
C169 (\13\:SN VSS) capacitor c=7.96288e-17
C170 (\23\:CKNb VSS) capacitor c=1.299e-16
C171 (\24\:CKNb VSS) capacitor c=1.34513e-16
C172 (\18\:qbint VSS) capacitor c=1.95635e-17
C173 (\19\:qbint VSS) capacitor c=3.00211e-17
C174 (\16\:n35 VSS) capacitor c=4.37466e-17
C175 (\3\:Q VSS) capacitor c=1.71982e-17
C176 (\3\:VDD VSS) capacitor c=2.57115e-17
C177 (\4\:VDD VSS) capacitor c=2.853e-17
C178 (\6\:VDD VSS) capacitor c=2.14039e-16
C179 (\9\:VDD VSS) capacitor c=1.7149e-17
C180 (\17\:VDD VSS) capacitor c=4.33062e-17
C181 (\22\:VDD VSS) capacitor c=3.8566e-17
Rk40 (ExtVDD ExtVDD) resistor r=0.002059 c=0
Rk38 (\2\:ExtVDD ExtVDD) resistor r=0.02212 c=0
Rk41 (ExtVDD \5\:ExtVDD) resistor r=0.02011 c=0
Rk42 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk66 (\2\:VDD \3\:VDD) resistor r=0.3358 c=0
Rk67 (\3\:VDD \4\:VDD) resistor r=0.1655 c=0
Rk68 (\4\:VDD \6\:VDD) resistor r=0.1087 c=0
Rk69 (\6\:VDD \8\:VDD) resistor r=1.6215 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.07655 c=0
Rk71 (\9\:VDD \11\:VDD) resistor r=0.2734 c=0
Rk72 (\3\:VDD \13\:VDD) resistor r=0.3558 c=0
Rk73 (\4\:VDD \15\:VDD) resistor r=0.3008 c=0
Rk74 (\9\:VDD \16\:VDD) resistor r=0.161 c=0
Rk78 (\17\:VDD VDD) resistor r=0.1011 c=0
Rk75 (\16\:VDD \17\:VDD) resistor r=0.1759 c=0
Rk76 (\17\:VDD \19\:VDD) resistor r=0.2748 c=0
Rk77 (\16\:VDD \21\:VDD) resistor r=0.448 c=0
Rk79 (VDD \22\:VDD) resistor r=0.1461 c=0
Rk80 (\22\:VDD VDD) resistor r=0.08868 c=0
Rk81 (\22\:VDD \24\:VDD) resistor r=0.358 c=0
Rk63 (\3\:Q Q) resistor r=0.01282 c=0
Rk62 (\2\:Q \3\:Q) resistor r=0.2889 c=0
Rk64 (\3\:Q \5\:Q) resistor r=0.3262 c=0
Rk12 (\10\:SN SN) resistor r=0.01917 c=0
Rk13 (SN \11\:SN) resistor r=0.1486 c=0
Rk56 (\12\:SN \13\:SN) resistor r=0.5349 c=0
Rk82 (\2\:VSS \4\:VSS) resistor r=0.6658 c=0
Rk83 (\4\:VSS \5\:VSS) resistor r=0.5151 c=0
Rk85 (\6\:VSS VSS) resistor r=0.09878 c=0
Rk84 (\5\:VSS \6\:VSS) resistor r=0.2771 c=0
Rk87 (\7\:VSS VSS) resistor r=0.1211 c=0
Rk86 (VSS \7\:VSS) resistor r=0.7924 c=0
Rk88 (VSS \9\:VSS) resistor r=0.3935 c=0
Rk89 (\5\:VSS \11\:VSS) resistor r=0.243 c=0
Rk90 (\13\:VSS \14\:VSS) resistor r=0.05179 c=0
Rk91 (\14\:VSS \15\:VSS) resistor r=0.09635 c=0
Rk92 (\15\:VSS \16\:VSS) resistor r=0.6932 c=0
Rk93 (\16\:VSS \17\:VSS) resistor r=0.1657 c=0
Rk95 (\18\:VSS VSS) resistor r=0.1209 c=0
Rk94 (\17\:VSS \18\:VSS) resistor r=0.2076 c=0
Rk97 (\19\:VSS VSS) resistor r=0.1186 c=0
Rk96 (VSS \19\:VSS) resistor r=0.6934 c=0
Rk98 (VSS \20\:VSS) resistor r=0.03719 c=0
Rk99 (\20\:VSS \21\:VSS) resistor r=0.4229 c=0
Rk100 (\21\:VSS \22\:VSS) resistor r=0.06417 c=0
Rk101 (\14\:VSS \24\:VSS) resistor r=0.26 c=0
Rk102 (\17\:VSS \26\:VSS) resistor r=0.1888 c=0
Rk103 (\18\:VSS \28\:VSS) resistor r=0.1939 c=0
Rk104 (\20\:VSS \30\:VSS) resistor r=0.236 c=0
Rk105 (\21\:VSS \32\:VSS) resistor r=0.2279 c=0
Rk2 (\4\:D D) resistor r=0.006922 c=0
Rk53 (RT \9\:RT) resistor r=0.1836 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6451 c=0
Rk55 (RT \11\:RT) resistor r=0.01477 c=0
Rk14 (CKN \5\:CKN) resistor r=0.004347 c=0
Rk16 (\5\:CKN \6\:CKN) resistor r=0.01654 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.004528 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6148 c=0
Rk17 (\18\:CKNb \19\:CKNb) resistor r=0.3357 c=0
Rk18 (\19\:CKNb \20\:CKNb) resistor r=0.163 c=0
Rk19 (\19\:CKNb \22\:CKNb) resistor r=0.2006 c=0
Rk57 (\23\:CKNb \24\:CKNb) resistor r=0.8232 c=0
Rk21 (\6\:mout \7\:mout) resistor r=0.5282 c=0
Rk22 (\7\:mout \8\:mout) resistor r=0.2958 c=0
Rk23 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk24 (\9\:mout \10\:mout) resistor r=0.3397 c=0
Rk25 (\7\:mout \12\:mout) resistor r=0.1276 c=0
Rk26 (\8\:mout \14\:mout) resistor r=0.09176 c=0
Rk27 (\9\:mout \15\:mout) resistor r=0.4799 c=0
Rk28 (\15\:mout \17\:mout) resistor r=0.04475 c=0
Rk29 (\10\:mout \18\:mout) resistor r=0.3472 c=0
Rk30 (\15\:mout \20\:mout) resistor r=0.03458 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.1919 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.21 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.3756 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4879 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1439 c=0
Rk20 (\19\:n20 \20\:n20) resistor r=0.2682 c=0
Rk8 (\11\:CKNbb \12\:CKNbb) resistor r=0.2126 c=0
Rk9 (\12\:CKNbb \13\:CKNbb) resistor r=0.01511 c=0
Rk10 (\12\:CKNbb \15\:CKNbb) resistor r=0.3377 c=0
Rk11 (\15\:CKNbb \16\:CKNbb) resistor r=0.2711 c=0
Rk33 (\17\:CKNbb \18\:CKNbb) resistor r=0.2992 c=0
Rk34 (\7\:n35g \8\:n35g) resistor r=0.2403 c=0
Rk35 (\7\:n35g \10\:n35g) resistor r=0.6903 c=0
Rk46 (\12\:n35g \13\:n35g) resistor r=0.2425 c=0
Rk47 (\13\:n35g \14\:n35g) resistor r=0.5645 c=0
Rk48 (\13\:n35g \16\:n35g) resistor r=0.4312 c=0
Rk43 (\12\:qbint \13\:qbint) resistor r=0.4937 c=0
Rk44 (\13\:qbint \15\:qbint) resistor r=0.5662 c=0
Rk45 (\13\:qbint \17\:qbint) resistor r=0.146 c=0
Rk58 (\18\:qbint \19\:qbint) resistor r=0.2114 c=0
Rk49 (\5\:RTb \7\:RTb) resistor r=0.2158 c=0
Rk50 (\7\:RTb \8\:RTb) resistor r=0.4158 c=0
Rk51 (\8\:RTb \9\:RTb) resistor r=0.6874 c=0
Rk52 (\8\:RTb \11\:RTb) resistor r=0.3061 c=0
Rk31 (\5\:n35 \6\:n35) resistor r=0.3332 c=0
Rk32 (\6\:n35 \8\:n35) resistor r=0.2898 c=0
Rk36 (\10\:n35 \11\:n35) resistor r=0.4003 c=0
Rk37 (\11\:n35 \13\:n35) resistor r=0.3293 c=0
Rk59 (\15\:n35 \16\:n35) resistor r=0.3032 c=0
Rk60 (\16\:n35 \18\:n35) resistor r=0.2743 c=0
Rk65 (\2\:n41 \4\:n41) resistor r=0.6517 c=0
Rk61 (\2\:net095 \4\:net095) resistor r=0.2043 c=0
Rl55 (\7\:SN \8\:SN) resistor r=234.813 c=0
Rl56 (\8\:SN \9\:SN) resistor r=434.764 c=0
Rl7 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl45 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl43 (\3\:SN \4\:SN) resistor r=1126.2 c=0
Rl44 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl2 (\2\:D \3\:D) resistor r=108.118 c=0
Rl1 (\1\:D \2\:D) resistor r=70.6183 c=0
Rl42 (\7\:RT \8\:RT) resistor r=650.933 c=0
Rl29 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl32 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl31 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl30 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl15 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl13 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl14 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl48 (\13\:CKNb \14\:CKNb) resistor r=166.412 c=0
Rl10 (\3\:CKNb \4\:CKNb) resistor r=446.586 c=0
Rl8 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl11 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl9 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl12 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl37 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl40 (\8\:CKNb \11\:CKNb) resistor r=794.708 c=0
Rl41 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl39 (\9\:CKNb \10\:CKNb) resistor r=129.238 c=0
Rl38 (\8\:CKNb \9\:CKNb) resistor r=430.133 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=105.531 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=236.609 c=0
Rl6 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl22 (\6\:CKNbb \7\:CKNbb) resistor r=196.122 c=0
Rl49 (\8\:CKNbb \9\:CKNbb) resistor r=870.726 c=0
Rl21 (\4\:CKNbb \6\:CKNbb) resistor r=422.225 c=0
Rl20 (\4\:CKNbb \5\:CKNbb) resistor r=113.702 c=0
Rl19 (\3\:CKNbb \4\:CKNbb) resistor r=158.657 c=0
Rl25 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl23 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl24 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl26 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl50 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl54 (\10\:qbint \11\:qbint) resistor r=252.671 c=0
Rl36 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl33 (qbint \2\:qbint) resistor r=112.732 c=0
Rl35 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl51 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl53 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl52 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl27 (RTb \2\:RTb) resistor r=112.412 c=0
Rl28 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl46 (n35 \2\:n35) resistor r=508.667 c=0
Rl47 (\2\:n35 \3\:n35) resistor r=367.189 c=0
Rz19 (\7\:VDD \8\:VDD) resistor r=25 c=0
Rz20 (\7\:VDD \16\:VDD) resistor r=15 c=0
Rz17 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz23 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz25 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz26 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz27 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz28 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz3 (\10\:CKNbb \11\:CKNbb) resistor r=75 c=0
Rz8 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz12 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz11 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz13 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz7 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz9 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz14 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz15 (net095 \2\:net095) resistor r=75 c=0
Rz16 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry21 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry22 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry23 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry24 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry25 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry26 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry27 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry28 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\3\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry30 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry31 (\12\:VSS \13\:VSS) resistor r=62 c=0
Ry32 (\12\:VSS \15\:VSS) resistor r=31 c=0
Ry33 (\12\:VSS \16\:VSS) resistor r=5.1667 c=0
Ry34 (\12\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry35 (\12\:VSS \22\:VSS) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\16\:mout \17\:mout) resistor r=62 c=0
Ry7 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry3 (\14\:CKNbb \15\:CKNbb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry17 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry19 (n41 \2\:n41) resistor r=62 c=0
Ry20 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx29 (\3\:SN \12\:SN) resistor r=45 c=0
Rx30 (\9\:SN \13\:SN) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx26 (\3\:RT \9\:RT) resistor r=45 c=0
Rx27 (\1\:RT \10\:RT) resistor r=45 c=0
Rx28 (\8\:RT \11\:RT) resistor r=45 c=0
Rx11 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx12 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx31 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx32 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \20\:n20) resistor r=45 c=0
Rx7 (CKNbb \13\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx18 (\7\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx19 (\9\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx20 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx23 (n35g \14\:n35g) resistor r=45 c=0
Rx22 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx33 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx34 (qbint \19\:qbint) resistor r=45 c=0
Rx24 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx25 (RTb \9\:RTb) resistor r=45 c=0
Rx17 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx21 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx35 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\10\:CKNbb CKNb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net426 \6\:SN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKNb \1\:CKN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \7\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\16\:qbint \5\:n35g \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \8\:CKNbb \3\:net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net095 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \8\:SN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\16\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \5\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.20139 \
        scb=0.00436827 scc=2.20651e-05 m=(1)
mp35 (n31 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.36777 \
        scb=0.00335337 scc=1.75985e-05 m=(1)
mp30 (\16\:mout \1\:SN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=6.506 scb=0.00275822 \
        scc=1.68594e-05 m=(1)
mp21 (\14\:CKNbb \5\:CKNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\21\:CKNb \4\:CKN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\19\:mout \3\:n20 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.97126 \
        scb=0.00301321 scc=1.70301e-05 m=(1)
mp40 (\4\:n35 \6\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp52 (n41 \10\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp55 (\4\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.3389 \
        scb=0.0172052 scc=0.000547772 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.7978 \
        scb=0.0191816 scc=0.000889993 m=(1)
ends RDFFNSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:43:25 2012 )
// Library name: gsclib045
// Cell name: RDFFNSRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFNSRQX1 CKN D ExtVDD Q RN RT SN VDD VSS
mp25 (n22 \3\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RN VSS) capacitor c=3.52019e-17
C2 (RT VSS) capacitor c=4.05474e-17
C3 (SN VSS) capacitor c=4.12623e-17
C4 (D VSS) capacitor c=4.53855e-17
C5 (VDD VSS) capacitor c=7.24518e-16
C6 (Q VSS) capacitor c=3.55556e-17
C7 (ExtVDD VSS) capacitor c=1.96812e-16
C8 (CKN VSS) capacitor c=3.86099e-17
C9 (CKNb VSS) capacitor c=4.72075e-17
C10 (mout VSS) capacitor c=5.3447e-17
C11 (n20 VSS) capacitor c=8.28078e-17
C12 (RNb VSS) capacitor c=3.91539e-17
C13 (CKNbb VSS) capacitor c=5.23837e-17
C14 (n35g VSS) capacitor c=1.7772e-17
C15 (qbint VSS) capacitor c=4.58346e-17
C16 (RTb VSS) capacitor c=5.17974e-17
C17 (n35 VSS) capacitor c=1.71683e-16
C18 (n41 VSS) capacitor c=8.47445e-17
C19 (n42 VSS) capacitor c=7.95221e-17
C20 (n40 VSS) capacitor c=8.46705e-17
C21 (net426 VSS) capacitor c=8.73516e-17
C22 (\7\:SN VSS) capacitor c=7.05736e-17
C23 (\7\:qbint VSS) capacitor c=3.87306e-17
C24 (\10\:qbint VSS) capacitor c=1.41626e-16
C25 (\4\:RNb VSS) capacitor c=3.13651e-16
C26 (\13\:CKNb VSS) capacitor c=5.88282e-17
C27 (\4\:RTb VSS) capacitor c=9.86719e-17
C28 (\6\:RT VSS) capacitor c=2.18204e-17
C29 (\4\:qbint VSS) capacitor c=5.35417e-17
C30 (\3\:n35g VSS) capacitor c=6.18567e-17
C31 (\5\:RT VSS) capacitor c=8.43946e-17
C32 (\5\:CKNbb VSS) capacitor c=1.1498e-16
C33 (\4\:RN VSS) capacitor c=3.24608e-17
C34 (\7\:RNb VSS) capacitor c=6.93875e-17
C35 (\3\:n20 VSS) capacitor c=4.64244e-17
C36 (\4\:CKN VSS) capacitor c=5.46674e-17
C37 (\1\:SN VSS) capacitor c=2.99249e-17
C38 (\5\:CKNb VSS) capacitor c=2.95711e-17
C39 (\4\:CKNbb VSS) capacitor c=8.62189e-17
C40 (\3\:CKNb VSS) capacitor c=1.65036e-16
C41 (\3\:D VSS) capacitor c=5.57301e-17
C42 (\8\:SN VSS) capacitor c=1.32033e-16
C43 (\6\:qbint VSS) capacitor c=4.18396e-17
C44 (\11\:qbint VSS) capacitor c=8.06262e-17
C45 (\3\:RNb VSS) capacitor c=6.80787e-17
C46 (\7\:CKNbb VSS) capacitor c=2.2248e-16
C47 (\8\:RT VSS) capacitor c=1.20611e-16
C48 (\2\:RT VSS) capacitor c=6.21686e-17
C49 (\5\:qbint VSS) capacitor c=3.87746e-17
C50 (\5\:n35g VSS) capacitor c=2.76477e-17
C51 (\2\:RTb VSS) capacitor c=4.66333e-17
C52 (\7\:CKNb VSS) capacitor c=3.24964e-17
C53 (\1\:RN VSS) capacitor c=3.57238e-17
C54 (\6\:n20 VSS) capacitor c=6.12355e-17
C55 (\6\:SN VSS) capacitor c=4.5982e-17
C56 (\1\:CKN VSS) capacitor c=2.8269e-17
C57 (\3\:mout VSS) capacitor c=4.58092e-17
C58 (\12\:CKNb VSS) capacitor c=4.97927e-17
C59 (\2\:CKNbb VSS) capacitor c=8.18998e-17
C60 (\1\:D VSS) capacitor c=6.60532e-17
C61 (\9\:qbint VSS) capacitor c=9.30948e-17
C62 (\14\:CKNb VSS) capacitor c=8.17956e-17
C63 (\3\:SN VSS) capacitor c=3.75209e-16
C64 (\9\:SN VSS) capacitor c=9.15062e-17
C65 (\7\:RT VSS) capacitor c=1.58399e-16
C66 (\11\:CKNb VSS) capacitor c=1.67373e-16
C67 (\3\:RTb VSS) capacitor c=8.2455e-17
C68 (\3\:RT VSS) capacitor c=5.87737e-17
C69 (\1\:RT VSS) capacitor c=5.2908e-17
C70 (\3\:qbint VSS) capacitor c=4.39848e-17
C71 (\2\:n35 VSS) capacitor c=2.5286e-16
C72 (\4\:n35g VSS) capacitor c=7.14464e-17
C73 (\6\:CKNbb VSS) capacitor c=5.38192e-17
C74 (\8\:CKNbb VSS) capacitor c=2.1752e-16
C75 (\3\:n35 VSS) capacitor c=1.16128e-16
C76 (\2\:RNb VSS) capacitor c=3.31472e-17
C77 (\9\:RNb VSS) capacitor c=1.06902e-17
C78 (\8\:RNb VSS) capacitor c=8.69954e-17
C79 (\7\:n20 VSS) capacitor c=5.31263e-17
C80 (\3\:RN VSS) capacitor c=5.06506e-17
C81 (\4\:n20 VSS) capacitor c=9.37937e-17
C82 (\3\:CKN VSS) capacitor c=2.31214e-17
C83 (\2\:SN VSS) capacitor c=4.18649e-17
C84 (\5\:SN VSS) capacitor c=2.03422e-17
C85 (\6\:CKNb VSS) capacitor c=2.29509e-17
C86 (\3\:CKNbb VSS) capacitor c=1.22005e-16
C87 (\2\:mout VSS) capacitor c=4.70325e-17
C88 (\4\:mout VSS) capacitor c=3.1078e-17
C89 (\5\:n20 VSS) capacitor c=7.64058e-17
C90 (\2\:n20 VSS) capacitor c=7.16223e-17
C91 (\4\:CKNb VSS) capacitor c=8.28854e-17
C92 (\10\:CKNb VSS) capacitor c=3.16279e-17
C93 (\2\:D VSS) capacitor c=5.41911e-17
C94 (\1\:VDD VSS) capacitor c=3.00664e-17
C95 (\14\:VDD VSS) capacitor c=4.73736e-17
C96 (\3\:Q VSS) capacitor c=5.32065e-17
C97 (\16\:VDD VSS) capacitor c=4.98516e-17
C98 (\3\:n41 VSS) capacitor c=9.8764e-17
C99 (\14\:n35 VSS) capacitor c=5.33136e-17
C100 (\15\:n35g VSS) capacitor c=5.69979e-17
C101 (\6\:RTb VSS) capacitor c=7.22455e-17
C102 (\1\:ExtVDD VSS) capacitor c=2.78517e-16
C103 (\9\:n35 VSS) capacitor c=6.17077e-17
C104 (\14\:qbint VSS) capacitor c=6.60601e-17
C105 (\6\:n35g VSS) capacitor c=9.10033e-17
C106 (\4\:n35 VSS) capacitor c=6.8905e-17
C107 (\5\:mout VSS) capacitor c=1.28058e-16
C108 (\13\:RNb VSS) capacitor c=2.66956e-17
C109 (\18\:VDD VSS) capacitor c=4.33789e-17
C110 (\20\:VDD VSS) capacitor c=5.19401e-17
C111 (\19\:mout VSS) capacitor c=3.67577e-17
C112 (\21\:CKNb VSS) capacitor c=4.71821e-17
C113 (\16\:mout VSS) capacitor c=4.35833e-17
C114 (\22\:VDD VSS) capacitor c=6.4473e-17
C115 (\24\:VDD VSS) capacitor c=4.93224e-17
C116 (\13\:CKNbb VSS) capacitor c=5.21053e-17
C117 (\8\:n20 VSS) capacitor c=4.10729e-17
C118 (\16\:n20 VSS) capacitor c=6.45534e-17
C119 (\26\:VDD VSS) capacitor c=3.6831e-17
C120 (\1\:Q VSS) capacitor c=3.74881e-17
C121 (\3\:n42 VSS) capacitor c=8.1219e-17
C122 (\3\:n40 VSS) capacitor c=8.16243e-17
C123 (\17\:n35 VSS) capacitor c=4.84026e-17
C124 (\11\:n35g VSS) capacitor c=2.63056e-17
C125 (\10\:RTb VSS) capacitor c=5.83059e-17
C126 (\12\:n35 VSS) capacitor c=6.36671e-17
C127 (\16\:qbint VSS) capacitor c=2.27954e-17
C128 (\9\:n35g VSS) capacitor c=8.03366e-17
C129 (\7\:n35 VSS) capacitor c=4.91029e-17
C130 (\11\:mout VSS) capacitor c=3.73001e-17
C131 (\10\:RNb VSS) capacitor c=4.13942e-17
C132 (\13\:mout VSS) capacitor c=3.83866e-17
C133 (\3\:net426 VSS) capacitor c=1.00475e-16
C134 (\17\:CKNb VSS) capacitor c=6.03112e-17
C135 (\9\:CKNbb VSS) capacitor c=3.47839e-17
C136 (\12\:n20 VSS) capacitor c=6.64112e-17
C137 (\14\:n20 VSS) capacitor c=5.88356e-17
C138 (\2\:CKNb VSS) capacitor c=7.11435e-17
C139 (\2\:CKN VSS) capacitor c=3.39734e-17
C140 (\2\:n35g VSS) capacitor c=3.34308e-17
C141 (ExtVDD VSS) capacitor c=3.93674e-17
C142 (\4\:RT VSS) capacitor c=7.44104e-17
C143 (\2\:qbint VSS) capacitor c=4.11428e-17
C144 (\8\:CKNb VSS) capacitor c=1.36991e-16
C145 (\9\:CKNb VSS) capacitor c=7.71046e-17
C146 (\4\:SN VSS) capacitor c=3.37826e-16
C147 (\5\:RNb VSS) capacitor c=5.20411e-16
C148 (\6\:RNb VSS) capacitor c=1.2037e-16
C149 (\15\:CKNb VSS) capacitor c=6.37884e-17
C150 (\16\:CKNb VSS) capacitor c=7.44131e-17
C151 (\8\:qbint VSS) capacitor c=1.06688e-16
C152 (\10\:n20 VSS) capacitor c=2.90055e-17
C153 (\11\:n20 VSS) capacitor c=6.97291e-17
C154 (\18\:n20 VSS) capacitor c=3.71921e-17
C155 (\12\:CKNbb VSS) capacitor c=7.75706e-17
C156 (\15\:CKNbb VSS) capacitor c=5.09389e-17
C157 (\10\:SN VSS) capacitor c=4.02713e-17
C158 (\11\:SN VSS) capacitor c=4.59033e-17
C159 (\5\:CKN VSS) capacitor c=5.83508e-18
C160 (\6\:CKN VSS) capacitor c=3.45977e-17
C161 (\19\:CKNb VSS) capacitor c=6.53987e-17
C162 (\20\:CKNb VSS) capacitor c=4.8018e-17
C163 (\5\:RN VSS) capacitor c=3.68898e-17
C164 (\19\:n20 VSS) capacitor c=8.13077e-17
C165 (\20\:n20 VSS) capacitor c=8.10135e-17
C166 (\12\:RNb VSS) capacitor c=5.48754e-17
C167 (\15\:RNb VSS) capacitor c=7.18462e-17
C168 (\16\:RNb VSS) capacitor c=8.34723e-17
C169 (\7\:mout VSS) capacitor c=1.56815e-16
C170 (\8\:mout VSS) capacitor c=5.30709e-17
C171 (\9\:mout VSS) capacitor c=1.06012e-16
C172 (\10\:mout VSS) capacitor c=8.55052e-17
C173 (\15\:mout VSS) capacitor c=6.20018e-17
C174 (\18\:mout VSS) capacitor c=7.40466e-17
C175 (\6\:n35 VSS) capacitor c=1.07161e-16
C176 (\16\:CKNbb VSS) capacitor c=3.8856e-17
C177 (\17\:CKNbb VSS) capacitor c=4.15834e-17
C178 (\8\:n35g VSS) capacitor c=3.19653e-17
C179 (\11\:n35 VSS) capacitor c=7.57391e-17
C180 (\12\:qbint VSS) capacitor c=8.82391e-17
C181 (\13\:qbint VSS) capacitor c=1.08749e-16
C182 (\13\:n35g VSS) capacitor c=9.96775e-17
C183 (\14\:n35g VSS) capacitor c=1.16145e-16
C184 (\5\:RTb VSS) capacitor c=4.69196e-17
C185 (\8\:RTb VSS) capacitor c=1.00589e-16
C186 (\9\:RTb VSS) capacitor c=9.21104e-17
C187 (\12\:SN VSS) capacitor c=8.28873e-17
C188 (\13\:SN VSS) capacitor c=8.06e-17
C189 (\23\:CKNb VSS) capacitor c=1.33411e-16
C190 (\24\:CKNb VSS) capacitor c=1.34217e-16
C191 (\18\:qbint VSS) capacitor c=1.9305e-17
C192 (\19\:qbint VSS) capacitor c=3.00636e-17
C193 (\9\:RT VSS) capacitor c=5.10157e-17
C194 (\10\:RT VSS) capacitor c=1.06172e-16
C195 (\11\:RT VSS) capacitor c=1.18357e-16
C196 (\16\:n35 VSS) capacitor c=5.0763e-17
C197 (\3\:VDD VSS) capacitor c=3.25445e-17
C198 (\4\:VDD VSS) capacitor c=2.67356e-17
C199 (\6\:VDD VSS) capacitor c=2.30045e-16
C200 (\7\:VDD VSS) capacitor c=1.92265e-16
C201 (\8\:VDD VSS) capacitor c=2.44466e-17
C202 (\10\:VDD VSS) capacitor c=2.59166e-17
C203 (\11\:VDD VSS) capacitor c=2.9555e-17
C204 (\12\:VDD VSS) capacitor c=3.47111e-17
C205 (\13\:VDD VSS) capacitor c=3.06196e-17
Rk21 (\5\:RN RN) resistor r=0.03815 c=0
Rk62 (RT \9\:RT) resistor r=0.06666 c=0
Rk63 (\9\:RT \10\:RT) resistor r=0.2241 c=0
Rk64 (\10\:RT \11\:RT) resistor r=0.6461 c=0
Rk12 (SN \10\:SN) resistor r=0.01187 c=0
Rk13 (\10\:SN \11\:SN) resistor r=0.3244 c=0
Rk59 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk2 (\4\:D D) resistor r=0.006855 c=0
Rk82 (\2\:VDD \3\:VDD) resistor r=0.3366 c=0
Rk83 (\3\:VDD \4\:VDD) resistor r=0.2178 c=0
Rk84 (\4\:VDD \6\:VDD) resistor r=0.06676 c=0
Rk85 (\6\:VDD \7\:VDD) resistor r=1.6934 c=0
Rk86 (\7\:VDD \8\:VDD) resistor r=0.08888 c=0
Rk87 (\8\:VDD \10\:VDD) resistor r=0.1312 c=0
Rk88 (\10\:VDD \11\:VDD) resistor r=0.08907 c=0
Rk90 (\12\:VDD VDD) resistor r=0.1955 c=0
Rk89 (\11\:VDD \12\:VDD) resistor r=0.08144 c=0
Rk91 (VDD \13\:VDD) resistor r=0.1464 c=0
Rk92 (\13\:VDD VDD) resistor r=0.08883 c=0
Rk93 (\3\:VDD \15\:VDD) resistor r=0.3564 c=0
Rk94 (\4\:VDD \17\:VDD) resistor r=0.2927 c=0
Rk95 (\7\:VDD \19\:VDD) resistor r=0.2015 c=0
Rk96 (\8\:VDD \21\:VDD) resistor r=0.359 c=0
Rk97 (\11\:VDD \23\:VDD) resistor r=0.4032 c=0
Rk98 (\12\:VDD \25\:VDD) resistor r=0.2069 c=0
Rk99 (\13\:VDD \27\:VDD) resistor r=0.3585 c=0
Rk68 (\2\:Q Q) resistor r=0.1703 c=0
Rk69 (Q \4\:Q) resistor r=0.2987 c=0
Rk46 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk44 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk47 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk48 (ExtVDD \6\:ExtVDD) resistor r=0.1056 c=0
Rk72 (\2\:VSS \3\:VSS) resistor r=0.03204 c=0
Rk73 (\3\:VSS \4\:VSS) resistor r=0.5131 c=0
Rk74 (\4\:VSS \5\:VSS) resistor r=0.5159 c=0
Rk76 (\6\:VSS VSS) resistor r=0.04935 c=0
Rk75 (\5\:VSS \6\:VSS) resistor r=0.3271 c=0
Rk78 (\7\:VSS VSS) resistor r=0.1213 c=0
Rk77 (VSS \7\:VSS) resistor r=0.8929 c=0
Rk79 (\3\:VSS \9\:VSS) resistor r=0.2485 c=0
Rk80 (\5\:VSS \11\:VSS) resistor r=0.2434 c=0
Rk81 (VSS \13\:VSS) resistor r=0.3081 c=0
Rk100 (\15\:VSS \17\:VSS) resistor r=0.3613 c=0
Rk101 (\17\:VSS \18\:VSS) resistor r=0.8431 c=0
Rk102 (\18\:VSS \19\:VSS) resistor r=0.06676 c=0
Rk104 (\20\:VSS VSS) resistor r=0.1211 c=0
Rk103 (\19\:VSS \20\:VSS) resistor r=0.2079 c=0
Rk105 (VSS \21\:VSS) resistor r=0.7291 c=0
Rk107 (\22\:VSS VSS) resistor r=0.1188 c=0
Rk106 (\21\:VSS \22\:VSS) resistor r=0.06428 c=0
Rk108 (VSS \23\:VSS) resistor r=0.03725 c=0
Rk109 (\23\:VSS \24\:VSS) resistor r=0.4236 c=0
Rk110 (\24\:VSS \25\:VSS) resistor r=0.06428 c=0
Rk111 (\19\:VSS \27\:VSS) resistor r=0.1891 c=0
Rk112 (\20\:VSS \29\:VSS) resistor r=0.1942 c=0
Rk113 (\21\:VSS \31\:VSS) resistor r=0.2359 c=0
Rk114 (\23\:VSS \33\:VSS) resistor r=0.2364 c=0
Rk115 (\24\:VSS \35\:VSS) resistor r=0.2282 c=0
Rk14 (CKN \5\:CKN) resistor r=0.002227 c=0
Rk17 (\5\:CKN \6\:CKN) resistor r=0.01545 c=0
Rk16 (\6\:CKN \7\:CKN) resistor r=0.00544 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6841 c=0
Rk18 (\18\:CKNb \19\:CKNb) resistor r=0.3405 c=0
Rk19 (\19\:CKNb \20\:CKNb) resistor r=0.1632 c=0
Rk20 (\19\:CKNb \22\:CKNb) resistor r=0.2066 c=0
Rk60 (\23\:CKNb \24\:CKNb) resistor r=0.8226 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.7619 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.3523 c=0
Rk29 (\8\:mout \9\:mout) resistor r=0.1709 c=0
Rk30 (\9\:mout \10\:mout) resistor r=0.3404 c=0
Rk31 (\7\:mout \12\:mout) resistor r=0.1231 c=0
Rk32 (\8\:mout \14\:mout) resistor r=0.09956 c=0
Rk33 (\9\:mout \15\:mout) resistor r=0.5241 c=0
Rk34 (\15\:mout \17\:mout) resistor r=0.04481 c=0
Rk35 (\10\:mout \18\:mout) resistor r=0.425 c=0
Rk36 (\15\:mout \20\:mout) resistor r=0.03462 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.2067 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2104 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.4456 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4887 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1577 c=0
Rk22 (\19\:n20 \20\:n20) resistor r=0.4615 c=0
Rk24 (\11\:RNb \12\:RNb) resistor r=0.3447 c=0
Rk25 (\12\:RNb \14\:RNb) resistor r=0.1482 c=0
Rk26 (\15\:RNb \16\:RNb) resistor r=0.3465 c=0
Rk8 (\10\:CKNbb \11\:CKNbb) resistor r=0.2129 c=0
Rk9 (\11\:CKNbb \12\:CKNbb) resistor r=0.01514 c=0
Rk10 (\11\:CKNbb \14\:CKNbb) resistor r=0.3382 c=0
Rk11 (\14\:CKNbb \15\:CKNbb) resistor r=0.2715 c=0
Rk39 (\16\:CKNbb \17\:CKNbb) resistor r=0.3681 c=0
Rk40 (\7\:n35g \8\:n35g) resistor r=0.2407 c=0
Rk41 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk52 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk53 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk54 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk49 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk50 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
