C16 (\3\:B VSS) capacitor c=2.74329e-17
C17 (\3\:C VSS) capacitor c=4.67995e-17
C18 (\1\:D VSS) capacitor c=4.2875e-17
C19 (\2\:A VSS) capacitor c=3.96036e-17
C20 (\2\:B VSS) capacitor c=4.62016e-17
C21 (\2\:C VSS) capacitor c=5.81068e-17
C22 (\2\:D VSS) capacitor c=5.0918e-17
C23 (\4\:Y VSS) capacitor c=8.37415e-17
C24 (\11\:net100 VSS) capacitor c=9.69258e-17
C25 (\13\:VDD VSS) capacitor c=1.14189e-17
C26 (\13\:net100 VSS) capacitor c=3.57016e-17
C27 (\15\:VDD VSS) capacitor c=3.85519e-18
C28 (\1\:VDD VSS) capacitor c=2.87144e-17
C29 (\2\:Y VSS) capacitor c=5.21386e-17
C30 (\9\:net100 VSS) capacitor c=4.98838e-17
C31 (\4\:D VSS) capacitor c=7.32489e-17
C32 (\4\:C VSS) capacitor c=6.71376e-17
C33 (\4\:A VSS) capacitor c=7.06478e-17
C34 (\7\:net100 VSS) capacitor c=6.90498e-17
C35 (\8\:net100 VSS) capacitor c=1.31705e-16
C36 (\1\:Y VSS) capacitor c=5.67217e-17
C37 (\3\:VDD VSS) capacitor c=8.35815e-17
C38 (\5\:VDD VSS) capacitor c=9.32498e-18
Rk9 (Y \1\:Y) resistor r=0.01984 c=0
Rk10 (\1\:Y \3\:Y) resistor r=0.2732 c=0
Rk11 (\1\:Y \5\:Y) resistor r=0.4181 c=0
Rk2 (C \4\:C) resistor r=0.225 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.05497 c=0
Rk14 (\3\:VDD \5\:VDD) resistor r=0.2433 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.1076 c=0
Rk17 (\7\:VDD VDD) resistor r=0.05472 c=0
Rk16 (\6\:VDD \7\:VDD) resistor r=0.09509 c=0
Rk21 (\5\:VDD \14\:VDD) resistor r=0.07381 c=0
Rk22 (\7\:VDD \16\:VDD) resistor r=0.07381 c=0
Rk1 (D \4\:D) resistor r=0.03459 c=0
Rk4 (A \4\:A) resistor r=0.0214 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.05497 c=0
Rk26 (\5\:VSS VSS) resistor r=0.3508 c=0
Rk25 (\3\:VSS \5\:VSS) resistor r=0.1653 c=0
Rk5 (\7\:net100 \8\:net100) resistor r=0.3403 c=0
Rk6 (\8\:net100 \10\:net100) resistor r=0.4764 c=0
Rk7 (\8\:net100 \12\:net100) resistor r=0.5618 c=0
Rk8 (\12\:net100 \14\:net100) resistor r=0.2741 c=0
Rl5 (\1\:B \2\:B) resistor r=162.23 c=0
Rl6 (\2\:B \3\:B) resistor r=29.5379 c=0
Rl3 (\1\:C \2\:C) resistor r=160.307 c=0
Rl4 (\2\:C \3\:C) resistor r=31.461 c=0
Rl2 (\2\:D \3\:D) resistor r=147.872 c=0
Rl1 (\1\:D \2\:D) resistor r=44.208 c=0
Rl7 (\1\:A \2\:A) resistor r=93.4057 c=0
Rl8 (\2\:A \3\:A) resistor r=91.4826 c=0
Rz2 (\3\:Y \2\:Y) resistor r=75 c=0
Rz6 (VDD \1\:VDD) resistor r=75 c=0
Rz3 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz4 (\3\:VDD \1\:VDD) resistor r=15 c=0
Rz5 (\6\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\10\:net100 \9\:net100) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry7 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\5\:VSS \1\:VSS) resistor r=7.75 c=0
Ry1 (\12\:net100 \11\:net100) resistor r=62 c=0
Ry2 (\14\:net100 \13\:net100) resistor r=62 c=0
Rx3 (\2\:B B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\7\:net100 net100) resistor r=45 c=0
mn3 (\9\:net100 \1\:D net132 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn2 (net132 \3\:C net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=8.7e-15 ps=5.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.145e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (net124 \3\:B net120 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.175e-14 ps=8.4e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=9.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn0 (net120 \3\:A \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.988e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.3e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn4 (\2\:Y net100 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.653e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.16827e-07 sb=3.95e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(2)
mp2 (\13\:net100 \1\:C \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=3.548e-14 ps=1.46e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.145e-06 sd=160n sca=13.6785 \
        scb=0.0116931 scc=0.000214399 m=(1)
mp1 (\11\:net100 \1\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=5.913e-14 ps=1.46e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=9.5e-07 sd=160n sca=12.115 \
        scb=0.00975563 scc=0.000203878 m=(1)
mp0 (\11\:net100 \1\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=5.913e-14 ps=1.16e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=6.3e-07 sd=160n sca=11.62 \
        scb=0.00944645 scc=0.000203609 m=(1)
mp4 (\4\:Y net100 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.622e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.29231e-07 sb=3.95e-07 sd=160n sca=21.3165 \
        scb=0.0178846 scc=0.00184501 m=(2)
ends AND4X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:11:41 2012 )
// Library name: gsclib045
// Cell name: AND4X4
// View name: extracted

simulator lang=spectre

subckt AND4X4 A B C D VDD VSS Y
mp3 (\20\:net100 \3\:D \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.62e-06 sd=160n sca=16.3241 \
        scb=0.0161972 scc=0.000342398 m=(1)
C1 (Y VSS) capacitor c=2.77963e-17
C2 (B VSS) capacitor c=6.40864e-17
C3 (C VSS) capacitor c=1.3634e-16
C4 (VDD VSS) capacitor c=1.07678e-16
C5 (D VSS) capacitor c=1.03085e-16
C6 (A VSS) capacitor c=7.36067e-17
C7 (net132 VSS) capacitor c=4.07302e-18
C8 (net100 VSS) capacitor c=3.5709e-16
C9 (net124 VSS) capacitor c=9.21374e-18
C10 (net120 VSS) capacitor c=6.17703e-18
C11 (\1\:A VSS) capacitor c=4.5907e-17
C12 (\1\:B VSS) capacitor c=6.11077e-17
C13 (\1\:C VSS) capacitor c=6.78791e-17
C14 (\3\:D VSS) capacitor c=5.13368e-17
C15 (\3\:A VSS) capacitor c=6.61759e-17
C16 (\4\:B VSS) capacitor c=4.31116e-17
C17 (\3\:C VSS) capacitor c=4.2511e-17
C18 (\1\:D VSS) capacitor c=3.40741e-17
C19 (\2\:A VSS) capacitor c=4.21027e-17
C20 (\3\:B VSS) capacitor c=5.28381e-17
C21 (\2\:C VSS) capacitor c=5.96786e-17
C22 (\2\:D VSS) capacitor c=4.77979e-17
C23 (\1\:VDD VSS) capacitor c=1.96941e-16
C24 (\22\:net100 VSS) capacitor c=4.61777e-17
C25 (\11\:VDD VSS) capacitor c=5.48626e-17
C26 (\20\:net100 VSS) capacitor c=8.3386e-17
C27 (\14\:VDD VSS) capacitor c=5.06884e-17
C28 (\2\:Y VSS) capacitor c=1.20384e-16
C29 (\16\:net100 VSS) capacitor c=7.69087e-17
C30 (\6\:B VSS) capacitor c=8.97087e-17
C31 (\4\:A VSS) capacitor c=3.50316e-17
C32 (\15\:net100 VSS) capacitor c=1.35554e-16
C33 (\19\:net100 VSS) capacitor c=7.96229e-17
C34 (\1\:Y VSS) capacitor c=3.437e-17
C35 (\6\:Y VSS) capacitor c=1.99718e-16
C36 (\10\:VDD VSS) capacitor c=2.04734e-17
C37 (\13\:VDD VSS) capacitor c=9.54187e-18
Rk14 (Y \1\:Y) resistor r=0.04645 c=0
Rk15 (\1\:Y \2\:Y) resistor r=0.1721 c=0
Rk17 (\1\:Y \6\:Y) resistor r=0.3252 c=0
Rk5 (B \6\:B) resistor r=0.027 c=0
Rk34 (\8\:VSS VSS) resistor r=0.2003 c=0
Rk33 (\1\:VSS \8\:VSS) resistor r=0.2656 c=0
Rk2 (C \4\:C) resistor r=0.003974 c=0
Rk24 (\1\:VDD \10\:VDD) resistor r=0.2208 c=0
Rk25 (\10\:VDD \12\:VDD) resistor r=0.2256 c=0
Rk28 (\13\:VDD VDD) resistor r=0.07478 c=0
Rk26 (\10\:VDD \13\:VDD) resistor r=0.2052 c=0
Rk27 (\13\:VDD \15\:VDD) resistor r=0.2785 c=0
Rk1 (D \4\:D) resistor r=0.003974 c=0
Rk6 (A \4\:A) resistor r=0.1169 c=0
Rk8 (net100 \15\:net100) resistor r=0.3508 c=0
Rk9 (\15\:net100 \17\:net100) resistor r=0.6395 c=0
Rk11 (\15\:net100 \19\:net100) resistor r=0.3601 c=0
Rk12 (\19\:net100 \21\:net100) resistor r=0.3953 c=0
Rk13 (\19\:net100 \23\:net100) resistor r=0.1272 c=0
Rl5 (\1\:B \2\:B) resistor r=141.187 c=0
Rl7 (\2\:B \4\:B) resistor r=48.8796 c=0
Rl6 (\2\:B \3\:B) resistor r=0.6051 c=0
Rl3 (\1\:C \2\:C) resistor r=144.923 c=0
Rl4 (\2\:C \3\:C) resistor r=29.5379 c=0
Rl2 (\2\:D \3\:D) resistor r=147.31 c=0
Rl1 (\1\:D \2\:D) resistor r=31.7349 c=0
Rl8 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl9 (\2\:A \3\:A) resistor r=112.26 c=0
Rz1 (\17\:net100 \16\:net100) resistor r=75 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry12 (\8\:VSS \3\:VSS) resistor r=12.4 c=0
Ry8 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\15\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry1 (\21\:net100 \20\:net100) resistor r=20.6667 c=0
Ry2 (\23\:net100 \22\:net100) resistor r=20.6667 c=0
Rx3 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
mn3 (\16\:net100 \1\:D net132 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.64e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn2 (net132 \3\:C net124 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.415e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn1 (net124 \4\:B net120 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.21e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn0 (net120 \3\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.12e-14 ps=8.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.045e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn4 (\2\:Y net100 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.582e-14 ad=4.355e-14 ps=8.725e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=8.4e-07 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
mp2 (\20\:net100 \1\:C \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.415e-06 sd=160n sca=13.0557 \
        scb=0.010793 scc=0.000234604 m=(1)
mp1 (\22\:net100 \1\:B \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.215e-14 ps=1.1e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.21e-06 sd=160n sca=11.9089 \
        scb=0.00972252 scc=0.000231915 m=(1)
mp0 (\22\:net100 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.215e-14 ps=1.14e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=9.8e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4 (\6\:Y net100 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=7.55e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
ends AND4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:12:19 2012 )
// Library name: gsclib045
// Cell name: AND4X6
// View name: extracted

simulator lang=spectre

subckt AND4X6 A B C D VDD VSS Y
mp0 (\16\:net116 A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1165e-13 ad=6.24e-14 ps=1.61e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98071e-06 sd=160n sca=18.0971 \
        scb=0.0181198 scc=0.000732406 m=(2)
C1 (B VSS) capacitor c=5.34448e-16
C2 (Y VSS) capacitor c=1.39221e-17
C3 (VDD VSS) capacitor c=1.56234e-16
C4 (D VSS) capacitor c=4.43249e-17
C5 (A VSS) capacitor c=6.55374e-16
C6 (11 VSS) capacitor c=8.18896e-18
C7 (net116 VSS) capacitor c=2.80761e-16
C8 (12 VSS) capacitor c=2.27984e-18
C9 (13 VSS) capacitor c=8.35121e-18
C10 (14 VSS) capacitor c=2.26439e-18
C11 (\6\:A VSS) capacitor c=8.01655e-17
C12 (\6\:B VSS) capacitor c=7.50467e-17
C13 (\7\:C VSS) capacitor c=5.33809e-17
C14 (\1\:D VSS) capacitor c=6.33252e-17
C15 (\5\:D VSS) capacitor c=1.76577e-17
C16 (\3\:C VSS) capacitor c=3.95852e-17
C17 (\3\:B VSS) capacitor c=6.5123e-17
C18 (\1\:A VSS) capacitor c=5.8059e-17
C19 (\2\:D VSS) capacitor c=2.7768e-17
C20 (\1\:C VSS) capacitor c=4.16098e-16
C21 (\1\:Y VSS) capacitor c=2.44438e-16
C22 (\1\:VDD VSS) capacitor c=4.00975e-16
C23 (\16\:net116 VSS) capacitor c=3.70001e-16
C24 (\19\:VDD VSS) capacitor c=2.81299e-17
C25 (\24\:net116 VSS) capacitor c=8.59949e-17
C26 (\3\:D VSS) capacitor c=1.17313e-16
C27 (\7\:D VSS) capacitor c=3.64368e-17
C28 (\14\:net116 VSS) capacitor c=7.72543e-17
C29 (\15\:net116 VSS) capacitor c=1.22407e-16
C30 (\4\:Y VSS) capacitor c=2.13665e-16
Rk15 (\1\:Y Y) resistor r=0.04656 c=0
Rk16 (Y \4\:Y) resistor r=0.1832 c=0
Rk3 (\1\:C C) resistor r=0.009678 c=0
Rk32 (\1\:VDD VDD) resistor r=0.08224 c=0
Rk36 (\1\:VDD \20\:VDD) resistor r=0.102 c=0
Rk1 (\7\:D D) resistor r=0.2106 c=0
Rk42 (\1\:VSS \7\:VSS) resistor r=0.3782 c=0
Rk44 (\8\:VSS VSS) resistor r=0.1248 c=0
Rk43 (\7\:VSS \8\:VSS) resistor r=0.4258 c=0
Rk47 (\8\:VSS \14\:VSS) resistor r=0.2027 c=0
Rk9 (\15\:net116 \16\:net116) resistor r=0.5321 c=0
Rk8 (\14\:net116 \15\:net116) resistor r=0.3077 c=0
Rk13 (\15\:net116 \25\:net116) resistor r=0.7326 c=0
Rl16 (B \6\:B) resistor r=126.098 c=0
Rl4 (B \3\:B) resistor r=110.713 c=0
Rl14 (\1\:C \7\:C) resistor r=45.3297 c=0
Rl6 (\1\:C \3\:C) resistor r=110.418 c=0
Rl8 (\2\:D \1\:D) resistor r=105.323 c=0
Rl11 (\2\:D \5\:D) resistor r=24.2328 c=0
Rl9 (\3\:D \2\:D) resistor r=87.3759 c=0
Rl18 (A \6\:A) resistor r=115.18 c=0
Rl1 (A \1\:A) resistor r=116.483 c=0
Rz11 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\25\:net116 \24\:net116) resistor r=75 c=0
Ry12 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=12.4 c=0
Ry16 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
Rx8 (\14\:net116 net116) resistor r=22.5 c=0
mn0_1__rcx (9 \1\:A \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.95e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \3\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.72e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_1__rcx (10 \3\:C 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=5.72e-14 ps=1.04e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\24\:net116 \5\:D 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.99e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\24\:net116 \1\:D 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.69e-14 ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.785e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (12 \7\:C 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.69e-14 ps=1.07e-06 pd=6.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.145e-06 sb=1.675e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (14 \6\:B 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.465e-06 sb=1.355e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.87e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\4\:Y net116 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.342e-14 ad=4.836e-14 ps=9.74e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57613e-06 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp1 (\16\:net116 B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96231e-06 sd=160n sca=15.113 \
        scb=0.013285 scc=0.000649598 m=(2)
mp2 (\16\:net116 \1\:C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.93853e-06 sd=160n sca=13.8524 \
        scb=0.01226 scc=0.000647526 m=(2)
mp3 (\16\:net116 \3\:D \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.92013e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\1\:Y net116 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=9.39e-14 ad=7.332e-14 ps=1.44e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.53511e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND4X6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:12:56 2012 )
// Library name: gsclib045
// Cell name: AND4X8
// View name: extracted

simulator lang=spectre

subckt AND4X8 A B C D VDD VSS Y
mp0_1__rcx (\29\:net116 A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.29e-14 ad=6.24e-14 ps=1.51e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96692e-06 sd=160n sca=24.3679 \
        scb=0.0278844 scc=0.00150868 m=(2)
C1 (B VSS) capacitor c=1.62076e-16
C2 (Y VSS) capacitor c=1.52101e-17
C3 (C VSS) capacitor c=1.04687e-16
C4 (VDD VSS) capacitor c=5.71251e-16
C5 (D VSS) capacitor c=2.88978e-17
C6 (A VSS) capacitor c=6.61617e-16
C7 (11 VSS) capacitor c=9.7715e-18
C8 (net116 VSS) capacitor c=4.78933e-16
C9 (12 VSS) capacitor c=1.35399e-18
C10 (13 VSS) capacitor c=8.8607e-18
C11 (14 VSS) capacitor c=2.0734e-18
C12 (\1\:C VSS) capacitor c=3.1173e-16
C13 (\1\:B VSS) capacitor c=3.99978e-16
C14 (\6\:A VSS) capacitor c=8.12265e-17
C15 (\6\:B VSS) capacitor c=6.843e-17
C16 (\6\:C VSS) capacitor c=5.58909e-17
C17 (\1\:D VSS) capacitor c=6.50461e-17
C18 (\5\:D VSS) capacitor c=1.7781e-17
C19 (\3\:C VSS) capacitor c=3.88191e-17
C20 (\3\:B VSS) capacitor c=6.30635e-17
C21 (\1\:A VSS) capacitor c=5.77698e-17
C22 (\2\:D VSS) capacitor c=2.67366e-17
C23 (\1\:Y VSS) capacitor c=3.40302e-16
C24 (\29\:net116 VSS) capacitor c=3.75822e-16
C25 (\18\:VDD VSS) capacitor c=2.83717e-17
C26 (\37\:net116 VSS) capacitor c=9.18218e-17
C27 (\3\:D VSS) capacitor c=1.15975e-16
C28 (\7\:D VSS) capacitor c=7.0879e-17
C29 (\28\:net116 VSS) capacitor c=1.33523e-16
C30 (\4\:Y VSS) capacitor c=2.14524e-16
C31 (\8\:VDD VSS) capacitor c=6.5253e-17
Rk5 (\1\:B B) resistor r=0.005636 c=0
Rk17 (\1\:Y Y) resistor r=0.05089 c=0
Rk18 (Y \4\:Y) resistor r=0.2039 c=0
Rk2 (C \1\:C) resistor r=0.03168 c=0
Rk37 (\8\:VDD \19\:VDD) resistor r=0.1024 c=0
Rk1 (\7\:D D) resistor r=0.145 c=0
Rk47 (\1\:VSS \7\:VSS) resistor r=0.411 c=0
Rk49 (\8\:VSS VSS) resistor r=0.05721 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.3934 c=0
Rk54 (\8\:VSS \17\:VSS) resistor r=0.2036 c=0
Rk10 (net116 \28\:net116) resistor r=0.2198 c=0
Rk11 (\28\:net116 \29\:net116) resistor r=0.5551 c=0
Rk15 (\28\:net116 \38\:net116) resistor r=0.7024 c=0
Rl15 (\1\:B \6\:B) resistor r=96.8456 c=0
Rl4 (\1\:B \3\:B) resistor r=110.713 c=0
Rl13 (\1\:C \6\:C) resistor r=45.3297 c=0
Rl6 (\1\:C \3\:C) resistor r=102.615 c=0
Rl7 (\2\:D \1\:D) resistor r=105.323 c=0
Rl10 (\2\:D \5\:D) resistor r=31.9251 c=0
Rl8 (\3\:D \2\:D) resistor r=79.6836 c=0
Rl17 (A \6\:A) resistor r=115.18 c=0
Rl1 (A \1\:A) resistor r=116.483 c=0
Rz8 (\8\:VDD VDD) resistor r=0.0778 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\38\:net116 \37\:net116) resistor r=75 c=0
Ry14 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (VSS \3\:VSS) resistor r=62 c=0
Ry17 (\1\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry18 (\7\:VSS \3\:VSS) resistor r=7.75 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0_1__rcx (9 \1\:A \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.95e-14 ps=8e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \3\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.72e-14 ps=6.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_1__rcx (10 \3\:C 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=5.72e-14 ps=1.05e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\37\:net116 \5\:D 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=4.16e-14 ps=1.05e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\37\:net116 \1\:D 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (12 \6\:C 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.145e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (14 \6\:B 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=7.15e-14 \
        ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.465e-06 sb=1.75e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.645e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\4\:Y net116 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.95e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63797e-06 sb=1.37e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mp1_1__rcx (\29\:net116 \1\:B \8\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.93538e-06 sd=160n \
        sca=16.6587 scb=0.0156 scc=0.000671901 m=(2)
mp2 (\29\:net116 \1\:C \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.89462e-06 sd=160n sca=14.3316 \
        scb=0.0125202 scc=0.000647698 m=(2)
mp3_1__rcx (\29\:net116 \3\:D \18\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.15e-07 sb=1.86308e-06 sd=160n \
        sca=13.679 scb=0.0122069 scc=0.000647515 m=(2)
mp4_1__rcx (\1\:Y net116 VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.977e-14 ad=6.993e-14 ps=1.31714e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.50899e-06 sb=1.37e-06 sd=160n \
        sca=27.9404 scb=0.0185207 scc=0.00295096 m=(7)
ends AND4X8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:13:34 2012 )
// Library name: gsclib045
// Cell name: AND4XL
// View name: extracted

simulator lang=spectre

subckt AND4XL A B C D VDD VSS Y
mp3 (\4\:net100 \3\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06e-06 sd=160n sca=18.9752 \
        scb=0.0206746 scc=0.000592578 m=(1)
C1 (B VSS) capacitor c=8.91507e-17
C2 (Y VSS) capacitor c=4.8176e-17
C3 (C VSS) capacitor c=9.30388e-17
C4 (VDD VSS) capacitor c=1.13366e-16
C5 (D VSS) capacitor c=6.51335e-17
C6 (A VSS) capacitor c=7.33314e-17
C7 (net100 VSS) capacitor c=5.65986e-17
C8 (\4\:A VSS) capacitor c=3.50496e-17
C9 (\1\:B VSS) capacitor c=5.73298e-17
C10 (\1\:C VSS) capacitor c=6.00358e-17
C11 (\3\:D VSS) capacitor c=4.34208e-17
C12 (\3\:net100 VSS) capacitor c=2.97641e-17
C13 (\3\:A VSS) capacitor c=6.65701e-17
C14 (\3\:B VSS) capacitor c=4.28262e-17
C15 (\3\:C VSS) capacitor c=6.38602e-17
C16 (\1\:D VSS) capacitor c=5.4177e-17
C17 (\2\:net100 VSS) capacitor c=4.84936e-17
C18 (\1\:A VSS) capacitor c=2.42766e-17
C19 (\2\:B VSS) capacitor c=6.02889e-17
C20 (\2\:C VSS) capacitor c=7.07138e-17
C21 (\2\:D VSS) capacitor c=5.98458e-17
C22 (\1\:Y VSS) capacitor c=5.8463e-17
C23 (\9\:VDD VSS) capacitor c=1.79849e-17
C24 (\6\:net100 VSS) capacitor c=1.13064e-16
C25 (\11\:VDD VSS) capacitor c=1.07066e-17
C26 (\4\:net100 VSS) capacitor c=5.23259e-17
C27 (\13\:VDD VSS) capacitor c=1.71833e-17
C28 (\1\:VDD VSS) capacitor c=3.96786e-17
C29 (\3\:Y VSS) capacitor c=3.53314e-17
C30 (\9\:net100 VSS) capacitor c=6.95286e-17
C31 (\2\:A VSS) capacitor c=3.77787e-17
C32 (\5\:D VSS) capacitor c=3.79253e-17
C33 (\4\:C VSS) capacitor c=5.39356e-17
C34 (\4\:B VSS) capacitor c=5.22398e-17
C35 (\5\:A VSS) capacitor c=4.97289e-17
C36 (\8\:net100 VSS) capacitor c=1.13162e-16
C37 (\11\:net100 VSS) capacitor c=4.3286e-17
C38 (\3\:VDD VSS) capacitor c=1.45424e-18
C39 (\5\:VDD VSS) capacitor c=9.99989e-19
C40 (\7\:VDD VSS) capacitor c=3.63352e-18
Rk5 (B \4\:B) resistor r=0.08971 c=0
Rk11 (\2\:Y Y) resistor r=0.4497 c=0
Rk12 (Y \4\:Y) resistor r=0.1253 c=0
Rk4 (C \4\:C) resistor r=0.08971 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.06749 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.1327 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1277 c=0
Rk16 (\5\:VDD \6\:VDD) resistor r=0.07251 c=0
Rk18 (\7\:VDD VDD) resistor r=0.03716 c=0
Rk17 (\6\:VDD \7\:VDD) resistor r=0.1126 c=0
Rk20 (\3\:VDD \10\:VDD) resistor r=0.07369 c=0
Rk21 (\5\:VDD \12\:VDD) resistor r=0.07369 c=0
Rk22 (\7\:VDD \14\:VDD) resistor r=0.2669 c=0
Rk1 (\4\:D \5\:D) resistor r=0.001403 c=0
Rk2 (\6\:D D) resistor r=0.001473 c=0
Rk3 (\5\:D \6\:D) resistor r=0.09276 c=0
Rk6 (A \5\:A) resistor r=0.1977 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.1001 c=0
Rk25 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk24 (\3\:VSS \4\:VSS) resistor r=0.2505 c=0
Rk26 (\3\:VSS \6\:VSS) resistor r=0.1981 c=0
Rk7 (\5\:net100 \7\:net100) resistor r=0.2737 c=0
Rk8 (\7\:net100 \8\:net100) resistor r=0.6003 c=0
Rk9 (\8\:net100 \10\:net100) resistor r=0.507 c=0
Rk10 (\8\:net100 \11\:net100) resistor r=0.1838 c=0
Rl5 (\1\:B \2\:B) resistor r=150.692 c=0
Rl6 (\2\:B \3\:B) resistor r=100.692 c=0
Rl3 (\1\:C \2\:C) resistor r=150.692 c=0
Rl4 (\2\:C \3\:C) resistor r=100.692 c=0
Rl2 (\2\:D \3\:D) resistor r=157.224 c=0
Rl1 (\1\:D \2\:D) resistor r=101.9 c=0
Rl9 (\2\:A \4\:A) resistor r=73.8796 c=0
Rl8 (\2\:A \3\:A) resistor r=193.694 c=0
Rl7 (\1\:A \2\:A) resistor r=6.3321 c=0
Rl10 (net100 \2\:net100) resistor r=215.648 c=0
Rl11 (\2\:net100 \3\:net100) resistor r=34.4104 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\9\:net100 \10\:net100) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry6 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry1 (\4\:net100 \5\:net100) resistor r=62 c=0
Ry2 (\6\:net100 \7\:net100) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\1\:A \5\:A) resistor r=45 c=0
Rx5 (\2\:net100 \11\:net100) resistor r=45 c=0
mn3 (\9\:net100 \1\:D net136 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (net136 \3\:C net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=8.7e-15 ps=5.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.6e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (net128 \3\:B net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.175e-14 ps=6.4e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=5.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (net124 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.538e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\3\:Y \3\:net100 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mp2 (\4\:net100 \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.55e-07 sd=160n sca=13.6507 \
        scb=0.0115074 scc=0.000198787 m=(1)
mp1 (\6\:net100 \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=4.515e-14 ps=1.45e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.6e-07 sd=160n sca=12.6747 \
        scb=0.00982871 scc=0.000188391 m=(1)
mp0 (\6\:net100 \4\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=4.515e-14 ps=1.45e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=4.05e-07 sd=160n sca=13.816 \
        scb=0.0118118 scc=0.000202165 m=(1)
mp4 (\1\:Y net100 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.4e-07 sd=160n sca=24.7768 \
        scb=0.0281397 scc=0.00159433 m=(1)
ends AND4XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:14:11 2012 )
// Library name: gsclib045
// Cell name: AO21X1
// View name: extracted

simulator lang=spectre

subckt AO21X1 A0 A1 B0 VDD VSS Y
mp0 (\3\:net96 \3\:A0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.01e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.79419e-07 sd=160n sca=25.6618 \
        scb=0.0302163 scc=0.00167813 m=(1)
C1 (B0 VSS) capacitor c=8.99867e-17
C2 (A1 VSS) capacitor c=4.86034e-17
C3 (A0 VSS) capacitor c=2.44705e-17
C4 (Y VSS) capacitor c=3.02409e-17
C5 (VDD VSS) capacitor c=8.4885e-17
C6 (net049 VSS) capacitor c=4.21563e-17
C7 (net96 VSS) capacitor c=6.30342e-17
C8 (\3\:B0 VSS) capacitor c=3.25176e-17
C9 (\1\:A1 VSS) capacitor c=4.00508e-17
C10 (\3\:A0 VSS) capacitor c=3.13979e-17
C11 (\3\:net049 VSS) capacitor c=3.77563e-17
C12 (\1\:B0 VSS) capacitor c=3.74918e-17
C13 (\3\:A1 VSS) capacitor c=4.57668e-17
C14 (\1\:A0 VSS) capacitor c=4.22744e-17
C15 (\2\:net049 VSS) capacitor c=4.1902e-17
C16 (\2\:B0 VSS) capacitor c=5.46164e-17
C17 (\2\:A1 VSS) capacitor c=5.31927e-17
C18 (\2\:A0 VSS) capacitor c=4.65025e-17
C19 (\1\:Y VSS) capacitor c=3.12474e-17
C20 (\6\:VDD VSS) capacitor c=2.63882e-17
C21 (\8\:net049 VSS) capacitor c=5.12407e-17
C22 (\8\:VDD VSS) capacitor c=4.31885e-17
C23 (\3\:net96 VSS) capacitor c=5.90208e-17
C24 (\1\:VDD VSS) capacitor c=2.30618e-17
C25 (\3\:Y VSS) capacitor c=6.91255e-17
C26 (\6\:net049 VSS) capacitor c=7.39509e-17
C27 (\4\:A0 VSS) capacitor c=4.2946e-17
C28 (\4\:A1 VSS) capacitor c=5.85715e-17
C29 (\4\:net049 VSS) capacitor c=2.22186e-17
C30 (\5\:net049 VSS) capacitor c=6.87592e-17
C31 (\3\:VDD VSS) capacitor c=6.51698e-18
C32 (\5\:VDD VSS) capacitor c=2.80181e-18
Rk4 (\4\:B0 B0) resistor r=0.00268 c=0
Rk2 (A1 \4\:A1) resistor r=0.1877 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.3308 c=0
Rk18 (\5\:VSS VSS) resistor r=0.05687 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.2914 c=0
Rk20 (\5\:VSS \8\:VSS) resistor r=0.2828 c=0
Rk1 (A0 \4\:A0) resistor r=0.1132 c=0
Rk8 (\2\:Y Y) resistor r=0.106 c=0
Rk9 (Y \4\:Y) resistor r=0.3914 c=0
Rk10 (\2\:VDD \3\:VDD) resistor r=0.107 c=0
Rk11 (\3\:VDD \4\:VDD) resistor r=0.2415 c=0
Rk13 (\5\:VDD VDD) resistor r=0.1192 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.07955 c=0
Rk14 (\3\:VDD \7\:VDD) resistor r=0.2445 c=0
Rk15 (\5\:VDD \9\:VDD) resistor r=0.3259 c=0
Rk5 (\4\:net049 \5\:net049) resistor r=0.01521 c=0
Rk6 (\5\:net049 \7\:net049) resistor r=0.3496 c=0
Rk7 (\5\:net049 \9\:net049) resistor r=0.3248 c=0
Rk3 (\2\:net96 \4\:net96) resistor r=0.3509 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=64.5604 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=98.4743 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=62.6944 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=95.3867 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=51.9707 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=111.538 c=0
Rl7 (net049 \2\:net049) resistor r=108.746 c=0
Rl8 (\2\:net049 \3\:net049) resistor r=24.2328 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz1 (\6\:net049 \7\:net049) resistor r=75 c=0
Ry8 (\3\:VSS VSS) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry3 (\8\:net049 \9\:net049) resistor r=62 c=0
Ry1 (net96 \2\:net96) resistor r=62 c=0
Ry2 (\3\:net96 \4\:net96) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:net049 \4\:net049) resistor r=45 c=0
mn0 (net104 \1\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.305e-14 ps=5.7e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn1 (\6\:net049 \3\:A1 net104 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=3.988e-14 ps=4.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.65e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\6\:net049 \1\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.528e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (\3\:Y \3\:net049 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.528e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92596e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp1 (net96 \1\:A1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.978e-14 ps=7.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.64419e-07 sd=160n sca=18.1415 \
        scb=0.0180564 scc=0.000904054 m=(1)
mp2 (\8\:net049 \3\:B0 net96 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=2.89e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.34419e-07 sd=160n sca=16.8124 \
        scb=0.0157246 scc=0.000885849 m=(1)
mp3 (\1\:Y net049 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.4e-07 sd=160n sca=21.7112 \
        scb=0.0229031 scc=0.00124467 m=(1)
ends AO21X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:14:49 2012 )
// Library name: gsclib045
// Cell name: AO21X2
// View name: extracted

simulator lang=spectre

subckt AO21X2 A0 A1 B0 VDD VSS Y
mp0 (\3\:net84 \1\:A0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.01e-14 ps=1.57e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=16.4235 \
        scb=0.0160509 scc=0.000530362 m=(1)
C1 (B0 VSS) capacitor c=5.40313e-17
C2 (A1 VSS) capacitor c=5.55863e-17
C3 (VDD VSS) capacitor c=1.17845e-16
C4 (A0 VSS) capacitor c=5.0597e-17
C5 (Y VSS) capacitor c=5.17199e-17
C6 (net104 VSS) capacitor c=3.48915e-18
C7 (net100 VSS) capacitor c=8.72953e-17
C8 (net84 VSS) capacitor c=4.06589e-17
C9 (\3\:B0 VSS) capacitor c=4.70129e-17
C10 (\1\:A1 VSS) capacitor c=6.46672e-17
C11 (\1\:A0 VSS) capacitor c=4.86109e-17
C12 (\1\:B0 VSS) capacitor c=3.21929e-17
C13 (\3\:A1 VSS) capacitor c=3.48821e-17
C14 (\4\:A0 VSS) capacitor c=3.63037e-17
C15 (\4\:net100 VSS) capacitor c=4.09349e-17
C16 (\2\:B0 VSS) capacitor c=5.2042e-17
C17 (\2\:A1 VSS) capacitor c=5.23795e-17
C18 (\3\:A0 VSS) capacitor c=1.26784e-17
C19 (\1\:VDD VSS) capacitor c=7.57529e-17
C20 (\1\:Y VSS) capacitor c=1.00812e-16
C21 (\11\:net100 VSS) capacitor c=7.48654e-17
C22 (\8\:VDD VSS) capacitor c=1.22659e-17
C23 (\3\:net84 VSS) capacitor c=3.84746e-17
C24 (\3\:VDD VSS) capacitor c=2.48676e-17
C25 (\3\:Y VSS) capacitor c=2.2182e-17
C26 (\8\:net100 VSS) capacitor c=5.81936e-17
C27 (\2\:A0 VSS) capacitor c=3.45489e-17
C28 (\3\:net100 VSS) capacitor c=5.55148e-17
C29 (\5\:A0 VSS) capacitor c=2.90221e-17
C30 (\4\:A1 VSS) capacitor c=4.36499e-17
C31 (\5\:B0 VSS) capacitor c=4.22761e-17
C32 (\10\:net100 VSS) capacitor c=9.89402e-17
Rk4 (\4\:B0 \5\:B0) resistor r=0.003877 c=0
Rk5 (\6\:B0 B0) resistor r=0.003963 c=0
Rk6 (\5\:B0 \6\:B0) resistor r=0.08164 c=0
Rk2 (\4\:A1 A1) resistor r=0.09547 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.03225 c=0
Rk20 (\3\:VSS \6\:VSS) resistor r=0.2619 c=0
Rk22 (\7\:VSS VSS) resistor r=0.1119 c=0
Rk21 (\6\:VSS \7\:VSS) resistor r=0.08717 c=0
Rk25 (\7\:VSS \13\:VSS) resistor r=0.2653 c=0
Rk13 (\1\:VDD \7\:VDD) resistor r=0.2698 c=0
Rk14 (\7\:VDD \9\:VDD) resistor r=0.07277 c=0
Rk16 (\10\:VDD VDD) resistor r=0.0996 c=0
Rk15 (\7\:VDD \10\:VDD) resistor r=0.1296 c=0
Rk1 (A0 \5\:A0) resistor r=0.1223 c=0
Rk9 (\2\:Y Y) resistor r=0.3867 c=0
Rk10 (Y \4\:Y) resistor r=0.1837 c=0
Rk7 (\9\:net100 \10\:net100) resistor r=0.2925 c=0
Rk8 (\10\:net100 \12\:net100) resistor r=0.4742 c=0
Rk3 (\2\:net84 \4\:net84) resistor r=0.2387 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=129.945 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=57.6923 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=161.538 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=26.3736 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.649 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=46.9565 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=8.9604 c=0
Rl9 (\3\:net100 net100) resistor r=159.312 c=0
Rl10 (\3\:net100 \4\:net100) resistor r=3.3229 c=0
Rz7 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz3 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz4 (\10\:VDD \3\:VDD) resistor r=25 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz1 (\9\:net100 \8\:net100) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry10 (\6\:VSS \1\:VSS) resistor r=12.4 c=0
Ry7 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry4 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry3 (\12\:net100 \11\:net100) resistor r=62 c=0
Ry1 (net84 \2\:net84) resistor r=62 c=0
Ry2 (\3\:net84 \4\:net84) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\10\:net100 \4\:net100) resistor r=45 c=0
mn0 (net104 \4\:A0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.087e-14 ps=5.7e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\8\:net100 \3\:A1 net104 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=4.205e-14 ps=4.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=9.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\8\:net100 \1\:B0 \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.205e-14 ps=9.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=5.9e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y \3\:net100 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.075e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.30385e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp1 (net84 \1\:A1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.44e-14 ps=1.57e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.45e-07 sd=160n sca=14.3559 \
        scb=0.0130561 scc=0.000502004 m=(1)
mp2 (\11\:net100 \3\:B0 net84 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.4e-07 sd=160n sca=13.9642 scb=0.012601 \
        scc=0.000501242 m=(1)
mp3 (\1\:Y net100 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=3.45e-07 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(2)
ends AO21X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:15:26 2012 )
// Library name: gsclib045
// Cell name: AO21X4
// View name: extracted

simulator lang=spectre

subckt AO21X4 A0 A1 B0 VDD VSS Y
mp0 (\3\:net88 \1\:A0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.3e-07 sd=160n sca=16.4723 \
        scb=0.0164029 scc=0.000368802 m=(1)
C1 (A0 VSS) capacitor c=6.81966e-17
C2 (Y VSS) capacitor c=2.67016e-17
C3 (VDD VSS) capacitor c=1.05713e-16
C4 (net100 VSS) capacitor c=3.57845e-16
C5 (net88 VSS) capacitor c=7.75574e-17
C6 (\1\:B0 VSS) capacitor c=4.90484e-17
C7 (\1\:A1 VSS) capacitor c=5.32067e-17
C8 (\1\:A0 VSS) capacitor c=5.42085e-17
C9 (\3\:B0 VSS) capacitor c=5.17915e-17
C10 (\3\:A1 VSS) capacitor c=6.07978e-17
C11 (\3\:A0 VSS) capacitor c=3.94809e-17
C12 (\2\:B0 VSS) capacitor c=4.05629e-17
C13 (\2\:A1 VSS) capacitor c=5.47134e-17
C14 (\2\:A0 VSS) capacitor c=4.46635e-17
C15 (\1\:VDD VSS) capacitor c=2.17237e-16
C16 (\20\:net100 VSS) capacitor c=5.0449e-17
C17 (\11\:VDD VSS) capacitor c=4.18588e-17
C18 (\3\:net88 VSS) capacitor c=5.06161e-17
C19 (\2\:Y VSS) capacitor c=1.24698e-16
C20 (\18\:net100 VSS) capacitor c=3.78686e-17
C21 (\4\:A0 VSS) capacitor c=1.88835e-17
C22 (\4\:A1 VSS) capacitor c=1.25893e-16
C23 (\4\:B0 VSS) capacitor c=1.39725e-16
C24 (\17\:net100 VSS) capacitor c=7.36995e-17
C25 (\1\:Y VSS) capacitor c=4.57762e-17
C26 (\6\:Y VSS) capacitor c=2.3375e-16
C27 (\10\:VDD VSS) capacitor c=2.32937e-17
Rk6 (\4\:B0 B0) resistor r=0.003683 c=0
Rk4 (\4\:A1 A1) resistor r=0.003683 c=0
Rk28 (\7\:VSS VSS) resistor r=0.07475 c=0
Rk27 (\1\:VSS \7\:VSS) resistor r=0.2979 c=0
Rk31 (\7\:VSS \13\:VSS) resistor r=0.1734 c=0
Rk3 (\4\:A0 A0) resistor r=0.00899 c=0
Rk11 (Y \1\:Y) resistor r=0.1369 c=0
Rk12 (\1\:Y \2\:Y) resistor r=0.2642 c=0
Rk14 (\1\:Y \6\:Y) resistor r=0.194 c=0
Rk23 (\10\:VDD VDD) resistor r=0.1775 c=0
Rk21 (\1\:VDD \10\:VDD) resistor r=0.273 c=0
Rk22 (\10\:VDD \12\:VDD) resistor r=0.19 c=0
Rk8 (net100 \17\:net100) resistor r=0.1486 c=0
Rk9 (\17\:net100 \19\:net100) resistor r=0.2864 c=0
Rk10 (\17\:net100 \21\:net100) resistor r=0.3745 c=0
Rk5 (\2\:net88 \4\:net88) resistor r=0.4345 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=72.2449 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=120.685 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=76.9231 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=126.099 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=149.175 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=45.3288 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\19\:net100 \18\:net100) resistor r=75 c=0
Ry9 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\21\:net100 \20\:net100) resistor r=62 c=0
Ry1 (net88 \2\:net88) resistor r=31 c=0
Ry2 (\3\:net88 \4\:net88) resistor r=31 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
mn0 (net104 \3\:A0 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.73e-14 ps=8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\18\:net100 \3\:A1 net104 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=5.07e-14 ps=7.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=1.2e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\18\:net100 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.07e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=9.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\2\:Y net100 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp1 (net88 \1\:A1 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.25e-07 sd=160n sca=13.2039 \
        scb=0.0109987 scc=0.000261009 m=(1)
mp2 (\20\:net100 \1\:B0 net88 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.68e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.2e-07 sd=160n sca=12.0571 \
        scb=0.00992821 scc=0.00025832 m=(1)
mp3 (\6\:Y net100 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=7.55e-07 sd=160n sca=14.0824 \
        scb=0.0125149 scc=0.000698926 m=(4)
ends AO21X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:16:03 2012 )
// Library name: gsclib045
// Cell name: AO21XL
// View name: extracted

simulator lang=spectre

subckt AO21XL A0 A1 B0 VDD VSS Y
mp0 (n2 \4\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.6e-07 sd=160n sca=20.0513 \
        scb=0.0219943 scc=0.000769518 m=(1)
C1 (B0 VSS) capacitor c=5.90369e-17
C2 (A1 VSS) capacitor c=6.83093e-17
C3 (VDD VSS) capacitor c=1.23887e-16
C4 (A0 VSS) capacitor c=8.59138e-17
C5 (Y VSS) capacitor c=3.62496e-17
C6 (n0 VSS) capacitor c=3.28738e-17
C7 (n2 VSS) capacitor c=5.71687e-17
C8 (\3\:B0 VSS) capacitor c=4.71406e-17
C9 (\1\:A1 VSS) capacitor c=6.62731e-17
C10 (\4\:A0 VSS) capacitor c=4.69037e-17
C11 (\3\:n0 VSS) capacitor c=2.50738e-17
C12 (\1\:B0 VSS) capacitor c=3.40479e-17
C13 (\3\:A1 VSS) capacitor c=4.39099e-17
C14 (\1\:A0 VSS) capacitor c=6.41018e-17
C15 (\2\:n0 VSS) capacitor c=3.83793e-17
C16 (\2\:B0 VSS) capacitor c=5.79195e-17
C17 (\2\:A1 VSS) capacitor c=8.01856e-17
C18 (\3\:A0 VSS) capacitor c=1.67274e-17
C19 (\1\:Y VSS) capacitor c=3.54865e-17
C20 (\1\:VDD VSS) capacitor c=3.20341e-17
C21 (\4\:n0 VSS) capacitor c=6.87371e-17
C22 (\3\:n2 VSS) capacitor c=6.48843e-17
C23 (\6\:VDD VSS) capacitor c=2.81809e-17
C24 (\3\:Y VSS) capacitor c=2.58542e-17
C25 (\7\:n0 VSS) capacitor c=5.4863e-17
C26 (\2\:A0 VSS) capacitor c=5.33424e-17
C27 (\4\:A1 VSS) capacitor c=4.12602e-17
C28 (\4\:B0 VSS) capacitor c=6.33679e-17
C29 (\9\:n0 VSS) capacitor c=1.09484e-16
C30 (\4\:VDD VSS) capacitor c=2.2323e-17
C31 (\5\:VDD VSS) capacitor c=1.33212e-17
Rk4 (B0 \4\:B0) resistor r=0.166 c=0
Rk2 (\4\:A1 A1) resistor r=0.1905 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.1374 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.2125 c=0
Rk17 (\5\:VSS VSS) resistor r=0.07212 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.07738 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2674 c=0
Rk19 (\5\:VSS \9\:VSS) resistor r=0.2716 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.4115 c=0
Rk12 (\5\:VDD VDD) resistor r=0.1247 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.175 c=0
Rk13 (\5\:VDD \7\:VDD) resistor r=0.1724 c=0
Rk1 (\5\:A0 A0) resistor r=0.003674 c=0
Rk8 (\2\:Y Y) resistor r=0.2372 c=0
Rk9 (Y \4\:Y) resistor r=0.1196 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.4613 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.2556 c=0
Rk7 (\6\:n0 \9\:n0) resistor r=0.03268 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.307 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=181.446 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=84.1579 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=218.464 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=37.6944 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=138.143 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.286 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=29.2356 c=0
Rl8 (n0 \2\:n0) resistor r=145.708 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=26.1559 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry1 (n2 \2\:n2) resistor r=62 c=0
Ry2 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:n0 \9\:n0) resistor r=45 c=0
mn0 (n1 \1\:A0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\7\:n0 \3\:A1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\7\:n0 \1\:B0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.698e-14 ps=6.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=3.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\3\:Y \3\:n0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.6e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp1 (\3\:n2 \1\:A1 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.55e-07 sd=160n sca=13.262 \
        scb=0.0108178 scc=0.00011707 m=(1)
mp2 (\4\:n0 \3\:B0 \3\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.5e-07 sd=160n sca=11.9601 \
        scb=0.00852872 scc=9.89728e-05 m=(1)
mp3 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=54.2014 scb=0.040719 \
        scc=0.00636357 m=(1)
ends AO21XL
// End of subcircuit definition.

// Generated for: spectre (May  8 14:59:52 2012 )
// Library name: gsclib045
// Cell name: AO22X1
// View name: extracted

simulator lang=spectre

subckt AO22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:n3 \3\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=24.7768 \
        scb=0.0281397 scc=0.00159433 m=(1)
C1 (A0 VSS) capacitor c=4.55445e-17
C2 (B0 VSS) capacitor c=4.7681e-17
C3 (B1 VSS) capacitor c=2.623e-17
C4 (VDD VSS) capacitor c=1.17128e-16
C5 (A1 VSS) capacitor c=2.94397e-17
C6 (n0 VSS) capacitor c=3.86517e-17
C7 (n2 VSS) capacitor c=6.05147e-18
C8 (n3 VSS) capacitor c=6.32654e-17
C9 (\4\:B0 VSS) capacitor c=5.11424e-17
C10 (\1\:B1 VSS) capacitor c=5.56833e-17
C11 (\1\:A1 VSS) capacitor c=5.41263e-17
C12 (\3\:A0 VSS) capacitor c=5.37643e-17
C13 (\3\:n0 VSS) capacitor c=4.56462e-17
C14 (\3\:B0 VSS) capacitor c=2.32873e-17
C15 (\3\:B1 VSS) capacitor c=3.29301e-17
C16 (\3\:A1 VSS) capacitor c=6.60005e-17
C17 (\1\:A0 VSS) capacitor c=4.19503e-17
C18 (\2\:n0 VSS) capacitor c=2.92401e-17
C19 (\1\:B0 VSS) capacitor c=1.9111e-17
C20 (\2\:B1 VSS) capacitor c=5.08974e-17
C21 (\2\:A1 VSS) capacitor c=5.70204e-17
C22 (\2\:A0 VSS) capacitor c=5.06711e-17
C23 (\3\:Y VSS) capacitor c=8.76838e-17
C24 (\1\:VDD VSS) capacitor c=9.12816e-17
C25 (\8\:n0 VSS) capacitor c=4.18972e-17
C26 (\3\:n3 VSS) capacitor c=6.95323e-17
C27 (\7\:VDD VSS) capacitor c=1.12661e-17
C28 (\5\:n3 VSS) capacitor c=3.622e-17
C29 (\3\:VDD VSS) capacitor c=4.33507e-17
C30 (\1\:Y VSS) capacitor c=6.62288e-17
C31 (\6\:n0 VSS) capacitor c=8.38476e-17
C32 (\2\:B0 VSS) capacitor c=3.3016e-17
C33 (\4\:A0 VSS) capacitor c=5.45822e-17
C34 (\4\:A1 VSS) capacitor c=3.7621e-17
C35 (\4\:B1 VSS) capacitor c=6.51324e-17
C36 (\5\:B0 VSS) capacitor c=6.31746e-17
C37 (\4\:n0 VSS) capacitor c=4.86233e-17
C38 (\5\:n0 VSS) capacitor c=1.1055e-16
C39 (\5\:VDD VSS) capacitor c=1.71965e-17
Rk1 (\4\:A0 A0) resistor r=0.2486 c=0
Rk6 (B0 \5\:B0) resistor r=0.1099 c=0
Rk3 (B1 \4\:B1) resistor r=0.02602 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.365 c=0
Rk19 (\5\:VSS VSS) resistor r=0.0446 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.3551 c=0
Rk21 (\5\:VSS \8\:VSS) resistor r=0.2782 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.3732 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.3326 c=0
Rk15 (\6\:VDD VDD) resistor r=0.0498 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.06737 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.07311 c=0
Rk2 (A1 \4\:A1) resistor r=0.02681 c=0
Rk10 (\2\:Y Y) resistor r=0.5751 c=0
Rk11 (Y \4\:Y) resistor r=0.004834 c=0
Rk7 (\4\:n0 \5\:n0) resistor r=0.2796 c=0
Rk8 (\5\:n0 \7\:n0) resistor r=0.49 c=0
Rk9 (\5\:n0 \9\:n0) resistor r=0.1947 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3951 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.2726 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=161.333 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=55.7464 c=0
Rl9 (\2\:B0 \4\:B0) resistor r=171.957 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=45.0334 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=5.0163 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=156.461 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=44.9225 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=91.5405 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=106.925 c=0
Rl10 (n0 \2\:n0) resistor r=35.7713 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=133.848 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry9 (\3\:VSS VSS) resistor r=62 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (n1 \1\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\6\:n0 \3\:A1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.55e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\6\:n0 \3\:B1 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.5e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=2.32e-14 ps=1.24e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.45e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=3.64e-14 ps=1.24e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.53077e-07 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp1 (\3\:n3 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=14.9462 \
        scb=0.0138238 scc=0.000237852 m=(1)
mp3 (\8\:n0 \1\:B1 \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.4379 \
        scb=0.00997048 scc=0.000189166 m=(1)
mp2 (\8\:n0 \4\:B0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=11.9066 \
        scb=0.00936839 scc=0.000188025 m=(1)
mp4 (\3\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2631 \
        scb=0.0157178 scc=0.000443168 m=(1)
ends AO22X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:17:17 2012 )
// Library name: gsclib045
// Cell name: AO22X2
// View name: extracted

simulator lang=spectre

subckt AO22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net111 \4\:A0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.21e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9e-07 sd=160n sca=24.7768 scb=0.0281397 \
        scc=0.00159433 m=(1)
C1 (A0 VSS) capacitor c=8.89283e-17
C2 (B0 VSS) capacitor c=3.94199e-17
C3 (B1 VSS) capacitor c=1.24177e-16
C4 (VDD VSS) capacitor c=1.5083e-16
C5 (A1 VSS) capacitor c=4.84702e-17
C6 (Y VSS) capacitor c=5.16415e-17
C7 (net128 VSS) capacitor c=8.61687e-17
C8 (net132 VSS) capacitor c=6.0962e-18
C9 (net111 VSS) capacitor c=6.54348e-17
C10 (\4\:B0 VSS) capacitor c=3.1041e-17
C11 (\3\:B1 VSS) capacitor c=4.82188e-17
C12 (\1\:A1 VSS) capacitor c=4.6414e-17
C13 (\4\:A0 VSS) capacitor c=3.29479e-17
C14 (\3\:B0 VSS) capacitor c=4.82953e-17
C15 (\1\:B1 VSS) capacitor c=2.83383e-17
C16 (\3\:A1 VSS) capacitor c=6.25384e-17
C17 (\1\:A0 VSS) capacitor c=7.22872e-17
C18 (\4\:net128 VSS) capacitor c=3.16304e-17
C19 (\1\:B0 VSS) capacitor c=1.82791e-17
C20 (\2\:B1 VSS) capacitor c=4.60489e-17
C21 (\2\:A1 VSS) capacitor c=6.52018e-17
C22 (\3\:A0 VSS) capacitor c=1.35421e-17
C23 (\1\:VDD VSS) capacitor c=8.80928e-17
C24 (\3\:Y VSS) capacitor c=5.95264e-17
C25 (\12\:net128 VSS) capacitor c=9.76738e-17
C26 (\3\:net111 VSS) capacitor c=6.96767e-17
C27 (\10\:VDD VSS) capacitor c=1.20268e-17
C28 (\5\:net111 VSS) capacitor c=4.29048e-17
C29 (\4\:VDD VSS) capacitor c=3.28863e-17
C30 (\1\:Y VSS) capacitor c=5.01546e-17
C31 (\10\:net128 VSS) capacitor c=3.61222e-17
C32 (\2\:A0 VSS) capacitor c=4.62756e-17
C33 (\2\:B0 VSS) capacitor c=2.6982e-17
C34 (\3\:net128 VSS) capacitor c=5.19111e-17
C35 (\4\:A1 VSS) capacitor c=5.33933e-17
C36 (\5\:B0 VSS) capacitor c=7.77567e-17
C37 (\8\:net128 VSS) capacitor c=7.05995e-17
C38 (\9\:net128 VSS) capacitor c=1.00535e-16
C39 (\6\:VDD VSS) capacitor c=1.71611e-17
Rk1 (\5\:A0 A0) resistor r=0.003674 c=0
Rk6 (\5\:B0 B0) resistor r=0.005849 c=0
Rk3 (\4\:B1 B1) resistor r=0.02017 c=0
Rk20 (\1\:VSS \5\:VSS) resistor r=0.1925 c=0
Rk22 (\6\:VSS VSS) resistor r=0.07963 c=0
Rk21 (\5\:VSS \6\:VSS) resistor r=0.3201 c=0
Rk24 (\6\:VSS \10\:VSS) resistor r=0.2782 c=0
Rk13 (\1\:VDD \5\:VDD) resistor r=0.07988 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.3827 c=0
Rk16 (\7\:VDD VDD) resistor r=0.0498 c=0
Rk15 (\6\:VDD \7\:VDD) resistor r=0.06737 c=0
Rk18 (\6\:VDD \11\:VDD) resistor r=0.07311 c=0
Rk2 (\4\:A1 A1) resistor r=0.1211 c=0
Rk10 (\2\:Y Y) resistor r=0.373 c=0
Rk11 (Y \4\:Y) resistor r=0.1488 c=0
Rk7 (\8\:net128 \9\:net128) resistor r=0.3614 c=0
Rk8 (\9\:net128 \11\:net128) resistor r=0.2109 c=0
Rk9 (\9\:net128 \13\:net128) resistor r=0.4766 c=0
Rk4 (\2\:net111 \4\:net111) resistor r=0.4223 c=0
Rk5 (\4\:net111 \6\:net111) resistor r=0.3262 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=24.4619 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=224.51 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=6.4284 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=37.3411 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=179.649 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=5.6742 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=164.56 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=38.4615 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=81.9251 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.54 c=0
Rl12 (\3\:net128 net128) resistor r=131.714 c=0
Rl13 (\3\:net128 \4\:net128) resistor r=4.9601 c=0
Rz7 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\5\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz4 (\7\:VDD \4\:VDD) resistor r=37.5 c=0
Rz2 (\2\:Y \1\:Y) resistor r=75 c=0
Rz1 (\11\:net128 \10\:net128) resistor r=75 c=0
Ry8 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry4 (\13\:net128 \12\:net128) resistor r=62 c=0
Ry1 (net111 \2\:net111) resistor r=62 c=0
Ry2 (\3\:net111 \4\:net111) resistor r=62 c=0
Ry3 (\5\:net111 \6\:net111) resistor r=62 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\8\:net128 \4\:net128) resistor r=45 c=0
mn0 (net124 \1\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\10\:net128 \3\:A1 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.625e-14 ps=4.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.265e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\10\:net128 \1\:B1 net132 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=3.625e-14 ps=6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=9.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (net132 \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.248e-14 ps=1.28e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=7.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:net128 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.11635e-07 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp1 (\3\:net111 \1\:A1 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.21e-14 ad=4.192e-14 ps=1.45e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.35e-07 sd=160n sca=13.7572 \
        scb=0.0118002 scc=0.000202164 m=(1)
mp3 (\12\:net128 \3\:B1 \3\:net111 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.192e-14 ad=4.515e-14 ps=8.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=3.95e-07 sd=160n sca=11.856 \
        scb=0.00944487 scc=0.000188136 m=(1)
mp2 (\12\:net128 \4\:B0 net111 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.4e-07 sd=160n sca=11.3991 scb=0.00920061 \
        scc=0.000187981 m=(1)
mp4 (\3\:Y net128 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=3.45e-07 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(2)
ends AO22X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:17:54 2012 )
// Library name: gsclib045
// Cell name: AO22X4
// View name: extracted

simulator lang=spectre

subckt AO22X4 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:n3 \1\:A0 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=18.7619 \
        scb=0.0191068 scc=0.000809457 m=(1)
C1 (A0 VSS) capacitor c=8.9979e-17
C2 (B0 VSS) capacitor c=6.45214e-17
C3 (B1 VSS) capacitor c=1.50964e-16
C4 (VDD VSS) capacitor c=9.36508e-17
C5 (Y VSS) capacitor c=4.25723e-17
C6 (n1 VSS) capacitor c=1.95858e-18
C7 (n0 VSS) capacitor c=3.25496e-16
C8 (n2 VSS) capacitor c=6.90179e-18
C9 (n3 VSS) capacitor c=5.23871e-17
C10 (\4\:B0 VSS) capacitor c=4.8734e-17
C11 (\1\:B1 VSS) capacitor c=5.9607e-17
C12 (\1\:A1 VSS) capacitor c=5.00573e-17
C13 (\1\:A0 VSS) capacitor c=5.11403e-17
C14 (\3\:B0 VSS) capacitor c=4.61912e-17
C15 (\4\:B1 VSS) capacitor c=3.61422e-17
C16 (\3\:A1 VSS) capacitor c=5.3625e-17
C17 (\3\:A0 VSS) capacitor c=2.72845e-17
C18 (\1\:B0 VSS) capacitor c=1.92796e-17
C19 (\3\:B1 VSS) capacitor c=4.82646e-17
C20 (\2\:A1 VSS) capacitor c=4.51072e-17
C21 (\2\:A0 VSS) capacitor c=3.52097e-17
C22 (\1\:VDD VSS) capacitor c=1.42096e-16
C23 (\1\:Y VSS) capacitor c=1.77568e-16
C24 (\19\:n0 VSS) capacitor c=7.23237e-17
C25 (\3\:n3 VSS) capacitor c=8.48215e-17
C26 (\12\:VDD VSS) capacitor c=4.79458e-17
C27 (\5\:n3 VSS) capacitor c=5.16793e-17
C28 (\3\:VDD VSS) capacitor c=4.53992e-17
C29 (\4\:Y VSS) capacitor c=1.13054e-16
C30 (\17\:n0 VSS) capacitor c=5.72332e-17
C31 (\2\:B0 VSS) capacitor c=2.65999e-17
C32 (\4\:A1 VSS) capacitor c=1.21398e-16
C33 (\5\:B0 VSS) capacitor c=3.7786e-17
C34 (\16\:n0 VSS) capacitor c=1.07309e-16
C35 (\11\:VDD VSS) capacitor c=7.11304e-18
Rk1 (A0 \4\:A0) resistor r=0.002995 c=0
Rk6 (\5\:B0 B0) resistor r=0.09861 c=0
Rk3 (\5\:B1 B1) resistor r=0.002995 c=0
Rk26 (\5\:VSS VSS) resistor r=0.07474 c=0
Rk25 (\1\:VSS \5\:VSS) resistor r=0.4264 c=0
Rk29 (\5\:VSS \10\:VSS) resistor r=0.2196 c=0
Rk20 (\1\:VDD \10\:VDD) resistor r=0.3231 c=0
Rk23 (\11\:VDD VDD) resistor r=0.1775 c=0
Rk21 (\10\:VDD \11\:VDD) resistor r=0.07248 c=0
Rk22 (\11\:VDD \13\:VDD) resistor r=0.2363 c=0
Rk2 (\4\:A1 A1) resistor r=0.003681 c=0
Rk12 (\1\:Y Y) resistor r=0.1925 c=0
Rk13 (Y \4\:Y) resistor r=0.1889 c=0
Rk8 (n0 \16\:n0) resistor r=0.3828 c=0
Rk9 (\16\:n0 \18\:n0) resistor r=0.3614 c=0
Rk10 (\16\:n0 \20\:n0) resistor r=0.3493 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3523 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.4372 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=114.56 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.098 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=59.3295 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=105.483 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=5.915 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=130.483 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=34.3295 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.5166 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=48.7687 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=98.7687 c=0
Rz8 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz5 (\10\:VDD \3\:VDD) resistor r=12.5 c=0
Rz1 (\18\:n0 \17\:n0) resistor r=75 c=0
Ry10 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry4 (\20\:n0 \19\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=31 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=31 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \5\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (n1 \3\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.65e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (\17\:n0 \3\:A1 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.445e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (\17\:n0 \4\:B1 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.24e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.29e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.03e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\4\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=8e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(4)
mp1 (\3\:n3 \1\:A1 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=15.4935 \
        scb=0.0137026 scc=0.000701664 m=(1)
mp3 (\19\:n0 \1\:B1 \3\:n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=14.3467 \
        scb=0.0126321 scc=0.000698974 m=(1)
mp2 (\19\:n0 \4\:B0 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.8244 \
        scb=0.0124477 scc=0.000698915 m=(1)
mp4 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.076e-14 ad=6.24e-14 ps=1.2575e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.55e-07 sd=160n sca=26.0272 scb=0.019144 \
        scc=0.00277829 m=(4)
ends AO22X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:18:33 2012 )
// Library name: gsclib045
// Cell name: AO22XL
// View name: extracted

simulator lang=spectre

subckt AO22XL A0 A1 B0 B1 VDD VSS Y
mp0 (n3 \1\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
C1 (A0 VSS) capacitor c=7.70736e-17
C2 (B1 VSS) capacitor c=6.61461e-17
C3 (VDD VSS) capacitor c=1.28404e-16
C4 (A1 VSS) capacitor c=1.10091e-16
C5 (Y VSS) capacitor c=3.73394e-17
C6 (n1 VSS) capacitor c=1.69272e-18
C7 (n0 VSS) capacitor c=4.62998e-17
C8 (n2 VSS) capacitor c=2.49646e-18
C9 (n3 VSS) capacitor c=4.77465e-17
C10 (\4\:B0 VSS) capacitor c=4.49779e-17
C11 (\3\:B1 VSS) capacitor c=6.38286e-17
C12 (\1\:A1 VSS) capacitor c=6.94928e-17
C13 (\1\:A0 VSS) capacitor c=5.5864e-17
C14 (\4\:n0 VSS) capacitor c=2.57087e-17
C15 (\3\:B0 VSS) capacitor c=4.93179e-17
C16 (\1\:B1 VSS) capacitor c=3.40074e-17
C17 (\3\:A1 VSS) capacitor c=2.9879e-17
C18 (\3\:A0 VSS) capacitor c=2.24708e-17
C19 (\3\:n0 VSS) capacitor c=5.15045e-17
C20 (\1\:B0 VSS) capacitor c=2.45248e-17
C21 (\2\:B1 VSS) capacitor c=6.70813e-17
C22 (\2\:A1 VSS) capacitor c=7.02887e-17
C23 (\2\:A0 VSS) capacitor c=5.04068e-17
C24 (\1\:Y VSS) capacitor c=4.05933e-17
C25 (\1\:VDD VSS) capacitor c=2.93354e-17
C26 (\5\:n3 VSS) capacitor c=7.78697e-17
C27 (\9\:n0 VSS) capacitor c=7.95822e-17
C28 (\3\:n3 VSS) capacitor c=8.60602e-17
C29 (\7\:VDD VSS) capacitor c=3.45844e-17
C30 (\3\:VDD VSS) capacitor c=5.49459e-17
C31 (\3\:Y VSS) capacitor c=2.88236e-17
C32 (\7\:n0 VSS) capacitor c=5.63768e-17
C33 (\2\:B0 VSS) capacitor c=4.07289e-17
C34 (\4\:B1 VSS) capacitor c=5.36212e-17
C35 (\5\:B0 VSS) capacitor c=1.05928e-16
C36 (\5\:n0 VSS) capacitor c=5.58229e-17
C37 (\6\:n0 VSS) capacitor c=8.77338e-17
C38 (\5\:VDD VSS) capacitor c=2.12127e-17
Rk1 (\4\:A0 A0) resistor r=0.002991 c=0
Rk6 (B0 \5\:B0) resistor r=0.0283 c=0
Rk3 (B1 \4\:B1) resistor r=0.1166 c=0
Rk18 (\3\:VSS VSS) resistor r=0.06717 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.272 c=0
Rk20 (\3\:VSS \6\:VSS) resistor r=0.3329 c=0
Rk21 (\6\:VSS \8\:VSS) resistor r=0.3639 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.341 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.2803 c=0
Rk15 (\6\:VDD VDD) resistor r=0.04984 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.12 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.1818 c=0
Rk2 (\4\:A1 A1) resistor r=0.002991 c=0
Rk10 (\2\:Y Y) resistor r=0.2466 c=0
Rk11 (Y \4\:Y) resistor r=0.1181 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.1549 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.2578 c=0
Rk9 (\6\:n0 \10\:n0) resistor r=0.5192 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3844 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.4773 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=219.923 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=39.1533 c=0
Rl9 (\2\:B0 \4\:B0) resistor r=166.187 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=108.495 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=5.0163 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=216.483 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=47.9962 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=218.464 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=37.6944 c=0
Rl10 (n0 \2\:n0) resistor r=166.216 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=28.208 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=14.3357 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry8 (\4\:VSS VSS) resistor r=62 c=0
Ry9 (\4\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (n1 \3\:A0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\7\:n0 \3\:A1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.117e-14 ps=6.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\7\:n0 \1\:B1 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.117e-14 ps=5.4e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=5.15e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (\3\:Y \4\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (n2 \3\:B0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.812e-14 ps=6.1e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp1 (\3\:n3 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.7e-07 sd=160n sca=12.1773 \
        scb=0.00921403 scc=0.000102074 m=(1)
mp3 (\9\:n0 \3\:B1 \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.65e-07 sd=160n sca=11.1982 \
        scb=0.00806486 scc=9.85433e-05 m=(1)
mp2 (\9\:n0 \4\:B0 \5\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.4e-07 sd=160n sca=11.5366 \
        scb=0.00846388 scc=9.92084e-05 m=(1)
mp4 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=55.1271 scb=0.0420653 \
        scc=0.00650135 m=(1)
ends AO22XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:19:10 2012 )
// Library name: gsclib045
// Cell name: AOI211X1
// View name: extracted

simulator lang=spectre

subckt AOI211X1 A0 A1 B0 C0 VDD VSS Y
mp0 (\3\:net82 \1\:A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.25e-07 sd=160n sca=15.668 \
        scb=0.0150333 scc=0.000302999 m=(1)
C1 (C0 VSS) capacitor c=7.38299e-17
C2 (A0 VSS) capacitor c=9.568e-17
C3 (Y VSS) capacitor c=9.39856e-17
C4 (B0 VSS) capacitor c=5.71442e-17
C5 (A1 VSS) capacitor c=6.30768e-17
C6 (VDD VSS) capacitor c=9.5452e-17
C7 (net82 VSS) capacitor c=6.96684e-17
C8 (\1\:C0 VSS) capacitor c=5.60998e-17
C9 (\1\:B0 VSS) capacitor c=7.05948e-17
C10 (\1\:A1 VSS) capacitor c=4.71344e-17
C11 (\1\:A0 VSS) capacitor c=5.74617e-17
C12 (\3\:C0 VSS) capacitor c=3.36017e-17
C13 (\3\:B0 VSS) capacitor c=3.2616e-17
C14 (\3\:A1 VSS) capacitor c=8.0503e-17
C15 (\4\:A0 VSS) capacitor c=5.03796e-17
C16 (\2\:C0 VSS) capacitor c=3.6804e-17
C17 (\2\:B0 VSS) capacitor c=4.48993e-17
C18 (\2\:A1 VSS) capacitor c=6.35025e-17
C19 (\3\:A0 VSS) capacitor c=1.02411e-17
C20 (\5\:Y VSS) capacitor c=9.07864e-17
C21 (\4\:VDD VSS) capacitor c=4.24627e-17
C22 (\3\:net82 VSS) capacitor c=6.28208e-17
C23 (\3\:Y VSS) capacitor c=5.97328e-17
C24 (\2\:A0 VSS) capacitor c=4.5509e-17
C25 (\4\:A1 VSS) capacitor c=5.84351e-17
C26 (\4\:B0 VSS) capacitor c=6.38904e-17
C27 (\4\:C0 VSS) capacitor c=3.34192e-17
C28 (\3\:VDD VSS) capacitor c=5.29477e-17
Rk5 (\4\:C0 C0) resistor r=0.1325 c=0
Rk1 (\5\:A0 A0) resistor r=0.002985 c=0
Rk6 (Y \2\:Y) resistor r=0.005069 c=0
Rk7 (\2\:Y \4\:Y) resistor r=0.3489 c=0
Rk8 (Y \6\:Y) resistor r=0.7916 c=0
Rk4 (B0 \4\:B0) resistor r=0.1064 c=0
Rk2 (A1 \4\:A1) resistor r=0.0597 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.1347 c=0
Rk10 (\3\:VSS \4\:VSS) resistor r=0.2147 c=0
Rk12 (\5\:VSS VSS) resistor r=0.08699 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.06226 c=0
Rk13 (\3\:VSS \7\:VSS) resistor r=0.2069 c=0
Rk14 (\5\:VSS \9\:VSS) resistor r=0.2114 c=0
Rk16 (\3\:VDD VDD) resistor r=0.1894 c=0
Rk17 (\3\:VDD \5\:VDD) resistor r=0.1817 c=0
Rk3 (\2\:net82 \4\:net82) resistor r=0.428 c=0
Rl8 (\1\:C0 \2\:C0) resistor r=137.23 c=0
Rl9 (\2\:C0 \3\:C0) resistor r=44.9225 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=160.418 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=37.3411 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=2.4801 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=145.329 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=29.9442 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=42.2849 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=138.257 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=75 c=0
Ry3 (\5\:Y \6\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (net82 \2\:net82) resistor r=31 c=0
Ry2 (\3\:net82 \4\:net82) resistor r=31 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (net95 \4\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.5e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1 (\3\:Y \3\:A1 net95 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=5.59e-14 ps=6.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.45e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn2 (\3\:Y \3\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=5.59e-14 ps=8.7e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=3.85e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3 (\1\:Y \3\:C0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.29e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.65e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mp1 (net82 \1\:A1 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.2e-07 sd=160n sca=13.1976 \
        scb=0.0106472 scc=0.00023361 m=(1)
mp2 (net82 \1\:B0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=6.24e-14 ps=1.04e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.15e-07 sd=160n sca=13.0795 \
        scb=0.0104536 scc=0.000232888 m=(1)
mp3 (\5\:Y \1\:C0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=5.46e-14 ps=1.04e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.4e-07 sd=160n sca=14.4782 \
        scb=0.0129551 scc=0.000256244 m=(1)
ends AOI211X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:19:47 2012 )
// Library name: gsclib045
// Cell name: AOI211X2
// View name: extracted

simulator lang=spectre

subckt AOI211X2 A0 A1 B0 C0 VDD VSS Y
mp0 (net82 \2\:A0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.712e-14 ad=6.24e-14 ps=1.335e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=28.3818 \
        scb=0.0323196 scc=0.00228512 m=(2)
C1 (C0 VSS) capacitor c=3.23636e-17
C2 (B0 VSS) capacitor c=7.82221e-17
C3 (VDD VSS) capacitor c=1.71142e-16
C4 (A0 VSS) capacitor c=1.70186e-17
C5 (Y VSS) capacitor c=9.06731e-17
C6 (11 VSS) capacitor c=1.71309e-18
C7 (net82 VSS) capacitor c=1.61492e-16
C8 (net91 VSS) capacitor c=1.96349e-16
C9 (\1\:C0 VSS) capacitor c=1.47431e-16
C10 (\1\:B0 VSS) capacitor c=1.655e-16
C11 (\6\:A0 VSS) capacitor c=5.25059e-17
C12 (\1\:A1 VSS) capacitor c=4.91087e-17
C13 (\4\:A1 VSS) capacitor c=4.26646e-17
C14 (\1\:A0 VSS) capacitor c=4.60555e-17
C15 (\3\:A1 VSS) capacitor c=1.08975e-16
C16 (\2\:A0 VSS) capacitor c=3.3392e-16
C17 (\1\:Y VSS) capacitor c=1.14149e-16
C18 (\6\:net82 VSS) capacitor c=9.36182e-17
C19 (\7\:VDD VSS) capacitor c=4.48502e-17
C20 (\1\:VDD VSS) capacitor c=7.58909e-17
C21 (\8\:Y VSS) capacitor c=5.22987e-17
C22 (\6\:Y VSS) capacitor c=5.20022e-17
C23 (\4\:Y VSS) capacitor c=6.49755e-17
C24 (\2\:A1 VSS) capacitor c=4.35268e-17
C25 (\8\:A1 VSS) capacitor c=3.22092e-17
C26 (\9\:A1 VSS) capacitor c=6.74725e-17
C27 (\7\:B0 VSS) capacitor c=3.79271e-17
C28 (\3\:Y VSS) capacitor c=4.27218e-17
C29 (\7\:C0 VSS) capacitor c=4.2641e-17
Rk18 (C0 \7\:C0) resistor r=0.04844 c=0
Rk1 (\7\:A1 \8\:A1) resistor r=0.001734 c=0
Rk2 (\9\:A1 A1) resistor r=0.001734 c=0
Rk3 (\8\:A1 \9\:A1) resistor r=0.06012 c=0
Rk23 (\7\:VSS VSS) resistor r=0.09483 c=0
Rk22 (\1\:VSS \7\:VSS) resistor r=0.3005 c=0
Rk26 (\7\:VSS \13\:VSS) resistor r=0.2039 c=0
Rk9 (\7\:B0 B0) resistor r=0.1081 c=0
Rk27 (\2\:VDD VDD) resistor r=0.2756 c=0
Rk30 (VDD \8\:VDD) resistor r=0.2936 c=0
Rk5 (\2\:A0 A0) resistor r=0.03871 c=0
Rk10 (\2\:Y Y) resistor r=0.7072 c=0
Rk11 (Y \3\:Y) resistor r=0.08439 c=0
Rk12 (\3\:Y \5\:Y) resistor r=0.3749 c=0
Rk13 (\3\:Y \7\:Y) resistor r=0.1174 c=0
Rk14 (\7\:Y \9\:Y) resistor r=0.3374 c=0
Rk8 (net82 \7\:net82) resistor r=0.4201 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=73.5354 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=54.3046 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.0112 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=33.3841 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=28.6412 c=0
Rz7 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz9 (VDD \1\:VDD) resistor r=15 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=15 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:Y \6\:Y) resistor r=75 c=0
Rz3 (\9\:Y \8\:Y) resistor r=75 c=0
Ry10 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\2\:Y \1\:Y) resistor r=31 c=0
Ry3 (\7\:net82 \6\:net82) resistor r=62 c=0
Rx5 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\7\:A1 \3\:A1) resistor r=45 c=0
Rx4 (\7\:B0 \1\:B0) resistor r=45 c=0
mn0 (10 \1\:A0 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.545e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\4\:Y \4\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.55e-07 sb=1.43e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\4\:Y \1\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.225e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_1__rcx (11 \6\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.54e-14 ad=1.56e-14 ps=1.1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.12e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\6\:Y \1\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn3 (\8\:Y \1\:C0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mp1 (net82 \3\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.1e-07 sd=160n sca=18.3481 \
        scb=0.0176469 scc=0.000920496 m=(2)
mp2 (\6\:net82 \1\:B0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=17.5811 \
        scb=0.0153688 scc=0.00137895 m=(2)
mp3 (\1\:Y \1\:C0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=20.8676 \
        scb=0.019613 scc=0.00142067 m=(2)
ends AOI211X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:20:30 2012 )
// Library name: gsclib045
// Cell name: AOI211X4
// View name: extracted

simulator lang=spectre

subckt AOI211X4 A0 A1 B0 C0 VDD VSS Y
mp0_1__rcx (net82 A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.914e-14 ad=6.24e-14 ps=1.1925e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.535e-06 sd=160n sca=21.0705 \
        scb=0.0236471 scc=0.000934065 m=(4)
C1 (C0 VSS) capacitor c=3.45199e-16
C2 (A1 VSS) capacitor c=3.77491e-16
C3 (B0 VSS) capacitor c=2.06411e-17
C4 (VDD VSS) capacitor c=2.09602e-16
C5 (A0 VSS) capacitor c=6.33261e-16
C6 (Y VSS) capacitor c=1.30542e-17
C7 (11 VSS) capacitor c=1.7621e-18
C8 (12 VSS) capacitor c=1.7621e-18
C9 (13 VSS) capacitor c=1.7621e-18
C10 (net82 VSS) capacitor c=3.13657e-16
C11 (net91 VSS) capacitor c=3.49082e-16
C12 (\1\:B0 VSS) capacitor c=3.99807e-16
C13 (\12\:A0 VSS) capacitor c=5.73082e-17
C14 (\8\:A1 VSS) capacitor c=6.27883e-17
C15 (\11\:A1 VSS) capacitor c=5.54296e-17
C16 (\4\:A0 VSS) capacitor c=6.61102e-17
C17 (\6\:A0 VSS) capacitor c=4.70392e-17
C18 (\1\:A1 VSS) capacitor c=6.5802e-17
C19 (\4\:A1 VSS) capacitor c=4.62066e-17
C20 (\1\:A0 VSS) capacitor c=7.52716e-17
C21 (\1\:Y VSS) capacitor c=2.42444e-16
C22 (\8\:net82 VSS) capacitor c=2.03014e-16
C23 (\1\:VDD VSS) capacitor c=1.96273e-16
C24 (\16\:Y VSS) capacitor c=1.22701e-16
C25 (\12\:Y VSS) capacitor c=6.08891e-17
C26 (\6\:Y VSS) capacitor c=9.81297e-17
C27 (\8\:Y VSS) capacitor c=6.95998e-17
C28 (\2\:A1 VSS) capacitor c=3.18911e-17
C29 (\9\:A1 VSS) capacitor c=3.50269e-17
C30 (\4\:Y VSS) capacitor c=1.35963e-16
C31 (\5\:Y VSS) capacitor c=6.69811e-17
C32 (\3\:VDD VSS) capacitor c=1.81247e-16
Rk35 (\2\:VSS \3\:VSS) resistor r=0.06993 c=0
Rk41 (\3\:VSS \9\:VSS) resistor r=0.3107 c=0
Rk43 (\10\:VSS VSS) resistor r=0.2049 c=0
Rk42 (\9\:VSS \10\:VSS) resistor r=0.2956 c=0
Rk49 (\9\:VSS \22\:VSS) resistor r=0.2439 c=0
Rk50 (\10\:VSS \24\:VSS) resistor r=0.2024 c=0
Rk6 (B0 \1\:B0) resistor r=0.03619 c=0
Rk60 (\3\:VDD VDD) resistor r=0.02961 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.4857 c=0
Rk27 (\12\:Y \16\:Y) resistor r=0.3006 c=0
Rk24 (\4\:Y Y) resistor r=0.003066 c=0
Rk19 (\1\:Y \4\:Y) resistor r=1.1187 c=0
Rk25 (\5\:Y \12\:Y) resistor r=0.05823 c=0
Rk20 (\4\:Y \5\:Y) resistor r=0.1072 c=0
Rk21 (\5\:Y \7\:Y) resistor r=0.3845 c=0
Rk22 (\7\:Y \9\:Y) resistor r=0.4656 c=0
Rk12 (net82 \8\:net82) resistor r=0.4445 c=0
Rl4 (\2\:A1 A1) resistor r=29.4415 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl15 (\9\:A1 A1) resistor r=6.3032 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=137.946 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=88.5249 c=0
Rl20 (A0 \12\:A0) resistor r=41.4835 c=0
Rl9 (A0 \4\:A0) resistor r=85.3597 c=0
Rl10 (A0 \6\:A0) resistor r=39.5284 c=0
Rl1 (A0 \1\:A0) resistor r=140.362 c=0
Rz12 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz13 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz19 (VDD \1\:VDD) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=7.5 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=9.375 c=0
Rz1 (\7\:Y \6\:Y) resistor r=75 c=0
Rz2 (\9\:Y \8\:Y) resistor r=75 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry15 (\3\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=5.6364 c=0
mn0_1__rcx (10 \1\:A0 \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\8\:Y \4\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\8\:Y \1\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (11 \6\:A0 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (12 \4\:A0 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_2__rcx (\6\:Y \11\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\6\:Y \8\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (13 \12\:A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=1.56e-14 ps=9.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.95e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\12\:Y \1\:B0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.492e-14 ad=4.225e-14 ps=9.425e-07 pd=8.45e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.42e-06 sb=1.705e-06 sd=160n \
        sca=9.14564 scb=0.00759168 scc=0.000213449 m=(4)
mn3_1__rcx (\16\:Y C0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.582e-14 ad=4.16e-14 ps=8.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp1_1__rcx (net82 A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.33e-06 sd=160n sca=15.0091 \
        scb=0.0134988 scc=0.00042661 m=(4)
mp2_1__rcx (\8\:net82 \1\:B0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.04e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39487e-07 sb=1.575e-06 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(4)
mp3_1__rcx (\1\:Y C0 net91 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59487e-07 sb=7.55e-07 sd=160n sca=12.5232 \
        scb=0.0108581 scc=0.000412418 m=(4)
ends AOI211X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:21:07 2012 )
// Library name: gsclib045
// Cell name: AOI211XL
// View name: extracted

simulator lang=spectre

subckt AOI211XL A0 A1 B0 C0 VDD VSS Y
mp0 (net82 \3\:A0 \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.95e-07 sd=160n sca=21.1265 \
        scb=0.0233936 scc=0.000954114 m=(1)
C1 (C0 VSS) capacitor c=5.26923e-17
C2 (Y VSS) capacitor c=5.08394e-17
C3 (B0 VSS) capacitor c=3.90192e-17
C4 (A1 VSS) capacitor c=5.40825e-17
C5 (VDD VSS) capacitor c=1.13751e-16
C6 (net82 VSS) capacitor c=6.25959e-17
C7 (\1\:C0 VSS) capacitor c=4.73078e-17
C8 (\1\:B0 VSS) capacitor c=5.4126e-17
C9 (\1\:A1 VSS) capacitor c=5.41768e-17
C10 (\3\:A0 VSS) capacitor c=5.35797e-17
C11 (\3\:C0 VSS) capacitor c=3.70419e-17
C12 (\3\:B0 VSS) capacitor c=3.44705e-17
C13 (\3\:A1 VSS) capacitor c=5.65254e-17
C14 (\1\:A0 VSS) capacitor c=6.78647e-17
C15 (\2\:C0 VSS) capacitor c=5.25664e-17
C16 (\2\:B0 VSS) capacitor c=5.76099e-17
C17 (\2\:A1 VSS) capacitor c=5.85212e-17
C18 (\2\:A0 VSS) capacitor c=5.23193e-17
C19 (\1\:Y VSS) capacitor c=1.59034e-17
C20 (\3\:net82 VSS) capacitor c=4.98433e-17
C21 (\4\:VDD VSS) capacitor c=3.40072e-17
C22 (\6\:Y VSS) capacitor c=2.81004e-17
C23 (\4\:Y VSS) capacitor c=6.79634e-17
C24 (\4\:A0 VSS) capacitor c=1.97153e-17
C25 (\6\:A0 VSS) capacitor c=7.83462e-17
C26 (\4\:A1 VSS) capacitor c=4.98154e-17
C27 (\4\:B0 VSS) capacitor c=7.0695e-17
C28 (\4\:C0 VSS) capacitor c=6.28833e-17
C29 (\3\:Y VSS) capacitor c=7.19008e-17
C30 (\3\:VDD VSS) capacitor c=3.11818e-17
Rk7 (C0 \4\:C0) resistor r=0.225 c=0
Rk1 (\4\:A0 \5\:A0) resistor r=0.002021 c=0
Rk2 (A0 \6\:A0) resistor r=0.001953 c=0
Rk3 (\4\:A0 \6\:A0) resistor r=0.05142 c=0
Rk8 (\2\:Y Y) resistor r=0.1267 c=0
Rk9 (Y \3\:Y) resistor r=0.4242 c=0
Rk10 (\3\:Y \5\:Y) resistor r=0.3839 c=0
Rk11 (\3\:Y \7\:Y) resistor r=0.0641 c=0
Rk6 (B0 \4\:B0) resistor r=0.1148 c=0
Rk4 (\4\:A1 A1) resistor r=0.1584 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1001 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.1502 c=0
Rk15 (\5\:VSS VSS) resistor r=0.06475 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.1352 c=0
Rk17 (\3\:VSS \8\:VSS) resistor r=0.1898 c=0
Rk18 (\5\:VSS \10\:VSS) resistor r=0.1939 c=0
Rk20 (\3\:VDD VDD) resistor r=0.1174 c=0
Rk21 (\3\:VDD \5\:VDD) resistor r=0.234 c=0
Rk5 (\2\:net82 \4\:net82) resistor r=0.3117 c=0
Rl7 (\1\:C0 \2\:C0) resistor r=181.461 c=0
Rl8 (\2\:C0 \3\:C0) resistor r=89.1533 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=225.722 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=105.323 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=193 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=77.6149 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=178.079 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=89.6174 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry7 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (net82 \2\:net82) resistor r=62 c=0
Ry2 (\3\:net82 \4\:net82) resistor r=62 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\2\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (net95 \1\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (\4\:Y \3\:A1 net95 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.35e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\4\:Y \3\:B0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.553e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn3 (\6\:Y \3\:C0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mp1 (\3\:net82 \1\:A1 \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.268e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.9e-07 sd=160n sca=13.9396 \
        scb=0.0112937 scc=0.000117391 m=(1)
mp2 (\3\:net82 \1\:B0 net91 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.268e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=4e-07 sd=160n sca=13.5585 scb=0.010525 \
        scc=0.000106027 m=(1)
mp3 (\1\:Y \1\:C0 net91 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.95e-07 sd=160n sca=18.7951 \
        scb=0.0200922 scc=0.000572349 m=(1)
ends AOI211XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:21:44 2012 )
// Library name: gsclib045
// Cell name: AOI21X1
// View name: extracted

simulator lang=spectre

subckt AOI21X1 A0 A1 B0 VDD VSS Y
mp0 (\3\:net62 \1\:A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=26.2807 \
        scb=0.0297759 scc=0.00178997 m=(1)
C1 (VDD VSS) capacitor c=6.84328e-17
C2 (A0 VSS) capacitor c=1.84425e-17
C3 (Y VSS) capacitor c=8.38023e-17
C4 (B0 VSS) capacitor c=4.93668e-17
C5 (net62 VSS) capacitor c=9.28878e-17
C6 (\1\:B0 VSS) capacitor c=5.45897e-17
C7 (\1\:A1 VSS) capacitor c=5.82886e-17
C8 (\1\:A0 VSS) capacitor c=5.86008e-17
C9 (\3\:B0 VSS) capacitor c=2.78151e-17
C10 (\3\:A1 VSS) capacitor c=7.57355e-17
C11 (\4\:A0 VSS) capacitor c=5.01833e-17
C12 (\2\:B0 VSS) capacitor c=4.16267e-17
C13 (\2\:A1 VSS) capacitor c=6.22793e-17
C14 (\3\:A0 VSS) capacitor c=1.05126e-17
C15 (\1\:Y VSS) capacitor c=5.8913e-17
C16 (\4\:VDD VSS) capacitor c=6.56514e-17
C17 (\3\:net62 VSS) capacitor c=5.45021e-17
C18 (\3\:Y VSS) capacitor c=7.42154e-17
C19 (\2\:A0 VSS) capacitor c=4.85878e-17
C20 (\6\:A0 VSS) capacitor c=4.22859e-17
C21 (\4\:A1 VSS) capacitor c=5.42143e-17
C22 (\6\:A1 VSS) capacitor c=1.55348e-17
C23 (\4\:B0 VSS) capacitor c=7.12824e-17
C24 (\3\:VDD VSS) capacitor c=2.97889e-17
Rk3 (\4\:A1 \5\:A1) resistor r=0.00183 c=0
Rk4 (A1 \6\:A1) resistor r=0.001708 c=0
Rk5 (\4\:A1 \6\:A1) resistor r=0.0108 c=0
Rk16 (\3\:VDD VDD) resistor r=0.1022 c=0
Rk17 (\3\:VDD \5\:VDD) resistor r=0.2588 c=0
Rk2 (\6\:A0 A0) resistor r=0.0108 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.001318 c=0
Rk8 (\2\:Y Y) resistor r=0.4 c=0
Rk9 (Y \4\:Y) resistor r=0.4281 c=0
Rk10 (\2\:VSS \3\:VSS) resistor r=0.09247 c=0
Rk12 (\4\:VSS VSS) resistor r=0.1002 c=0
Rk11 (\3\:VSS \4\:VSS) resistor r=0.1576 c=0
Rk13 (VSS \6\:VSS) resistor r=0.1814 c=0
Rk14 (\3\:VSS \8\:VSS) resistor r=0.177 c=0
Rk7 (B0 \4\:B0) resistor r=0.205 c=0
Rk6 (\2\:net62 \4\:net62) resistor r=0.5592 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=94.208 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=94.0258 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=160.418 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=45.0334 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=3.1183 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=159.593 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=28.6412 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=31 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry1 (net62 \2\:net62) resistor r=31 c=0
Ry2 (\3\:net62 \4\:net62) resistor r=31 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net78 \4\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=1.56e-14 ps=1.1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:Y \3\:A1 net78 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\3\:Y \3\:B0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=4.16e-14 ps=1.1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (net62 \1\:A1 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.6e-07 sd=160n sca=17.2376 \
        scb=0.0159027 scc=0.000426763 m=(1)
mp2 (\1\:Y \1\:B0 net62 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.55e-07 sd=160n sca=17.5198 \
        scb=0.0164926 scc=0.000444164 m=(1)
ends AOI21X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:22:21 2012 )
// Library name: gsclib045
// Cell name: AOI21X2
// View name: extracted

simulator lang=spectre

subckt AOI21X2 A0 A1 B0 VDD VSS Y
mp0 (net70 A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.922e-14 ps=1.1e-06 pd=1.135e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=39.514 \
        scb=0.0334743 scc=0.00392846 m=(2)
C1 (A0 VSS) capacitor c=3.22996e-16
C2 (Y VSS) capacitor c=3.74176e-17
C3 (B0 VSS) capacitor c=3.97402e-17
C4 (VDD VSS) capacitor c=5.29171e-17
C5 (9 VSS) capacitor c=2.32326e-18
C6 (net70 VSS) capacitor c=2.1119e-16
C7 (\1\:B0 VSS) capacitor c=8.49735e-17
C8 (\1\:A1 VSS) capacitor c=8.4009e-17
C9 (\6\:A0 VSS) capacitor c=5.27164e-17
C10 (\6\:A1 VSS) capacitor c=4.71086e-17
C11 (\4\:A1 VSS) capacitor c=5.3509e-17
C12 (\1\:A0 VSS) capacitor c=5.11807e-17
C13 (\1\:Y VSS) capacitor c=5.83748e-17
C14 (\8\:net70 VSS) capacitor c=3.40629e-17
C15 (\1\:VDD VSS) capacitor c=4.14118e-17
C16 (\3\:Y VSS) capacitor c=5.26042e-17
C17 (\5\:Y VSS) capacitor c=6.79613e-17
C18 (\3\:A1 VSS) capacitor c=3.95375e-17
C19 (\4\:B0 VSS) capacitor c=6.28428e-17
C20 (\7\:A1 VSS) capacitor c=4.76613e-17
C21 (\9\:A1 VSS) capacitor c=4.652e-17
C22 (\8\:B0 VSS) capacitor c=4.04216e-17
C23 (\3\:VDD VSS) capacitor c=9.24357e-17
Rk6 (\2\:Y Y) resistor r=0.2816 c=0
Rk7 (Y \4\:Y) resistor r=0.1446 c=0
Rk8 (\4\:Y \6\:Y) resistor r=0.4409 c=0
Rk1 (\7\:A1 A1) resistor r=0.005392 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.0965 c=0
Rk2 (\8\:A1 \9\:A1) resistor r=0.005392 c=0
Rk15 (\1\:VSS \5\:VSS) resistor r=0.03487 c=0
Rk17 (\6\:VSS VSS) resistor r=0.07719 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.2728 c=0
Rk19 (\6\:VSS \10\:VSS) resistor r=0.1792 c=0
Rk13 (B0 \8\:B0) resistor r=0.1159 c=0
Rk20 (\2\:VDD \3\:VDD) resistor r=0.2152 c=0
Rk24 (\6\:VDD VDD) resistor r=0.04984 c=0
Rk23 (\3\:VDD \6\:VDD) resistor r=0.07995 c=0
Rk12 (net70 \9\:net70) resistor r=0.06065 c=0
Rl9 (A0 \6\:A0) resistor r=45.6044 c=0
Rl1 (A0 \1\:A0) resistor r=31.9251 c=0
Rl4 (\3\:A1 \1\:A1) resistor r=9.9515 c=0
Rl7 (\3\:A1 \6\:A1) resistor r=113.668 c=0
Rl5 (\3\:A1 \4\:A1) resistor r=70.6802 c=0
Rl12 (\4\:B0 \1\:B0) resistor r=26.8198 c=0
Rz1 (\4\:Y \3\:Y) resistor r=75 c=0
Rz2 (\6\:Y \5\:Y) resistor r=75 c=0
Rz5 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\6\:VDD \1\:VDD) resistor r=37.5 c=0
Ry1 (\2\:Y \1\:Y) resistor r=62 c=0
Ry5 (\9\:net70 \8\:net70) resistor r=31 c=0
Rx1 (\8\:A1 \1\:A1) resistor r=45 c=0
Rx4 (\8\:B0 \1\:B0) resistor r=45 c=0
mn0 (8 \1\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (\5\:Y \4\:A1 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.9e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn1_1__rcx (\5\:Y \6\:A1 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.16e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.85e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn0_1__rcx (9 \6\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=2.21e-14 ps=8.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=5.55e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (\3\:Y \4\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=4.16e-14 ps=8.25e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=3.45e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(2)
mp1 (\8\:net70 \1\:A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.015e-06 sd=160n sca=33.2136 \
        scb=0.0229892 scc=0.00337651 m=(2)
mp2 (\1\:Y \1\:B0 net70 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.922e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=3.45e-07 sd=160n sca=33.1443 \
        scb=0.0228772 scc=0.00337517 m=(2)
ends AOI21X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:22:58 2012 )
// Library name: gsclib045
// Cell name: AOI21X4
// View name: extracted

simulator lang=spectre

subckt AOI21X4 A0 A1 B0 VDD VSS Y
mp0 (net70 \2\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.142e-14 ps=1.1e-06 pd=1.095e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.7719 scb=0.023448 \
        scc=0.0017399 m=(4)
C1 (A0 VSS) capacitor c=3.74006e-17
C2 (Y VSS) capacitor c=6.05931e-17
C3 (A1 VSS) capacitor c=3.82528e-16
C4 (B0 VSS) capacitor c=3.48696e-16
C5 (VDD VSS) capacitor c=1.11327e-16
C6 (9 VSS) capacitor c=1.82117e-18
C7 (10 VSS) capacitor c=1.77435e-18
C8 (11 VSS) capacitor c=1.79527e-18
C9 (net70 VSS) capacitor c=4.77129e-16
C10 (\12\:A0 VSS) capacitor c=6.62844e-17
C11 (\12\:A1 VSS) capacitor c=6.18572e-17
C12 (\10\:A1 VSS) capacitor c=5.37464e-17
C13 (\4\:A0 VSS) capacitor c=5.22019e-17
C14 (\6\:A0 VSS) capacitor c=4.80365e-17
C15 (\1\:A1 VSS) capacitor c=6.83111e-17
C16 (\4\:A1 VSS) capacitor c=4.80598e-17
C17 (\1\:A0 VSS) capacitor c=5.29758e-17
C18 (\2\:A0 VSS) capacitor c=6.00853e-16
C19 (\10\:Y VSS) capacitor c=1.01769e-16
C20 (\1\:VDD VSS) capacitor c=3.36995e-17
C21 (\1\:Y VSS) capacitor c=1.04473e-16
C22 (\4\:Y VSS) capacitor c=8.75742e-17
C23 (\6\:Y VSS) capacitor c=6.76584e-17
C24 (\2\:A1 VSS) capacitor c=3.09817e-17
C25 (\9\:A1 VSS) capacitor c=3.89699e-17
C26 (\3\:Y VSS) capacitor c=6.35687e-17
C27 (\3\:VDD VSS) capacitor c=2.35297e-16
Rk3 (A0 \2\:A0) resistor r=0.08359 c=0
Rk11 (Y \10\:Y) resistor r=0.0853 c=0
Rk10 (\3\:Y Y) resistor r=0.3437 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.04576 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.3361 c=0
Rk8 (\5\:Y \7\:Y) resistor r=0.4638 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.09474 c=0
Rk29 (\3\:VSS \7\:VSS) resistor r=0.2721 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.03728 c=0
Rk32 (\9\:VSS VSS) resistor r=0.2169 c=0
Rk31 (\8\:VSS \9\:VSS) resistor r=0.2944 c=0
Rk36 (\8\:VSS \17\:VSS) resistor r=0.197 c=0
Rk37 (\9\:VSS \19\:VSS) resistor r=0.2015 c=0
Rk38 (\2\:VDD \3\:VDD) resistor r=0.6144 c=0
Rk44 (\8\:VDD VDD) resistor r=0.04971 c=0
Rk43 (\3\:VDD \8\:VDD) resistor r=0.1197 c=0
Rl19 (\2\:A0 \12\:A0) resistor r=55.0021 c=0
Rl8 (\2\:A0 \4\:A0) resistor r=73.8213 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=51.7021 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=43.4636 c=0
Rl4 (\2\:A1 A1) resistor r=25.7773 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=86.2215 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=38.3697 c=0
Rl14 (\9\:A1 A1) resistor r=10.2925 c=0
Rl17 (\9\:A1 \12\:A1) resistor r=128.331 c=0
Rl15 (\9\:A1 \10\:A1) resistor r=78.9095 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz8 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz9 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\8\:VDD \1\:VDD) resistor r=37.5 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry11 (\3\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (8 \1\:A0 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\6\:Y \4\:A1 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.905e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\6\:Y \1\:A1 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.7e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (9 \6\:A0 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.595e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (10 \4\:A0 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.39e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\4\:Y \10\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\4\:Y \12\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.08e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (11 \12\:A0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=9.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\1\:Y B0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=7.7e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp1 (net70 A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=20.1813 scb=0.0174167 \
        scc=0.00159977 m=(4)
mp2 (\10\:Y B0 net70 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.142e-14 ad=6.24e-14 ps=1.095e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=7.55e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
ends AOI21X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:23:36 2012 )
// Library name: gsclib045
// Cell name: AOI21XL
// View name: extracted

simulator lang=spectre

subckt AOI21XL A0 A1 B0 VDD VSS Y
mp0 (net70 \3\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.01e-14 ps=1.23e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=17.8246 \
        scb=0.0177319 scc=0.000363007 m=(1)
C1 (A1 VSS) capacitor c=5.18501e-17
C2 (Y VSS) capacitor c=7.22103e-17
C3 (A0 VSS) capacitor c=3.94575e-17
C4 (VDD VSS) capacitor c=1.25063e-16
C5 (B0 VSS) capacitor c=7.66857e-17
C6 (net70 VSS) capacitor c=3.47418e-17
C7 (\4\:B0 VSS) capacitor c=4.71505e-17
C8 (\1\:A1 VSS) capacitor c=7.11196e-17
C9 (\3\:A0 VSS) capacitor c=5.79423e-17
C10 (\1\:B0 VSS) capacitor c=2.62935e-17
C11 (\3\:A1 VSS) capacitor c=4.05455e-17
C12 (\1\:A0 VSS) capacitor c=4.11061e-17
C13 (\3\:B0 VSS) capacitor c=5.66639e-17
C14 (\2\:A1 VSS) capacitor c=7.48214e-17
C15 (\2\:A0 VSS) capacitor c=4.69277e-17
C16 (\3\:Y VSS) capacitor c=5.84304e-17
C17 (\3\:net70 VSS) capacitor c=5.56909e-17
C18 (\5\:VDD VSS) capacitor c=2.68635e-17
C19 (\1\:VDD VSS) capacitor c=3.01039e-17
C20 (\1\:Y VSS) capacitor c=7.5811e-17
C21 (\4\:A0 VSS) capacitor c=3.70212e-17
C22 (\4\:A1 VSS) capacitor c=6.51864e-17
C23 (\5\:B0 VSS) capacitor c=2.91125e-17
C24 (\3\:VDD VSS) capacitor c=5.11781e-20
Rk2 (A1 \4\:A1) resistor r=0.2094 c=0
Rk7 (\2\:Y Y) resistor r=0.2871 c=0
Rk8 (Y \4\:Y) resistor r=0.4296 c=0
Rk1 (\4\:A0 A0) resistor r=0.09189 c=0
Rk10 (\3\:VSS VSS) resistor r=0.08721 c=0
Rk9 (\2\:VSS \3\:VSS) resistor r=0.2882 c=0
Rk11 (\3\:VSS \5\:VSS) resistor r=0.1125 c=0
Rk12 (\5\:VSS \7\:VSS) resistor r=0.4421 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.135 c=0
Rk15 (\4\:VDD VDD) resistor r=0.04984 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.115 c=0
Rk16 (\3\:VDD \6\:VDD) resistor r=0.07323 c=0
Rk6 (\5\:B0 B0) resistor r=0.03888 c=0
Rk3 (\2\:net70 \4\:net70) resistor r=0.2768 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=218.312 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.9451 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=203.641 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=55.7464 c=0
Rl7 (\2\:B0 \4\:B0) resistor r=168.236 c=0
Rl5 (\1\:B0 \2\:B0) resistor r=98.4889 c=0
Rl6 (\2\:B0 \3\:B0) resistor r=2.0644 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry5 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (net70 \2\:net70) resistor r=62 c=0
Ry2 (\3\:net70 \4\:net70) resistor r=62 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\3\:B0 \5\:B0) resistor r=45 c=0
mn0 (net74 \1\:A0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.35e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (\1\:Y \3\:A1 net74 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (\1\:Y \1\:B0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.553e-14 ps=5.7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp1 (\3\:net70 \1\:A1 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.44e-14 ps=1.23e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=14.8802 \
        scb=0.0119982 scc=0.000102266 m=(1)
mp2 (\3\:Y \4\:B0 \3\:net70 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=21.4669 \
        scb=0.0232556 scc=0.000936595 m=(1)
ends AOI21XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:00:39 2012 )
// Library name: gsclib045
// Cell name: AOI221X1
// View name: extracted

simulator lang=spectre

subckt AOI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\3\:net108 \3\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.05e-07 sd=160n sca=40.7758 \
        scb=0.038454 scc=0.00437052 m=(1)
C1 (A0 VSS) capacitor c=2.97566e-17
C2 (VDD VSS) capacitor c=5.15606e-17
C3 (Y VSS) capacitor c=4.11254e-17
C4 (net128 VSS) capacitor c=1.66661e-18
C5 (net120 VSS) capacitor c=3.08887e-18
C6 (net108 VSS) capacitor c=9.32052e-17
C7 (net111 VSS) capacitor c=7.02549e-17
C8 (\1\:C0 VSS) capacitor c=4.32573e-17
C9 (\1\:B0 VSS) capacitor c=4.78191e-17
C10 (\1\:B1 VSS) capacitor c=5.74231e-17
C11 (\1\:A1 VSS) capacitor c=5.42375e-17
C12 (\3\:A0 VSS) capacitor c=4.66029e-17
C13 (\3\:C0 VSS) capacitor c=3.80372e-17
C14 (\3\:B0 VSS) capacitor c=6.98594e-17
C15 (\4\:B1 VSS) capacitor c=5.28607e-17
C16 (\3\:A1 VSS) capacitor c=4.5035e-17
C17 (\1\:A0 VSS) capacitor c=3.60487e-17
C18 (\2\:C0 VSS) capacitor c=3.61186e-17
C19 (\2\:B0 VSS) capacitor c=5.51936e-17
C20 (\3\:B1 VSS) capacitor c=4.9841e-17
C21 (\2\:A1 VSS) capacitor c=3.81714e-17
C22 (\2\:A0 VSS) capacitor c=3.85002e-17
C23 (\4\:Y VSS) capacitor c=2.66047e-17
C24 (\3\:net111 VSS) capacitor c=6.5118e-17
C25 (\7\:VDD VSS) capacitor c=1.18851e-17
C26 (\3\:net108 VSS) capacitor c=5.76541e-17
C27 (\5\:VDD VSS) capacitor c=3.58033e-17
C28 (\1\:VDD VSS) capacitor c=4.43939e-17
C29 (\6\:Y VSS) capacitor c=2.70563e-17
C30 (\1\:Y VSS) capacitor c=7.47651e-17
C31 (\4\:A0 VSS) capacitor c=4.16641e-17
C32 (\4\:A1 VSS) capacitor c=6.14891e-17
C33 (\6\:B1 VSS) capacitor c=6.02088e-17
C34 (\7\:B1 VSS) capacitor c=4.11389e-17
C35 (\4\:B0 VSS) capacitor c=7.16203e-17
C36 (\6\:B0 VSS) capacitor c=3.23349e-17
C37 (\4\:C0 VSS) capacitor c=4.55362e-17
C38 (\6\:C0 VSS) capacitor c=3.88793e-17
C39 (\3\:Y VSS) capacitor c=8.02639e-17
C40 (\3\:VDD VSS) capacitor c=1.62283e-18
Rk11 (C0 \4\:C0) resistor r=0.002852 c=0
Rk13 (\4\:C0 \6\:C0) resistor r=0.007527 c=0
Rk12 (\5\:C0 \6\:C0) resistor r=0.002852 c=0
Rk2 (\4\:A1 A1) resistor r=0.03258 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.1201 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.2303 c=0
Rk21 (\5\:VSS VSS) resistor r=0.01709 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.1827 c=0
Rk22 (\3\:VSS \7\:VSS) resistor r=0.1683 c=0
Rk23 (\5\:VSS \9\:VSS) resistor r=0.2127 c=0
Rk1 (A0 \4\:A0) resistor r=0.07948 c=0
Rk7 (\4\:B0 \5\:B0) resistor r=0.001408 c=0
Rk8 (B0 \6\:B0) resistor r=0.001314 c=0
Rk9 (\4\:B0 \6\:B0) resistor r=0.04218 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.2303 c=0
Rk26 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.1201 c=0
Rk27 (VDD \6\:VDD) resistor r=0.3929 c=0
Rk28 (\3\:VDD \8\:VDD) resistor r=0.1563 c=0
Rk3 (\5\:B1 \6\:B1) resistor r=0.001878 c=0
Rk4 (B1 \7\:B1) resistor r=0.001784 c=0
Rk5 (\5\:B1 \7\:B1) resistor r=0.1097 c=0
Rk15 (\3\:Y Y) resistor r=0.4127 c=0
Rk14 (\2\:Y \3\:Y) resistor r=0.4174 c=0
Rk16 (Y \5\:Y) resistor r=0.03477 c=0
Rk17 (\3\:Y \7\:Y) resistor r=0.08872 c=0
Rk6 (\2\:net108 \4\:net108) resistor r=0.4022 c=0
Rk10 (\2\:net111 \4\:net111) resistor r=0.3777 c=0
Rl10 (\1\:C0 \2\:C0) resistor r=79.0433 c=0
Rl11 (\2\:C0 \3\:C0) resistor r=60.989 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=73.7687 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=62.2302 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=106.868 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=41.3798 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=94.0258 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=91.1873 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=60.4181 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.6051 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry8 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry1 (net108 \2\:net108) resistor r=62 c=0
Ry2 (\3\:net108 \4\:net108) resistor r=62 c=0
Ry3 (net111 \2\:net111) resistor r=31 c=0
Ry4 (\3\:net111 \4\:net111) resistor r=62 c=0
Rx5 (\2\:C0 \5\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
mn0 (net128 \1\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=2.34e-14 ps=8.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=1.03e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \4\:B1 net120 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=8.32e-14 ps=6.6e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=5.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\1\:Y \3\:A1 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.32e-14 ps=7e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=8.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net120 \3\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.82e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=4.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\6\:Y \3\:C0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.46e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (\3\:net108 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=6.24e-14 ps=1.78e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-07 sd=160n sca=30.7421 scb=0.0237813 \
        scc=0.0030059 m=(1)
mp3 (net108 \1\:B1 \3\:net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=28.7609 scb=0.020281 \
        scc=0.00296496 m=(1)
mp2 (net108 \1\:B0 net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=30.4607 \
        scb=0.0232925 scc=0.00299608 m=(1)
mp4 (\4\:Y \1\:C0 net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=39.2278 \
        scb=0.0367431 scc=0.00406631 m=(1)
ends AOI221X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:24:56 2012 )
// Library name: gsclib045
// Cell name: AOI221X2
// View name: extracted

simulator lang=spectre

subckt AOI221X2 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\5\:net104 \2\:A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=22.5802 \
        scb=0.0254567 scc=0.001215 m=(2)
C1 (C0 VSS) capacitor c=3.57679e-17
C2 (A1 VSS) capacitor c=5.18422e-17
C3 (B0 VSS) capacitor c=3.96288e-16
C4 (VDD VSS) capacitor c=1.47221e-16
C5 (Y VSS) capacitor c=1.70817e-16
C6 (12 VSS) capacitor c=1.69916e-18
C7 (13 VSS) capacitor c=1.71895e-18
C8 (14 VSS) capacitor c=1.71625e-18
C9 (net104 VSS) capacitor c=2.03338e-16
C10 (net103 VSS) capacitor c=2.78198e-16
C11 (\1\:C0 VSS) capacitor c=9.30303e-17
C12 (\1\:B1 VSS) capacitor c=9.17024e-17
C13 (\6\:B0 VSS) capacitor c=6.98561e-17
C14 (\6\:B1 VSS) capacitor c=6.182e-17
C15 (\5\:B1 VSS) capacitor c=5.77349e-17
C16 (\3\:B0 VSS) capacitor c=5.61647e-17
C17 (\6\:A0 VSS) capacitor c=5.688e-17
C18 (\1\:A1 VSS) capacitor c=4.71772e-17
C19 (\6\:A1 VSS) capacitor c=5.16238e-17
C20 (\1\:A0 VSS) capacitor c=6.89553e-17
C21 (\3\:B1 VSS) capacitor c=5.24056e-17
C22 (\3\:A1 VSS) capacitor c=2.05406e-17
C23 (\2\:A0 VSS) capacitor c=3.10156e-16
C24 (\8\:Y VSS) capacitor c=1.55502e-16
C25 (\9\:net103 VSS) capacitor c=3.92808e-18
C26 (\5\:net104 VSS) capacitor c=1.79447e-16
C27 (\9\:VDD VSS) capacitor c=3.98946e-17
C28 (\1\:VDD VSS) capacitor c=9.97753e-17
C29 (\1\:Y VSS) capacitor c=5.84617e-17
C30 (\3\:Y VSS) capacitor c=7.16718e-17
C31 (\6\:Y VSS) capacitor c=5.51862e-17
C32 (\2\:A1 VSS) capacitor c=4.20553e-17
C33 (\4\:A1 VSS) capacitor c=8.9444e-17
C34 (\3\:C0 VSS) capacitor c=8.45511e-17
C35 (\7\:B1 VSS) capacitor c=1.40987e-16
C36 (\5\:Y VSS) capacitor c=7.60606e-17
C37 (\7\:C0 VSS) capacitor c=5.52215e-17
C38 (\4\:VDD VSS) capacitor c=1.08323e-16
Rk20 (C0 \7\:C0) resistor r=0.189 c=0
Rk3 (\2\:A0 A0) resistor r=0.002375 c=0
Rk22 (\1\:VSS \5\:VSS) resistor r=0.4133 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.2379 c=0
Rk25 (\7\:VSS VSS) resistor r=0.1274 c=0
Rk24 (\6\:VSS \7\:VSS) resistor r=0.07248 c=0
Rk27 (\5\:VSS \11\:VSS) resistor r=0.1885 c=0
Rk28 (\7\:VSS \13\:VSS) resistor r=0.213 c=0
Rk1 (\8\:A1 A1) resistor r=0.002995 c=0
Rk29 (\2\:VDD \3\:VDD) resistor r=0.6516 c=0
Rk33 (\4\:VDD VDD) resistor r=0.02712 c=0
Rk30 (\3\:VDD \4\:VDD) resistor r=0.1276 c=0
Rk35 (\4\:VDD \10\:VDD) resistor r=0.2206 c=0
Rk9 (B1 \7\:B1) resistor r=0.002695 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.4227 c=0
Rk13 (\5\:Y Y) resistor r=0.2422 c=0
Rk11 (\4\:Y \5\:Y) resistor r=0.3149 c=0
Rk12 (\5\:Y \7\:Y) resistor r=0.3374 c=0
Rk14 (Y \9\:Y) resistor r=0.9701 c=0
Rk5 (net104 \5\:net104) resistor r=0.4835 c=0
Rk19 (net103 \10\:net103) resistor r=0.0153 c=0
Rl21 (\3\:C0 \1\:C0) resistor r=30.2393 c=0
Rl10 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=71.2234 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=54.3046 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=73.5354 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.2612 c=0
Rl5 (\4\:A1 \3\:A1) resistor r=8.9152 c=0
Rl19 (B0 \6\:B0) resistor r=65.3618 c=0
Rl12 (B0 \3\:B0) resistor r=31.461 c=0
Rl14 (\1\:B1 \3\:B1) resistor r=9.4152 c=0
Rl17 (\3\:B1 \6\:B1) resistor r=129.041 c=0
Rl16 (\3\:B1 \5\:B1) resistor r=107.643 c=0
Rz6 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=7.75 c=0
Ry11 (\6\:VSS \3\:VSS) resistor r=12.4 c=0
Ry13 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry5 (\9\:Y \8\:Y) resistor r=62 c=0
Ry9 (\10\:net103 \9\:net103) resistor r=62 c=0
Rx7 (\7\:C0 \1\:C0) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
Rx6 (\7\:B1 \3\:B1) resistor r=45 c=0
mn0_1__rcx (11 \1\:A0 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.895e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1_1__rcx (\6\:Y \6\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.79e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1 (\6\:Y \1\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.585e-06 sd=160n sca=9.69565 scb=0.00844644 \
        scc=0.000275168 m=(1)
mn0 (12 \6\:A0 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.102e-13 ad=1.56e-14 ps=1.4e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.48e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn2_1__rcx (\10\:VSS \3\:B0 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=1.102e-13 ps=6.4e-07 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.025e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3_1__rcx (13 \5\:B1 \3\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=9.2e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn3 (14 \6\:B1 \3\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.32e-06 sb=7.15e-07 sd=160n sca=9.69565 scb=0.00844644 \
        scc=0.000275168 m=(1)
mn2 (\1\:VSS \6\:B0 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.08e-14 ps=6.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=6.1e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn4 (\1\:Y \3\:C0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.86e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69e-06 sb=3.45e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mp1 (\5\:net104 \4\:A1 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=16.2799 \
        scb=0.0149716 scc=0.000663053 m=(2)
mp2 (net104 B0 net103 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp3 (net104 \1\:B1 \9\:net103 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\8\:Y \1\:C0 net103 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=16.4248 \
        scb=0.0152088 scc=0.000666128 m=(2)
ends AOI221X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:25:33 2012 )
// Library name: gsclib045
// Cell name: AOI221X4
// View name: extracted

simulator lang=spectre

subckt AOI221X4 A0 A1 B0 B1 C0 VDD VSS Y
mp0_1__rcx (net104 A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=22.272 \
        scb=0.025008 scc=0.00116916 m=(4)
C1 (C0 VSS) capacitor c=3.43508e-16
C2 (A0 VSS) capacitor c=6.15905e-16
C3 (A1 VSS) capacitor c=3.84743e-16
C4 (B0 VSS) capacitor c=3.63641e-17
C5 (VDD VSS) capacitor c=2.52165e-16
C6 (B1 VSS) capacitor c=4.33858e-16
C7 (Y VSS) capacitor c=1.21727e-17
C8 (12 VSS) capacitor c=1.7621e-18
C9 (13 VSS) capacitor c=1.7621e-18
C10 (14 VSS) capacitor c=1.7621e-18
C11 (15 VSS) capacitor c=4.47631e-18
C12 (16 VSS) capacitor c=5.14255e-18
C13 (17 VSS) capacitor c=3.10511e-18
C14 (18 VSS) capacitor c=2.07007e-18
C15 (net104 VSS) capacitor c=3.84643e-16
C16 (net107 VSS) capacitor c=5.05064e-16
C17 (\1\:B0 VSS) capacitor c=6.25628e-16
C18 (\12\:B0 VSS) capacitor c=5.55893e-17
C19 (\13\:B1 VSS) capacitor c=5.90859e-17
C20 (\12\:B1 VSS) capacitor c=4.08151e-17
C21 (\9\:B0 VSS) capacitor c=4.54034e-17
C22 (\8\:B0 VSS) capacitor c=2.671e-17
C23 (\7\:B1 VSS) capacitor c=2.40918e-17
C24 (\5\:B1 VSS) capacitor c=3.74762e-17
C25 (\3\:B0 VSS) capacitor c=2.93467e-17
C26 (\12\:A0 VSS) capacitor c=5.06025e-17
C27 (\8\:A1 VSS) capacitor c=6.2908e-17
C28 (\11\:A1 VSS) capacitor c=5.54627e-17
C29 (\4\:A0 VSS) capacitor c=6.61169e-17
C30 (\6\:A0 VSS) capacitor c=4.70848e-17
C31 (\1\:A1 VSS) capacitor c=6.58025e-17
C32 (\4\:A1 VSS) capacitor c=4.62066e-17
C33 (\1\:A0 VSS) capacitor c=7.53628e-17
C34 (\15\:Y VSS) capacitor c=3.13573e-16
C35 (\9\:net104 VSS) capacitor c=3.98036e-16
C36 (\1\:VDD VSS) capacitor c=2.10289e-16
C37 (\1\:Y VSS) capacitor c=1.34454e-16
C38 (\3\:Y VSS) capacitor c=1.06138e-16
C39 (\5\:Y VSS) capacitor c=9.74202e-17
C40 (\8\:Y VSS) capacitor c=9.76195e-17
C41 (\10\:Y VSS) capacitor c=6.93788e-17
C42 (\2\:A1 VSS) capacitor c=3.18665e-17
C43 (\9\:A1 VSS) capacitor c=3.39458e-17
C44 (\4\:B1 VSS) capacitor c=1.91516e-17
C45 (\7\:Y VSS) capacitor c=5.63246e-17
C46 (\14\:Y VSS) capacitor c=2.13166e-16
C47 (\4\:VDD VSS) capacitor c=2.58547e-16
Rk41 (\2\:VSS \3\:VSS) resistor r=0.05998 c=0
Rk45 (\3\:VSS \7\:VSS) resistor r=0.3381 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.1051 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.4411 c=0
Rk48 (\9\:VSS \10\:VSS) resistor r=0.2606 c=0
Rk49 (\10\:VSS \11\:VSS) resistor r=0.04995 c=0
Rk51 (\12\:VSS VSS) resistor r=0.2052 c=0
Rk50 (\11\:VSS \12\:VSS) resistor r=0.2955 c=0
Rk55 (\7\:VSS \20\:VSS) resistor r=0.1993 c=0
Rk56 (\9\:VSS \22\:VSS) resistor r=0.1993 c=0
Rk57 (\11\:VSS \24\:VSS) resistor r=0.1993 c=0
Rk58 (\12\:VSS \26\:VSS) resistor r=0.2039 c=0
Rk15 (B0 \1\:B0) resistor r=0.1258 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.7021 c=0
Rk67 (\4\:VDD VDD) resistor r=0.02964 c=0
Rk60 (\3\:VDD \4\:VDD) resistor r=0.6166 c=0
Rk20 (\1\:Y \4\:Y) resistor r=0.3923 c=0
Rk21 (\4\:Y \6\:Y) resistor r=0.5694 c=0
Rk22 (\6\:Y \7\:Y) resistor r=0.3618 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.3734 c=0
Rk24 (\9\:Y \11\:Y) resistor r=0.4686 c=0
Rk27 (\14\:Y Y) resistor r=0.003075 c=0
Rk28 (\14\:Y \15\:Y) resistor r=1.7225 c=0
Rk26 (\7\:Y \14\:Y) resistor r=0.1119 c=0
Rk11 (net104 \9\:net104) resistor r=0.4915 c=0
Rl20 (A0 \12\:A0) resistor r=41.4835 c=0
Rl9 (A0 \4\:A0) resistor r=85.3597 c=0
Rl10 (A0 \6\:A0) resistor r=39.5284 c=0
Rl1 (A0 \1\:A0) resistor r=140.362 c=0
Rl4 (\2\:A1 A1) resistor r=29.4415 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl15 (\9\:A1 A1) resistor r=6.3032 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=137.946 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=88.5249 c=0
Rl40 (\1\:B0 \12\:B0) resistor r=50.8402 c=0
Rl33 (\1\:B0 \9\:B0) resistor r=90.1033 c=0
Rl32 (\1\:B0 \8\:B0) resistor r=44.5244 c=0
Rl22 (\1\:B0 \3\:B0) resistor r=44.9225 c=0
Rl38 (B1 \13\:B1) resistor r=151.642 c=0
Rl37 (B1 \12\:B1) resistor r=106.063 c=0
Rl25 (\4\:B1 B1) resistor r=67.233 c=0
Rl28 (\4\:B1 \7\:B1) resistor r=35.772 c=0
Rl26 (\4\:B1 \5\:B1) resistor r=100.426 c=0
Rz10 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz11 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz12 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz13 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz18 (VDD \1\:VDD) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz16 (\4\:VDD \1\:VDD) resistor r=9.375 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\6\:Y \5\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\11\:Y \10\:Y) resistor r=75 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry19 (\3\:VSS \1\:VSS) resistor r=7.75 c=0
Ry20 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry21 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (11 \1\:A0 \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\10\:Y \4\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\10\:Y \1\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (12 \6\:A0 \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (13 \4\:A0 \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_2__rcx (\8\:Y \11\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\8\:Y \8\:A1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (14 \12\:A0 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=1.56e-14 ps=1.38e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (15 \3\:B0 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=4.16e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\5\:Y \5\:B1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\5\:Y \7\:B1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.885e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (16 \8\:B0 \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (17 \9\:B0 \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.73e-14 ps=8.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.475e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (\3\:Y \12\:B1 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=4.16e-14 ps=7.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.325e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\3\:Y \13\:B1 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.12e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (18 \12\:B0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=1.82e-14 ps=8.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\1\:Y C0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.517e-14 ad=4.16e-14 ps=8.675e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp1_1__rcx (net104 A1 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=16.2105 \
        scb=0.0148596 scc=0.000661709 m=(4)
mp2_1__rcx (\9\:net104 \1\:B0 net107 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp3_1__rcx (\9\:net104 B1 net107 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp4_1__rcx (\15\:Y C0 net107 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=7.55e-07 sd=160n sca=13.8524 \
        scb=0.01226 scc=0.000647526 m=(4)
ends AOI221X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:26:10 2012 )
// Library name: gsclib045
// Cell name: AOI221XL
// View name: extracted

simulator lang=spectre

subckt AOI221XL A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\3\:net104 \3\:A0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=19.0229 scb=0.0208122 \
        scc=0.00061956 m=(1)
C1 (C0 VSS) capacitor c=6.54284e-17
C2 (A1 VSS) capacitor c=5.15688e-17
C3 (VDD VSS) capacitor c=1.50251e-16
C4 (B1 VSS) capacitor c=6.9562e-17
C5 (Y VSS) capacitor c=1.35941e-17
C6 (net124 VSS) capacitor c=1.22498e-18
C7 (net104 VSS) capacitor c=1.23043e-16
C8 (net107 VSS) capacitor c=8.05378e-17
C9 (\1\:C0 VSS) capacitor c=2.40761e-17
C10 (\1\:B0 VSS) capacitor c=3.34954e-17
C11 (\1\:B1 VSS) capacitor c=3.69811e-17
C12 (\1\:A1 VSS) capacitor c=4.42418e-17
C13 (\3\:A0 VSS) capacitor c=3.21617e-17
C14 (\3\:C0 VSS) capacitor c=2.54496e-17
C15 (\3\:B0 VSS) capacitor c=4.20841e-17
C16 (\3\:B1 VSS) capacitor c=4.08635e-17
C17 (\3\:A1 VSS) capacitor c=3.76165e-17
C18 (\1\:A0 VSS) capacitor c=5.11419e-17
C19 (\2\:C0 VSS) capacitor c=3.19289e-17
C20 (\2\:B0 VSS) capacitor c=4.69123e-17
C21 (\2\:B1 VSS) capacitor c=4.1145e-17
C22 (\2\:A1 VSS) capacitor c=4.82346e-17
C23 (\2\:A0 VSS) capacitor c=4.94601e-17
C24 (\5\:Y VSS) capacitor c=2.40368e-17
C25 (\3\:net107 VSS) capacitor c=9.33844e-17
C26 (\7\:VDD VSS) capacitor c=2.48135e-17
C27 (\3\:net104 VSS) capacitor c=9.01367e-17
C28 (\9\:VDD VSS) capacitor c=3.12454e-18
C29 (\1\:VDD VSS) capacitor c=8.41914e-17
C30 (\7\:Y VSS) capacitor c=1.08577e-17
C31 (\3\:Y VSS) capacitor c=7.74456e-17
C32 (\4\:A0 VSS) capacitor c=2.40377e-17
C33 (\6\:A0 VSS) capacitor c=3.08562e-17
C34 (\4\:A1 VSS) capacitor c=3.8751e-17
C35 (\4\:B1 VSS) capacitor c=4.0049e-17
C36 (\4\:B0 VSS) capacitor c=1.16211e-16
C37 (\4\:C0 VSS) capacitor c=4.71477e-17
C38 (\1\:Y VSS) capacitor c=4.04426e-17
C39 (\2\:Y VSS) capacitor c=7.84621e-17
Rk9 (\4\:C0 C0) resistor r=0.2039 c=0
Rk4 (\4\:A1 A1) resistor r=0.2264 c=0
Rk16 (\3\:VSS VSS) resistor r=0.09707 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.3369 c=0
Rk17 (\3\:VSS \5\:VSS) resistor r=0.3523 c=0
Rk18 (\5\:VSS \7\:VSS) resistor r=0.4976 c=0
Rk1 (\4\:A0 \5\:A0) resistor r=0.004428 c=0
Rk2 (A0 \6\:A0) resistor r=0.004302 c=0
Rk3 (\4\:A0 \6\:A0) resistor r=0.0628 c=0
Rk8 (B0 \4\:B0) resistor r=0.004101 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.3323 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.1173 c=0
Rk22 (\5\:VDD VDD) resistor r=0.06706 c=0
Rk21 (\4\:VDD \5\:VDD) resistor r=0.08231 c=0
Rk24 (\3\:VDD \8\:VDD) resistor r=0.149 c=0
Rk25 (\5\:VDD \10\:VDD) resistor r=0.073 c=0
Rk5 (\4\:B1 B1) resistor r=0.1112 c=0
Rk10 (Y \1\:Y) resistor r=0.01014 c=0
Rk11 (\1\:Y \2\:Y) resistor r=0.2246 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.6366 c=0
Rk13 (\1\:Y \6\:Y) resistor r=0.2289 c=0
Rk14 (\2\:Y \8\:Y) resistor r=0.07365 c=0
Rk6 (\2\:net104 \4\:net104) resistor r=0.7271 c=0
Rk7 (\2\:net107 \4\:net107) resistor r=0.4817 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=76.9231 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=89.5604 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=135.307 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=72.3097 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=107.408 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=71.1538 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=95.6044 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=58.3841 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=106.461 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=10.7143 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:Y \8\:Y) resistor r=75 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\5\:Y \6\:Y) resistor r=62 c=0
Ry1 (net104 \2\:net104) resistor r=62 c=0
Ry2 (\3\:net104 \4\:net104) resistor r=62 c=0
Ry3 (net107 \2\:net107) resistor r=62 c=0
Ry4 (\3\:net107 \4\:net107) resistor r=62 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (net124 \1\:A0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn1 (\3\:Y \3\:A1 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=7.975e-14 ps=4.1e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.28e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn3 (\3\:Y \3\:B1 net116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.378e-14 ad=7.975e-14 ps=4.8e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=6.85e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn2 (net116 \3\:B0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=1.378e-14 ps=1.01e-06 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=5.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn4 (\7\:Y \3\:C0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.03e-14 ps=1.01e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mp1 (\3\:net104 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.04e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=14.333 scb=0.0127992 \
        scc=0.000339629 m=(1)
mp3 (net104 \1\:B1 \3\:net107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.655e-14 ps=8.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=7.9e-07 sd=160n sca=12.2475 \
        scb=0.0108235 scc=0.000332112 m=(1)
mp2 (net104 \1\:B0 net107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=3.655e-14 ps=1.11e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=5.75e-07 sd=160n sca=12.9588 \
        scb=0.011186 scc=0.000332355 m=(1)
mp4 (\5\:Y \1\:C0 net107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=4.085e-14 ps=1.11e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.9e-07 sd=160n sca=18.8069 \
        scb=0.0204563 scc=0.000595877 m=(1)
ends AOI221XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:26:48 2012 )
// Library name: gsclib045
// Cell name: AOI222X1
// View name: extracted

simulator lang=spectre

subckt AOI222X1 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (net118 \3\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.9913 \
        scb=0.020688 scc=0.00060344 m=(1)
C1 (A1 VSS) capacitor c=4.15512e-17
C2 (VDD VSS) capacitor c=1.12672e-16
C3 (A0 VSS) capacitor c=3.78787e-17
C4 (Y VSS) capacitor c=8.23593e-17
C5 (B0 VSS) capacitor c=6.71007e-17
C6 (net139 VSS) capacitor c=6.24372e-18
C7 (net147 VSS) capacitor c=1.55458e-18
C8 (net155 VSS) capacitor c=1.3325e-18
C9 (net118 VSS) capacitor c=8.14914e-17
C10 (net122 VSS) capacitor c=5.51404e-17
C11 (\1\:C1 VSS) capacitor c=5.1478e-17
C12 (\1\:C0 VSS) capacitor c=5.31362e-17
C13 (\1\:B0 VSS) capacitor c=5.14585e-17
C14 (\1\:B1 VSS) capacitor c=6.39359e-17
C15 (\1\:A1 VSS) capacitor c=6.7846e-17
C16 (\3\:A0 VSS) capacitor c=5.33201e-17
C17 (\3\:C1 VSS) capacitor c=5.94033e-17
C18 (\3\:C0 VSS) capacitor c=7.48517e-17
C19 (\3\:B0 VSS) capacitor c=7.23635e-17
C20 (\4\:B1 VSS) capacitor c=5.17647e-17
C21 (\3\:A1 VSS) capacitor c=4.96193e-17
C22 (\1\:A0 VSS) capacitor c=5.2172e-17
C23 (\2\:C1 VSS) capacitor c=5.49841e-17
C24 (\2\:C0 VSS) capacitor c=5.46038e-17
C25 (\2\:B0 VSS) capacitor c=6.788e-17
C26 (\3\:B1 VSS) capacitor c=2.39145e-17
C27 (\2\:A1 VSS) capacitor c=5.34182e-17
C28 (\2\:A0 VSS) capacitor c=4.89249e-17
C29 (\5\:Y VSS) capacitor c=6.72271e-17
C30 (\3\:net122 VSS) capacitor c=7.63446e-17
C31 (\3\:net118 VSS) capacitor c=9.71329e-17
C32 (\5\:net122 VSS) capacitor c=6.29093e-17
C33 (\7\:VDD VSS) capacitor c=4.29471e-17
C34 (\9\:VDD VSS) capacitor c=3.47057e-17
C35 (\1\:VDD VSS) capacitor c=1.00299e-16
C36 (\3\:Y VSS) capacitor c=9.95829e-17
C37 (\1\:Y VSS) capacitor c=7.42771e-17
C38 (\2\:B1 VSS) capacitor c=5.00094e-17
C39 (\4\:A0 VSS) capacitor c=3.75329e-17
C40 (\4\:A1 VSS) capacitor c=6.77519e-17
C41 (\5\:B1 VSS) capacitor c=3.21139e-17
C42 (\7\:B1 VSS) capacitor c=7.57764e-17
C43 (\4\:B0 VSS) capacitor c=5.13208e-17
C44 (\4\:C0 VSS) capacitor c=1.24053e-16
C45 (\5\:C1 VSS) capacitor c=3.8589e-17
C46 (\6\:C1 VSS) capacitor c=8.59083e-17
C47 (\3\:VDD VSS) capacitor c=2.55476e-18
C48 (\5\:VDD VSS) capacitor c=1.55461e-18
Rk5 (\5\:B1 \6\:B1) resistor r=0.002024 c=0
Rk6 (B1 \7\:B1) resistor r=0.001956 c=0
Rk7 (\5\:B1 \7\:B1) resistor r=0.09482 c=0
Rk11 (\4\:C1 \5\:C1) resistor r=0.002024 c=0
Rk12 (\6\:C1 C1) resistor r=0.002091 c=0
Rk13 (\5\:C1 \6\:C1) resistor r=0.09482 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.288 c=0
Rk21 (\5\:VSS VSS) resistor r=0.08985 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.3108 c=0
Rk22 (\5\:VSS \7\:VSS) resistor r=0.1871 c=0
Rk10 (\4\:C0 C0) resistor r=0.01234 c=0
Rk4 (A1 \4\:A1) resistor r=0.1891 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.3058 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.09512 c=0
Rk26 (\5\:VDD VDD) resistor r=0.03969 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.1102 c=0
Rk28 (\3\:VDD \8\:VDD) resistor r=0.1845 c=0
Rk29 (\5\:VDD \10\:VDD) resistor r=0.2793 c=0
Rk3 (\4\:A0 A0) resistor r=0.01803 c=0
Rk17 (\4\:Y Y) resistor r=0.4959 c=0
Rk16 (\2\:Y \4\:Y) resistor r=0.4841 c=0
Rk18 (Y \6\:Y) resistor r=0.32 c=0
Rk9 (\4\:B0 B0) resistor r=0.0767 c=0
Rk8 (\2\:net118 \4\:net118) resistor r=0.5158 c=0
Rk14 (\2\:net122 \4\:net122) resistor r=0.295 c=0
Rk15 (\4\:net122 \6\:net122) resistor r=0.295 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=152.726 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=64.2642 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=14.8815 c=0
Rl12 (\1\:C1 \2\:C1) resistor r=143.464 c=0
Rl13 (\2\:C1 \3\:C1) resistor r=79.2614 c=0
Rl10 (\1\:C0 \2\:C0) resistor r=79.5379 c=0
Rl11 (\2\:C0 \3\:C0) resistor r=121.846 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=171.846 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=157.487 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=65.782 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=137.637 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=12.5 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:Y \6\:Y) resistor r=62 c=0
Ry1 (net118 \2\:net118) resistor r=31 c=0
Ry2 (\3\:net118 \4\:net118) resistor r=62 c=0
Ry3 (net122 \2\:net122) resistor r=62 c=0
Ry4 (\3\:net122 \4\:net122) resistor r=62 c=0
Ry5 (\5\:net122 \6\:net122) resistor r=62 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net139 \1\:A0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (net147 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=1.82e-14 ps=1.02e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.4e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (\1\:Y \3\:A1 net139 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=9.36e-14 ps=6.4e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.06e-06 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn3 (\1\:Y \4\:B1 net147 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=9.36e-14 ps=6.6e-07 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=6.55e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn4 (net155 \3\:C0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=2.45e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn5 (\3\:Y \3\:C1 net155 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mp1 (net118 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.7713 \
        scb=0.0118072 scc=0.000241734 m=(1)
mp3 (\3\:net118 \1\:B1 \5\:net122 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=11.6444 \
        scb=0.00959467 scc=0.000231862 m=(1)
mp2 (\3\:net118 \1\:B0 \3\:net122 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=12.1511 \
        scb=0.00987528 scc=0.000232041 m=(1)
mp4 (\5\:Y \1\:C0 \3\:net122 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=13.6523 \
        scb=0.011626 scc=0.000240092 m=(1)
mp5 (\5\:Y \1\:C1 net122 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=18.5104 \
        scb=0.0199204 scc=0.000545053 m=(1)
ends AOI222X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:27:26 2012 )
// Library name: gsclib045
// Cell name: AOI222X2
// View name: extracted

simulator lang=spectre

subckt AOI222X2 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (net134 \2\:A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=18.3639 \
        scb=0.0185931 scc=0.000748758 m=(2)
C1 (B1 VSS) capacitor c=3.47351e-17
C2 (C0 VSS) capacitor c=2.82593e-17
C3 (A0 VSS) capacitor c=2.46865e-17
C4 (C1 VSS) capacitor c=5.92283e-17
C5 (VDD VSS) capacitor c=1.64448e-16
C6 (A1 VSS) capacitor c=6.0549e-17
C7 (Y VSS) capacitor c=1.63164e-16
C8 (B0 VSS) capacitor c=3.72591e-16
C9 (13 VSS) capacitor c=1.68035e-18
C10 (14 VSS) capacitor c=3.13109e-18
C11 (15 VSS) capacitor c=2.99523e-18
C12 (16 VSS) capacitor c=2.87924e-18
C13 (net134 VSS) capacitor c=2.13131e-16
C14 (net126 VSS) capacitor c=3.20484e-16
C15 (\1\:C1 VSS) capacitor c=1.04297e-16
C16 (\1\:C0 VSS) capacitor c=3.11425e-16
C17 (\1\:B1 VSS) capacitor c=8.64668e-17
C18 (\6\:C0 VSS) capacitor c=5.56767e-17
C19 (\4\:C1 VSS) capacitor c=4.71963e-17
C20 (\6\:C1 VSS) capacitor c=4.64191e-17
C21 (\3\:C0 VSS) capacitor c=4.75814e-17
C22 (\6\:B0 VSS) capacitor c=4.78464e-17
C23 (\7\:B1 VSS) capacitor c=4.54012e-17
C24 (\5\:B1 VSS) capacitor c=3.08947e-17
C25 (\3\:B0 VSS) capacitor c=3.92133e-17
C26 (\6\:A0 VSS) capacitor c=5.49742e-17
C27 (\1\:A1 VSS) capacitor c=5.06685e-17
C28 (\6\:A1 VSS) capacitor c=4.79998e-17
C29 (\1\:A0 VSS) capacitor c=5.30941e-17
C30 (\3\:B1 VSS) capacitor c=1.8284e-17
C31 (\3\:A1 VSS) capacitor c=1.69201e-17
C32 (\2\:A0 VSS) capacitor c=3.19928e-16
C33 (\8\:net126 VSS) capacitor c=2.96264e-18
C34 (\8\:Y VSS) capacitor c=2.14734e-16
C35 (\12\:net126 VSS) capacitor c=4.09942e-18
C36 (\5\:net134 VSS) capacitor c=2.25913e-16
C37 (\9\:VDD VSS) capacitor c=4.27713e-17
C38 (\1\:VDD VSS) capacitor c=1.29276e-16
C39 (\1\:Y VSS) capacitor c=8.72852e-17
C40 (\3\:Y VSS) capacitor c=1.05559e-16
C41 (\6\:Y VSS) capacitor c=6.40273e-17
C42 (\2\:A1 VSS) capacitor c=4.03646e-17
C43 (\4\:A1 VSS) capacitor c=9.02082e-17
C44 (\4\:B1 VSS) capacitor c=3.37444e-17
C45 (\3\:C1 VSS) capacitor c=2.79323e-17
C46 (\9\:B1 VSS) capacitor c=1.08519e-16
C47 (\5\:Y VSS) capacitor c=7.29549e-17
C48 (\4\:VDD VSS) capacitor c=1.22679e-16
Rk11 (B1 \9\:B1) resistor r=0.01466 c=0
Rk20 (\1\:C0 C0) resistor r=0.02444 c=0
Rk28 (\2\:VSS \4\:VSS) resistor r=0.2926 c=0
Rk29 (\4\:VSS \5\:VSS) resistor r=0.3256 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.4759 c=0
Rk31 (\6\:VSS \7\:VSS) resistor r=0.06245 c=0
Rk33 (\8\:VSS VSS) resistor r=0.1775 c=0
Rk32 (\7\:VSS \8\:VSS) resistor r=0.3103 c=0
Rk34 (\5\:VSS \10\:VSS) resistor r=0.1882 c=0
Rk35 (\7\:VSS \12\:VSS) resistor r=0.1882 c=0
Rk36 (\8\:VSS \14\:VSS) resistor r=0.2293 c=0
Rk3 (\2\:A0 A0) resistor r=0.1022 c=0
Rk12 (\7\:C1 C1) resistor r=0.005083 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.6515 c=0
Rk44 (\4\:VDD VDD) resistor r=0.1006 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.3782 c=0
Rk42 (\4\:VDD \10\:VDD) resistor r=0.2216 c=0
Rk1 (A1 \8\:A1) resistor r=0.004597 c=0
Rk17 (Y \8\:Y) resistor r=0.9775 c=0
Rk13 (\2\:Y \4\:Y) resistor r=0.6027 c=0
Rk16 (\5\:Y Y) resistor r=0.234 c=0
Rk14 (\4\:Y \5\:Y) resistor r=0.3576 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.4032 c=0
Rk5 (net134 \5\:net134) resistor r=0.5745 c=0
Rk25 (net126 \9\:net126) resistor r=0.0153 c=0
Rk27 (net126 \13\:net126) resistor r=0.0153 c=0
Rl14 (\1\:B1 \3\:B1) resistor r=9.6652 c=0
Rl18 (\4\:B1 \7\:B1) resistor r=82.1768 c=0
Rl16 (\4\:B1 \5\:B1) resistor r=32.7557 c=0
Rl15 (\4\:B1 \3\:B1) resistor r=23.3085 c=0
Rl29 (\1\:C0 \6\:C0) resistor r=65.3618 c=0
Rl22 (\1\:C0 \3\:C0) resistor r=29.5379 c=0
Rl10 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=49.5597 c=0
Rl24 (\3\:C1 \1\:C1) resistor r=23.8563 c=0
Rl25 (\3\:C1 \4\:C1) resistor r=32.7557 c=0
Rl27 (\3\:C1 \6\:C1) resistor r=82.1768 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=64.2686 c=0
Rl7 (\2\:A1 \6\:A1) resistor r=31.8259 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=19.3454 c=0
Rl5 (\4\:A1 \3\:A1) resistor r=5.8921 c=0
Rl20 (B0 \6\:B0) resistor r=24.7951 c=0
Rl12 (B0 \3\:B0) resistor r=29.5379 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz9 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz10 (\4\:VDD \1\:VDD) resistor r=25 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry13 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry15 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\9\:net126 \8\:net126) resistor r=62 c=0
Ry11 (\13\:net126 \12\:net126) resistor r=62 c=0
Rx6 (\9\:B1 \3\:B1) resistor r=45 c=0
Rx7 (\7\:C1 \1\:C1) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
mn0 (12 \1\:A0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\6\:Y \6\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\6\:Y \1\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0_1__rcx (13 \6\:A0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.418e-13 ad=1.56e-14 ps=1.67e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.99e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (14 \3\:B0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.418e-13 ad=2.99e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.425e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (\3\:Y \5\:B1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.28e-06 sb=1.265e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_1__rcx (\3\:Y \7\:B1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.6e-14 ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=1.06e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_1__rcx (15 \6\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.81e-14 ad=2.6e-14 ps=1.18e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=9.15e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (16 \3\:C0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.81e-14 ad=2.6e-14 ps=1.18e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=5.95e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn5 (\1\:Y \6\:C1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.6e-14 \
        ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn5_1__rcx (\1\:Y \4\:C1 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn4_1__rcx (17 \6\:C0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (net134 \4\:A1 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=15.1941 \
        scb=0.0133849 scc=0.00065002 m=(2)
mp2 (\5\:net134 B0 net126 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.435e-14 ps=1.08e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.585e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp3 (\5\:net134 \1\:B1 \12\:net126 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.37e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\8\:Y \1\:C0 net126 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=7.55e-07 sd=160n sca=13.8663 \
        scb=0.0122652 scc=0.000647528 m=(2)
mp5 (\8\:Y \1\:C1 \8\:net126 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=5.5e-07 sd=160n sca=14.7281 \
        scb=0.0128603 scc=0.000648267 m=(2)
ends AOI222X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:28:05 2012 )
// Library name: gsclib045
// Cell name: AOI222X4
// View name: extracted

simulator lang=spectre

subckt AOI222X4 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0_1__rcx (\9\:net122 A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=21.9778 \
        scb=0.0245713 scc=0.00112692 m=(4)
C1 (B1 VSS) capacitor c=4.26363e-16
C2 (C0 VSS) capacitor c=6.49689e-16
C3 (A0 VSS) capacitor c=6.42044e-16
C4 (C1 VSS) capacitor c=4.32849e-16
C5 (VDD VSS) capacitor c=2.9221e-16
C6 (A1 VSS) capacitor c=2.13749e-17
C7 (Y VSS) capacitor c=1.08316e-17
C8 (B0 VSS) capacitor c=3.83607e-17
C9 (13 VSS) capacitor c=1.75543e-18
C10 (14 VSS) capacitor c=1.75543e-18
C11 (15 VSS) capacitor c=1.75543e-18
C12 (16 VSS) capacitor c=3.05999e-18
C13 (17 VSS) capacitor c=1.75543e-18
C14 (18 VSS) capacitor c=9.86637e-18
C15 (19 VSS) capacitor c=4.50319e-18
C16 (20 VSS) capacitor c=3.05317e-18
C17 (21 VSS) capacitor c=1.75543e-18
C18 (22 VSS) capacitor c=2.07885e-18
C19 (net122 VSS) capacitor c=3.99026e-16
C20 (net130 VSS) capacitor c=6.10433e-16
C21 (\1\:B0 VSS) capacitor c=6.59737e-16
C22 (\12\:C0 VSS) capacitor c=6.85191e-17
C23 (\13\:C1 VSS) capacitor c=4.71552e-17
C24 (\11\:C1 VSS) capacitor c=6.61577e-17
C25 (\8\:C0 VSS) capacitor c=4.75284e-17
C26 (\9\:C0 VSS) capacitor c=6.43546e-17
C27 (\4\:C1 VSS) capacitor c=5.34196e-17
C28 (\6\:C1 VSS) capacitor c=4.64111e-17
C29 (\3\:C0 VSS) capacitor c=4.46007e-17
C30 (\12\:B0 VSS) capacitor c=3.7638e-17
C31 (\13\:B1 VSS) capacitor c=3.72475e-17
C32 (\12\:B1 VSS) capacitor c=1.80572e-17
C33 (\8\:B0 VSS) capacitor c=1.99724e-17
C34 (\9\:B0 VSS) capacitor c=6.52895e-17
C35 (\6\:B1 VSS) capacitor c=4.5703e-17
C36 (\4\:B1 VSS) capacitor c=4.89836e-17
C37 (\3\:B0 VSS) capacitor c=3.31608e-17
C38 (\12\:A0 VSS) capacitor c=4.86412e-17
C39 (\8\:A1 VSS) capacitor c=6.06902e-17
C40 (\11\:A1 VSS) capacitor c=5.35802e-17
C41 (\4\:A0 VSS) capacitor c=6.52752e-17
C42 (\8\:A0 VSS) capacitor c=4.58101e-17
C43 (\1\:A1 VSS) capacitor c=6.52722e-17
C44 (\4\:A1 VSS) capacitor c=4.69371e-17
C45 (\1\:A0 VSS) capacitor c=5.49671e-17
C46 (\3\:A1 VSS) capacitor c=3.73357e-16
C47 (\15\:Y VSS) capacitor c=4.3318e-16
C48 (\9\:net122 VSS) capacitor c=3.93853e-16
C49 (\1\:VDD VSS) capacitor c=2.68945e-16
C50 (\12\:Y VSS) capacitor c=6.83851e-17
C51 (\1\:Y VSS) capacitor c=1.30685e-16
C52 (\3\:Y VSS) capacitor c=1.41916e-16
C53 (\5\:Y VSS) capacitor c=1.26983e-16
C54 (\8\:Y VSS) capacitor c=1.06186e-16
C55 (\10\:Y VSS) capacitor c=7.54124e-17
C56 (\2\:A1 VSS) capacitor c=2.80048e-17
C57 (\9\:A1 VSS) capacitor c=3.24257e-17
C58 (\3\:B1 VSS) capacitor c=2.40179e-17
C59 (\11\:B1 VSS) capacitor c=1.46614e-17
C60 (\3\:C1 VSS) capacitor c=3.52925e-17
C61 (\10\:C1 VSS) capacitor c=2.7734e-17
C62 (\7\:Y VSS) capacitor c=6.28143e-17
C63 (\14\:Y VSS) capacitor c=2.4592e-16
C64 (\4\:VDD VSS) capacitor c=2.73547e-16
Rk51 (\2\:VSS \3\:VSS) resistor r=0.1652 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.03489 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.2905 c=0
Rk54 (\5\:VSS \6\:VSS) resistor r=0.3613 c=0
Rk55 (\3\:VSS \8\:VSS) resistor r=0.223 c=0
Rk56 (\5\:VSS \10\:VSS) resistor r=0.2184 c=0
Rk57 (\6\:VSS \11\:VSS) resistor r=0.4584 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.4833 c=0
Rk59 (\12\:VSS \13\:VSS) resistor r=0.2604 c=0
Rk60 (\13\:VSS \14\:VSS) resistor r=0.04993 c=0
Rk62 (\15\:VSS VSS) resistor r=0.2051 c=0
Rk61 (\14\:VSS \15\:VSS) resistor r=0.2953 c=0
Rk63 (\6\:VSS \17\:VSS) resistor r=0.2645 c=0
Rk64 (\11\:VSS \19\:VSS) resistor r=0.2184 c=0
Rk65 (\12\:VSS \21\:VSS) resistor r=0.2184 c=0
Rk66 (\14\:VSS \23\:VSS) resistor r=0.2184 c=0
Rk67 (\15\:VSS \25\:VSS) resistor r=0.223 c=0
Rk68 (\2\:VDD \3\:VDD) resistor r=0.9523 c=0
Rk76 (\4\:VDD VDD) resistor r=0.03213 c=0
Rk69 (\3\:VDD \4\:VDD) resistor r=0.6138 c=0
Rk2 (\3\:A1 A1) resistor r=0.02665 c=0
Rk21 (\2\:Y \4\:Y) resistor r=0.5586 c=0
Rk22 (\4\:Y \6\:Y) resistor r=0.641 c=0
Rk23 (\6\:Y \7\:Y) resistor r=0.3405 c=0
Rk24 (\7\:Y \9\:Y) resistor r=0.3668 c=0
Rk25 (\9\:Y \11\:Y) resistor r=0.4668 c=0
Rk26 (\2\:Y \13\:Y) resistor r=0.4605 c=0
Rk28 (\14\:Y Y) resistor r=0.00307 c=0
Rk29 (\14\:Y \15\:Y) resistor r=1.6097 c=0
Rk27 (\7\:Y \14\:Y) resistor r=0.2256 c=0
Rk18 (\1\:B0 B0) resistor r=0.1119 c=0
Rk11 (net122 \9\:net122) resistor r=0.501 c=0
Rl24 (\3\:B1 B1) resistor r=48.1957 c=0
Rl27 (\3\:B1 \6\:B1) resistor r=34.9276 c=0
Rl25 (\3\:B1 \4\:B1) resistor r=97.2646 c=0
Rl36 (\11\:B1 B1) resistor r=55.6945 c=0
Rl38 (\11\:B1 \13\:B1) resistor r=100.426 c=0
Rl37 (\11\:B1 \12\:B1) resistor r=35.772 c=0
Rl60 (C0 \12\:C0) resistor r=101.421 c=0
Rl51 (C0 \8\:C0) resistor r=28.5806 c=0
Rl52 (C0 \9\:C0) resistor r=84.3341 c=0
Rl42 (C0 \3\:C0) resistor r=29.9442 c=0
Rl20 (A0 \12\:A0) resistor r=33.7912 c=0
Rl9 (A0 \4\:A0) resistor r=82.4994 c=0
Rl12 (A0 \8\:A0) resistor r=33.1976 c=0
Rl1 (A0 \1\:A0) resistor r=67.0977 c=0
Rl44 (\3\:C1 C1) resistor r=6.3032 c=0
Rl45 (\3\:C1 \4\:C1) resistor r=76.9865 c=0
Rl47 (\3\:C1 \6\:C1) resistor r=126.408 c=0
Rl55 (\10\:C1 C1) resistor r=24.9043 c=0
Rl58 (\10\:C1 \13\:C1) resistor r=32.7557 c=0
Rl56 (\10\:C1 \11\:C1) resistor r=82.1768 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=82.1768 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.7557 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=24.6542 c=0
Rl14 (\9\:A1 \8\:A1) resistor r=126.408 c=0
Rl16 (\9\:A1 \11\:A1) resistor r=76.9865 c=0
Rl15 (\9\:A1 \3\:A1) resistor r=6.3032 c=0
Rl40 (\1\:B0 \12\:B0) resistor r=33.3841 c=0
Rl31 (\1\:B0 \8\:B0) resistor r=28.5806 c=0
Rl32 (\1\:B0 \9\:B0) resistor r=84.3341 c=0
Rl22 (\1\:B0 \3\:B0) resistor r=33.3841 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz10 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz11 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz12 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz13 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz18 (VDD \1\:VDD) resistor r=75 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz16 (\4\:VDD \1\:VDD) resistor r=9.375 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\6\:Y \5\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\11\:Y \10\:Y) resistor r=75 c=0
Rz6 (\13\:Y \12\:Y) resistor r=75 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry25 (\1\:VSS \13\:VSS) resistor r=5.1667 c=0
mn0 (12 \1\:A0 \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (\10\:Y \4\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (\10\:Y \1\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn0_1__rcx (13 \8\:A0 \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_2__rcx (14 \4\:A0 \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_2__rcx (\8\:Y \11\:A1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_3__rcx (\8\:Y \8\:A1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_3__rcx (\3\:Y \12\:B1 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.84e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (15 \12\:A0 \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.17e-13 ad=1.56e-14 ps=1.42e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (16 \3\:B0 \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.17e-13 ad=2.99e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_1__rcx (\1\:Y \4\:C1 21 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.65e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (\5\:Y \4\:B1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=2e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_2__rcx (\5\:Y \6\:B1 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_2__rcx (17 \9\:B0 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_3__rcx (18 \8\:B0 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=7.93e-14 ps=8.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn3 (\3\:Y \13\:B1 19 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.635e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2 (19 \12\:B0 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.43e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4 (20 \3\:C0 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.86e-14 ps=8.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.225e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5 (\1\:Y \6\:C1 20 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.86e-14 \
        ad=4.16e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=1.07e-06 sd=160n sca=10.3222 scb=0.00938145 scc=0.000353946 \
        m=(1)
mn4_1__rcx (21 \9\:C0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.6e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn4_2__rcx (22 \8\:C0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn5_2__rcx (\12\:Y \11\:C1 22 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn5_3__rcx (\12\:Y \13\:C1 23 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4_3__rcx (23 \12\:C0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mp1_1__rcx (\9\:net122 \3\:A1 \4\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n \
        sca=16.1431 scb=0.0147518 scc=0.000660481 m=(4)
mp2_1__rcx (net122 \1\:B0 net130 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp3_1__rcx (net122 B1 net130 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp4_1__rcx (\15\:Y C0 net130 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp5_1__rcx (\15\:Y C1 net130 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.37e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
ends AOI222X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:28:42 2012 )
// Library name: gsclib045
// Cell name: AOI222XL
// View name: extracted

simulator lang=spectre

subckt AOI222XL A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (\3\:net122 \3\:A0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.44e-14 ad=3.977e-14 ps=1.75e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.3e-07 sd=160n sca=43.6839 scb=0.0409846 \
        scc=0.00506402 m=(1)
C1 (B1 VSS) capacitor c=6.49188e-17
C2 (C1 VSS) capacitor c=6.92633e-17
C3 (C0 VSS) capacitor c=8.90889e-17
C4 (A1 VSS) capacitor c=6.02464e-17
C5 (VDD VSS) capacitor c=1.53049e-16
C6 (A0 VSS) capacitor c=3.95014e-17
C7 (Y VSS) capacitor c=9.16305e-17
C8 (B0 VSS) capacitor c=3.50728e-17
C9 (net147 VSS) capacitor c=5.71964e-18
C10 (net155 VSS) capacitor c=3.97139e-18
C11 (net122 VSS) capacitor c=1.09689e-16
C12 (net134 VSS) capacitor c=1.90307e-17
C13 (\1\:C1 VSS) capacitor c=3.2969e-17
C14 (\1\:C0 VSS) capacitor c=6.03424e-17
C15 (\1\:B0 VSS) capacitor c=4.41776e-17
C16 (\1\:B1 VSS) capacitor c=5.29784e-17
C17 (\1\:A1 VSS) capacitor c=4.70908e-17
C18 (\3\:A0 VSS) capacitor c=3.35547e-17
C19 (\3\:C1 VSS) capacitor c=6.01852e-17
C20 (\3\:C0 VSS) capacitor c=3.80588e-17
C21 (\3\:B0 VSS) capacitor c=5.22708e-17
C22 (\3\:B1 VSS) capacitor c=3.41203e-17
C23 (\3\:A1 VSS) capacitor c=2.94979e-17
C24 (\1\:A0 VSS) capacitor c=4.11024e-17
C25 (\2\:C1 VSS) capacitor c=5.01671e-17
C26 (\2\:C0 VSS) capacitor c=6.38889e-17
C27 (\2\:B0 VSS) capacitor c=5.31909e-17
C28 (\2\:B1 VSS) capacitor c=4.34547e-17
C29 (\2\:A1 VSS) capacitor c=3.94947e-17
C30 (\2\:A0 VSS) capacitor c=4.17712e-17
C31 (\4\:net134 VSS) capacitor c=5.98812e-17
C32 (\1\:Y VSS) capacitor c=9.62512e-17
C33 (\6\:net134 VSS) capacitor c=6.05544e-17
C34 (\7\:VDD VSS) capacitor c=7.52958e-18
C35 (\3\:net122 VSS) capacitor c=5.19962e-17
C36 (\9\:VDD VSS) capacitor c=3.27075e-18
C37 (\1\:VDD VSS) capacitor c=7.44115e-17
C38 (\3\:Y VSS) capacitor c=8.37465e-17
C39 (\5\:Y VSS) capacitor c=7.28711e-17
C40 (\4\:A0 VSS) capacitor c=3.7135e-17
C41 (\4\:A1 VSS) capacitor c=3.60721e-17
C42 (\4\:B1 VSS) capacitor c=3.91336e-17
C43 (\4\:B0 VSS) capacitor c=8.81558e-17
C44 (\4\:C0 VSS) capacitor c=4.4051e-17
C45 (\4\:C1 VSS) capacitor c=5.99924e-17
C46 (\3\:net134 VSS) capacitor c=4.76511e-17
C47 (\5\:VDD VSS) capacitor c=7.57753e-19
Rk3 (\4\:B1 B1) resistor r=0.07088 c=0
Rk7 (C1 \4\:C1) resistor r=0.112 c=0
Rk6 (C0 \4\:C0) resistor r=0.09829 c=0
Rk2 (\4\:A1 A1) resistor r=0.1778 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.3507 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.1001 c=0
Rk22 (\5\:VDD VDD) resistor r=0.03715 c=0
Rk21 (\4\:VDD \5\:VDD) resistor r=0.1126 c=0
Rk24 (\3\:VDD \8\:VDD) resistor r=0.07346 c=0
Rk25 (\5\:VDD \10\:VDD) resistor r=0.07346 c=0
Rk1 (\4\:A0 A0) resistor r=0.191 c=0
Rk11 (\2\:Y Y) resistor r=0.6536 c=0
Rk12 (Y \4\:Y) resistor r=0.2087 c=0
Rk13 (\4\:Y \6\:Y) resistor r=0.5987 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.1719 c=0
Rk16 (\5\:VSS VSS) resistor r=0.05469 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.4459 c=0
Rk18 (\5\:VSS \8\:VSS) resistor r=0.1798 c=0
Rk5 (B0 \4\:B0) resistor r=0.06743 c=0
Rk4 (\2\:net122 \4\:net122) resistor r=0.4783 c=0
Rk8 (\2\:net134 \3\:net134) resistor r=0.04758 c=0
Rk9 (\3\:net134 \5\:net134) resistor r=0.3715 c=0
Rk10 (\3\:net134 \7\:net134) resistor r=0.3269 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=156.461 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=83.3841 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=71.1538 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=170.604 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=210.307 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=29.5379 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=152.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=95.6044 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=88.4615 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=97.872 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=134.603 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=10.7143 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\5\:Y \6\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\7\:VSS \8\:VSS) resistor r=75 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\1\:Y \2\:Y) resistor r=62 c=0
Ry8 (\3\:VSS VSS) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry1 (net122 \2\:net122) resistor r=62 c=0
Ry2 (\3\:net122 \4\:net122) resistor r=62 c=0
Ry3 (net134 \2\:net134) resistor r=62 c=0
Ry4 (\4\:net134 \5\:net134) resistor r=62 c=0
Ry5 (\6\:net134 \7\:net134) resistor r=62 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net139 \1\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.595e-14 ps=5.7e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (\5\:Y \3\:A1 net139 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=7.395e-14 ps=5.1e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=1.315e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn3 (\5\:Y \3\:B1 net147 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=7.395e-14 ps=5.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=7.6e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn2 (net147 \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.175e-14 ps=1.05e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=5.65e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn4 (net155 \3\:C0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.668e-14 ps=1.05e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=3e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn5 (\3\:Y \3\:C1 net155 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mp1 (\3\:net122 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.44e-14 ad=3.977e-14 ps=1.75e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1e-07 sd=160n sca=35.9206 scb=0.0284699 \
        scc=0.00428553 m=(1)
mp3 (net122 \1\:B1 \6\:net134 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp2 (net122 \1\:B0 net134 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.44e-14 ps=8.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=13.1974 \
        scb=0.0118569 scc=0.000425239 m=(1)
mp4 (\1\:Y \1\:C0 net134 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=4.085e-14 ps=8.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=3.75e-07 sd=160n sca=14.7565 scb=0.0134564 \
        scc=0.00043091 m=(1)
mp5 (\1\:Y \1\:C1 \4\:net134 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.085e-14 ps=7.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=20.3151 \
        scb=0.022841 scc=0.000796775 m=(1)
ends AOI222XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:01:25 2012 )
// Library name: gsclib045
// Cell name: AOI22X1
// View name: extracted

simulator lang=spectre

subckt AOI22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=5.46e-14 ps=1.44e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=25.383 \
        scb=0.0290112 scc=0.00169816 m=(1)
C1 (B1 VSS) capacitor c=2.44604e-17
C2 (Y VSS) capacitor c=7.86073e-17
C3 (VDD VSS) capacitor c=8.57015e-17
C4 (A0 VSS) capacitor c=7.35516e-17
C5 (B0 VSS) capacitor c=3.48235e-17
C6 (net102 VSS) capacitor c=2.43791e-18
C7 (net89 VSS) capacitor c=5.34498e-17
C8 (\1\:B0 VSS) capacitor c=5.46265e-17
C9 (\1\:B1 VSS) capacitor c=5.68589e-17
C10 (\1\:A1 VSS) capacitor c=8.202e-17
C11 (\1\:A0 VSS) capacitor c=6.87969e-17
C12 (\3\:B0 VSS) capacitor c=4.189e-17
C13 (\3\:B1 VSS) capacitor c=5.40722e-17
C14 (\3\:A1 VSS) capacitor c=3.99751e-17
C15 (\4\:A0 VSS) capacitor c=4.32286e-17
C16 (\2\:B0 VSS) capacitor c=5.09864e-17
C17 (\2\:B1 VSS) capacitor c=5.53738e-17
C18 (\2\:A1 VSS) capacitor c=6.18703e-17
C19 (\3\:A0 VSS) capacitor c=1.69313e-17
C20 (\1\:Y VSS) capacitor c=8.59762e-17
C21 (\3\:net89 VSS) capacitor c=9.50726e-17
C22 (\5\:VDD VSS) capacitor c=4.79117e-17
C23 (\5\:net89 VSS) capacitor c=4.34788e-17
C24 (\1\:VDD VSS) capacitor c=4.60398e-17
C25 (\3\:Y VSS) capacitor c=1.06093e-16
C26 (\2\:A0 VSS) capacitor c=3.84168e-17
C27 (\4\:A1 VSS) capacitor c=4.08718e-17
C28 (\5\:A1 VSS) capacitor c=4.94804e-17
C29 (\4\:B1 VSS) capacitor c=7.18194e-17
C30 (\4\:B0 VSS) capacitor c=3.53857e-17
C31 (\3\:VDD VSS) capacitor c=3.69618e-18
Rk5 (B1 \4\:B1) resistor r=0.03079 c=0
Rk6 (\2\:Y Y) resistor r=0.2428 c=0
Rk7 (Y \4\:Y) resistor r=0.5393 c=0
Rk2 (A1 \4\:A1) resistor r=0.004076 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.06597 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.004196 c=0
Rk12 (\4\:VSS VSS) resistor r=0.2507 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.3583 c=0
Rk13 (VSS \6\:VSS) resistor r=0.2284 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.247 c=0
Rk16 (\4\:VDD VDD) resistor r=0.04987 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.05148 c=0
Rk17 (\3\:VDD \6\:VDD) resistor r=0.1285 c=0
Rk1 (A0 \5\:A0) resistor r=0.00426 c=0
Rk10 (\4\:B0 B0) resistor r=0.03383 c=0
Rk8 (\2\:net89 \4\:net89) resistor r=0.4624 c=0
Rk9 (\4\:net89 \6\:net89) resistor r=0.4119 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=98.0568 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=94.2107 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=171.131 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=152.726 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=60.4181 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.013 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=144.231 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=54.9451 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=20.6667 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=31 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=31 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net102 \4\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.99e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:Y \3\:A1 net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=5.46e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=5.5e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
mn3 (\3\:Y \3\:B1 net98 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=5.46e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net98 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.86e-14 ps=8e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (\3\:net89 \1\:A1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=6.435e-14 ps=1.44e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.6e-07 sd=160n sca=15.7692 \
        scb=0.0144715 scc=0.000333573 m=(1)
mp3 (\1\:Y \1\:B1 \3\:net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.435e-14 ps=1.11e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.5e-07 sd=160n sca=14.4126 \
        scb=0.011746 scc=0.00029444 m=(1)
mp2 (\1\:Y \1\:B0 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.4e-07 sd=160n sca=16.4371 \
        scb=0.0157949 scc=0.000369535 m=(1)
ends AOI22X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:29:56 2012 )
// Library name: gsclib045
// Cell name: AOI22X2
// View name: extracted

simulator lang=spectre

subckt AOI22X2 A0 A1 B0 B1 VDD VSS Y
mp0 (net89 \2\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=9.262e-14 ps=1.19e-06 pd=1.255e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.84e-06 sd=160n sca=31.4293 \
        scb=0.0302361 scc=0.00287283 m=(2)
C1 (B1 VSS) capacitor c=5.73807e-17
C2 (Y VSS) capacitor c=3.79393e-17
C3 (A0 VSS) capacitor c=2.38564e-17
C4 (B0 VSS) capacitor c=3.79991e-17
C5 (VDD VSS) capacitor c=8.4173e-17
C6 (10 VSS) capacitor c=1.596e-18
C7 (11 VSS) capacitor c=3.31755e-18
C8 (net89 VSS) capacitor c=2.40607e-16
C9 (\1\:B1 VSS) capacitor c=9.58827e-17
C10 (\1\:B0 VSS) capacitor c=3.12938e-16
C11 (\6\:B0 VSS) capacitor c=3.71983e-17
C12 (\6\:B1 VSS) capacitor c=3.45292e-17
C13 (\4\:B1 VSS) capacitor c=4.76902e-17
C14 (\3\:B0 VSS) capacitor c=4.05831e-17
C15 (\6\:A0 VSS) capacitor c=5.76594e-17
C16 (\1\:A1 VSS) capacitor c=5.62756e-17
C17 (\4\:A1 VSS) capacitor c=5.13875e-17
C18 (\1\:A0 VSS) capacitor c=5.02193e-17
C19 (\3\:A1 VSS) capacitor c=9.8036e-17
C20 (\2\:A0 VSS) capacitor c=3.17072e-16
C21 (\1\:Y VSS) capacitor c=1.97565e-16
C22 (\3\:net89 VSS) capacitor c=1.11955e-16
C23 (\10\:net89 VSS) capacitor c=3.47459e-17
C24 (\1\:VDD VSS) capacitor c=4.66289e-17
C25 (\9\:Y VSS) capacitor c=5.09876e-17
C26 (\7\:Y VSS) capacitor c=5.37193e-17
C27 (\2\:A1 VSS) capacitor c=3.68135e-17
C28 (\3\:B1 VSS) capacitor c=1.85469e-17
C29 (\7\:A1 VSS) capacitor c=2.888e-17
C30 (\9\:A1 VSS) capacitor c=3.71019e-17
C31 (\8\:B1 VSS) capacitor c=2.80036e-17
C32 (\5\:Y VSS) capacitor c=4.40246e-17
C33 (\6\:Y VSS) capacitor c=7.11498e-17
C34 (\3\:VDD VSS) capacitor c=1.08836e-16
Rk6 (\7\:B1 \8\:B1) resistor r=0.001097 c=0
Rk7 (\9\:B1 B1) resistor r=0.001206 c=0
Rk8 (\8\:B1 \9\:B1) resistor r=0.03292 c=0
Rk13 (\5\:Y Y) resistor r=0.06149 c=0
Rk10 (\1\:Y \5\:Y) resistor r=0.2738 c=0
Rk11 (\5\:Y \6\:Y) resistor r=0.2504 c=0
Rk12 (\6\:Y \8\:Y) resistor r=0.3232 c=0
Rk14 (\6\:Y \10\:Y) resistor r=0.3095 c=0
Rk5 (\2\:A0 A0) resistor r=0.1194 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.06245 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.4481 c=0
Rk24 (\4\:VSS \5\:VSS) resistor r=0.0399 c=0
Rk26 (\6\:VSS VSS) resistor r=0.18 c=0
Rk25 (\5\:VSS \6\:VSS) resistor r=0.2704 c=0
Rk27 (\3\:VSS \8\:VSS) resistor r=0.2293 c=0
Rk28 (\4\:VSS \10\:VSS) resistor r=0.165 c=0
Rk29 (\6\:VSS \12\:VSS) resistor r=0.2293 c=0
Rk1 (\7\:A1 \8\:A1) resistor r=0.001293 c=0
Rk2 (A1 \9\:A1) resistor r=0.001164 c=0
Rk3 (\7\:A1 \9\:A1) resistor r=0.0225 c=0
Rk20 (B0 \1\:B0) resistor r=0.1831 c=0
Rk30 (\2\:VDD \3\:VDD) resistor r=0.2569 c=0
Rk33 (\5\:VDD VDD) resistor r=0.04986 c=0
Rk32 (\3\:VDD \5\:VDD) resistor r=0.0875 c=0
Rk19 (net89 \11\:net89) resistor r=0.06242 c=0
Rl13 (\3\:B1 \1\:B1) resistor r=13.5863 c=0
Rl16 (\3\:B1 \6\:B1) resistor r=32.2187 c=0
Rl14 (\3\:B1 \4\:B1) resistor r=75.2063 c=0
Rl9 (\2\:A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.9849 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=95.9194 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=51.7685 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=10.4 c=0
Rl18 (\1\:B0 \6\:B0) resistor r=24.7951 c=0
Rl11 (\1\:B0 \3\:B0) resistor r=29.5379 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Rz2 (\10\:Y \9\:Y) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz7 (\5\:VDD \1\:VDD) resistor r=37.5 c=0
Ry8 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry9 (\1\:VSS \5\:VSS) resistor r=6.2 c=0
Ry4 (net89 \3\:net89) resistor r=62 c=0
Ry7 (\11\:net89 \10\:net89) resistor r=31 c=0
Rx4 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx1 (\8\:A1 \3\:A1) resistor r=45 c=0
mn0_1__rcx (9 \1\:A0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\7\:Y \4\:A1 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.345e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1 (\7\:Y \1\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.14e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (10 \6\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=1.56e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.035e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (11 \3\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=3.12e-14 ps=1.37e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.35e-07 sb=6.55e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (\9\:Y \4\:B1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.12e-14 \
        ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.1e-06 sb=4.9e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_1__rcx (\9\:Y \6\:B1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.6e-14 ad=4.16e-14 ps=7.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=2.85e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_1__rcx (12 \6\:B0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.6e-14 ps=8e-07 pd=7.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.45e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (\10\:net89 \3\:A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.995e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.635e-06 sd=160n sca=25.8099 \
        scb=0.0207374 scc=0.00244421 m=(2)
mp2 (\1\:Y \1\:B0 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.262e-14 ad=6.24e-14 ps=1.255e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=7.55e-07 sd=160n sca=23.571 \
        scb=0.0183444 scc=0.00243237 m=(2)
mp3 (\1\:Y \1\:B1 \3\:net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.5e-07 sd=160n sca=24.4001 \
        scb=0.0188912 scc=0.00243299 m=(2)
ends AOI22X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:30:34 2012 )
// Library name: gsclib045
// Cell name: AOI22X4
// View name: extracted

simulator lang=spectre

subckt AOI22X4 A0 A1 B0 B1 VDD VSS Y
mp0_1__rcx (net89 \2\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=28.0553 scb=0.030197 \
        scc=0.00226721 m=(4)
C1 (B1 VSS) capacitor c=3.97005e-16
C2 (Y VSS) capacitor c=6.90144e-17
C3 (A0 VSS) capacitor c=3.54132e-17
C4 (A1 VSS) capacitor c=3.81584e-16
C5 (B0 VSS) capacitor c=6.06508e-16
C6 (VDD VSS) capacitor c=1.32751e-16
C7 (10 VSS) capacitor c=1.77435e-18
C8 (11 VSS) capacitor c=1.76875e-18
C9 (12 VSS) capacitor c=4.21738e-18
C10 (13 VSS) capacitor c=4.18649e-18
C11 (14 VSS) capacitor c=1.73781e-18
C12 (15 VSS) capacitor c=2.07872e-18
C13 (net89 VSS) capacitor c=5.97184e-16
C14 (\13\:B0 VSS) capacitor c=7.13776e-17
C15 (\12\:B1 VSS) capacitor c=4.71428e-17
C16 (\10\:B1 VSS) capacitor c=6.74389e-17
C17 (\10\:B0 VSS) capacitor c=4.79977e-17
C18 (\9\:B0 VSS) capacitor c=5.02582e-17
C19 (\4\:B1 VSS) capacitor c=5.34416e-17
C20 (\6\:B1 VSS) capacitor c=3.84697e-17
C21 (\3\:B0 VSS) capacitor c=3.90582e-17
C22 (\14\:A0 VSS) capacitor c=3.8234e-17
C23 (\12\:A1 VSS) capacitor c=3.79192e-17
C24 (\10\:A1 VSS) capacitor c=5.37984e-17
C25 (\4\:A0 VSS) capacitor c=6.56212e-17
C26 (\9\:A0 VSS) capacitor c=4.72109e-17
C27 (\1\:A1 VSS) capacitor c=6.69789e-17
C28 (\4\:A1 VSS) capacitor c=4.71301e-17
C29 (\1\:A0 VSS) capacitor c=7.29396e-17
C30 (\2\:A0 VSS) capacitor c=5.68253e-16
C31 (\10\:Y VSS) capacitor c=2.7704e-16
C32 (\1\:VDD VSS) capacitor c=1.33535e-16
C33 (\8\:Y VSS) capacitor c=6.41223e-17
C34 (\1\:Y VSS) capacitor c=9.43691e-17
C35 (\4\:Y VSS) capacitor c=8.44064e-17
C36 (\6\:Y VSS) capacitor c=6.80835e-17
C37 (\2\:A1 VSS) capacitor c=2.7786e-17
C38 (\5\:A0 VSS) capacitor c=2.04019e-17
C39 (\9\:A1 VSS) capacitor c=3.72559e-17
C40 (\3\:B1 VSS) capacitor c=3.61156e-17
C41 (\9\:B1 VSS) capacitor c=1.9345e-17
C42 (\3\:Y VSS) capacitor c=7.66993e-17
C43 (\3\:VDD VSS) capacitor c=1.77773e-16
Rk14 (Y \10\:Y) resistor r=0.1778 c=0
Rk13 (\3\:Y Y) resistor r=0.2982 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.3131 c=0
Rk10 (\3\:Y \5\:Y) resistor r=0.2888 c=0
Rk11 (\5\:Y \7\:Y) resistor r=0.4656 c=0
Rk12 (\2\:Y \9\:Y) resistor r=0.4593 c=0
Rk3 (A0 \2\:A0) resistor r=0.06806 c=0
Rk32 (\2\:VSS \3\:VSS) resistor r=0.1876 c=0
Rk33 (\3\:VSS \4\:VSS) resistor r=0.3252 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.1376 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.2227 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.3603 c=0
Rk42 (\8\:VSS VSS) resistor r=0.2007 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.2678 c=0
Rk38 (\3\:VSS \10\:VSS) resistor r=0.2024 c=0
Rk39 (\4\:VSS \12\:VSS) resistor r=0.1979 c=0
Rk40 (\6\:VSS \14\:VSS) resistor r=0.1979 c=0
Rk41 (\7\:VSS \16\:VSS) resistor r=0.1979 c=0
Rk43 (\8\:VSS \18\:VSS) resistor r=0.2485 c=0
Rk54 (\3\:VDD VDD) resistor r=0.1506 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.5107 c=0
Rl26 (\3\:B1 B1) resistor r=10.2925 c=0
Rl27 (\3\:B1 \4\:B1) resistor r=78.9095 c=0
Rl29 (\3\:B1 \6\:B1) resistor r=128.331 c=0
Rl36 (\9\:B1 B1) resistor r=27.337 c=0
Rl39 (\9\:B1 \12\:B1) resistor r=32.6005 c=0
Rl37 (\9\:B1 \10\:B1) resistor r=80.4523 c=0
Rl21 (\2\:A0 \14\:A0) resistor r=52.7257 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=124.977 c=0
Rl8 (\5\:A0 \4\:A0) resistor r=82.1768 c=0
Rl12 (\5\:A0 \9\:A0) resistor r=32.7557 c=0
Rl9 (\5\:A0 \2\:A0) resistor r=3.9095 c=0
Rl4 (\2\:A1 A1) resistor r=28.05 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=80.4523 c=0
Rl5 (\2\:A1 \4\:A1) resistor r=32.6005 c=0
Rl15 (\9\:A1 A1) resistor r=10.2925 c=0
Rl18 (\9\:A1 \12\:A1) resistor r=128.331 c=0
Rl16 (\9\:A1 \10\:A1) resistor r=78.9095 c=0
Rl41 (B0 \13\:B0) resistor r=121.131 c=0
Rl34 (B0 \10\:B0) resistor r=45.9329 c=0
Rl33 (B0 \9\:B0) resistor r=67.3652 c=0
Rl23 (B0 \3\:B0) resistor r=48.8796 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz9 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=7.5 c=0
Rz12 (\3\:VDD \1\:VDD) resistor r=9.375 c=0
Ry14 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry16 (\1\:VSS \8\:VSS) resistor r=12.4 c=0
mn0_1__rcx (9 \1\:A0 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (\6\:Y \4\:A1 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (\6\:Y \1\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (10 \9\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (11 \4\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.995e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (\8\:Y \12\:B1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (\4\:Y \10\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.89e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (16 \13\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (\4\:Y \12\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.685e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (12 \14\:A0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.48e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (13 \3\:B0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.275e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\1\:Y \6\:B1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.685e-06 sb=1.07e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_1__rcx (\1\:Y \4\:B1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=8.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (14 \9\:B0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=7.6e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (15 \10\:B0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\8\:Y \10\:B1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mp1_1__rcx (net89 A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=21.2373 scb=0.019015 \
        scc=0.00161477 m=(4)
mp2_1__rcx (\10\:Y B0 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3_1__rcx (\10\:Y B1 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.37e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
ends AOI22X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:02:16 2012 )
// Library name: gsclib045
// Cell name: AOI22XL
// View name: extracted

simulator lang=spectre

subckt AOI22XL A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
C1 (B1 VSS) capacitor c=6.71792e-17
C2 (Y VSS) capacitor c=8.13889e-17
C3 (A1 VSS) capacitor c=3.17764e-17
C4 (A0 VSS) capacitor c=2.3033e-17
C5 (VDD VSS) capacitor c=1.04732e-16
C6 (net98 VSS) capacitor c=3.10182e-18
C7 (net89 VSS) capacitor c=5.47903e-17
C8 (\4\:B0 VSS) capacitor c=4.41446e-17
C9 (\1\:B1 VSS) capacitor c=5.04512e-17
C10 (\1\:A1 VSS) capacitor c=6.58241e-17
C11 (\1\:A0 VSS) capacitor c=3.874e-17
C12 (\3\:B0 VSS) capacitor c=4.07835e-17
C13 (\3\:B1 VSS) capacitor c=3.55663e-17
C14 (\3\:A1 VSS) capacitor c=2.86893e-17
C15 (\4\:A0 VSS) capacitor c=5.23884e-17
C16 (\1\:B0 VSS) capacitor c=1.15583e-17
C17 (\2\:B1 VSS) capacitor c=5.78925e-17
C18 (\2\:A1 VSS) capacitor c=5.67568e-17
C19 (\3\:A0 VSS) capacitor c=5.27976e-17
C20 (\3\:Y VSS) capacitor c=3.53837e-17
C21 (\3\:net89 VSS) capacitor c=8.84435e-17
C22 (\5\:VDD VSS) capacitor c=4.7993e-17
C23 (\5\:net89 VSS) capacitor c=5.21661e-17
C24 (\1\:VDD VSS) capacitor c=4.25558e-17
C25 (\1\:Y VSS) capacitor c=1.08725e-16
C26 (\2\:B0 VSS) capacitor c=4.41809e-17
C27 (\5\:A0 VSS) capacitor c=3.00928e-17
C28 (\4\:A1 VSS) capacitor c=4.00821e-17
C29 (\4\:B1 VSS) capacitor c=5.13275e-17
C30 (\5\:B0 VSS) capacitor c=2.96057e-17
C31 (\7\:B0 VSS) capacitor c=2.04827e-17
C32 (\3\:VDD VSS) capacitor c=1.48719e-18
Rk3 (B1 \4\:B1) resistor r=0.1085 c=0
Rk4 (\2\:Y Y) resistor r=0.572 c=0
Rk5 (Y \4\:Y) resistor r=0.07986 c=0
Rk2 (A1 \4\:A1) resistor r=0.08406 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.05994 c=0
Rk13 (\4\:VSS VSS) resistor r=0.2005 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.2404 c=0
Rk14 (VSS \6\:VSS) resistor r=0.1816 c=0
Rk15 (\3\:VSS \8\:VSS) resistor r=0.1729 c=0
Rk1 (A0 \5\:A0) resistor r=0.0139 c=0
Rk6 (\5\:B0 \6\:B0) resistor r=0.004213 c=0
Rk7 (B0 \7\:B0) resistor r=0.004073 c=0
Rk8 (\5\:B0 \7\:B0) resistor r=0.04761 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.2479 c=0
Rk18 (\4\:VDD VDD) resistor r=0.04986 c=0
Rk17 (\3\:VDD \4\:VDD) resistor r=0.05242 c=0
Rk19 (\3\:VDD \6\:VDD) resistor r=0.2816 c=0
Rk9 (\2\:net89 \4\:net89) resistor r=0.5175 c=0
Rk10 (\4\:net89 \6\:net89) resistor r=0.2845 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=160.771 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=95.3867 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=231.925 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.2328 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=96.9565 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=177.726 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=0.6051 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=132.406 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=143.945 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=0.5213 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=62 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=62 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=62 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \6\:B0) resistor r=45 c=0
mn0 (net106 \4\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\1\:Y \3\:A1 net106 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \3\:B1 net98 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (net98 \3\:B0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp1 (\3\:net89 \1\:A1 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=15.407 scb=0.01402 \
        scc=0.000262427 m=(1)
mp3 (\3\:Y \1\:B1 \3\:net89 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=14.2109 \
        scb=0.0116139 scc=0.000225742 m=(1)
mp2 (\3\:Y \4\:B0 net89 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=17.4411 \
        scb=0.0179282 scc=0.000407312 m=(1)
ends AOI22XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:03:06 2012 )
// Library name: gsclib045
// Cell name: AOI2BB1X1
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y n0 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.40705e-07 sd=160n sca=15.9621 scb=0.0150202 \
        scc=0.000309344 m=(1)
C1 (Y VSS) capacitor c=9.42279e-17
C2 (B0 VSS) capacitor c=5.11059e-17
C3 (A1N VSS) capacitor c=2.50266e-17
C4 (VDD VSS) capacitor c=9.44019e-17
C5 (A0N VSS) capacitor c=6.26112e-17
C6 (n0 VSS) capacitor c=9.12335e-17
C7 (n2 VSS) capacitor c=1.75431e-18
C8 (\3\:A1N VSS) capacitor c=7.75483e-17
C9 (\1\:A0N VSS) capacitor c=6.92147e-17
C10 (\3\:B0 VSS) capacitor c=8.93613e-17
C11 (\1\:A1N VSS) capacitor c=2.80272e-17
C12 (\3\:A0N VSS) capacitor c=4.5907e-17
C13 (\1\:B0 VSS) capacitor c=5.93751e-17
C14 (\3\:n0 VSS) capacitor c=2.88397e-17
C15 (\4\:A1N VSS) capacitor c=1.22835e-17
C16 (\2\:A0N VSS) capacitor c=6.35302e-17
C17 (\2\:B0 VSS) capacitor c=6.54199e-17
C18 (\2\:n0 VSS) capacitor c=5.66095e-17
C19 (\4\:n0 VSS) capacitor c=5.53819e-17
C20 (\5\:VDD VSS) capacitor c=3.76739e-17
C21 (\1\:Y VSS) capacitor c=8.04762e-17
C22 (\1\:VDD VSS) capacitor c=1.88459e-17
C23 (\8\:n0 VSS) capacitor c=3.11188e-17
C24 (\3\:Y VSS) capacitor c=4.46671e-17
C25 (\2\:A1N VSS) capacitor c=4.26746e-17
C26 (\4\:B0 VSS) capacitor c=6.57927e-17
C27 (\4\:A0N VSS) capacitor c=4.61162e-17
C28 (\6\:n0 VSS) capacitor c=1.06502e-16
C29 (\7\:n0 VSS) capacitor c=8.58824e-17
C30 (\5\:A1N VSS) capacitor c=4.34788e-17
C31 (\3\:VDD VSS) capacitor c=2.88702e-18
Rk1 (\2\:Y Y) resistor r=0.6666 c=0
Rk2 (Y \4\:Y) resistor r=0.08156 c=0
Rk3 (B0 \4\:B0) resistor r=0.09846 c=0
Rk10 (\5\:A1N \6\:A1N) resistor r=0.01391 c=0
Rk11 (A1N \7\:A1N) resistor r=0.01391 c=0
Rk12 (\5\:A1N \7\:A1N) resistor r=0.02119 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1552 c=0
Rk23 (\4\:VDD VDD) resistor r=0.1 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1452 c=0
Rk24 (\3\:VDD \6\:VDD) resistor r=0.2213 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3506 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.1326 c=0
Rk15 (\5\:VSS \6\:VSS) resistor r=0.1176 c=0
Rk17 (\7\:VSS VSS) resistor r=0.03965 c=0
Rk16 (\6\:VSS \7\:VSS) resistor r=0.1101 c=0
Rk19 (\5\:VSS \10\:VSS) resistor r=0.2611 c=0
Rk20 (\7\:VSS \12\:VSS) resistor r=0.1785 c=0
Rk6 (\4\:A0N A0N) resistor r=0.02396 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.4796 c=0
Rk8 (\6\:n0 \7\:n0) resistor r=0.3662 c=0
Rk9 (\6\:n0 \9\:n0) resistor r=0.1404 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.6365 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=103.021 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=167.616 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=71.8171 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=5.1011 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=106.461 c=0
Rl1 (n0 \2\:n0) resistor r=165.385 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=33.7912 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry5 (\3\:VSS VSS) resistor r=62 c=0
Ry3 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry4 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y \3\:n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=5.72692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn2 (\3\:Y \1\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.67692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn0 (\8\:n0 \3\:A0N \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.755e-14 ps=8.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.75e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn1 (\8\:n0 \1\:A1N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.4e-07 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mp2 (n2 \3\:B0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=2.34e-14 ps=1.19e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.35705e-07 sd=160n sca=14.5611 \
        scb=0.0122104 scc=0.000254242 m=(1)
mp0 (n1 \1\:A0N \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=1.29e-14 ps=1.19e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2.45e-07 sd=160n sca=15.6375 \
        scb=0.0141102 scc=0.000376252 m=(1)
mp1 (\4\:n0 \3\:A1N n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.4e-07 sd=160n sca=17.3765 scb=0.017565 \
        scc=0.000461873 m=(1)
ends AOI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:32:23 2012 )
// Library name: gsclib045
// Cell name: AOI2BB1X2
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X2 A0N A1N B0 VDD VSS Y
mp2 (3 \1\:B0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.56218e-07 sd=160n sca=15.3142 \
        scb=0.0139264 scc=0.00046091 m=(1)
C1 (A0N VSS) capacitor c=4.66322e-17
C2 (Y VSS) capacitor c=8.3837e-17
C3 (B0 VSS) capacitor c=2.13543e-17
C4 (VDD VSS) capacitor c=1.06718e-16
C5 (A1N VSS) capacitor c=5.80854e-17
C6 (net104 VSS) capacitor c=5.89007e-17
C7 (3 VSS) capacitor c=1.82166e-18
C8 (net87 VSS) capacitor c=1.42137e-18
C9 (\3\:A1N VSS) capacitor c=7.02906e-17
C10 (\3\:A0N VSS) capacitor c=7.63271e-17
C11 (\6\:B0 VSS) capacitor c=9.14288e-17
C12 (\5\:net104 VSS) capacitor c=7.40155e-17
C13 (\1\:B0 VSS) capacitor c=8.0094e-17
C14 (\1\:A1N VSS) capacitor c=3.37484e-17
C15 (\1\:A0N VSS) capacitor c=3.16919e-17
C16 (\2\:A1N VSS) capacitor c=3.35261e-17
C17 (\2\:A0N VSS) capacitor c=4.47482e-17
C18 (\2\:net104 VSS) capacitor c=2.27017e-17
C19 (\2\:B0 VSS) capacitor c=3.25056e-16
C20 (\11\:net104 VSS) capacitor c=1.61735e-17
C21 (\6\:VDD VSS) capacitor c=4.645e-17
C22 (\5\:Y VSS) capacitor c=9.76196e-17
C23 (\8\:VDD VSS) capacitor c=2.44892e-17
C24 (\1\:VDD VSS) capacitor c=4.01437e-17
C25 (\7\:net104 VSS) capacitor c=8.01456e-17
C26 (\1\:Y VSS) capacitor c=1.11076e-16
C27 (\3\:net104 VSS) capacitor c=1.4288e-16
C28 (\4\:A0N VSS) capacitor c=6.48024e-17
C29 (\9\:net104 VSS) capacitor c=1.0096e-16
C30 (\10\:net104 VSS) capacitor c=8.40919e-17
C31 (\5\:A1N VSS) capacitor c=3.81634e-17
C32 (\3\:VDD VSS) capacitor c=8.02831e-18
C33 (\5\:VDD VSS) capacitor c=2.73718e-18
Rk7 (\4\:A0N A0N) resistor r=0.02184 c=0
Rk2 (\1\:Y Y) resistor r=0.3463 c=0
Rk3 (Y \6\:Y) resistor r=0.7463 c=0
Rk6 (\2\:B0 B0) resistor r=0.04405 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.2123 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.2373 c=0
Rk27 (\5\:VDD VDD) resistor r=0.1271 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.07231 c=0
Rk28 (\3\:VDD \7\:VDD) resistor r=0.258 c=0
Rk29 (\5\:VDD \9\:VDD) resistor r=0.2051 c=0
Rk13 (A1N \5\:A1N) resistor r=0.03585 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.03481 c=0
Rk19 (\4\:VSS VSS) resistor r=0.07706 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.2771 c=0
Rk20 (\3\:VSS \9\:VSS) resistor r=0.2481 c=0
Rk22 (\4\:VSS \13\:VSS) resistor r=0.1721 c=0
Rk8 (\8\:net104 \9\:net104) resistor r=0.4788 c=0
Rk9 (\9\:net104 \10\:net104) resistor r=0.4618 c=0
Rk10 (\9\:net104 \12\:net104) resistor r=0.1068 c=0
Rl11 (\2\:A0N \3\:A0N) resistor r=134.066 c=0
Rl10 (\1\:A0N \2\:A0N) resistor r=53.8462 c=0
Rl9 (\2\:B0 \6\:B0) resistor r=99.7951 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=103.079 c=0
Rl13 (\2\:A1N \3\:A1N) resistor r=108.232 c=0
Rl12 (\1\:A1N \2\:A1N) resistor r=149.233 c=0
Rl3 (\2\:net104 net104) resistor r=38.4089 c=0
Rl6 (\2\:net104 \5\:net104) resistor r=79.9751 c=0
Rl4 (\3\:net104 \2\:net104) resistor r=6.662 c=0
Rz8 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz4 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz3 (\8\:net104 \7\:net104) resistor r=75 c=0
Ry1 (\6\:Y \5\:Y) resistor r=20.6667 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=31 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry3 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry4 (\4\:VSS \1\:VSS) resistor r=7.75 c=0
Ry2 (\12\:net104 \11\:net104) resistor r=62 c=0
Rx3 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx5 (\2\:A1N \5\:A1N) resistor r=45 c=0
Rx4 (\10\:net104 \2\:net104) resistor r=45 c=0
mn2 (\1\:Y \2\:B0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06452e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (\1\:Y \3\:net104 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.59519e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn0 (\7\:net104 \1\:A0N \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.988e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=4.6e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn1 (\7\:net104 \1\:A1N \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=3.988e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mp3 (\5\:Y \5\:net104 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.51218e-07 sd=160n sca=14.157 \
        scb=0.0122233 scc=0.000446408 m=(1)
mp3_1__rcx (\5\:Y net104 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=4.46218e-07 sd=160n sca=13.0345 \
        scb=0.0111963 scc=0.000443955 m=(1)
mp2_1__rcx (5 \6\:B0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=2.34e-14 ps=1.21e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.41218e-07 sd=160n sca=12.7928 \
        scb=0.0110816 scc=0.000443908 m=(1)
mp0 (net87 \3\:A0N \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=1.29e-14 ps=1.21e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=2.45e-07 sd=160n sca=15.4989 \
        scb=0.01467 scc=0.00075392 m=(1)
mp1 (\11\:net104 \3\:A1N net87 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.4e-07 sd=160n sca=16.1917 \
        scb=0.0154022 scc=0.000756069 m=(1)
ends AOI2BB1X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:33:00 2012 )
// Library name: gsclib045
// Cell name: AOI2BB1X4
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X4 A0N A1N B0 VDD VSS Y
mp2_1__rcx (2 \1\:B0 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=2.34e-14 ps=1.12e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.685e-06 sd=160n sca=14.6306 \
        scb=0.0131928 scc=0.00027089 m=(1)
C1 (Y VSS) capacitor c=9.73062e-17
C2 (B0 VSS) capacitor c=1.61272e-17
C3 (A1N VSS) capacitor c=5.94403e-17
C4 (VDD VSS) capacitor c=1.70264e-16
C5 (A0N VSS) capacitor c=2.36977e-17
C6 (net104 VSS) capacitor c=5.92918e-17
C7 (2 VSS) capacitor c=1.93443e-18
C8 (4 VSS) capacitor c=1.95976e-18
C9 (5 VSS) capacitor c=2.07104e-18
C10 (6 VSS) capacitor c=5.86508e-18
C11 (net87 VSS) capacitor c=1.35348e-18
C12 (\3\:A1N VSS) capacitor c=9.26625e-17
C13 (\3\:A0N VSS) capacitor c=8.76638e-17
C14 (\12\:B0 VSS) capacitor c=5.08823e-17
C15 (\12\:net104 VSS) capacitor c=2.1999e-17
C16 (\11\:net104 VSS) capacitor c=7.34737e-17
C17 (\9\:B0 VSS) capacitor c=6.82631e-17
C18 (\8\:B0 VSS) capacitor c=7.57378e-17
C19 (\5\:net104 VSS) capacitor c=7.48822e-17
C20 (\1\:B0 VSS) capacitor c=7.55232e-17
C21 (\1\:A1N VSS) capacitor c=3.83945e-17
C22 (\1\:A0N VSS) capacitor c=5.19696e-17
C23 (\4\:A1N VSS) capacitor c=1.1237e-17
C24 (\2\:A0N VSS) capacitor c=6.67073e-17
C25 (\2\:net104 VSS) capacitor c=5.04198e-16
C26 (\2\:B0 VSS) capacitor c=5.5088e-16
C27 (\13\:net104 VSS) capacitor c=2.8501e-17
C28 (\5\:VDD VSS) capacitor c=4.61456e-17
C29 (\12\:Y VSS) capacitor c=8.42728e-17
C30 (\7\:VDD VSS) capacitor c=3.36299e-17
C31 (\10\:Y VSS) capacitor c=2.92016e-17
C32 (\10\:VDD VSS) capacitor c=3.6864e-17
C33 (\1\:VDD VSS) capacitor c=7.39481e-17
C34 (\18\:net104 VSS) capacitor c=7.56639e-17
C35 (\1\:Y VSS) capacitor c=2.52413e-16
C36 (\7\:B0 VSS) capacitor c=3.39322e-17
C37 (\2\:A1N VSS) capacitor c=3.05892e-17
C38 (\9\:Y VSS) capacitor c=5.67606e-17
C39 (\4\:A0N VSS) capacitor c=9.65314e-17
C40 (\15\:net104 VSS) capacitor c=9.67321e-17
C41 (\6\:A1N VSS) capacitor c=1.67382e-17
C42 (\3\:VDD VSS) capacitor c=1.50073e-17
C43 (\9\:VDD VSS) capacitor c=1.5409e-17
Rk30 (\3\:VSS VSS) resistor r=0.06471 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.3877 c=0
Rk4 (\1\:Y Y) resistor r=0.6989 c=0
Rk5 (Y \9\:Y) resistor r=0.236 c=0
Rk6 (\9\:Y \11\:Y) resistor r=0.05755 c=0
Rk7 (\9\:Y \13\:Y) resistor r=0.5091 c=0
Rk11 (\2\:B0 B0) resistor r=0.006364 c=0
Rk22 (A1N \6\:A1N) resistor r=0.05091 c=0
Rk36 (\2\:VDD \3\:VDD) resistor r=0.1652 c=0
Rk37 (\3\:VDD \4\:VDD) resistor r=0.4365 c=0
Rk38 (\3\:VDD \6\:VDD) resistor r=0.2296 c=0
Rk39 (\4\:VDD \8\:VDD) resistor r=0.2226 c=0
Rk42 (\9\:VDD VDD) resistor r=0.08476 c=0
Rk40 (\4\:VDD \9\:VDD) resistor r=0.3156 c=0
Rk41 (\9\:VDD \11\:VDD) resistor r=0.1719 c=0
Rk14 (\4\:A0N A0N) resistor r=0.005989 c=0
Rk16 (\15\:net104 \2\:net104) resistor r=0.5356 c=0
Rk15 (\14\:net104 \15\:net104) resistor r=0.1408 c=0
Rk18 (\15\:net104 \19\:net104) resistor r=0.5113 c=0
Rl19 (\2\:B0 \12\:B0) resistor r=86.3335 c=0
Rl1 (\2\:B0 \1\:B0) resistor r=89.6174 c=0
Rl12 (\7\:B0 \9\:B0) resistor r=78.4102 c=0
Rl11 (\7\:B0 \8\:B0) resistor r=122.561 c=0
Rl10 (\7\:B0 \2\:B0) resistor r=6.3032 c=0
Rl23 (\2\:A1N \3\:A1N) resistor r=111.048 c=0
Rl22 (\1\:A1N \2\:A1N) resistor r=149.462 c=0
Rl24 (\2\:A1N \4\:A1N) resistor r=11.6126 c=0
Rl21 (\2\:A0N \3\:A0N) resistor r=78.079 c=0
Rl20 (\1\:A0N \2\:A0N) resistor r=134.331 c=0
Rl3 (\2\:net104 net104) resistor r=25.3355 c=0
Rl17 (\2\:net104 \12\:net104) resistor r=21.8511 c=0
Rl16 (\2\:net104 \11\:net104) resistor r=76.7238 c=0
Rl6 (\2\:net104 \5\:net104) resistor r=84.3341 c=0
Rz6 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz5 (\19\:net104 \18\:net104) resistor r=75 c=0
Ry6 (VSS \4\:VSS) resistor r=62 c=0
Ry4 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry1 (\11\:Y \10\:Y) resistor r=31 c=0
Ry2 (\13\:Y \12\:Y) resistor r=31 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\14\:net104 \13\:net104) resistor r=20.6667 c=0
Rx7 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx4 (\2\:A0N \4\:A0N) resistor r=45 c=0
mn2 (\1\:Y \2\:B0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
mn3 (\1\:Y \2\:net104 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.78e-06 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(4)
mn0 (\18\:net104 \1\:A0N \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=3.45e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn1 (\18\:net104 \1\:A1N \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mp3_1__rcx (\10\:Y \5\:net104 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.58e-06 sd=160n sca=13.3043 \
        scb=0.011125 scc=0.000248176 m=(1)
mp3_2__rcx (\10\:Y net104 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.375e-06 sd=160n sca=12.0532 \
        scb=0.00986215 scc=0.000244296 m=(1)
mp2_2__rcx (4 \8\:B0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.27e-06 sd=160n sca=11.7142 \
        scb=0.00970251 scc=0.00024422 m=(1)
mp2_3__rcx (5 \9\:B0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.065e-06 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp3_3__rcx (\12\:Y \11\:net104 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=9.6e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp3 (\12\:Y \12\:net104 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.014e-13 ad=6.24e-14 ps=1.3e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=7.55e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp2 (6 \12\:B0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.014e-13 ps=1.1e-06 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=4.5e-07 sd=160n sca=12.0927 \
        scb=0.00988629 scc=0.000244314 m=(1)
mp0 (net87 \3\:A0N \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61e-06 sb=2.45e-07 sd=160n sca=13.4007 \
        scb=0.0112573 scc=0.000248973 m=(1)
mp1 (\13\:net104 \3\:A1N net87 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=1.4e-07 sd=160n sca=14.804 \
        scb=0.0134899 scc=0.000276131 m=(1)
ends AOI2BB1X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:33:37 2012 )
// Library name: gsclib045
// Cell name: AOI2BB1XL
// View name: extracted

simulator lang=spectre

subckt AOI2BB1XL A0N A1N B0 VDD VSS Y
mp3 (\1\:Y net100 net79 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=14.7825 \
        scb=0.0129755 scc=0.000158065 m=(1)
C1 (B0 VSS) capacitor c=7.36646e-17
C2 (VDD VSS) capacitor c=1.41144e-16
C3 (A1N VSS) capacitor c=7.11139e-17
C4 (Y VSS) capacitor c=7.218e-17
C5 (A0N VSS) capacitor c=1.41639e-16
C6 (net100 VSS) capacitor c=9.10912e-17
C7 (\3\:A1N VSS) capacitor c=1.03318e-16
C8 (\1\:A0N VSS) capacitor c=6.20562e-17
C9 (\1\:B0 VSS) capacitor c=8.04012e-17
C10 (\1\:A1N VSS) capacitor c=2.41729e-17
C11 (\3\:A0N VSS) capacitor c=7.62753e-17
C12 (\3\:B0 VSS) capacitor c=5.20836e-17
C13 (\3\:net100 VSS) capacitor c=3.1017e-17
C14 (\4\:A1N VSS) capacitor c=1.479e-17
C15 (\2\:A0N VSS) capacitor c=9.24719e-17
C16 (\2\:B0 VSS) capacitor c=9.73411e-17
C17 (\2\:net100 VSS) capacitor c=7.86807e-17
C18 (\8\:net100 VSS) capacitor c=6.54329e-17
C19 (\5\:VDD VSS) capacitor c=1.61364e-17
C20 (\1\:Y VSS) capacitor c=4.77023e-17
C21 (\1\:VDD VSS) capacitor c=2.66452e-17
C22 (\6\:net100 VSS) capacitor c=4.37953e-17
C23 (\3\:Y VSS) capacitor c=8.9149e-17
C24 (\2\:A1N VSS) capacitor c=7.2511e-17
C25 (\4\:B0 VSS) capacitor c=4.70393e-17
C26 (\4\:net100 VSS) capacitor c=5.43307e-17
C27 (\5\:net100 VSS) capacitor c=1.24291e-16
C28 (\6\:A1N VSS) capacitor c=3.67661e-17
C29 (\3\:VDD VSS) capacitor c=3.80366e-18
Rk11 (\2\:VSS \3\:VSS) resistor r=0.03492 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.1152 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1026 c=0
Rk14 (\5\:VSS \6\:VSS) resistor r=0.09763 c=0
Rk16 (\7\:VSS VSS) resistor r=0.04219 c=0
Rk15 (\6\:VSS \7\:VSS) resistor r=0.1077 c=0
Rk18 (\3\:VSS \10\:VSS) resistor r=0.177 c=0
Rk19 (\5\:VSS \12\:VSS) resistor r=0.1765 c=0
Rk20 (\7\:VSS \14\:VSS) resistor r=0.1748 c=0
Rk3 (B0 \4\:B0) resistor r=0.1277 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1528 c=0
Rk23 (\4\:VDD VDD) resistor r=0.1001 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1478 c=0
Rk24 (\3\:VDD \6\:VDD) resistor r=0.1744 c=0
Rk8 (\5\:A1N \6\:A1N) resistor r=0.00454 c=0
Rk9 (\7\:A1N A1N) resistor r=0.004604 c=0
Rk10 (\6\:A1N \7\:A1N) resistor r=0.06643 c=0
Rk1 (\2\:Y Y) resistor r=0.4532 c=0
Rk2 (Y \4\:Y) resistor r=0.5209 c=0
Rk4 (A0N \4\:A0N) resistor r=0.002514 c=0
Rk5 (\4\:net100 \5\:net100) resistor r=0.3496 c=0
Rk6 (\5\:net100 \7\:net100) resistor r=0.2429 c=0
Rk7 (\5\:net100 \9\:net100) resistor r=0.4838 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=154.538 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=162.23 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=315.693 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=37.2017 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=12.1383 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=73.7687 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=243 c=0
Rl1 (net100 \2\:net100) resistor r=226.156 c=0
Rl2 (\2\:net100 \3\:net100) resistor r=111.954 c=0
Rz3 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz4 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz5 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\6\:net100 \7\:net100) resistor r=75 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\8\:net100 \9\:net100) resistor r=62 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \5\:A1N) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx3 (\2\:net100 \4\:net100) resistor r=45 c=0
mn3 (\3\:Y \3\:net100 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\3\:Y \3\:B0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\6\:net100 \3\:A0N \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.465e-14 ad=2.537e-14 ps=6.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.6e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\6\:net100 \1\:A1N \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp2 (net79 \1\:B0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.29e-14 ps=7.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.6e-07 sd=160n sca=13.4422 \
        scb=0.0102845 scc=0.000107644 m=(1)
mp0 (net87 \1\:A0N \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.29e-14 ps=7.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.45e-07 sd=160n sca=13.4422 \
        scb=0.0102845 scc=0.000107644 m=(1)
mp1 (\8\:net100 \3\:A1N net87 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.4e-07 sd=160n sca=14.7825 \
        scb=0.0129755 scc=0.000158065 m=(1)
ends AOI2BB1XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:34:15 2012 )
// Library name: gsclib045
// Cell name: AOI2BB2X1
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X1 A0N A1N B0 B1 VDD VSS Y
mp1 (\4\:n1 \1\:A1N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.5e-07 sd=160n sca=20.0627 \
        scb=0.0223685 scc=0.000742304 m=(1)
C1 (Y VSS) capacitor c=2.81833e-17
C2 (A0N VSS) capacitor c=5.80968e-17
C3 (VDD VSS) capacitor c=1.05797e-16
C4 (A1N VSS) capacitor c=5.43542e-17
C5 (B0 VSS) capacitor c=1.87806e-17
C6 (B1 VSS) capacitor c=2.98672e-17
C7 (n1 VSS) capacitor c=5.68741e-17
C8 (n0 VSS) capacitor c=3.74003e-17
C9 (n2 VSS) capacitor c=2.72591e-18
C10 (n3 VSS) capacitor c=9.12392e-18
C11 (n4 VSS) capacitor c=4.23619e-17
C12 (\1\:B0 VSS) capacitor c=4.42452e-17
C13 (\1\:B1 VSS) capacitor c=4.07245e-17
C14 (\3\:n0 VSS) capacitor c=4.35914e-17
C15 (\3\:A0N VSS) capacitor c=3.26023e-17
C16 (\1\:A1N VSS) capacitor c=4.16199e-17
C17 (\3\:B0 VSS) capacitor c=3.72823e-17
C18 (\4\:B1 VSS) capacitor c=5.17834e-17
C19 (\3\:n1 VSS) capacitor c=3.60057e-17
C20 (\1\:A0N VSS) capacitor c=3.54492e-17
C21 (\3\:A1N VSS) capacitor c=2.49687e-17
C22 (\4\:B0 VSS) capacitor c=1.22869e-17
C23 (\3\:B1 VSS) capacitor c=1.71413e-17
C24 (\2\:n1 VSS) capacitor c=3.99414e-17
C25 (\2\:n0 VSS) capacitor c=3.36127e-17
C26 (\2\:A0N VSS) capacitor c=3.51691e-17
C27 (\2\:A1N VSS) capacitor c=3.30417e-17
C28 (\1\:Y VSS) capacitor c=1.13507e-16
C29 (\3\:n4 VSS) capacitor c=7.38176e-17
C30 (\7\:VDD VSS) capacitor c=4.63755e-17
C31 (\5\:n4 VSS) capacitor c=6.09299e-17
C32 (\6\:n0 VSS) capacitor c=6.39647e-17
C33 (\9\:VDD VSS) capacitor c=3.34817e-17
C34 (\4\:n1 VSS) capacitor c=5.42165e-17
C35 (\1\:VDD VSS) capacitor c=5.81399e-17
C36 (\3\:Y VSS) capacitor c=9.81346e-17
C37 (\8\:n0 VSS) capacitor c=2.57718e-17
C38 (\6\:n1 VSS) capacitor c=1.28165e-16
C39 (\2\:B1 VSS) capacitor c=2.71802e-17
C40 (\2\:B0 VSS) capacitor c=2.43228e-17
C41 (\4\:A1N VSS) capacitor c=5.34841e-17
C42 (\4\:A0N VSS) capacitor c=5.69221e-17
C43 (\4\:n0 VSS) capacitor c=5.22901e-17
C44 (\5\:n0 VSS) capacitor c=5.3887e-17
C45 (\8\:n1 VSS) capacitor c=1.68127e-16
C46 (\5\:B1 VSS) capacitor c=1.00026e-16
C47 (\5\:B0 VSS) capacitor c=8.02747e-17
C48 (\5\:VDD VSS) capacitor c=2.82246e-19
Rk12 (\4\:Y Y) resistor r=0.01611 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.6902 c=0
Rk2 (\4\:A0N A0N) resistor r=0.1907 c=0
Rk26 (\2\:VDD \3\:VDD) resistor r=0.2003 c=0
Rk27 (\3\:VDD \4\:VDD) resistor r=0.2003 c=0
Rk28 (\4\:VDD \5\:VDD) resistor r=0.2178 c=0
Rk30 (\6\:VDD VDD) resistor r=0.04987 c=0
Rk29 (\5\:VDD \6\:VDD) resistor r=0.08251 c=0
Rk31 (\3\:VDD \8\:VDD) resistor r=0.2828 c=0
Rk32 (\5\:VDD \10\:VDD) resistor r=0.2728 c=0
Rk1 (\4\:A1N A1N) resistor r=0.1524 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.03489 c=0
Rk17 (\3\:VSS \4\:VSS) resistor r=0.2153 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.1828 c=0
Rk19 (\5\:VSS \6\:VSS) resistor r=0.1677 c=0
Rk20 (\6\:VSS \7\:VSS) resistor r=0.1527 c=0
Rk22 (\8\:VSS VSS) resistor r=0.04987 c=0
Rk21 (\7\:VSS \8\:VSS) resistor r=0.09754 c=0
Rk23 (\3\:VSS \10\:VSS) resistor r=0.1953 c=0
Rk24 (\5\:VSS \12\:VSS) resistor r=0.1931 c=0
Rk25 (\7\:VSS \14\:VSS) resistor r=0.07346 c=0
Rk15 (B0 \5\:B0) resistor r=0.02177 c=0
Rk10 (\5\:B1 B1) resistor r=0.01497 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4253 c=0
Rk7 (\7\:n1 \8\:n1) resistor r=1.0427 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.248 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.4196 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.06021 c=0
Rk13 (\2\:n4 \4\:n4) resistor r=0.4736 c=0
Rk14 (\4\:n4 \6\:n4) resistor r=0.4226 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=74.1758 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=76.9231 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=119.922 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=29.5379 c=0
Rl12 (\1\:B0 \2\:B0) resistor r=92.9709 c=0
Rl13 (\2\:B0 \3\:B0) resistor r=52.2314 c=0
Rl14 (\2\:B0 \4\:B0) resistor r=5.1011 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=37.3411 c=0
Rl11 (\2\:B1 \4\:B1) resistor r=114.264 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=1.2301 c=0
Rl7 (n1 \2\:n1) resistor r=106.461 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=29.5379 c=0
Rl5 (n0 \2\:n0) resistor r=46.6893 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=87.6365 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz6 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry11 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry12 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry9 (\1\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry10 (\1\:VSS \8\:VSS) resistor r=31 c=0
Ry2 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (n4 \2\:n4) resistor r=31 c=0
Ry5 (\3\:n4 \4\:n4) resistor r=31 c=0
Ry6 (\5\:n4 \6\:n4) resistor r=31 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx5 (\3\:B1 \5\:B1) resistor r=45 c=0
Rx4 (\2\:n1 \8\:n1) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\6\:n1 \3\:A1N \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\8\:n0 \1\:A0N \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=3.263e-14 ps=1.6e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=2.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n2 n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=3.12e-14 ps=8e-07 pd=7.6e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=7.3e-07 sd=160n sca=8.65991 scb=0.00681295 scc=0.000165238 \
        m=(1)
mn3 (\3\:Y \3\:n1 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.12e-14 \
        ad=5.72e-14 ps=7.6e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.05e-07 sb=5.65e-07 sd=160n sca=8.65991 scb=0.00681295 \
        scc=0.000165238 m=(1)
mn5 (n3 \4\:B1 \3\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=2.99e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.7e-07 sb=3e-07 sd=160n sca=8.65991 scb=0.00681295 \
        scc=0.000165238 m=(1)
mn4 (\9\:VSS \3\:B0 n3 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.64e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mp0 (\6\:n0 \3\:A0N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.4e-07 sd=160n sca=13.9338 \
        scb=0.0121124 scc=0.00023362 m=(1)
mp2 (\5\:n4 \3\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=20.624 \
        scb=0.0171402 scc=0.00197772 m=(1)
mp3 (\3\:n4 n1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=21.2883 \
        scb=0.0174673 scc=0.00197792 m=(1)
mp5 (\1\:Y \1\:B1 \3\:n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=23.6754 \
        scb=0.020671 scc=0.0020044 m=(1)
mp4 (\1\:Y \1\:B0 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.46e-14 \
        ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.15e-07 sb=1.4e-07 sd=160n sca=31.7169 scb=0.0333373 \
        scc=0.002913 m=(1)
ends AOI2BB2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:34:52 2012 )
// Library name: gsclib045
// Cell name: AOI2BB2X2
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X2 A0N A1N B0 B1 VDD VSS Y
mp1 (\10\:n1 \1\:A1N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.3686e-07 sd=160n sca=35.2997 \
        scb=0.0321645 scc=0.00387088 m=(1)
C1 (Y VSS) capacitor c=7.24219e-17
C2 (A0N VSS) capacitor c=3.65457e-17
C3 (A1N VSS) capacitor c=4.64921e-17
C4 (B0 VSS) capacitor c=3.63264e-16
C5 (VDD VSS) capacitor c=1.46817e-16
C6 (B1 VSS) capacitor c=5.41882e-17
C7 (n1 VSS) capacitor c=1.6952e-16
C8 (n0 VSS) capacitor c=6.45181e-17
C9 (12 VSS) capacitor c=4.23054e-18
C10 (13 VSS) capacitor c=4.43154e-18
C11 (n4 VSS) capacitor c=1.84286e-16
C12 (\1\:B1 VSS) capacitor c=1.31451e-16
C13 (\1\:A0N VSS) capacitor c=3.65133e-17
C14 (\1\:A1N VSS) capacitor c=3.7748e-17
C15 (\7\:B0 VSS) capacitor c=5.09899e-17
C16 (\4\:B1 VSS) capacitor c=5.96693e-17
C17 (\5\:B1 VSS) capacitor c=3.65058e-17
C18 (\3\:B0 VSS) capacitor c=3.13624e-17
C19 (\6\:n0 VSS) capacitor c=4.79297e-17
C20 (\5\:n1 VSS) capacitor c=3.08199e-17
C21 (\4\:n1 VSS) capacitor c=4.57651e-17
C22 (\3\:A0N VSS) capacitor c=2.69162e-17
C23 (\3\:A1N VSS) capacitor c=2.57764e-17
C24 (\2\:n0 VSS) capacitor c=3.30666e-16
C25 (\2\:A0N VSS) capacitor c=2.98406e-17
C26 (\2\:A1N VSS) capacitor c=3.44914e-17
C27 (\1\:Y VSS) capacitor c=1.6455e-16
C28 (\3\:n4 VSS) capacitor c=7.37848e-17
C29 (\10\:n4 VSS) capacitor c=3.59503e-17
C30 (\12\:n0 VSS) capacitor c=2.54223e-17
C31 (\11\:VDD VSS) capacitor c=1.1669e-17
C32 (\10\:n1 VSS) capacitor c=5.68196e-17
C33 (\1\:VDD VSS) capacitor c=5.8796e-17
C34 (\8\:Y VSS) capacitor c=5.65979e-17
C35 (\6\:Y VSS) capacitor c=4.67838e-17
C36 (\10\:n0 VSS) capacitor c=4.57738e-17
C37 (\8\:n1 VSS) capacitor c=1.66597e-16
C38 (\4\:A1N VSS) capacitor c=8.71147e-17
C39 (\4\:A0N VSS) capacitor c=9.16653e-17
C40 (\7\:n1 VSS) capacitor c=1.75459e-16
C41 (\9\:n0 VSS) capacitor c=5.44186e-17
C42 (\7\:B1 VSS) capacitor c=9.13271e-17
C43 (\5\:Y VSS) capacitor c=7.03864e-17
C44 (\3\:VDD VSS) capacitor c=1.04119e-16
C45 (\6\:VDD VSS) capacitor c=6.55062e-18
Rk13 (\1\:Y Y) resistor r=0.2512 c=0
Rk14 (Y \5\:Y) resistor r=0.2241 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.3113 c=0
Rk16 (\5\:Y \9\:Y) resistor r=0.3209 c=0
Rk24 (\2\:VSS \4\:VSS) resistor r=0.3249 c=0
Rk25 (\4\:VSS \5\:VSS) resistor r=0.2996 c=0
Rk26 (\5\:VSS \6\:VSS) resistor r=0.3502 c=0
Rk27 (\5\:VSS \8\:VSS) resistor r=0.197 c=0
Rk28 (\6\:VSS \9\:VSS) resistor r=0.377 c=0
Rk30 (\10\:VSS VSS) resistor r=0.04971 c=0
Rk29 (\9\:VSS \10\:VSS) resistor r=0.07225 c=0
Rk31 (\6\:VSS \12\:VSS) resistor r=0.2474 c=0
Rk32 (\9\:VSS \14\:VSS) resistor r=0.07288 c=0
Rk4 (A0N \4\:A0N) resistor r=0.07164 c=0
Rk3 (\4\:A1N A1N) resistor r=0.05075 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.3296 c=0
Rk35 (\3\:VDD \5\:VDD) resistor r=0.2296 c=0
Rk37 (\6\:VDD VDD) resistor r=0.1844 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.1647 c=0
Rk40 (\6\:VDD \12\:VDD) resistor r=0.1982 c=0
Rk11 (B1 \7\:B1) resistor r=0.129 c=0
Rk5 (\7\:n1 \9\:n1) resistor r=1.2698 c=0
Rk6 (\9\:n1 \11\:n1) resistor r=0.4365 c=0
Rk8 (\2\:n0 \9\:n0) resistor r=0.3855 c=0
Rk9 (\9\:n0 \11\:n0) resistor r=0.1739 c=0
Rk10 (\9\:n0 \13\:n0) resistor r=0.1404 c=0
Rk23 (n4 \11\:n4) resistor r=0.05922 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=43.4636 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=33.8482 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=51.9231 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=29.9451 c=0
Rl23 (B0 \7\:B0) resistor r=28.6412 c=0
Rl15 (B0 \3\:B0) resistor r=41.1873 c=0
Rl19 (\1\:B1 \4\:B1) resistor r=111.253 c=0
Rl20 (\1\:B1 \5\:B1) resistor r=103.297 c=0
Rl10 (n1 \5\:n1) resistor r=30.0028 c=0
Rl9 (n1 \4\:n1) resistor r=29.579 c=0
Rl5 (\2\:n0 n0) resistor r=90.1797 c=0
Rl13 (\2\:n0 \6\:n0) resistor r=90.1797 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz9 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz10 (\5\:VDD \1\:VDD) resistor r=9.375 c=0
Rz1 (\9\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry10 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry11 (\3\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry12 (\3\:VSS \10\:VSS) resistor r=31 c=0
Ry15 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry6 (n4 \3\:n4) resistor r=62 c=0
Ry9 (\11\:n4 \10\:n4) resistor r=31 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx3 (\7\:n1 n1) resistor r=45 c=0
mn1 (\8\:n1 \3\:A1N \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.988e-14 ad=2.755e-14 ps=1.71e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (\10\:n0 \3\:A0N \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.988e-14 ad=2.538e-14 ps=1.71e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2_1__rcx (11 n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.425e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (\6\:Y \4\:n1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.32e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\6\:Y \5\:n1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.115e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (12 \6\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=2.99e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=9.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\7\:VSS \3\:B0 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=6.63e-14 ps=8.4e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=6.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (13 \5\:B1 \8\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.115e-06 sb=4.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_1__rcx (14 \4\:B1 \8\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\1\:VSS \7\:B0 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp0 (\12\:n0 \1\:A0N \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.05e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4186e-07 sd=160n sca=31.8032 \
        scb=0.0262603 scc=0.00373148 m=(1)
mp2 (n4 \2\:n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.605e-14 ps=1.1e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28718e-07 sb=1.625e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp3 (\10\:n4 n1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.33718e-07 sb=1.42e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(2)
mp4 (\1\:Y B0 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.98718e-07 sb=7.55e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(2)
mp5 (\1\:Y \1\:B1 \3\:n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.20372e-06 sb=5.5e-07 sd=160n sca=14.0716 \
        scb=0.0123579 scc=0.000647567 m=(2)
ends AOI2BB2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:35:29 2012 )
// Library name: gsclib045
// Cell name: AOI2BB2X4
// View name: extracted

simulator lang=spectre

subckt AOI2BB2X4 A0N A1N B0 B1 VDD VSS Y
mp1 (\17\:net144 \1\:A1N \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.26538e-07 sd=160n sca=18.6612 \
        scb=0.0194292 scc=0.000712894 m=(1)
C1 (Y VSS) capacitor c=3.53567e-16
C2 (A0N VSS) capacitor c=7.39729e-17
C3 (A1N VSS) capacitor c=9.15986e-17
C4 (B0 VSS) capacitor c=6.84269e-16
C5 (VDD VSS) capacitor c=1.98233e-16
C6 (B1 VSS) capacitor c=4.02346e-16
C7 (net144 VSS) capacitor c=6.23334e-17
C8 (net148 VSS) capacitor c=7.46855e-17
C9 (12 VSS) capacitor c=1.73025e-18
C10 (13 VSS) capacitor c=1.73025e-18
C11 (14 VSS) capacitor c=4.73764e-18
C12 (15 VSS) capacitor c=5.31477e-18
C13 (17 VSS) capacitor c=2.03972e-18
C14 (18 VSS) capacitor c=1.00853e-17
C15 (net127 VSS) capacitor c=7.2716e-16
C16 (\1\:A0N VSS) capacitor c=4.82809e-17
C17 (\1\:A1N VSS) capacitor c=4.5369e-17
C18 (\13\:B0 VSS) capacitor c=3.24447e-17
C19 (\11\:B1 VSS) capacitor c=4.63312e-17
C20 (\13\:B1 VSS) capacitor c=5.01204e-17
C21 (\9\:B0 VSS) capacitor c=3.74808e-17
C22 (\8\:B0 VSS) capacitor c=2.82348e-17
C23 (\1\:B1 VSS) capacitor c=2.8427e-17
C24 (\5\:B1 VSS) capacitor c=4.08673e-17
C25 (\3\:B0 VSS) capacitor c=3.64163e-17
C26 (\13\:net148 VSS) capacitor c=4.68587e-17
C27 (\11\:net144 VSS) capacitor c=2.36987e-17
C28 (\10\:net144 VSS) capacitor c=4.46799e-17
C29 (\4\:net148 VSS) capacitor c=6.14103e-17
C30 (\8\:net148 VSS) capacitor c=5.72333e-17
C31 (\5\:net144 VSS) capacitor c=4.66433e-17
C32 (\3\:A0N VSS) capacitor c=3.38302e-17
C33 (\3\:A1N VSS) capacitor c=2.98516e-17
C34 (\2\:net144 VSS) capacitor c=6.03441e-16
C35 (\2\:net148 VSS) capacitor c=6.49372e-16
C36 (\2\:A0N VSS) capacitor c=3.43385e-17
C37 (\2\:A1N VSS) capacitor c=3.91393e-17
C38 (\18\:net148 VSS) capacitor c=5.74326e-17
C39 (\18\:VDD VSS) capacitor c=3.62595e-17
C40 (\17\:net144 VSS) capacitor c=8.46657e-17
C41 (\1\:VDD VSS) capacitor c=9.43097e-17
C42 (\1\:Y VSS) capacitor c=8.88911e-17
C43 (\17\:Y VSS) capacitor c=4.73472e-17
C44 (\13\:Y VSS) capacitor c=8.83582e-17
C45 (\15\:Y VSS) capacitor c=7.92684e-17
C46 (\20\:net148 VSS) capacitor c=4.73676e-17
C47 (\15\:net144 VSS) capacitor c=1.99718e-16
C48 (\2\:B1 VSS) capacitor c=2.23355e-17
C49 (\4\:A1N VSS) capacitor c=4.17298e-17
C50 (\4\:A0N VSS) capacitor c=5.80703e-17
C51 (\17\:net148 VSS) capacitor c=4.31367e-17
C52 (\12\:Y VSS) capacitor c=8.86297e-17
C53 (\3\:VDD VSS) capacitor c=2.77973e-16
C54 (\8\:VDD VSS) capacitor c=8.16677e-18
Rk13 (\2\:Y Y) resistor r=0.3821 c=0
Rk19 (Y \12\:Y) resistor r=0.4902 c=0
Rk20 (\12\:Y \14\:Y) resistor r=0.2977 c=0
Rk21 (\14\:Y \16\:Y) resistor r=0.4686 c=0
Rk22 (\12\:Y \18\:Y) resistor r=0.3133 c=0
Rk2 (A0N \4\:A0N) resistor r=0.174 c=0
Rk1 (A1N \4\:A1N) resistor r=0.06001 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.6743 c=0
Rk56 (\3\:VDD \8\:VDD) resistor r=0.3105 c=0
Rk58 (\9\:VDD VDD) resistor r=0.0499 c=0
Rk57 (\8\:VDD \9\:VDD) resistor r=0.1177 c=0
Rk63 (\8\:VDD \19\:VDD) resistor r=0.2217 c=0
Rk37 (\2\:VSS \4\:VSS) resistor r=0.4471 c=0
Rk38 (\4\:VSS \5\:VSS) resistor r=0.1452 c=0
Rk39 (\5\:VSS \6\:VSS) resistor r=0.4259 c=0
Rk40 (\6\:VSS \7\:VSS) resistor r=0.3607 c=0
Rk41 (\7\:VSS \8\:VSS) resistor r=0.07001 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.2255 c=0
Rk43 (\9\:VSS \10\:VSS) resistor r=0.3958 c=0
Rk45 (\11\:VSS VSS) resistor r=0.0499 c=0
Rk44 (\10\:VSS \11\:VSS) resistor r=0.08004 c=0
Rk46 (\5\:VSS \13\:VSS) resistor r=0.2076 c=0
Rk47 (\6\:VSS \15\:VSS) resistor r=0.1993 c=0
Rk48 (\7\:VSS \17\:VSS) resistor r=0.1993 c=0
Rk49 (\9\:VSS \19\:VSS) resistor r=0.2069 c=0
Rk50 (\10\:VSS \21\:VSS) resistor r=0.2366 c=0
Rk4 (\2\:net144 \16\:net144) resistor r=1.2504 c=0
Rk5 (\16\:net144 \18\:net144) resistor r=0.6517 c=0
Rk8 (\2\:net148 \17\:net148) resistor r=0.2067 c=0
Rk9 (\17\:net148 \19\:net148) resistor r=0.2172 c=0
Rk10 (\17\:net148 \21\:net148) resistor r=0.2177 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=56.461 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=92.3077 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=57.1429 c=0
Rl45 (B0 \13\:B0) resistor r=39.5604 c=0
Rl36 (B0 \9\:B0) resistor r=41.5412 c=0
Rl35 (B0 \8\:B0) resistor r=39.6174 c=0
Rl26 (B0 \3\:B0) resistor r=41.1873 c=0
Rl41 (B1 \11\:B1) resistor r=103.08 c=0
Rl43 (B1 \13\:B1) resistor r=106.868 c=0
Rl29 (\2\:B1 B1) resistor r=38.2679 c=0
Rl28 (\2\:B1 \1\:B1) resistor r=33.7068 c=0
Rl31 (\2\:B1 \5\:B1) resistor r=90.7134 c=0
Rl7 (\2\:net144 net144) resistor r=82.6695 c=0
Rl20 (\2\:net144 \11\:net144) resistor r=30.0028 c=0
Rl19 (\2\:net144 \10\:net144) resistor r=29.579 c=0
Rl10 (\2\:net144 \5\:net144) resistor r=28.9526 c=0
Rl5 (\2\:net148 net148) resistor r=165.08 c=0
Rl24 (\2\:net148 \13\:net148) resistor r=102.726 c=0
Rl12 (\2\:net148 \4\:net148) resistor r=124.51 c=0
Rl15 (\2\:net148 \8\:net148) resistor r=94.6154 c=0
Rz3 (\2\:Y \1\:Y) resistor r=75 c=0
Rz4 (\14\:Y \13\:Y) resistor r=75 c=0
Rz5 (\16\:Y \15\:Y) resistor r=75 c=0
Rz6 (\18\:Y \17\:Y) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=9.375 c=0
Rz14 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz15 (\9\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz10 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz11 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz12 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\16\:net144 \15\:net144) resistor r=75 c=0
Rz2 (\21\:net148 \20\:net148) resistor r=75 c=0
Ry23 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry17 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \11\:VSS) resistor r=31 c=0
Ry1 (\18\:net144 \17\:net144) resistor r=62 c=0
Ry2 (\19\:net148 \18\:net148) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
mn1 (\15\:net144 \3\:A1N \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (\20\:net148 \3\:A0N \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (11 net148 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_1__rcx (\15\:Y \5\:net144 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (\15\:Y net144 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_2__rcx (12 \8\:net148 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (13 \4\:net148 \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_3__rcx (\13\:Y \10\:net144 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\13\:Y \11\:net144 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.93e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (14 \13\:net148 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.725e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\14\:VSS \3\:B0 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.52e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (15 \5\:B1 \17\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.94e-14 ps=8.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_1__rcx (16 \1\:B1 \17\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.38e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.08e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\12\:VSS \8\:B0 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.38e-14 ad=4.16e-14 ps=7.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.05e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (\12\:VSS \9\:B0 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.16e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_2__rcx (17 \13\:B1 \1\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.08e-14 ps=1e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.75e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_3__rcx (18 \11\:B1 \1\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.73e-14 ps=1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.9e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4_3__rcx (\1\:VSS \13\:B0 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=3.64e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mp0 (\18\:net148 \1\:A0N \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=4.74e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.21538e-07 sd=160n sca=14.9537 \
        scb=0.0131754 scc=0.000560012 m=(1)
mp2_1__rcx (net127 \2\:net148 \3\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=5.775e-14 ps=1.1e-06 pd=1.09e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.12308e-07 sb=2e-06 sd=160n \
        sca=18.3986 scb=0.0159927 scc=0.00159615 m=(4)
mp3_1__rcx (net127 \2\:net144 \3\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.17308e-07 sb=2e-06 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(4)
mp4_1__rcx (Y B0 net127 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.75231e-06 sb=1.575e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp5_1__rcx (Y B1 net127 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95731e-06 sb=1.37e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
ends AOI2BB2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:36:06 2012 )
// Library name: gsclib045
// Cell name: AOI2BB2XL
// View name: extracted

simulator lang=spectre

subckt AOI2BB2XL A0N A1N B0 B1 VDD VSS Y
mp1 (\7\:net164 \1\:A1N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.38488e-07 sd=160n sca=16.1102 \
        scb=0.0158781 scc=0.000281876 m=(1)
C1 (Y VSS) capacitor c=8.93986e-17
C2 (A0N VSS) capacitor c=4.44785e-17
C3 (A1N VSS) capacitor c=2.8661e-17
C4 (B0 VSS) capacitor c=3.09961e-17
C5 (B1 VSS) capacitor c=9.21847e-17
C6 (VDD VSS) capacitor c=1.49503e-16
C7 (net164 VSS) capacitor c=6.08798e-17
C8 (net146 VSS) capacitor c=5.5679e-17
C9 (net144 VSS) capacitor c=8.767e-19
C10 (net156 VSS) capacitor c=6.87186e-18
C11 (net124 VSS) capacitor c=4.69748e-17
C12 (\1\:B0 VSS) capacitor c=3.36703e-17
C13 (\1\:B1 VSS) capacitor c=3.89459e-17
C14 (\4\:net146 VSS) capacitor c=3.59247e-17
C15 (\1\:A0N VSS) capacitor c=4.53839e-17
C16 (\1\:A1N VSS) capacitor c=3.21417e-17
C17 (\3\:B0 VSS) capacitor c=2.34843e-17
C18 (\3\:B1 VSS) capacitor c=3.84054e-17
C19 (\2\:net164 VSS) capacitor c=6.38077e-17
C20 (\3\:A0N VSS) capacitor c=3.41201e-17
C21 (\3\:A1N VSS) capacitor c=5.16054e-17
C22 (\2\:B0 VSS) capacitor c=2.8565e-17
C23 (\2\:B1 VSS) capacitor c=4.07312e-17
C24 (\3\:net164 VSS) capacitor c=3.33401e-17
C25 (\3\:net146 VSS) capacitor c=2.43209e-17
C26 (\2\:A0N VSS) capacitor c=4.05449e-17
C27 (\2\:A1N VSS) capacitor c=4.04967e-17
C28 (\5\:net124 VSS) capacitor c=5.81939e-17
C29 (\1\:Y VSS) capacitor c=9.66695e-17
C30 (\3\:net124 VSS) capacitor c=8.60044e-17
C31 (\7\:VDD VSS) capacitor c=4.21604e-17
C32 (\7\:net146 VSS) capacitor c=5.79298e-17
C33 (\9\:VDD VSS) capacitor c=3.64608e-17
C34 (\7\:net164 VSS) capacitor c=8.62351e-17
C35 (\1\:VDD VSS) capacitor c=4.10682e-17
C36 (\3\:Y VSS) capacitor c=1.2084e-16
C37 (\9\:net146 VSS) capacitor c=3.80962e-17
C38 (\5\:net164 VSS) capacitor c=1.8085e-16
C39 (\2\:net146 VSS) capacitor c=3.73232e-17
C40 (\4\:A1N VSS) capacitor c=9.53496e-17
C41 (\4\:A0N VSS) capacitor c=7.49621e-17
C42 (\5\:net146 VSS) capacitor c=3.384e-17
C43 (\6\:net146 VSS) capacitor c=5.33861e-17
C44 (\4\:net164 VSS) capacitor c=1.30218e-16
C45 (\4\:B1 VSS) capacitor c=2.89421e-17
C46 (\4\:B0 VSS) capacitor c=6.28047e-17
C47 (\3\:VDD VSS) capacitor c=6.52398e-18
C48 (\5\:VDD VSS) capacitor c=8.78513e-18
Rk12 (\4\:Y Y) resistor r=0.4266 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5505 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.06242 c=0
Rk17 (\3\:VSS \4\:VSS) resistor r=0.3884 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.4014 c=0
Rk20 (\6\:VSS VSS) resistor r=0.04984 c=0
Rk19 (\5\:VSS \6\:VSS) resistor r=0.09998 c=0
Rk21 (\3\:VSS \8\:VSS) resistor r=0.3095 c=0
Rk22 (\4\:VSS \10\:VSS) resistor r=0.07138 c=0
Rk23 (\5\:VSS \12\:VSS) resistor r=0.07323 c=0
Rk4 (\4\:A0N A0N) resistor r=0.1036 c=0
Rk3 (\4\:A1N A1N) resistor r=0.005982 c=0
Rk15 (B0 \4\:B0) resistor r=0.1854 c=0
Rk10 (\4\:B1 B1) resistor r=0.09348 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.2452 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.2052 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.2302 c=0
Rk28 (\6\:VDD VDD) resistor r=0.04984 c=0
Rk27 (\5\:VDD \6\:VDD) resistor r=0.12 c=0
Rk29 (\3\:VDD \8\:VDD) resistor r=0.3517 c=0
Rk30 (\5\:VDD \10\:VDD) resistor r=0.2584 c=0
Rk8 (\4\:net164 \6\:net164) resistor r=0.9559 c=0
Rk9 (\6\:net164 \8\:net164) resistor r=0.6795 c=0
Rk5 (\5\:net146 \6\:net146) resistor r=0.14 c=0
Rk6 (\6\:net146 \8\:net146) resistor r=0.4649 c=0
Rk7 (\6\:net146 \10\:net146) resistor r=0.1195 c=0
Rk13 (\2\:net124 \4\:net124) resistor r=0.385 c=0
Rk14 (\4\:net124 \6\:net124) resistor r=0.4406 c=0
Rl3 (\1\:A0N \2\:A0N) resistor r=160.771 c=0
Rl4 (\2\:A0N \3\:A0N) resistor r=33.8482 c=0
Rl1 (\1\:A1N \2\:A1N) resistor r=29.5379 c=0
Rl2 (\2\:A1N \3\:A1N) resistor r=168 c=0
Rl12 (\1\:B0 \2\:B0) resistor r=95.3867 c=0
Rl13 (\2\:B0 \3\:B0) resistor r=37.6944 c=0
Rl10 (\1\:B1 \2\:B1) resistor r=72.3097 c=0
Rl11 (\2\:B1 \3\:B1) resistor r=60.7713 c=0
Rl8 (net164 \2\:net164) resistor r=161.538 c=0
Rl9 (\2\:net164 \3\:net164) resistor r=29.5379 c=0
Rl5 (net146 \2\:net146) resistor r=82.6702 c=0
Rl7 (\2\:net146 \4\:net146) resistor r=99.6815 c=0
Rl6 (\2\:net146 \3\:net146) resistor r=92.233 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz4 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\5\:net164 \6\:net164) resistor r=75 c=0
Rz1 (\9\:net146 \10\:net146) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry9 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry10 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry11 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\7\:net164 \8\:net164) resistor r=62 c=0
Ry1 (\7\:net146 \8\:net146) resistor r=62 c=0
Ry4 (net124 \2\:net124) resistor r=62 c=0
Ry5 (\3\:net124 \4\:net124) resistor r=62 c=0
Ry6 (\5\:net124 \6\:net124) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:A1N \4\:A1N) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx4 (\3\:net164 \4\:net164) resistor r=45 c=0
Rx3 (\3\:net146 \5\:net146) resistor r=45 c=0
mn1 (\5\:net164 \3\:A1N \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.86e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn0 (\9\:net146 \3\:A0N \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.86e-14 ad=3.19e-14 ps=1.43e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.2e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (net144 net146 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.725e-14 ad=8.7e-15 ps=1.34e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.05e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\3\:Y \2\:net164 net144 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn5 (net156 \3\:B1 \3\:Y VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=3.95e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (\7\:VSS \3\:B0 net156 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp0 (\7\:net146 \1\:A0N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.87e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.33488e-07 sd=160n sca=12.5196 \
        scb=0.0098468 scc=0.00014175 m=(1)
mp2 (net124 \4\:net146 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.63e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=8.2e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp3 (\3\:net124 net164 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=6.15e-07 sd=160n sca=18.3739 \
        scb=0.0179115 scc=0.00142386 m=(1)
mp5 (\1\:Y \1\:B1 \3\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.32326e-07 sb=4.1e-07 sd=160n sca=19.4061 \
        scb=0.0187808 scc=0.00142556 m=(1)
mp4 (\1\:Y \1\:B0 \5\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=4.515e-14 ps=7.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.87326e-07 sb=1.55e-07 sd=160n sca=23.6629 \
        scb=0.0258087 scc=0.00159495 m=(1)
ends AOI2BB2XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:03:51 2012 )
// Library name: gsclib045
// Cell name: AOI31X1
// View name: extracted

simulator lang=spectre

subckt AOI31X1 A0 A1 A2 B0 VDD VSS Y
mp0 (net81 \3\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=18.8466 \
        scb=0.0203197 scc=0.000573038 m=(1)
C1 (Y VSS) capacitor c=1.85774e-17
C2 (A2 VSS) capacitor c=7.86189e-17
C3 (A1 VSS) capacitor c=8.2004e-17
C4 (VDD VSS) capacitor c=8.52842e-17
C5 (A0 VSS) capacitor c=5.05844e-17
C6 (B0 VSS) capacitor c=6.56714e-17
C7 (net81 VSS) capacitor c=1.00567e-16
C8 (\1\:B0 VSS) capacitor c=4.33396e-17
C9 (\1\:A2 VSS) capacitor c=5.73701e-17
C10 (\1\:A1 VSS) capacitor c=7.19411e-17
C11 (\3\:A0 VSS) capacitor c=4.54482e-17
C12 (\3\:B0 VSS) capacitor c=3.85851e-17
C13 (\3\:A2 VSS) capacitor c=6.01513e-17
C14 (\3\:A1 VSS) capacitor c=6.47379e-17
C15 (\1\:A0 VSS) capacitor c=7.37816e-17
C16 (\2\:B0 VSS) capacitor c=4.38065e-17
C17 (\2\:A2 VSS) capacitor c=6.29509e-17
C18 (\2\:A1 VSS) capacitor c=7.82413e-17
C19 (\2\:A0 VSS) capacitor c=5.75657e-17
C20 (\4\:Y VSS) capacitor c=2.2384e-17
C21 (\3\:net81 VSS) capacitor c=1.02821e-16
C22 (\7\:VDD VSS) capacitor c=7.10009e-17
C23 (\9\:VDD VSS) capacitor c=4.04035e-17
C24 (\1\:VDD VSS) capacitor c=5.14901e-17
C25 (\1\:Y VSS) capacitor c=1.2086e-16
C26 (\4\:A0 VSS) capacitor c=2.70655e-17
C27 (\4\:A1 VSS) capacitor c=4.72527e-17
C28 (\4\:A2 VSS) capacitor c=3.80121e-17
C29 (\4\:B0 VSS) capacitor c=5.32995e-17
C30 (\3\:Y VSS) capacitor c=9.13787e-17
C31 (\3\:VDD VSS) capacitor c=2.51972e-18
C32 (\5\:VDD VSS) capacitor c=1.53794e-18
Rk10 (\3\:Y Y) resistor r=0.01805 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.9703 c=0
Rk9 (\3\:Y \5\:Y) resistor r=0.2458 c=0
Rk4 (\6\:A2 A2) resistor r=0.001036 c=0
Rk5 (\4\:A2 \6\:A2) resistor r=0.05079 c=0
Rk2 (\4\:A1 A1) resistor r=0.1517 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.06752 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.233 c=0
Rk14 (\5\:VSS VSS) resistor r=0.09234 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1076 c=0
Rk15 (\3\:VSS \7\:VSS) resistor r=0.2232 c=0
Rk16 (\5\:VSS \9\:VSS) resistor r=0.2143 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.1528 c=0
Rk18 (\3\:VDD \4\:VDD) resistor r=0.09761 c=0
Rk20 (\5\:VDD VDD) resistor r=0.04219 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.1076 c=0
Rk22 (\3\:VDD \8\:VDD) resistor r=0.2343 c=0
Rk23 (\5\:VDD \10\:VDD) resistor r=0.2789 c=0
Rk1 (A0 \4\:A0) resistor r=0.1111 c=0
Rk7 (\4\:B0 B0) resistor r=0.1654 c=0
Rk6 (\2\:net81 \4\:net81) resistor r=0.5322 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=110.771 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=91.5405 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=175.692 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=78.079 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=138.261 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=113.462 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=93.4066 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz3 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry3 (\4\:Y \5\:Y) resistor r=31 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry1 (net81 \2\:net81) resistor r=31 c=0
Ry2 (\3\:net81 \4\:net81) resistor r=31 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net97 \1\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (net97 \3\:A1 net93 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \3\:A2 net93 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.29e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \3\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.29e-14 ps=8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (net81 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=14.4531 \
        scb=0.0120361 scc=0.000241045 m=(1)
mp2 (\3\:net81 \1\:A2 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.825e-14 ps=1.1e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.6e-07 sd=160n sca=14.3825 \
        scb=0.0118943 scc=0.000239579 m=(1)
mp3 (\4\:Y \1\:B0 \3\:net81 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=5.46e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=19.0814 \
        scb=0.0207066 scc=0.000603442 m=(1)
ends AOI31X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:37:19 2012 )
// Library name: gsclib045
// Cell name: AOI31X2
// View name: extracted

simulator lang=spectre

subckt AOI31X2 A0 A1 A2 B0 VDD VSS Y
mp0 (net81 \2\:A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=33.3935 \
        scb=0.0357498 scc=0.00324908 m=(2)
C1 (A0 VSS) capacitor c=3.37347e-17
C2 (VDD VSS) capacitor c=8.66891e-17
C3 (A1 VSS) capacitor c=3.31731e-17
C4 (Y VSS) capacitor c=4.23926e-17
C5 (A2 VSS) capacitor c=5.9422e-17
C6 (B0 VSS) capacitor c=5.52795e-17
C7 (9 VSS) capacitor c=1.36221e-18
C8 (10 VSS) capacitor c=4.82868e-18
C9 (11 VSS) capacitor c=4.22545e-18
C10 (12 VSS) capacitor c=2.8113e-18
C11 (net81 VSS) capacitor c=3.31899e-16
C12 (\1\:B0 VSS) capacitor c=7.13444e-17
C13 (\1\:A1 VSS) capacitor c=3.75752e-16
C14 (\6\:A0 VSS) capacitor c=5.87578e-17
C15 (\6\:A1 VSS) capacitor c=6.29192e-17
C16 (\1\:A2 VSS) capacitor c=3.83475e-17
C17 (\4\:A2 VSS) capacitor c=2.91865e-17
C18 (\3\:A1 VSS) capacitor c=6.02888e-17
C19 (\1\:A0 VSS) capacitor c=4.96065e-17
C20 (\7\:B0 VSS) capacitor c=1.72795e-17
C21 (\3\:A2 VSS) capacitor c=8.73966e-17
C22 (\2\:A0 VSS) capacitor c=4.42916e-16
C23 (\5\:Y VSS) capacitor c=4.98474e-17
C24 (\9\:VDD VSS) capacitor c=4.2508e-17
C25 (\1\:VDD VSS) capacitor c=4.08424e-17
C26 (\3\:Y VSS) capacitor c=8.40322e-17
C27 (\1\:Y VSS) capacitor c=8.74284e-17
C28 (\2\:A2 VSS) capacitor c=4.41106e-17
C29 (\4\:B0 VSS) capacitor c=7.64341e-17
C30 (\7\:A2 VSS) capacitor c=4.35105e-17
C31 (\3\:VDD VSS) capacitor c=1.18676e-16
Rk4 (A0 \2\:A0) resistor r=0.05589 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.0374 c=0
Rk27 (\6\:VDD VDD) resistor r=0.04988 c=0
Rk26 (\3\:VDD \6\:VDD) resistor r=0.05244 c=0
Rk29 (\3\:VDD \10\:VDD) resistor r=0.2799 c=0
Rk3 (\1\:A1 A1) resistor r=0.09536 c=0
Rk7 (\4\:Y Y) resistor r=0.2324 c=0
Rk6 (\2\:Y \4\:Y) resistor r=0.5358 c=0
Rk8 (Y \6\:Y) resistor r=0.2206 c=0
Rk17 (\1\:VSS \5\:VSS) resistor r=0.08658 c=0
Rk19 (\6\:VSS VSS) resistor r=0.03465 c=0
Rk18 (\5\:VSS \6\:VSS) resistor r=0.466 c=0
Rk22 (\6\:VSS \11\:VSS) resistor r=0.1987 c=0
Rk1 (A2 \7\:A2) resistor r=0.06041 c=0
Rk15 (B0 \9\:B0) resistor r=0.002997 c=0
Rl13 (\2\:A0 \6\:A0) resistor r=31.4665 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=29.8412 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=44.9225 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=44.9225 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=97.7009 c=0
Rl7 (\2\:A2 \4\:A2) resistor r=113.085 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=6.6414 c=0
Rl15 (\3\:B0 \1\:B0) resistor r=48.6954 c=0
Rl19 (\3\:B0 \7\:B0) resistor r=30.0336 c=0
Rl16 (\4\:B0 \3\:B0) resistor r=7.3053 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=9.375 c=0
Rz7 (\6\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz5 (\11\:VSS \10\:VSS) resistor r=75 c=0
Ry10 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\6\:Y \5\:Y) resistor r=62 c=0
Ry8 (VSS \4\:VSS) resistor r=62 c=0
Ry7 (\5\:VSS \4\:VSS) resistor r=6.8889 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
Rx6 (\9\:B0 \7\:B0) resistor r=45 c=0
mn0 (9 \1\:A0 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (9 \3\:A1 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.33e-14 \
        ad=1.56e-14 ps=9.3e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.345e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (\1\:Y \4\:A2 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.33e-14 \
        ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.95e-07 sb=1.095e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (\3\:Y \4\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=4.16e-14 ps=1.075e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.245e-06 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(2)
mn2_1__rcx (\1\:Y \1\:A2 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=8.9e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (11 \6\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=2.99e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=7.3e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_1__rcx (12 \6\:A0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.95e-14 ps=1.35e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=6.1e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp1 (net81 \1\:A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.37e-06 sd=160n sca=23.3597 \
        scb=0.0210771 scc=0.00188446 m=(2)
mp2 (net81 \3\:A2 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.165e-06 sd=160n sca=20.9872 \
        scb=0.0175085 scc=0.00184372 m=(2)
mp3 (\5\:Y \1\:B0 net81 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.45e-07 sd=160n sca=21.3165 \
        scb=0.0178846 scc=0.00184501 m=(2)
ends AOI31X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:37:56 2012 )
// Library name: gsclib045
// Cell name: AOI31X4
// View name: extracted

simulator lang=spectre

subckt AOI31X4 A0 A1 A2 B0 VDD VSS Y
mp0 (net89 A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.912 scb=0.0201637 \
        scc=0.00163433 m=(4)
C1 (A2 VSS) capacitor c=2.86518e-17
C2 (A1 VSS) capacitor c=3.75474e-16
C3 (A0 VSS) capacitor c=3.51678e-16
C4 (B0 VSS) capacitor c=3.43794e-16
C5 (VDD VSS) capacitor c=1.41484e-16
C6 (net101 VSS) capacitor c=3.0516e-16
C7 (net97 VSS) capacitor c=1.47954e-16
C8 (net89 VSS) capacitor c=6.87548e-16
C9 (\1\:A2 VSS) capacitor c=3.22776e-16
C10 (\4\:Y VSS) capacitor c=1.56569e-16
C11 (\1\:VDD VSS) capacitor c=7.42103e-17
C12 (\1\:Y VSS) capacitor c=3.1027e-16
C13 (\4\:net97 VSS) capacitor c=1.53256e-16
C14 (\3\:VDD VSS) capacitor c=9.43796e-17
C15 (\6\:VDD VSS) capacitor c=1.00849e-16
C16 (\9\:VDD VSS) capacitor c=1.06837e-16
Rk21 (Y \4\:Y) resistor r=0.01331 c=0
Rk20 (\1\:Y Y) resistor r=0.2519 c=0
Rk12 (\1\:A2 A2) resistor r=0.0566 c=0
Rk42 (\2\:VSS \3\:VSS) resistor r=0.1126 c=0
Rk45 (\3\:VSS \6\:VSS) resistor r=0.1326 c=0
Rk46 (\6\:VSS \7\:VSS) resistor r=0.7518 c=0
Rk49 (\8\:VSS VSS) resistor r=0.1023 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.2429 c=0
Rk54 (\2\:VDD \3\:VDD) resistor r=0.3181 c=0
Rk57 (\3\:VDD \6\:VDD) resistor r=0.2051 c=0
Rk59 (\6\:VDD \8\:VDD) resistor r=0.06747 c=0
Rk62 (\9\:VDD VDD) resistor r=0.2076 c=0
Rk60 (\8\:VDD \9\:VDD) resistor r=0.1376 c=0
Rk14 (net97 \4\:net97) resistor r=0.4187 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=12.5 c=0
Rz20 (\3\:VDD \1\:VDD) resistor r=75 c=0
Rz21 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry20 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry21 (\6\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry22 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0 (net101 A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn1 (net101 A1 \4\:net97 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2 (\1\:Y \1\:A2 net97 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn3 (\1\:Y B0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mp1 (net89 A1 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=18.3796 scb=0.0159892 \
        scc=0.00159615 m=(4)
mp2 (net89 \1\:A2 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.655e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(4)
mp3 (\4\:Y B0 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.361e-14 \
        ad=6.24e-14 ps=1.1575e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.35e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
ends AOI31X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:38:35 2012 )
// Library name: gsclib045
// Cell name: AOI31XL
// View name: extracted

simulator lang=spectre

subckt AOI31XL A0 A1 A2 B0 VDD VSS Y
mp0 (net89 \1\:A0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=9.95e-07 sd=160n sca=17.5166 scb=0.0182556 \
        scc=0.000475856 m=(1)
C1 (A2 VSS) capacitor c=4.41489e-17
C2 (A1 VSS) capacitor c=9.61583e-17
C3 (Y VSS) capacitor c=2.38486e-17
C4 (VDD VSS) capacitor c=1.17935e-16
C5 (A0 VSS) capacitor c=5.07746e-17
C6 (B0 VSS) capacitor c=7.13322e-17
C7 (net101 VSS) capacitor c=1.59504e-18
C8 (net97 VSS) capacitor c=4.09452e-18
C9 (net89 VSS) capacitor c=3.01396e-17
C10 (\1\:B0 VSS) capacitor c=2.33485e-17
C11 (\1\:A2 VSS) capacitor c=5.15088e-17
C12 (\1\:A1 VSS) capacitor c=4.74723e-17
C13 (\1\:A0 VSS) capacitor c=2.82467e-17
C14 (\3\:B0 VSS) capacitor c=3.31116e-17
C15 (\3\:A2 VSS) capacitor c=2.64786e-17
C16 (\3\:A1 VSS) capacitor c=3.06263e-17
C17 (\3\:A0 VSS) capacitor c=3.28857e-17
C18 (\2\:B0 VSS) capacitor c=3.35461e-17
C19 (\2\:A2 VSS) capacitor c=3.55548e-17
C20 (\2\:A1 VSS) capacitor c=3.95143e-17
C21 (\2\:A0 VSS) capacitor c=3.33947e-17
C22 (\1\:Y VSS) capacitor c=4.14993e-17
C23 (\3\:net89 VSS) capacitor c=5.78519e-17
C24 (\4\:VDD VSS) capacitor c=1.28166e-17
C25 (\8\:VDD VSS) capacitor c=3.16193e-18
C26 (\1\:VDD VSS) capacitor c=4.96552e-17
C27 (\4\:Y VSS) capacitor c=6.27615e-17
C28 (\4\:A0 VSS) capacitor c=1.51632e-17
C29 (\4\:A2 VSS) capacitor c=6.36773e-17
C30 (\4\:B0 VSS) capacitor c=3.34225e-17
C31 (\3\:Y VSS) capacitor c=6.10153e-17
Rk3 (A2 \4\:A2) resistor r=0.01337 c=0
Rk2 (\4\:A1 A1) resistor r=0.002876 c=0
Rk8 (\3\:Y Y) resistor r=0.08474 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.2153 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4511 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.249 c=0
Rk15 (\3\:VDD \5\:VDD) resistor r=0.1181 c=0
Rk16 (\3\:VDD \6\:VDD) resistor r=0.15 c=0
Rk19 (\7\:VDD VDD) resistor r=0.05185 c=0
Rk17 (\6\:VDD \7\:VDD) resistor r=0.09691 c=0
Rk18 (\7\:VDD \9\:VDD) resistor r=0.07243 c=0
Rk1 (\4\:A0 A0) resistor r=0.073 c=0
Rk9 (\2\:VSS \4\:VSS) resistor r=0.4794 c=0
Rk11 (\5\:VSS VSS) resistor r=0.06678 c=0
Rk10 (\4\:VSS \5\:VSS) resistor r=0.331 c=0
Rk13 (\5\:VSS \8\:VSS) resistor r=0.3578 c=0
Rk5 (\4\:B0 B0) resistor r=0.02648 c=0
Rk4 (\2\:net89 \4\:net89) resistor r=0.2755 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=112.694 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=79.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=60.3072 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=110.307 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=24.2328 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=112.694 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz5 (\1\:VDD \3\:VDD) resistor r=75 c=0
Rz6 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry7 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry5 (\3\:VSS VSS) resistor r=62 c=0
Ry4 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry1 (net89 \2\:net89) resistor r=62 c=0
Ry2 (\3\:net89 \4\:net89) resistor r=62 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net101 \3\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (net101 \3\:A1 net97 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (\4\:Y \3\:A2 net97 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\4\:Y \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (net89 \1\:A1 \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=7.9e-07 sd=160n sca=13.9261 \
        scb=0.0122243 scc=0.000335729 m=(1)
mp2 (\3\:net89 \1\:A2 \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.87e-14 ps=1.52e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=5.25e-07 sd=160n sca=12.9171 \
        scb=0.0110416 scc=0.000332167 m=(1)
mp3 (\1\:Y \1\:B0 \3\:net89 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=6.45e-14 ps=7.9e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=3e-07 sd=160n sca=13.7104 scb=0.0119478 \
        scc=0.000334396 m=(1)
ends AOI31XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:39:12 2012 )
// Library name: gsclib045
// Cell name: AOI32X1
// View name: extracted

simulator lang=spectre

subckt AOI32X1 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (\5\:net114 \1\:A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=25.2855 \
        scb=0.0288799 scc=0.00168046 m=(1)
C1 (B1 VSS) capacitor c=4.64829e-17
C2 (A0 VSS) capacitor c=3.57496e-17
C3 (Y VSS) capacitor c=6.78996e-17
C4 (A2 VSS) capacitor c=4.82796e-17
C5 (VDD VSS) capacitor c=1.03708e-16
C6 (B0 VSS) capacitor c=2.91237e-17
C7 (net126 VSS) capacitor c=3.28987e-18
C8 (net122 VSS) capacitor c=2.41572e-18
C9 (net118 VSS) capacitor c=2.72112e-18
C10 (net114 VSS) capacitor c=5.75427e-17
C11 (\1\:B0 VSS) capacitor c=5.0758e-17
C12 (\1\:B1 VSS) capacitor c=5.47079e-17
C13 (\1\:A2 VSS) capacitor c=7.26062e-17
C14 (\1\:A1 VSS) capacitor c=7.15411e-17
C15 (\1\:A0 VSS) capacitor c=4.46117e-17
C16 (\3\:B0 VSS) capacitor c=3.51396e-17
C17 (\3\:B1 VSS) capacitor c=3.77887e-17
C18 (\3\:A2 VSS) capacitor c=3.25243e-17
C19 (\3\:A1 VSS) capacitor c=4.24017e-17
C20 (\4\:A0 VSS) capacitor c=3.67501e-17
C21 (\2\:B0 VSS) capacitor c=4.40069e-17
C22 (\2\:B1 VSS) capacitor c=4.83172e-17
C23 (\2\:A2 VSS) capacitor c=4.82759e-17
C24 (\2\:A1 VSS) capacitor c=6.43067e-17
C25 (\3\:A0 VSS) capacitor c=1.48462e-17
C26 (\1\:Y VSS) capacitor c=7.43688e-17
C27 (\3\:net114 VSS) capacitor c=9.32736e-17
C28 (\6\:VDD VSS) capacitor c=4.0469e-17
C29 (\5\:net114 VSS) capacitor c=7.02613e-17
C30 (\4\:VDD VSS) capacitor c=4.55823e-17
C31 (\3\:Y VSS) capacitor c=9.30921e-17
C32 (\2\:A0 VSS) capacitor c=3.49795e-17
C33 (\5\:A0 VSS) capacitor c=5.26806e-17
C34 (\4\:A1 VSS) capacitor c=6.32656e-17
C35 (\6\:A1 VSS) capacitor c=4.29648e-17
C36 (\5\:A2 VSS) capacitor c=5.75898e-17
C37 (\4\:B1 VSS) capacitor c=6.42878e-17
C38 (\5\:B0 VSS) capacitor c=2.84155e-17
C39 (\3\:VDD VSS) capacitor c=5.46184e-17
Rk8 (B1 \4\:B1) resistor r=0.1163 c=0
Rk1 (A0 \5\:A0) resistor r=0.1767 c=0
Rk9 (\2\:Y Y) resistor r=0.249 c=0
Rk10 (Y \4\:Y) resistor r=0.4035 c=0
Rk7 (A2 \5\:A2) resistor r=0.005989 c=0
Rk20 (\3\:VDD VDD) resistor r=0.2054 c=0
Rk21 (VDD \5\:VDD) resistor r=0.2553 c=0
Rk22 (\3\:VDD \7\:VDD) resistor r=0.1931 c=0
Rk2 (\4\:A1 \5\:A1) resistor r=0.002562 c=0
Rk3 (A1 \6\:A1) resistor r=0.002476 c=0
Rk4 (\4\:A1 \6\:A1) resistor r=0.07567 c=0
Rk17 (\4\:VSS VSS) resistor r=0.3008 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.5158 c=0
Rk18 (VSS \6\:VSS) resistor r=0.3131 c=0
Rk11 (\4\:B0 \5\:B0) resistor r=0.001269 c=0
Rk12 (\6\:B0 B0) resistor r=0.001396 c=0
Rk13 (\5\:B0 \6\:B0) resistor r=0.01797 c=0
Rk14 (\2\:net114 \4\:net114) resistor r=0.4828 c=0
Rk15 (\4\:net114 \6\:net114) resistor r=0.4341 c=0
Rl8 (\1\:B1 \2\:B1) resistor r=91.5405 c=0
Rl9 (\2\:B1 \3\:B1) resistor r=53.079 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=125.803 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=37.3411 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.013 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=132.246 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=117.565 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl10 (\1\:B0 \2\:B0) resistor r=110.771 c=0
Rl11 (\2\:B0 \3\:B0) resistor r=50.3716 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=31 c=0
Ry7 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (net114 \2\:net114) resistor r=20.6667 c=0
Ry3 (\3\:net114 \4\:net114) resistor r=31 c=0
Ry4 (\5\:net114 \6\:net114) resistor r=31 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \5\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
Rx5 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net126 \4\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.99e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.55e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn1 (net126 \3\:A1 net122 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=2.99e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=7.95e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn2 (\3\:Y \3\:A2 net122 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=5.98e-14 ps=8.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=5.95e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn4 (\3\:Y \3\:B1 net118 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.98e-14 ps=7.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.2e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn3 (net118 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.51e-14 ps=8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mp1 (\5\:net114 \1\:A1 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.23e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=15.2518 \
        scb=0.0142072 scc=0.000315834 m=(1)
mp2 (\3\:net114 \1\:A2 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.23e-14 ad=7.02e-14 ps=1.43e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.7e-07 sd=160n sca=13.3156 \
        scb=0.0107792 scc=0.000275125 m=(1)
mp4 (\1\:Y \1\:B1 \3\:net114 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=6.24e-14 ps=1.14e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=13.5349 \
        scb=0.0111426 scc=0.000276613 m=(1)
mp3 (\1\:Y \1\:B0 net114 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=16.4194 \
        scb=0.0162738 scc=0.000375337 m=(1)
ends AOI32X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:39:50 2012 )
// Library name: gsclib045
// Cell name: AOI32X2
// View name: extracted

simulator lang=spectre

subckt AOI32X2 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (net47 A0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.4492 scb=0.017739 \
        scc=0.000533089 m=(2)
C1 (B1 VSS) capacitor c=5.17948e-17
C2 (A2 VSS) capacitor c=7.47507e-17
C3 (VDD VSS) capacitor c=1.46016e-16
C4 (A0 VSS) capacitor c=4.39905e-16
C5 (Y VSS) capacitor c=2.17513e-17
C6 (A1 VSS) capacitor c=1.93986e-17
C7 (B0 VSS) capacitor c=3.3973e-16
C8 (10 VSS) capacitor c=1.92813e-18
C9 (11 VSS) capacitor c=5.26255e-18
C10 (12 VSS) capacitor c=2.77956e-18
C11 (13 VSS) capacitor c=9.71586e-18
C12 (14 VSS) capacitor c=4.61637e-18
C13 (15 VSS) capacitor c=6.32374e-18
C14 (net47 VSS) capacitor c=3.5502e-16
C15 (\1\:B1 VSS) capacitor c=8.36561e-17
C16 (\1\:A1 VSS) capacitor c=3.58592e-16
C17 (\6\:B0 VSS) capacitor c=1.94569e-17
C18 (\4\:B1 VSS) capacitor c=2.12797e-17
C19 (\6\:B1 VSS) capacitor c=4.58855e-17
C20 (\1\:B0 VSS) capacitor c=4.08368e-17
C21 (\6\:A0 VSS) capacitor c=3.20648e-17
C22 (\6\:A1 VSS) capacitor c=5.82842e-17
C23 (\1\:A2 VSS) capacitor c=6.40117e-17
C24 (\5\:A2 VSS) capacitor c=2.39746e-17
C25 (\3\:A1 VSS) capacitor c=5.85117e-17
C26 (\1\:A0 VSS) capacitor c=4.58538e-17
C27 (\3\:A2 VSS) capacitor c=9.22526e-17
C28 (\4\:net47 VSS) capacitor c=8.95394e-17
C29 (\7\:Y VSS) capacitor c=1.46168e-16
C30 (\11\:VDD VSS) capacitor c=3.89795e-17
C31 (\1\:VDD VSS) capacitor c=9.81158e-17
C32 (\1\:Y VSS) capacitor c=5.07546e-17
C33 (\4\:Y VSS) capacitor c=7.83937e-17
C34 (\2\:A2 VSS) capacitor c=1.86552e-17
C35 (\3\:B1 VSS) capacitor c=2.03189e-17
C36 (\7\:A2 VSS) capacitor c=3.83647e-17
C37 (\3\:Y VSS) capacitor c=9.85553e-17
C38 (\6\:Y VSS) capacitor c=4.88781e-17
C39 (\7\:B1 VSS) capacitor c=5.06661e-17
C40 (\3\:VDD VSS) capacitor c=9.19742e-17
Rk12 (B1 \7\:B1) resistor r=0.02928 c=0
Rk1 (\7\:A2 A2) resistor r=0.2025 c=0
Rk28 (\2\:VDD \3\:VDD) resistor r=0.3306 c=0
Rk34 (\8\:VDD VDD) resistor r=0.04987 c=0
Rk33 (\3\:VDD \8\:VDD) resistor r=0.1101 c=0
Rk36 (\3\:VDD \12\:VDD) resistor r=0.1995 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3186 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4836 c=0
Rk9 (\6\:Y Y) resistor r=0.02559 c=0
Rk10 (\6\:Y \7\:Y) resistor r=0.2431 c=0
Rk8 (\3\:Y \6\:Y) resistor r=0.3845 c=0
Rk21 (\2\:VSS \4\:VSS) resistor r=0.4718 c=0
Rk22 (\4\:VSS \5\:VSS) resistor r=0.3256 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.3256 c=0
Rk25 (\7\:VSS VSS) resistor r=0.1073 c=0
Rk24 (\6\:VSS \7\:VSS) resistor r=0.2429 c=0
Rk26 (\5\:VSS \9\:VSS) resistor r=0.1021 c=0
Rk27 (\7\:VSS \11\:VSS) resistor r=0.2815 c=0
Rk2 (A1 \1\:A1) resistor r=0.02396 c=0
Rl17 (\3\:B1 \1\:B1) resistor r=23.8563 c=0
Rl18 (\3\:B1 \4\:B1) resistor r=32.7557 c=0
Rl20 (\3\:B1 \6\:B1) resistor r=82.1768 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=82.6702 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=49.9779 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=49.0067 c=0
Rl13 (A0 \6\:A0) resistor r=28.1859 c=0
Rl1 (A0 \1\:A0) resistor r=29.8412 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=47.2527 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=35.3072 c=0
Rl22 (B0 \6\:B0) resistor r=37.3411 c=0
Rl14 (B0 \1\:B0) resistor r=24.7951 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz9 (\8\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz5 (\10\:VSS \11\:VSS) resistor r=75 c=0
Ry13 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry11 (\3\:VSS \6\:VSS) resistor r=7.75 c=0
Ry5 (net47 \4\:net47) resistor r=62 c=0
Rx6 (\7\:B1 \1\:B1) resistor r=45 c=0
Rx1 (\7\:A2 \3\:A2) resistor r=45 c=0
mn0_1__rcx (10 \1\:A0 \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1_1__rcx (10 \3\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=1.56e-14 ps=8.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.955e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_1__rcx (\4\:Y \5\:A2 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.735e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\4\:Y \1\:A2 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.7e-07 sb=1.53e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (12 \6\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.72e-14 \
        ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.75e-07 sb=1.425e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn0 (13 \6\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.177e-13 ad=5.72e-14 ps=1.77e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.16e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (14 \1\:B0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.177e-13 ad=3.12e-14 ps=1.77e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=8.1e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4 (\1\:Y \6\:B1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.12e-14 \
        ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.555e-06 sb=6.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn4_1__rcx (\1\:Y \4\:B1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=4.16e-14 ps=1.03e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=4.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3_1__rcx (15 \6\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=6.63e-14 ps=8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp1 (net47 \1\:A1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.955e-06 sd=160n sca=14.0779 \
        scb=0.0121323 scc=0.000415426 m=(2)
mp2 (net47 \3\:A2 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.75e-06 sd=160n sca=12.9062 \
        scb=0.0110166 scc=0.000412479 m=(2)
mp3 (\7\:Y B0 net47 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.41e-14 \
        ad=8.093e-14 ps=1.16e-06 pd=1.195e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.45e-06 sb=8.5e-07 sd=160n sca=12.4042 scb=0.0108296 \
        scc=0.000412414 m=(2)
mp4 (\7\:Y \1\:B1 \4\:net47 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.093e-14 ps=1.1e-06 pd=1.195e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=6.45e-07 sd=160n sca=12.9823 \
        scb=0.0110609 scc=0.000412509 m=(2)
ends AOI32X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:40:28 2012 )
// Library name: gsclib045
// Cell name: AOI32X4
// View name: extracted

simulator lang=spectre

subckt AOI32X4 A0 A1 A2 B0 B1 VDD VSS Y
mp0_1__rcx (net106 A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=24.9718 scb=0.0274046 \
        scc=0.00171026 m=(4)
C1 (B1 VSS) capacitor c=3.9006e-16
C2 (A2 VSS) capacitor c=4.84552e-16
C3 (VDD VSS) capacitor c=1.84275e-16
C4 (A0 VSS) capacitor c=8.69785e-16
C5 (Y VSS) capacitor c=7.59364e-17
C6 (A1 VSS) capacitor c=2.56353e-17
C7 (B0 VSS) capacitor c=5.60666e-16
C8 (10 VSS) capacitor c=1.3429e-18
C9 (11 VSS) capacitor c=4.08664e-18
C10 (12 VSS) capacitor c=2.23291e-18
C11 (13 VSS) capacitor c=4.22545e-18
C12 (14 VSS) capacitor c=3.93582e-18
C13 (15 VSS) capacitor c=8.50463e-18
C14 (16 VSS) capacitor c=7.45868e-18
C15 (17 VSS) capacitor c=4.16847e-18
C16 (18 VSS) capacitor c=3.58574e-18
C17 (19 VSS) capacitor c=1.90394e-18
C18 (20 VSS) capacitor c=2.01768e-18
C19 (net106 VSS) capacitor c=7.99581e-16
C20 (\12\:B0 VSS) capacitor c=7.10391e-17
C21 (\12\:B1 VSS) capacitor c=4.79192e-17
C22 (\10\:B1 VSS) capacitor c=4.9482e-17
C23 (\8\:B0 VSS) capacitor c=5.15816e-17
C24 (\9\:B0 VSS) capacitor c=7.13507e-17
C25 (\4\:B1 VSS) capacitor c=5.56308e-17
C26 (\6\:B1 VSS) capacitor c=4.56271e-17
C27 (\1\:B0 VSS) capacitor c=4.2459e-17
C28 (\12\:A0 VSS) capacitor c=4.55566e-17
C29 (\13\:A1 VSS) capacitor c=4.52345e-17
C30 (\12\:A2 VSS) capacitor c=4.27906e-17
C31 (\10\:A2 VSS) capacitor c=2.35545e-17
C32 (\9\:A1 VSS) capacitor c=4.72943e-17
C33 (\9\:A0 VSS) capacitor c=3.42244e-17
C34 (\7\:A0 VSS) capacitor c=5.36906e-17
C35 (\6\:A1 VSS) capacitor c=6.91757e-17
C36 (\1\:A2 VSS) capacitor c=5.21984e-17
C37 (\5\:A2 VSS) capacitor c=2.55912e-17
C38 (\1\:A1 VSS) capacitor c=6.12597e-17
C39 (\1\:A0 VSS) capacitor c=4.82375e-17
C40 (\2\:A1 VSS) capacitor c=8.37539e-16
C41 (\10\:Y VSS) capacitor c=2.72258e-16
C42 (\1\:VDD VSS) capacitor c=4.40464e-16
C43 (\1\:Y VSS) capacitor c=6.15227e-17
C44 (\3\:Y VSS) capacitor c=6.99895e-17
C45 (\6\:Y VSS) capacitor c=1.56541e-16
C46 (\8\:Y VSS) capacitor c=1.29095e-16
C47 (\2\:A2 VSS) capacitor c=3.84791e-17
C48 (\9\:A2 VSS) capacitor c=2.23393e-17
C49 (\3\:B1 VSS) capacitor c=3.514e-17
C50 (\9\:B1 VSS) capacitor c=4.38501e-17
C51 (\5\:Y VSS) capacitor c=1.09328e-16
Rk64 (\1\:VDD VDD) resistor r=0.04988 c=0
Rk19 (Y \10\:Y) resistor r=0.1127 c=0
Rk14 (\2\:Y \4\:Y) resistor r=0.4599 c=0
Rk18 (\5\:Y Y) resistor r=0.4494 c=0
Rk15 (\4\:Y \5\:Y) resistor r=0.3002 c=0
Rk16 (\5\:Y \7\:Y) resistor r=0.4803 c=0
Rk17 (\7\:Y \9\:Y) resistor r=0.8447 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.05244 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.3245 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.4235 c=0
Rk43 (\3\:VSS \7\:VSS) resistor r=0.2033 c=0
Rk44 (\4\:VSS \9\:VSS) resistor r=0.04328 c=0
Rk45 (\5\:VSS \10\:VSS) resistor r=0.6029 c=0
Rk46 (\10\:VSS \11\:VSS) resistor r=0.3473 c=0
Rk48 (\12\:VSS VSS) resistor r=0.1149 c=0
Rk47 (\11\:VSS \12\:VSS) resistor r=0.1853 c=0
Rk49 (\5\:VSS \14\:VSS) resistor r=0.07144 c=0
Rk50 (\10\:VSS \16\:VSS) resistor r=0.04328 c=0
Rk51 (\12\:VSS \18\:VSS) resistor r=0.1987 c=0
Rk7 (\2\:A1 A1) resistor r=0.08428 c=0
Rl32 (\3\:B1 B1) resistor r=7.101 c=0
Rl33 (\3\:B1 \4\:B1) resistor r=86.6019 c=0
Rl35 (\3\:B1 \6\:B1) resistor r=136.023 c=0
Rl42 (\9\:B1 B1) resistor r=25.8618 c=0
Rl45 (\9\:B1 \12\:B1) resistor r=60.0739 c=0
Rl43 (\9\:B1 \10\:B1) resistor r=67.7662 c=0
Rl6 (\2\:A2 A2) resistor r=62.3759 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=73.0548 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=59.5933 c=0
Rl20 (\9\:A2 A2) resistor r=77.3125 c=0
Rl23 (\9\:A2 \12\:A2) resistor r=100.426 c=0
Rl21 (\9\:A2 \10\:A2) resistor r=35.772 c=0
Rl28 (A0 \12\:A0) resistor r=40.1797 c=0
Rl16 (A0 \9\:A0) resistor r=24.2328 c=0
Rl14 (A0 \7\:A0) resistor r=98.3529 c=0
Rl1 (A0 \1\:A0) resistor r=30.2349 c=0
Rl26 (\2\:A1 \13\:A1) resistor r=52.7257 c=0
Rl18 (\2\:A1 \9\:A1) resistor r=56.8681 c=0
Rl11 (\2\:A1 \6\:A1) resistor r=44.9225 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=44.9225 c=0
Rl47 (B0 \12\:B0) resistor r=98.0541 c=0
Rl39 (B0 \8\:B0) resistor r=40.6783 c=0
Rl40 (B0 \9\:B0) resistor r=109.334 c=0
Rl29 (B0 \1\:B0) resistor r=31.9251 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz9 (\17\:VSS \18\:VSS) resistor r=75 c=0
Ry17 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry18 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \11\:VSS) resistor r=8.8571 c=0
mn0_1__rcx (10 \1\:A0 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (10 \1\:A1 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=1.56e-14 ps=8.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\8\:Y \5\:A2 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2_2__rcx (\8\:Y \1\:A2 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_2__rcx (12 \6\:A1 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_2__rcx (13 \7\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0_3__rcx (14 \9\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.73e-14 ps=1.35e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (14 \9\:A1 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.73e-14 ps=9.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (\6\:Y \10\:A2 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.16e-14 ps=9.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (\6\:Y \12\:A2 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_1__rcx (\3\:Y \6\:B1 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.13e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (16 \13\:A1 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.55e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=1.785e-06 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn0 (17 \12\:A0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=2.99e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.625e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (18 \1\:B0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=3.51e-14 ps=1.45e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.31e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\3\:Y \4\:B1 19 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=9.25e-07 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn3 (19 \9\:B0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.35e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.2e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_2__rcx (20 \8\:B0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.35e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (\1\:Y \10\:B1 20 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4_3__rcx (\1\:Y \12\:B1 21 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (21 \12\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mp1_1__rcx (net106 \2\:A1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=18.9104 \
        scb=0.0172562 scc=0.00120281 m=(4)
mp2_1__rcx (net106 A2 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=17.1755 scb=0.0150279 \
        scc=0.00118894 m=(4)
mp3_1__rcx (\10\:Y B0 net106 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.575e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
mp4_1__rcx (\10\:Y B1 net106 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
ends AOI32X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:41:05 2012 )
// Library name: gsclib045
// Cell name: AOI32XL
// View name: extracted

simulator lang=spectre

subckt AOI32XL A0 A1 A2 B0 B1 VDD VSS Y
mp0 (net114 \1\:A0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.12e-06 sd=160n sca=16.0514 scb=0.0157827 \
        scc=0.00029851 m=(1)
C1 (B1 VSS) capacitor c=1.05067e-16
C2 (A0 VSS) capacitor c=3.50849e-17
C3 (Y VSS) capacitor c=5.68795e-17
C4 (A2 VSS) capacitor c=5.0504e-17
C5 (VDD VSS) capacitor c=1.29924e-16
C6 (A1 VSS) capacitor c=4.31409e-17
C7 (B0 VSS) capacitor c=3.95594e-17
C8 (net130 VSS) capacitor c=6.03317e-18
C9 (net126 VSS) capacitor c=5.90245e-19
C10 (net114 VSS) capacitor c=2.33797e-17
C11 (\1\:B0 VSS) capacitor c=3.41173e-17
C12 (\1\:B1 VSS) capacitor c=4.64643e-17
C13 (\1\:A2 VSS) capacitor c=5.71075e-17
C14 (\1\:A1 VSS) capacitor c=6.80218e-17
C15 (\1\:A0 VSS) capacitor c=4.41063e-17
C16 (\3\:B0 VSS) capacitor c=6.47927e-17
C17 (\3\:B1 VSS) capacitor c=4.12914e-17
C18 (\3\:A2 VSS) capacitor c=2.30487e-17
C19 (\3\:A1 VSS) capacitor c=2.86058e-17
C20 (\3\:A0 VSS) capacitor c=2.53599e-17
C21 (\4\:B0 VSS) capacitor c=1.21347e-17
C22 (\2\:B1 VSS) capacitor c=6.23237e-17
C23 (\2\:A2 VSS) capacitor c=4.86341e-17
C24 (\2\:A1 VSS) capacitor c=5.90326e-17
C25 (\2\:A0 VSS) capacitor c=4.21124e-17
C26 (\5\:net114 VSS) capacitor c=6.88652e-17
C27 (\1\:Y VSS) capacitor c=5.59512e-17
C28 (\3\:net114 VSS) capacitor c=7.13854e-17
C29 (\7\:VDD VSS) capacitor c=1.14483e-17
C30 (\9\:VDD VSS) capacitor c=1.64308e-19
C31 (\1\:VDD VSS) capacitor c=5.38945e-17
C32 (\3\:Y VSS) capacitor c=8.29619e-17
C33 (\2\:B0 VSS) capacitor c=4.83685e-17
C34 (\4\:A0 VSS) capacitor c=3.15874e-17
C35 (\4\:A1 VSS) capacitor c=7.01258e-17
C36 (\4\:A2 VSS) capacitor c=6.48818e-17
C37 (\5\:B0 VSS) capacitor c=4.61704e-17
C38 (\3\:VDD VSS) capacitor c=9.58307e-18
Rk4 (\4\:B1 B1) resistor r=0.00298 c=0
Rk1 (A0 \4\:A0) resistor r=0.1043 c=0
Rk5 (\2\:Y Y) resistor r=0.2993 c=0
Rk6 (Y \4\:Y) resistor r=0.4062 c=0
Rk3 (A2 \4\:A2) resistor r=0.2135 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.2042 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.1443 c=0
Rk17 (\5\:VDD VDD) resistor r=0.05936 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.08952 c=0
Rk19 (\3\:VDD \8\:VDD) resistor r=0.07254 c=0
Rk20 (\5\:VDD \10\:VDD) resistor r=0.07254 c=0
Rk2 (\4\:A1 A1) resistor r=0.1068 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.5648 c=0
Rk12 (\5\:VSS VSS) resistor r=0.07432 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.2739 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.284 c=0
Rk7 (\5\:B0 B0) resistor r=0.0535 c=0
Rk8 (\2\:net114 \4\:net114) resistor r=0.2677 c=0
Rk9 (\4\:net114 \6\:net114) resistor r=0.4787 c=0
Rl7 (\1\:B1 \2\:B1) resistor r=164.617 c=0
Rl8 (\2\:B1 \3\:B1) resistor r=30.0021 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=154.944 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=35.7134 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=170.387 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.2328 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=168 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl9 (\1\:B0 \2\:B0) resistor r=71.8171 c=0
Rl10 (\2\:B0 \3\:B0) resistor r=156.078 c=0
Rl11 (\2\:B0 \4\:B0) resistor r=5.1011 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (net114 \2\:net114) resistor r=62 c=0
Ry3 (\3\:net114 \4\:net114) resistor r=62 c=0
Ry4 (\5\:net114 \6\:net114) resistor r=62 c=0
Rx4 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\4\:B0 \5\:B0) resistor r=45 c=0
mn0 (net130 \3\:A0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn1 (net130 \3\:A1 net126 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=2.32e-14 ps=5.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.15e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\3\:Y \3\:A2 net126 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.785e-14 ps=5.9e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.2e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (\3\:Y \3\:B1 net118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.785e-14 ps=4.1e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (net118 \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp1 (net114 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.15e-07 sd=160n sca=12.7829 \
        scb=0.0103785 scc=0.000190716 m=(1)
mp2 (\3\:net114 \1\:A2 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=7.095e-14 ps=1.45e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=7.2e-07 sd=160n sca=11.9309 scb=0.00939564 \
        scc=0.00018805 m=(1)
mp4 (\1\:Y \1\:B1 \3\:net114 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.095e-14 ad=3.44e-14 ps=1.09e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=3.45e-07 sd=160n sca=13.6898 \
        scb=0.0116924 scc=0.000200935 m=(1)
mp3 (\1\:Y \1\:B0 \5\:net114 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=1.4e-07 sd=160n sca=19.5246 \
        scb=0.021512 scc=0.000667372 m=(1)
ends AOI32XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:41:43 2012 )
// Library name: gsclib045
// Cell name: AOI33X1
// View name: extracted

simulator lang=spectre

subckt AOI33X1 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (\5\:net059 \3\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=19.248 \
        scb=0.0210891 scc=0.000636466 m=(1)
C1 (B1 VSS) capacitor c=6.37878e-17
C2 (A1 VSS) capacitor c=4.83284e-17
C3 (Y VSS) capacitor c=1.03452e-16
C4 (B2 VSS) capacitor c=5.7416e-17
C5 (A0 VSS) capacitor c=3.00852e-17
C6 (VDD VSS) capacitor c=8.6878e-17
C7 (A2 VSS) capacitor c=6.43092e-17
C8 (B0 VSS) capacitor c=5.15292e-17
C9 (net149 VSS) capacitor c=1.51532e-18
C10 (net137 VSS) capacitor c=6.36837e-18
C11 (net141 VSS) capacitor c=7.6705e-19
C12 (net059 VSS) capacitor c=8.23958e-17
C13 (\1\:B0 VSS) capacitor c=5.1266e-17
C14 (\1\:B1 VSS) capacitor c=6.24703e-17
C15 (\1\:B2 VSS) capacitor c=6.10703e-17
C16 (\1\:A2 VSS) capacitor c=6.50129e-17
C17 (\1\:A1 VSS) capacitor c=6.83715e-17
C18 (\3\:A0 VSS) capacitor c=5.40584e-17
C19 (\3\:B0 VSS) capacitor c=6.14783e-17
C20 (\3\:B1 VSS) capacitor c=6.96217e-17
C21 (\3\:B2 VSS) capacitor c=3.70955e-17
C22 (\3\:A2 VSS) capacitor c=3.79787e-17
C23 (\3\:A1 VSS) capacitor c=6.40795e-17
C24 (\1\:A0 VSS) capacitor c=5.54088e-17
C25 (\2\:B0 VSS) capacitor c=5.78837e-17
C26 (\2\:B1 VSS) capacitor c=6.24994e-17
C27 (\2\:B2 VSS) capacitor c=5.29328e-17
C28 (\2\:A2 VSS) capacitor c=5.25353e-17
C29 (\2\:A1 VSS) capacitor c=5.75919e-17
C30 (\2\:A0 VSS) capacitor c=5.07792e-17
C31 (\1\:Y VSS) capacitor c=2.6891e-17
C32 (\5\:Y VSS) capacitor c=8.25519e-17
C33 (\3\:net059 VSS) capacitor c=8.95583e-17
C34 (\7\:VDD VSS) capacitor c=6.50028e-17
C35 (\5\:net059 VSS) capacitor c=9.09599e-17
C36 (\9\:VDD VSS) capacitor c=3.64873e-17
C37 (\1\:VDD VSS) capacitor c=8.37423e-17
C38 (\3\:Y VSS) capacitor c=1.86059e-16
C39 (\4\:A0 VSS) capacitor c=4.78123e-17
C40 (\4\:A1 VSS) capacitor c=7.78277e-17
C41 (\4\:A2 VSS) capacitor c=7.50124e-17
C42 (\4\:B2 VSS) capacitor c=2.71061e-17
C43 (\4\:B1 VSS) capacitor c=3.88118e-17
C44 (\4\:B0 VSS) capacitor c=6.54651e-17
C45 (\3\:VDD VSS) capacitor c=2.88038e-18
C46 (\5\:VDD VSS) capacitor c=1.53794e-18
Rk7 (B1 \4\:B1) resistor r=0.08064 c=0
Rk2 (A1 \4\:A1) resistor r=0.1264 c=0
Rk11 (\2\:Y Y) resistor r=0.08352 c=0
Rk12 (Y \4\:Y) resistor r=1.0424 c=0
Rk13 (Y \6\:Y) resistor r=0.4076 c=0
Rk6 (\4\:B2 B2) resistor r=0.04214 c=0
Rk1 (A0 \4\:A0) resistor r=0.03311 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4324 c=0
Rk16 (\5\:VSS VSS) resistor r=0.08739 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2633 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2308 c=0
Rk18 (\2\:VDD \3\:VDD) resistor r=0.2583 c=0
Rk19 (\3\:VDD \4\:VDD) resistor r=0.09266 c=0
Rk21 (\5\:VDD VDD) resistor r=0.0372 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.1127 c=0
Rk23 (\3\:VDD \8\:VDD) resistor r=0.2357 c=0
Rk24 (\5\:VDD \10\:VDD) resistor r=0.2805 c=0
Rk3 (A2 \4\:A2) resistor r=0.2167 c=0
Rk10 (B0 \4\:B0) resistor r=0.1686 c=0
Rk8 (\2\:net059 \4\:net059) resistor r=0.4629 c=0
Rk9 (\4\:net059 \6\:net059) resistor r=0.5223 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=125.692 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=71.8456 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=152.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=44.9225 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=151.156 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=43.4636 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=153.641 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=149.98 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=44.9225 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=126.923 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=77.6561 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\5\:Y \6\:Y) resistor r=31 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry1 (net059 \2\:net059) resistor r=31 c=0
Ry2 (\3\:net059 \4\:net059) resistor r=31 c=0
Ry3 (\5\:net059 \6\:net059) resistor r=20.6667 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B2 \4\:B2) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx6 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net157 \1\:A0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mn1 (net157 \3\:A1 net149 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=1.56e-14 ps=7.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.95e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\3\:Y \3\:A2 net149 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.72e-14 ps=7.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=7.15e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn5 (\3\:Y \3\:B2 net137 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=4.5e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn4 (net141 \3\:B1 net137 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=2.45e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn3 (net141 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.4e-07 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mp1 (\5\:net059 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.045e-06 sd=160n sca=13.8333 \
        scb=0.0119033 scc=0.000242673 m=(1)
mp2 (\3\:net059 \1\:A2 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.605e-14 ps=1.1e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=8.4e-07 sd=160n sca=12.3219 \
        scb=0.00994851 scc=0.000232104 m=(1)
mp5 (\5\:Y \1\:B2 \3\:net059 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.605e-14 ad=6.24e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6e-07 sd=160n sca=12.3642 scb=0.0100002 \
        scc=0.000232183 m=(1)
mp4 (\5\:Y \1\:B1 net059 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.95e-07 sd=160n sca=14.03 \
        scb=0.0122147 scc=0.000246052 m=(1)
mp3 (\1\:Y \1\:B0 net059 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.41e-14 ps=1.1e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.9e-07 sd=160n sca=20.0914 \
        scb=0.0223631 scc=0.000753507 m=(1)
ends AOI33X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:42:21 2012 )
// Library name: gsclib045
// Cell name: AOI33X2
// View name: extracted

simulator lang=spectre

subckt AOI33X2 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (net124 A0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.117e-14 ad=8.58e-14 ps=1.145e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.0413 scb=0.02503 \
        scc=0.00108348 m=(2)
C1 (B1 VSS) capacitor c=3.14736e-17
C2 (A1 VSS) capacitor c=2.42879e-17
C3 (VDD VSS) capacitor c=1.6561e-16
C4 (B2 VSS) capacitor c=7.39649e-17
C5 (Y VSS) capacitor c=7.05132e-17
C6 (A2 VSS) capacitor c=6.84288e-17
C7 (A0 VSS) capacitor c=4.42514e-16
C8 (B0 VSS) capacitor c=4.56764e-16
C9 (11 VSS) capacitor c=2.6935e-18
C10 (12 VSS) capacitor c=6.81468e-18
C11 (13 VSS) capacitor c=2.64226e-18
C12 (14 VSS) capacitor c=1.19232e-17
C13 (15 VSS) capacitor c=7.18522e-18
C14 (16 VSS) capacitor c=4.78439e-18
C15 (17 VSS) capacitor c=7.28075e-18
C16 (18 VSS) capacitor c=3.44348e-18
C17 (net124 VSS) capacitor c=4.89395e-16
C18 (\1\:B2 VSS) capacitor c=1.11256e-16
C19 (\1\:B1 VSS) capacitor c=4.05239e-16
C20 (\1\:A1 VSS) capacitor c=3.84742e-16
C21 (\6\:B0 VSS) capacitor c=3.8649e-17
C22 (\6\:B1 VSS) capacitor c=4.9799e-17
C23 (\6\:B2 VSS) capacitor c=3.0376e-17
C24 (\4\:B2 VSS) capacitor c=3.12555e-17
C25 (\3\:B1 VSS) capacitor c=4.42022e-17
C26 (\3\:B0 VSS) capacitor c=3.57642e-17
C27 (\6\:A0 VSS) capacitor c=3.01842e-17
C28 (\6\:A1 VSS) capacitor c=5.45001e-17
C29 (\1\:A2 VSS) capacitor c=4.74494e-17
C30 (\4\:A2 VSS) capacitor c=3.1144e-17
C31 (\3\:A1 VSS) capacitor c=5.69811e-17
C32 (\1\:A0 VSS) capacitor c=4.70491e-17
C33 (\3\:A2 VSS) capacitor c=1.1922e-16
C34 (\9\:Y VSS) capacitor c=9.50336e-17
C35 (\7\:Y VSS) capacitor c=1.33871e-16
C36 (\9\:VDD VSS) capacitor c=4.75666e-17
C37 (\1\:VDD VSS) capacitor c=7.91103e-17
C38 (\1\:Y VSS) capacitor c=7.44739e-17
C39 (\4\:Y VSS) capacitor c=8.28547e-17
C40 (\2\:A2 VSS) capacitor c=2.49045e-17
C41 (\3\:B2 VSS) capacitor c=2.58196e-17
C42 (\7\:A2 VSS) capacitor c=4.93988e-17
C43 (\7\:B2 VSS) capacitor c=6.00626e-17
C44 (\3\:Y VSS) capacitor c=1.30749e-16
C45 (\4\:VDD VSS) capacitor c=1.27511e-16
Rk9 (B1 \1\:B1) resistor r=0.08385 c=0
Rk2 (\1\:A1 A1) resistor r=0.09952 c=0
Rk34 (\2\:VDD \3\:VDD) resistor r=0.7518 c=0
Rk38 (\4\:VDD VDD) resistor r=0.1098 c=0
Rk35 (\3\:VDD \4\:VDD) resistor r=0.02988 c=0
Rk40 (\4\:VDD \10\:VDD) resistor r=0.202 c=0
Rk8 (\7\:B2 B2) resistor r=0.02105 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.4463 c=0
Rk12 (\3\:Y \5\:Y) resistor r=0.5299 c=0
Rk14 (\6\:Y Y) resistor r=0.02126 c=0
Rk15 (\6\:Y \7\:Y) resistor r=0.1544 c=0
Rk13 (\3\:Y \6\:Y) resistor r=0.4542 c=0
Rk26 (\2\:VSS \3\:VSS) resistor r=0.04241 c=0
Rk27 (\3\:VSS \4\:VSS) resistor r=0.66 c=0
Rk28 (\3\:VSS \6\:VSS) resistor r=0.2184 c=0
Rk30 (\7\:VSS VSS) resistor r=0.0572 c=0
Rk29 (\4\:VSS \7\:VSS) resistor r=0.5938 c=0
Rk32 (\4\:VSS \10\:VSS) resistor r=0.07143 c=0
Rk33 (\7\:VSS \12\:VSS) resistor r=0.2184 c=0
Rk5 (\7\:A2 A2) resistor r=0.005542 c=0
Rl24 (\1\:B1 \6\:B1) resistor r=44.9225 c=0
Rl17 (\1\:B1 \3\:B1) resistor r=33.3841 c=0
Rl11 (\1\:A1 \6\:A1) resistor r=29.9442 c=0
Rl4 (\1\:A1 \3\:A1) resistor r=33.3841 c=0
Rl19 (\3\:B2 \1\:B2) resistor r=24.6542 c=0
Rl22 (\3\:B2 \6\:B2) resistor r=82.1768 c=0
Rl20 (\3\:B2 \4\:B2) resistor r=32.7557 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=32.7557 c=0
Rl7 (\2\:A2 \4\:A2) resistor r=82.1768 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=24.6542 c=0
Rl13 (A0 \6\:A0) resistor r=29.5379 c=0
Rl1 (A0 \1\:A0) resistor r=29.8412 c=0
Rl26 (B0 \6\:B0) resistor r=24.7951 c=0
Rl15 (B0 \3\:B0) resistor r=29.5379 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\5\:Y \4\:Y) resistor r=75 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Ry15 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry2 (\7\:Y \9\:Y) resistor r=62 c=0
Ry13 (\1\:VSS VSS) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Rx6 (\7\:B2 \1\:B2) resistor r=45 c=0
Rx3 (\7\:A2 \3\:A2) resistor r=45 c=0
mn0 (11 \1\:A0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (11 \3\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.59e-14 \
        ad=1.56e-14 ps=9.5e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (\4\:Y \4\:A2 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.59e-14 \
        ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.05e-07 sb=2e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_1__rcx (\4\:Y \1\:A2 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.865e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (13 \6\:A1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.76e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_1__rcx (14 \6\:A0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.05e-13 ad=6.5e-14 ps=1.57e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.11e-06 sb=1.465e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3 (15 \3\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.05e-13 ad=4.29e-14 ps=1.57e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=1.12e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4 (15 \3\:B1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.29e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.665e-06 sb=9.1e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn5 (\1\:Y \4\:B2 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.825e-06 sb=7.5e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn5_1__rcx (\1\:Y \6\:B2 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.45e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn4_1__rcx (17 \6\:B1 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=6.11e-14 ps=6.8e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.65e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3_1__rcx (18 \6\:B0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.08e-14 ps=8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mp1 (net124 \1\:A1 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.117e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=15.2233 scb=0.013848 \
        scc=0.000431029 m=(2)
mp2 (net124 \3\:A2 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=13.3531 scb=0.0113375 \
        scc=0.000412845 m=(2)
mp3 (\7\:Y B0 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=6.338e-14 ps=1.22e-06 pd=1.105e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.555e-06 sb=1.2e-06 sd=160n sca=12.3656 scb=0.0108222 \
        scc=0.000412413 m=(2)
mp4 (\7\:Y \1\:B1 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.338e-14 ps=1.13e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=9.9e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(2)
mp5 (\9\:Y \1\:B2 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=7.75e-07 sd=160n sca=12.4666 \
        scb=0.0108434 scc=0.000412415 m=(2)
ends AOI33X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:42:58 2012 )
// Library name: gsclib045
// Cell name: AOI33X4
// View name: extracted

simulator lang=spectre

subckt AOI33X4 A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0_1__rcx (net124 \2\:A0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4303 scb=0.0198654 \
        scc=0.00125373 m=(4)
C1 (B1 VSS) capacitor c=8.29301e-16
C2 (A1 VSS) capacitor c=2.30984e-17
C3 (VDD VSS) capacitor c=2.18011e-16
C4 (B2 VSS) capacitor c=2.85897e-17
C5 (Y VSS) capacitor c=8.64779e-17
C6 (A0 VSS) capacitor c=1.44581e-16
C7 (B0 VSS) capacitor c=8.37236e-16
C8 (11 VSS) capacitor c=1.36221e-18
C9 (12 VSS) capacitor c=5.33534e-18
C10 (13 VSS) capacitor c=2.24904e-18
C11 (14 VSS) capacitor c=4.22889e-18
C12 (15 VSS) capacitor c=4.07685e-18
C13 (16 VSS) capacitor c=4.08884e-18
C14 (17 VSS) capacitor c=6.85657e-18
C15 (18 VSS) capacitor c=4.75885e-18
C16 (19 VSS) capacitor c=5.88913e-18
C17 (20 VSS) capacitor c=6.90016e-18
C18 (21 VSS) capacitor c=6.52952e-18
C19 (22 VSS) capacitor c=6.90839e-18
C20 (23 VSS) capacitor c=4.22752e-18
C21 (24 VSS) capacitor c=2.24904e-18
C22 (25 VSS) capacitor c=5.90293e-18
C23 (26 VSS) capacitor c=1.36221e-18
C24 (net124 VSS) capacitor c=9.92597e-16
C25 (\1\:B2 VSS) capacitor c=4.60398e-16
C26 (\12\:B0 VSS) capacitor c=4.81427e-17
C27 (\12\:B1 VSS) capacitor c=7.16682e-17
C28 (\12\:B2 VSS) capacitor c=2.79434e-17
C29 (\10\:B2 VSS) capacitor c=5.65528e-17
C30 (\9\:B1 VSS) capacitor c=7.11445e-17
C31 (\4\:B0 VSS) capacitor c=5.20455e-17
C32 (\6\:B0 VSS) capacitor c=2.69448e-17
C33 (\6\:B1 VSS) capacitor c=4.38115e-17
C34 (\6\:B2 VSS) capacitor c=2.75022e-17
C35 (\4\:B2 VSS) capacitor c=4.06308e-17
C36 (\3\:B1 VSS) capacitor c=4.0829e-17
C37 (\3\:B0 VSS) capacitor c=3.69409e-17
C38 (\13\:A0 VSS) capacitor c=3.79211e-17
C39 (\13\:A1 VSS) capacitor c=4.00796e-17
C40 (\12\:A2 VSS) capacitor c=2.56286e-17
C41 (\10\:A2 VSS) capacitor c=4.60109e-17
C42 (\9\:A1 VSS) capacitor c=6.29101e-17
C43 (\9\:A0 VSS) capacitor c=3.41201e-17
C44 (\7\:A0 VSS) capacitor c=4.85893e-17
C45 (\6\:A1 VSS) capacitor c=7.21389e-17
C46 (\1\:A2 VSS) capacitor c=5.24871e-17
C47 (\5\:A2 VSS) capacitor c=2.35095e-17
C48 (\1\:A1 VSS) capacitor c=7.10513e-17
C49 (\1\:A0 VSS) capacitor c=4.81684e-17
C50 (\3\:A2 VSS) capacitor c=5.10265e-16
C51 (\2\:A1 VSS) capacitor c=8.0359e-16
C52 (\2\:A0 VSS) capacitor c=7.01026e-16
C53 (\10\:Y VSS) capacitor c=5.0468e-16
C54 (\1\:VDD VSS) capacitor c=4.89431e-16
C55 (\1\:Y VSS) capacitor c=1.2779e-16
C56 (\3\:Y VSS) capacitor c=1.64401e-16
C57 (\6\:Y VSS) capacitor c=1.47516e-16
C58 (\8\:Y VSS) capacitor c=1.17623e-16
C59 (\2\:A2 VSS) capacitor c=3.69129e-17
C60 (\9\:A2 VSS) capacitor c=3.35452e-17
C61 (\3\:B2 VSS) capacitor c=2.19819e-17
C62 (\9\:B2 VSS) capacitor c=4.4508e-17
C63 (\5\:Y VSS) capacitor c=1.22491e-16
Rk6 (\2\:A1 A1) resistor r=0.01617 c=0
Rk70 (\1\:VDD VDD) resistor r=0.1927 c=0
Rk12 (\1\:B2 B2) resistor r=0.02372 c=0
Rk22 (Y \10\:Y) resistor r=0.3024 c=0
Rk17 (\2\:Y \4\:Y) resistor r=0.8483 c=0
Rk21 (\5\:Y Y) resistor r=0.3287 c=0
Rk18 (\4\:Y \5\:Y) resistor r=0.5468 c=0
Rk19 (\5\:Y \7\:Y) resistor r=0.4541 c=0
Rk20 (\7\:Y \9\:Y) resistor r=0.7852 c=0
Rk49 (\2\:VSS \3\:VSS) resistor r=0.08758 c=0
Rk50 (\3\:VSS \4\:VSS) resistor r=0.5651 c=0
Rk51 (\3\:VSS \6\:VSS) resistor r=0.1995 c=0
Rk52 (\4\:VSS \7\:VSS) resistor r=0.6484 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.5531 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.6054 c=0
Rk56 (\10\:VSS VSS) resistor r=0.04991 c=0
Rk55 (\9\:VSS \10\:VSS) resistor r=0.09761 c=0
Rk57 (\4\:VSS \12\:VSS) resistor r=0.07147 c=0
Rk58 (\7\:VSS \14\:VSS) resistor r=0.04331 c=0
Rk59 (\8\:VSS \16\:VSS) resistor r=0.07147 c=0
Rk60 (\9\:VSS \18\:VSS) resistor r=0.1995 c=0
Rk2 (\3\:A2 A2) resistor r=0.009678 c=0
Rk7 (A0 \2\:A0) resistor r=0.01801 c=0
Rl54 (B1 \12\:B1) resistor r=102.615 c=0
Rl47 (B1 \9\:B1) resistor r=52.6149 c=0
Rl40 (B1 \6\:B1) resistor r=53.0211 c=0
Rl33 (B1 \3\:B1) resistor r=44.9225 c=0
Rl26 (\2\:A1 \13\:A1) resistor r=52.7257 c=0
Rl18 (\2\:A1 \9\:A1) resistor r=87.6374 c=0
Rl11 (\2\:A1 \6\:A1) resistor r=56.461 c=0
Rl3 (\2\:A1 \1\:A1) resistor r=92.1028 c=0
Rl35 (\3\:B2 \1\:B2) resistor r=70.1824 c=0
Rl38 (\3\:B2 \6\:B2) resistor r=35.772 c=0
Rl36 (\3\:B2 \4\:B2) resistor r=100.426 c=0
Rl49 (\9\:B2 \1\:B2) resistor r=6.7128 c=0
Rl52 (\9\:B2 \12\:B2) resistor r=129.305 c=0
Rl50 (\9\:B2 \10\:B2) resistor r=106.228 c=0
Rl5 (\2\:A2 \1\:A2) resistor r=73.0548 c=0
Rl8 (\2\:A2 \5\:A2) resistor r=59.5933 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=71.9912 c=0
Rl23 (\9\:A2 \12\:A2) resistor r=47.4088 c=0
Rl21 (\9\:A2 \10\:A2) resistor r=94.2087 c=0
Rl20 (\9\:A2 \3\:A2) resistor r=69.6756 c=0
Rl29 (\2\:A0 \13\:A0) resistor r=23.7402 c=0
Rl16 (\2\:A0 \9\:A0) resistor r=24.2328 c=0
Rl14 (\2\:A0 \7\:A0) resistor r=98.3529 c=0
Rl1 (\2\:A0 \1\:A0) resistor r=30.2349 c=0
Rl56 (B0 \12\:B0) resistor r=24.7951 c=0
Rl41 (B0 \4\:B0) resistor r=96.595 c=0
Rl42 (B0 \6\:B0) resistor r=21.8676 c=0
Rl31 (B0 \3\:B0) resistor r=24.2328 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz3 (\7\:Y \6\:Y) resistor r=75 c=0
Rz4 (\9\:Y \8\:Y) resistor r=75 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz9 (\17\:VSS \18\:VSS) resistor r=75 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry25 (\1\:VSS \10\:VSS) resistor r=31 c=0
mn0_1__rcx (11 \1\:A0 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_1__rcx (11 \1\:A1 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=1.56e-14 ps=9.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (\8\:Y \5\:A2 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\8\:Y \1\:A2 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.3e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (13 \6\:A1 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.35e-07 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn0 (14 \7\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_2__rcx (15 \9\:A0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.73e-14 ps=1.35e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_1__rcx (19 \3\:B0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1_2__rcx (15 \9\:A1 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=2.73e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_2__rcx (\6\:Y \10\:A2 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_3__rcx (\6\:Y \12\:A2 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_3__rcx (17 \13\:A1 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_3__rcx (18 \13\:A0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4_1__rcx (19 \3\:B1 20 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_1__rcx (\3\:Y \4\:B2 20 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.885e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5_2__rcx (\3\:Y \6\:B2 21 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=4.16e-14 ps=8.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.68e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_2__rcx (21 \6\:B1 22 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.77e-14 ps=8.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.49e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_2__rcx (22 \6\:B0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=4.16e-14 ps=1.35e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.285e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3_3__rcx (23 \4\:B0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=2.99e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.02e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4_3__rcx (23 \9\:B1 24 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=2.99e-14 ps=6.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn5_3__rcx (\1\:Y \10\:B2 24 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn5 (\1\:Y \12\:B2 25 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn4 (25 \12\:B1 26 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=6.76e-14 ps=6.4e-07 pd=1.04e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2.45e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (26 \12\:B0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mp1_1__rcx (net124 \2\:A1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.386e-14 ad=6.435e-14 ps=1.1075e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.6981 \
        scb=0.0155463 scc=0.00119019 m=(4)
mp2_1__rcx (net124 \3\:A2 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=16.6869 scb=0.0147126 \
        scc=0.00118865 m=(4)
mp3_1__rcx (\10\:Y B0 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp4_1__rcx (\10\:Y B1 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp5_1__rcx (\10\:Y \1\:B2 net124 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.985e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
ends AOI33X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:04:38 2012 )
// Library name: gsclib045
// Cell name: AOI33XL
// View name: extracted

simulator lang=spectre

subckt AOI33XL A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (net124 \3\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=3.655e-14 ps=1.31e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.165e-06 sd=160n sca=30.1692 \
        scb=0.0324471 scc=0.00278498 m=(1)
C1 (B1 VSS) capacitor c=6.50543e-17
C2 (A1 VSS) capacitor c=2.43984e-17
C3 (B2 VSS) capacitor c=2.38334e-17
C4 (A0 VSS) capacitor c=2.34647e-17
C5 (Y VSS) capacitor c=1.52516e-17
C6 (VDD VSS) capacitor c=1.35578e-16
C7 (A2 VSS) capacitor c=3.2482e-17
C8 (net153 VSS) capacitor c=8.56836e-22
C9 (net137 VSS) capacitor c=4.72564e-18
C10 (net141 VSS) capacitor c=2.36208e-18
C11 (net124 VSS) capacitor c=4.4056e-17
C12 (\1\:B0 VSS) capacitor c=3.89731e-17
C13 (\1\:B1 VSS) capacitor c=6.5389e-17
C14 (\1\:B2 VSS) capacitor c=3.33416e-17
C15 (\1\:A2 VSS) capacitor c=6.99965e-17
C16 (\1\:A1 VSS) capacitor c=5.50463e-17
C17 (\3\:A0 VSS) capacitor c=2.37436e-17
C18 (\3\:B0 VSS) capacitor c=5.97523e-17
C19 (\3\:B1 VSS) capacitor c=4.63477e-17
C20 (\3\:B2 VSS) capacitor c=6.97729e-17
C21 (\3\:A2 VSS) capacitor c=3.78089e-17
C22 (\3\:A1 VSS) capacitor c=5.9591e-17
C23 (\1\:A0 VSS) capacitor c=6.75056e-17
C24 (\2\:B0 VSS) capacitor c=6.64762e-17
C25 (\2\:B1 VSS) capacitor c=7.90526e-17
C26 (\2\:B2 VSS) capacitor c=5.92895e-17
C27 (\2\:A2 VSS) capacitor c=6.25662e-17
C28 (\2\:A1 VSS) capacitor c=6.76566e-17
C29 (\2\:A0 VSS) capacitor c=6.22191e-17
C30 (\5\:net124 VSS) capacitor c=6.94576e-17
C31 (\1\:Y VSS) capacitor c=6.0659e-17
C32 (\3\:net124 VSS) capacitor c=6.31313e-17
C33 (\8\:VDD VSS) capacitor c=1.10389e-17
C34 (\6\:VDD VSS) capacitor c=4.65568e-18
C35 (\1\:VDD VSS) capacitor c=6.64951e-17
C36 (\4\:Y VSS) capacitor c=1.28197e-16
C37 (\4\:A0 VSS) capacitor c=1.95538e-17
C38 (\4\:A1 VSS) capacitor c=2.76177e-17
C39 (\4\:A2 VSS) capacitor c=2.9359e-17
C40 (\6\:B2 VSS) capacitor c=2.60123e-17
C41 (\4\:B1 VSS) capacitor c=6.57915e-17
C42 (\4\:B0 VSS) capacitor c=7.55762e-17
C43 (\5\:B0 VSS) capacitor c=7.17837e-17
C44 (\3\:Y VSS) capacitor c=1.18241e-16
Rk7 (B1 \4\:B1) resistor r=0.1592 c=0
Rk2 (\4\:A1 A1) resistor r=0.04585 c=0
Rk4 (\4\:B2 B2) resistor r=0.005012 c=0
Rk6 (\4\:B2 \6\:B2) resistor r=0.01641 c=0
Rk5 (\5\:B2 \6\:B2) resistor r=0.005012 c=0
Rk1 (\4\:A0 A0) resistor r=0.04463 c=0
Rk13 (\2\:Y \3\:Y) resistor r=0.3216 c=0
Rk14 (\3\:Y \5\:Y) resistor r=0.9777 c=0
Rk16 (\7\:Y Y) resistor r=0.002814 c=0
Rk15 (\3\:Y \7\:Y) resistor r=0.07134 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.2304 c=0
Rk25 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.06998 c=0
Rk27 (VDD \7\:VDD) resistor r=0.1006 c=0
Rk28 (\3\:VDD \9\:VDD) resistor r=0.07346 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.05243 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.298 c=0
Rk20 (\5\:VSS VSS) resistor r=0.0171 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.2329 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.122 c=0
Rk22 (\5\:VSS \9\:VSS) resistor r=0.213 c=0
Rk3 (A2 \4\:A2) resistor r=0.0404 c=0
Rk10 (B0 \4\:B0) resistor r=0.001228 c=0
Rk12 (\4\:B0 \5\:B0) resistor r=0.1041 c=0
Rk11 (\5\:B0 \6\:B0) resistor r=0.001293 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.2726 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.3667 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=204.944 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=35.7134 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=106.461 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=141.076 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=33.3841 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=214.153 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.3736 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=223.077 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=175.692 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=71.8456 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=102.978 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=147.253 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz2 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\8\:VSS \9\:VSS) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry5 (\6\:Y \7\:Y) resistor r=62 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry1 (net124 \2\:net124) resistor r=62 c=0
Ry2 (\3\:net124 \4\:net124) resistor r=62 c=0
Ry3 (\5\:net124 \6\:net124) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B2 \5\:B2) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx6 (\2\:B0 \6\:B0) resistor r=45 c=0
mn0 (net153 \1\:A0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.378e-14 ps=5.7e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.025e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn1 (net153 \3\:A1 net149 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=1.378e-14 ps=5.9e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=8.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn2 (\4\:Y \3\:A2 net149 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=2.32e-14 ps=5.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=6.9e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn5 (\4\:Y \3\:B2 net137 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=4.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn4 (net137 \3\:B1 net141 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=2.32e-14 ps=4.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2.8e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (net141 \3\:B0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=9.43e-15 ps=8.9e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=1.7e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mp1 (net124 \1\:A1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.655e-14 ps=1.41e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=9.5e-07 sd=160n sca=14.9994 \
        scb=0.0139145 scc=0.000209273 m=(1)
mp2 (\3\:net124 \1\:A2 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.55e-07 sd=160n sca=12.5773 \
        scb=0.00960893 scc=0.000140232 m=(1)
mp5 (\1\:Y \1\:B2 \3\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.5e-07 sd=160n sca=12.38 \
        scb=0.00928483 scc=0.000139001 m=(1)
mp4 (\1\:Y \1\:B1 \5\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=14.1566 \
        scb=0.012431 scc=0.000173041 m=(1)
mp3 (\6\:Y \1\:B0 \5\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=23.3203 \
        scb=0.0262833 scc=0.00133399 m=(1)
ends AOI33XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:44:13 2012 )
// Library name: gsclib045
// Cell name: BMXIX2
// View name: extracted

simulator lang=spectre

subckt BMXIX2 A M0 M1 PPN S VDD VSS X2
mp0 (\11\:M0b \1\:M0 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7886e-06 sd=160n sca=16.5061 \
        scb=0.0165824 scc=0.000331714 m=(1)
C1 (M0 VSS) capacitor c=6.56976e-17
C2 (M1 VSS) capacitor c=3.32546e-17
C3 (PPN VSS) capacitor c=2.36937e-17
C4 (S VSS) capacitor c=1.6593e-16
C5 (VDD VSS) capacitor c=3.29914e-16
C6 (A VSS) capacitor c=5.16627e-17
C7 (X2 VSS) capacitor c=5.33691e-17
C8 (M0b VSS) capacitor c=6.19923e-17
C9 (n3 VSS) capacitor c=7.26019e-19
C10 (n0 VSS) capacitor c=2.59163e-17
C11 (n5 VSS) capacitor c=3.40937e-18
C12 (n1 VSS) capacitor c=1.06631e-16
C13 (n7 VSS) capacitor c=7.28746e-21
C14 (M1b VSS) capacitor c=5.64069e-17
C15 (net293 VSS) capacitor c=1.24102e-16
C16 (X2b VSS) capacitor c=4.84245e-17
C17 (n4 VSS) capacitor c=3.60548e-18
C18 (n10 VSS) capacitor c=4.35927e-19
C19 (n8 VSS) capacitor c=4.1654e-18
C20 (\1\:X2 VSS) capacitor c=3.03588e-17
C21 (\6\:X2 VSS) capacitor c=3.08723e-17
C22 (\4\:M1 VSS) capacitor c=4.06585e-17
C23 (\4\:S VSS) capacitor c=6.06294e-17
C24 (\1\:M1 VSS) capacitor c=6.74269e-17
C25 (\1\:A VSS) capacitor c=3.37974e-17
C26 (\5\:A VSS) capacitor c=5.47219e-17
C27 (\3\:M0b VSS) capacitor c=6.39208e-17
C28 (\6\:M0 VSS) capacitor c=4.79456e-17
C29 (\1\:S VSS) capacitor c=3.98069e-17
C30 (\1\:M0 VSS) capacitor c=3.73588e-17
C31 (\5\:X2 VSS) capacitor c=3.53661e-17
C32 (\3\:X2b VSS) capacitor c=5.09858e-17
C33 (\4\:X2 VSS) capacitor c=4.58558e-17
C34 (\6\:M1 VSS) capacitor c=3.73068e-17
C35 (\6\:S VSS) capacitor c=9.40115e-17
C36 (\3\:M1b VSS) capacitor c=6.50486e-17
C37 (\3\:M1 VSS) capacitor c=5.3037e-17
C38 (\6\:A VSS) capacitor c=1.61166e-17
C39 (\4\:A VSS) capacitor c=3.14943e-17
C40 (\4\:M0 VSS) capacitor c=4.67359e-17
C41 (\3\:S VSS) capacitor c=7.85102e-17
C42 (\3\:M0 VSS) capacitor c=3.58141e-17
C43 (\4\:net293 VSS) capacitor c=1.26922e-17
C44 (\2\:X2 VSS) capacitor c=5.12684e-17
C45 (\4\:X2b VSS) capacitor c=4.92652e-17
C46 (\2\:X2b VSS) capacitor c=2.49046e-17
C47 (\5\:M1 VSS) capacitor c=2.57489e-17
C48 (\5\:S VSS) capacitor c=2.68731e-17
C49 (\4\:M1b VSS) capacitor c=5.39714e-17
C50 (\2\:M1 VSS) capacitor c=7.4544e-17
C51 (\2\:M1b VSS) capacitor c=4.50928e-17
C52 (\2\:A VSS) capacitor c=5.4296e-17
C53 (\4\:M0b VSS) capacitor c=4.96838e-17
C54 (\5\:M0 VSS) capacitor c=4.95471e-17
C55 (\2\:M0b VSS) capacitor c=4.81998e-17
C56 (\2\:S VSS) capacitor c=6.55326e-17
C57 (\2\:M0 VSS) capacitor c=4.68798e-17
C58 (\1\:VDD VSS) capacitor c=1.18368e-16
C59 (\3\:PPN VSS) capacitor c=8.03129e-17
C60 (\5\:X2b VSS) capacitor c=3.00464e-17
C61 (\11\:net293 VSS) capacitor c=7.59396e-17
C62 (\5\:M1b VSS) capacitor c=5.07442e-17
C63 (\13\:VDD VSS) capacitor c=2.13163e-17
C64 (\4\:n1 VSS) capacitor c=1.6389e-16
C65 (\15\:VDD VSS) capacitor c=2.37099e-17
C66 (\9\:n0 VSS) capacitor c=2.38793e-17
C67 (\17\:VDD VSS) capacitor c=5.38885e-17
C68 (\11\:M0b VSS) capacitor c=4.86949e-17
C69 (\4\:VDD VSS) capacitor c=8.65329e-17
C70 (\1\:PPN VSS) capacitor c=3.68448e-17
C71 (\10\:X2b VSS) capacitor c=4.13085e-17
C72 (\6\:n1 VSS) capacitor c=7.62569e-17
C73 (\9\:net293 VSS) capacitor c=1.576e-16
C74 (\7\:n0 VSS) capacitor c=6.9022e-17
C75 (\10\:M1b VSS) capacitor c=4.78437e-17
C76 (\8\:n1 VSS) capacitor c=1.7495e-16
C77 (\5\:n0 VSS) capacitor c=9.71826e-17
C78 (\8\:M0b VSS) capacitor c=1.79486e-17
C79 (\3\:A VSS) capacitor c=1.55886e-17
C80 (\3\:X2 VSS) capacitor c=6.47109e-17
C81 (\7\:M0 VSS) capacitor c=7.37229e-17
C82 (\5\:M0b VSS) capacitor c=1.4061e-16
C83 (\6\:M0b VSS) capacitor c=1.30062e-16
C84 (\7\:M0b VSS) capacitor c=5.83902e-17
C85 (\10\:M0b VSS) capacitor c=2.34598e-17
C86 (\7\:A VSS) capacitor c=5.53598e-17
C87 (\7\:S VSS) capacitor c=1.52304e-16
C88 (\7\:M1 VSS) capacitor c=5.17755e-17
C89 (\8\:M1 VSS) capacitor c=2.78578e-17
C90 (\7\:M1b VSS) capacitor c=6.11493e-17
C91 (\8\:M1b VSS) capacitor c=9.36497e-17
C92 (\9\:M1b VSS) capacitor c=4.81491e-17
C93 (\3\:n0 VSS) capacitor c=2.33269e-16
C94 (\4\:n0 VSS) capacitor c=1.90008e-16
C95 (\3\:n1 VSS) capacitor c=3.47279e-16
C96 (\7\:X2b VSS) capacitor c=8.15406e-17
C97 (\8\:X2b VSS) capacitor c=5.75519e-17
C98 (\9\:X2b VSS) capacitor c=7.52033e-17
C99 (\7\:X2 VSS) capacitor c=4.70434e-17
C100 (\8\:net293 VSS) capacitor c=1.26155e-16
C101 (\6\:VDD VSS) capacitor c=4.44252e-17
C102 (\8\:VDD VSS) capacitor c=2.99935e-17
C103 (\9\:VDD VSS) capacitor c=2.14266e-17
Rk1 (\7\:M0 M0) resistor r=0.2478 c=0
Rk11 (\7\:M1 M1) resistor r=0.1922 c=0
Rk12 (M1 \8\:M1) resistor r=0.0364 c=0
Rk49 (\1\:VSS \6\:VSS) resistor r=0.729 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.1369 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.4653 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=0.198 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.2181 c=0
Rk55 (\11\:VSS VSS) resistor r=0.04993 c=0
Rk54 (\10\:VSS \11\:VSS) resistor r=0.0826 c=0
Rk57 (\7\:VSS \15\:VSS) resistor r=0.04334 c=0
Rk58 (\8\:VSS \17\:VSS) resistor r=0.3248 c=0
Rk59 (\10\:VSS \19\:VSS) resistor r=0.3281 c=0
Rk33 (PPN \2\:PPN) resistor r=0.1534 c=0
Rk34 (PPN \4\:PPN) resistor r=0.1444 c=0
Rk10 (\8\:S S) resistor r=0.00755 c=0
Rk9 (\7\:S \8\:S) resistor r=1.2624 c=0
Rk36 (\1\:VDD \5\:VDD) resistor r=0.1253 c=0
Rk37 (\5\:VDD \6\:VDD) resistor r=0.739 c=0
Rk38 (\6\:VDD \7\:VDD) resistor r=0.2623 c=0
Rk39 (\7\:VDD \8\:VDD) resistor r=0.177 c=0
Rk40 (\8\:VDD \9\:VDD) resistor r=0.4026 c=0
Rk42 (\10\:VDD VDD) resistor r=0.04993 c=0
Rk41 (\9\:VDD \10\:VDD) resistor r=0.1202 c=0
Rk44 (\6\:VDD \14\:VDD) resistor r=0.04334 c=0
Rk45 (\8\:VDD \16\:VDD) resistor r=0.04334 c=0
Rk46 (\9\:VDD \18\:VDD) resistor r=0.2808 c=0
Rk8 (A \7\:A) resistor r=0.02572 c=0
Rk30 (X2 \7\:X2) resistor r=0.1414 c=0
Rk3 (\5\:M0b \6\:M0b) resistor r=0.9383 c=0
Rk4 (\6\:M0b \7\:M0b) resistor r=0.2916 c=0
Rk5 (\7\:M0b \9\:M0b) resistor r=0.09782 c=0
Rk6 (\6\:M0b \10\:M0b) resistor r=0.072 c=0
Rk7 (\7\:M0b \12\:M0b) resistor r=0.4752 c=0
Rk17 (\2\:n0 \3\:n0) resistor r=0.02033 c=0
Rk18 (\3\:n0 \4\:n0) resistor r=1.4965 c=0
Rk19 (\4\:n0 \6\:n0) resistor r=0.5347 c=0
Rk20 (\3\:n0 \8\:n0) resistor r=0.4151 c=0
Rk21 (\4\:n0 \10\:n0) resistor r=0.06984 c=0
Rk22 (\2\:n1 \3\:n1) resistor r=0.4252 c=0
Rk23 (\3\:n1 \5\:n1) resistor r=1.0478 c=0
Rk24 (\2\:n1 \7\:n1) resistor r=0.4278 c=0
Rk25 (\3\:n1 \9\:n1) resistor r=1.5837 c=0
Rk13 (\6\:M1b \7\:M1b) resistor r=0.2551 c=0
Rk14 (\7\:M1b \8\:M1b) resistor r=0.4766 c=0
Rk15 (\8\:M1b \9\:M1b) resistor r=0.299 c=0
Rk16 (\7\:M1b \11\:M1b) resistor r=0.2465 c=0
Rk31 (\8\:net293 \10\:net293) resistor r=1.0046 c=0
Rk32 (\10\:net293 \12\:net293) resistor r=0.4278 c=0
Rk26 (\6\:X2b \7\:X2b) resistor r=0.1086 c=0
Rk27 (\7\:X2b \8\:X2b) resistor r=0.2904 c=0
Rk28 (\7\:X2b \9\:X2b) resistor r=0.5037 c=0
Rk29 (\8\:X2b \11\:X2b) resistor r=0.1523 c=0
Rl7 (\5\:M0 \6\:M0) resistor r=84.0659 c=0
Rl6 (\4\:M0 \5\:M0) resistor r=109.181 c=0
Rl1 (\1\:M0 \2\:M0) resistor r=84.6154 c=0
Rl2 (\2\:M0 \3\:M0) resistor r=101.374 c=0
Rl20 (\4\:M1 \5\:M1) resistor r=24.2328 c=0
Rl21 (\5\:M1 \6\:M1) resistor r=76.1559 c=0
Rl15 (\1\:M1 \2\:M1) resistor r=81.9251 c=0
Rl16 (\2\:M1 \3\:M1) resistor r=122.264 c=0
Rl19 (\4\:S \6\:S) resistor r=198.077 c=0
Rl18 (\4\:S \5\:S) resistor r=25.2509 c=0
Rl3 (\1\:S \2\:S) resistor r=26.9231 c=0
Rl4 (\2\:S \3\:S) resistor r=159.066 c=0
Rl9 (\1\:A \2\:A) resistor r=96.131 c=0
Rl12 (\2\:A \5\:A) resistor r=80.7464 c=0
Rl13 (\3\:A \6\:A) resistor r=44.2087 c=0
Rl11 (\3\:A \4\:A) resistor r=88.4394 c=0
Rl10 (\2\:A \3\:A) resistor r=72.5535 c=0
Rl24 (\1\:X2 \2\:X2) resistor r=24.848 c=0
Rl27 (\2\:X2 \5\:X2) resistor r=76.2482 c=0
Rl28 (\3\:X2 \6\:X2) resistor r=30.4507 c=0
Rl26 (\3\:X2 \4\:X2) resistor r=153.39 c=0
Rl25 (\2\:X2 \3\:X2) resistor r=179.178 c=0
Rl8 (\3\:M0b \4\:M0b) resistor r=102.615 c=0
Rl5 (M0b \2\:M0b) resistor r=26.1559 c=0
Rl17 (\3\:M1b \4\:M1b) resistor r=26.1559 c=0
Rl14 (M1b \2\:M1b) resistor r=102.615 c=0
Rl31 (net293 \4\:net293) resistor r=4.8851 c=0
Rl23 (\3\:X2b \4\:X2b) resistor r=120.667 c=0
Rl22 (X2b \2\:X2b) resistor r=76.7653 c=0
Rz15 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz9 (\2\:PPN \1\:PPN) resistor r=75 c=0
Rz10 (\5\:VDD \4\:VDD) resistor r=9.375 c=0
Rz11 (\7\:VDD \4\:VDD) resistor r=6.25 c=0
Rz12 (\10\:VDD \4\:VDD) resistor r=37.5 c=0
Rz1 (\8\:M0b \9\:M0b) resistor r=75 c=0
Rz3 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz4 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz2 (\10\:M1b \11\:M1b) resistor r=75 c=0
Rz8 (\10\:net293 \9\:net293) resistor r=75 c=0
Rz7 (\10\:X2b \11\:X2b) resistor r=75 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry16 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\9\:VSS \3\:VSS) resistor r=15.5 c=0
Ry18 (\11\:VSS \3\:VSS) resistor r=31 c=0
Ry9 (\4\:PPN \3\:PPN) resistor r=20.6667 c=0
Ry12 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry1 (\11\:M0b \12\:M0b) resistor r=62 c=0
Ry3 (n0 \2\:n0) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry5 (n1 \2\:n1) resistor r=62 c=0
Ry6 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry2 (\5\:M1b \6\:M1b) resistor r=62 c=0
Ry8 (\12\:net293 \11\:net293) resistor r=62 c=0
Ry7 (\5\:X2b \6\:X2b) resistor r=62 c=0
Rx2 (\2\:M0 M0) resistor r=45 c=0
Rx1 (\5\:M0 \7\:M0) resistor r=45 c=0
Rx8 (\5\:M1 \7\:M1) resistor r=45 c=0
Rx9 (\2\:M1 \8\:M1) resistor r=45 c=0
Rx6 (\5\:S \7\:S) resistor r=45 c=0
Rx7 (\2\:S \8\:S) resistor r=45 c=0
Rx5 (\2\:A \7\:A) resistor r=45 c=0
Rx14 (\2\:X2 \7\:X2) resistor r=45 c=0
Rx3 (\4\:M0b \5\:M0b) resistor r=45 c=0
Rx4 (\2\:M0b \10\:M0b) resistor r=45 c=0
Rx10 (\4\:M1b \8\:M1b) resistor r=45 c=0
Rx11 (\2\:M1b \9\:M1b) resistor r=45 c=0
Rx15 (\8\:net293 \4\:net293) resistor r=45 c=0
Rx12 (\4\:X2b \8\:X2b) resistor r=45 c=0
Rx13 (\2\:X2b \9\:X2b) resistor r=45 c=0
mn0 (\8\:M0b \3\:M0 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.97931e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (n3 \3\:S \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.88138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (\5\:n0 M0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.77638e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn6 (\5\:n0 \4\:M0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.9e-14 ps=7.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.53138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (n5 \4\:A \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.25638e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn9 (n9 \6\:A \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.93e-14 ps=6.1e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.05138e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\8\:n1 \3\:M1 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.32e-14 ps=9.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=6.66379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn8 (\8\:n1 \3\:M1b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=4.61379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn7 (n7 \6\:S \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=3.56379e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn1 (\10\:M1b \6\:M1 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.6e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6069e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (\9\:net293 \4\:X2 \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.697e-14 ad=2.32e-14 ps=8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (\6\:n1 \3\:X2b \9\:net293 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\10\:X2b \5\:X2 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.045e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=6.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn13_1__rcx (\1\:PPN net293 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.675e-14 ad=4.16e-14 ps=1.25e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67981e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp3 (n4 \1\:S \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.935e-14 ps=7.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.61372e-06 sd=160n sca=12.9155 \
        scb=0.0105511 scc=0.000191587 m=(1)
mp4 (\9\:n0 \6\:M0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=6.128e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.47872e-06 sd=160n sca=11.9971 \
        scb=0.00955136 scc=0.000188264 m=(1)
mp6 (\9\:n0 \3\:M0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.14872e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp5 (n6 \5\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=1.29e-14 ps=1.45e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.04372e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp9 (n10 \1\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.78721e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp10 (\4\:n1 M1b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.56e-14 ps=7.8e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.58721e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp8 (\4\:n1 \1\:M1 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.56e-14 ps=7.2e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=4.68837e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp7 (n8 \4\:S \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.32e-14 ad=3.117e-14 ps=1.81e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2.78837e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp1 (\5\:M1b \4\:M1 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.32e-14 ad=5.697e-14 ps=1.81e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.72791e-07 sb=2.65e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp11 (\11\:net293 X2b n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.547e-14 ps=9.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=3.5e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp12 (n1 \6\:X2 \11\:net293 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp2 (\5\:X2b \1\:X2 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.942e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=18.9525 \
        scb=0.0183104 scc=0.0014243 m=(1)
mp13_1__rcx (\3\:PPN net293 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.701e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.54359e-07 sb=3.45e-07 sd=160n sca=34.0333 \
        scb=0.0243751 scc=0.00339915 m=(2)
ends BMXIX2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:44:52 2012 )
// Library name: gsclib045
// Cell name: BMXIX4
// View name: extracted

simulator lang=spectre

subckt BMXIX4 A M0 M1 PPN S VDD VSS X2
mp0 (\11\:M0b \1\:M0 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.276e-13 ad=3.44e-14 ps=2.05e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=44.4931 scb=0.0420172 \
        scc=0.00520661 m=(1)
C1 (M0 VSS) capacitor c=8.2055e-17
C2 (M1 VSS) capacitor c=6.15333e-17
C3 (PPN VSS) capacitor c=2.57104e-16
C4 (S VSS) capacitor c=1.9116e-16
C5 (VDD VSS) capacitor c=2.87285e-16
C6 (A VSS) capacitor c=3.09259e-17
C7 (X2 VSS) capacitor c=9.30464e-17
C8 (M0b VSS) capacitor c=6.45388e-17
C9 (n0 VSS) capacitor c=7.04935e-17
C10 (n5 VSS) capacitor c=2.40959e-18
C11 (n1 VSS) capacitor c=9.76951e-17
C12 (M1b VSS) capacitor c=3.27798e-17
C13 (net293 VSS) capacitor c=2.10952e-16
C14 (X2b VSS) capacitor c=5.31255e-17
C15 (n4 VSS) capacitor c=2.52684e-18
C16 (n6 VSS) capacitor c=1.68863e-18
C17 (n10 VSS) capacitor c=4.47851e-18
C18 (n8 VSS) capacitor c=1.39476e-18
C19 (\3\:X2 VSS) capacitor c=3.18564e-17
C20 (\5\:X2 VSS) capacitor c=6.92234e-17
C21 (\4\:X2b VSS) capacitor c=4.92668e-17
C22 (\7\:M1 VSS) capacitor c=3.13963e-17
C23 (\5\:S VSS) capacitor c=1.18721e-16
C24 (\3\:M1 VSS) capacitor c=7.32634e-17
C25 (\3\:M1b VSS) capacitor c=7.99958e-17
C26 (\1\:A VSS) capacitor c=2.27358e-17
C27 (\5\:A VSS) capacitor c=5.36044e-17
C28 (\3\:M0b VSS) capacitor c=7.32238e-17
C29 (\4\:M0 VSS) capacitor c=5.91652e-17
C30 (\1\:S VSS) capacitor c=2.75854e-17
C31 (\1\:M0 VSS) capacitor c=2.41844e-17
C32 (\6\:X2 VSS) capacitor c=3.56152e-17
C33 (\3\:X2b VSS) capacitor c=3.19038e-17
C34 (\2\:X2 VSS) capacitor c=3.85712e-17
C35 (\5\:M1 VSS) capacitor c=3.22189e-17
C36 (\4\:S VSS) capacitor c=8.1854e-17
C37 (\1\:M1 VSS) capacitor c=4.66238e-17
C38 (\4\:A VSS) capacitor c=2.92208e-17
C39 (\6\:A VSS) capacitor c=2.83156e-17
C40 (\5\:M0 VSS) capacitor c=5.72763e-17
C41 (\3\:S VSS) capacitor c=7.57341e-17
C42 (\3\:M0 VSS) capacitor c=4.43649e-17
C43 (\6\:net293 VSS) capacitor c=2.22445e-17
C44 (\7\:X2 VSS) capacitor c=1.81246e-17
C45 (\1\:X2 VSS) capacitor c=3.15599e-17
C46 (\6\:M1 VSS) capacitor c=2.70229e-17
C47 (\2\:M1b VSS) capacitor c=8.58787e-17
C48 (\6\:S VSS) capacitor c=3.04223e-17
C49 (\4\:M1 VSS) capacitor c=5.01103e-17
C50 (\2\:M1 VSS) capacitor c=2.15317e-17
C51 (\2\:A VSS) capacitor c=2.78534e-17
C52 (\4\:M0b VSS) capacitor c=3.56923e-17
C53 (\6\:M0 VSS) capacitor c=3.16015e-17
C54 (\2\:M0b VSS) capacitor c=3.18768e-17
C55 (\2\:S VSS) capacitor c=5.30173e-17
C56 (\2\:M0 VSS) capacitor c=4.29686e-17
C57 (\1\:VDD VSS) capacitor c=1.88518e-16
C58 (\5\:X2b VSS) capacitor c=3.91765e-17
C59 (\7\:n1 VSS) capacitor c=9.05581e-17
C60 (\15\:net293 VSS) capacitor c=1.50333e-16
C61 (\3\:n0 VSS) capacitor c=2.95145e-16
C62 (\7\:M1b VSS) capacitor c=6.33933e-17
C63 (\16\:VDD VSS) capacitor c=2.39923e-17
C64 (\3\:n1 VSS) capacitor c=3.22204e-16
C65 (\18\:VDD VSS) capacitor c=1.72938e-17
C66 (\6\:n0 VSS) capacitor c=3.11451e-16
C67 (\20\:VDD VSS) capacitor c=1.3696e-17
C68 (\11\:M0b VSS) capacitor c=4.64537e-17
C69 (\3\:VDD VSS) capacitor c=9.56354e-17
C70 (\9\:X2b VSS) capacitor c=2.65755e-17
C71 (\5\:n1 VSS) capacitor c=2.51292e-16
C72 (\17\:net293 VSS) capacitor c=1.01144e-16
C73 (\4\:M1b VSS) capacitor c=6.02024e-17
C74 (\8\:n0 VSS) capacitor c=1.14012e-16
C75 (\8\:M0b VSS) capacitor c=2.09804e-17
C76 (\3\:A VSS) capacitor c=2.89501e-17
C77 (\2\:X2b VSS) capacitor c=3.33682e-17
C78 (\4\:X2 VSS) capacitor c=5.58867e-17
C79 (\7\:M0 VSS) capacitor c=7.31232e-17
C80 (\8\:M0 VSS) capacitor c=5.1844e-17
C81 (\5\:M0b VSS) capacitor c=1.52414e-16
C82 (\6\:M0b VSS) capacitor c=1.38199e-16
C83 (\7\:M0b VSS) capacitor c=4.1201e-17
C84 (\10\:M0b VSS) capacitor c=2.35688e-17
C85 (\7\:A VSS) capacitor c=5.35352e-17
C86 (\7\:S VSS) capacitor c=1.44702e-16
C87 (\8\:S VSS) capacitor c=5.83051e-17
C88 (\8\:M1 VSS) capacitor c=7.79983e-17
C89 (\9\:M1 VSS) capacitor c=8.03828e-17
C90 (\10\:M1 VSS) capacitor c=1.04166e-16
C91 (\6\:M1b VSS) capacitor c=5.04589e-17
C92 (\8\:X2 VSS) capacitor c=1.30937e-16
C93 (\7\:X2b VSS) capacitor c=2.26886e-17
C94 (\8\:X2b VSS) capacitor c=1.8907e-17
C95 (\14\:net293 VSS) capacitor c=1.19046e-16
C96 (\8\:VDD VSS) capacitor c=4.19131e-17
C97 (\9\:VDD VSS) capacitor c=1.67843e-17
C98 (\11\:VDD VSS) capacitor c=2.19578e-17
Rk1 (\7\:M0 M0) resistor r=0.5202 c=0
Rk2 (M0 \8\:M0) resistor r=0.2854 c=0
Rk11 (\8\:M1 M1) resistor r=0.3572 c=0
Rk12 (M1 \9\:M1) resistor r=0.01532 c=0
Rk13 (\9\:M1 \10\:M1) resistor r=0.6634 c=0
Rk9 (\7\:S S) resistor r=1.1385 c=0
Rk10 (S \8\:S) resistor r=0.3351 c=0
Rk39 (\1\:VDD \7\:VDD) resistor r=0.3259 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.6033 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.4392 c=0
Rk42 (\9\:VDD \10\:VDD) resistor r=0.1067 c=0
Rk44 (\11\:VDD VDD) resistor r=0.129 c=0
Rk43 (\10\:VDD \11\:VDD) resistor r=0.3701 c=0
Rk47 (\8\:VDD \17\:VDD) resistor r=0.04332 c=0
Rk48 (\9\:VDD \19\:VDD) resistor r=0.04332 c=0
Rk49 (\11\:VDD \21\:VDD) resistor r=0.04332 c=0
Rk8 (A \7\:A) resistor r=0.03906 c=0
Rk53 (\1\:VSS \7\:VSS) resistor r=0.2406 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.6168 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.5881 c=0
Rk57 (\10\:VSS VSS) resistor r=0.1149 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.4365 c=0
Rk60 (\8\:VSS \16\:VSS) resistor r=0.07405 c=0
Rk61 (\9\:VSS \18\:VSS) resistor r=0.1618 c=0
Rk62 (\10\:VSS \20\:VSS) resistor r=0.1967 c=0
Rk21 (\9\:X2 X2) resistor r=0.003305 c=0
Rk20 (\8\:X2 \9\:X2) resistor r=0.6718 c=0
Rk3 (\5\:M0b \6\:M0b) resistor r=1.049 c=0
Rk4 (\6\:M0b \7\:M0b) resistor r=0.3176 c=0
Rk5 (\7\:M0b \9\:M0b) resistor r=0.1435 c=0
Rk6 (\6\:M0b \10\:M0b) resistor r=0.08444 c=0
Rk7 (\7\:M0b \12\:M0b) resistor r=0.325 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.3782 c=0
Rk17 (\4\:n0 \5\:n0) resistor r=0.1747 c=0
Rk18 (\5\:n0 \7\:n0) resistor r=1.6976 c=0
Rk19 (\7\:n0 \9\:n0) resistor r=0.6814 c=0
Rk22 (\2\:n1 \4\:n1) resistor r=0.5269 c=0
Rk23 (\4\:n1 \6\:n1) resistor r=1.8847 c=0
Rk24 (\6\:n1 \8\:n1) resistor r=0.511 c=0
Rk14 (\5\:M1b \6\:M1b) resistor r=0.3062 c=0
Rk15 (\5\:M1b \8\:M1b) resistor r=0.2797 c=0
Rk28 (\14\:net293 \16\:net293) resistor r=0.8735 c=0
Rk29 (\16\:net293 \18\:net293) resistor r=0.5134 c=0
Rk25 (\6\:X2b \7\:X2b) resistor r=0.1599 c=0
Rk26 (\7\:X2b \8\:X2b) resistor r=0.07445 c=0
Rk27 (\7\:X2b \10\:X2b) resistor r=0.0638 c=0
Rl6 (\4\:M0 \5\:M0) resistor r=200 c=0
Rl7 (\4\:M0 \6\:M0) resistor r=87.2302 c=0
Rl1 (\1\:M0 \2\:M0) resistor r=24.2328 c=0
Rl2 (\2\:M0 \3\:M0) resistor r=147.31 c=0
Rl21 (\6\:M1 \7\:M1) resistor r=32.4874 c=0
Rl20 (\5\:M1 \6\:M1) resistor r=44.4893 c=0
Rl15 (\3\:M1 \4\:M1) resistor r=35.7713 c=0
Rl14 (\1\:M1 \2\:M1) resistor r=24.2328 c=0
Rl18 (\4\:S \5\:S) resistor r=278.412 c=0
Rl19 (\5\:S \6\:S) resistor r=49.2328 c=0
Rl3 (\1\:S \2\:S) resistor r=65.3618 c=0
Rl4 (\2\:S \3\:S) resistor r=130.564 c=0
Rl9 (\1\:A \2\:A) resistor r=46.1884 c=0
Rl12 (\2\:A \5\:A) resistor r=63.6565 c=0
Rl11 (\3\:A \4\:A) resistor r=105.833 c=0
Rl13 (\3\:A \6\:A) resistor r=155.254 c=0
Rl10 (\2\:A \3\:A) resistor r=11.0904 c=0
Rl29 (\5\:X2 \7\:X2) resistor r=26.1559 c=0
Rl22 (\1\:X2 \2\:X2) resistor r=49.2922 c=0
Rl26 (\3\:X2 \4\:X2) resistor r=28.0797 c=0
Rl27 (\4\:X2 \5\:X2) resistor r=221.58 c=0
Rl28 (\4\:X2 \6\:X2) resistor r=60.772 c=0
Rl8 (\3\:M0b \4\:M0b) resistor r=24.2328 c=0
Rl5 (M0b \2\:M0b) resistor r=73.0541 c=0
Rl16 (M1b \2\:M1b) resistor r=74.2328 c=0
Rl17 (\2\:M1b \3\:M1b) resistor r=236.093 c=0
Rl34 (net293 \6\:net293) resistor r=4.6806 c=0
Rl23 (X2b \2\:X2b) resistor r=154.219 c=0
Rl25 (\2\:X2b \4\:X2b) resistor r=76.1566 c=0
Rl24 (\2\:X2b \3\:X2b) resistor r=28.0797 c=0
Rz11 (\1\:VDD \3\:VDD) resistor r=37.5 c=0
Rz12 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz13 (\10\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz17 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz19 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\8\:M0b \9\:M0b) resistor r=75 c=0
Rz3 (n0 \2\:n0) resistor r=75 c=0
Rz4 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz5 (n1 \2\:n1) resistor r=75 c=0
Rz6 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz2 (\4\:M1b \5\:M1b) resistor r=75 c=0
Rz8 (\18\:net293 \17\:net293) resistor r=75 c=0
Rz7 (\9\:X2b \10\:X2b) resistor r=75 c=0
Ry15 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry19 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry20 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\11\:M0b \12\:M0b) resistor r=62 c=0
Ry3 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry4 (\3\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\3\:n1 \4\:n1) resistor r=62 c=0
Ry7 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry2 (\7\:M1b \8\:M1b) resistor r=62 c=0
Ry9 (\16\:net293 \15\:net293) resistor r=31 c=0
Ry8 (\5\:X2b \6\:X2b) resistor r=62 c=0
Rx1 (\6\:M0 \7\:M0) resistor r=45 c=0
Rx2 (\2\:M0 \8\:M0) resistor r=45 c=0
Rx8 (\6\:M1 \8\:M1) resistor r=45 c=0
Rx9 (\4\:M1 \9\:M1) resistor r=45 c=0
Rx10 (\2\:M1 \10\:M1) resistor r=45 c=0
Rx6 (\6\:S \7\:S) resistor r=45 c=0
Rx7 (\2\:S \8\:S) resistor r=45 c=0
Rx5 (\2\:A \7\:A) resistor r=45 c=0
Rx12 (\1\:X2 \8\:X2) resistor r=45 c=0
Rx13 (\7\:X2 \9\:X2) resistor r=45 c=0
Rx3 (\4\:M0b \5\:M0b) resistor r=45 c=0
Rx4 (\2\:M0b \10\:M0b) resistor r=45 c=0
Rx11 (\2\:M1b \6\:M1b) resistor r=45 c=0
Rx15 (\14\:net293 \6\:net293) resistor r=45 c=0
Rx14 (X2b \8\:X2b) resistor r=45 c=0
mn0 (\8\:M0b \3\:M0 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn3 (n3 \3\:S \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.905e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\8\:n0 M0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=4.205e-14 ps=4.1e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.7e-07 sb=1.8e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn6 (\8\:n0 \5\:M0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=4.205e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.465e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn5 (n5 \6\:A \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.21e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn9 (n9 \4\:A \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.005e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn10 (n1 \1\:M1 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.537e-14 \
        ad=6.67e-14 ps=6.4e-07 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.485e-06 sb=7.85e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn8 (n1 M1b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=6.67e-14 ps=5.6e-07 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.99e-06 sb=2.8e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn7 (n7 \4\:S \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.957e-14 ps=1.6e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1e-07 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn1 (\4\:M1b \5\:M1 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn11 (\17\:net293 \2\:X2 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.30385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn12 (\5\:n1 \3\:X2b \17\:net293 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.26e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.25385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn2 (\9\:X2b \6\:X2 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn13_1__rcx (PPN net293 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.858e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp3 (n4 \1\:S \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.276e-13 ad=5.053e-14 ps=2.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=2e-06 sd=160n sca=34.6718 scb=0.0267184 \
        scc=0.00427277 m=(1)
mp4 (\6\:n0 \4\:M0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.73e-06 sd=160n sca=33.4709 \
        scb=0.0258398 scc=0.00427134 m=(1)
mp6 (\6\:n0 \3\:M0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.525e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp5 (n6 \5\:A \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=1.29e-14 ps=1.85e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.42e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp9 (n10 \1\:A \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.515e-14 ad=5.483e-14 ps=1.85e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.225e-06 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp10 (\3\:n1 \3\:M1b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.61e-06 sb=9.25e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp8 (\3\:n1 \3\:M1 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=7.2e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp7 (n8 \5\:S \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3835e-13 ad=1.29e-14 ps=2.15e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=6.15e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp1 (\7\:M1b \7\:M1 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3835e-13 ad=4.3e-14 ps=2.15e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=33.2772 scb=0.0257934 \
        scc=0.00427133 m=(1)
mp11 (\15\:net293 \4\:X2b \3\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.945e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp12 (\7\:n1 \5\:X2 \15\:net293 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp2 (\5\:X2b \3\:X2 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.605e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp13_1__rcx (PPN net293 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.136e-14 ad=6.24e-14 ps=1.1825e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35962e-07 sb=7.55e-07 sd=160n sca=30.8435 \
        scb=0.0202998 scc=0.00336099 m=(4)
ends BMXIX4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:45:31 2012 )
// Library name: gsclib045
// Cell name: BUFX12
// View name: extracted

simulator lang=spectre

subckt BUFX12 A VDD VSS Y
mp1 (\1\:Y n0 VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.378e-14 \
        ad=7.52e-14 ps=1.256e-06 pd=1.26e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.99064e-06 sd=160n sca=28.0481 scb=0.031636 \
        scc=0.00223037 m=(10)
C1 (Y VSS) capacitor c=1.69823e-17
C2 (VDD VSS) capacitor c=6.84978e-16
C3 (A VSS) capacitor c=4.04626e-17
C4 (n0 VSS) capacitor c=9.0255e-16
C5 (\1\:A VSS) capacitor c=2.42549e-16
C6 (\31\:n0 VSS) capacitor c=1.67764e-16
C7 (\1\:Y VSS) capacitor c=5.36753e-16
C8 (\1\:VDD VSS) capacitor c=3.22273e-17
C9 (\15\:Y VSS) capacitor c=6.37652e-16
C10 (\10\:A VSS) capacitor c=4.06488e-17
C11 (\34\:n0 VSS) capacitor c=4.23084e-17
C12 (\42\:n0 VSS) capacitor c=1.64887e-16
Rk5 (\1\:Y Y) resistor r=0.1468 c=0
Rk10 (Y \15\:Y) resistor r=0.1717 c=0
Rk31 (\2\:VDD VDD) resistor r=0.1178 c=0
Rk19 (A \10\:A) resistor r=0.09983 c=0
Rk47 (\2\:VSS VSS) resistor r=0.1178 c=0
Rk22 (\34\:n0 n0) resistor r=0.3289 c=0
Rk21 (\31\:n0 \34\:n0) resistor r=0.2235 c=0
Rk28 (\34\:n0 \42\:n0) resistor r=0.08258 c=0
Rz9 (VDD \1\:VDD) resistor r=5.7692 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Ry16 (VSS \1\:VSS) resistor r=4.7692 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=31 c=0
Rx1 (\10\:A \1\:A) resistor r=45 c=0
mn1 (VSS n0 \15\:Y VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.96e-14 \
        ad=4.868e-14 ps=9.4e-07 pd=9.36e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.99113e-06 sd=160n sca=9.61806 scb=0.00827687 \
        scc=0.000298696 m=(10)
mn0 (VSS \1\:A \42\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.327e-14 ps=8.2667e-07 pd=8.7333e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(3)
mp0 (\31\:n0 \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.507e-14 ad=5.98e-14 ps=1.15333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=12.5423 scb=0.0105189 \
        scc=0.000333341 m=(3)
ends BUFX12
// End of subcircuit definition.

// Generated for: spectre (May  9 13:46:08 2012 )
// Library name: gsclib045
// Cell name: BUFX16
// View name: extracted

simulator lang=spectre

subckt BUFX16 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.033e-14 ad=7.12e-14 ps=1.20714e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (Y VSS) capacitor c=1.6684e-17
C2 (VDD VSS) capacitor c=9.24973e-16
C3 (A VSS) capacitor c=3.60905e-17
C4 (n0 VSS) capacitor c=1.2547e-15
C5 (\1\:A VSS) capacitor c=2.40359e-16
C6 (\43\:n0 VSS) capacitor c=2.2771e-16
C7 (\1\:Y VSS) capacitor c=8.62011e-16
C8 (\9\:Y VSS) capacitor c=7.47065e-16
C9 (\46\:n0 VSS) capacitor c=2.67797e-17
C10 (\56\:n0 VSS) capacitor c=1.71777e-16
C11 (\13\:A VSS) capacitor c=6.77088e-17
C12 (\14\:A VSS) capacitor c=5.94293e-17
Rk7 (\1\:Y Y) resistor r=0.08238 c=0
Rk8 (Y \9\:Y) resistor r=0.0911 c=0
Rk40 (A \13\:A) resistor r=0.1621 c=0
Rk41 (\13\:A \14\:A) resistor r=0.138 c=0
Rk29 (\46\:n0 n0) resistor r=0.203 c=0
Rk28 (\43\:n0 \46\:n0) resistor r=0.09951 c=0
Rk37 (\46\:n0 \56\:n0) resistor r=0.1042 c=0
Rx8 (\13\:A \1\:A) resistor r=45 c=0
Rx9 (\14\:A \1\:A) resistor r=45 c=0
mn1_1__rcx (VSS n0 \9\:Y VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=6.251e-14 ps=9.1e-07 pd=1.43643e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
mn0_1__rcx (VSS \1\:A \56\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.557e-14 ps=8.4e-07 pd=1.3275e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mp0_1__rcx (\43\:n0 \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.182e-14 ad=6.24e-14 ps=1.1175e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=18.4487 scb=0.016003 \
        scc=0.00159615 m=(4)
ends BUFX16
// End of subcircuit definition.

// Generated for: spectre (May  9 13:46:45 2012 )
// Library name: gsclib045
// Cell name: BUFX2
// View name: extracted

simulator lang=spectre

subckt BUFX2 A VDD VSS Y
mp1 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.325e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.40064e-07 sd=160n sca=36.3413 scb=0.0370255 \
        scc=0.00367875 m=(2)
C1 (VDD VSS) capacitor c=1.541e-16
C2 (A VSS) capacitor c=2.072e-17
C3 (Y VSS) capacitor c=1.43584e-17
C4 (n0 VSS) capacitor c=1.66981e-16
C5 (\1\:A VSS) capacitor c=4.14791e-17
C6 (\3\:A VSS) capacitor c=3.79386e-17
C7 (\2\:A VSS) capacitor c=4.68756e-17
C8 (\7\:n0 VSS) capacitor c=6.00595e-17
C9 (\1\:Y VSS) capacitor c=8.11563e-17
C10 (\10\:n0 VSS) capacitor c=4.58397e-17
C11 (\4\:Y VSS) capacitor c=6.31819e-17
C12 (\3\:Y VSS) capacitor c=3.6452e-17
C13 (\9\:n0 VSS) capacitor c=1.13585e-16
C14 (\4\:A VSS) capacitor c=6.34529e-17
Rk6 (A \4\:A) resistor r=0.03418 c=0
Rk2 (\3\:Y Y) resistor r=0.02506 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.2469 c=0
Rk3 (\3\:Y \5\:Y) resistor r=0.2478 c=0
Rk4 (\8\:n0 \9\:n0) resistor r=0.5054 c=0
Rk5 (\9\:n0 \11\:n0) resistor r=0.3851 c=0
Rl6 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl7 (\2\:A \3\:A) resistor r=100.692 c=0
Rz1 (\5\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\9\:n0 n0) resistor r=45 c=0
mn1 (VSS n0 \4\:Y VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.555e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.41635e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(2)
mn0 (VSS \3\:A \10\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.47e-14 ps=5.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp0 (\7\:n0 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=16.9419 \
        scb=0.0158681 scc=0.000320204 m=(1)
ends BUFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:47:23 2012 )
// Library name: gsclib045
// Cell name: BUFX20
// View name: extracted

simulator lang=spectre

subckt BUFX20 A VDD VSS Y
mp1_1__rcx (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.335e-14 ad=7.306e-14 ps=1.24e-06 pd=1.23765e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=39.4883 scb=0.0368308 \
        scc=0.00409097 m=(17)
C1 (Y VSS) capacitor c=1.51032e-17
C2 (VDD VSS) capacitor c=1.61253e-16
C3 (A VSS) capacitor c=4.25706e-17
C4 (n0 VSS) capacitor c=1.6528e-15
C5 (\1\:A VSS) capacitor c=3.76196e-16
C6 (\52\:n0 VSS) capacitor c=2.56493e-16
C7 (\1\:Y VSS) capacitor c=1.11593e-15
C8 (\1\:VDD VSS) capacitor c=9.45456e-16
C9 (\11\:Y VSS) capacitor c=1.11206e-15
C10 (\56\:n0 VSS) capacitor c=1.96569e-17
C11 (\69\:n0 VSS) capacitor c=2.34829e-16
Rk9 (\1\:Y Y) resistor r=0.09454 c=0
Rk10 (Y \11\:Y) resistor r=0.0734 c=0
Rk72 (\1\:VDD VDD) resistor r=0.1026 c=0
Rk35 (A \1\:A) resistor r=0.1211 c=0
Rk101 (\1\:VSS VSS) resistor r=0.1026 c=0
Rk40 (\56\:n0 n0) resistor r=0.1469 c=0
Rk39 (\52\:n0 \56\:n0) resistor r=0.2067 c=0
Rk50 (\56\:n0 \69\:n0) resistor r=0.1315 c=0
mn1_1__rcx (\1\:VSS n0 \11\:Y VSS) g45n1svt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.864e-14 ps=9.2765e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
mn0_1__rcx (\1\:VSS \1\:A \69\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.056e-14 ad=4.25e-14 ps=8.32e-07 pd=8.58e-07 nrd=1.16667 \
