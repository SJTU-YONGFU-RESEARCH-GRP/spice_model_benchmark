        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\18\:n0 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\4\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.323e-14 ad=4.16e-14 ps=8.525e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.7e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp0 (n1 \1\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.9e-07 sd=160n sca=16.2105 \
        scb=0.0148596 scc=0.000661709 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.484e-14 ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.7e-07 sd=160n sca=14.5024 \
        scb=0.0125934 scc=0.000647761 m=(4)
ends OR2X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:27:38 2012 )
// Library name: gsclib045
// Cell name: OR2X6
// View name: extracted

simulator lang=spectre

subckt OR2X6 A B VDD VSS Y
mp0 (3 \1\:A \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.68e-06 sd=160n sca=18.0856 \
        scb=0.0187649 scc=0.00060075 m=(1)
C1 (Y VSS) capacitor c=2.24543e-17
C2 (A VSS) capacitor c=2.64898e-17
C3 (VDD VSS) capacitor c=1.0842e-16
C4 (B VSS) capacitor c=3.50776e-17
C5 (n0 VSS) capacitor c=4.28685e-16
C6 (3 VSS) capacitor c=1.21067e-18
C7 (5 VSS) capacitor c=1.33527e-18
C8 (\6\:A VSS) capacitor c=8.67337e-17
C9 (\1\:B VSS) capacitor c=7.68936e-17
C10 (\5\:B VSS) capacitor c=4.22224e-17
C11 (\1\:A VSS) capacitor c=5.93981e-17
C12 (\2\:B VSS) capacitor c=2.92452e-17
C13 (\2\:A VSS) capacitor c=3.56524e-16
C14 (\1\:Y VSS) capacitor c=2.88332e-16
C15 (\23\:n0 VSS) capacitor c=9.40939e-17
C16 (\16\:VDD VSS) capacitor c=4.36455e-17
C17 (\1\:VDD VSS) capacitor c=5.16649e-17
C18 (\3\:B VSS) capacitor c=9.60239e-17
C19 (\7\:B VSS) capacitor c=3.70096e-17
C20 (\19\:n0 VSS) capacitor c=1.2088e-16
C21 (\20\:n0 VSS) capacitor c=2.34595e-16
C22 (\4\:Y VSS) capacitor c=2.99999e-16
C23 (\3\:VDD VSS) capacitor c=2.39326e-16
C24 (\8\:VDD VSS) capacitor c=1.22816e-17
Rk20 (\4\:Y Y) resistor r=0.06242 c=0
Rk11 (\1\:Y \4\:Y) resistor r=0.1348 c=0
Rk3 (\2\:A A) resistor r=0.01427 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1153 c=0
Rk25 (\3\:VDD \7\:VDD) resistor r=0.03996 c=0
Rk27 (\8\:VDD VDD) resistor r=0.06481 c=0
Rk26 (\7\:VDD \8\:VDD) resistor r=0.2859 c=0
Rk32 (\8\:VDD \17\:VDD) resistor r=0.3 c=0
Rk33 (\2\:VSS VSS) resistor r=0.1153 c=0
Rk44 (VSS \18\:VSS) resistor r=0.3168 c=0
Rk1 (B \7\:B) resistor r=0.04792 c=0
Rk5 (n0 \19\:n0) resistor r=0.2354 c=0
Rk6 (\19\:n0 \20\:n0) resistor r=0.3061 c=0
Rk8 (\19\:n0 \24\:n0) resistor r=0.6687 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz9 (VDD \1\:VDD) resistor r=75 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\7\:VDD \1\:VDD) resistor r=12.5 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=37.5 c=0
Ry8 (\17\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry10 (VSS \1\:VSS) resistor r=6.8889 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\24\:n0 \23\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\20\:n0 \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=4.355e-14 ps=8.85e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.81e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn1 (\20\:n0 \3\:B \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.59e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn2 (\4\:Y n0 VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.978e-14 \
        ad=4.836e-14 ps=9.46e-07 pd=9.32e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.46452e-07 sb=9.6e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mp1 (\23\:n0 \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.545e-06 sd=160n sca=15.1734 scb=0.013698 \
        scc=0.000458097 m=(1)
mp1_1__rcx (\23\:n0 \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.34e-06 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_1__rcx (5 \6\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=2.34e-14 ps=1.4e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.235e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=7.332e-14 ps=1.288e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30638e-07 sb=9.6e-07 sd=160n sca=16.497 \
        scb=0.0142421 scc=0.00124485 m=(5)
ends OR2X6
// End of subcircuit definition.

// Generated for: spectre (May  8 15:28:26 2012 )
// Library name: gsclib045
// Cell name: OR2X8
// View name: extracted

simulator lang=spectre

subckt OR2X8 A B VDD VSS Y
mp0 (3 \1\:A \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.0856 scb=0.0187649 \
        scc=0.00060075 m=(1)
C1 (Y VSS) capacitor c=1.97308e-17
C2 (A VSS) capacitor c=2.44302e-17
C3 (VDD VSS) capacitor c=1.4172e-16
C4 (B VSS) capacitor c=3.5955e-17
C5 (n0 VSS) capacitor c=6.27249e-16
C6 (3 VSS) capacitor c=1.2068e-18
C7 (5 VSS) capacitor c=1.33304e-18
C8 (\6\:A VSS) capacitor c=8.67308e-17
C9 (\1\:B VSS) capacitor c=7.6852e-17
C10 (\5\:B VSS) capacitor c=4.21805e-17
C11 (\1\:A VSS) capacitor c=5.94081e-17
C12 (\2\:B VSS) capacitor c=2.91242e-17
C13 (\2\:A VSS) capacitor c=3.55553e-16
C14 (\1\:Y VSS) capacitor c=4.20907e-16
C15 (\30\:n0 VSS) capacitor c=9.44353e-17
C16 (\20\:VDD VSS) capacitor c=4.2369e-17
C17 (\1\:VDD VSS) capacitor c=6.86343e-17
C18 (\3\:B VSS) capacitor c=9.60212e-17
C19 (\7\:B VSS) capacitor c=3.6763e-17
C20 (\26\:n0 VSS) capacitor c=1.19699e-16
C21 (\27\:n0 VSS) capacitor c=2.34143e-16
C22 (\4\:Y VSS) capacitor c=4.37834e-16
C23 (\3\:VDD VSS) capacitor c=3.08631e-16
C24 (\10\:VDD VSS) capacitor c=1.22986e-17
Rk25 (\4\:Y Y) resistor r=0.05758 c=0
Rk12 (\1\:Y \4\:Y) resistor r=0.1288 c=0
Rk3 (\2\:A A) resistor r=0.01429 c=0
Rk26 (\2\:VDD \3\:VDD) resistor r=0.1103 c=0
Rk32 (\3\:VDD \9\:VDD) resistor r=0.03998 c=0
Rk34 (\10\:VDD VDD) resistor r=0.06483 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.286 c=0
Rk40 (\10\:VDD \21\:VDD) resistor r=0.3009 c=0
Rk41 (\2\:VSS VSS) resistor r=0.1103 c=0
Rk55 (VSS \22\:VSS) resistor r=0.3178 c=0
Rk1 (B \7\:B) resistor r=0.04793 c=0
Rk6 (n0 \26\:n0) resistor r=0.2362 c=0
Rk7 (\26\:n0 \27\:n0) resistor r=0.3069 c=0
Rk9 (\26\:n0 \31\:n0) resistor r=0.6715 c=0
Rl9 (\2\:A \6\:A) resistor r=76.0989 c=0
Rl1 (\2\:A \1\:A) resistor r=86.5157 c=0
Rl3 (\2\:B \1\:B) resistor r=77.4283 c=0
Rl6 (\2\:B \5\:B) resistor r=21.9171 c=0
Rl4 (\3\:B \2\:B) resistor r=54.2909 c=0
Rz11 (VDD \1\:VDD) resistor r=75 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz10 (\9\:VDD \1\:VDD) resistor r=12.5 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=37.5 c=0
Ry10 (\21\:VDD \20\:VDD) resistor r=20.6667 c=0
Ry14 (VSS \1\:VSS) resistor r=5.6364 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\31\:n0 \30\:n0) resistor r=31 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\27\:n0 \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.295e-14 ad=4.355e-14 ps=8.75e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn1 (\27\:n0 \3\:B \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.355e-14 ps=8.4e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2e-06 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(2)
mn2 (\4\:Y n0 VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 as=4.821e-14 \
        ad=4.714e-14 ps=9.2429e-07 pd=9.1429e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.71333e-07 sb=1.37e-06 sd=160n sca=15.1988 scb=0.0148036 \
        scc=0.00121652 m=(7)
mp1 (\30\:n0 \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=6.24e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.955e-06 sd=160n sca=15.1734 scb=0.013698 \
        scc=0.000458097 m=(1)
mp1_1__rcx (\30\:n0 \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.75e-06 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_1__rcx (5 \6\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.57e-14 ad=2.34e-14 ps=1.36e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.645e-06 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp2 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.539e-14 ad=7.071e-14 ps=1.24e-06 pd=1.21429e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.58667e-07 sb=1.37e-06 sd=160n sca=15.101 \
        scb=0.013378 scc=0.000967521 m=(7)
ends OR2X8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:29:12 2012 )
// Library name: gsclib045
// Cell name: OR3X1
// View name: extracted

simulator lang=spectre

subckt OR3X1 A B C VDD VSS Y
mp2 (\11\:n0 \1\:C n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=25.9711 scb=0.030099 \
        scc=0.00176698 m=(1)
C1 (Y VSS) capacitor c=1.96149e-17
C2 (C VSS) capacitor c=3.48509e-17
C3 (A VSS) capacitor c=4.65865e-17
C4 (VDD VSS) capacitor c=8.96527e-17
C5 (n0 VSS) capacitor c=4.67931e-17
C6 (n2 VSS) capacitor c=9.47701e-18
C7 (n1 VSS) capacitor c=6.32316e-18
C8 (\1\:A VSS) capacitor c=5.15304e-17
C9 (\1\:B VSS) capacitor c=3.77316e-17
C10 (\1\:C VSS) capacitor c=4.92391e-17
C11 (\3\:n0 VSS) capacitor c=3.53794e-17
C12 (\3\:A VSS) capacitor c=3.84388e-17
C13 (\4\:B VSS) capacitor c=5.02672e-17
C14 (\4\:C VSS) capacitor c=3.38176e-17
C15 (\2\:n0 VSS) capacitor c=2.51117e-17
C16 (\2\:A VSS) capacitor c=4.76141e-17
C17 (\3\:B VSS) capacitor c=2.38718e-17
C18 (\3\:C VSS) capacitor c=1.4037e-17
C19 (\3\:Y VSS) capacitor c=6.55932e-17
C20 (\5\:VDD VSS) capacitor c=4.63907e-17
C21 (\11\:n0 VSS) capacitor c=8.51099e-17
C22 (\1\:VDD VSS) capacitor c=9.94629e-18
C23 (\1\:Y VSS) capacitor c=7.07594e-17
C24 (\9\:n0 VSS) capacitor c=2.99757e-17
C25 (\7\:n0 VSS) capacitor c=5.92443e-17
C26 (\2\:C VSS) capacitor c=4.20855e-17
C27 (\2\:B VSS) capacitor c=4.08596e-17
C28 (\5\:C VSS) capacitor c=1.88362e-17
C29 (\5\:B VSS) capacitor c=3.4527e-17
C30 (\7\:B VSS) capacitor c=4.92237e-17
C31 (\4\:A VSS) capacitor c=4.72463e-17
C32 (\4\:n0 VSS) capacitor c=7.95339e-17
C33 (\6\:n0 VSS) capacitor c=1.50909e-16
Rk11 (Y \2\:Y) resistor r=0.05713 c=0
Rk12 (\2\:Y \4\:Y) resistor r=0.4047 c=0
Rk1 (C \5\:C) resistor r=0.01625 c=0
Rk5 (A \4\:A) resistor r=0.09354 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.1201 c=0
Rk15 (\4\:VDD VDD) resistor r=0.1502 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.1803 c=0
Rk16 (\3\:VDD \6\:VDD) resistor r=0.3128 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.03992 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.2077 c=0
Rk20 (\5\:VSS VSS) resistor r=0.04989 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.05245 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.2402 c=0
Rk22 (\4\:VSS \9\:VSS) resistor r=0.2428 c=0
Rk2 (\5\:B \6\:B) resistor r=0.005209 c=0
Rk3 (B \7\:B) resistor r=0.005093 c=0
Rk4 (\5\:B \7\:B) resistor r=0.07853 c=0
Rk6 (\4\:n0 \5\:n0) resistor r=0.3674 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.04641 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.3505 c=0
Rk9 (\5\:n0 \10\:n0) resistor r=0.07643 c=0
Rk10 (\6\:n0 \12\:n0) resistor r=0.7331 c=0
Rl1 (\1\:C \2\:C) resistor r=141.187 c=0
Rl3 (\2\:C \4\:C) resistor r=85.4181 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl7 (\1\:A \2\:A) resistor r=133.384 c=0
Rl8 (\2\:A \3\:A) resistor r=77.6149 c=0
Rl4 (\1\:B \2\:B) resistor r=68.1104 c=0
Rl6 (\2\:B \4\:B) resistor r=158.495 c=0
Rl5 (\2\:B \3\:B) resistor r=1.8551 c=0
Rl9 (n0 \2\:n0) resistor r=66.0764 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=33.3841 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \5\:VSS) resistor r=31 c=0
Ry1 (\11\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\3\:B \6\:B) resistor r=45 c=0
Rx4 (\2\:n0 \4\:n0) resistor r=45 c=0
mn2 (\7\:n0 \4\:C \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn1 (\9\:n0 \4\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.95e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn0 (\9\:n0 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=2.393e-14 ps=9.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn3 (\1\:Y \3\:n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.05e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.90385e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.548e-14 \
        ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=5.95e-07 sd=160n sca=16.3573 scb=0.0155593 \
        scc=0.000402391 m=(1)
mp0 (n1 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=3.548e-14 ps=1.18e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.85e-07 sd=160n sca=15.0007 \
        scb=0.0128338 scc=0.000363258 m=(1)
mp3 (\3\:Y n0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.75e-14 ad=5.46e-14 ps=1.18e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.03846e-07 sb=1.4e-07 sd=160n sca=32.724 \
        scb=0.0269508 scc=0.00310791 m=(1)
ends OR3X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:29:59 2012 )
// Library name: gsclib045
// Cell name: OR3X4
// View name: extracted

simulator lang=spectre

subckt OR3X4 A B C VDD VSS Y
mp2 (\19\:n0 \1\:C n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=22.1268 \
        scb=0.0251863 scc=0.00108449 m=(1)
C1 (C VSS) capacitor c=3.20224e-17
C2 (A VSS) capacitor c=4.4988e-17
C3 (VDD VSS) capacitor c=1.28808e-16
C4 (Y VSS) capacitor c=1.86027e-17
C5 (B VSS) capacitor c=6.65032e-17
C6 (n0 VSS) capacitor c=3.64942e-16
C7 (n2 VSS) capacitor c=6.99106e-18
C8 (n1 VSS) capacitor c=1.03954e-17
C9 (\3\:A VSS) capacitor c=4.83927e-17
C10 (\3\:B VSS) capacitor c=8.41582e-17
C11 (\1\:C VSS) capacitor c=8.71936e-17
C12 (\4\:A VSS) capacitor c=4.83433e-17
C13 (\1\:B VSS) capacitor c=4.60766e-17
C14 (\4\:C VSS) capacitor c=3.66873e-17
C15 (\2\:B VSS) capacitor c=6.72932e-17
C16 (\3\:C VSS) capacitor c=1.67417e-17
C17 (\1\:VDD VSS) capacitor c=2.31747e-16
C18 (\19\:n0 VSS) capacitor c=8.16747e-17
C19 (\21\:n0 VSS) capacitor c=3.12314e-17
C20 (\17\:n0 VSS) capacitor c=4.78037e-17
C21 (\2\:C VSS) capacitor c=4.54042e-17
C22 (\2\:A VSS) capacitor c=4.79077e-17
C23 (\5\:C VSS) capacitor c=3.18017e-17
C24 (\4\:B VSS) capacitor c=4.62745e-17
C25 (\5\:A VSS) capacitor c=4.79497e-17
C26 (\15\:n0 VSS) capacitor c=1.49688e-16
C27 (\16\:n0 VSS) capacitor c=3.10459e-17
C28 (\1\:Y VSS) capacitor c=3.08193e-17
C29 (\2\:Y VSS) capacitor c=2.33712e-16
C30 (\5\:Y VSS) capacitor c=1.69356e-16
Rk17 (\2\:VSS \3\:VSS) resistor r=0.03994 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.06753 c=0
Rk23 (\8\:VSS VSS) resistor r=0.1124 c=0
Rk22 (\7\:VSS \8\:VSS) resistor r=0.1378 c=0
Rk27 (\8\:VSS \16\:VSS) resistor r=0.1811 c=0
Rk1 (C \5\:C) resistor r=0.1112 c=0
Rk3 (A \5\:A) resistor r=0.1472 c=0
Rk31 (\1\:VDD VDD) resistor r=0.3156 c=0
Rk10 (Y \1\:Y) resistor r=0.005323 c=0
Rk11 (\1\:Y \2\:Y) resistor r=0.2944 c=0
Rk13 (\1\:Y \5\:Y) resistor r=0.2054 c=0
Rk2 (\4\:B B) resistor r=0.194 c=0
Rk5 (n0 \15\:n0) resistor r=0.3625 c=0
Rk6 (\15\:n0 \16\:n0) resistor r=0.1086 c=0
Rk7 (\16\:n0 \18\:n0) resistor r=0.3418 c=0
Rk8 (\15\:n0 \20\:n0) resistor r=0.7963 c=0
Rk9 (\16\:n0 \22\:n0) resistor r=0.09038 c=0
Rl1 (\1\:C \2\:C) resistor r=151.157 c=0
Rl3 (\2\:C \4\:C) resistor r=68.7458 c=0
Rl2 (\2\:C \3\:C) resistor r=10.2762 c=0
Rl7 (\2\:A \3\:A) resistor r=100.412 c=0
Rl8 (\2\:A \4\:A) resistor r=116.083 c=0
Rl6 (\1\:A \2\:A) resistor r=2.0692 c=0
Rl5 (\2\:B \3\:B) resistor r=118.407 c=0
Rl4 (\1\:B \2\:B) resistor r=80.5087 c=0
Rz8 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\18\:n0 \17\:n0) resistor r=37.5 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=37.5 c=0
Ry4 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry5 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\7\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\20\:n0 \19\:n0) resistor r=31 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\1\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn2 (\17\:n0 \4\:C \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\21\:n0 \1\:B \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.23e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\21\:n0 \4\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.025e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\5\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.355e-14 ps=8.55e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp1 (n2 \3\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.36e-14 \
        ad=2.34e-14 ps=1.26e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.245e-06 sd=160n sca=16.9551 scb=0.0171783 \
        scc=0.000423515 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.36e-14 ps=1.1e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=9.6e-07 sd=160n sca=12.8811 \
        scb=0.0106724 scc=0.000292552 m=(1)
mp3 (\2\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.55e-07 sd=160n sca=12.0193 \
        scb=0.0100773 scc=0.000291813 m=(4)
ends OR3X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:30:47 2012 )
// Library name: gsclib045
// Cell name: OR3XL
// View name: extracted

simulator lang=spectre

subckt OR3XL A B C VDD VSS Y
mp2 (\4\:n0 \1\:C n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=25.7873 \
        scb=0.0298129 scc=0.00173847 m=(1)
C1 (C VSS) capacitor c=7.16394e-17
C2 (A VSS) capacitor c=7.46505e-17
C3 (VDD VSS) capacitor c=9.3687e-17
C4 (Y VSS) capacitor c=1.90876e-17
C5 (n0 VSS) capacitor c=2.79729e-17
C6 (n2 VSS) capacitor c=5.37616e-18
C7 (n1 VSS) capacitor c=7.71032e-18
C8 (\3\:n0 VSS) capacitor c=5.45235e-17
C9 (\3\:A VSS) capacitor c=5.10222e-17
C10 (\1\:B VSS) capacitor c=5.43844e-17
C11 (\1\:C VSS) capacitor c=4.652e-17
C12 (\1\:A VSS) capacitor c=4.50455e-17
C13 (\3\:B VSS) capacitor c=4.38367e-17
C14 (\4\:C VSS) capacitor c=3.73045e-17
C15 (\2\:n0 VSS) capacitor c=5.5021e-17
C16 (\4\:A VSS) capacitor c=6.96823e-17
C17 (\2\:B VSS) capacitor c=6.36754e-17
C18 (\3\:C VSS) capacitor c=1.77294e-17
C19 (\3\:Y VSS) capacitor c=7.00484e-17
C20 (\1\:VDD VSS) capacitor c=4.48087e-17
C21 (\4\:n0 VSS) capacitor c=8.09959e-17
C22 (\1\:Y VSS) capacitor c=7.81873e-17
C23 (\9\:n0 VSS) capacitor c=2.69083e-17
C24 (\7\:n0 VSS) capacitor c=6.2567e-17
C25 (\2\:C VSS) capacitor c=4.42806e-17
C26 (\5\:B VSS) capacitor c=5.91349e-17
C27 (\6\:B VSS) capacitor c=3.84999e-17
C28 (\5\:A VSS) capacitor c=5.53313e-17
C29 (\6\:n0 VSS) capacitor c=1.52172e-16
C30 (\11\:n0 VSS) capacitor c=5.32627e-17
C31 (\4\:VDD VSS) capacitor c=2.70572e-17
Rk12 (\2\:VSS \3\:VSS) resistor r=0.03992 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.2077 c=0
Rk15 (\5\:VSS VSS) resistor r=0.0499 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.05246 c=0
Rk16 (\3\:VSS \7\:VSS) resistor r=0.1831 c=0
Rk17 (\4\:VSS \9\:VSS) resistor r=0.1831 c=0
Rk1 (C \5\:C) resistor r=0.005129 c=0
Rk5 (\5\:A A) resistor r=0.1712 c=0
Rk19 (\4\:VDD VDD) resistor r=0.2505 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.3523 c=0
Rk11 (\4\:Y Y) resistor r=0.04601 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.4975 c=0
Rk2 (\4\:B \5\:B) resistor r=0.008389 c=0
Rk3 (B \6\:B) resistor r=0.008277 c=0
Rk4 (\4\:B \6\:B) resistor r=0.0651 c=0
Rk6 (\5\:n0 \6\:n0) resistor r=0.8776 c=0
Rk7 (\6\:n0 \8\:n0) resistor r=0.4127 c=0
Rk8 (\6\:n0 \10\:n0) resistor r=0.1271 c=0
Rk9 (\6\:n0 \11\:n0) resistor r=0.2034 c=0
Rl1 (\1\:C \2\:C) resistor r=154.649 c=0
Rl3 (\2\:C \4\:C) resistor r=108.495 c=0
Rl2 (\2\:C \3\:C) resistor r=5.6709 c=0
Rl7 (\2\:A \3\:A) resistor r=144.685 c=0
Rl6 (\1\:A \2\:A) resistor r=121.608 c=0
Rl8 (\2\:A \4\:A) resistor r=3.0741 c=0
Rl4 (\1\:B \2\:B) resistor r=133.79 c=0
Rl5 (\2\:B \3\:B) resistor r=106.867 c=0
Rl9 (n0 \2\:n0) resistor r=35.7134 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=204.944 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry4 (\1\:VSS \5\:VSS) resistor r=31 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry1 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\4\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx4 (\2\:n0 \11\:n0) resistor r=45 c=0
mn2 (\7\:n0 \4\:C \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\9\:n0 \3\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.55e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn0 (\9\:n0 \1\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.5e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y n0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mp1 (n2 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.225e-14 \
        ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=5.4e-07 sd=160n sca=16.1735 scb=0.0152732 \
        scc=0.000373884 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.225e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=14.8074 \
        scb=0.0125288 scc=0.000334622 m=(1)
mp3 (\3\:Y \3\:n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=16.4362 \
        scb=0.0157971 scc=0.000386659 m=(1)
ends OR3XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:31:34 2012 )
// Library name: gsclib045
// Cell name: RDFFNRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFNRQX1 CKN D ExtVDD Q RN RT VDD VSS
mp25 (n22 \3\:D \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RT VSS) capacitor c=2.16535e-17
C2 (ExtVDD VSS) capacitor c=2.08374e-16
C3 (D VSS) capacitor c=5.11133e-17
C4 (RN VSS) capacitor c=4.58072e-17
C5 (VDD VSS) capacitor c=6.59444e-16
C6 (CKN VSS) capacitor c=4.20253e-17
C7 (Q VSS) capacitor c=1.20933e-17
C8 (CKNb VSS) capacitor c=4.72155e-17
C9 (mout VSS) capacitor c=4.98512e-17
C10 (CKNbb VSS) capacitor c=5.23932e-17
C11 (n20 VSS) capacitor c=8.27414e-17
C12 (RNb VSS) capacitor c=5.59904e-17
C13 (n35g VSS) capacitor c=1.77671e-17
C14 (qbint VSS) capacitor c=4.57316e-17
C15 (RTb VSS) capacitor c=4.52673e-17
C16 (n35 VSS) capacitor c=1.81499e-16
C17 (net098 VSS) capacitor c=6.14297e-17
C18 (n40 VSS) capacitor c=7.48681e-17
C19 (\7\:qbint VSS) capacitor c=1.25063e-16
C20 (\2\:RNb VSS) capacitor c=2.98879e-16
C21 (\10\:qbint VSS) capacitor c=3.44253e-17
C22 (\13\:CKNb VSS) capacitor c=6.99757e-17
C23 (\4\:RTb VSS) capacitor c=9.85972e-17
C24 (\6\:RT VSS) capacitor c=2.23776e-17
C25 (\4\:qbint VSS) capacitor c=5.35139e-17
C26 (\3\:n35g VSS) capacitor c=6.24285e-17
C27 (\5\:RT VSS) capacitor c=8.45408e-17
C28 (\5\:CKNbb VSS) capacitor c=1.02117e-16
C29 (\4\:RN VSS) capacitor c=3.2145e-17
C30 (\5\:RNb VSS) capacitor c=6.41482e-17
C31 (\3\:n20 VSS) capacitor c=7.34077e-17
C32 (\4\:CKN VSS) capacitor c=5.42384e-17
C33 (\5\:CKNb VSS) capacitor c=2.95745e-17
C34 (\4\:CKNbb VSS) capacitor c=8.40157e-17
C35 (\3\:CKNb VSS) capacitor c=1.64383e-16
C36 (\3\:D VSS) capacitor c=5.61482e-17
C37 (\6\:qbint VSS) capacitor c=5.79729e-17
C38 (\11\:qbint VSS) capacitor c=4.09948e-17
C39 (\7\:CKNbb VSS) capacitor c=1.94152e-16
C40 (\8\:RT VSS) capacitor c=1.21969e-16
C41 (\2\:RT VSS) capacitor c=5.6984e-17
C42 (\5\:qbint VSS) capacitor c=3.87694e-17
C43 (\5\:n35g VSS) capacitor c=3.48637e-17
C44 (\2\:RTb VSS) capacitor c=4.91473e-17
C45 (\7\:CKNb VSS) capacitor c=3.23618e-17
C46 (\1\:RN VSS) capacitor c=3.41629e-17
C47 (\7\:RNb VSS) capacitor c=6.11841e-17
C48 (\1\:CKN VSS) capacitor c=2.8269e-17
C49 (\6\:n20 VSS) capacitor c=6.24185e-17
C50 (\3\:mout VSS) capacitor c=5.02446e-17
C51 (\12\:CKNb VSS) capacitor c=4.99683e-17
C52 (\2\:CKNbb VSS) capacitor c=8.20966e-17
C53 (\1\:D VSS) capacitor c=6.58183e-17
C54 (\9\:qbint VSS) capacitor c=8.34749e-17
C55 (\14\:CKNb VSS) capacitor c=7.11054e-17
C56 (\7\:RT VSS) capacitor c=1.54253e-16
C57 (\11\:CKNb VSS) capacitor c=1.43255e-16
C58 (\3\:RT VSS) capacitor c=5.78489e-17
C59 (\1\:RT VSS) capacitor c=4.85351e-17
C60 (\3\:RTb VSS) capacitor c=7.57807e-17
C61 (\3\:qbint VSS) capacitor c=4.42689e-17
C62 (\2\:n35 VSS) capacitor c=2.63216e-16
C63 (\4\:n35g VSS) capacitor c=7.15717e-17
C64 (\6\:CKNbb VSS) capacitor c=5.61043e-17
C65 (\8\:CKNbb VSS) capacitor c=2.28276e-16
C66 (\3\:n35 VSS) capacitor c=1.20797e-16
C67 (\6\:RNb VSS) capacitor c=7.97794e-17
C68 (\3\:RN VSS) capacitor c=4.97773e-17
C69 (\3\:CKN VSS) capacitor c=2.31414e-17
C70 (\6\:CKNb VSS) capacitor c=2.31103e-17
C71 (\3\:CKNbb VSS) capacitor c=1.06267e-16
C72 (\2\:mout VSS) capacitor c=4.01023e-17
C73 (\4\:mout VSS) capacitor c=3.90488e-17
C74 (\5\:n20 VSS) capacitor c=3.95232e-17
C75 (\2\:n20 VSS) capacitor c=7.1615e-17
C76 (\4\:CKNb VSS) capacitor c=8.28372e-17
C77 (\10\:CKNb VSS) capacitor c=3.16235e-17
C78 (\2\:D VSS) capacitor c=5.42815e-17
C79 (\1\:VDD VSS) capacitor c=4.75934e-17
C80 (\12\:VDD VSS) capacitor c=4.91532e-17
C81 (\4\:Q VSS) capacitor c=6.00017e-17
C82 (\3\:net098 VSS) capacitor c=9.84746e-17
C83 (\14\:n35 VSS) capacitor c=4.32074e-17
C84 (\15\:n35g VSS) capacitor c=5.80512e-17
C85 (\6\:RTb VSS) capacitor c=8.35247e-17
C86 (\1\:ExtVDD VSS) capacitor c=2.81313e-16
C87 (\9\:n35 VSS) capacitor c=5.4768e-17
C88 (\14\:qbint VSS) capacitor c=6.93529e-17
C89 (\6\:n35g VSS) capacitor c=9.1372e-17
C90 (\4\:n35 VSS) capacitor c=5.54247e-17
C91 (\11\:RNb VSS) capacitor c=2.80641e-17
C92 (\5\:mout VSS) capacitor c=7.05774e-17
C93 (\14\:VDD VSS) capacitor c=5.30535e-17
C94 (\16\:VDD VSS) capacitor c=4.40366e-17
C95 (\21\:CKNb VSS) capacitor c=4.74851e-17
C96 (\17\:mout VSS) capacitor c=3.51139e-17
C97 (\18\:VDD VSS) capacitor c=6.44243e-17
C98 (\20\:VDD VSS) capacitor c=4.60888e-17
C99 (\13\:CKNbb VSS) capacitor c=5.21642e-17
C100 (\7\:n20 VSS) capacitor c=4.09751e-17
C101 (\15\:n20 VSS) capacitor c=6.2982e-17
C102 (\23\:VDD VSS) capacitor c=4.0773e-17
C103 (\1\:Q VSS) capacitor c=3.98992e-17
C104 (\3\:n40 VSS) capacitor c=7.90524e-17
C105 (\17\:n35 VSS) capacitor c=4.8912e-17
C106 (\11\:n35g VSS) capacitor c=2.71993e-17
C107 (\10\:RTb VSS) capacitor c=4.83653e-17
C108 (\12\:n35 VSS) capacitor c=6.15791e-17
C109 (\16\:qbint VSS) capacitor c=2.32084e-17
C110 (\9\:n35g VSS) capacitor c=7.74366e-17
C111 (\7\:n35 VSS) capacitor c=4.51039e-17
C112 (\8\:RNb VSS) capacitor c=3.95412e-17
C113 (\8\:VDD VSS) capacitor c=5.37365e-17
C114 (\13\:mout VSS) capacitor c=5.50814e-17
C115 (\17\:CKNb VSS) capacitor c=6.04735e-17
C116 (\15\:mout VSS) capacitor c=3.62361e-17
C117 (\9\:CKNbb VSS) capacitor c=3.48248e-17
C118 (\11\:n20 VSS) capacitor c=6.1664e-17
C119 (\13\:n20 VSS) capacitor c=5.88843e-17
C120 (\2\:CKNb VSS) capacitor c=7.13597e-17
C121 (\2\:CKN VSS) capacitor c=3.37123e-17
C122 (\4\:n20 VSS) capacitor c=6.6185e-17
C123 (\2\:n35g VSS) capacitor c=3.24201e-17
C124 (ExtVDD VSS) capacitor c=3.9408e-17
C125 (\4\:RT VSS) capacitor c=7.41198e-17
C126 (\2\:qbint VSS) capacitor c=4.15851e-17
C127 (\8\:CKNb VSS) capacitor c=1.24521e-16
C128 (\9\:CKNb VSS) capacitor c=6.28227e-17
C129 (\3\:RNb VSS) capacitor c=4.94804e-16
C130 (\4\:RNb VSS) capacitor c=1.13129e-16
C131 (\15\:CKNb VSS) capacitor c=6.34123e-17
C132 (\16\:CKNb VSS) capacitor c=7.45499e-17
C133 (\8\:qbint VSS) capacitor c=9.73739e-17
C134 (\9\:n20 VSS) capacitor c=2.90276e-17
C135 (\10\:n20 VSS) capacitor c=4.9973e-17
C136 (\17\:n20 VSS) capacitor c=3.72237e-17
C137 (\12\:CKNbb VSS) capacitor c=7.85106e-17
C138 (\15\:CKNbb VSS) capacitor c=5.09428e-17
C139 (\5\:CKN VSS) capacitor c=4.75539e-18
C140 (\6\:CKN VSS) capacitor c=3.5698e-17
C141 (\19\:CKNb VSS) capacitor c=7.07801e-17
C142 (\20\:CKNb VSS) capacitor c=4.83044e-17
C143 (\5\:RN VSS) capacitor c=5.29406e-17
C144 (\7\:mout VSS) capacitor c=5.29264e-17
C145 (\8\:mout VSS) capacitor c=4.64473e-17
C146 (\9\:mout VSS) capacitor c=1.00843e-17
C147 (\10\:mout VSS) capacitor c=2.76665e-17
C148 (\11\:mout VSS) capacitor c=1.52201e-17
C149 (\12\:mout VSS) capacitor c=3.01153e-17
C150 (\10\:RNb VSS) capacitor c=6.48312e-17
C151 (\6\:n35 VSS) capacitor c=5.89856e-17
C152 (\16\:CKNbb VSS) capacitor c=3.24421e-17
C153 (\17\:CKNbb VSS) capacitor c=3.22711e-17
C154 (\8\:n35g VSS) capacitor c=3.24313e-17
C155 (\11\:n35 VSS) capacitor c=6.21676e-17
C156 (\12\:qbint VSS) capacitor c=8.82866e-17
C157 (\13\:qbint VSS) capacitor c=1.03557e-16
C158 (\13\:n35g VSS) capacitor c=1.06902e-16
C159 (\14\:n35g VSS) capacitor c=1.16408e-16
C160 (\5\:RTb VSS) capacitor c=4.96e-17
C161 (\8\:RTb VSS) capacitor c=8.74815e-17
C162 (\9\:RTb VSS) capacitor c=5.09192e-17
C163 (\9\:RT VSS) capacitor c=1.06563e-16
C164 (\10\:RT VSS) capacitor c=1.18671e-16
C165 (\11\:RT VSS) capacitor c=3.826e-17
C166 (\23\:CKNb VSS) capacitor c=9.71009e-17
C167 (\24\:CKNb VSS) capacitor c=9.4266e-17
C168 (\18\:qbint VSS) capacitor c=2.00599e-17
C169 (\19\:qbint VSS) capacitor c=3.01482e-17
C170 (\16\:n35 VSS) capacitor c=4.42287e-17
C171 (\3\:Q VSS) capacitor c=1.64947e-17
C172 (\3\:VDD VSS) capacitor c=3.85813e-17
C173 (\5\:VDD VSS) capacitor c=2.28584e-16
C174 (\6\:VDD VSS) capacitor c=1.91623e-16
C175 (\7\:VDD VSS) capacitor c=5.4939e-18
C176 (\10\:VDD VSS) capacitor c=3.15159e-17
C177 (\22\:VDD VSS) capacitor c=3.15031e-17
Rk53 (RT \9\:RT) resistor r=0.1834 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6402 c=0
Rk55 (RT \11\:RT) resistor r=0.01476 c=0
Rk40 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk38 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk41 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk42 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk2 (\4\:D D) resistor r=0.006389 c=0
Rk19 (RN \5\:RN) resistor r=0.02713 c=0
Rk98 (\2\:VDD \3\:VDD) resistor r=0.4044 c=0
Rk99 (\3\:VDD \5\:VDD) resistor r=0.06659 c=0
Rk100 (\5\:VDD \6\:VDD) resistor r=1.6793 c=0
Rk101 (\6\:VDD \7\:VDD) resistor r=0.0293 c=0
Rk102 (\7\:VDD \9\:VDD) resistor r=0.04186 c=0
Rk103 (\9\:VDD \10\:VDD) resistor r=0.1482 c=0
Rk110 (\11\:VDD VDD) resistor r=0.218 c=0
Rk104 (\10\:VDD \11\:VDD) resistor r=0.05917 c=0
Rk105 (\3\:VDD \13\:VDD) resistor r=0.2921 c=0
Rk106 (\6\:VDD \15\:VDD) resistor r=0.3582 c=0
Rk107 (\7\:VDD \17\:VDD) resistor r=0.201 c=0
Rk108 (\10\:VDD \19\:VDD) resistor r=0.4023 c=0
Rk109 (\11\:VDD \21\:VDD) resistor r=0.2464 c=0
Rk111 (VDD \22\:VDD) resistor r=0.146 c=0
Rk112 (\22\:VDD VDD) resistor r=0.08861 c=0
Rk113 (\22\:VDD \24\:VDD) resistor r=0.3577 c=0
Rk12 (CKN \5\:CKN) resistor r=0.0023 c=0
Rk15 (\5\:CKN \6\:CKN) resistor r=0.01102 c=0
Rk14 (\6\:CKN \7\:CKN) resistor r=0.006334 c=0
Rk61 (\3\:Q Q) resistor r=0.009578 c=0
Rk60 (\2\:Q \3\:Q) resistor r=0.2292 c=0
Rk62 (\3\:Q \5\:Q) resistor r=0.3184 c=0
Rk65 (\2\:VSS \3\:VSS) resistor r=0.03444 c=0
Rk66 (\3\:VSS \4\:VSS) resistor r=0.1136 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.08885 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.356 c=0
Rk70 (\7\:VSS VSS) resistor r=0.3755 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.3661 c=0
Rk71 (VSS \8\:VSS) resistor r=0.1487 c=0
Rk73 (\9\:VSS VSS) resistor r=0.2073 c=0
Rk72 (\8\:VSS \9\:VSS) resistor r=0.5564 c=0
Rk74 (VSS \10\:VSS) resistor r=0.01737 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.1086 c=0
Rk76 (\3\:VSS \13\:VSS) resistor r=0.2393 c=0
Rk77 (\5\:VSS \15\:VSS) resistor r=0.2456 c=0
Rk78 (\7\:VSS \17\:VSS) resistor r=0.2429 c=0
Rk79 (\9\:VSS \19\:VSS) resistor r=0.2393 c=0
Rk80 (\10\:VSS \21\:VSS) resistor r=0.2393 c=0
Rk81 (\23\:VSS \24\:VSS) resistor r=0.07154 c=0
Rk82 (\24\:VSS \25\:VSS) resistor r=0.6701 c=0
Rk83 (\25\:VSS \26\:VSS) resistor r=0.1655 c=0
Rk85 (\27\:VSS VSS) resistor r=0.1208 c=0
Rk84 (\26\:VSS \27\:VSS) resistor r=0.2074 c=0
Rk86 (VSS \28\:VSS) resistor r=0.6283 c=0
Rk88 (\29\:VSS VSS) resistor r=0.1185 c=0
Rk87 (\28\:VSS \29\:VSS) resistor r=0.06412 c=0
Rk89 (VSS \30\:VSS) resistor r=0.03716 c=0
Rk90 (\30\:VSS \31\:VSS) resistor r=0.4226 c=0
Rk91 (\31\:VSS \32\:VSS) resistor r=0.06412 c=0
Rk92 (\24\:VSS \34\:VSS) resistor r=0.2598 c=0
Rk93 (\26\:VSS \36\:VSS) resistor r=0.1887 c=0
Rk94 (\27\:VSS \38\:VSS) resistor r=0.1938 c=0
Rk95 (\28\:VSS \40\:VSS) resistor r=0.2353 c=0
Rk96 (\30\:VSS \42\:VSS) resistor r=0.2358 c=0
Rk97 (\31\:VSS \44\:VSS) resistor r=0.2277 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6826 c=0
Rk16 (\18\:CKNb \19\:CKNb) resistor r=0.3415 c=0
Rk17 (\19\:CKNb \20\:CKNb) resistor r=0.1628 c=0
Rk18 (\19\:CKNb \22\:CKNb) resistor r=0.2072 c=0
Rk56 (\23\:CKNb \24\:CKNb) resistor r=0.7171 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.4253 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.3621 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1413 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.1929 c=0
Rk24 (\7\:mout \11\:mout) resistor r=0.1185 c=0
Rk25 (\11\:mout \12\:mout) resistor r=0.2157 c=0
Rk26 (\8\:mout \14\:mout) resistor r=0.3227 c=0
Rk27 (\9\:mout \16\:mout) resistor r=0.1036 c=0
Rk28 (\11\:mout \18\:mout) resistor r=0.1202 c=0
Rk8 (\10\:CKNbb \11\:CKNbb) resistor r=0.2124 c=0
Rk9 (\11\:CKNbb \12\:CKNbb) resistor r=0.0151 c=0
Rk10 (\11\:CKNbb \14\:CKNbb) resistor r=0.3374 c=0
Rk11 (\14\:CKNbb \15\:CKNbb) resistor r=0.2709 c=0
Rk33 (\16\:CKNbb \17\:CKNbb) resistor r=0.2958 c=0
Rk3 (\8\:n20 \9\:n20) resistor r=0.2062 c=0
Rk4 (\8\:n20 \10\:n20) resistor r=0.2091 c=0
Rk5 (\10\:n20 \12\:n20) resistor r=0.4399 c=0
Rk6 (\14\:n20 \16\:n20) resistor r=0.4876 c=0
Rk7 (\16\:n20 \17\:n20) resistor r=0.1574 c=0
Rk29 (\9\:RNb \10\:RNb) resistor r=0.3424 c=0
Rk30 (\10\:RNb \12\:RNb) resistor r=0.1478 c=0
Rk34 (\7\:n35g \8\:n35g) resistor r=0.2401 c=0
Rk35 (\7\:n35g \10\:n35g) resistor r=0.6898 c=0
Rk46 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk47 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk48 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk43 (\12\:qbint \13\:qbint) resistor r=0.4933 c=0
Rk44 (\13\:qbint \15\:qbint) resistor r=0.5658 c=0
Rk45 (\13\:qbint \17\:qbint) resistor r=0.1459 c=0
Rk57 (\18\:qbint \19\:qbint) resistor r=0.2113 c=0
Rk49 (\5\:RTb \7\:RTb) resistor r=0.2157 c=0
Rk50 (\7\:RTb \8\:RTb) resistor r=0.5203 c=0
Rk51 (\8\:RTb \9\:RTb) resistor r=0.3878 c=0
Rk52 (\8\:RTb \11\:RTb) resistor r=0.2011 c=0
Rk31 (\5\:n35 \6\:n35) resistor r=0.3193 c=0
Rk32 (\6\:n35 \8\:n35) resistor r=0.4233 c=0
Rk36 (\10\:n35 \11\:n35) resistor r=0.3178 c=0
Rk37 (\11\:n35 \13\:n35) resistor r=0.3869 c=0
Rk58 (\15\:n35 \16\:n35) resistor r=0.2315 c=0
Rk59 (\16\:n35 \18\:n35) resistor r=0.3583 c=0
Rk64 (\2\:net098 \4\:net098) resistor r=0.7055 c=0
Rk63 (\2\:n40 \4\:n40) resistor r=0.6241 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl20 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl18 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl19 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl46 (\13\:CKNb \14\:CKNb) resistor r=159.438 c=0
Rl9 (\3\:CKNb \4\:CKNb) resistor r=349.426 c=0
Rl7 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl10 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl8 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl11 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl38 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl41 (\8\:CKNb \11\:CKNb) resistor r=820.277 c=0
Rl42 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl40 (\9\:CKNb \10\:CKNb) resistor r=132.647 c=0
Rl39 (\8\:CKNb \9\:CKNb) resistor r=339.792 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl4 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=177.372 c=0
Rl47 (\7\:CKNbb \8\:CKNbb) resistor r=908.226 c=0
Rl22 (\3\:CKNbb \5\:CKNbb) resistor r=446.949 c=0
Rl21 (\3\:CKNbb \4\:CKNbb) resistor r=188.95 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=154.568 c=0
Rl17 (\4\:n20 \6\:n20) resistor r=191.976 c=0
Rl16 (\4\:n20 \5\:n20) resistor r=128.737 c=0
Rl48 (RNb \2\:RNb) resistor r=234.8 c=0
Rl49 (\2\:RNb \3\:RNb) resistor r=1125.6 c=0
Rl52 (\3\:RNb \6\:RNb) resistor r=707.521 c=0
Rl51 (\4\:RNb \5\:RNb) resistor r=106.884 c=0
Rl53 (\4\:RNb \7\:RNb) resistor r=197.09 c=0
Rl50 (\3\:RNb \4\:RNb) resistor r=336.011 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl54 (\6\:qbint \7\:qbint) resistor r=237.758 c=0
Rl58 (\10\:qbint \11\:qbint) resistor r=149.805 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl55 (\7\:qbint \8\:qbint) resistor r=252.339 c=0
Rl57 (\8\:qbint \10\:qbint) resistor r=60.508 c=0
Rl56 (\8\:qbint \9\:qbint) resistor r=419.685 c=0
Rl28 (RTb \2\:RTb) resistor r=121.113 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl44 (n35 \2\:n35) resistor r=508.667 c=0
Rl45 (\2\:n35 \3\:n35) resistor r=358.667 c=0
Rz31 (\8\:VDD \9\:VDD) resistor r=15 c=0
Rz32 (\8\:VDD \11\:VDD) resistor r=37.5 c=0
Rz16 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\33\:VSS \34\:VSS) resistor r=37.5 c=0
Rz25 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz26 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz27 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz28 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz29 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz5 (\13\:mout \14\:mout) resistor r=75 c=0
Rz6 (\15\:mout \16\:mout) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz1 (\11\:n20 \12\:n20) resistor r=75 c=0
Rz2 (\13\:n20 \14\:n20) resistor r=75 c=0
Rz7 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz9 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz13 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz12 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz14 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz8 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz10 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (n40 \2\:n40) resistor r=75 c=0
Rz18 (\3\:n40 \4\:n40) resistor r=75 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry21 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry23 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry25 (\1\:VSS \11\:VSS) resistor r=8.8571 c=0
Ry26 (\22\:VSS \23\:VSS) resistor r=20.6667 c=0
Ry27 (\22\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry28 (\22\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry29 (\22\:VSS \32\:VSS) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\17\:mout \18\:mout) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\15\:n20 \16\:n20) resistor r=62 c=0
Ry7 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry17 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry19 (net098 \2\:net098) resistor r=62 c=0
Ry20 (\3\:net098 \4\:net098) resistor r=62 c=0
Rx24 (\3\:RT \9\:RT) resistor r=45 c=0
Rx25 (\1\:RT \10\:RT) resistor r=45 c=0
Rx26 (\7\:RT \11\:RT) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx11 (\3\:RN \5\:RN) resistor r=45 c=0
Rx9 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx10 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx27 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx28 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx12 (\4\:mout \10\:mout) resistor r=45 c=0
Rx13 (\2\:mout \12\:mout) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx16 (\6\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx17 (\8\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx4 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \10\:n20) resistor r=45 c=0
Rx6 (n20 \17\:n20) resistor r=45 c=0
Rx14 (\6\:RNb \10\:RNb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx29 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx30 (qbint \19\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\13\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\11\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\9\:CKNbb CKNb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \6\:n20 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKNb \1\:CKN \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\13\:mout \7\:RNb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\8\:RNb \1\:RN \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \7\:CKNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM3 (net0121 \5\:qbint \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\16\:qbint \5\:n35g \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \7\:CKNbb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \11\:qbint \33\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n40 RNb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \6\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\15\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\7\:n20 \4\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\13\:CKNbb \5\:CKNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\21\:CKNb \4\:CKN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\17\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.71023 \
        scb=0.00138809 scc=2.58214e-06 m=(1)
mp31 (net402 \5\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.19408 \
        scb=0.00174819 scc=3.02997e-06 m=(1)
mp22 (\11\:RNb \4\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.8901 \
        scb=0.0121892 scc=0.000217629 m=(1)
mp40 (\4\:n35 \5\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.8142 \
        scb=0.0201994 scc=0.00140887 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:net098 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp55 (\4\:Q \10\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2692 \
        scb=0.0111076 scc=0.000317226 m=(1)
mp51 (n43 \2\:RNb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp52 (net098 \7\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.9152 \
        scb=0.0114244 scc=0.000185803 m=(1)
ends RDFFNRQX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:32:23 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX1 CK D Q RN SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.72308e-07 sd=160n sca=23.0036 \
        scb=0.0261368 scc=0.00127103 m=(1)
C1 (D VSS) capacitor c=4.02453e-17
C2 (Q VSS) capacitor c=1.32018e-17
C3 (SE VSS) capacitor c=7.29835e-17
C4 (VDD VSS) capacitor c=3.19083e-16
C5 (SI VSS) capacitor c=4.95894e-17
C6 (qbint VSS) capacitor c=1.8666e-17
C7 (CKb VSS) capacitor c=5.75641e-17
C8 (net337 VSS) capacitor c=4.46366e-18
C9 (n30 VSS) capacitor c=5.26225e-17
C10 (net405 VSS) capacitor c=2.68183e-18
C11 (mout VSS) capacitor c=5.78085e-17
C12 (CKbb VSS) capacitor c=2.14988e-17
C13 (n20 VSS) capacitor c=4.92579e-17
C14 (Db VSS) capacitor c=1.25197e-16
C15 (net450 VSS) capacitor c=6.64026e-18
C16 (SEb VSS) capacitor c=4.53363e-17
C17 (net326 VSS) capacitor c=3.58673e-18
C18 (net349 VSS) capacitor c=5.67054e-17
C19 (net381 VSS) capacitor c=1.5388e-18
C20 (net373 VSS) capacitor c=3.89779e-18
C21 (\5\:SE VSS) capacitor c=4.33742e-17
C22 (\3\:SI VSS) capacitor c=6.70732e-17
C23 (\2\:SE VSS) capacitor c=7.23799e-17
C24 (\1\:D VSS) capacitor c=1.07026e-16
C25 (\8\:CKb VSS) capacitor c=4.85877e-17
C26 (\7\:CKbb VSS) capacitor c=5.24778e-17
C27 (\5\:CKb VSS) capacitor c=5.31697e-17
C28 (\2\:RN VSS) capacitor c=1.35234e-16
C29 (\3\:n20 VSS) capacitor c=5.72447e-17
C30 (\3\:CKb VSS) capacitor c=4.39449e-17
C31 (\3\:CKbb VSS) capacitor c=8.76428e-17
C32 (\5\:qbint VSS) capacitor c=6.82722e-17
C33 (\3\:RN VSS) capacitor c=1.04194e-16
C34 (\1\:CK VSS) capacitor c=3.98388e-17
C35 (\4\:qbint VSS) capacitor c=5.66845e-17
C36 (\7\:SE VSS) capacitor c=3.24012e-17
C37 (\1\:SI VSS) capacitor c=7.95551e-17
C38 (\3\:SE VSS) capacitor c=5.76891e-17
C39 (\3\:SEb VSS) capacitor c=6.40842e-17
C40 (\4\:D VSS) capacitor c=3.83435e-17
C41 (\10\:CKb VSS) capacitor c=6.06352e-17
C42 (\7\:CKb VSS) capacitor c=4.71508e-17
C43 (\4\:CKbb VSS) capacitor c=4.60951e-17
C44 (\3\:mout VSS) capacitor c=6.53194e-17
C45 (\1\:RN VSS) capacitor c=8.87394e-17
C46 (\7\:qbint VSS) capacitor c=5.58413e-17
C47 (\5\:RN VSS) capacitor c=5.06381e-17
C48 (\3\:n30 VSS) capacitor c=2.89554e-17
C49 (\3\:CK VSS) capacitor c=4.8822e-17
C50 (\3\:qbint VSS) capacitor c=3.43207e-17
C51 (\6\:SE VSS) capacitor c=3.99169e-17
C52 (\2\:SI VSS) capacitor c=6.44661e-17
C53 (\4\:SE VSS) capacitor c=4.34497e-17
C54 (\2\:SEb VSS) capacitor c=5.75778e-17
C55 (\1\:SE VSS) capacitor c=5.17725e-17
C56 (\3\:D VSS) capacitor c=2.56117e-17
C57 (\9\:CKb VSS) capacitor c=2.7182e-17
C58 (\6\:CKbb VSS) capacitor c=3.78216e-17
C59 (\6\:CKb VSS) capacitor c=2.05361e-17
C60 (\5\:CKbb VSS) capacitor c=3.96094e-17
C61 (\2\:mout VSS) capacitor c=5.8223e-17
C62 (\2\:n20 VSS) capacitor c=4.8284e-17
C63 (\4\:CKb VSS) capacitor c=3.21145e-17
C64 (\2\:CKbb VSS) capacitor c=5.81635e-17
C65 (\2\:CKb VSS) capacitor c=5.74618e-17
C66 (\6\:qbint VSS) capacitor c=6.89973e-17
C67 (\6\:RN VSS) capacitor c=2.54588e-17
C68 (\2\:n30 VSS) capacitor c=3.91622e-17
C69 (\2\:CK VSS) capacitor c=4.49232e-17
C70 (\5\:SEb VSS) capacitor c=9.49605e-17
C71 (\13\:VDD VSS) capacitor c=3.57158e-17
C72 (\3\:Db VSS) capacitor c=1.44669e-16
C73 (\15\:VDD VSS) capacitor c=1.5325e-17
C74 (\8\:CKbb VSS) capacitor c=6.71514e-17
C75 (\6\:Db VSS) capacitor c=1.7105e-16
C76 (\4\:n20 VSS) capacitor c=5.70403e-17
C77 (\17\:VDD VSS) capacitor c=3.43218e-17
C78 (\3\:net349 VSS) capacitor c=6.77142e-17
C79 (\19\:VDD VSS) capacitor c=4.55952e-17
C80 (\8\:mout VSS) capacitor c=8.76952e-17
C81 (\4\:n30 VSS) capacitor c=1.20802e-16
C82 (\21\:VDD VSS) capacitor c=4.95628e-17
C83 (\12\:qbint VSS) capacitor c=5.58073e-17
C84 (\23\:VDD VSS) capacitor c=3.75339e-17
C85 (\15\:CKb VSS) capacitor c=1.3939e-16
C86 (\25\:VDD VSS) capacitor c=6.90152e-17
C87 (\1\:Q VSS) capacitor c=6.65752e-17
C88 (\1\:VDD VSS) capacitor c=9.02713e-17
C89 (\7\:SEb VSS) capacitor c=7.52394e-17
C90 (\14\:CKbb VSS) capacitor c=1.92016e-17
C91 (\8\:Db VSS) capacitor c=1.06039e-16
C92 (\8\:n20 VSS) capacitor c=9.33367e-17
C93 (\6\:mout VSS) capacitor c=6.53961e-17
C94 (\6\:n30 VSS) capacitor c=1.54843e-16
C95 (\10\:qbint VSS) capacitor c=1.45283e-16
C96 (\19\:CKb VSS) capacitor c=1.1267e-16
C97 (\4\:Q VSS) capacitor c=3.18303e-17
C98 (\2\:qbint VSS) capacitor c=2.41945e-17
C99 (\4\:RN VSS) capacitor c=3.35984e-17
C100 (\2\:D VSS) capacitor c=2.57251e-17
C101 (\3\:Q VSS) capacitor c=5.29535e-17
C102 (\4\:CK VSS) capacitor c=6.00298e-17
C103 (\5\:CK VSS) capacitor c=4.39801e-17
C104 (\8\:RN VSS) capacitor c=4.94482e-17
C105 (\9\:RN VSS) capacitor c=4.92634e-17
C106 (\8\:qbint VSS) capacitor c=6.41981e-17
C107 (\9\:qbint VSS) capacitor c=1.0413e-16
C108 (\14\:qbint VSS) capacitor c=1.25451e-16
C109 (\8\:n30 VSS) capacitor c=1.20311e-16
C110 (\4\:mout VSS) capacitor c=8.76156e-17
C111 (\5\:mout VSS) capacitor c=1.06221e-16
C112 (\6\:n20 VSS) capacitor c=9.93722e-17
C113 (\7\:n20 VSS) capacitor c=8.07966e-17
C114 (\10\:CKbb VSS) capacitor c=3.82308e-17
C115 (\11\:CKbb VSS) capacitor c=9.873e-17
C116 (\12\:CKbb VSS) capacitor c=2.22169e-16
C117 (\13\:CKbb VSS) capacitor c=1.90129e-16
C118 (\16\:CKbb VSS) capacitor c=3.85165e-17
C119 (\11\:CKb VSS) capacitor c=8.08544e-17
C120 (\12\:CKb VSS) capacitor c=1.49296e-16
C121 (\13\:CKb VSS) capacitor c=1.35122e-16
C122 (\14\:CKb VSS) capacitor c=1.65666e-16
C123 (\17\:CKb VSS) capacitor c=8.30345e-17
C124 (\18\:CKb VSS) capacitor c=5.23108e-17
C125 (\6\:D VSS) capacitor c=3.78475e-17
C126 (\5\:Db VSS) capacitor c=4.96719e-17
C127 (\4\:SI VSS) capacitor c=5.58424e-17
C128 (\8\:SE VSS) capacitor c=6.24425e-17
C129 (\9\:SE VSS) capacitor c=4.45178e-17
C130 (\10\:SE VSS) capacitor c=5.99557e-17
C131 (\4\:SEb VSS) capacitor c=8.14355e-17
C132 (\3\:VDD VSS) capacitor c=1.33767e-18
C133 (\5\:VDD VSS) capacitor c=2.64168e-17
C134 (\6\:VDD VSS) capacitor c=2.7281e-17
C135 (\8\:VDD VSS) capacitor c=3.14196e-17
C136 (\9\:VDD VSS) capacitor c=3.23475e-17
C137 (\11\:VDD VSS) capacitor c=9.39858e-18
Rk36 (\5\:D \6\:D) resistor r=0.002289 c=0
Rk37 (\7\:D D) resistor r=0.002403 c=0
Rk38 (\6\:D \7\:D) resistor r=0.09354 c=0
Rk2 (\3\:Q Q) resistor r=0.007258 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.4303 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1825 c=0
Rk7 (\7\:RN \8\:RN) resistor r=0.008733 c=0
Rk8 (\9\:RN RN) resistor r=0.008733 c=0
Rk9 (\8\:RN \9\:RN) resistor r=0.01996 c=0
Rk45 (\8\:SE SE) resistor r=0.3149 c=0
Rk46 (SE \9\:SE) resistor r=0.0751 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.2249 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.1178 c=0
Rk60 (\3\:VDD \4\:VDD) resistor r=0.1831 c=0
Rk61 (\4\:VDD \5\:VDD) resistor r=0.1906 c=0
Rk62 (\5\:VDD \6\:VDD) resistor r=0.4657 c=0
Rk63 (\6\:VDD \7\:VDD) resistor r=0.09426 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.1253 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.4741 c=0
Rk66 (\9\:VDD \10\:VDD) resistor r=0.1027 c=0
Rk67 (\10\:VDD \11\:VDD) resistor r=0.163 c=0
Rk76 (\12\:VDD VDD) resistor r=0.151 c=0
Rk68 (\11\:VDD \12\:VDD) resistor r=0.1881 c=0
Rk69 (\3\:VDD \14\:VDD) resistor r=0.203 c=0
Rk70 (\5\:VDD \16\:VDD) resistor r=0.07476 c=0
Rk71 (\6\:VDD \18\:VDD) resistor r=0.04338 c=0
Rk72 (\8\:VDD \20\:VDD) resistor r=0.1543 c=0
Rk73 (\9\:VDD \22\:VDD) resistor r=0.247 c=0
Rk74 (\11\:VDD \24\:VDD) resistor r=0.1543 c=0
Rk75 (\12\:VDD \26\:VDD) resistor r=0.3671 c=0
Rk4 (CK \4\:CK) resistor r=0.004227 c=0
Rk6 (\4\:CK \5\:CK) resistor r=0.07064 c=0
Rk5 (\5\:CK \6\:CK) resistor r=0.004227 c=0
Rk44 (SI \4\:SI) resistor r=0.02621 c=0
Rk50 (\2\:VSS \4\:VSS) resistor r=0.7354 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.6777 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.5277 c=0
Rk54 (\7\:VSS VSS) resistor r=0.1251 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.4266 c=0
Rk55 (\4\:VSS \9\:VSS) resistor r=0.3693 c=0
Rk56 (\5\:VSS \11\:VSS) resistor r=0.2545 c=0
Rk57 (\6\:VSS \13\:VSS) resistor r=0.1976 c=0
Rk58 (\7\:VSS \15\:VSS) resistor r=0.3086 c=0
Rk10 (\8\:qbint \9\:qbint) resistor r=0.3799 c=0
Rk11 (\9\:qbint \11\:qbint) resistor r=0.5415 c=0
Rk12 (\9\:qbint \13\:qbint) resistor r=0.2374 c=0
Rk13 (\11\:qbint \14\:qbint) resistor r=0.6457 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.3924 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8429 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3488 c=0
Rk32 (\14\:CKb \16\:CKb) resistor r=0.781 c=0
Rk33 (\13\:CKb \17\:CKb) resistor r=0.2949 c=0
Rk34 (\14\:CKb \18\:CKb) resistor r=0.326 c=0
Rk35 (\16\:CKb \20\:CKb) resistor r=0.5326 c=0
Rk14 (\5\:n30 \7\:n30) resistor r=0.588 c=0
Rk15 (\7\:n30 \8\:n30) resistor r=0.7398 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.473 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2059 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3244 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.3799 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1571 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.8393 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.0921 c=0
Rk27 (\10\:CKbb \15\:CKbb) resistor r=0.0921 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.07888 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2171 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5467 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3571 c=0
Rk39 (\2\:Db \4\:Db) resistor r=0.7348 c=0
Rk40 (\4\:Db \5\:Db) resistor r=0.0391 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.583 c=0
Rk42 (\7\:Db \9\:Db) resistor r=0.6106 c=0
Rk43 (\5\:Db \10\:Db) resistor r=0.0987 c=0
Rk48 (\4\:SEb \6\:SEb) resistor r=0.5531 c=0
Rk49 (\6\:SEb \8\:SEb) resistor r=0.5391 c=0
Rk19 (\2\:net349 \4\:net349) resistor r=0.3075 c=0
Rl29 (\1\:D \2\:D) resistor r=127.726 c=0
Rl31 (\2\:D \4\:D) resistor r=45.0334 c=0
Rl30 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl17 (\2\:RN \3\:RN) resistor r=603.412 c=0
Rl16 (\1\:RN \2\:RN) resistor r=215.232 c=0
Rl18 (\3\:RN \4\:RN) resistor r=96.9565 c=0
Rl19 (\4\:RN \5\:RN) resistor r=106.572 c=0
Rl20 (\4\:RN \6\:RN) resistor r=5.013 c=0
Rl38 (\5\:SE \6\:SE) resistor r=119.922 c=0
Rl39 (\6\:SE \7\:SE) resistor r=46.8456 c=0
Rl35 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl32 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl4 (\1\:CK \2\:CK) resistor r=104.538 c=0
Rl5 (\2\:CK \3\:CK) resistor r=110.307 c=0
Rl37 (\2\:SI \3\:SI) resistor r=101.477 c=0
Rl36 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=160.771 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=24.2328 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=121.957 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=41.1873 c=0
Rl28 (\8\:CKb \10\:CKb) resistor r=182.692 c=0
Rl25 (\5\:CKb \7\:CKb) resistor r=150 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=52.1862 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=64.1533 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl10 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl6 (n30 \2\:n30) resistor r=158.384 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl21 (mout \2\:mout) resistor r=108.79 c=0
Rl22 (\2\:mout \3\:mout) resistor r=72.2519 c=0
Rl26 (\6\:CKbb \7\:CKbb) resistor r=99.2573 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=41.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=214.504 c=0
Rl14 (n20 \2\:n20) resistor r=138.462 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=51.0989 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.404 c=0
Rz1 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=6.8182 c=0
Rz19 (\1\:VDD \10\:VDD) resistor r=25 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=18.75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \26\:VDD) resistor r=20.6667 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry9 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\3\:Db \10\:Db) resistor r=62 c=0
Ry13 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\6\:RN \7\:RN) resistor r=45 c=0
Rx17 (\1\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\6\:SE \10\:SE) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx4 (qbint \14\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn55 (\4\:Q \3\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.73846e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn20 (\19\:CKb \3\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.103e-14 ps=9e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn46 (\10\:qbint \3\:n30 net337 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.793e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn45 (net337 \5\:RN \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.28e-14 ps=1.06e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.95e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (net405 \7\:qbint \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=1.23e-14 ps=1.06e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.685e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.58e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.945e-14 ad=5.228e-14 ps=9.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.28e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=4.613e-14 ps=7.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn30 (\6\:mout n20 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=5.945e-14 ps=1.24e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=9.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net426 \1\:RN \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=2.665e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=7.1e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=1.333e-14 ps=6.7e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.35e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.333e-14 ad=4.613e-14 ps=5.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.915e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\14\:CKbb \10\:CKb \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12276e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net450 \4\:D \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=6.76e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=8.51635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41635e-07 sb=5.46635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46635e-07 sb=3.41635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51635e-07 sb=2.36635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\7\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12276e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.118e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.6299 \
        scb=0.00978612 scc=8.84613e-05 m=(1)
mp46 (\12\:qbint n30 \23\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=12.1897 \
        scb=0.0106254 scc=0.000361908 m=(1)
mp45 (\21\:VDD \3\:RN \12\:qbint VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=6.82e-14 ps=9.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp50 (net326 \5\:qbint \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=4.805e-14 ps=1.06e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.265e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.065e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=8.6e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp30 (\8\:mout \3\:n20 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=5.85e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp35 (\3\:net349 \2\:RN \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=4.96e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.2e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp36 (\3\:net349 mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.883e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.15e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\8\:CKbb \8\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.98e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp11 (net381 \1\:D \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.98e-14 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.20897e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp12 (\3\:Db \2\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.15897e-07 sd=160n sca=12.2524 \
        scb=0.0106415 scc=0.00038358 m=(1)
mp14 (\3\:Db SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.90897e-07 sd=160n sca=12.9125 \
        scb=0.0109255 scc=0.000383719 m=(1)
mp13 (net373 \3\:SI \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=5.265e-14 ps=1.31e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45064e-07 sb=3.10897e-07 sd=160n sca=14.0619 \
        scb=0.0121239 scc=0.000387547 m=(1)
mp10 (\5\:SEb \5\:SE \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=3.01e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=25.1693 \
        scb=0.0296469 scc=0.00157586 m=(1)
ends SDFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:33:11 2012 )
// Library name: gsclib045
// Cell name: XNOR2X1
// View name: extracted

simulator lang=spectre

subckt XNOR2X1 A B VDD VSS Y
mp5 (\1\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=5.46e-14 ps=1.84e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=33.3935 \
        scb=0.0357498 scc=0.00324908 m=(1)
C1 (A VSS) capacitor c=6.11438e-17
C2 (Y VSS) capacitor c=1.71652e-17
C3 (VDD VSS) capacitor c=1.07384e-16
C4 (n0 VSS) capacitor c=4.0102e-17
C5 (n1 VSS) capacitor c=1.07239e-16
C6 (n2 VSS) capacitor c=4.47272e-17
C7 (\4\:B VSS) capacitor c=3.75175e-17
C8 (\1\:B VSS) capacitor c=5.60507e-17
C9 (\1\:A VSS) capacitor c=4.10192e-17
C10 (\6\:B VSS) capacitor c=3.64948e-17
C11 (\2\:n1 VSS) capacitor c=6.69076e-17
C12 (\3\:n2 VSS) capacitor c=4.87453e-17
C13 (\3\:B VSS) capacitor c=4.97573e-17
C14 (\3\:A VSS) capacitor c=4.19523e-17
C15 (\3\:n0 VSS) capacitor c=4.11916e-17
C16 (\5\:B VSS) capacitor c=3.64294e-17
C17 (\3\:n1 VSS) capacitor c=3.09785e-17
C18 (\2\:B VSS) capacitor c=7.75677e-17
C19 (\4\:n2 VSS) capacitor c=4.81e-17
C20 (\2\:n2 VSS) capacitor c=2.66676e-17
C21 (\2\:A VSS) capacitor c=3.9633e-17
C22 (\2\:n0 VSS) capacitor c=2.6583e-17
C23 (\8\:n2 VSS) capacitor c=7.05858e-17
C24 (\7\:VDD VSS) capacitor c=3.2284e-17
C25 (\6\:n0 VSS) capacitor c=1.50756e-16
C26 (\4\:n1 VSS) capacitor c=9.73074e-17
C27 (\9\:VDD VSS) capacitor c=7.90217e-18
C28 (\1\:Y VSS) capacitor c=8.01002e-17
C29 (\1\:VDD VSS) capacitor c=3.14598e-17
C30 (\5\:n2 VSS) capacitor c=1.99647e-17
C31 (\4\:n0 VSS) capacitor c=1.00133e-16
C32 (\6\:n1 VSS) capacitor c=1.21043e-16
C33 (\3\:Y VSS) capacitor c=4.93172e-17
C34 (\4\:A VSS) capacitor c=4.81728e-17
C35 (\8\:n0 VSS) capacitor c=1.25666e-16
C36 (\8\:n1 VSS) capacitor c=8.54141e-17
C37 (\7\:B VSS) capacitor c=3.6053e-17
C38 (\8\:B VSS) capacitor c=7.21869e-17
C39 (\7\:n2 VSS) capacitor c=4.88624e-17
C40 (\10\:n2 VSS) capacitor c=1.05678e-16
C41 (\11\:n2 VSS) capacitor c=8.22381e-17
C42 (\3\:VDD VSS) capacitor c=6.66368e-18
C43 (\5\:VDD VSS) capacitor c=5.22727e-18
Rk3 (\4\:A A) resistor r=0.1344 c=0
Rk2 (\4\:Y Y) resistor r=0.02554 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.4604 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.08523 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.1656 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1983 c=0
Rk18 (\6\:VSS VSS) resistor r=0.05 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.05256 c=0
Rk19 (\3\:VSS \8\:VSS) resistor r=0.2983 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.3051 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1044 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1948 c=0
Rk24 (\5\:VDD VDD) resistor r=0.07995 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1707 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.1037 c=0
Rk27 (\5\:VDD \10\:VDD) resistor r=0.07488 c=0
Rk8 (\7\:B B) resistor r=0.105 c=0
Rk9 (B \8\:B) resistor r=0.04993 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.5904 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.738 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4858 c=0
Rk7 (\7\:n1 \8\:n1) resistor r=0.4295 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1354 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2777 c=0
Rk12 (\9\:n2 \10\:n2) resistor r=0.6504 c=0
Rk13 (\7\:n2 \11\:n2) resistor r=0.2288 c=0
Rl3 (\1\:A \2\:A) resistor r=29.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=104.538 c=0
Rl11 (\4\:B \5\:B) resistor r=24.2328 c=0
Rl12 (\5\:B \6\:B) resistor r=106.925 c=0
Rl6 (\1\:B \2\:B) resistor r=26.098 c=0
Rl7 (\2\:B \3\:B) resistor r=138.45 c=0
Rl1 (n0 \2\:n0) resistor r=26.098 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=56.8672 c=0
Rl9 (n1 \2\:n1) resistor r=159.615 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=66.5405 c=0
Rl8 (\3\:n2 \4\:n2) resistor r=24.2328 c=0
Rl5 (n2 \2\:n2) resistor r=52.6149 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\1\:VDD VDD) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry7 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.40962e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(1)
mn0 (\6\:n1 \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.65e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn4 (\4\:n0 \3\:B \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn3 (\4\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net145 \2\:n1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.45e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\5\:n2 \6\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp0 (\4\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.677e-14 ad=3.44e-14 ps=1.84e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.47326e-07 sd=160n sca=30.7589 \
        scb=0.0279464 scc=0.00328165 m=(1)
mp4 (\4\:n1 n2 \6\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=6.42326e-07 sd=160n sca=28.8228 \
        scb=0.0245184 scc=0.00324094 m=(1)
mp3 (\6\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.548e-14 ps=5.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=4.32326e-07 sd=160n sca=28.9644 \
        scb=0.0247513 scc=0.00324182 m=(1)
mp2 (net112 n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=3.27326e-07 sd=160n sca=29.7748 \
        scb=0.0261855 scc=0.00325287 m=(1)
mp1 (\8\:n2 \4\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=2.63e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.22326e-07 sd=160n sca=35.5405 \
        scb=0.0359913 scc=0.00371931 m=(1)
ends XNOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:33:59 2012 )
// Library name: gsclib045
// Cell name: XNOR2X2
// View name: extracted

simulator lang=spectre

subckt XNOR2X2 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.095e-14 \
        ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.53654e-07 sd=160n sca=26.5621 scb=0.0304693 \
        scc=0.00192189 m=(2)
C1 (A VSS) capacitor c=4.41192e-17
C2 (Y VSS) capacitor c=5.32654e-17
C3 (VDD VSS) capacitor c=2.54699e-16
C4 (B VSS) capacitor c=8.4326e-17
C5 (n0 VSS) capacitor c=1.62566e-16
C6 (n1 VSS) capacitor c=7.13602e-17
C7 (n2 VSS) capacitor c=4.16924e-17
C8 (net112 VSS) capacitor c=2.2804e-18
C9 (\4\:B VSS) capacitor c=3.17976e-17
C10 (\1\:B VSS) capacitor c=4.36825e-17
C11 (\1\:A VSS) capacitor c=4.69734e-17
C12 (\6\:B VSS) capacitor c=3.58334e-17
C13 (\2\:n1 VSS) capacitor c=4.88415e-17
C14 (\3\:n2 VSS) capacitor c=4.17189e-17
C15 (\3\:B VSS) capacitor c=5.44142e-17
C16 (\3\:A VSS) capacitor c=2.79798e-17
C17 (\5\:B VSS) capacitor c=3.32121e-17
C18 (\3\:n1 VSS) capacitor c=3.08564e-17
C19 (\2\:B VSS) capacitor c=7.2017e-17
C20 (\4\:n2 VSS) capacitor c=4.39871e-17
C21 (\2\:n2 VSS) capacitor c=2.48373e-17
C22 (\2\:A VSS) capacitor c=3.73386e-17
C23 (\6\:n2 VSS) capacitor c=1.27059e-16
C24 (\8\:VDD VSS) capacitor c=6.4106e-17
C25 (\7\:n0 VSS) capacitor c=1.41783e-16
C26 (\7\:n1 VSS) capacitor c=8.87859e-17
C27 (\1\:Y VSS) capacitor c=9.30756e-17
C28 (\1\:VDD VSS) capacitor c=3.5561e-17
C29 (\10\:n2 VSS) capacitor c=1.92086e-17
C30 (\10\:n0 VSS) capacitor c=7.95358e-17
C31 (\5\:n1 VSS) capacitor c=1.06814e-16
C32 (\3\:Y VSS) capacitor c=6.70233e-17
C33 (\5\:A VSS) capacitor c=5.02697e-17
C34 (\9\:n0 VSS) capacitor c=1.39681e-16
C35 (\4\:n1 VSS) capacitor c=5.91681e-17
C36 (\8\:B VSS) capacitor c=7.56672e-17
C37 (\5\:n2 VSS) capacitor c=1.1007e-16
C38 (\8\:n2 VSS) capacitor c=6.42876e-17
C39 (\9\:n2 VSS) capacitor c=9.23344e-17
C40 (\3\:VDD VSS) capacitor c=1.96694e-17
Rk3 (\4\:A \5\:A) resistor r=0.002857 c=0
Rk4 (\6\:A A) resistor r=0.002971 c=0
Rk5 (\5\:A \6\:A) resistor r=0.06502 c=0
Rk1 (\2\:Y Y) resistor r=0.2399 c=0
Rk2 (Y \4\:Y) resistor r=0.1958 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1128 c=0
Rk23 (\4\:VDD VDD) resistor r=0.09518 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.3386 c=0
Rk26 (\3\:VDD \9\:VDD) resistor r=0.3456 c=0
Rk17 (\4\:VSS VSS) resistor r=0.1956 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.6113 c=0
Rk10 (B \7\:B) resistor r=0.0075 c=0
Rk11 (\7\:B \8\:B) resistor r=0.1907 c=0
Rk6 (\8\:n0 \9\:n0) resistor r=0.7954 c=0
Rk7 (\8\:n0 \11\:n0) resistor r=0.4367 c=0
Rk8 (\4\:n1 \6\:n1) resistor r=0.4285 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.4717 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.7606 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.2667 c=0
Rk14 (\8\:n2 \9\:n2) resistor r=0.3421 c=0
Rk15 (\8\:n2 \11\:n2) resistor r=0.09346 c=0
Rl6 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl7 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl14 (\4\:B \5\:B) resistor r=48.7687 c=0
Rl15 (\5\:B \6\:B) resistor r=87.2302 c=0
Rl10 (\1\:B \2\:B) resistor r=30.6172 c=0
Rl11 (\2\:B \3\:B) resistor r=155.254 c=0
Rl12 (n1 \2\:n1) resistor r=161.538 c=0
Rl13 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl9 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl8 (n2 \2\:n2) resistor r=50.6918 c=0
Rz1 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz8 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz9 (\4\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz5 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\10\:n2 \11\:n2) resistor r=75 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry7 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\5\:B \7\:B) resistor r=45 c=0
Rx5 (\2\:B \8\:B) resistor r=45 c=0
Rx2 (\9\:n0 n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n2 \5\:n2) resistor r=45 c=0
Rx7 (\4\:n2 \9\:n2) resistor r=45 c=0
mn5 (\3\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.039e-14 \
        ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.6125e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mn0 (\5\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.263e-14 ps=9.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.005e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\10\:n0 \3\:B \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.393e-14 ps=7.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (\10\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.393e-14 ps=5.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=5.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.885e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.5e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (\10\:n2 \6\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.45e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mp0 (\7\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=4.837e-14 ps=1.17e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1e-06 sd=160n sca=16.298 scb=0.01559 \
        scc=0.000885958 m=(1)
mp4 (\7\:n1 n2 \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=7.3e-07 sd=160n sca=15.5147 \
        scb=0.015083 scc=0.000885445 m=(1)
mp3 (\7\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=5.25e-07 sd=160n sca=16.1384 \
        scb=0.0154529 scc=0.000885735 m=(1)
mp2 (net112 n1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=3.45e-07 sd=160n sca=17.5209 \
        scb=0.017113 scc=0.000893675 m=(1)
mp1 (\6\:n2 \4\:B \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=22.379 \
        scb=0.0254075 scc=0.00119864 m=(1)
ends XNOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:34:46 2012 )
// Library name: gsclib045
// Cell name: XNOR2X4
// View name: extracted

simulator lang=spectre

subckt XNOR2X4 A B VDD VSS Y
mp5 (\1\:Y n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.119e-14 \
        ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.38346e-06 sd=160n sca=25.2855 scb=0.0288799 \
        scc=0.00168046 m=(4)
C1 (A VSS) capacitor c=3.95837e-17
C2 (Y VSS) capacitor c=3.50158e-17
C3 (VDD VSS) capacitor c=3.28777e-16
C4 (B VSS) capacitor c=3.04594e-17
C5 (n0 VSS) capacitor c=2.78982e-16
C6 (n1 VSS) capacitor c=7.4897e-17
C7 (n2 VSS) capacitor c=4.89088e-17
C8 (\5\:B VSS) capacitor c=4.29698e-17
C9 (\3\:B VSS) capacitor c=9.02236e-17
C10 (\3\:n2 VSS) capacitor c=5.79358e-17
C11 (\1\:A VSS) capacitor c=4.74841e-17
C12 (\7\:B VSS) capacitor c=3.27055e-17
C13 (\3\:n1 VSS) capacitor c=8.69951e-17
C14 (\1\:B VSS) capacitor c=4.71432e-17
C15 (\3\:A VSS) capacitor c=4.68975e-17
C16 (\6\:B VSS) capacitor c=5.52281e-17
C17 (\2\:n1 VSS) capacitor c=7.64792e-17
C18 (\4\:B VSS) capacitor c=6.06321e-17
C19 (\2\:n2 VSS) capacitor c=7.15177e-17
C20 (\2\:B VSS) capacitor c=4.43249e-17
C21 (\2\:A VSS) capacitor c=4.36359e-17
C22 (\4\:n2 VSS) capacitor c=4.50864e-17
C23 (\5\:VDD VSS) capacitor c=4.74424e-17
C24 (\13\:n0 VSS) capacitor c=1.31716e-16
C25 (\4\:n1 VSS) capacitor c=3.62893e-17
C26 (\1\:Y VSS) capacitor c=2.28788e-16
C27 (\1\:VDD VSS) capacitor c=4.04351e-17
C28 (\8\:n2 VSS) capacitor c=3.08266e-17
C29 (\16\:n0 VSS) capacitor c=1.33286e-16
C30 (\7\:n1 VSS) capacitor c=9.65013e-17
C31 (\4\:Y VSS) capacitor c=1.62826e-16
C32 (\4\:A VSS) capacitor c=5.53456e-17
C33 (\15\:n0 VSS) capacitor c=2.60313e-16
C34 (\6\:n1 VSS) capacitor c=9.83439e-17
C35 (\9\:n1 VSS) capacitor c=6.96053e-17
C36 (\8\:B VSS) capacitor c=7.69056e-17
C37 (\9\:B VSS) capacitor c=5.12502e-17
C38 (\10\:B VSS) capacitor c=7.3825e-17
C39 (\6\:n2 VSS) capacitor c=8.9246e-17
C40 (\7\:n2 VSS) capacitor c=7.20778e-17
C41 (\3\:VDD VSS) capacitor c=2.8249e-17
Rk7 (A \4\:A) resistor r=0.05291 c=0
Rk28 (\4\:VSS VSS) resistor r=0.1011 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.5025 c=0
Rk2 (\1\:Y Y) resistor r=0.2077 c=0
Rk3 (Y \4\:Y) resistor r=0.103 c=0
Rk20 (\3\:VDD VDD) resistor r=0.4663 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.08796 c=0
Rk21 (\3\:VDD \6\:VDD) resistor r=0.2687 c=0
Rk13 (B \8\:B) resistor r=0.05065 c=0
Rk14 (\8\:B \9\:B) resistor r=0.1995 c=0
Rk15 (\9\:B \10\:B) resistor r=0.3157 c=0
Rk8 (\14\:n0 \15\:n0) resistor r=1.1557 c=0
Rk9 (\15\:n0 \17\:n0) resistor r=0.9928 c=0
Rk10 (\5\:n1 \6\:n1) resistor r=0.06323 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.4893 c=0
Rk12 (\6\:n1 \9\:n1) resistor r=0.341 c=0
Rk16 (\5\:n2 \6\:n2) resistor r=0.369 c=0
Rk17 (\6\:n2 \7\:n2) resistor r=0.4101 c=0
Rk18 (\6\:n2 \9\:n2) resistor r=0.0803 c=0
Rl12 (\1\:A \2\:A) resistor r=123.769 c=0
Rl13 (\2\:A \3\:A) resistor r=57.2589 c=0
Rl20 (\5\:B \6\:B) resistor r=105.746 c=0
Rl21 (\6\:B \7\:B) resistor r=86.3335 c=0
Rl17 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl14 (\1\:B \2\:B) resistor r=51.903 c=0
Rl18 (n1 \2\:n1) resistor r=24.2328 c=0
Rl19 (\2\:n1 \3\:n1) resistor r=177.645 c=0
Rl15 (n2 \2\:n2) resistor r=26.9231 c=0
Rl16 (\2\:n2 \3\:n2) resistor r=157.143 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz7 (VDD \1\:VDD) resistor r=8.3333 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz3 (\17\:n0 \16\:n0) resistor r=37.5 c=0
Rz4 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz5 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry6 (\6\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry3 (\14\:n0 \13\:n0) resistor r=31 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\15\:n0 n0) resistor r=45 c=0
Rx3 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \7\:n2) resistor r=45 c=0
mn5 (\4\:Y n0 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.081e-14 \
        ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.34894e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(4)
mn0 (\7\:n1 \3\:A VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.833e-14 ps=9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=9.7e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\16\:n0 \1\:B \7\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.833e-14 ad=4.16e-14 ps=8.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.24615e-07 sb=6.36058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn3 (\16\:n0 n2 net145 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.16e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.29615e-07 sb=4.31058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (net145 \3\:n1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.21e-14 ps=9.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05962e-06 sb=3.01058e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\8\:n2 \7\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp0 (\4\:n1 \1\:A VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=8.523e-14 ps=1.16e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.045e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\4\:n1 \3\:n2 \13\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.523e-14 ps=1.1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.89103e-07 sb=5.79551e-07 sd=160n sca=12.0589 \
        scb=0.0100044 scc=0.000274129 m=(1)
mp3 (\13\:n0 \3\:B net112 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.94103e-07 sb=3.74551e-07 sd=160n sca=13.0911 \
        scb=0.0108737 scc=0.000275827 m=(1)
mp2 (net112 n1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0991e-06 sb=2.69551e-07 sd=160n sca=14.1331 \
        scb=0.0123288 scc=0.000285937 m=(1)
mp1 (\4\:n2 \5\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=1.4e-07 sd=160n sca=22.7425 \
        scb=0.0263845 scc=0.00115464 m=(1)
ends XNOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:35:33 2012 )
// Library name: gsclib045
// Cell name: XNOR2XL
// View name: extracted

simulator lang=spectre

subckt XNOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.17e-14 ps=1.74e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47442e-07 sb=1.15733e-06 sd=160n sca=27.5082 \
        scb=0.031157 scc=0.00214164 m=(1)
C1 (A VSS) capacitor c=6.40372e-17
C2 (Y VSS) capacitor c=3.98833e-17
C3 (B VSS) capacitor c=2.74316e-17
C4 (VDD VSS) capacitor c=1.35166e-16
C5 (n0 VSS) capacitor c=3.29803e-17
C6 (n1 VSS) capacitor c=7.80705e-17
C7 (n2 VSS) capacitor c=5.26022e-17
C8 (net112 VSS) capacitor c=4.45915e-18
C9 (\5\:B VSS) capacitor c=3.66455e-17
C10 (\1\:B VSS) capacitor c=3.88835e-17
C11 (\1\:A VSS) capacitor c=5.14892e-17
C12 (\7\:B VSS) capacitor c=3.33979e-17
C13 (\2\:n1 VSS) capacitor c=4.29962e-17
C14 (\3\:n2 VSS) capacitor c=3.85041e-17
C15 (\3\:B VSS) capacitor c=6.0252e-17
C16 (\3\:A VSS) capacitor c=2.99841e-17
C17 (\3\:n0 VSS) capacitor c=3.51391e-17
C18 (\6\:B VSS) capacitor c=3.88171e-17
C19 (\3\:n1 VSS) capacitor c=2.99281e-17
C20 (\4\:B VSS) capacitor c=2.97005e-17
C21 (\4\:n2 VSS) capacitor c=4.22246e-17
C22 (\2\:n2 VSS) capacitor c=2.36728e-17
C23 (\2\:A VSS) capacitor c=3.99061e-17
C24 (\2\:n0 VSS) capacitor c=3.25749e-17
C25 (\8\:n2 VSS) capacitor c=9.32988e-17
C26 (\1\:VDD VSS) capacitor c=2.71754e-17
C27 (\4\:n0 VSS) capacitor c=1.6329e-16
C28 (\7\:n1 VSS) capacitor c=8.93955e-17
C29 (\7\:VDD VSS) capacitor c=2.86661e-17
C30 (\1\:Y VSS) capacitor c=5.87429e-17
C31 (\3\:VDD VSS) capacitor c=3.17065e-17
C32 (\5\:n2 VSS) capacitor c=1.93873e-17
C33 (\7\:n0 VSS) capacitor c=7.82499e-17
C34 (\5\:n1 VSS) capacitor c=1.24078e-16
C35 (\3\:Y VSS) capacitor c=2.59791e-17
C36 (\2\:B VSS) capacitor c=4.37565e-17
C37 (\4\:A VSS) capacitor c=3.5715e-17
C38 (\6\:n0 VSS) capacitor c=1.22079e-16
C39 (\4\:n1 VSS) capacitor c=6.4193e-17
C40 (\8\:B VSS) capacitor c=5.19334e-17
C41 (\9\:B VSS) capacitor c=4.89112e-17
C42 (\7\:n2 VSS) capacitor c=5.78438e-17
C43 (\10\:n2 VSS) capacitor c=7.76696e-17
C44 (\11\:n2 VSS) capacitor c=1.06336e-16
C45 (\5\:VDD VSS) capacitor c=1.41661e-17
Rk3 (A \4\:A) resistor r=0.08017 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4507 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.3158 c=0
Rk17 (\6\:VSS VSS) resistor r=0.04991 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.08507 c=0
Rk18 (\5\:VSS \8\:VSS) resistor r=0.3456 c=0
Rk1 (\2\:Y Y) resistor r=0.2937 c=0
Rk2 (Y \4\:Y) resistor r=0.08433 c=0
Rk8 (\8\:B B) resistor r=0.07907 c=0
Rk9 (B \9\:B) resistor r=0.0911 c=0
Rk19 (\2\:VDD \4\:VDD) resistor r=0.1918 c=0
Rk20 (\4\:VDD \5\:VDD) resistor r=0.3007 c=0
Rk22 (\6\:VDD VDD) resistor r=0.04991 c=0
Rk21 (\5\:VDD \6\:VDD) resistor r=0.1001 c=0
Rk23 (\5\:VDD \8\:VDD) resistor r=0.1608 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8388 c=0
Rk5 (\5\:n0 \8\:n0) resistor r=0.3989 c=0
Rk6 (\4\:n1 \6\:n1) resistor r=0.4559 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.5094 c=0
Rk10 (\6\:n2 \7\:n2) resistor r=0.1047 c=0
Rk11 (\7\:n2 \9\:n2) resistor r=0.2748 c=0
Rk12 (\7\:n2 \10\:n2) resistor r=0.3435 c=0
Rk13 (\9\:n2 \11\:n2) resistor r=0.7396 c=0
Rl3 (\1\:A \2\:A) resistor r=83.3841 c=0
Rl4 (\2\:A \3\:A) resistor r=39.1533 c=0
Rl12 (\5\:B \6\:B) resistor r=39.5596 c=0
Rl13 (\6\:B \7\:B) resistor r=76.098 c=0
Rl7 (\1\:B \2\:B) resistor r=25.7494 c=0
Rl8 (\2\:B \3\:B) resistor r=146.518 c=0
Rl9 (\2\:B \4\:B) resistor r=5.783 c=0
Rl1 (n0 \2\:n0) resistor r=33.3841 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.1533 c=0
Rl10 (n1 \2\:n1) resistor r=148.077 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl6 (\3\:n2 \4\:n2) resistor r=29.5379 c=0
Rl5 (n2 \2\:n2) resistor r=69.9225 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz8 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\4\:n2 \10\:n2) resistor r=45 c=0
Rx7 (\2\:n2 \11\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn3 (\7\:n0 \3\:n2 net145 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.392e-14 ps=6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn0 (\5\:n1 \3\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.7e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn4 (\7\:n0 \3\:B \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.392e-14 ps=6.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.6e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn2 (net145 \2\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.247e-14 ps=6.2e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=3.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (\5\:n2 \7\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mp0 (\7\:n1 \1\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.548e-14 ps=1.74e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52442e-07 sb=9.52326e-07 sd=160n sca=21.6735 \
        scb=0.0213374 scc=0.00167521 m=(1)
mp4 (\7\:n1 n2 \4\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.62442e-07 sb=7.42326e-07 sd=160n sca=20.0463 \
        scb=0.0191953 scc=0.00166251 m=(1)
mp3 (\4\:n0 \1\:B net112 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.67442e-07 sb=5.37326e-07 sd=160n sca=19.9753 \
        scb=0.0191105 scc=0.0016624 m=(1)
mp2 (net112 n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.75e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.72442e-07 sb=3.32326e-07 sd=160n sca=21.2505 \
        scb=0.0206889 scc=0.0016691 m=(1)
mp1 (\8\:n2 \5\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=2.63e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18244e-06 sb=1.22326e-07 sd=160n sca=25.996 \
        scb=0.028784 scc=0.00194969 m=(1)
ends XNOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:36:21 2012 )
// Library name: gsclib045
// Cell name: XOR2X1
// View name: extracted

simulator lang=spectre

subckt XOR2X1 A B VDD VSS Y
mp5 (\3\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.87115e-07 sd=160n sca=38.6307 \
        scb=0.0321643 scc=0.00380145 m=(1)
C1 (A VSS) capacitor c=9.61838e-17
C2 (Y VSS) capacitor c=1.49768e-17
C3 (VDD VSS) capacitor c=1.22108e-16
C4 (n0 VSS) capacitor c=4.06128e-17
C5 (n1 VSS) capacitor c=4.71489e-17
C6 (n2 VSS) capacitor c=3.42433e-17
C7 (net130 VSS) capacitor c=3.2875e-18
C8 (\7\:B VSS) capacitor c=4.00746e-17
C9 (\3\:n1 VSS) capacitor c=7.16692e-17
C10 (\1\:B VSS) capacitor c=4.49761e-17
C11 (\1\:A VSS) capacitor c=4.63311e-17
C12 (\5\:B VSS) capacitor c=3.62522e-17
C13 (\3\:B VSS) capacitor c=6.45495e-17
C14 (\3\:n2 VSS) capacitor c=6.56065e-17
C15 (\3\:A VSS) capacitor c=3.68305e-17
C16 (\3\:n0 VSS) capacitor c=3.47041e-17
C17 (\6\:B VSS) capacitor c=4.98476e-17
C18 (\2\:n1 VSS) capacitor c=7.34484e-17
C19 (\4\:B VSS) capacitor c=6.14704e-17
C20 (\2\:n2 VSS) capacitor c=6.22106e-17
C21 (\2\:B VSS) capacitor c=5.56873e-17
C22 (\2\:A VSS) capacitor c=4.6988e-17
C23 (\2\:n0 VSS) capacitor c=2.75721e-17
C24 (\6\:n2 VSS) capacitor c=1.0206e-16
C25 (\7\:VDD VSS) capacitor c=4.42523e-17
C26 (\7\:n0 VSS) capacitor c=1.1658e-16
C27 (\6\:n1 VSS) capacitor c=6.42075e-17
C28 (\9\:VDD VSS) capacitor c=2.72283e-17
C29 (\3\:Y VSS) capacitor c=8.46711e-17
C30 (\1\:VDD VSS) capacitor c=4.35488e-17
C31 (\4\:n2 VSS) capacitor c=5.57801e-17
C32 (\4\:n0 VSS) capacitor c=1.26802e-16
C33 (\8\:n1 VSS) capacitor c=3.8519e-17
C34 (\1\:Y VSS) capacitor c=7.5761e-17
C35 (\4\:A VSS) capacitor c=7.37136e-17
C36 (\6\:n0 VSS) capacitor c=2.83532e-16
C37 (\4\:n1 VSS) capacitor c=7.23955e-17
C38 (\5\:n1 VSS) capacitor c=1.47277e-16
C39 (\8\:B VSS) capacitor c=4.73523e-17
C40 (\9\:B VSS) capacitor c=1.02833e-16
C41 (\10\:B VSS) capacitor c=7.17341e-17
C42 (\8\:n2 VSS) capacitor c=7.13372e-17
Rk3 (A \4\:A) resistor r=0.2026 c=0
Rk2 (\4\:Y Y) resistor r=0.03363 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.488 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1027 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1981 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.1972 c=0
Rk25 (\6\:VDD VDD) resistor r=0.04996 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.1018 c=0
Rk26 (\3\:VDD \8\:VDD) resistor r=0.3038 c=0
Rk27 (\5\:VDD \10\:VDD) resistor r=0.06847 c=0
Rk14 (\2\:VSS \3\:VSS) resistor r=0.09269 c=0
Rk15 (\3\:VSS \4\:VSS) resistor r=0.2082 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1972 c=0
Rk18 (\6\:VSS VSS) resistor r=0.04996 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.1018 c=0
Rk19 (\3\:VSS \8\:VSS) resistor r=0.3132 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.0509 c=0
Rk9 (\8\:B B) resistor r=0.1378 c=0
Rk10 (B \9\:B) resistor r=0.03572 c=0
Rk11 (\9\:B \10\:B) resistor r=0.1734 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.9195 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8649 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.4267 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.4706 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.09434 c=0
Rk12 (\5\:n2 \7\:n2) resistor r=0.5146 c=0
Rk13 (\7\:n2 \8\:n2) resistor r=0.4061 c=0
Rl3 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl4 (\2\:A \3\:A) resistor r=69.9225 c=0
Rl12 (\6\:B \7\:B) resistor r=91.5895 c=0
Rl11 (\5\:B \6\:B) resistor r=70.9489 c=0
Rl8 (\3\:B \4\:B) resistor r=74.2328 c=0
Rl5 (\1\:B \2\:B) resistor r=87.6365 c=0
Rl1 (n0 \2\:n0) resistor r=35.3072 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rl9 (n1 \2\:n1) resistor r=32.267 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=136.894 c=0
Rl6 (n2 \2\:n2) resistor r=24.2328 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=148.798 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry7 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\6\:n2 \7\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\2\:n2 \8\:n2) resistor r=45 c=0
mn5 (\1\:Y \3\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.64e-14 ps=1.56e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.08942e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\8\:n1 \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=3.915e-14 ps=1.56e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.7e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\4\:n0 \3\:n2 \8\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net131 n1 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\4\:n2 \5\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mp0 (\6\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.635e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.5e-07 sd=160n sca=15.0952 \
        scb=0.0139603 scc=0.000435069 m=(1)
mp4 (\6\:n1 \1\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.45e-07 sd=160n sca=13.633 \
        scb=0.0120861 scc=0.000425416 m=(1)
mp3 (\7\:n0 n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=5.25e-07 sd=160n sca=13.6458 \
        scb=0.0121015 scc=0.000425438 m=(1)
mp2 (net130 \3\:n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=14.8634 \
        scb=0.0136114 scc=0.000432055 m=(1)
mp1 (\6\:n2 \7\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=19.3929 \
        scb=0.0213506 scc=0.000688958 m=(1)
ends XOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:37:09 2012 )
// Library name: gsclib045
// Cell name: XOR2XL
// View name: extracted

simulator lang=spectre

subckt XOR2XL A B VDD VSS Y
mp5 (\1\:Y n0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=3.01e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=25.0648 \
        scb=0.0294525 scc=0.00155947 m=(1)
C1 (A VSS) capacitor c=1.18154e-16
C2 (Y VSS) capacitor c=6.78553e-17
C3 (VDD VSS) capacitor c=1.28579e-16
C4 (B VSS) capacitor c=2.47732e-17
C5 (n0 VSS) capacitor c=4.19608e-17
C6 (n1 VSS) capacitor c=2.6303e-17
C7 (n2 VSS) capacitor c=6.4662e-17
C8 (net130 VSS) capacitor c=5.21894e-19
C9 (\7\:B VSS) capacitor c=3.65474e-17
C10 (\3\:n1 VSS) capacitor c=8.52312e-17
C11 (\2\:n2 VSS) capacitor c=5.84681e-17
C12 (\2\:B VSS) capacitor c=3.6827e-17
C13 (\1\:A VSS) capacitor c=4.00592e-17
C14 (\5\:B VSS) capacitor c=4.23866e-17
C15 (\4\:n1 VSS) capacitor c=4.24271e-17
C16 (\3\:B VSS) capacitor c=6.07595e-17
C17 (\3\:A VSS) capacitor c=4.29329e-17
C18 (\3\:n0 VSS) capacitor c=3.04869e-17
C19 (\6\:B VSS) capacitor c=5.98265e-17
C20 (\4\:B VSS) capacitor c=6.40614e-17
C21 (\3\:n2 VSS) capacitor c=3.31186e-17
C22 (\1\:B VSS) capacitor c=3.84951e-17
C23 (\2\:A VSS) capacitor c=3.9677e-17
C24 (\2\:n0 VSS) capacitor c=3.9628e-17
C25 (\8\:n2 VSS) capacitor c=1.07795e-17
C26 (\7\:VDD VSS) capacitor c=4.32719e-17
C27 (\7\:n0 VSS) capacitor c=1.24285e-16
C28 (\7\:n1 VSS) capacitor c=7.46724e-17
C29 (\9\:VDD VSS) capacitor c=1.40752e-17
C30 (\1\:Y VSS) capacitor c=5.51624e-17
C31 (\1\:VDD VSS) capacitor c=5.89447e-17
C32 (\4\:n2 VSS) capacitor c=3.99849e-17
C33 (\4\:n0 VSS) capacitor c=1.1781e-16
C34 (\9\:n1 VSS) capacitor c=4.03226e-17
C35 (\3\:Y VSS) capacitor c=2.85194e-17
C36 (\2\:n1 VSS) capacitor c=5.31009e-17
C37 (\4\:A VSS) capacitor c=7.48347e-17
C38 (\6\:n0 VSS) capacitor c=2.79883e-16
C39 (\5\:n1 VSS) capacitor c=6.98327e-17
C40 (\6\:n1 VSS) capacitor c=1.00633e-16
C41 (\8\:B VSS) capacitor c=6.33711e-17
C42 (\9\:B VSS) capacitor c=4.7616e-17
C43 (\10\:B VSS) capacitor c=6.27484e-17
C44 (\6\:n2 VSS) capacitor c=1.09292e-16
C45 (\7\:n2 VSS) capacitor c=9.4099e-17
C46 (\5\:VDD VSS) capacitor c=4.91091e-19
Rk3 (A \4\:A) resistor r=0.2701 c=0
Rk1 (\2\:Y Y) resistor r=0.2725 c=0
Rk2 (Y \4\:Y) resistor r=0.0976 c=0
Rk20 (\2\:VDD \3\:VDD) resistor r=0.1102 c=0
Rk21 (\3\:VDD \4\:VDD) resistor r=0.1906 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk24 (\6\:VDD VDD) resistor r=0.04995 c=0
Rk23 (\5\:VDD \6\:VDD) resistor r=0.07761 c=0
Rk25 (\3\:VDD \8\:VDD) resistor r=0.3135 c=0
Rk26 (\5\:VDD \10\:VDD) resistor r=0.1048 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.4443 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.3386 c=0
Rk18 (\6\:VSS VSS) resistor r=0.04995 c=0
Rk17 (\5\:VSS \6\:VSS) resistor r=0.06255 c=0
Rk19 (\5\:VSS \8\:VSS) resistor r=0.09135 c=0
Rk10 (\9\:B B) resistor r=0.06653 c=0
Rk9 (\8\:B \9\:B) resistor r=0.1615 c=0
Rk11 (B \10\:B) resistor r=0.1661 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.8935 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.8779 c=0
Rk6 (\5\:n1 \6\:n1) resistor r=0.4181 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.4325 c=0
Rk8 (\6\:n1 \10\:n1) resistor r=0.09515 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.445 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5898 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.04841 c=0
Rl3 (\1\:A \2\:A) resistor r=54.5379 c=0
Rl4 (\2\:A \3\:A) resistor r=112.23 c=0
Rl13 (\6\:B \7\:B) resistor r=70.3297 c=0
Rl12 (\5\:B \6\:B) resistor r=99.7901 c=0
Rl8 (\3\:B \4\:B) resistor r=89.6174 c=0
Rl5 (\1\:B \2\:B) resistor r=30.3481 c=0
Rl1 (n0 \2\:n0) resistor r=126.156 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=37.6944 c=0
Rl9 (n1 \2\:n1) resistor r=2.0213 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=170.434 c=0
Rl11 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl6 (n2 \2\:n2) resistor r=195.27 c=0
Rl7 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz9 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\9\:n1 \10\:n1) resistor r=75 c=0
Rz4 (\4\:n2 \5\:n2) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry4 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\1\:B \10\:B) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (n1 \5\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.3e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn0 (\9\:n1 \3\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.23e-14 ad=5.51e-14 ps=1.4e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.095e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn4 (\4\:n0 n2 \9\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=6.7e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn3 (\4\:n0 \3\:B net131 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=2.32e-14 ps=4.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=4.65e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (net131 \4\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.087e-14 ps=6.1e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn1 (\4\:n2 \5\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp0 (\7\:n1 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=4.515e-14 ps=1.58e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.95e-07 sd=160n sca=16.6712 \
        scb=0.0163973 scc=0.000573191 m=(1)
mp4 (\7\:n1 \2\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=7.4e-07 sd=160n sca=14.3602 scb=0.0131207 \
        scc=0.000544277 m=(1)
mp3 (\7\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.35e-07 sd=160n sca=14.2892 \
        scb=0.0130359 scc=0.000544163 m=(1)
mp2 (net130 \3\:n1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.45e-07 sd=160n sca=15.406 \
        scb=0.0143862 scc=0.000549226 m=(1)
mp1 (\8\:n2 \7\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=19.4967 \
        scb=0.0213498 scc=0.00074757 m=(1)
ends XOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 10:05:15 2012 )
// Library name: gsclib045
// Cell name: NOR2X8
// View name: extracted

simulator lang=spectre

subckt NOR2X8 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \14\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=2.67e-14 ps=1.17e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.537 scb=0.0176846 \
        scc=0.000953219 m=(1)
C1 (A VSS) capacitor c=1.1863e-15
C2 (Y VSS) capacitor c=4.02979e-17
C3 (VDD VSS) capacitor c=1.62353e-16
C4 (B VSS) capacitor c=1.05671e-15
C5 (2 VSS) capacitor c=3.0278e-18
C6 (4 VSS) capacitor c=2.01655e-18
C7 (5 VSS) capacitor c=1.8715e-18
C8 (6 VSS) capacitor c=2.01655e-18
C9 (7 VSS) capacitor c=2.01655e-18
C10 (8 VSS) capacitor c=2.0385e-18
C11 (9 VSS) capacitor c=2.01655e-18
C12 (\22\:B VSS) capacitor c=9.53584e-17
C13 (\23\:A VSS) capacitor c=7.21774e-17
C14 (\22\:A VSS) capacitor c=8.30955e-17
C15 (\19\:B VSS) capacitor c=6.33113e-17
C16 (\17\:B VSS) capacitor c=6.43905e-17
C17 (\16\:A VSS) capacitor c=7.22305e-17
C18 (\14\:A VSS) capacitor c=7.56934e-17
C19 (\12\:B VSS) capacitor c=8.052e-17
C20 (\11\:B VSS) capacitor c=6.37914e-17
C21 (\4\:A VSS) capacitor c=7.13019e-17
C22 (\10\:A VSS) capacitor c=7.17956e-17
C23 (\1\:B VSS) capacitor c=6.42803e-17
C24 (\5\:B VSS) capacitor c=8.10503e-17
C25 (\1\:A VSS) capacitor c=8.33517e-17
C26 (\32\:Y VSS) capacitor c=2.46809e-17
C27 (\8\:VDD VSS) capacitor c=5.02466e-17
C28 (\29\:Y VSS) capacitor c=3.85794e-17
C29 (\10\:VDD VSS) capacitor c=4.9988e-17
C30 (\26\:Y VSS) capacitor c=3.84973e-17
C31 (\12\:VDD VSS) capacitor c=4.99257e-17
C32 (\23\:Y VSS) capacitor c=3.84955e-17
C33 (\14\:VDD VSS) capacitor c=4.73711e-17
C34 (\1\:VDD VSS) capacitor c=5.35936e-17
C35 (\1\:Y VSS) capacitor c=9.76442e-16
C36 (\21\:A VSS) capacitor c=5.48518e-17
C37 (\34\:Y VSS) capacitor c=4.83786e-17
C38 (\22\:Y VSS) capacitor c=1.48894e-16
C39 (\25\:Y VSS) capacitor c=8.49541e-17
C40 (\28\:Y VSS) capacitor c=8.51082e-17
C41 (\31\:Y VSS) capacitor c=7.28489e-17
C42 (\3\:VDD VSS) capacitor c=1.57591e-17
C43 (\4\:VDD VSS) capacitor c=2.29513e-17
C44 (\6\:VDD VSS) capacitor c=1.55319e-17
C45 (\7\:VDD VSS) capacitor c=1.48165e-17
Rk31 (Y \34\:Y) resistor r=0.3651 c=0
Rk32 (\34\:Y \1\:Y) resistor r=0.07606 c=0
Rk22 (\1\:Y \22\:Y) resistor r=0.8362 c=0
Rk23 (\22\:Y \24\:Y) resistor r=0.09088 c=0
Rk24 (\22\:Y \25\:Y) resistor r=0.4605 c=0
Rk25 (\25\:Y \27\:Y) resistor r=0.09088 c=0
Rk26 (\25\:Y \28\:Y) resistor r=0.4641 c=0
Rk27 (\28\:Y \30\:Y) resistor r=0.08751 c=0
Rk30 (\31\:Y Y) resistor r=0.3427 c=0
Rk28 (\28\:Y \31\:Y) resistor r=0.4605 c=0
Rk29 (\31\:Y \33\:Y) resistor r=0.08751 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.2684 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.3109 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.09018 c=0
Rk57 (\7\:VDD VDD) resistor r=0.09997 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.3109 c=0
Rk58 (\3\:VDD \9\:VDD) resistor r=0.2499 c=0
Rk59 (\4\:VDD \11\:VDD) resistor r=0.2499 c=0
Rk60 (\6\:VDD \13\:VDD) resistor r=0.2499 c=0
Rk61 (\7\:VDD \15\:VDD) resistor r=0.2903 c=0
Rl23 (A \16\:A) resistor r=86.3033 c=0
Rl21 (A \14\:A) resistor r=101.842 c=0
Rl8 (A \4\:A) resistor r=81.5719 c=0
Rl13 (A \10\:A) resistor r=81.5719 c=0
Rl1 (A \1\:A) resistor r=99.5886 c=0
Rl33 (\21\:A A) resistor r=41.0733 c=0
Rl35 (\21\:A \23\:A) resistor r=65.6027 c=0
Rl34 (\21\:A \22\:A) resistor r=132.813 c=0
Rl37 (B \22\:B) resistor r=113.107 c=0
Rl29 (B \19\:B) resistor r=37.4703 c=0
Rl27 (B \17\:B) resistor r=40.3857 c=0
Rl18 (B \12\:B) resistor r=44.8736 c=0
Rl17 (B \11\:B) resistor r=38.5399 c=0
Rl3 (B \1\:B) resistor r=37.6767 c=0
Rl6 (B \5\:B) resistor r=44.8736 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz17 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Ry1 (\24\:Y \23\:Y) resistor r=20.6667 c=0
Ry2 (\27\:Y \26\:Y) resistor r=20.6667 c=0
Ry3 (\30\:Y \29\:Y) resistor r=20.6667 c=0
Ry4 (\33\:Y \32\:Y) resistor r=20.6667 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=31 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
mn0 (\1\:Y A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.678e-14 \
        ad=4.72e-14 ps=9.0714e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
mn1 (\1\:Y B VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
mp1_1__rcx (\23\:Y \5\:B 2 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.9609 scb=0.0150862 \
        scc=0.00091445 m=(1)
mp1 (\23\:Y \1\:B 4 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=2.67e-14 \
        ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.8e-06 sd=160n sca=15.5281 scb=0.013472 \
        scc=0.000907738 m=(1)
mp0 (4 \10\:A \12\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.695e-06 sd=160n sca=15.1505 \
        scb=0.0132652 scc=0.000907605 m=(1)
mp0_2__rcx (5 \4\:A \12\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.49e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_4__rcx (7 \16\:A \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=8.65e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_2__rcx (\26\:Y \11\:B 5 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.385e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_4__rcx (\29\:Y \17\:B 7 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=7.6e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_3__rcx (\26\:Y \12\:B 6 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.18e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_5__rcx (\29\:Y \19\:B 8 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=5.55e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_3__rcx (6 \14\:A \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.075e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_5__rcx (8 \22\:A \8\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=4.5e-07 sd=160n sca=14.8079 scb=0.013166 \
        scc=0.000907585 m=(1)
mp0_6__rcx (9 \23\:A \8\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=14.8666 scb=0.0131776 \
        scc=0.000907586 m=(1)
mp1_6__rcx (\32\:Y \22\:B 9 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=6.23e-14 ps=1.01e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.1213 scb=0.0132536 \
        scc=0.000907601 m=(1)
ends NOR2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 12:28:38 2012 )
// Library name: gsclib045
// Cell name: ADDFX1
// View name: extracted

simulator lang=spectre

subckt ADDFX1 A B CI CO S VDD VSS
mp12 (\1\:CO \4\:COb \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.615e-14 ad=5.46e-14 ps=1.33e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12821e-07 sd=160n sca=24.8923 \
        scb=0.0283314 scc=0.00161065 m=(1)
C1 (A VSS) capacitor c=1.01916e-16
C2 (B VSS) capacitor c=1.1004e-16
C3 (CO VSS) capacitor c=5.53574e-17
C4 (VDD VSS) capacitor c=2.25509e-16
C5 (S VSS) capacitor c=5.98885e-17
C6 (CI VSS) capacitor c=1.91306e-16
C7 (COb VSS) capacitor c=1.32321e-17
C8 (n2 VSS) capacitor c=8.98477e-17
C9 (n4 VSS) capacitor c=7.94196e-17
C10 (Sb VSS) capacitor c=4.52858e-17
C11 (n7 VSS) capacitor c=1.78033e-18
C12 (n6 VSS) capacitor c=1.50273e-18
C13 (n3 VSS) capacitor c=6.37448e-17
C14 (n1 VSS) capacitor c=1.4721e-18
C15 (n5 VSS) capacitor c=6.91224e-17
C16 (\12\:A VSS) capacitor c=9.1911e-17
C17 (\12\:B VSS) capacitor c=9.39089e-17
C18 (\10\:CI VSS) capacitor c=1.0761e-16
C19 (\7\:COb VSS) capacitor c=3.22178e-17
C20 (\9\:A VSS) capacitor c=6.54183e-17
C21 (\7\:B VSS) capacitor c=3.94173e-17
C22 (\5\:CI VSS) capacitor c=6.47751e-17
C23 (\4\:A VSS) capacitor c=6.88815e-17
C24 (\4\:B VSS) capacitor c=5.07826e-17
C25 (\4\:CI VSS) capacitor c=5.62731e-17
C26 (\1\:B VSS) capacitor c=4.08861e-17
C27 (\1\:A VSS) capacitor c=5.20741e-17
C28 (\4\:COb VSS) capacitor c=3.63097e-17
C29 (\3\:Sb VSS) capacitor c=4.98985e-17
C30 (\10\:A VSS) capacitor c=5.69726e-17
C31 (\10\:B VSS) capacitor c=8.63264e-17
C32 (\8\:CI VSS) capacitor c=4.23041e-17
C33 (\5\:COb VSS) capacitor c=6.61111e-17
C34 (\7\:A VSS) capacitor c=3.79991e-17
C35 (\9\:B VSS) capacitor c=6.2418e-17
C36 (\7\:CI VSS) capacitor c=4.08075e-17
C37 (\6\:A VSS) capacitor c=7.56648e-17
C38 (\6\:B VSS) capacitor c=8.51157e-17
C39 (\3\:CI VSS) capacitor c=4.06761e-17
C40 (\3\:B VSS) capacitor c=6.23183e-17
C41 (\3\:A VSS) capacitor c=4.50607e-17
C42 (\3\:COb VSS) capacitor c=3.50594e-17
C43 (\2\:Sb VSS) capacitor c=4.41245e-17
C44 (\11\:A VSS) capacitor c=8.51942e-17
C45 (\11\:B VSS) capacitor c=1.00319e-16
C46 (\9\:CI VSS) capacitor c=8.79454e-17
C47 (\6\:COb VSS) capacitor c=7.7396e-17
C48 (\8\:A VSS) capacitor c=6.09429e-17
C49 (\8\:B VSS) capacitor c=6.52422e-17
C50 (\6\:CI VSS) capacitor c=6.86721e-17
C51 (\5\:A VSS) capacitor c=8.54892e-17
C52 (\5\:B VSS) capacitor c=9.3236e-17
C53 (\1\:CI VSS) capacitor c=3.22661e-17
C54 (\2\:B VSS) capacitor c=6.96542e-17
C55 (\2\:A VSS) capacitor c=5.78554e-17
C56 (\1\:S VSS) capacitor c=3.16731e-17
C57 (\1\:VDD VSS) capacitor c=5.88099e-17
C58 (\7\:Sb VSS) capacitor c=1.08239e-16
C59 (\13\:VDD VSS) capacitor c=1.35571e-17
C60 (\3\:n5 VSS) capacitor c=6.86923e-17
C61 (\15\:VDD VSS) capacitor c=7.73761e-18
C62 (\12\:COb VSS) capacitor c=2.38226e-17
C63 (\17\:VDD VSS) capacitor c=1.2528e-17
C64 (\3\:n3 VSS) capacitor c=5.89506e-17
C65 (\19\:VDD VSS) capacitor c=2.73436e-17
C66 (\1\:CO VSS) capacitor c=3.3742e-17
C67 (\3\:VDD VSS) capacitor c=8.84522e-17
C68 (\3\:S VSS) capacitor c=7.42176e-17
C69 (\4\:Sb VSS) capacitor c=1.28263e-16
C70 (\3\:n4 VSS) capacitor c=8.18074e-17
C71 (\14\:COb VSS) capacitor c=1.53831e-16
C72 (\3\:n2 VSS) capacitor c=9.47729e-17
C73 (\3\:CO VSS) capacitor c=4.55275e-17
C74 (\2\:COb VSS) capacitor c=1.87979e-17
C75 (\2\:CI VSS) capacitor c=4.45461e-17
C76 (\8\:COb VSS) capacitor c=1.80903e-16
C77 (\9\:COb VSS) capacitor c=2.01744e-16
C78 (\10\:COb VSS) capacitor c=1.91056e-16
C79 (\11\:COb VSS) capacitor c=5.18265e-17
C80 (\11\:CI VSS) capacitor c=1.57591e-16
C81 (\13\:CI VSS) capacitor c=7.28932e-17
C82 (\13\:B VSS) capacitor c=1.12694e-16
C83 (\14\:B VSS) capacitor c=1.0967e-16
C84 (\15\:B VSS) capacitor c=1.2301e-16
C85 (\16\:B VSS) capacitor c=6.8993e-17
C86 (\13\:A VSS) capacitor c=1.77462e-16
C87 (\14\:A VSS) capacitor c=9.10753e-17
C88 (\15\:A VSS) capacitor c=1.29669e-16
C89 (\16\:A VSS) capacitor c=1.4608e-16
C90 (\6\:Sb VSS) capacitor c=1.73599e-16
C91 (\5\:VDD VSS) capacitor c=8.71484e-18
C92 (\11\:VDD VSS) capacitor c=2.31931e-18
Rk20 (\13\:A A) resistor r=0.4796 c=0
Rk19 (\13\:A \14\:A) resistor r=0.7021 c=0
Rk21 (A \15\:A) resistor r=0.2359 c=0
Rk22 (\15\:A \16\:A) resistor r=0.7149 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.3402 c=0
Rk28 (\4\:VSS \5\:VSS) resistor r=0.2812 c=0
Rk29 (\5\:VSS \6\:VSS) resistor r=0.1204 c=0
Rk30 (\6\:VSS \7\:VSS) resistor r=0.1003 c=0
Rk31 (\7\:VSS \8\:VSS) resistor r=0.3515 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.1087 c=0
Rk33 (\7\:VSS \12\:VSS) resistor r=0.189 c=0
Rk35 (\13\:VSS VSS) resistor r=0.1026 c=0
Rk34 (\8\:VSS \13\:VSS) resistor r=0.1988 c=0
Rk36 (\8\:VSS \15\:VSS) resistor r=0.2415 c=0
Rk37 (\13\:VSS \17\:VSS) resistor r=0.4242 c=0
Rk15 (\13\:B B) resistor r=0.5524 c=0
Rk16 (B \14\:B) resistor r=0.2651 c=0
Rk17 (\14\:B \15\:B) resistor r=0.5802 c=0
Rk18 (\15\:B \16\:B) resistor r=0.3774 c=0
Rk1 (\2\:CO CO) resistor r=0.168 c=0
Rk2 (CO \4\:CO) resistor r=0.3521 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.4917 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.3025 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.09898 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.08523 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.2159 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.1857 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.06513 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.09779 c=0
Rk47 (\12\:VDD VDD) resistor r=0.05 c=0
Rk46 (\11\:VDD \12\:VDD) resistor r=0.05256 c=0
Rk48 (\5\:VDD \14\:VDD) resistor r=0.1133 c=0
Rk49 (\7\:VDD \16\:VDD) resistor r=0.1188 c=0
Rk50 (\9\:VDD \18\:VDD) resistor r=0.1154 c=0
Rk51 (\11\:VDD \20\:VDD) resistor r=0.1706 c=0
Rk25 (\2\:S S) resistor r=0.1218 c=0
Rk26 (S \4\:S) resistor r=0.5035 c=0
Rk12 (\11\:CI CI) resistor r=0.8769 c=0
Rk13 (CI \12\:CI) resistor r=0.002725 c=0
Rk14 (CI \13\:CI) resistor r=0.364 c=0
Rk7 (\8\:COb \9\:COb) resistor r=1.113 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.6087 c=0
Rk9 (\10\:COb \11\:COb) resistor r=0.2346 c=0
Rk10 (\9\:COb \13\:COb) resistor r=0.0716 c=0
Rk11 (\10\:COb \15\:COb) resistor r=1.0491 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.5995 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.3718 c=0
Rk23 (\5\:Sb \6\:Sb) resistor r=0.7375 c=0
Rk24 (\6\:Sb \8\:Sb) resistor r=0.634 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.338 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.3676 c=0
Rl28 (\11\:A \12\:A) resistor r=150.223 c=0
Rl27 (\10\:A \11\:A) resistor r=81.8672 c=0
Rl20 (\8\:A \9\:A) resistor r=162.694 c=0
Rl19 (\7\:A \8\:A) resistor r=72.3097 c=0
Rl13 (\4\:A \5\:A) resistor r=74.2328 c=0
Rl14 (\5\:A \6\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=74.2328 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl26 (\11\:B \12\:B) resistor r=116.54 c=0
Rl25 (\10\:B \11\:B) resistor r=126.234 c=0
Rl17 (\7\:B \8\:B) resistor r=28.079 c=0
Rl18 (\8\:B \9\:B) resistor r=206.925 c=0
Rl11 (\4\:B \5\:B) resistor r=28.079 c=0
Rl12 (\5\:B \6\:B) resistor r=206.925 c=0
Rl6 (\1\:B \2\:B) resistor r=28.079 c=0
Rl7 (\2\:B \3\:B) resistor r=206.925 c=0
Rl24 (\9\:CI \10\:CI) resistor r=214.401 c=0
Rl23 (\8\:CI \9\:CI) resistor r=28.8462 c=0
Rl15 (\5\:CI \6\:CI) resistor r=139.56 c=0
Rl16 (\6\:CI \7\:CI) resistor r=91.4826 c=0
Rl10 (\2\:CI \4\:CI) resistor r=129.649 c=0
Rl9 (\2\:CI \3\:CI) resistor r=123.88 c=0
Rl8 (\1\:CI \2\:CI) resistor r=3.1216 c=0
Rl22 (\6\:COb \7\:COb) resistor r=37.6365 c=0
Rl21 (\5\:COb \6\:COb) resistor r=199.969 c=0
Rl1 (COb \2\:COb) resistor r=2.0213 c=0
Rl3 (\2\:COb \4\:COb) resistor r=49.7141 c=0
Rl2 (\2\:COb \3\:COb) resistor r=113.176 c=0
Rl29 (Sb \2\:Sb) resistor r=56.8672 c=0
Rl30 (\2\:Sb \3\:Sb) resistor r=110.713 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=37.5 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=18.75 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=75 c=0
Rz18 (\3\:VDD \12\:VDD) resistor r=37.5 c=0
Rz8 (\3\:S \4\:S) resistor r=37.5 c=0
Rz6 (\14\:COb \15\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz7 (\4\:Sb \5\:Sb) resistor r=75 c=0
Ry9 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry10 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry11 (\3\:VSS \8\:VSS) resistor r=8.8571 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry8 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry6 (\12\:COb \13\:COb) resistor r=62 c=0
Ry7 (\7\:Sb \8\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\5\:A \13\:A) resistor r=45 c=0
Rx11 (\2\:A \14\:A) resistor r=45 c=0
Rx12 (\8\:A \15\:A) resistor r=45 c=0
Rx13 (\11\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\9\:CI \11\:CI) resistor r=45 c=0
Rx4 (\6\:CI \12\:CI) resistor r=45 c=0
Rx5 (\1\:CI \13\:CI) resistor r=45 c=0
Rx1 (\6\:COb \8\:COb) resistor r=45 c=0
Rx2 (COb \11\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.22e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.23846e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn2 (\3\:n2 \3\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=1.93e-14 ps=9.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n2 \3\:B \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.38103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\14\:COb \3\:CI n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43103e-07 sb=1.95e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\14\:COb \6\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.48103e-07 sb=1.745e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \6\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=8.7e-15 ps=9.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.53103e-07 sb=1.64e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \7\:CI \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0581e-06 sb=1.435e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \9\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2631e-06 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5281e-06 sb=9.65e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn8 (\4\:Sb \5\:COb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7331e-06 sb=7.6e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9381e-06 sb=5.55e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn10 (n7 \10\:B n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=6.83173 scb=0.00357784 scc=2.82929e-05 \
        m=(1)
mn9 (n6 \10\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn13 (\3\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mp2 (\3\:n3 \1\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.91e-14 ps=1.59e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35349e-07 sb=2e-06 sd=160n sca=14.1415 \
        scb=0.0126578 scc=0.000426771 m=(1)
mp3 (n3 \1\:B \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.44e-14 ps=1.59e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.30349e-07 sb=2e-06 sd=160n sca=13.1633 \
        scb=0.0118398 scc=0.00042523 m=(1)
mp4 (\12\:COb \4\:CI n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35349e-07 sb=1.95e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\12\:COb \4\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.40349e-07 sb=1.745e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (n1 \4\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45349e-07 sb=1.64e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (\3\:n5 \5\:CI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=3.44e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05035e-06 sb=1.435e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\3\:n5 \7\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25535e-06 sb=1.23e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=1e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp8 (\7\:Sb \7\:COb n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69035e-06 sb=7.95e-07 sd=160n sca=12.9421 \
        scb=0.0117495 scc=0.000425199 m=(1)
mp11 (\7\:Sb \10\:CI n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89535e-06 sb=5.9e-07 sd=160n sca=13.7253 \
        scb=0.0122307 scc=0.000425663 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.99593e-06 sb=4.85e-07 sd=160n sca=14.4668 scb=0.0130588 \
        scc=0.000428492 m=(1)
mp9 (n8 \12\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.29e-14 ps=1.17e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.8e-07 sd=160n sca=15.7217 scb=0.0149728 \
        scc=0.00044748 m=(1)
mp13 (\1\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=5.46e-14 ps=1.17e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15032e-06 sb=1.4e-07 sd=160n sca=26.7686 \
        scb=0.0307018 scc=0.00196241 m=(1)
ends ADDFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 12:54:43 2012 )
// Library name: gsclib045
// Cell name: ACHCONX2
// View name: extracted

simulator lang=spectre

subckt ACHCONX2 A B CI CON VDD VSS
mp6 (\13\:n15 \1\:A VDD VDD) g45p1svt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=1.1335e-13 ad=6.16e-14 ps=1.85e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.10695e-06 sd=160n sca=41.5694 \
        scb=0.0360757 scc=0.00426513 m=(2)
C1 (B VSS) capacitor c=3.84996e-17
C2 (CON VSS) capacitor c=5.71461e-17
C3 (VDD VSS) capacitor c=5.37498e-16
C4 (CI VSS) capacitor c=2.83138e-17
C5 (n15 VSS) capacitor c=1.06856e-16
C6 (n11 VSS) capacitor c=2.82705e-16
C7 (n13 VSS) capacitor c=6.89787e-17
C8 (n9 VSS) capacitor c=1.27401e-16
C9 (n10 VSS) capacitor c=1.11299e-16
C10 (n12 VSS) capacitor c=1.117e-16
C11 (net0370 VSS) capacitor c=2.8264e-17
C12 (\1\:CI VSS) capacitor c=1.18586e-16
C13 (\23\:B VSS) capacitor c=1.6616e-16
C14 (\13\:n13 VSS) capacitor c=1.57962e-16
C15 (\16\:B VSS) capacitor c=1.40523e-16
C16 (\1\:B VSS) capacitor c=1.03851e-16
C17 (\1\:A VSS) capacitor c=1.15027e-16
C18 (\4\:n10 VSS) capacitor c=1.02774e-16
C19 (\20\:B VSS) capacitor c=8.81625e-17
C20 (\10\:B VSS) capacitor c=8.1211e-17
C21 (\6\:n10 VSS) capacitor c=3.73557e-17
C22 (\5\:n9 VSS) capacitor c=3.04074e-17
C23 (\22\:B VSS) capacitor c=1.90527e-17
C24 (\15\:n13 VSS) capacitor c=3.77125e-17
C25 (\3\:n13 VSS) capacitor c=4.52938e-17
C26 (\14\:B VSS) capacitor c=2.88535e-17
C27 (\13\:B VSS) capacitor c=4.39349e-17
C28 (\8\:n13 VSS) capacitor c=1.68756e-17
C29 (\3\:B VSS) capacitor c=1.56683e-16
C30 (\4\:n15 VSS) capacitor c=1.23786e-17
C31 (\4\:A VSS) capacitor c=1.12448e-17
C32 (\1\:VDD VSS) capacitor c=1.76917e-17
C33 (\4\:net0370 VSS) capacitor c=6.18716e-17
C34 (\8\:n12 VSS) capacitor c=9.26022e-17
C35 (\6\:n12 VSS) capacitor c=1.24265e-16
C36 (\9\:n9 VSS) capacitor c=3.30881e-16
C37 (\8\:n11 VSS) capacitor c=6.17492e-16
C38 (\10\:n10 VSS) capacitor c=3.03585e-16
C39 (\12\:n10 VSS) capacitor c=1.48969e-16
C40 (\11\:n9 VSS) capacitor c=3.05122e-16
C41 (\22\:n15 VSS) capacitor c=3.56424e-16
C42 (\20\:n13 VSS) capacitor c=7.3733e-17
C43 (\15\:n11 VSS) capacitor c=2.46703e-16
C44 (\13\:n15 VSS) capacitor c=5.15734e-17
C45 (\3\:VDD VSS) capacitor c=2.67804e-16
C46 (\9\:net0370 VSS) capacitor c=3.12475e-17
C47 (\1\:CON VSS) capacitor c=2.30084e-16
C48 (\7\:net0370 VSS) capacitor c=6.00214e-17
C49 (\4\:n12 VSS) capacitor c=5.78766e-17
C50 (\16\:n9 VSS) capacitor c=1.90557e-16
C51 (\16\:n10 VSS) capacitor c=1.13288e-16
C52 (\15\:n15 VSS) capacitor c=2.76431e-16
C53 (\14\:n10 VSS) capacitor c=1.22822e-16
C54 (\13\:n9 VSS) capacitor c=1.06007e-16
C55 (\18\:n13 VSS) capacitor c=8.52438e-17
C56 (\17\:n11 VSS) capacitor c=4.15383e-17
C57 (\11\:n15 VSS) capacitor c=1.41323e-17
C58 (\4\:n13 VSS) capacitor c=1.67594e-16
C59 (\6\:n13 VSS) capacitor c=1.1129e-16
C60 (\8\:A VSS) capacitor c=4.45239e-17
C61 (\10\:A VSS) capacitor c=2.0757e-17
C62 (\11\:A VSS) capacitor c=2.10204e-17
C63 (\9\:n15 VSS) capacitor c=2.23167e-17
C64 (\10\:n15 VSS) capacitor c=3.73149e-17
C65 (\3\:n9 VSS) capacitor c=1.24034e-16
C66 (\29\:B VSS) capacitor c=4.39417e-17
C67 (\17\:n13 VSS) capacitor c=5.81718e-17
C68 (\30\:B VSS) capacitor c=7.20973e-17
C69 (\31\:B VSS) capacitor c=6.59351e-17
C70 (\21\:n15 VSS) capacitor c=1.5741e-16
C71 (\24\:n15 VSS) capacitor c=2.05081e-17
C72 (\32\:B VSS) capacitor c=9.00081e-17
C73 (\33\:B VSS) capacitor c=8.88974e-17
C74 (\22\:n13 VSS) capacitor c=8.59559e-17
C75 (\23\:n13 VSS) capacitor c=7.76006e-17
C76 (\34\:B VSS) capacitor c=6.86602e-17
C77 (\35\:B VSS) capacitor c=5.85299e-17
C78 (\15\:n9 VSS) capacitor c=1.41024e-16
C79 (\3\:n12 VSS) capacitor c=9.69436e-17
C80 (\8\:n10 VSS) capacitor c=7.30962e-17
C81 (\9\:n10 VSS) capacitor c=2.3917e-16
C82 (\8\:CON VSS) capacitor c=2.04268e-16
C83 (\3\:net0370 VSS) capacitor c=7.4813e-17
C84 (\6\:net0370 VSS) capacitor c=6.35413e-17
C85 (\7\:CI VSS) capacitor c=5.11125e-17
C86 (\8\:VDD VSS) capacitor c=5.71963e-17
Rk9 (B \29\:B) resistor r=0.02495 c=0
Rk12 (\30\:B \31\:B) resistor r=0.3431 c=0
Rk20 (\32\:B \33\:B) resistor r=0.5279 c=0
Rk32 (\34\:B \35\:B) resistor r=0.3668 c=0
Rk47 (\1\:CON CON) resistor r=0.3565 c=0
Rk48 (CON \8\:CON) resistor r=0.1487 c=0
Rk1 (\8\:A \9\:A) resistor r=0.004315 c=0
Rk2 (A \10\:A) resistor r=0.002981 c=0
Rk3 (\8\:A \10\:A) resistor r=0.131 c=0
Rk4 (A \11\:A) resistor r=0.004237 c=0
Rk5 (\10\:A \11\:A) resistor r=0.003925 c=0
Rk83 (\1\:VSS \7\:VSS) resistor r=0.3449 c=0
Rk84 (\7\:VSS \8\:VSS) resistor r=0.4377 c=0
Rk87 (\10\:VSS VSS) resistor r=1.2036 c=0
Rk86 (\8\:VSS \10\:VSS) resistor r=0.2471 c=0
Rk64 (\1\:VDD \7\:VDD) resistor r=0.3458 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.4377 c=0
Rk68 (\10\:VDD VDD) resistor r=1.2036 c=0
Rk67 (\8\:VDD \10\:VDD) resistor r=0.2471 c=0
Rk58 (\7\:CI CI) resistor r=0.03134 c=0
Rk57 (\6\:CI \7\:CI) resistor r=0.001404 c=0
Rk6 (\9\:n15 \10\:n15) resistor r=0.1936 c=0
Rk7 (\10\:n15 \12\:n15) resistor r=0.14 c=0
Rk8 (\10\:n15 \14\:n15) resistor r=0.2545 c=0
Rk16 (\21\:n15 \22\:n15) resistor r=0.9409 c=0
Rk15 (\15\:n15 \21\:n15) resistor r=0.8016 c=0
Rk17 (\21\:n15 \24\:n15) resistor r=0.1413 c=0
Rk27 (n11 \9\:n11) resistor r=0.584 c=0
Rk30 (\8\:n11 \16\:n11) resistor r=2.0288 c=0
Rk31 (\16\:n11 \18\:n11) resistor r=0.2864 c=0
Rk10 (\17\:n13 \19\:n13) resistor r=0.3752 c=0
Rk11 (\19\:n13 \21\:n13) resistor r=0.359 c=0
Rk21 (\22\:n13 \23\:n13) resistor r=0.4623 c=0
Rk22 (\10\:n9 \12\:n9) resistor r=1.6127 c=0
Rk23 (\12\:n9 \14\:n9) resistor r=0.7132 c=0
Rk33 (\15\:n9 \17\:n9) resistor r=1.0916 c=0
Rk34 (\17\:n9 \18\:n9) resistor r=0.369 c=0
Rk39 (\8\:n10 \9\:n10) resistor r=0.307 c=0
Rk40 (\9\:n10 \11\:n10) resistor r=1.6899 c=0
Rk41 (\11\:n10 \13\:n10) resistor r=0.7903 c=0
Rk42 (\13\:n10 \15\:n10) resistor r=0.3355 c=0
Rk43 (\15\:n10 \17\:n10) resistor r=0.5938 c=0
Rk35 (\2\:n12 \3\:n12) resistor r=0.678 c=0
Rk36 (\3\:n12 \5\:n12) resistor r=0.2445 c=0
Rk37 (\3\:n12 \7\:n12) resistor r=0.1129 c=0
Rk38 (\9\:n12 \10\:n12) resistor r=0.6006 c=0
Rk52 (\2\:net0370 \3\:net0370) resistor r=0.218 c=0
Rk53 (\3\:net0370 \5\:net0370) resistor r=0.3714 c=0
Rk54 (\3\:net0370 \6\:net0370) resistor r=0.3912 c=0
Rk55 (\6\:net0370 \8\:net0370) resistor r=0.2749 c=0
Rk56 (\6\:net0370 \10\:net0370) resistor r=0.2546 c=0
Rl44 (\16\:B \20\:B) resistor r=277.645 c=0
Rl46 (\22\:B \20\:B) resistor r=33.8482 c=0
Rl25 (\14\:B \10\:B) resistor r=19.1561 c=0
Rl24 (\13\:B \10\:B) resistor r=16.4898 c=0
Rl15 (\3\:B \1\:B) resistor r=194.964 c=0
Rl3 (\1\:A \4\:A) resistor r=4.3693 c=0
Rl11 (n15 \6\:n15) resistor r=2.9484 c=0
Rl9 (n15 \4\:n15) resistor r=4.8851 c=0
Rl39 (\13\:n13 \15\:n13) resistor r=28.1587 c=0
Rl28 (\3\:n13 n13) resistor r=33.8482 c=0
Rl29 (\4\:n13 \3\:n13) resistor r=194.748 c=0
Rl33 (\6\:n13 \8\:n13) resistor r=13.7341 c=0
Rl31 (\6\:n13 \4\:n13) resistor r=154.981 c=0
Rl55 (\3\:n9 n9) resistor r=156.469 c=0
Rl57 (\3\:n9 \5\:n9) resistor r=101.848 c=0
Rl62 (\6\:n10 \4\:n10) resistor r=15.3298 c=0
Rz26 (VDD \3\:VDD) resistor r=5 c=0
Rz22 (\1\:VDD \3\:VDD) resistor r=25 c=0
Rz23 (\7\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz24 (\10\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\12\:n15 \11\:n15) resistor r=75 c=0
Rz10 (\18\:n11 \17\:n11) resistor r=75 c=0
Rz2 (\19\:n13 \18\:n13) resistor r=75 c=0
Rz6 (\14\:n9 \13\:n9) resistor r=75 c=0
Rz11 (\17\:n9 \16\:n9) resistor r=75 c=0
Rz14 (\15\:n10 \14\:n10) resistor r=75 c=0
Rz15 (\17\:n10 \16\:n10) resistor r=75 c=0
Rz12 (\2\:n12 n12) resistor r=75 c=0
Rz13 (\5\:n12 \4\:n12) resistor r=75 c=0
Rz19 (\8\:net0370 \7\:net0370) resistor r=75 c=0
Rz20 (\10\:net0370 \9\:net0370) resistor r=75 c=0
Ry38 (VSS \3\:VSS) resistor r=4.1333 c=0
Ry32 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry34 (\7\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry35 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\14\:n15 \13\:n15) resistor r=20.6667 c=0
Ry8 (\9\:n11 \8\:n11) resistor r=62 c=0
Ry12 (\16\:n11 \15\:n11) resistor r=31 c=0
Ry2 (\21\:n13 \20\:n13) resistor r=62 c=0
Ry6 (\10\:n9 \9\:n9) resistor r=62 c=0
Ry7 (\12\:n9 \11\:n9) resistor r=62 c=0
Ry13 (\18\:n9 \9\:n9) resistor r=62 c=0
Ry17 (\11\:n10 \10\:n10) resistor r=62 c=0
Ry18 (\13\:n10 \12\:n10) resistor r=62 c=0
Ry14 (\7\:n12 \6\:n12) resistor r=62 c=0
Ry15 (\9\:n12 \8\:n12) resistor r=62 c=0
Ry16 (\10\:n12 \6\:n12) resistor r=62 c=0
Ry22 (\2\:net0370 net0370) resistor r=62 c=0
Ry23 (\5\:net0370 \4\:net0370) resistor r=62 c=0
Rx3 (\29\:B \3\:B) resistor r=45 c=0
Rx5 (\30\:B \13\:B) resistor r=45 c=0
Rx6 (\31\:B \1\:B) resistor r=45 c=0
Rx8 (\32\:B \14\:B) resistor r=45 c=0
Rx9 (\33\:B \16\:B) resistor r=45 c=0
Rx12 (\34\:B \23\:B) resistor r=22.5 c=0
Rx13 (\35\:B \22\:B) resistor r=45 c=0
Rx1 (\9\:A \4\:A) resistor r=45 c=0
Rx17 (\6\:CI \1\:CI) resistor r=22.5 c=0
Rx2 (\9\:n15 \4\:n15) resistor r=45 c=0
Rx7 (\24\:n15 \6\:n15) resistor r=45 c=0
Rx4 (\17\:n13 \8\:n13) resistor r=45 c=0
Rx10 (\22\:n13 \3\:n13) resistor r=45 c=0
Rx11 (\23\:n13 \15\:n13) resistor r=45 c=0
Rx14 (\15\:n9 \5\:n9) resistor r=45 c=0
Rx15 (\8\:n10 \6\:n10) resistor r=45 c=0
Rx16 (\9\:n10 n10) resistor r=45 c=0
mn6 (\11\:n15 \1\:A VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=8.322e-14 ad=3.12e-14 ps=1.55e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.28513e-06 sd=160n sca=20.3563 \
        scb=0.0203131 scc=0.00210921 m=(2)
mn5 (\17\:n11 n15 VSS VSS) g45n1svt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=9.539e-14 ad=3.41e-14 ps=1.685e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.05e-06 sd=160n sca=22.6209 \
        scb=0.0224923 scc=0.0025451 m=(2)
mn11_1__rcx (\18\:n13 \3\:B VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=9.151e-14 ad=4.29e-14 ps=1.635e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04987e-06 sb=4.35e-07 sd=160n sca=20.3563 \
        scb=0.0203131 scc=0.00210921 m=(2)
mn3_1__rcx (\13\:n9 \6\:n13 \15\:n15 VSS) g45n1svt w=(1.95e-07) l=4.5e-08 \
        nf=1 as=3.982e-14 ad=4.95e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.65e-07 sd=160n sca=7.87233 \
        scb=0.00543612 scc=8.31178e-05 m=(2)
mn2 (\15\:n15 \10\:B \14\:n10 VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.95e-14 ad=4.163e-14 ps=9.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=4.35e-07 sd=160n sca=7.87233 \
        scb=0.00543612 scc=8.31178e-05 m=(2)
mn1_1__rcx (\16\:n10 n13 n11 VSS) g45n1svt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=5.772e-14 ad=3.71e-14 ps=1.1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.165e-06 sd=160n sca=9.18993 \
        scb=0.00765118 scc=0.000170292 m=(2)
mn4 (n11 \20\:B \16\:n9 VSS) g45n1svt w=(1.55e-07) l=4.5e-08 nf=1 \
        as=3.71e-14 ad=5.772e-14 ps=8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=4.35e-07 sd=160n sca=9.18993 \
        scb=0.00765118 scc=0.000170292 m=(2)
mn7 (\4\:n12 \23\:B \8\:VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=4.29e-14 ps=1.22e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=9.4847 \
        scb=0.00814735 scc=0.000215444 m=(2)
mn9 (n12 \3\:n9 \1\:CON VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.522e-14 ad=4.59e-14 ps=9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.03e-06 sd=160n sca=10.7156 \
        scb=0.0100774 scc=0.000358522 m=(2)
mn8_1__rcx (\7\:net0370 \4\:n10 \1\:CON VSS) g45n1svt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=4.522e-14 ad=6.217e-14 ps=9e-07 pd=1.07e-06 \
        nrd=1.16667 nrs=1.16667 sa=7e-07 sb=5e-07 sd=160n sca=10.7156 \
        scb=0.0100774 scc=0.000358522 m=(2)
mn10_1__rcx (\9\:net0370 \1\:CI \1\:VSS VSS) g45n1svt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=7.635e-14 ad=3.12e-14 ps=1.45e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=16.9754 \
        scb=0.0175701 scc=0.00143458 m=(2)
mp5 (\15\:n11 n15 VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.283e-13 ad=6.24e-14 ps=1.965e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=9.88846e-07 sd=160n sca=41.048 \
        scb=0.0261997 scc=0.00496428 m=(2)
mp11 (\20\:n13 \3\:B VDD VDD) g45p1svt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=1.182e-13 ad=9.19e-14 ps=1.855e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.02727e-07 sb=3.93701e-07 sd=160n sca=30.7686 \
        scb=0.0203743 scc=0.00340396 m=(2)
mp3_1__rcx (\11\:n9 \1\:B \22\:n15 VDD) g45p1svt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=5.775e-14 ad=6.737e-14 ps=1.07e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp2 (\22\:n15 \4\:n13 \12\:n10 VDD) g45p1svt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=9.73e-14 ad=5.775e-14 ps=1.42e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.05e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp1_1__rcx (\10\:n10 \16\:B \8\:n11 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.4e-14 ad=5.72e-14 ps=1.465e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.27788e-07 sd=160n sca=16.2062 \
        scb=0.015669 scc=0.00110578 m=(2)
mp4_1__rcx (\8\:n11 \13\:n13 \9\:n9 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.035e-13 ad=8.07e-14 ps=1.51e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.87885e-07 sb=5.3e-07 sd=160n sca=12.7937 \
        scb=0.0116617 scc=0.000458138 m=(2)
mp7 (\6\:n12 \23\:B \8\:VDD VDD) g45p1svt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=1.0265e-13 ad=9.13e-14 ps=1.73e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.35e-07 sd=160n sca=21.496 \
        scb=0.0176393 scc=0.00214786 m=(2)
mp9 (\8\:n12 n10 \8\:CON VDD) g45p1svt w=(3.85e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=6.16e-14 ps=1.07e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp8_1__rcx (\4\:net0370 n9 \8\:CON VDD) g45p1svt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=6.353e-14 ad=8.47e-14 ps=1.1e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4.35e-07 sd=160n sca=15.5058 \
        scb=0.0140133 scc=0.00103524 m=(2)
mp10_1__rcx (net0370 \1\:CI \1\:VDD VDD) g45p1svt w=(3.85e-07) l=4.5e-08 \
        nf=1 as=8.345e-14 ad=6.16e-14 ps=1.41e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=13.8213 \
        scb=0.011888 scc=0.000231499 m=(2)
ends ACHCONX2
// End of subcircuit definition.

// Generated for: spectre (May  9 12:55:21 2012 )
// Library name: gsclib045
// Cell name: ADDFHX1
// View name: extracted

simulator lang=spectre

subckt ADDFHX1 A B CI CO S VDD VSS
mp12 (\1\:CO COb \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=38.6307 \
        scb=0.0321643 scc=0.00380145 m=(1)
C1 (A VSS) capacitor c=3.65466e-17
C2 (B VSS) capacitor c=6.06227e-17
C3 (CO VSS) capacitor c=6.74237e-17
C4 (VDD VSS) capacitor c=2.34466e-16
C5 (S VSS) capacitor c=2.26934e-17
C6 (CI VSS) capacitor c=3.3119e-17
C7 (COb VSS) capacitor c=3.15516e-17
C8 (n2 VSS) capacitor c=8.77274e-17
C9 (n4 VSS) capacitor c=7.18454e-17
C10 (Sb VSS) capacitor c=3.38611e-17
C11 (n7 VSS) capacitor c=2.00123e-18
C12 (n6 VSS) capacitor c=2.33477e-18
C13 (n3 VSS) capacitor c=6.66478e-17
C14 (n1 VSS) capacitor c=2.10879e-18
C15 (n5 VSS) capacitor c=8.20243e-17
C16 (n9 VSS) capacitor c=4.257e-18
C17 (n8 VSS) capacitor c=2.25667e-18
C18 (\10\:A VSS) capacitor c=7.29475e-17
C19 (\11\:B VSS) capacitor c=6.24937e-17
C20 (\11\:CI VSS) capacitor c=7.43936e-17
C21 (\6\:COb VSS) capacitor c=3.43225e-17
C22 (\9\:A VSS) capacitor c=6.43396e-17
C23 (\10\:B VSS) capacitor c=5.31937e-17
C24 (\7\:CI VSS) capacitor c=7.47828e-17
C25 (\6\:A VSS) capacitor c=8.50631e-17
C26 (\7\:B VSS) capacitor c=6.42909e-17
C27 (\1\:CI VSS) capacitor c=4.69457e-17
C28 (\1\:B VSS) capacitor c=4.41219e-17
C29 (\1\:A VSS) capacitor c=5.38534e-17
C30 (\3\:Sb VSS) capacitor c=2.58842e-17
C31 (\12\:A VSS) capacitor c=6.1801e-17
C32 (\13\:B VSS) capacitor c=1.0662e-16
C33 (\8\:CI VSS) capacitor c=5.81276e-17
C34 (\4\:COb VSS) capacitor c=5.74031e-17
C35 (\7\:A VSS) capacitor c=5.1079e-17
C36 (\8\:B VSS) capacitor c=6.05331e-17
C37 (\5\:CI VSS) capacitor c=3.37099e-17
C38 (\4\:A VSS) capacitor c=7.42475e-17
C39 (\4\:B VSS) capacitor c=9.5906e-17
C40 (\3\:CI VSS) capacitor c=4.22663e-17
C41 (\3\:B VSS) capacitor c=5.13155e-17
C42 (\3\:A VSS) capacitor c=3.89534e-17
C43 (\3\:COb VSS) capacitor c=2.17231e-17
C44 (\2\:Sb VSS) capacitor c=2.14858e-17
C45 (\11\:A VSS) capacitor c=5.28313e-17
C46 (\12\:B VSS) capacitor c=7.42695e-17
C47 (\10\:CI VSS) capacitor c=6.06293e-17
C48 (\7\:COb VSS) capacitor c=2.17597e-17
C49 (\8\:A VSS) capacitor c=5.18594e-17
C50 (\9\:B VSS) capacitor c=5.45441e-17
C51 (\6\:CI VSS) capacitor c=5.77139e-17
C52 (\5\:A VSS) capacitor c=6.93078e-17
C53 (\6\:B VSS) capacitor c=1.45171e-17
C54 (\4\:CI VSS) capacitor c=3.65201e-17
C55 (\2\:B VSS) capacitor c=3.39323e-17
C56 (\2\:A VSS) capacitor c=2.33915e-17
C57 (\2\:COb VSS) capacitor c=1.52276e-17
C58 (\3\:S VSS) capacitor c=4.5203e-17
C59 (\11\:VDD VSS) capacitor c=3.86996e-17
C60 (\9\:Sb VSS) capacitor c=7.51183e-17
C61 (\11\:Sb VSS) capacitor c=4.7557e-17
C62 (\13\:VDD VSS) capacitor c=1.40476e-17
C63 (\3\:n5 VSS) capacitor c=7.21537e-17
C64 (\15\:VDD VSS) capacitor c=1.52958e-17
C65 (\9\:COb VSS) capacitor c=1.25799e-16
C66 (\12\:COb VSS) capacitor c=1.76031e-17
C67 (\3\:n3 VSS) capacitor c=9.50741e-17
C68 (\17\:VDD VSS) capacitor c=1.86787e-17
C69 (\1\:CO VSS) capacitor c=8.60889e-17
C70 (\19\:VDD VSS) capacitor c=4.11511e-17
C71 (\1\:VDD VSS) capacitor c=8.59631e-17
C72 (\1\:S VSS) capacitor c=4.01084e-17
C73 (\4\:Sb VSS) capacitor c=8.53146e-17
C74 (\6\:Sb VSS) capacitor c=5.29666e-17
C75 (\3\:n4 VSS) capacitor c=8.48443e-17
C76 (\16\:COb VSS) capacitor c=5.59128e-17
C77 (\19\:COb VSS) capacitor c=2.58375e-17
C78 (\3\:n2 VSS) capacitor c=7.90429e-17
C79 (\3\:CO VSS) capacitor c=4.27816e-17
C80 (\2\:CI VSS) capacitor c=2.67469e-17
C81 (\5\:B VSS) capacitor c=4.44495e-17
C82 (\5\:COb VSS) capacitor c=5.30196e-17
C83 (\8\:COb VSS) capacitor c=1.64008e-16
C84 (\11\:COb VSS) capacitor c=9.68125e-17
C85 (\14\:COb VSS) capacitor c=1.83876e-16
C86 (\15\:COb VSS) capacitor c=1.44178e-16
C87 (\18\:COb VSS) capacitor c=5.51493e-17
C88 (\12\:CI VSS) capacitor c=1.46443e-16
C89 (\13\:CI VSS) capacitor c=1.73891e-16
C90 (\14\:CI VSS) capacitor c=6.91488e-17
C91 (\14\:B VSS) capacitor c=8.74937e-17
C92 (\15\:B VSS) capacitor c=7.44824e-17
C93 (\16\:B VSS) capacitor c=1.85997e-16
C94 (\17\:B VSS) capacitor c=1.39774e-16
C95 (\13\:A VSS) capacitor c=1.1629e-16
C96 (\14\:A VSS) capacitor c=1.95194e-16
C97 (\15\:A VSS) capacitor c=2.0647e-16
C98 (\16\:A VSS) capacitor c=1.27752e-16
C99 (\8\:Sb VSS) capacitor c=1.73084e-16
C100 (\5\:VDD VSS) capacitor c=7.66751e-18
C101 (\6\:VDD VSS) capacitor c=2.25416e-17
C102 (\8\:VDD VSS) capacitor c=1.91051e-17
C103 (\9\:VDD VSS) capacitor c=1.20473e-17
Rk22 (A \13\:A) resistor r=0.05405 c=0
Rk23 (\13\:A \14\:A) resistor r=0.8074 c=0
Rk24 (\14\:A \15\:A) resistor r=0.5547 c=0
Rk25 (\15\:A \16\:A) resistor r=0.8886 c=0
Rk46 (\2\:VSS \3\:VSS) resistor r=0.1578 c=0
Rk47 (\3\:VSS \4\:VSS) resistor r=0.2932 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.3082 c=0
Rk49 (\5\:VSS \6\:VSS) resistor r=0.09258 c=0
Rk50 (\6\:VSS \7\:VSS) resistor r=0.1126 c=0
Rk51 (\7\:VSS \8\:VSS) resistor r=0.4887 c=0
Rk52 (\8\:VSS \9\:VSS) resistor r=0.0816 c=0
Rk54 (\10\:VSS VSS) resistor r=0.03466 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.4324 c=0
Rk56 (\3\:VSS \13\:VSS) resistor r=0.1492 c=0
Rk57 (\5\:VSS \15\:VSS) resistor r=0.1359 c=0
Rk58 (\7\:VSS \17\:VSS) resistor r=0.1839 c=0
Rk59 (\9\:VSS \19\:VSS) resistor r=0.0433 c=0
Rk60 (\10\:VSS \21\:VSS) resistor r=0.274 c=0
Rk18 (\14\:B B) resistor r=0.3954 c=0
Rk19 (B \15\:B) resistor r=0.06271 c=0
Rk20 (\15\:B \16\:B) resistor r=0.5018 c=0
Rk21 (\16\:B \17\:B) resistor r=0.8662 c=0
Rk1 (\2\:CO CO) resistor r=0.4916 c=0
Rk2 (CO \4\:CO) resistor r=0.2015 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.1578 c=0
Rk33 (\3\:VDD \4\:VDD) resistor r=0.2932 c=0
Rk34 (\4\:VDD \5\:VDD) resistor r=0.3007 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.2344 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.3649 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.1819 c=0
Rk39 (\9\:VDD VDD) resistor r=0.03466 c=0
Rk38 (\8\:VDD \9\:VDD) resistor r=0.4324 c=0
Rk41 (\3\:VDD \12\:VDD) resistor r=0.1959 c=0
Rk42 (\5\:VDD \14\:VDD) resistor r=0.07381 c=0
Rk43 (\6\:VDD \16\:VDD) resistor r=0.0433 c=0
Rk44 (\8\:VDD \18\:VDD) resistor r=0.0433 c=0
Rk45 (\9\:VDD \20\:VDD) resistor r=0.3385 c=0
Rk30 (S \2\:S) resistor r=0.07795 c=0
Rk31 (\2\:S \4\:S) resistor r=0.3675 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8837 c=0
Rk17 (\14\:CI CI) resistor r=0.01639 c=0
Rk16 (\13\:CI \14\:CI) resistor r=0.4688 c=0
Rk7 (\8\:COb \10\:COb) resistor r=1.1562 c=0
Rk8 (\10\:COb \11\:COb) resistor r=0.1576 c=0
Rk9 (\11\:COb \13\:COb) resistor r=0.04526 c=0
Rk10 (\11\:COb \14\:COb) resistor r=1.0324 c=0
Rk11 (\14\:COb \15\:COb) resistor r=0.9294 c=0
Rk12 (\15\:COb \17\:COb) resistor r=0.337 c=0
Rk13 (\14\:COb \18\:COb) resistor r=0.2088 c=0
Rk14 (\15\:COb \20\:COb) resistor r=0.07456 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.282 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2808 c=0
Rk26 (\5\:Sb \7\:Sb) resistor r=0.2103 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.6086 c=0
Rk28 (\8\:Sb \10\:Sb) resistor r=0.7525 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1267 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.4404 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2356 c=0
Rl29 (\10\:A \11\:A) resistor r=89.6174 c=0
Rl30 (\11\:A \12\:A) resistor r=93.4636 c=0
Rl20 (\8\:A \9\:A) resistor r=83.9406 c=0
Rl19 (\7\:A \8\:A) resistor r=99.2576 c=0
Rl14 (\5\:A \6\:A) resistor r=87.9121 c=0
Rl13 (\4\:A \5\:A) resistor r=100 c=0
Rl3 (\1\:A \2\:A) resistor r=68.4636 c=0
Rl4 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl27 (\11\:B \12\:B) resistor r=24.2328 c=0
Rl28 (\12\:B \13\:B) resistor r=158.848 c=0
Rl18 (\9\:B \10\:B) resistor r=24.2328 c=0
Rl17 (\8\:B \9\:B) resistor r=155.814 c=0
Rl5 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=87.2302 c=0
Rl12 (\5\:B \7\:B) resistor r=34.3295 c=0
Rl10 (\4\:B \5\:B) resistor r=180.049 c=0
Rl11 (\5\:B \6\:B) resistor r=4.3144 c=0
Rl16 (\6\:CI \7\:CI) resistor r=155.814 c=0
Rl15 (\5\:CI \6\:CI) resistor r=24.2328 c=0
Rl7 (\1\:CI \2\:CI) resistor r=99.0311 c=0
Rl8 (\2\:CI \3\:CI) resistor r=53.4552 c=0
Rl9 (\2\:CI \4\:CI) resistor r=89.3546 c=0
Rl26 (\9\:CI \11\:CI) resistor r=158.774 c=0
Rl24 (\8\:CI \9\:CI) resistor r=65.0471 c=0
Rl25 (\9\:CI \10\:CI) resistor r=15.0424 c=0
Rl1 (COb \2\:COb) resistor r=29.5379 c=0
Rl2 (\2\:COb \3\:COb) resistor r=44.9225 c=0
Rl22 (\5\:COb \6\:COb) resistor r=59.5933 c=0
Rl21 (\4\:COb \5\:COb) resistor r=166.989 c=0
Rl23 (\5\:COb \7\:COb) resistor r=79.5158 c=0
Rl31 (Sb \2\:Sb) resistor r=39.6174 c=0
Rl32 (\2\:Sb \3\:Sb) resistor r=24.2328 c=0
Rz15 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz16 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz17 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz19 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz14 (\1\:VDD VDD) resistor r=75 c=0
Rz11 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz13 (\1\:VDD \7\:VDD) resistor r=6.25 c=0
Rz10 (\1\:S \2\:S) resistor r=75 c=0
Rz6 (\16\:COb \17\:COb) resistor r=75 c=0
Rz7 (\19\:COb \20\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry20 (\1\:VSS VSS) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry18 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \8\:VSS) resistor r=6.2 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry10 (\3\:S \4\:S) resistor r=20.6667 c=0
Ry6 (\9\:COb \10\:COb) resistor r=31 c=0
Ry7 (\12\:COb \13\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\2\:B \14\:B) resistor r=45 c=0
Rx7 (\6\:B \15\:B) resistor r=45 c=0
Rx8 (\9\:B \16\:B) resistor r=45 c=0
Rx9 (\12\:B \17\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\7\:COb \8\:COb) resistor r=45 c=0
Rx2 (\2\:COb \18\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \8\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (\3\:n2 \3\:A \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=2.87e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn3 (n2 \3\:B \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=3.28e-14 ps=1.45e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn4 (\19\:COb \3\:CI n2 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn1 (\16\:COb \4\:B n0 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.125e-06 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn0 (n0 \4\:A \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.02e-06 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn7 (\3\:n4 \5\:CI \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.15e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn6 (\3\:n4 \8\:B \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.29e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.1e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn5 (n4 \7\:A \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.29e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn8 (\6\:Sb \4\:COb n4 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=7.4441 \
        scb=0.00471561 scc=6.10752e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.12927e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 as=1.435e-14 \
        ad=1.23e-14 ps=5.5e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.07927e-07 sd=160n sca=8.14041 scb=0.00590656 \
        scc=0.000103269 m=(1)
mn9 (n6 \12\:A \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=1.435e-14 ps=1.42e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2.92927e-07 sd=160n sca=8.14041 \
        scb=0.00590656 scc=0.000103269 m=(1)
mn13 (\1\:S \3\:Sb \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=4.94e-14 ps=1.42e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.70769e-07 sb=1.9e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp2 (n3 \1\:A \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1475e-13 ad=4.34e-14 ps=1.9e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.14113e-07 sd=160n sca=35.8226 \
        scb=0.0234328 scc=0.00420469 m=(1)
mp3 (\3\:n3 \1\:B \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1475e-13 ad=8.525e-14 ps=1.9e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.63306e-07 sb=4.6e-07 sd=160n sca=20.5825 \
        scb=0.0183783 scc=0.00199566 m=(1)
mp4 (\12\:COb \1\:CI \3\:n3 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.525e-14 ad=4.34e-14 ps=1.17e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.83306e-07 sb=1.4e-07 sd=160n sca=20.5825 \
        scb=0.0183783 scc=0.00199566 m=(1)
mp1 (\9\:COb \7\:B n1 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.135e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp0 (n1 \6\:A \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.066e-13 ad=1.86e-14 ps=1.7e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.03e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp7 (\3\:n5 \7\:CI \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.066e-13 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp6 (\3\:n5 \10\:B \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.6e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=4.96e-14 ps=1.7e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=3.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.6e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=3.7e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19355e-07 sb=7.29194e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=2.17e-14 \
        ad=4.185e-14 ps=7.6e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.99355e-07 sb=5.49194e-07 sd=160n sca=13.9217 scb=0.012619 \
        scc=0.000630881 m=(1)
mp9 (n8 \10\:A \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=2.17e-14 ps=1.58e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.14355e-07 sb=4.34194e-07 sd=160n sca=14.3211 \
        scb=0.0128282 scc=0.000631006 m=(1)
mp13 (\3\:S Sb \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=7.41e-14 ps=1.58e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.0359e-07 sb=1.9e-07 sd=160n sca=33.8487 \
        scb=0.0240553 scc=0.00339289 m=(1)
ends ADDFHX1
// End of subcircuit definition.

// Generated for: spectre (May  9 12:55:58 2012 )
// Library name: gsclib045
// Cell name: ADDFHX2
// View name: extracted

simulator lang=spectre

subckt ADDFHX2 A B CI CO S VDD VSS
mp12_1__rcx (\1\:CO COb VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (A VSS) capacitor c=1.25833e-16
C2 (B VSS) capacitor c=2.42834e-17
C3 (VDD VSS) capacitor c=3.58837e-16
C4 (S VSS) capacitor c=7.16355e-18
C5 (CI VSS) capacitor c=3.33398e-17
C6 (COb VSS) capacitor c=8.91798e-17
C7 (n2 VSS) capacitor c=8.77426e-17
C8 (n4 VSS) capacitor c=7.86043e-17
C9 (Sb VSS) capacitor c=5.54079e-17
C10 (n7 VSS) capacitor c=1.84284e-18
C11 (n6 VSS) capacitor c=2.35235e-18
C12 (n3 VSS) capacitor c=5.23609e-17
C13 (n1 VSS) capacitor c=2.08841e-18
C14 (n5 VSS) capacitor c=7.63119e-17
C15 (n9 VSS) capacitor c=4.15246e-18
C16 (n8 VSS) capacitor c=2.89896e-18
C17 (\10\:A VSS) capacitor c=8.23464e-17
C18 (\11\:B VSS) capacitor c=6.9611e-17
C19 (\11\:CI VSS) capacitor c=7.58648e-17
C20 (\10\:COb VSS) capacitor c=4.05376e-17
C21 (\9\:A VSS) capacitor c=7.29083e-17
C22 (\8\:B VSS) capacitor c=5.23617e-17
C23 (\5\:CI VSS) capacitor c=7.60649e-17
C24 (\4\:A VSS) capacitor c=8.96318e-17
C25 (\4\:B VSS) capacitor c=6.42157e-17
C26 (\1\:CI VSS) capacitor c=5.24981e-17
C27 (\1\:B VSS) capacitor c=4.82788e-17
C28 (\1\:A VSS) capacitor c=4.19377e-17
C29 (\12\:A VSS) capacitor c=5.57635e-17
C30 (\13\:B VSS) capacitor c=9.36526e-17
C31 (\8\:CI VSS) capacitor c=5.31266e-17
C32 (\8\:COb VSS) capacitor c=5.20332e-17
C33 (\7\:A VSS) capacitor c=4.61714e-17
C34 (\10\:B VSS) capacitor c=6.80261e-17
C35 (\7\:CI VSS) capacitor c=3.31848e-17
C36 (\6\:A VSS) capacitor c=6.67187e-17
C37 (\7\:B VSS) capacitor c=7.7021e-17
C38 (\3\:CI VSS) capacitor c=2.7156e-17
C39 (\3\:B VSS) capacitor c=5.31678e-17
C40 (\3\:A VSS) capacitor c=3.38172e-17
C41 (\3\:Sb VSS) capacitor c=8.90697e-17
C42 (\11\:A VSS) capacitor c=5.6478e-17
C43 (\12\:B VSS) capacitor c=7.31848e-17
C44 (\10\:CI VSS) capacitor c=2.83997e-17
C45 (\11\:COb VSS) capacitor c=3.29942e-17
C46 (\8\:A VSS) capacitor c=4.21311e-17
C47 (\9\:B VSS) capacitor c=5.7847e-17
C48 (\6\:CI VSS) capacitor c=6.1526e-17
C49 (\5\:A VSS) capacitor c=6.41917e-17
C50 (\6\:B VSS) capacitor c=2.52145e-17
C51 (\4\:CI VSS) capacitor c=3.73281e-17
C52 (\2\:B VSS) capacitor c=4.09186e-17
C53 (\2\:A VSS) capacitor c=2.61877e-17
C54 (\6\:COb VSS) capacitor c=6.90255e-18
C55 (\3\:S VSS) capacitor c=1.01355e-16
C56 (\12\:Sb VSS) capacitor c=5.30494e-17
C57 (\14\:Sb VSS) capacitor c=5.27581e-17
C58 (\14\:VDD VSS) capacitor c=1.53461e-17
C59 (\3\:n5 VSS) capacitor c=8.0209e-17
C60 (\16\:VDD VSS) capacitor c=1.49361e-17
C61 (\18\:COb VSS) capacitor c=2.60696e-17
C62 (\14\:COb VSS) capacitor c=1.24439e-16
C63 (\3\:n3 VSS) capacitor c=7.92906e-17
C64 (\18\:VDD VSS) capacitor c=1.63699e-17
C65 (\1\:CO VSS) capacitor c=7.35092e-17
C66 (\1\:VDD VSS) capacitor c=7.68483e-17
C67 (\1\:S VSS) capacitor c=4.68978e-17
C68 (\7\:Sb VSS) capacitor c=9.56099e-17
C69 (\9\:Sb VSS) capacitor c=5.7513e-17
C70 (\3\:n4 VSS) capacitor c=7.8408e-17
C71 (\21\:COb VSS) capacitor c=6.29243e-17
C72 (\23\:COb VSS) capacitor c=2.31666e-17
C73 (\3\:n2 VSS) capacitor c=7.82749e-17
C74 (\3\:CO VSS) capacitor c=2.92921e-17
C75 (\2\:CI VSS) capacitor c=3.2123e-17
C76 (\5\:B VSS) capacitor c=4.93956e-17
C77 (\9\:COb VSS) capacitor c=3.35978e-17
C78 (\9\:CI VSS) capacitor c=5.22704e-17
C79 (\12\:COb VSS) capacitor c=1.71822e-16
C80 (\13\:COb VSS) capacitor c=1.2434e-16
C81 (\16\:COb VSS) capacitor c=1.64703e-16
C82 (\17\:COb VSS) capacitor c=2.79734e-17
C83 (\20\:COb VSS) capacitor c=1.39644e-16
C84 (\12\:CI VSS) capacitor c=1.41461e-16
C85 (\13\:CI VSS) capacitor c=1.77992e-16
C86 (\14\:CI VSS) capacitor c=7.99302e-17
C87 (\14\:B VSS) capacitor c=1.26753e-16
C88 (\15\:B VSS) capacitor c=2.19518e-16
C89 (\16\:B VSS) capacitor c=6.49628e-17
C90 (\17\:B VSS) capacitor c=5.41679e-17
C91 (\18\:B VSS) capacitor c=7.54924e-17
C92 (\13\:A VSS) capacitor c=3.3958e-17
C93 (\14\:A VSS) capacitor c=1.73465e-16
C94 (\15\:A VSS) capacitor c=1.88289e-16
C95 (\16\:A VSS) capacitor c=1.46855e-16
C96 (\11\:Sb VSS) capacitor c=1.67624e-16
C97 (\3\:VDD VSS) capacitor c=1.16209e-16
C98 (\6\:VDD VSS) capacitor c=1.89889e-17
C99 (\8\:VDD VSS) capacitor c=2.73579e-17
Rk23 (\13\:A A) resistor r=0.13 c=0
Rk24 (A \14\:A) resistor r=0.7218 c=0
Rk25 (\14\:A \15\:A) resistor r=0.5487 c=0
Rk26 (\15\:A \16\:A) resistor r=0.9631 c=0
Rk35 (\1\:VSS \6\:VSS) resistor r=0.4386 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.2054 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.2052 c=0
Rk42 (\9\:VSS VSS) resistor r=0.3433 c=0
Rk38 (\8\:VSS \9\:VSS) resistor r=0.6429 c=0
Rk40 (\7\:VSS \13\:VSS) resistor r=0.1025 c=0
Rk41 (\8\:VSS \15\:VSS) resistor r=0.2088 c=0
Rk44 (\9\:VSS \18\:VSS) resistor r=0.07146 c=0
Rk18 (\14\:B \15\:B) resistor r=0.9002 c=0
Rk19 (\15\:B \16\:B) resistor r=0.6029 c=0
Rk22 (\17\:B B) resistor r=0.0525 c=0
Rk20 (\16\:B \17\:B) resistor r=0.06503 c=0
Rk21 (\17\:B \18\:B) resistor r=0.3682 c=0
Rk47 (\2\:VDD \3\:VDD) resistor r=0.03742 c=0
Rk49 (\3\:VDD \5\:VDD) resistor r=0.1728 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.411 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.1402 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.09414 c=0
Rk59 (\9\:VDD VDD) resistor r=0.3433 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.657 c=0
Rk56 (\6\:VDD \15\:VDD) resistor r=0.07381 c=0
Rk57 (\8\:VDD \17\:VDD) resistor r=0.0433 c=0
Rk58 (\9\:VDD \19\:VDD) resistor r=0.07146 c=0
Rk31 (S \2\:S) resistor r=0.01262 c=0
Rk32 (\2\:S \4\:S) resistor r=0.5162 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.7923 c=0
Rk17 (\14\:CI CI) resistor r=0.03871 c=0
Rk16 (\13\:CI \14\:CI) resistor r=0.5535 c=0
Rk1 (\2\:CO CO) resistor r=0.3167 c=0
Rk2 (CO \4\:CO) resistor r=0.05422 c=0
Rk7 (\12\:COb \13\:COb) resistor r=1.1197 c=0
Rk8 (\13\:COb \15\:COb) resistor r=0.3289 c=0
Rk9 (\15\:COb \16\:COb) resistor r=0.9704 c=0
Rk10 (\16\:COb \17\:COb) resistor r=0.2113 c=0
Rk11 (\13\:COb \19\:COb) resistor r=0.03584 c=0
Rk12 (\16\:COb \20\:COb) resistor r=0.8731 c=0
Rk13 (\20\:COb \22\:COb) resistor r=0.3793 c=0
Rk14 (\20\:COb \24\:COb) resistor r=0.06269 c=0
Rk4 (\2\:n2 \4\:n2) resistor r=0.282 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2776 c=0
Rk27 (\8\:Sb \10\:Sb) resistor r=0.2719 c=0
Rk28 (\8\:Sb \11\:Sb) resistor r=0.6913 c=0
Rk29 (\11\:Sb \13\:Sb) resistor r=0.6131 c=0
Rk30 (\13\:Sb \15\:Sb) resistor r=0.1267 c=0
Rk3 (\2\:n3 \4\:n3) resistor r=0.2522 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2356 c=0
Rl33 (\10\:A \11\:A) resistor r=125.692 c=0
Rl34 (\11\:A \12\:A) resistor r=77.6149 c=0
Rl24 (\8\:A \9\:A) resistor r=66.5405 c=0
Rl23 (\7\:A \8\:A) resistor r=65.6355 c=0
Rl17 (\4\:A \5\:A) resistor r=106.461 c=0
Rl18 (\5\:A \6\:A) resistor r=79.5379 c=0
Rl7 (\1\:A \2\:A) resistor r=51.1559 c=0
Rl8 (\2\:A \3\:A) resistor r=45.2671 c=0
Rl31 (\11\:B \12\:B) resistor r=74.2328 c=0
Rl32 (\12\:B \13\:B) resistor r=126.156 c=0
Rl21 (\8\:B \9\:B) resistor r=26.9231 c=0
Rl22 (\9\:B \10\:B) resistor r=160.292 c=0
Rl9 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl10 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl14 (\4\:B \5\:B) resistor r=51.1566 c=0
Rl16 (\5\:B \7\:B) resistor r=156.926 c=0
Rl15 (\5\:B \6\:B) resistor r=75.8374 c=0
Rl19 (\5\:CI \6\:CI) resistor r=160.584 c=0
Rl20 (\6\:CI \7\:CI) resistor r=26.3736 c=0
Rl11 (\1\:CI \2\:CI) resistor r=118.464 c=0
Rl12 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl13 (\2\:CI \4\:CI) resistor r=116.966 c=0
Rl30 (\9\:CI \11\:CI) resistor r=184.297 c=0
Rl28 (\8\:CI \9\:CI) resistor r=55.7471 c=0
Rl29 (\9\:CI \10\:CI) resistor r=46.9347 c=0
Rl5 (COb \6\:COb) resistor r=9.5287 c=0
Rl26 (\9\:COb \10\:COb) resistor r=27.9027 c=0
Rl25 (\9\:COb \8\:COb) resistor r=145.139 c=0
Rl27 (\9\:COb \11\:COb) resistor r=96.0333 c=0
Rl36 (\3\:Sb Sb) resistor r=23.4085 c=0
Rz13 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz15 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz19 (\5\:VDD \1\:VDD) resistor r=9.375 c=0
Rz20 (\7\:VDD \1\:VDD) resistor r=25 c=0
Rz21 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz10 (\2\:S \1\:S) resistor r=75 c=0
Rz1 (\4\:CO \3\:CO) resistor r=75 c=0
Rz6 (\22\:COb \21\:COb) resistor r=75 c=0
Rz7 (\24\:COb \23\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\8\:Sb \7\:Sb) resistor r=75 c=0
Rz9 (\10\:Sb \9\:Sb) resistor r=75 c=0
Ry11 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry12 (\6\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry13 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry10 (\4\:S \3\:S) resistor r=20.6667 c=0
Ry1 (\2\:CO \1\:CO) resistor r=20.6667 c=0
Ry6 (\15\:COb \14\:COb) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=31 c=0
Ry8 (\13\:Sb \12\:Sb) resistor r=62 c=0
Ry9 (\15\:Sb \14\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\6\:B \16\:B) resistor r=45 c=0
Rx9 (\2\:B \18\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\12\:COb \11\:COb) resistor r=45 c=0
Rx2 (\17\:COb \6\:COb) resistor r=45 c=0
Rx14 (\11\:Sb \3\:Sb) resistor r=45 c=0
mn12_1__rcx (\3\:CO COb VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\3\:n2 \3\:A \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.35e-14 ad=2.87e-14 ps=1.49e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn3 (n2 \3\:B \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.35e-14 ad=3.28e-14 ps=1.49e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn4 (\23\:COb \3\:CI n2 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn1 (\21\:COb \7\:B n0 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=1.11427e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn0 (n0 \6\:A \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.28415e-07 sb=1.00927e-06 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn7 (\3\:n4 \7\:CI \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.28e-14 ps=7.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33415e-07 sb=8.04268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn6 (\3\:n4 \10\:B \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.28e-14 ps=1.25e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38415e-07 sb=5.99268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn5 (n4 \7\:A \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.28e-14 ps=1.25e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.03415e-07 sb=3.34268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn8 (\9\:Sb \8\:COb n4 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.65e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10841e-06 sb=1.29268e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn11 (\7\:Sb \8\:CI n7 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=5.92805e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 as=1.64e-14 \
        ad=1.23e-14 ps=5.7e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28415e-07 sb=4.87805e-07 sd=160n sca=8.27167 scb=0.00612996 \
        scc=0.000112653 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.273e-14 ad=1.64e-14 ps=1.65e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.53415e-07 sb=3.62805e-07 sd=160n sca=8.27167 \
        scb=0.00612996 scc=0.000112653 m=(1)
mn13_1__rcx (\1\:S Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.956e-14 ad=4.16e-14 ps=1.225e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mp2 (n3 \1\:A \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.343e-14 ad=4.34e-14 ps=1.97e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.29435e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp5 (n5 \9\:A \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.59e-14 ad=5.16e-14 ps=1.9e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.57258e-07 sb=3.06935e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp3 (\3\:n3 \1\:B \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.343e-14 ad=4.96e-14 ps=1.97e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.87258e-07 sb=3.45e-07 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(1)
mp4 (\14\:COb \1\:CI \3\:n3 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92258e-07 sb=1.4e-07 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(1)
mp1 (\18\:COb \4\:B n1 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.35806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp0 (n1 \4\:A \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.024e-13 ad=1.86e-14 ps=1.63e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.30806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp7 (\3\:n5 \5\:CI \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.024e-13 ad=4.96e-14 ps=1.63e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.65806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp6 (\3\:n5 \8\:B \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.59e-14 ad=4.96e-14 ps=1.9e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=3.60806e-07 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp8 (\14\:Sb \10\:COb n5 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.96e-14 ps=1.04e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.29194e-07 sb=1.6e-07 sd=160n sca=21.39 \
        scb=0.0188316 scc=0.00214554 m=(1)
mp11 (\12\:Sb \11\:CI n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.1e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32258e-07 sb=8.95e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=2.48e-14 \
        ad=4.185e-14 ps=7.8e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.12258e-07 sb=7.15e-07 sd=160n sca=11.9366 scb=0.0100265 \
        scc=0.000286595 m=(1)
mp9 (n8 \10\:A \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=2.48e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.37258e-07 sb=5.9e-07 sd=160n sca=12.3487 \
        scb=0.0102277 scc=0.000286701 m=(1)
mp13_1__rcx (\3\:S \3\:Sb \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.61e-14 ad=7.8e-14 ps=1.08e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.31026e-07 sb=3.85e-07 sd=160n sca=16.3933 \
        scb=0.0147003 scc=0.000819495 m=(2)
ends ADDFHX2
// End of subcircuit definition.

// Generated for: spectre (May  9 12:56:35 2012 )
// Library name: gsclib045
// Cell name: ADDFHX4
// View name: extracted

simulator lang=spectre

subckt ADDFHX4 A B CI CO S VDD VSS
mp12_1__rcx (\1\:CO COb \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=37.1131 scb=0.03221 \
        scc=0.00363789 m=(4)
C1 (A VSS) capacitor c=1.06028e-16
C2 (B VSS) capacitor c=6.85247e-17
C3 (CO VSS) capacitor c=1.34805e-17
C4 (VDD VSS) capacitor c=2.5692e-16
C5 (S VSS) capacitor c=1.52681e-17
C6 (CI VSS) capacitor c=8.88231e-17
C7 (COb VSS) capacitor c=2.81272e-16
C8 (n2 VSS) capacitor c=8.95462e-17
C9 (n0 VSS) capacitor c=1.23995e-18
C10 (n4 VSS) capacitor c=8.09696e-17
C11 (Sb VSS) capacitor c=2.95539e-16
C12 (n7 VSS) capacitor c=1.61961e-18
C13 (n6 VSS) capacitor c=3.27294e-18
C14 (n3 VSS) capacitor c=6.39387e-17
C15 (n1 VSS) capacitor c=2.07034e-18
C16 (n5 VSS) capacitor c=8.07899e-17
C17 (n9 VSS) capacitor c=3.59321e-18
C18 (n8 VSS) capacitor c=3.22966e-18
C19 (\10\:A VSS) capacitor c=6.96874e-17
C20 (\12\:B VSS) capacitor c=7.08016e-17
C21 (\12\:CI VSS) capacitor c=7.57386e-17
C22 (\13\:COb VSS) capacitor c=3.57435e-17
C23 (\7\:A VSS) capacitor c=7.20271e-17
C24 (\11\:B VSS) capacitor c=5.50043e-17
C25 (\5\:CI VSS) capacitor c=7.19723e-17
C26 (\6\:A VSS) capacitor c=8.98701e-17
C27 (\7\:B VSS) capacitor c=7.15459e-17
C28 (\1\:CI VSS) capacitor c=5.34565e-17
C29 (\1\:B VSS) capacitor c=5.652e-17
C30 (\1\:A VSS) capacitor c=5.82268e-17
C31 (\12\:A VSS) capacitor c=4.82108e-17
C32 (\14\:B VSS) capacitor c=9.41004e-17
C33 (\9\:CI VSS) capacitor c=5.95552e-17
C34 (\15\:COb VSS) capacitor c=6.03615e-17
C35 (\9\:A VSS) capacitor c=5.02092e-17
C36 (\10\:B VSS) capacitor c=5.96451e-17
C37 (\8\:CI VSS) capacitor c=3.73575e-17
C38 (\4\:A VSS) capacitor c=7.87912e-17
C39 (\4\:B VSS) capacitor c=8.88717e-17
C40 (\3\:CI VSS) capacitor c=3.19267e-17
C41 (\3\:B VSS) capacitor c=5.42063e-17
C42 (\3\:A VSS) capacitor c=3.93293e-17
C43 (\11\:A VSS) capacitor c=4.22166e-17
C44 (\13\:B VSS) capacitor c=5.92853e-17
C45 (\11\:CI VSS) capacitor c=3.38895e-17
C46 (\16\:COb VSS) capacitor c=3.40075e-17
C47 (\8\:A VSS) capacitor c=5.22135e-17
C48 (\8\:B VSS) capacitor c=3.00208e-17
C49 (\7\:CI VSS) capacitor c=5.27559e-17
C50 (\5\:A VSS) capacitor c=6.16425e-17
C51 (\6\:B VSS) capacitor c=1.64751e-17
C52 (\4\:CI VSS) capacitor c=4.10318e-17
C53 (\2\:B VSS) capacitor c=3.68483e-17
C54 (\2\:A VSS) capacitor c=2.64068e-17
C55 (\22\:Sb VSS) capacitor c=7.409e-17
C56 (\24\:Sb VSS) capacitor c=6.06533e-17
C57 (\23\:VDD VSS) capacitor c=1.74088e-17
C58 (\3\:n5 VSS) capacitor c=9.50056e-17
C59 (\25\:VDD VSS) capacitor c=1.56255e-17
C60 (\18\:COb VSS) capacitor c=1.25467e-16
C61 (\24\:COb VSS) capacitor c=3.43749e-17
C62 (\3\:n3 VSS) capacitor c=8.3402e-17
C63 (\27\:VDD VSS) capacitor c=1.64098e-17
C64 (\1\:CO VSS) capacitor c=1.94493e-16
C65 (\1\:VDD VSS) capacitor c=1.17922e-16
C66 (\2\:S VSS) capacitor c=1.12091e-16
C67 (\18\:Sb VSS) capacitor c=9.82405e-17
C68 (\20\:Sb VSS) capacitor c=5.89726e-17
C69 (\3\:n4 VSS) capacitor c=7.9281e-17
C70 (\27\:COb VSS) capacitor c=6.11286e-17
C71 (\29\:COb VSS) capacitor c=1.56272e-17
C72 (\3\:n2 VSS) capacitor c=7.76519e-17
C73 (\6\:CO VSS) capacitor c=1.03783e-16
C74 (\2\:CI VSS) capacitor c=3.42557e-17
C75 (\5\:B VSS) capacitor c=3.60721e-17
C76 (\9\:B VSS) capacitor c=2.72344e-17
C77 (\14\:COb VSS) capacitor c=3.5157e-17
C78 (\10\:CI VSS) capacitor c=4.76252e-17
C79 (\17\:COb VSS) capacitor c=1.74543e-16
C80 (\20\:COb VSS) capacitor c=1.02053e-16
C81 (\21\:COb VSS) capacitor c=1.88787e-16
C82 (\26\:COb VSS) capacitor c=1.50936e-16
C83 (\13\:CI VSS) capacitor c=1.50337e-16
C84 (\14\:CI VSS) capacitor c=1.87737e-16
C85 (\15\:B VSS) capacitor c=1.27843e-16
C86 (\16\:B VSS) capacitor c=2.0793e-16
C87 (\17\:B VSS) capacitor c=7.53019e-17
C88 (\18\:B VSS) capacitor c=7.70592e-17
C89 (\13\:A VSS) capacitor c=3.78723e-17
C90 (\14\:A VSS) capacitor c=1.83377e-16
C91 (\15\:A VSS) capacitor c=2.15942e-16
C92 (\16\:A VSS) capacitor c=1.38603e-16
C93 (\17\:Sb VSS) capacitor c=1.49755e-16
C94 (\1\:S VSS) capacitor c=2.99562e-17
C95 (\6\:S VSS) capacitor c=1.94307e-16
C96 (\3\:VDD VSS) capacitor c=1.50999e-16
C97 (\7\:VDD VSS) capacitor c=3.34992e-17
C98 (\9\:VDD VSS) capacitor c=2.09432e-17
C99 (\11\:VDD VSS) capacitor c=1.27497e-16
Rk27 (\13\:A A) resistor r=0.08561 c=0
Rk28 (A \14\:A) resistor r=0.7093 c=0
Rk29 (\14\:A \15\:A) resistor r=0.6289 c=0
Rk30 (\15\:A \16\:A) resistor r=0.9088 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.04996 c=0
Rk47 (\3\:VSS \7\:VSS) resistor r=0.2004 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.4437 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.1076 c=0
Rk50 (\9\:VSS \10\:VSS) resistor r=0.09761 c=0
Rk51 (\10\:VSS \11\:VSS) resistor r=0.4537 c=0
Rk52 (\11\:VSS \12\:VSS) resistor r=0.1167 c=0
Rk58 (\13\:VSS VSS) resistor r=0.03215 c=0
Rk53 (\12\:VSS \13\:VSS) resistor r=0.3347 c=0
Rk63 (\8\:VSS \26\:VSS) resistor r=0.1026 c=0
Rk64 (\10\:VSS \28\:VSS) resistor r=0.1742 c=0
Rk65 (\12\:VSS \30\:VSS) resistor r=0.04331 c=0
Rk24 (\16\:B B) resistor r=0.6363 c=0
Rk23 (\15\:B \16\:B) resistor r=0.814 c=0
Rk25 (B \17\:B) resistor r=0.06364 c=0
Rk26 (\17\:B \18\:B) resistor r=0.534 c=0
Rk2 (\1\:CO CO) resistor r=0.242 c=0
Rk4 (CO \6\:CO) resistor r=0.05252 c=0
Rk69 (\2\:VDD \3\:VDD) resistor r=0.05498 c=0
Rk73 (\3\:VDD \7\:VDD) resistor r=0.6286 c=0
Rk74 (\7\:VDD \8\:VDD) resistor r=0.2224 c=0
Rk75 (\8\:VDD \9\:VDD) resistor r=0.57 c=0
Rk76 (\9\:VDD \10\:VDD) resistor r=0.1829 c=0
Rk82 (\11\:VDD VDD) resistor r=0.03215 c=0
Rk77 (\10\:VDD \11\:VDD) resistor r=0.1678 c=0
Rk87 (\7\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk88 (\8\:VDD \26\:VDD) resistor r=0.07147 c=0
Rk89 (\9\:VDD \28\:VDD) resistor r=0.07393 c=0
Rk37 (S \1\:S) resistor r=0.007742 c=0
Rk38 (\1\:S \2\:S) resistor r=0.1493 c=0
Rk40 (\1\:S \6\:S) resistor r=0.324 c=0
Rk20 (\14\:CI CI) resistor r=0.4248 c=0
Rk19 (\13\:CI \14\:CI) resistor r=0.8934 c=0
Rk21 (CI \15\:CI) resistor r=0.003053 c=0
Rk22 (\14\:CI \16\:CI) resistor r=0.04261 c=0
Rk10 (\17\:COb \19\:COb) resistor r=1.1276 c=0
Rk11 (\19\:COb \20\:COb) resistor r=0.2594 c=0
Rk13 (\21\:COb COb) resistor r=0.3988 c=0
Rk12 (\20\:COb \21\:COb) resistor r=0.8996 c=0
Rk15 (\20\:COb \25\:COb) resistor r=0.04927 c=0
Rk16 (\21\:COb \26\:COb) resistor r=0.949 c=0
Rk17 (\26\:COb \28\:COb) resistor r=0.3306 c=0
Rk18 (\26\:COb \30\:COb) resistor r=0.05759 c=0
Rk7 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk9 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk32 (Sb \17\:Sb) resistor r=0.1901 c=0
Rk33 (\17\:Sb \19\:Sb) resistor r=0.593 c=0
Rk34 (\19\:Sb \21\:Sb) resistor r=0.2807 c=0
Rk35 (\17\:Sb \23\:Sb) resistor r=0.7415 c=0
Rk36 (\23\:Sb \25\:Sb) resistor r=0.2136 c=0
Rk6 (\2\:n3 \4\:n3) resistor r=0.2734 c=0
Rk8 (\2\:n5 \4\:n5) resistor r=0.2822 c=0
Rl39 (\10\:A \11\:A) resistor r=108.384 c=0
Rl40 (\11\:A \12\:A) resistor r=44.9225 c=0
Rl29 (\7\:A \8\:A) resistor r=85.7713 c=0
Rl30 (\8\:A \9\:A) resistor r=62.6944 c=0
Rl22 (\5\:A \6\:A) resistor r=62.8119 c=0
Rl21 (\4\:A \5\:A) resistor r=82.2239 c=0
Rl11 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl12 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl37 (\12\:B \13\:B) resistor r=44.9225 c=0
Rl38 (\13\:B \14\:B) resistor r=108.384 c=0
Rl13 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl14 (\2\:B \3\:B) resistor r=75.6918 c=0
Rl20 (\5\:B \7\:B) resistor r=45.0334 c=0
Rl18 (\4\:B \5\:B) resistor r=127.291 c=0
Rl19 (\5\:B \6\:B) resistor r=3.1183 c=0
Rl28 (\9\:B \11\:B) resistor r=34.3295 c=0
Rl27 (\9\:B \10\:B) resistor r=134.329 c=0
Rl26 (\8\:B \9\:B) resistor r=11.5001 c=0
Rl15 (\1\:CI \2\:CI) resistor r=99.2335 c=0
Rl16 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl17 (\2\:CI \4\:CI) resistor r=132.351 c=0
Rl23 (\5\:CI \6\:CI) resistor r=134.329 c=0
Rl25 (\6\:CI \8\:CI) resistor r=34.3295 c=0
Rl24 (\6\:CI \7\:CI) resistor r=0.5166 c=0
Rl36 (\10\:CI \12\:CI) resistor r=134.297 c=0
Rl34 (\9\:CI \10\:CI) resistor r=48.0548 c=0
Rl35 (\10\:CI \11\:CI) resistor r=68.4415 c=0
Rl31 (\14\:COb \13\:COb) resistor r=28.0797 c=0
Rl32 (\14\:COb \15\:COb) resistor r=145.387 c=0
Rl33 (\14\:COb \16\:COb) resistor r=99.1945 c=0
Rz16 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz17 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz18 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz29 (VDD \1\:VDD) resistor r=75 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz24 (\3\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz25 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz26 (\10\:VDD \1\:VDD) resistor r=25 c=0
Rz28 (\11\:VDD \1\:VDD) resistor r=18.75 c=0
Rz7 (\28\:COb \27\:COb) resistor r=75 c=0
Rz8 (\30\:COb \29\:COb) resistor r=75 c=0
Rz3 (n2 \2\:n2) resistor r=75 c=0
Rz4 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz9 (\19\:Sb \18\:Sb) resistor r=75 c=0
Rz10 (\21\:Sb \20\:Sb) resistor r=75 c=0
Ry20 (VSS \1\:VSS) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\11\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry18 (\13\:VSS \1\:VSS) resistor r=15.5 c=0
Ry24 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry25 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=62 c=0
Ry8 (\25\:COb \24\:COb) resistor r=20.6667 c=0
Ry9 (\23\:Sb \22\:Sb) resistor r=62 c=0
Ry10 (\25\:Sb \24\:Sb) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n5 \2\:n5) resistor r=62 c=0
Ry6 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx11 (\11\:A \13\:A) resistor r=45 c=0
Rx12 (\8\:A \14\:A) resistor r=45 c=0
Rx13 (\5\:A \15\:A) resistor r=45 c=0
Rx14 (\2\:A \16\:A) resistor r=45 c=0
Rx7 (\13\:B \15\:B) resistor r=45 c=0
Rx8 (\8\:B \16\:B) resistor r=45 c=0
Rx9 (\6\:B \17\:B) resistor r=45 c=0
Rx10 (\2\:B \18\:B) resistor r=45 c=0
Rx4 (\11\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \15\:CI) resistor r=45 c=0
Rx6 (\7\:CI \16\:CI) resistor r=45 c=0
Rx1 (\17\:COb \16\:COb) resistor r=45 c=0
mn12_1__rcx (\6\:CO COb \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn2 (\3\:n2 \3\:A \29\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.64e-14 ps=1.46e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn3 (n2 \3\:B \29\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=4.16e-14 ps=1.46e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn4 (\29\:COb \3\:CI n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn1 (\27\:COb \4\:B n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.14e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (n0 \4\:A \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.035e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn7 (\3\:n4 \8\:CI \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn6 (\3\:n4 \10\:B \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.25e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (n4 \9\:A \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn8 (\20\:Sb \15\:COb n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn11 (\18\:Sb \9\:CI n7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.22e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23846e-07 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (n7 \14\:B n6 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.56e-14 ps=7e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28846e-07 sb=1.145e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn9 (n6 \12\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.34e-14 ps=9.2e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.63846e-07 sb=1.01e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn13_1__rcx (\2\:S Sb \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.08846e-07 sb=7.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp2 (n3 \1\:A \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.70769e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp3 (\3\:n3 \1\:B \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=6.24e-14 ps=1.9e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.86923e-07 sb=3.45e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp4 (\24\:COb \1\:CI \3\:n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.91923e-07 sb=1.4e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp1 (\18\:COb \7\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.20192e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp0 (n1 \6\:A \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=2.34e-14 ps=1.8e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.09692e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp7 (\3\:n5 \5\:CI \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.31923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp6 (\3\:n5 \11\:B \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.26923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp5 (n5 \7\:A \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.61923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp8 (\24\:Sb \13\:COb n5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.12e-14 ps=1.1e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.56923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp11 (\22\:Sb \12\:CI n9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=1.01e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.295e-06 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.485e-14 ps=9.6e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.135e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp9 (n8 \10\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=3.51e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp13_1__rcx (\6\:S Sb \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=7.55e-07 sd=160n sca=14.4678 \
        scb=0.0130219 scc=0.000814276 m=(4)
ends ADDFHX4
// End of subcircuit definition.

// Generated for: spectre (May  9 12:57:12 2012 )
// Library name: gsclib045
// Cell name: ADDFHXL
// View name: extracted

simulator lang=spectre

subckt ADDFHXL A B CI CO S VDD VSS
mp12 (\1\:CO COb \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.34e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.8293 scb=0.0353699 \
        scc=0.00464516 m=(1)
C1 (B VSS) capacitor c=1.40441e-16
C2 (VDD VSS) capacitor c=2.89289e-16
C3 (S VSS) capacitor c=2.33969e-17
C4 (CI VSS) capacitor c=6.06873e-17
C5 (CO VSS) capacitor c=6.58383e-17
C6 (COb VSS) capacitor c=2.4171e-17
C7 (n2 VSS) capacitor c=7.82165e-17
C8 (n4 VSS) capacitor c=7.37055e-17
C9 (Sb VSS) capacitor c=3.72757e-17
C10 (n7 VSS) capacitor c=2.09961e-18
C11 (n6 VSS) capacitor c=3.49935e-18
C12 (n3 VSS) capacitor c=6.66759e-17
C13 (n1 VSS) capacitor c=1.71568e-18
C14 (n5 VSS) capacitor c=8.27196e-17
C15 (n9 VSS) capacitor c=3.83514e-18
C16 (n8 VSS) capacitor c=3.16792e-18
C17 (\10\:A VSS) capacitor c=6.13544e-17
C18 (\10\:B VSS) capacitor c=5.33096e-17
C19 (\11\:CI VSS) capacitor c=6.98984e-17
C20 (\6\:COb VSS) capacitor c=4.25824e-17
C21 (\9\:A VSS) capacitor c=6.78011e-17
C22 (\7\:B VSS) capacitor c=5.08518e-17
C23 (\5\:CI VSS) capacitor c=6.18458e-17
C24 (\6\:A VSS) capacitor c=7.79215e-17
C25 (\6\:B VSS) capacitor c=6.35371e-17
C26 (\1\:CI VSS) capacitor c=6.16811e-17
C27 (\1\:B VSS) capacitor c=4.94644e-17
C28 (\1\:A VSS) capacitor c=4.79254e-17
C29 (\3\:Sb VSS) capacitor c=2.44147e-17
C30 (\12\:A VSS) capacitor c=4.9981e-17
C31 (\12\:B VSS) capacitor c=8.75567e-17
C32 (\8\:CI VSS) capacitor c=5.11819e-17
C33 (\4\:COb VSS) capacitor c=5.2394e-17
C34 (\7\:A VSS) capacitor c=5.05345e-17
C35 (\9\:B VSS) capacitor c=5.97777e-17
C36 (\7\:CI VSS) capacitor c=3.28919e-17
C37 (\4\:A VSS) capacitor c=6.69604e-17
C38 (\4\:B VSS) capacitor c=1.03177e-16
C39 (\3\:CI VSS) capacitor c=3.11872e-17
C40 (\3\:B VSS) capacitor c=5.40367e-17
C41 (\3\:A VSS) capacitor c=4.58751e-17
C42 (\3\:COb VSS) capacitor c=2.70273e-17
C43 (\2\:Sb VSS) capacitor c=3.28161e-17
C44 (\11\:A VSS) capacitor c=4.57408e-17
C45 (\11\:B VSS) capacitor c=6.07207e-17
C46 (\10\:CI VSS) capacitor c=2.73445e-17
C47 (\7\:COb VSS) capacitor c=2.23363e-17
C48 (\8\:A VSS) capacitor c=4.7732e-17
C49 (\8\:B VSS) capacitor c=6.06002e-17
C50 (\6\:CI VSS) capacitor c=5.22259e-17
C51 (\5\:A VSS) capacitor c=7.25279e-17
C52 (\5\:B VSS) capacitor c=5.97928e-17
C53 (\4\:CI VSS) capacitor c=4.70115e-17
C54 (\2\:B VSS) capacitor c=5.44547e-17
C55 (\2\:A VSS) capacitor c=3.59924e-17
C56 (\2\:COb VSS) capacitor c=1.68401e-17
C57 (\4\:S VSS) capacitor c=5.11981e-17
C58 (\11\:VDD VSS) capacitor c=4.03607e-17
C59 (\9\:Sb VSS) capacitor c=8.7821e-17
C60 (\11\:Sb VSS) capacitor c=4.80204e-17
C61 (\13\:VDD VSS) capacitor c=2.87163e-17
C62 (\3\:n5 VSS) capacitor c=8.42194e-17
C63 (\15\:VDD VSS) capacitor c=4.72965e-17
C64 (\9\:COb VSS) capacitor c=1.79108e-16
C65 (\12\:COb VSS) capacitor c=2.94503e-17
C66 (\3\:n3 VSS) capacitor c=7.05729e-17
C67 (\17\:VDD VSS) capacitor c=2.42851e-17
C68 (\1\:CO VSS) capacitor c=9.08805e-17
C69 (\19\:VDD VSS) capacitor c=4.25866e-17
C70 (\1\:VDD VSS) capacitor c=1.11668e-16
C71 (\2\:S VSS) capacitor c=5.57055e-17
C72 (\4\:Sb VSS) capacitor c=7.24389e-17
C73 (\6\:Sb VSS) capacitor c=4.91892e-17
C74 (\3\:n4 VSS) capacitor c=7.15517e-17
C75 (\19\:COb VSS) capacitor c=5.37214e-17
C76 (\16\:COb VSS) capacitor c=1.43864e-17
C77 (\3\:n2 VSS) capacitor c=7.25891e-17
C78 (\3\:CO VSS) capacitor c=6.14164e-17
C79 (\2\:CI VSS) capacitor c=3.13594e-17
C80 (\5\:COb VSS) capacitor c=4.89704e-17
C81 (\9\:CI VSS) capacitor c=4.4712e-17
C82 (\8\:COb VSS) capacitor c=1.99034e-16
C83 (\11\:COb VSS) capacitor c=1.21753e-16
C84 (\14\:COb VSS) capacitor c=2.07164e-16
C85 (\15\:COb VSS) capacitor c=1.102e-16
C86 (\18\:COb VSS) capacitor c=5.13483e-17
C87 (\12\:CI VSS) capacitor c=1.44204e-16
C88 (\13\:CI VSS) capacitor c=1.45004e-16
C89 (\14\:CI VSS) capacitor c=3.85203e-17
C90 (\13\:B VSS) capacitor c=1.23988e-16
C91 (\14\:B VSS) capacitor c=2.10856e-16
C92 (\16\:B VSS) capacitor c=8.20424e-17
C93 (\13\:A VSS) capacitor c=1.37855e-16
C94 (\14\:A VSS) capacitor c=1.93075e-16
C95 (\15\:A VSS) capacitor c=1.90945e-16
C96 (\16\:A VSS) capacitor c=1.07417e-16
C97 (\8\:Sb VSS) capacitor c=1.776e-16
C98 (\5\:VDD VSS) capacitor c=1.51465e-17
C99 (\6\:VDD VSS) capacitor c=2.57669e-17
C100 (\8\:VDD VSS) capacitor c=2.61533e-17
C101 (\9\:VDD VSS) capacitor c=1.43603e-17
Rk22 (A \13\:A) resistor r=0.003104 c=0
Rk23 (\13\:A \14\:A) resistor r=0.9007 c=0
Rk24 (\14\:A \15\:A) resistor r=0.5026 c=0
Rk25 (\15\:A \16\:A) resistor r=0.7694 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.1703 c=0
Rk48 (\3\:VSS \4\:VSS) resistor r=0.2807 c=0
Rk49 (\4\:VSS \5\:VSS) resistor r=0.3584 c=0
Rk50 (\5\:VSS \6\:VSS) resistor r=0.2103 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.3333 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.2195 c=0
Rk54 (\9\:VSS VSS) resistor r=0.03466 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.3949 c=0
Rk56 (\3\:VSS \12\:VSS) resistor r=0.2129 c=0
Rk57 (\5\:VSS \14\:VSS) resistor r=0.1995 c=0
Rk58 (\6\:VSS \16\:VSS) resistor r=0.2878 c=0
Rk59 (\8\:VSS \18\:VSS) resistor r=0.04331 c=0
Rk60 (\9\:VSS \20\:VSS) resistor r=0.2744 c=0
Rk18 (\13\:B \14\:B) resistor r=0.9231 c=0
Rk20 (\15\:B B) resistor r=0.005207 c=0
Rk19 (\14\:B \15\:B) resistor r=0.5499 c=0
Rk21 (\15\:B \16\:B) resistor r=0.4236 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.1703 c=0
Rk34 (\3\:VDD \4\:VDD) resistor r=0.2807 c=0
Rk35 (\4\:VDD \5\:VDD) resistor r=0.3424 c=0
Rk36 (\5\:VDD \6\:VDD) resistor r=0.2921 c=0
Rk37 (\6\:VDD \7\:VDD) resistor r=0.2656 c=0
Rk38 (\7\:VDD \8\:VDD) resistor r=0.2195 c=0
Rk40 (\9\:VDD VDD) resistor r=0.03466 c=0
Rk39 (\8\:VDD \9\:VDD) resistor r=0.3949 c=0
Rk42 (\3\:VDD \12\:VDD) resistor r=0.1327 c=0
Rk43 (\5\:VDD \14\:VDD) resistor r=0.04331 c=0
Rk44 (\6\:VDD \16\:VDD) resistor r=0.1857 c=0
Rk45 (\8\:VDD \18\:VDD) resistor r=0.04331 c=0
Rk46 (\9\:VDD \20\:VDD) resistor r=0.3628 c=0
Rk30 (S \1\:S) resistor r=0.07549 c=0
Rk31 (\1\:S \3\:S) resistor r=0.08787 c=0
Rk32 (\1\:S \5\:S) resistor r=0.4153 c=0
Rk16 (\13\:CI CI) resistor r=0.3243 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8368 c=0
Rk17 (CI \14\:CI) resistor r=0.06635 c=0
Rk1 (\2\:CO CO) resistor r=0.4648 c=0
Rk2 (CO \4\:CO) resistor r=0.2836 c=0
Rk7 (\8\:COb \10\:COb) resistor r=1.3892 c=0
Rk8 (\10\:COb \11\:COb) resistor r=0.1621 c=0
Rk9 (\11\:COb \13\:COb) resistor r=0.06391 c=0
Rk10 (\11\:COb \14\:COb) resistor r=1.0341 c=0
Rk11 (\14\:COb \15\:COb) resistor r=0.8971 c=0
Rk12 (\15\:COb \17\:COb) resistor r=0.03458 c=0
Rk13 (\14\:COb \18\:COb) resistor r=0.159 c=0
Rk14 (\15\:COb \20\:COb) resistor r=0.2602 c=0
Rk4 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2778 c=0
Rk26 (\5\:Sb \7\:Sb) resistor r=0.2431 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.5482 c=0
Rk28 (\8\:Sb \10\:Sb) resistor r=0.873 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1246 c=0
Rk3 (\2\:n3 \4\:n3) resistor r=0.2195 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2402 c=0
Rl28 (\10\:A \11\:A) resistor r=85.7713 c=0
Rl29 (\11\:A \12\:A) resistor r=64.6174 c=0
Rl19 (\8\:A \9\:A) resistor r=24.2328 c=0
Rl18 (\7\:A \8\:A) resistor r=100.539 c=0
Rl13 (\5\:A \6\:A) resistor r=114.01 c=0
Rl12 (\4\:A \5\:A) resistor r=84.6154 c=0
Rl3 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl4 (\2\:A \3\:A) resistor r=84.1695 c=0
Rl26 (\10\:B \11\:B) resistor r=24.2328 c=0
Rl27 (\11\:B \12\:B) resistor r=126.156 c=0
Rl16 (\7\:B \8\:B) resistor r=24.2328 c=0
Rl17 (\8\:B \9\:B) resistor r=158.848 c=0
Rl11 (\5\:B \6\:B) resistor r=39.6174 c=0
Rl10 (\4\:B \5\:B) resistor r=177.645 c=0
Rl5 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl6 (\2\:B \3\:B) resistor r=114.617 c=0
Rl14 (\5\:CI \6\:CI) resistor r=158.848 c=0
Rl15 (\6\:CI \7\:CI) resistor r=24.2328 c=0
Rl7 (\1\:CI \2\:CI) resistor r=135.772 c=0
Rl8 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl9 (\2\:CI \4\:CI) resistor r=97.9741 c=0
Rl25 (\9\:CI \11\:CI) resistor r=135.855 c=0
Rl23 (\8\:CI \9\:CI) resistor r=40.105 c=0
Rl24 (\9\:CI \10\:CI) resistor r=46.5525 c=0
Rl1 (COb \2\:COb) resistor r=29.5379 c=0
Rl2 (\2\:COb \3\:COb) resistor r=66.0764 c=0
Rl21 (\5\:COb \6\:COb) resistor r=53.824 c=0
Rl20 (\4\:COb \5\:COb) resistor r=143.912 c=0
Rl22 (\5\:COb \7\:COb) resistor r=85.285 c=0
Rl30 (Sb \2\:Sb) resistor r=126.156 c=0
Rl31 (\2\:Sb \3\:Sb) resistor r=24.2328 c=0
Rz15 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz14 (\1\:VDD VDD) resistor r=75 c=0
Rz11 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz13 (\1\:VDD \7\:VDD) resistor r=6.25 c=0
Rz10 (\2\:S \3\:S) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz6 (\16\:COb \17\:COb) resistor r=75 c=0
Rz7 (\19\:COb \20\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry19 (\1\:VSS VSS) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry18 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry11 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry10 (\4\:S \5\:S) resistor r=31 c=0
Ry1 (\1\:CO \2\:CO) resistor r=31 c=0
Ry6 (\9\:COb \10\:COb) resistor r=31 c=0
Ry7 (\12\:COb \13\:COb) resistor r=31 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\7\:COb \8\:COb) resistor r=45 c=0
Rx2 (\2\:COb \18\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \8\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.87e-14 ps=6.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn2 (\3\:n2 \3\:A \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.01e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3 (n2 \3\:B \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.01e-14 ad=3.28e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\16\:COb \3\:CI n2 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn1 (\19\:COb \4\:B n0 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12329e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn0 (n0 \4\:A \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=1.23e-14 ps=7.5e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.01829e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn7 (\3\:n4 \7\:CI \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=3.28e-14 ps=7.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=8.03293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn6 (\3\:n4 \9\:B \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.01e-14 ad=3.28e-14 ps=1.1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=5.98293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn5 (n4 \7\:A \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.01e-14 ad=3.28e-14 ps=1.1e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=3.33293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn8 (\6\:Sb \4\:COb n4 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.63e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.28293e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=7.45e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn9 (n6 \12\:A \11\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=2.05e-14 ps=1.19e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.73415e-07 sb=4.95e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn10 (n7 \12\:B n6 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 as=2.05e-14 \
        ad=1.23e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28415e-07 sb=6.4e-07 sd=160n sca=16.0682 scb=0.0166045 \
        scc=0.00126927 m=(1)
mn13 (\2\:S \3\:Sb \11\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=3.895e-14 ps=1.19e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.78415e-07 sb=1.9e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mp2 (n3 \1\:A \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.34e-14 ps=1.77e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55484e-07 sd=160n sca=19.2885 \
        scb=0.0175179 scc=0.00172295 m=(1)
mp3 (\3\:n3 \1\:B \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.96e-14 ps=1.77e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36452e-07 sb=3.45e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp4 (\12\:COb \1\:CI \3\:n3 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41452e-07 sb=1.4e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp1 (\9\:COb \6\:B n1 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.65e-14 ps=7.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=9.14839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp0 (n1 \6\:A \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=1.86e-14 ps=1.23e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=8.09839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp7 (\3\:n5 \5\:CI \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=4.96e-14 ps=1.23e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=4.59839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp6 (\3\:n5 \7\:B \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=4.96e-14 ps=1.77e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=2.54839e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=5.48e-14 ps=1.77e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.50323e-07 sb=2.19032e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=5.32e-14 ps=1.2e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.69355e-07 sb=1.71613e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp9 (n8 \10\:A \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=3.1e-14 ps=1.4e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.40484e-07 sb=4.95e-07 sd=160n sca=11.9282 \
        scb=0.00964102 scc=0.000229002 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=3.58e-14 ps=8.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=8.2e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp10 (n9 \10\:B n8 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=3.1e-14 \
        ad=4.185e-14 ps=8.2e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.95484e-07 sb=6.4e-07 sd=160n sca=11.4887 scb=0.00945 \
        scc=0.00022892 m=(1)
mp13 (\4\:S Sb \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.62e-14 ad=5.89e-14 ps=1.4e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45484e-07 sb=1.9e-07 sd=160n sca=14.4228 \
        scb=0.0128311 scc=0.000253304 m=(1)
ends ADDFHXL
// End of subcircuit definition.

// Generated for: spectre (May  9 12:28:38 2012 )
// Library name: gsclib045
// Cell name: ADDFX1
// View name: extracted

simulator lang=spectre

subckt ADDFX1 A B CI CO S VDD VSS
mp12 (\1\:CO \4\:COb \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.615e-14 ad=5.46e-14 ps=1.33e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12821e-07 sd=160n sca=24.8923 \
        scb=0.0283314 scc=0.00161065 m=(1)
C1 (A VSS) capacitor c=1.01916e-16
C2 (B VSS) capacitor c=1.1004e-16
C3 (CO VSS) capacitor c=5.53574e-17
C4 (VDD VSS) capacitor c=2.25509e-16
C5 (S VSS) capacitor c=5.98885e-17
C6 (CI VSS) capacitor c=1.91306e-16
C7 (COb VSS) capacitor c=1.32321e-17
C8 (n2 VSS) capacitor c=8.98477e-17
C9 (n4 VSS) capacitor c=7.94196e-17
C10 (Sb VSS) capacitor c=4.52858e-17
C11 (n7 VSS) capacitor c=1.78033e-18
C12 (n6 VSS) capacitor c=1.50273e-18
C13 (n3 VSS) capacitor c=6.37448e-17
C14 (n1 VSS) capacitor c=1.4721e-18
C15 (n5 VSS) capacitor c=6.91224e-17
C16 (\12\:A VSS) capacitor c=9.1911e-17
C17 (\12\:B VSS) capacitor c=9.39089e-17
C18 (\10\:CI VSS) capacitor c=1.0761e-16
C19 (\7\:COb VSS) capacitor c=3.22178e-17
C20 (\9\:A VSS) capacitor c=6.54183e-17
C21 (\7\:B VSS) capacitor c=3.94173e-17
C22 (\5\:CI VSS) capacitor c=6.47751e-17
C23 (\4\:A VSS) capacitor c=6.88815e-17
C24 (\4\:B VSS) capacitor c=5.07826e-17
C25 (\4\:CI VSS) capacitor c=5.62731e-17
C26 (\1\:B VSS) capacitor c=4.08861e-17
C27 (\1\:A VSS) capacitor c=5.20741e-17
C28 (\4\:COb VSS) capacitor c=3.63097e-17
C29 (\3\:Sb VSS) capacitor c=4.98985e-17
C30 (\10\:A VSS) capacitor c=5.69726e-17
C31 (\10\:B VSS) capacitor c=8.63264e-17
C32 (\8\:CI VSS) capacitor c=4.23041e-17
C33 (\5\:COb VSS) capacitor c=6.61111e-17
C34 (\7\:A VSS) capacitor c=3.79991e-17
C35 (\9\:B VSS) capacitor c=6.2418e-17
C36 (\7\:CI VSS) capacitor c=4.08075e-17
C37 (\6\:A VSS) capacitor c=7.56648e-17
C38 (\6\:B VSS) capacitor c=8.51157e-17
C39 (\3\:CI VSS) capacitor c=4.06761e-17
C40 (\3\:B VSS) capacitor c=6.23183e-17
C41 (\3\:A VSS) capacitor c=4.50607e-17
C42 (\3\:COb VSS) capacitor c=3.50594e-17
C43 (\2\:Sb VSS) capacitor c=4.41245e-17
C44 (\11\:A VSS) capacitor c=8.51942e-17
C45 (\11\:B VSS) capacitor c=1.00319e-16
C46 (\9\:CI VSS) capacitor c=8.79454e-17
C47 (\6\:COb VSS) capacitor c=7.7396e-17
C48 (\8\:A VSS) capacitor c=6.09429e-17
C49 (\8\:B VSS) capacitor c=6.52422e-17
C50 (\6\:CI VSS) capacitor c=6.86721e-17
C51 (\5\:A VSS) capacitor c=8.54892e-17
C52 (\5\:B VSS) capacitor c=9.3236e-17
C53 (\1\:CI VSS) capacitor c=3.22661e-17
C54 (\2\:B VSS) capacitor c=6.96542e-17
C55 (\2\:A VSS) capacitor c=5.78554e-17
C56 (\1\:S VSS) capacitor c=3.16731e-17
C57 (\1\:VDD VSS) capacitor c=5.88099e-17
C58 (\7\:Sb VSS) capacitor c=1.08239e-16
C59 (\13\:VDD VSS) capacitor c=1.35571e-17
C60 (\3\:n5 VSS) capacitor c=6.86923e-17
C61 (\15\:VDD VSS) capacitor c=7.73761e-18
C62 (\12\:COb VSS) capacitor c=2.38226e-17
C63 (\17\:VDD VSS) capacitor c=1.2528e-17
C64 (\3\:n3 VSS) capacitor c=5.89506e-17
C65 (\19\:VDD VSS) capacitor c=2.73436e-17
C66 (\1\:CO VSS) capacitor c=3.3742e-17
C67 (\3\:VDD VSS) capacitor c=8.84522e-17
C68 (\3\:S VSS) capacitor c=7.42176e-17
C69 (\4\:Sb VSS) capacitor c=1.28263e-16
C70 (\3\:n4 VSS) capacitor c=8.18074e-17
C71 (\14\:COb VSS) capacitor c=1.53831e-16
C72 (\3\:n2 VSS) capacitor c=9.47729e-17
C73 (\3\:CO VSS) capacitor c=4.55275e-17
C74 (\2\:COb VSS) capacitor c=1.87979e-17
C75 (\2\:CI VSS) capacitor c=4.45461e-17
C76 (\8\:COb VSS) capacitor c=1.80903e-16
C77 (\9\:COb VSS) capacitor c=2.01744e-16
C78 (\10\:COb VSS) capacitor c=1.91056e-16
C79 (\11\:COb VSS) capacitor c=5.18265e-17
C80 (\11\:CI VSS) capacitor c=1.57591e-16
C81 (\13\:CI VSS) capacitor c=7.28932e-17
C82 (\13\:B VSS) capacitor c=1.12694e-16
C83 (\14\:B VSS) capacitor c=1.0967e-16
C84 (\15\:B VSS) capacitor c=1.2301e-16
C85 (\16\:B VSS) capacitor c=6.8993e-17
C86 (\13\:A VSS) capacitor c=1.77462e-16
C87 (\14\:A VSS) capacitor c=9.10753e-17
C88 (\15\:A VSS) capacitor c=1.29669e-16
C89 (\16\:A VSS) capacitor c=1.4608e-16
C90 (\6\:Sb VSS) capacitor c=1.73599e-16
C91 (\5\:VDD VSS) capacitor c=8.71484e-18
C92 (\11\:VDD VSS) capacitor c=2.31931e-18
Rk20 (\13\:A A) resistor r=0.4796 c=0
Rk19 (\13\:A \14\:A) resistor r=0.7021 c=0
Rk21 (A \15\:A) resistor r=0.2359 c=0
Rk22 (\15\:A \16\:A) resistor r=0.7149 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.3402 c=0
Rk28 (\4\:VSS \5\:VSS) resistor r=0.2812 c=0
Rk29 (\5\:VSS \6\:VSS) resistor r=0.1204 c=0
Rk30 (\6\:VSS \7\:VSS) resistor r=0.1003 c=0
Rk31 (\7\:VSS \8\:VSS) resistor r=0.3515 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.1087 c=0
Rk33 (\7\:VSS \12\:VSS) resistor r=0.189 c=0
Rk35 (\13\:VSS VSS) resistor r=0.1026 c=0
Rk34 (\8\:VSS \13\:VSS) resistor r=0.1988 c=0
Rk36 (\8\:VSS \15\:VSS) resistor r=0.2415 c=0
Rk37 (\13\:VSS \17\:VSS) resistor r=0.4242 c=0
Rk15 (\13\:B B) resistor r=0.5524 c=0
Rk16 (B \14\:B) resistor r=0.2651 c=0
Rk17 (\14\:B \15\:B) resistor r=0.5802 c=0
Rk18 (\15\:B \16\:B) resistor r=0.3774 c=0
Rk1 (\2\:CO CO) resistor r=0.168 c=0
Rk2 (CO \4\:CO) resistor r=0.3521 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.4917 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.3025 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.09898 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.08523 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.2159 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.1857 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.06513 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.09779 c=0
Rk47 (\12\:VDD VDD) resistor r=0.05 c=0
Rk46 (\11\:VDD \12\:VDD) resistor r=0.05256 c=0
Rk48 (\5\:VDD \14\:VDD) resistor r=0.1133 c=0
Rk49 (\7\:VDD \16\:VDD) resistor r=0.1188 c=0
Rk50 (\9\:VDD \18\:VDD) resistor r=0.1154 c=0
Rk51 (\11\:VDD \20\:VDD) resistor r=0.1706 c=0
Rk25 (\2\:S S) resistor r=0.1218 c=0
Rk26 (S \4\:S) resistor r=0.5035 c=0
Rk12 (\11\:CI CI) resistor r=0.8769 c=0
Rk13 (CI \12\:CI) resistor r=0.002725 c=0
Rk14 (CI \13\:CI) resistor r=0.364 c=0
Rk7 (\8\:COb \9\:COb) resistor r=1.113 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.6087 c=0
Rk9 (\10\:COb \11\:COb) resistor r=0.2346 c=0
Rk10 (\9\:COb \13\:COb) resistor r=0.0716 c=0
Rk11 (\10\:COb \15\:COb) resistor r=1.0491 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.5995 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.3718 c=0
Rk23 (\5\:Sb \6\:Sb) resistor r=0.7375 c=0
Rk24 (\6\:Sb \8\:Sb) resistor r=0.634 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.338 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.3676 c=0
Rl28 (\11\:A \12\:A) resistor r=150.223 c=0
Rl27 (\10\:A \11\:A) resistor r=81.8672 c=0
Rl20 (\8\:A \9\:A) resistor r=162.694 c=0
Rl19 (\7\:A \8\:A) resistor r=72.3097 c=0
Rl13 (\4\:A \5\:A) resistor r=74.2328 c=0
Rl14 (\5\:A \6\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=74.2328 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl26 (\11\:B \12\:B) resistor r=116.54 c=0
Rl25 (\10\:B \11\:B) resistor r=126.234 c=0
Rl17 (\7\:B \8\:B) resistor r=28.079 c=0
Rl18 (\8\:B \9\:B) resistor r=206.925 c=0
Rl11 (\4\:B \5\:B) resistor r=28.079 c=0
Rl12 (\5\:B \6\:B) resistor r=206.925 c=0
Rl6 (\1\:B \2\:B) resistor r=28.079 c=0
Rl7 (\2\:B \3\:B) resistor r=206.925 c=0
Rl24 (\9\:CI \10\:CI) resistor r=214.401 c=0
Rl23 (\8\:CI \9\:CI) resistor r=28.8462 c=0
Rl15 (\5\:CI \6\:CI) resistor r=139.56 c=0
Rl16 (\6\:CI \7\:CI) resistor r=91.4826 c=0
Rl10 (\2\:CI \4\:CI) resistor r=129.649 c=0
Rl9 (\2\:CI \3\:CI) resistor r=123.88 c=0
Rl8 (\1\:CI \2\:CI) resistor r=3.1216 c=0
Rl22 (\6\:COb \7\:COb) resistor r=37.6365 c=0
Rl21 (\5\:COb \6\:COb) resistor r=199.969 c=0
Rl1 (COb \2\:COb) resistor r=2.0213 c=0
Rl3 (\2\:COb \4\:COb) resistor r=49.7141 c=0
Rl2 (\2\:COb \3\:COb) resistor r=113.176 c=0
Rl29 (Sb \2\:Sb) resistor r=56.8672 c=0
Rl30 (\2\:Sb \3\:Sb) resistor r=110.713 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=37.5 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=18.75 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=75 c=0
Rz18 (\3\:VDD \12\:VDD) resistor r=37.5 c=0
Rz8 (\3\:S \4\:S) resistor r=37.5 c=0
Rz6 (\14\:COb \15\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz7 (\4\:Sb \5\:Sb) resistor r=75 c=0
Ry9 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry10 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry11 (\3\:VSS \8\:VSS) resistor r=8.8571 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry8 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry6 (\12\:COb \13\:COb) resistor r=62 c=0
Ry7 (\7\:Sb \8\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\5\:A \13\:A) resistor r=45 c=0
Rx11 (\2\:A \14\:A) resistor r=45 c=0
Rx12 (\8\:A \15\:A) resistor r=45 c=0
Rx13 (\11\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\9\:CI \11\:CI) resistor r=45 c=0
Rx4 (\6\:CI \12\:CI) resistor r=45 c=0
Rx5 (\1\:CI \13\:CI) resistor r=45 c=0
Rx1 (\6\:COb \8\:COb) resistor r=45 c=0
Rx2 (COb \11\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.22e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.23846e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn2 (\3\:n2 \3\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=1.93e-14 ps=9.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n2 \3\:B \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.38103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\14\:COb \3\:CI n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43103e-07 sb=1.95e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\14\:COb \6\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.48103e-07 sb=1.745e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \6\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=8.7e-15 ps=9.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.53103e-07 sb=1.64e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \7\:CI \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0581e-06 sb=1.435e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \9\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2631e-06 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5281e-06 sb=9.65e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn8 (\4\:Sb \5\:COb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7331e-06 sb=7.6e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9381e-06 sb=5.55e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn10 (n7 \10\:B n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=6.83173 scb=0.00357784 scc=2.82929e-05 \
        m=(1)
mn9 (n6 \10\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn13 (\3\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mp2 (\3\:n3 \1\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.91e-14 ps=1.59e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35349e-07 sb=2e-06 sd=160n sca=14.1415 \
        scb=0.0126578 scc=0.000426771 m=(1)
mp3 (n3 \1\:B \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.44e-14 ps=1.59e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.30349e-07 sb=2e-06 sd=160n sca=13.1633 \
        scb=0.0118398 scc=0.00042523 m=(1)
mp4 (\12\:COb \4\:CI n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35349e-07 sb=1.95e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\12\:COb \4\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.40349e-07 sb=1.745e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (n1 \4\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45349e-07 sb=1.64e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (\3\:n5 \5\:CI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=3.44e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05035e-06 sb=1.435e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\3\:n5 \7\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25535e-06 sb=1.23e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=1e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp8 (\7\:Sb \7\:COb n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69035e-06 sb=7.95e-07 sd=160n sca=12.9421 \
        scb=0.0117495 scc=0.000425199 m=(1)
mp11 (\7\:Sb \10\:CI n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89535e-06 sb=5.9e-07 sd=160n sca=13.7253 \
        scb=0.0122307 scc=0.000425663 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.99593e-06 sb=4.85e-07 sd=160n sca=14.4668 scb=0.0130588 \
        scc=0.000428492 m=(1)
mp9 (n8 \12\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.29e-14 ps=1.17e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.8e-07 sd=160n sca=15.7217 scb=0.0149728 \
        scc=0.00044748 m=(1)
mp13 (\1\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=5.46e-14 ps=1.17e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15032e-06 sb=1.4e-07 sd=160n sca=26.7686 \
        scb=0.0307018 scc=0.00196241 m=(1)
ends ADDFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 12:58:26 2012 )
// Library name: gsclib045
// Cell name: ADDFX2
// View name: extracted

simulator lang=spectre

subckt ADDFX2 A B CI CO S VDD VSS
mp12_1__rcx (\1\:CO COb VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.0983 \
        scb=0.0376779 scc=0.00400735 m=(2)
C1 (A VSS) capacitor c=3.35773e-17
C2 (CO VSS) capacitor c=3.30511e-17
C3 (B VSS) capacitor c=3.72937e-17
C4 (VDD VSS) capacitor c=3.34532e-16
C5 (S VSS) capacitor c=5.02749e-17
C6 (CI VSS) capacitor c=7.90448e-17
C7 (COb VSS) capacitor c=9.61663e-17
C8 (n2 VSS) capacitor c=6.61996e-17
C9 (n4 VSS) capacitor c=7.75144e-17
C10 (Sb VSS) capacitor c=6.66049e-17
C11 (n7 VSS) capacitor c=1.94584e-18
C12 (n6 VSS) capacitor c=2.27739e-18
C13 (n3 VSS) capacitor c=6.35292e-17
C14 (n5 VSS) capacitor c=7.30705e-17
C15 (n9 VSS) capacitor c=1.27798e-18
C16 (n8 VSS) capacitor c=1.94624e-18
C17 (\10\:A VSS) capacitor c=6.48582e-17
C18 (\11\:B VSS) capacitor c=8.65759e-17
C19 (\8\:CI VSS) capacitor c=1.25021e-16
C20 (\8\:COb VSS) capacitor c=2.18495e-17
C21 (\9\:A VSS) capacitor c=5.68119e-17
C22 (\10\:B VSS) capacitor c=4.30055e-17
C23 (\7\:CI VSS) capacitor c=5.24665e-17
C24 (\6\:A VSS) capacitor c=6.55518e-17
C25 (\7\:B VSS) capacitor c=4.94901e-17
C26 (\1\:CI VSS) capacitor c=4.86371e-17
C27 (\4\:B VSS) capacitor c=4.34108e-17
C28 (\1\:A VSS) capacitor c=3.74337e-17
C29 (\12\:A VSS) capacitor c=4.84175e-17
C30 (\13\:B VSS) capacitor c=8.69074e-17
C31 (\11\:CI VSS) capacitor c=4.5701e-17
C32 (\10\:COb VSS) capacitor c=5.3484e-17
C33 (\7\:A VSS) capacitor c=4.34393e-17
C34 (\8\:B VSS) capacitor c=5.43221e-17
C35 (\5\:CI VSS) capacitor c=2.58978e-17
C36 (\4\:A VSS) capacitor c=5.58639e-17
C37 (\5\:B VSS) capacitor c=8.564e-17
C38 (\3\:CI VSS) capacitor c=2.54444e-17
C39 (\3\:B VSS) capacitor c=5.10737e-17
C40 (\3\:A VSS) capacitor c=3.71643e-17
C41 (\4\:Sb VSS) capacitor c=1.52325e-17
C42 (\11\:A VSS) capacitor c=6.8451e-17
C43 (\12\:B VSS) capacitor c=9.10526e-17
C44 (\10\:CI VSS) capacitor c=2.04868e-17
C45 (\11\:COb VSS) capacitor c=4.91813e-17
C46 (\8\:A VSS) capacitor c=6.71725e-17
C47 (\9\:B VSS) capacitor c=5.79621e-17
C48 (\6\:CI VSS) capacitor c=4.43419e-17
C49 (\5\:A VSS) capacitor c=6.32284e-17
C50 (\6\:B VSS) capacitor c=5.53246e-17
C51 (\4\:CI VSS) capacitor c=3.89145e-17
C52 (\1\:B VSS) capacitor c=2.36426e-17
C53 (\2\:A VSS) capacitor c=2.88477e-17
C54 (\6\:COb VSS) capacitor c=7.46612e-18
C55 (\1\:VDD VSS) capacitor c=9.77971e-17
C56 (\3\:S VSS) capacitor c=5.45475e-17
C57 (\8\:Sb VSS) capacitor c=1.23063e-17
C58 (\16\:Sb VSS) capacitor c=4.38087e-17
C59 (\13\:VDD VSS) capacitor c=1.34744e-17
C60 (\3\:n5 VSS) capacitor c=7.42776e-17
C61 (\15\:VDD VSS) capacitor c=1.07532e-17
C62 (\17\:COb VSS) capacitor c=1.93279e-17
C63 (\19\:COb VSS) capacitor c=1.30828e-17
C64 (\17\:VDD VSS) capacitor c=1.15727e-17
C65 (\3\:n3 VSS) capacitor c=6.58259e-17
C66 (\1\:CO VSS) capacitor c=6.49861e-17
C67 (\4\:VDD VSS) capacitor c=6.3515e-17
C68 (\1\:S VSS) capacitor c=1.90592e-17
C69 (\12\:Sb VSS) capacitor c=7.80965e-17
C70 (\14\:Sb VSS) capacitor c=4.60313e-17
C71 (\3\:n4 VSS) capacitor c=7.45722e-17
C72 (\24\:COb VSS) capacitor c=6.1993e-17
C73 (\22\:COb VSS) capacitor c=4.04993e-17
C74 (\3\:n2 VSS) capacitor c=6.86735e-17
C75 (\4\:CO VSS) capacitor c=1.594e-17
C76 (\2\:B VSS) capacitor c=3.18394e-17
C77 (\2\:CI VSS) capacitor c=3.41986e-17
C78 (\9\:COb VSS) capacitor c=3.84803e-17
C79 (\9\:CI VSS) capacitor c=5.83978e-17
C80 (\3\:Sb VSS) capacitor c=6.39954e-17
C81 (\3\:CO VSS) capacitor c=1.73669e-17
C82 (\12\:COb VSS) capacitor c=1.99001e-16
C83 (\13\:COb VSS) capacitor c=1.28596e-16
C84 (\14\:COb VSS) capacitor c=1.07514e-16
C85 (\15\:COb VSS) capacitor c=1.58833e-16
C86 (\16\:COb VSS) capacitor c=2.44148e-17
C87 (\21\:COb VSS) capacitor c=1.30514e-16
C88 (\12\:CI VSS) capacitor c=1.43686e-16
C89 (\13\:CI VSS) capacitor c=1.89269e-16
C90 (\14\:CI VSS) capacitor c=3.05142e-17
C91 (\14\:B VSS) capacitor c=1.46906e-16
C92 (\15\:B VSS) capacitor c=1.69326e-16
C93 (\16\:B VSS) capacitor c=6.133e-17
C94 (\17\:B VSS) capacitor c=7.30101e-17
C95 (\18\:B VSS) capacitor c=9.13563e-17
C96 (\13\:A VSS) capacitor c=1.32283e-16
C97 (\14\:A VSS) capacitor c=2.11864e-16
C98 (\15\:A VSS) capacitor c=2.09264e-16
C99 (\16\:A VSS) capacitor c=1.40533e-16
C100 (\10\:Sb VSS) capacitor c=8.42541e-17
C101 (\11\:Sb VSS) capacitor c=1.85997e-16
C102 (\6\:VDD VSS) capacitor c=2.02348e-17
C103 (\7\:VDD VSS) capacitor c=1.71769e-17
C104 (\9\:VDD VSS) capacitor c=1.62829e-17
Rk25 (\13\:A A) resistor r=0.06533 c=0
Rk26 (\13\:A \14\:A) resistor r=0.7932 c=0
Rk27 (\14\:A \15\:A) resistor r=0.6933 c=0
Rk28 (\15\:A \16\:A) resistor r=0.8404 c=0
Rk2 (\3\:CO CO) resistor r=0.1357 c=0
Rk1 (\2\:CO \3\:CO) resistor r=0.2202 c=0
Rk3 (\3\:CO \5\:CO) resistor r=0.1623 c=0
Rk20 (\14\:B \15\:B) resistor r=0.8613 c=0
Rk24 (\16\:B B) resistor r=0.09945 c=0
Rk21 (\15\:B \16\:B) resistor r=0.4055 c=0
Rk22 (\16\:B \17\:B) resistor r=0.1781 c=0
Rk23 (\17\:B \18\:B) resistor r=0.4817 c=0
Rk37 (\1\:VDD \5\:VDD) resistor r=0.2556 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.3826 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.2419 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.2757 c=0
Rk42 (\9\:VDD VDD) resistor r=0.2255 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.3258 c=0
Rk44 (\6\:VDD \14\:VDD) resistor r=0.04331 c=0
Rk45 (\7\:VDD \16\:VDD) resistor r=0.07393 c=0
Rk46 (\9\:VDD \18\:VDD) resistor r=0.07393 c=0
Rk34 (\2\:S S) resistor r=0.1254 c=0
Rk35 (S \4\:S) resistor r=0.2559 c=0
Rk51 (\1\:VSS \5\:VSS) resistor r=0.1202 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.4763 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.1252 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.1628 c=0
Rk59 (\9\:VSS VSS) resistor r=0.2957 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.54 c=0
Rk57 (\6\:VSS \13\:VSS) resistor r=0.1026 c=0
Rk58 (\8\:VSS \15\:VSS) resistor r=0.2029 c=0
Rk61 (\9\:VSS \18\:VSS) resistor r=0.07147 c=0
Rk18 (\13\:CI CI) resistor r=0.5487 c=0
Rk17 (\12\:CI \13\:CI) resistor r=0.8562 c=0
Rk19 (CI \14\:CI) resistor r=0.01762 c=0
Rk8 (\12\:COb \13\:COb) resistor r=1.326 c=0
Rk9 (\13\:COb \14\:COb) resistor r=0.2254 c=0
Rk10 (\14\:COb \15\:COb) resistor r=0.8921 c=0
Rk11 (\15\:COb \16\:COb) resistor r=0.1482 c=0
Rk12 (\13\:COb \18\:COb) resistor r=0.07468 c=0
Rk13 (\14\:COb \20\:COb) resistor r=0.07468 c=0
Rk14 (\15\:COb \21\:COb) resistor r=0.9012 c=0
Rk15 (\21\:COb \23\:COb) resistor r=0.115 c=0
Rk16 (\21\:COb \25\:COb) resistor r=0.2821 c=0
Rk5 (\2\:n2 \4\:n2) resistor r=0.2358 c=0
Rk7 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk29 (\9\:Sb \10\:Sb) resistor r=0.0279 c=0
Rk30 (\10\:Sb \11\:Sb) resistor r=0.789 c=0
Rk31 (\11\:Sb \13\:Sb) resistor r=0.6146 c=0
Rk32 (\13\:Sb \15\:Sb) resistor r=0.1664 c=0
Rk33 (\10\:Sb \17\:Sb) resistor r=0.1905 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.2358 c=0
Rk6 (\2\:n5 \4\:n5) resistor r=0.2358 c=0
Rl33 (\10\:A \11\:A) resistor r=162.23 c=0
Rl34 (\11\:A \12\:A) resistor r=100.692 c=0
Rl24 (\8\:A \9\:A) resistor r=132.669 c=0
Rl23 (\7\:A \8\:A) resistor r=84.4104 c=0
Rl18 (\5\:A \6\:A) resistor r=83.9406 c=0
Rl17 (\4\:A \5\:A) resistor r=89.6422 c=0
Rl7 (\1\:A \2\:A) resistor r=58.3841 c=0
Rl8 (\2\:A \3\:A) resistor r=29.5379 c=0
Rl31 (\11\:B \12\:B) resistor r=112.23 c=0
Rl32 (\12\:B \13\:B) resistor r=150.692 c=0
Rl22 (\9\:B \10\:B) resistor r=26.3736 c=0
Rl21 (\8\:B \9\:B) resistor r=151.923 c=0
Rl16 (\6\:B \7\:B) resistor r=24.2328 c=0
Rl15 (\5\:B \6\:B) resistor r=164.183 c=0
Rl11 (\2\:B \4\:B) resistor r=37.3411 c=0
Rl10 (\2\:B \3\:B) resistor r=96.9565 c=0
Rl9 (\1\:B \2\:B) resistor r=0.6084 c=0
Rl20 (\6\:CI \7\:CI) resistor r=149.451 c=0
Rl19 (\5\:CI \6\:CI) resistor r=28.8462 c=0
Rl12 (\1\:CI \2\:CI) resistor r=112.695 c=0
Rl13 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl14 (\2\:CI \4\:CI) resistor r=120.348 c=0
Rl28 (\8\:CI \9\:CI) resistor r=235.905 c=0
Rl30 (\9\:CI \11\:CI) resistor r=49.1216 c=0
Rl29 (\9\:CI \10\:CI) resistor r=10.5855 c=0
Rl5 (COb \6\:COb) resistor r=9.5287 c=0
Rl25 (\9\:COb \8\:COb) resistor r=35.772 c=0
Rl26 (\9\:COb \10\:COb) resistor r=187.695 c=0
Rl27 (\9\:COb \11\:COb) resistor r=97.2715 c=0
Rl36 (\3\:Sb Sb) resistor r=79.8492 c=0
Rl37 (\3\:Sb \4\:Sb) resistor r=4.3693 c=0
Rz1 (\5\:CO \4\:CO) resistor r=75 c=0
Rz13 (VDD \4\:VDD) resistor r=15 c=0
Rz11 (\5\:VDD \4\:VDD) resistor r=6.25 c=0
Rz12 (\8\:VDD \4\:VDD) resistor r=12.5 c=0
Rz10 (\2\:S \1\:S) resistor r=75 c=0
Rz16 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz6 (\23\:COb \22\:COb) resistor r=75 c=0
Rz7 (\25\:COb \24\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\13\:Sb \12\:Sb) resistor r=75 c=0
Rz9 (\15\:Sb \14\:Sb) resistor r=75 c=0
Ry1 (\2\:CO \1\:CO) resistor r=20.6667 c=0
Ry13 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry10 (\4\:S \3\:S) resistor r=62 c=0
Ry18 (\5\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry19 (\7\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry20 (\9\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry6 (\18\:COb \17\:COb) resistor r=62 c=0
Ry7 (\20\:COb \19\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \8\:Sb) resistor r=62 c=0
Ry9 (\17\:Sb \16\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\6\:B \17\:B) resistor r=45 c=0
Rx9 (\1\:B \18\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\12\:COb \11\:COb) resistor r=45 c=0
Rx2 (\16\:COb \6\:COb) resistor r=45 c=0
Rx14 (\11\:Sb \4\:Sb) resistor r=45 c=0
mn12_1__rcx (\4\:CO COb VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (\3\:n2 \3\:A \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.48966e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn3 (n2 \3\:B \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=2.32e-14 ps=1.49e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.86379e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (\22\:COb \3\:CI n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.91379e-07 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\24\:COb \5\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn0 (n0 \4\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=8.7e-15 ps=8.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.185e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn7 (\3\:n4 \5\:CI \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.278e-14 ad=2.32e-14 ps=8.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=8.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn6 (\3\:n4 \8\:B \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.32e-14 ps=1.13e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn8 (\14\:Sb \10\:COb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=1.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn5 (n4 \7\:A \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.755e-14 ps=1.13e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=3.75e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn11 (\12\:Sb \11\:CI n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.3e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn10 (n7 \13\:B n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.305e-14 \
        ad=8.7e-15 ps=4.7e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.25e-07 sd=160n sca=7.47547 scb=0.00467957 \
        scc=5.27432e-05 m=(1)
mn9 (n6 \12\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.5e-14 ad=1.305e-14 ps=1.12e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.9e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn13_1__rcx (\1\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.57e-14 ad=4.16e-14 ps=9.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.48558e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
mp2 (\3\:n3 \1\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=3.01e-14 ps=2.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.37674e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp3 (n3 \4\:B \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=3.44e-14 ps=2.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80349e-07 sb=3.45e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp4 (\19\:COb \1\:CI n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.85349e-07 sb=1.4e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp1 (\17\:COb \7\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18907e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp0 (n1 \6\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.723e-14 ad=1.29e-14 ps=2.11e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.08407e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp7 (\3\:n5 \7\:CI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.723e-14 ad=3.44e-14 ps=2.11e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=7.3407e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp6 (\3\:n5 \10\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=5.2907e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=7.202e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.24419e-07 sb=5.2e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp8 (\16\:Sb \8\:COb n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.202e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10442e-06 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp11 (\8\:Sb \8\:CI n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.3e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp10 (n9 \11\:B n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.935e-14 \
        ad=1.29e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.25e-07 sd=160n sca=10.46 scb=0.0077219 \
        scc=9.29465e-05 m=(1)
mp9 (n8 \10\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.2e-14 ad=1.935e-14 ps=1.38e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.9e-07 sd=160n sca=10.848 scb=0.0078767 \
        scc=9.30025e-05 m=(1)
mp13_1__rcx (\3\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.44551e-07 sb=3.45e-07 sd=160n sca=17.8374 \
        scb=0.0170197 scc=0.000849186 m=(2)
ends ADDFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 12:59:03 2012 )
// Library name: gsclib045
// Cell name: ADDFX4
// View name: extracted

simulator lang=spectre

subckt ADDFX4 A B CI CO S VDD VSS
mp12_1__rcx (\1\:CO COb \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=37.1131 scb=0.03221 \
        scc=0.00363789 m=(4)
C1 (A VSS) capacitor c=1.06028e-16
C2 (B VSS) capacitor c=6.85247e-17
C3 (CO VSS) capacitor c=1.34805e-17
C4 (VDD VSS) capacitor c=2.5692e-16
C5 (S VSS) capacitor c=1.52681e-17
C6 (CI VSS) capacitor c=8.88231e-17
C7 (COb VSS) capacitor c=2.81272e-16
C8 (n2 VSS) capacitor c=8.95462e-17
C9 (n0 VSS) capacitor c=1.23995e-18
C10 (n4 VSS) capacitor c=8.09696e-17
C11 (Sb VSS) capacitor c=2.95539e-16
C12 (n7 VSS) capacitor c=1.61961e-18
C13 (n6 VSS) capacitor c=3.27294e-18
C14 (n3 VSS) capacitor c=6.39387e-17
C15 (n1 VSS) capacitor c=2.07034e-18
C16 (n5 VSS) capacitor c=8.07899e-17
C17 (n9 VSS) capacitor c=3.59321e-18
C18 (n8 VSS) capacitor c=3.22966e-18
C19 (\10\:A VSS) capacitor c=6.96874e-17
C20 (\12\:B VSS) capacitor c=7.08016e-17
C21 (\12\:CI VSS) capacitor c=7.57386e-17
C22 (\13\:COb VSS) capacitor c=3.57435e-17
C23 (\7\:A VSS) capacitor c=7.20271e-17
C24 (\11\:B VSS) capacitor c=5.50043e-17
C25 (\5\:CI VSS) capacitor c=7.19723e-17
C26 (\6\:A VSS) capacitor c=8.98701e-17
C27 (\7\:B VSS) capacitor c=7.15459e-17
C28 (\1\:CI VSS) capacitor c=5.34565e-17
C29 (\1\:B VSS) capacitor c=5.652e-17
C30 (\1\:A VSS) capacitor c=5.82268e-17
C31 (\12\:A VSS) capacitor c=4.82108e-17
C32 (\14\:B VSS) capacitor c=9.41004e-17
C33 (\9\:CI VSS) capacitor c=5.95552e-17
C34 (\15\:COb VSS) capacitor c=6.03615e-17
C35 (\9\:A VSS) capacitor c=5.02092e-17
C36 (\10\:B VSS) capacitor c=5.96451e-17
C37 (\8\:CI VSS) capacitor c=3.73575e-17
C38 (\4\:A VSS) capacitor c=7.87912e-17
C39 (\4\:B VSS) capacitor c=8.88717e-17
C40 (\3\:CI VSS) capacitor c=3.19267e-17
C41 (\3\:B VSS) capacitor c=5.42063e-17
C42 (\3\:A VSS) capacitor c=3.93293e-17
C43 (\11\:A VSS) capacitor c=4.22166e-17
C44 (\13\:B VSS) capacitor c=5.92853e-17
C45 (\11\:CI VSS) capacitor c=3.38895e-17
C46 (\16\:COb VSS) capacitor c=3.40075e-17
C47 (\8\:A VSS) capacitor c=5.22135e-17
C48 (\8\:B VSS) capacitor c=3.00208e-17
C49 (\7\:CI VSS) capacitor c=5.27559e-17
C50 (\5\:A VSS) capacitor c=6.16425e-17
C51 (\6\:B VSS) capacitor c=1.64751e-17
C52 (\4\:CI VSS) capacitor c=4.10318e-17
C53 (\2\:B VSS) capacitor c=3.68483e-17
C54 (\2\:A VSS) capacitor c=2.64068e-17
C55 (\22\:Sb VSS) capacitor c=7.409e-17
C56 (\24\:Sb VSS) capacitor c=6.06533e-17
C57 (\23\:VDD VSS) capacitor c=1.74088e-17
C58 (\3\:n5 VSS) capacitor c=9.50056e-17
C59 (\25\:VDD VSS) capacitor c=1.56255e-17
C60 (\18\:COb VSS) capacitor c=1.25467e-16
C61 (\24\:COb VSS) capacitor c=3.43749e-17
C62 (\3\:n3 VSS) capacitor c=8.3402e-17
C63 (\27\:VDD VSS) capacitor c=1.64098e-17
C64 (\1\:CO VSS) capacitor c=1.94493e-16
C65 (\1\:VDD VSS) capacitor c=1.17922e-16
C66 (\2\:S VSS) capacitor c=1.12091e-16
C67 (\18\:Sb VSS) capacitor c=9.82405e-17
C68 (\20\:Sb VSS) capacitor c=5.89726e-17
C69 (\3\:n4 VSS) capacitor c=7.9281e-17
C70 (\27\:COb VSS) capacitor c=6.11286e-17
C71 (\29\:COb VSS) capacitor c=1.56272e-17
C72 (\3\:n2 VSS) capacitor c=7.76519e-17
C73 (\6\:CO VSS) capacitor c=1.03783e-16
C74 (\2\:CI VSS) capacitor c=3.42557e-17
C75 (\5\:B VSS) capacitor c=3.60721e-17
C76 (\9\:B VSS) capacitor c=2.72344e-17
C77 (\14\:COb VSS) capacitor c=3.5157e-17
C78 (\10\:CI VSS) capacitor c=4.76252e-17
C79 (\17\:COb VSS) capacitor c=1.74543e-16
C80 (\20\:COb VSS) capacitor c=1.02053e-16
C81 (\21\:COb VSS) capacitor c=1.88787e-16
C82 (\26\:COb VSS) capacitor c=1.50936e-16
C83 (\13\:CI VSS) capacitor c=1.50337e-16
C84 (\14\:CI VSS) capacitor c=1.87737e-16
C85 (\15\:B VSS) capacitor c=1.27843e-16
C86 (\16\:B VSS) capacitor c=2.0793e-16
C87 (\17\:B VSS) capacitor c=7.53019e-17
C88 (\18\:B VSS) capacitor c=7.70592e-17
C89 (\13\:A VSS) capacitor c=3.78723e-17
C90 (\14\:A VSS) capacitor c=1.83377e-16
C91 (\15\:A VSS) capacitor c=2.15942e-16
C92 (\16\:A VSS) capacitor c=1.38603e-16
C93 (\17\:Sb VSS) capacitor c=1.49755e-16
C94 (\1\:S VSS) capacitor c=2.99562e-17
C95 (\6\:S VSS) capacitor c=1.94307e-16
C96 (\3\:VDD VSS) capacitor c=1.50999e-16
C97 (\7\:VDD VSS) capacitor c=3.34992e-17
C98 (\9\:VDD VSS) capacitor c=2.09432e-17
C99 (\11\:VDD VSS) capacitor c=1.27497e-16
Rk27 (\13\:A A) resistor r=0.08561 c=0
Rk28 (A \14\:A) resistor r=0.7093 c=0
Rk29 (\14\:A \15\:A) resistor r=0.6289 c=0
Rk30 (\15\:A \16\:A) resistor r=0.9088 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.04996 c=0
Rk47 (\3\:VSS \7\:VSS) resistor r=0.2004 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.4437 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.1076 c=0
Rk50 (\9\:VSS \10\:VSS) resistor r=0.09761 c=0
Rk51 (\10\:VSS \11\:VSS) resistor r=0.4537 c=0
Rk52 (\11\:VSS \12\:VSS) resistor r=0.1167 c=0
Rk58 (\13\:VSS VSS) resistor r=0.03215 c=0
Rk53 (\12\:VSS \13\:VSS) resistor r=0.3347 c=0
Rk63 (\8\:VSS \26\:VSS) resistor r=0.1026 c=0
Rk64 (\10\:VSS \28\:VSS) resistor r=0.1742 c=0
Rk65 (\12\:VSS \30\:VSS) resistor r=0.04331 c=0
Rk24 (\16\:B B) resistor r=0.6363 c=0
Rk23 (\15\:B \16\:B) resistor r=0.814 c=0
Rk25 (B \17\:B) resistor r=0.06364 c=0
Rk26 (\17\:B \18\:B) resistor r=0.534 c=0
Rk2 (\1\:CO CO) resistor r=0.242 c=0
Rk4 (CO \6\:CO) resistor r=0.05252 c=0
Rk69 (\2\:VDD \3\:VDD) resistor r=0.05498 c=0
Rk73 (\3\:VDD \7\:VDD) resistor r=0.6286 c=0
Rk74 (\7\:VDD \8\:VDD) resistor r=0.2224 c=0
Rk75 (\8\:VDD \9\:VDD) resistor r=0.57 c=0
Rk76 (\9\:VDD \10\:VDD) resistor r=0.1829 c=0
Rk82 (\11\:VDD VDD) resistor r=0.03215 c=0
Rk77 (\10\:VDD \11\:VDD) resistor r=0.1678 c=0
Rk87 (\7\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk88 (\8\:VDD \26\:VDD) resistor r=0.07147 c=0
Rk89 (\9\:VDD \28\:VDD) resistor r=0.07393 c=0
Rk37 (S \1\:S) resistor r=0.007742 c=0
Rk38 (\1\:S \2\:S) resistor r=0.1493 c=0
Rk40 (\1\:S \6\:S) resistor r=0.324 c=0
Rk20 (\14\:CI CI) resistor r=0.4248 c=0
Rk19 (\13\:CI \14\:CI) resistor r=0.8934 c=0
Rk21 (CI \15\:CI) resistor r=0.003053 c=0
Rk22 (\14\:CI \16\:CI) resistor r=0.04261 c=0
Rk10 (\17\:COb \19\:COb) resistor r=1.1276 c=0
Rk11 (\19\:COb \20\:COb) resistor r=0.2594 c=0
Rk13 (\21\:COb COb) resistor r=0.3988 c=0
Rk12 (\20\:COb \21\:COb) resistor r=0.8996 c=0
Rk15 (\20\:COb \25\:COb) resistor r=0.04927 c=0
Rk16 (\21\:COb \26\:COb) resistor r=0.949 c=0
Rk17 (\26\:COb \28\:COb) resistor r=0.3306 c=0
Rk18 (\26\:COb \30\:COb) resistor r=0.05759 c=0
Rk7 (\2\:n2 \4\:n2) resistor r=0.2822 c=0
Rk9 (\2\:n4 \4\:n4) resistor r=0.2822 c=0
Rk32 (Sb \17\:Sb) resistor r=0.1901 c=0
Rk33 (\17\:Sb \19\:Sb) resistor r=0.593 c=0
Rk34 (\19\:Sb \21\:Sb) resistor r=0.2807 c=0
Rk35 (\17\:Sb \23\:Sb) resistor r=0.7415 c=0
Rk36 (\23\:Sb \25\:Sb) resistor r=0.2136 c=0
Rk6 (\2\:n3 \4\:n3) resistor r=0.2734 c=0
Rk8 (\2\:n5 \4\:n5) resistor r=0.2822 c=0
Rl39 (\10\:A \11\:A) resistor r=108.384 c=0
Rl40 (\11\:A \12\:A) resistor r=44.9225 c=0
Rl29 (\7\:A \8\:A) resistor r=85.7713 c=0
Rl30 (\8\:A \9\:A) resistor r=62.6944 c=0
Rl22 (\5\:A \6\:A) resistor r=62.8119 c=0
Rl21 (\4\:A \5\:A) resistor r=82.2239 c=0
Rl11 (\1\:A \2\:A) resistor r=66.5405 c=0
Rl12 (\2\:A \3\:A) resistor r=24.2328 c=0
Rl37 (\12\:B \13\:B) resistor r=44.9225 c=0
Rl38 (\13\:B \14\:B) resistor r=108.384 c=0
Rl13 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl14 (\2\:B \3\:B) resistor r=75.6918 c=0
Rl20 (\5\:B \7\:B) resistor r=45.0334 c=0
Rl18 (\4\:B \5\:B) resistor r=127.291 c=0
Rl19 (\5\:B \6\:B) resistor r=3.1183 c=0
Rl28 (\9\:B \11\:B) resistor r=34.3295 c=0
Rl27 (\9\:B \10\:B) resistor r=134.329 c=0
Rl26 (\8\:B \9\:B) resistor r=11.5001 c=0
Rl15 (\1\:CI \2\:CI) resistor r=99.2335 c=0
Rl16 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl17 (\2\:CI \4\:CI) resistor r=132.351 c=0
Rl23 (\5\:CI \6\:CI) resistor r=134.329 c=0
Rl25 (\6\:CI \8\:CI) resistor r=34.3295 c=0
Rl24 (\6\:CI \7\:CI) resistor r=0.5166 c=0
Rl36 (\10\:CI \12\:CI) resistor r=134.297 c=0
Rl34 (\9\:CI \10\:CI) resistor r=48.0548 c=0
Rl35 (\10\:CI \11\:CI) resistor r=68.4415 c=0
Rl31 (\14\:COb \13\:COb) resistor r=28.0797 c=0
Rl32 (\14\:COb \15\:COb) resistor r=145.387 c=0
Rl33 (\14\:COb \16\:COb) resistor r=99.1945 c=0
Rz16 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz17 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz18 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz29 (VDD \1\:VDD) resistor r=75 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz24 (\3\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz25 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz26 (\10\:VDD \1\:VDD) resistor r=25 c=0
Rz28 (\11\:VDD \1\:VDD) resistor r=18.75 c=0
Rz7 (\28\:COb \27\:COb) resistor r=75 c=0
Rz8 (\30\:COb \29\:COb) resistor r=75 c=0
Rz3 (n2 \2\:n2) resistor r=75 c=0
Rz4 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz5 (n4 \2\:n4) resistor r=75 c=0
Rz6 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz9 (\19\:Sb \18\:Sb) resistor r=75 c=0
Rz10 (\21\:Sb \20\:Sb) resistor r=75 c=0
Ry20 (VSS \1\:VSS) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\11\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry18 (\13\:VSS \1\:VSS) resistor r=15.5 c=0
Ry24 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry25 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry7 (\19\:COb \18\:COb) resistor r=62 c=0
Ry8 (\25\:COb \24\:COb) resistor r=20.6667 c=0
Ry9 (\23\:Sb \22\:Sb) resistor r=62 c=0
Ry10 (\25\:Sb \24\:Sb) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n5 \2\:n5) resistor r=62 c=0
Ry6 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx11 (\11\:A \13\:A) resistor r=45 c=0
Rx12 (\8\:A \14\:A) resistor r=45 c=0
Rx13 (\5\:A \15\:A) resistor r=45 c=0
Rx14 (\2\:A \16\:A) resistor r=45 c=0
Rx7 (\13\:B \15\:B) resistor r=45 c=0
Rx8 (\8\:B \16\:B) resistor r=45 c=0
Rx9 (\6\:B \17\:B) resistor r=45 c=0
Rx10 (\2\:B \18\:B) resistor r=45 c=0
Rx4 (\11\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \15\:CI) resistor r=45 c=0
Rx6 (\7\:CI \16\:CI) resistor r=45 c=0
Rx1 (\17\:COb \16\:COb) resistor r=45 c=0
mn12_1__rcx (\6\:CO COb \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn2 (\3\:n2 \3\:A \29\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.64e-14 ps=1.46e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn3 (n2 \3\:B \29\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=4.16e-14 ps=1.46e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.45e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn4 (\29\:COb \3\:CI n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mn1 (\27\:COb \4\:B n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.14e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (n0 \4\:A \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.035e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn7 (\3\:n4 \8\:CI \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn6 (\3\:n4 \10\:B \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.25e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (n4 \9\:A \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=4.16e-14 ps=1.26e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.6e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn8 (\20\:Sb \15\:COb n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn11 (\18\:Sb \9\:CI n7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.22e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23846e-07 sb=1.25e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (n7 \14\:B n6 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.56e-14 ps=7e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.28846e-07 sb=1.145e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn9 (n6 \12\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=2.34e-14 ps=9.2e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.63846e-07 sb=1.01e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn13_1__rcx (\2\:S Sb \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.08846e-07 sb=7.65e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(4)
mp2 (n3 \1\:A \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.70769e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp3 (\3\:n3 \1\:B \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.245e-13 ad=6.24e-14 ps=1.9e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.86923e-07 sb=3.45e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp4 (\24\:COb \1\:CI \3\:n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.91923e-07 sb=1.4e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp1 (\18\:COb \7\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.20192e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp0 (n1 \6\:A \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=2.34e-14 ps=1.8e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.09692e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp7 (\3\:n5 \5\:CI \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.31923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp6 (\3\:n5 \11\:B \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.26923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp5 (n5 \7\:A \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.61923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp8 (\24\:Sb \13\:COb n5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.12e-14 ps=1.1e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.56923e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp11 (\22\:Sb \12\:CI n9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=5.46e-14 ps=1.01e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.295e-06 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.485e-14 ps=9.6e-07 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=1.135e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp9 (n8 \10\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.8e-14 ad=3.51e-14 ps=1.18e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1e-06 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp13_1__rcx (\6\:S Sb \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=7.55e-07 sd=160n sca=14.4678 \
        scb=0.0130219 scc=0.000814276 m=(4)
ends ADDFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 12:59:41 2012 )
// Library name: gsclib045
// Cell name: ADDFXL
// View name: extracted

simulator lang=spectre

subckt ADDFXL A B CI CO S VDD VSS
mp12 (\1\:CO COb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.3093 \
        scb=0.0404867 scc=0.00500078 m=(1)
C1 (A VSS) capacitor c=1.15636e-16
C2 (CO VSS) capacitor c=5.92787e-17
C3 (B VSS) capacitor c=3.17565e-17
C4 (VDD VSS) capacitor c=2.51335e-16
C5 (S VSS) capacitor c=5.76637e-17
C6 (CI VSS) capacitor c=4.19936e-17
C7 (COb VSS) capacitor c=2.22473e-17
C8 (n2 VSS) capacitor c=7.52823e-17
C9 (n4 VSS) capacitor c=8.13013e-17
C10 (Sb VSS) capacitor c=4.69793e-17
C11 (n7 VSS) capacitor c=1.88509e-18
C12 (n6 VSS) capacitor c=3.44312e-18
C13 (n3 VSS) capacitor c=7.22925e-17
C14 (n5 VSS) capacitor c=7.1346e-17
C15 (n9 VSS) capacitor c=2.07985e-18
C16 (n8 VSS) capacitor c=4.98975e-18
C17 (\12\:A VSS) capacitor c=3.76881e-17
C18 (\13\:B VSS) capacitor c=6.55356e-17
C19 (\11\:CI VSS) capacitor c=8.65377e-17
C20 (\6\:COb VSS) capacitor c=2.85721e-17
C21 (\9\:A VSS) capacitor c=6.19316e-17
C22 (\10\:B VSS) capacitor c=4.40835e-17
C23 (\7\:CI VSS) capacitor c=7.84158e-17
C24 (\6\:A VSS) capacitor c=8.54272e-17
C25 (\4\:B VSS) capacitor c=5.89879e-17
C26 (\1\:CI VSS) capacitor c=4.78944e-17
C27 (\1\:B VSS) capacitor c=4.27584e-17
C28 (\1\:A VSS) capacitor c=4.74181e-17
C29 (\3\:Sb VSS) capacitor c=2.78342e-17
C30 (\10\:A VSS) capacitor c=6.13837e-17
C31 (\11\:B VSS) capacitor c=7.60904e-17
C32 (\8\:CI VSS) capacitor c=5.08988e-17
C33 (\4\:COb VSS) capacitor c=6.4422e-17
C34 (\7\:A VSS) capacitor c=4.3128e-17
C35 (\7\:B VSS) capacitor c=5.59741e-17
C36 (\5\:CI VSS) capacitor c=3.32859e-17
C37 (\4\:A VSS) capacitor c=4.96963e-17
C38 (\6\:B VSS) capacitor c=6.36851e-17
C39 (\3\:CI VSS) capacitor c=2.64351e-17
C40 (\3\:B VSS) capacitor c=5.41601e-17
C41 (\3\:A VSS) capacitor c=3.89732e-17
C42 (\3\:COb VSS) capacitor c=2.62296e-17
C43 (\2\:Sb VSS) capacitor c=4.20884e-17
C44 (\11\:A VSS) capacitor c=5.48879e-17
C45 (\12\:B VSS) capacitor c=7.93293e-17
C46 (\10\:CI VSS) capacitor c=7.3175e-17
C47 (\5\:COb VSS) capacitor c=5.87447e-17
C48 (\8\:A VSS) capacitor c=7.31391e-17
C49 (\9\:B VSS) capacitor c=2.7606e-17
C50 (\6\:CI VSS) capacitor c=5.89715e-17
C51 (\5\:A VSS) capacitor c=8.68361e-17
C52 (\5\:B VSS) capacitor c=7.29827e-17
C53 (\4\:CI VSS) capacitor c=4.96416e-17
C54 (\2\:B VSS) capacitor c=4.08561e-17
C55 (\2\:A VSS) capacitor c=2.76602e-17
C56 (\2\:COb VSS) capacitor c=2.57695e-17
C57 (\1\:S VSS) capacitor c=3.64707e-17
C58 (\11\:VDD VSS) capacitor c=3.04996e-17
C59 (\9\:Sb VSS) capacitor c=8.35808e-17
C60 (\11\:Sb VSS) capacitor c=3.67842e-17
C61 (\13\:VDD VSS) capacitor c=1.87371e-17
C62 (\3\:n5 VSS) capacitor c=7.52583e-17
C63 (\15\:VDD VSS) capacitor c=1.28193e-17
C64 (\8\:COb VSS) capacitor c=1.391e-16
C65 (\11\:COb VSS) capacitor c=2.03888e-17
C66 (\17\:VDD VSS) capacitor c=9.91644e-18
C67 (\3\:n3 VSS) capacitor c=6.61008e-17
C68 (\1\:CO VSS) capacitor c=4.45273e-17
C69 (\19\:VDD VSS) capacitor c=3.06534e-17
C70 (\1\:VDD VSS) capacitor c=7.7948e-17
C71 (\3\:S VSS) capacitor c=2.60999e-17
C72 (\4\:Sb VSS) capacitor c=7.30217e-17
C73 (\7\:Sb VSS) capacitor c=3.81367e-17
C74 (\3\:n4 VSS) capacitor c=7.86812e-17
C75 (\18\:COb VSS) capacitor c=4.26635e-17
C76 (\15\:COb VSS) capacitor c=4.2054e-17
C77 (\3\:n2 VSS) capacitor c=7.14931e-17
C78 (\3\:CO VSS) capacitor c=8.58849e-17
C79 (\2\:CI VSS) capacitor c=3.03827e-17
C80 (\8\:B VSS) capacitor c=4.6527e-17
C81 (\7\:COb VSS) capacitor c=1.4879e-16
C82 (\10\:COb VSS) capacitor c=1.07216e-16
C83 (\13\:COb VSS) capacitor c=1.74827e-16
C84 (\14\:COb VSS) capacitor c=1.14886e-16
C85 (\17\:COb VSS) capacitor c=4.7446e-17
C86 (\12\:CI VSS) capacitor c=1.35766e-16
C87 (\13\:CI VSS) capacitor c=1.59543e-16
C88 (\14\:CI VSS) capacitor c=5.27339e-17
C89 (\14\:B VSS) capacitor c=1.2966e-16
C90 (\15\:B VSS) capacitor c=1.56794e-16
C91 (\16\:B VSS) capacitor c=7.97368e-17
C92 (\17\:B VSS) capacitor c=7.04908e-17
C93 (\13\:A VSS) capacitor c=2.11707e-16
C94 (\14\:A VSS) capacitor c=1.62075e-16
C95 (\15\:A VSS) capacitor c=1.2689e-16
C96 (\16\:A VSS) capacitor c=2.48978e-17
C97 (\6\:Sb VSS) capacitor c=1.54051e-16
C98 (\3\:VDD VSS) capacitor c=1.36262e-17
C99 (\5\:VDD VSS) capacitor c=1.51021e-17
C100 (\6\:VDD VSS) capacitor c=1.1452e-17
C101 (\8\:VDD VSS) capacitor c=1.33309e-17
C102 (\10\:VDD VSS) capacitor c=3.82149e-18
Rk22 (A \13\:A) resistor r=0.8877 c=0
Rk23 (\13\:A \14\:A) resistor r=0.578 c=0
Rk24 (\14\:A \15\:A) resistor r=0.7117 c=0
Rk25 (A \16\:A) resistor r=0.05411 c=0
Rk1 (\2\:CO CO) resistor r=0.2529 c=0
Rk2 (CO \4\:CO) resistor r=0.52 c=0
Rk18 (\14\:B \15\:B) resistor r=0.8953 c=0
Rk21 (\16\:B B) resistor r=0.05733 c=0
Rk19 (\15\:B \16\:B) resistor r=0.3853 c=0
Rk20 (\16\:B \17\:B) resistor r=0.4344 c=0
Rk45 (\2\:VDD \3\:VDD) resistor r=0.1027 c=0
Rk46 (\3\:VDD \4\:VDD) resistor r=0.3987 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.3375 c=0
Rk48 (\5\:VDD \6\:VDD) resistor r=0.109 c=0
Rk49 (\6\:VDD \7\:VDD) resistor r=0.203 c=0
Rk50 (\7\:VDD \8\:VDD) resistor r=0.2883 c=0
Rk51 (\8\:VDD \9\:VDD) resistor r=0.213 c=0
Rk53 (\10\:VDD VDD) resistor r=0.01962 c=0
Rk52 (\9\:VDD \10\:VDD) resistor r=0.1804 c=0
Rk54 (\3\:VDD \12\:VDD) resistor r=0.235 c=0
Rk55 (\5\:VDD \14\:VDD) resistor r=0.04333 c=0
Rk56 (\6\:VDD \16\:VDD) resistor r=0.08012 c=0
Rk57 (\8\:VDD \18\:VDD) resistor r=0.07416 c=0
Rk58 (\10\:VDD \20\:VDD) resistor r=0.4025 c=0
Rk30 (\2\:S S) resistor r=0.3444 c=0
Rk31 (S \4\:S) resistor r=0.2115 c=0
Rk32 (\2\:VSS \3\:VSS) resistor r=0.09012 c=0
Rk33 (\3\:VSS \4\:VSS) resistor r=0.3109 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.3184 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.2078 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.1252 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.3526 c=0
Rk39 (\9\:VSS VSS) resistor r=0.2007 c=0
Rk38 (\8\:VSS \9\:VSS) resistor r=0.2472 c=0
Rk40 (VSS \11\:VSS) resistor r=0.2036 c=0
Rk41 (\3\:VSS \13\:VSS) resistor r=0.2037 c=0
Rk42 (\5\:VSS \15\:VSS) resistor r=0.1029 c=0
Rk43 (\6\:VSS \17\:VSS) resistor r=0.1851 c=0
Rk44 (\8\:VSS \19\:VSS) resistor r=0.04333 c=0
Rk16 (\13\:CI CI) resistor r=0.2408 c=0
Rk15 (\12\:CI \13\:CI) resistor r=0.8824 c=0
Rk17 (CI \14\:CI) resistor r=0.08714 c=0
Rk7 (\7\:COb \9\:COb) resistor r=1.1789 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.1499 c=0
Rk9 (\10\:COb \12\:COb) resistor r=0.05483 c=0
Rk10 (\10\:COb \13\:COb) resistor r=0.9636 c=0
Rk11 (\13\:COb \14\:COb) resistor r=0.8694 c=0
Rk12 (\14\:COb \16\:COb) resistor r=0.1125 c=0
Rk13 (\13\:COb \17\:COb) resistor r=0.1933 c=0
Rk14 (\14\:COb \19\:COb) resistor r=0.1501 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.2374 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.2862 c=0
Rk26 (\5\:Sb \6\:Sb) resistor r=0.5258 c=0
Rk27 (\5\:Sb \8\:Sb) resistor r=0.201 c=0
Rk28 (\6\:Sb \10\:Sb) resistor r=0.9101 c=0
Rk29 (\10\:Sb \12\:Sb) resistor r=0.1293 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.2405 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.2806 c=0
Rl29 (\11\:A \12\:A) resistor r=39.5604 c=0
Rl28 (\10\:A \11\:A) resistor r=192.308 c=0
Rl20 (\8\:A \9\:A) resistor r=161.516 c=0
Rl19 (\7\:A \8\:A) resistor r=97.872 c=0
Rl13 (\5\:A \6\:A) resistor r=141.758 c=0
Rl12 (\4\:A \5\:A) resistor r=103.846 c=0
Rl3 (\1\:A \2\:A) resistor r=64.1533 c=0
Rl4 (\2\:A \3\:A) resistor r=29.5379 c=0
Rl27 (\12\:B \13\:B) resistor r=76.3736 c=0
Rl26 (\11\:B \12\:B) resistor r=155.769 c=0
Rl10 (\4\:B \5\:B) resistor r=69.9225 c=0
Rl11 (\5\:B \6\:B) resistor r=173.769 c=0
Rl5 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=92.9995 c=0
Rl18 (\8\:B \10\:B) resistor r=23.7402 c=0
Rl16 (\7\:B \8\:B) resistor r=188.77 c=0
Rl17 (\8\:B \9\:B) resistor r=5.8511 c=0
Rl15 (\6\:CI \7\:CI) resistor r=149.451 c=0
Rl14 (\5\:CI \6\:CI) resistor r=42.3077 c=0
Rl7 (\1\:CI \2\:CI) resistor r=116.541 c=0
Rl8 (\2\:CI \3\:CI) resistor r=28.0797 c=0
Rl9 (\2\:CI \4\:CI) resistor r=118.425 c=0
Rl25 (\9\:CI \11\:CI) resistor r=199.313 c=0
Rl23 (\8\:CI \9\:CI) resistor r=56.0256 c=0
Rl24 (\9\:CI \10\:CI) resistor r=8.1539 c=0
Rl22 (\5\:COb \6\:COb) resistor r=24.2328 c=0
Rl21 (\4\:COb \5\:COb) resistor r=257.246 c=0
Rl1 (COb \2\:COb) resistor r=73.7687 c=0
Rl2 (\2\:COb \3\:COb) resistor r=100.692 c=0
Rl30 (Sb \2\:Sb) resistor r=191.076 c=0
Rl31 (\2\:Sb \3\:Sb) resistor r=39.1533 c=0
Rz1 (\3\:CO \4\:CO) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=15 c=0
Rz19 (\1\:VDD \9\:VDD) resistor r=15 c=0
Rz10 (\3\:S \4\:S) resistor r=75 c=0
Rz11 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz12 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz6 (\15\:COb \16\:COb) resistor r=75 c=0
Rz7 (\18\:COb \19\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz8 (\4\:Sb \5\:Sb) resistor r=75 c=0
Rz9 (\7\:Sb \8\:Sb) resistor r=75 c=0
Ry1 (\1\:CO \2\:CO) resistor r=62 c=0
Ry15 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry10 (\1\:S \2\:S) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry13 (\1\:VSS \7\:VSS) resistor r=8.8571 c=0
Ry14 (\1\:VSS \9\:VSS) resistor r=12.4 c=0
Ry6 (\8\:COb \9\:COb) resistor r=62 c=0
Ry7 (\11\:COb \12\:COb) resistor r=62 c=0
Ry8 (\9\:Sb \10\:Sb) resistor r=62 c=0
Ry9 (\11\:Sb \12\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\8\:A \13\:A) resistor r=45 c=0
Rx11 (\5\:A \14\:A) resistor r=45 c=0
Rx12 (\2\:A \15\:A) resistor r=45 c=0
Rx13 (\11\:A \16\:A) resistor r=45 c=0
Rx6 (\12\:B \14\:B) resistor r=45 c=0
Rx7 (\9\:B \15\:B) resistor r=45 c=0
Rx8 (\5\:B \16\:B) resistor r=45 c=0
Rx9 (\2\:B \17\:B) resistor r=45 c=0
Rx3 (\10\:CI \12\:CI) resistor r=45 c=0
Rx4 (\6\:CI \13\:CI) resistor r=45 c=0
Rx5 (\4\:CI \14\:CI) resistor r=45 c=0
Rx1 (\5\:COb \7\:COb) resistor r=45 c=0
Rx2 (\2\:COb \17\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.393e-14 ps=6.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.65e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\3\:n2 \3\:A \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.7931e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn3 (n2 \3\:B \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=2.32e-14 ps=1.46e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.02586e-07 sb=3.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn4 (\15\:COb \3\:CI n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.07586e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn1 (\18\:COb \6\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \4\:A \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.957e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=1.05e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \5\:CI \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=8.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \7\:B \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.392e-14 ps=1.06e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=6.35e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.682e-14 ps=1.06e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.7e-07 sd=160n sca=6.83173 scb=0.00357784 \
        scc=2.82929e-05 m=(1)
mn8 (\7\:Sb \4\:COb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.4e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.95e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn10 (n7 \11\:B n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=8.7e-15 ps=5.6e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.9e-07 sd=160n sca=7.27658 scb=0.00433573 \
        scc=4.41722e-05 m=(1)
mn9 (n6 \10\:A \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=1.958e-14 ps=6.2e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=4.1e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn13 (\3\:S \3\:Sb \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.9e-14 ps=6.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mp2 (\3\:n3 \1\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.27442e-07 sd=160n sca=46.0095 \
        scb=0.0283849 scc=0.00588417 m=(1)
mp3 (n3 \1\:B \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.64e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.74884e-07 sb=3.45e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp4 (\11\:COb \1\:CI n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.79884e-07 sb=1.4e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp1 (\8\:COb \4\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.0407e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp0 (n1 \6\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.9907e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp7 (\3\:n5 \7\:CI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=3.44e-14 ps=1.82e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.22093e-07 sb=4.61047e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp6 (\3\:n5 \10\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.322e-14 ad=3.44e-14 ps=2.14e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.27093e-07 sb=2.56047e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.322e-14 ad=4.407e-14 ps=2.14e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98256e-07 sb=4.9e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp8 (\11\:Sb \6\:COb n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=5.16e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.48256e-07 sb=2.4e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp11 (\9\:Sb \11\:CI n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=12.7748 scb=0.011453 \
        scc=0.000391592 m=(1)
mp10 (n9 \13\:B n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.332e-14 \
        ad=1.29e-14 ps=7.4e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.65e-07 sd=160n sca=13.1199 scb=0.0116197 \
        scc=0.000391676 m=(1)
mp9 (n8 \12\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.87e-14 ad=3.332e-14 ps=1.06e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=4.65e-07 sd=160n sca=14.3514 \
        scb=0.0128708 scc=0.000395547 m=(1)
mp13 (\1\:S Sb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.87e-14 ad=4.3e-14 ps=1.06e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=2e-07 sd=160n sca=20.6331 scb=0.0233447 \
        scc=0.000832054 m=(1)
ends ADDFXL
// End of subcircuit definition.

// Generated for: spectre (May  8 14:56:45 2012 )
// Library name: gsclib045
// Cell name: ADDHX1
// View name: extracted

simulator lang=spectre

subckt ADDHX1 A B CO S VDD VSS
mp8 (\3\:CO \4\:COb \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=5.46e-14 ps=1.83e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.20513e-07 sd=160n sca=35.0084 \
        scb=0.0365133 scc=0.00352722 m=(1)
C1 (S VSS) capacitor c=3.99054e-17
C2 (A VSS) capacitor c=5.13784e-17
C3 (CO VSS) capacitor c=5.31134e-17
C4 (VDD VSS) capacitor c=1.62939e-16
C5 (B VSS) capacitor c=9.03743e-17
C6 (COb VSS) capacitor c=2.50084e-17
C7 (n4 VSS) capacitor c=1.28943e-18
C8 (n1 VSS) capacitor c=2.65767e-17
C9 (n0 VSS) capacitor c=9.18366e-17
C10 (Sb VSS) capacitor c=4.92449e-17
C11 (\3\:n1 VSS) capacitor c=5.89877e-17
C12 (\2\:B VSS) capacitor c=1.04161e-16
C13 (\4\:A VSS) capacitor c=5.16667e-17
C14 (\3\:B VSS) capacitor c=5.40052e-17
C15 (\8\:B VSS) capacitor c=2.84416e-17
C16 (\3\:A VSS) capacitor c=6.20925e-17
C17 (\4\:COb VSS) capacitor c=4.47158e-17
C18 (\3\:Sb VSS) capacitor c=3.9651e-17
C19 (\2\:n0 VSS) capacitor c=7.75832e-17
C20 (\1\:B VSS) capacitor c=1.02365e-16
C21 (\6\:A VSS) capacitor c=2.64181e-17
C22 (\7\:B VSS) capacitor c=2.67415e-17
C23 (\6\:B VSS) capacitor c=4.15246e-17
C24 (\1\:A VSS) capacitor c=3.95687e-17
C25 (\3\:COb VSS) capacitor c=5.07611e-17
C26 (\2\:Sb VSS) capacitor c=2.62628e-17
C27 (\3\:n0 VSS) capacitor c=3.67466e-17
C28 (\4\:n1 VSS) capacitor c=3.60316e-17
C29 (\2\:n1 VSS) capacitor c=4.31328e-17
C30 (\5\:A VSS) capacitor c=4.06934e-17
C31 (\5\:B VSS) capacitor c=5.31496e-17
C32 (\2\:A VSS) capacitor c=8.14263e-17
C33 (\1\:S VSS) capacitor c=3.17145e-17
C34 (\1\:VDD VSS) capacitor c=5.76866e-17
C35 (\8\:Sb VSS) capacitor c=6.49764e-17
C36 (\7\:n0 VSS) capacitor c=1.12006e-16
C37 (\10\:VDD VSS) capacitor c=7.2928e-17
C38 (\11\:n1 VSS) capacitor c=2.09853e-17
C39 (\12\:VDD VSS) capacitor c=1.1775e-17
C40 (\9\:COb VSS) capacitor c=2.19897e-17
C41 (\14\:VDD VSS) capacitor c=6.25084e-18
C42 (\3\:CO VSS) capacitor c=3.32493e-17
C43 (\3\:VDD VSS) capacitor c=5.83125e-17
C44 (\3\:S VSS) capacitor c=3.59221e-17
C45 (\6\:Sb VSS) capacitor c=2.90335e-17
C46 (\5\:n0 VSS) capacitor c=1.48007e-16
C47 (\8\:n1 VSS) capacitor c=6.92803e-17
C48 (\5\:COb VSS) capacitor c=1.20742e-16
C49 (\1\:CO VSS) capacitor c=6.52541e-17
C50 (\2\:COb VSS) capacitor c=2.38977e-17
C51 (\4\:B VSS) capacitor c=2.90105e-17
C52 (\7\:COb VSS) capacitor c=1.16118e-16
C53 (\8\:COb VSS) capacitor c=7.55608e-17
C54 (\7\:A VSS) capacitor c=1.59448e-16
C55 (\8\:A VSS) capacitor c=1.43082e-16
C56 (\5\:n1 VSS) capacitor c=3.14875e-17
C57 (\6\:n1 VSS) capacitor c=1.44142e-16
C58 (\7\:n1 VSS) capacitor c=1.34228e-16
C59 (\10\:n1 VSS) capacitor c=1.30975e-16
C60 (\4\:n0 VSS) capacitor c=6.64718e-17
C61 (\4\:Sb VSS) capacitor c=4.56305e-17
C62 (\5\:Sb VSS) capacitor c=6.5372e-17
C63 (\5\:VDD VSS) capacitor c=2.15248e-17
C64 (\6\:VDD VSS) capacitor c=5.08388e-18
C65 (\8\:VDD VSS) capacitor c=3.48914e-18
Rk19 (\2\:S S) resistor r=0.1429 c=0
Rk20 (S \4\:S) resistor r=0.2039 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.5291 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2912 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.2611 c=0
Rk35 (\7\:VSS VSS) resistor r=0.1016 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.09684 c=0
Rk36 (\5\:VSS \9\:VSS) resistor r=0.129 c=0
Rk37 (\7\:VSS \11\:VSS) resistor r=0.2133 c=0
Rk8 (\8\:A A) resistor r=0.06006 c=0
Rk7 (\7\:A \8\:A) resistor r=1.1293 c=0
Rk1 (\2\:CO CO) resistor r=0.4599 c=0
Rk2 (CO \4\:CO) resistor r=0.0513 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.5408 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2159 c=0
Rk23 (\5\:VDD \6\:VDD) resistor r=0.1679 c=0
Rk24 (\6\:VDD \7\:VDD) resistor r=0.1179 c=0
Rk26 (\8\:VDD VDD) resistor r=0.08246 c=0
Rk25 (\7\:VDD \8\:VDD) resistor r=0.1179 c=0
Rk28 (\5\:VDD \11\:VDD) resistor r=0.3843 c=0
Rk29 (\6\:VDD \13\:VDD) resistor r=0.129 c=0
Rk30 (\8\:VDD \15\:VDD) resistor r=0.0884 c=0
Rk3 (B \9\:B) resistor r=0.04302 c=0
Rk4 (\6\:COb \7\:COb) resistor r=0.6944 c=0
Rk5 (\7\:COb \8\:COb) resistor r=0.3126 c=0
Rk6 (\7\:COb \10\:COb) resistor r=0.14 c=0
Rk9 (\5\:n1 \6\:n1) resistor r=0.1405 c=0
Rk10 (\6\:n1 \7\:n1) resistor r=0.7645 c=0
Rk11 (\7\:n1 \9\:n1) resistor r=0.3294 c=0
Rk12 (\6\:n1 \10\:n1) resistor r=0.5446 c=0
Rk13 (\7\:n1 \12\:n1) resistor r=0.1051 c=0
Rk14 (\4\:n0 \6\:n0) resistor r=0.4938 c=0
Rk15 (\6\:n0 \8\:n0) resistor r=0.4481 c=0
Rk16 (\4\:Sb \5\:Sb) resistor r=0.2357 c=0
Rk17 (\5\:Sb \7\:Sb) resistor r=0.1233 c=0
Rk18 (\5\:Sb \9\:Sb) resistor r=0.3607 c=0
Rl6 (\4\:A \5\:A) resistor r=99.1749 c=0
Rl7 (\5\:A \6\:A) resistor r=29.9442 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=31.9251 c=0
Rl11 (\2\:B \3\:B) resistor r=328.412 c=0
Rl10 (\1\:B \2\:B) resistor r=204.9 c=0
Rl16 (\5\:B \8\:B) resistor r=93.4057 c=0
Rl14 (\5\:B \6\:B) resistor r=95.3288 c=0
Rl12 (\3\:B \4\:B) resistor r=80.0028 c=0
Rl15 (\4\:B \7\:B) resistor r=78.0797 c=0
Rl13 (\4\:B \5\:B) resistor r=123.856 c=0
Rl1 (COb \2\:COb) resistor r=1.2334 c=0
Rl3 (\2\:COb \4\:COb) resistor r=37.3411 c=0
Rl2 (\2\:COb \3\:COb) resistor r=106.572 c=0
Rl9 (\3\:n1 \4\:n1) resistor r=31.9251 c=0
Rl8 (n1 \2\:n1) resistor r=37.2302 c=0
Rl17 (n0 \2\:n0) resistor r=161.538 c=0
Rl18 (\2\:n0 \3\:n0) resistor r=74.2328 c=0
Rl19 (Sb \2\:Sb) resistor r=39.6174 c=0
Rl20 (\2\:Sb \3\:Sb) resistor r=26.1559 c=0
Rz6 (\3\:S \4\:S) resistor r=37.5 c=0
Rz10 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz11 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\1\:CO \2\:CO) resistor r=37.5 c=0
Rz9 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz8 (\3\:VDD \7\:VDD) resistor r=25 c=0
Rz2 (\5\:COb \6\:COb) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz5 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry6 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry12 (\3\:VSS \6\:VSS) resistor r=12.4 c=0
Ry1 (\3\:CO \4\:CO) resistor r=20.6667 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry10 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry2 (\9\:COb \10\:COb) resistor r=62 c=0
Ry3 (\11\:n1 \12\:n1) resistor r=62 c=0
Ry4 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry5 (\8\:Sb \9\:Sb) resistor r=62 c=0
Rx3 (\5\:A \7\:A) resistor r=45 c=0
Rx4 (\2\:A \8\:A) resistor r=45 c=0
Rx1 (\5\:B \9\:B) resistor r=45 c=0
Rx2 (COb \8\:COb) resistor r=45 c=0
Rx5 (\4\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n1 \10\:n1) resistor r=45 c=0
Rx7 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Sb \4\:Sb) resistor r=45 c=0
mn8 (\1\:CO \3\:COb \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.11923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn6 (n4 \1\:A \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.305e-14 ps=8.4e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn7 (\5\:COb \6\:B n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.03e-14 ps=4.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\8\:n1 \7\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn0 (\5\:n0 \6\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=3.335e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.35e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn4 (\6\:Sb n1 \5\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.393e-14 ps=7.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=6.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\6\:Sb \1\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.4e-07 sb=4.5e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn2 (n2 \2\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn5 (\3\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85577e-07 sb=1.4e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mp6 (\9\:COb \3\:A \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.05e-07 sd=160n sca=15.3248 \
        scb=0.0144711 scc=0.000289176 m=(1)
mp7 (\9\:COb \8\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.495e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1e-07 sd=160n sca=12.8165 scb=0.0106177 \
        scc=0.00024049 m=(1)
mp1 (\11\:n1 \3\:B \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=2.63e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.15e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (\7\:n0 \4\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.052e-14 ps=7.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.37326e-07 sb=9.35e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\8\:Sb \2\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.17326e-07 sb=6.55e-07 sd=160n sca=13.327 \
        scb=0.0119299 scc=0.000425286 m=(1)
mp3 (\8\:Sb \3\:n1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.22326e-07 sb=4.5e-07 sd=160n sca=14.6061 \
        scb=0.0132457 scc=0.000429538 m=(1)
mp2 (n3 n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=5.19e-14 \
        ad=1.29e-14 ps=1.1e-06 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.27326e-07 sb=3.45e-07 sd=160n sca=15.9702 scb=0.0153945 \
        scc=0.000454375 m=(1)
mp5 (\1\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.69103e-07 sb=1.4e-07 sd=160n sca=42.1543 \
        scb=0.0369591 scc=0.00437643 m=(1)
ends ADDHX1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:00:56 2012 )
// Library name: gsclib045
// Cell name: ADDHX2
// View name: extracted

simulator lang=spectre

subckt ADDHX2 A B CO S VDD VSS
mp7 (\7\:COb \1\:B \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.026 scb=0.0229138 \
        scc=0.00110307 m=(1)
C1 (B VSS) capacitor c=9.8365e-17
C2 (CO VSS) capacitor c=6.72663e-17
C3 (VDD VSS) capacitor c=1.63385e-16
C4 (S VSS) capacitor c=2.30972e-17
C5 (n4 VSS) capacitor c=1.29764e-18
C6 (COb VSS) capacitor c=1.95446e-16
C7 (n0 VSS) capacitor c=9.33154e-17
C8 (Sb VSS) capacitor c=1.85861e-16
C9 (n1 VSS) capacitor c=4.04853e-17
C10 (\8\:B VSS) capacitor c=4.98055e-17
C11 (\2\:n0 VSS) capacitor c=4.93861e-17
C12 (\4\:B VSS) capacitor c=5.16938e-17
C13 (\6\:A VSS) capacitor c=4.061e-17
C14 (\4\:A VSS) capacitor c=2.37174e-17
C15 (\1\:B VSS) capacitor c=3.22645e-17
C16 (\9\:B VSS) capacitor c=2.42549e-17
C17 (\6\:B VSS) capacitor c=8.00524e-17
C18 (\3\:n1 VSS) capacitor c=3.96422e-17
C19 (\5\:A VSS) capacitor c=5.14901e-17
C20 (\3\:A VSS) capacitor c=5.14454e-17
C21 (\3\:B VSS) capacitor c=1.88744e-17
C22 (\10\:B VSS) capacitor c=2.19294e-17
C23 (\3\:n0 VSS) capacitor c=3.14894e-17
C24 (\4\:n1 VSS) capacitor c=3.32569e-17
C25 (\7\:B VSS) capacitor c=2.95803e-17
C26 (\5\:B VSS) capacitor c=2.62693e-17
C27 (\7\:A VSS) capacitor c=3.88456e-17
C28 (\1\:A VSS) capacitor c=3.02962e-17
C29 (\2\:B VSS) capacitor c=3.33026e-17
C30 (\6\:n1 VSS) capacitor c=7.9833e-17
C31 (\3\:S VSS) capacitor c=6.78768e-17
C32 (\8\:Sb VSS) capacitor c=5.47005e-17
C33 (\5\:n0 VSS) capacitor c=1.14096e-16
C34 (\1\:VDD VSS) capacitor c=7.67702e-17
C35 (\1\:CO VSS) capacitor c=4.31259e-17
C36 (\7\:COb VSS) capacitor c=2.79365e-17
C37 (\14\:VDD VSS) capacitor c=2.86296e-17
C38 (\4\:VDD VSS) capacitor c=4.8397e-17
C39 (\8\:n1 VSS) capacitor c=3.50666e-17
C40 (\1\:S VSS) capacitor c=3.82295e-17
C41 (\11\:Sb VSS) capacitor c=3.69427e-17
C42 (\7\:n0 VSS) capacitor c=8.40146e-17
C43 (\3\:CO VSS) capacitor c=9.76358e-17
C44 (\10\:COb VSS) capacitor c=5.47625e-17
C45 (\2\:A VSS) capacitor c=2.17696e-17
C46 (\2\:n1 VSS) capacitor c=4.33918e-17
C47 (\9\:COb VSS) capacitor c=9.40536e-17
C48 (\12\:COb VSS) capacitor c=7.10166e-17
C49 (\8\:A VSS) capacitor c=1.41414e-16
C50 (\9\:A VSS) capacitor c=7.62471e-17
C51 (\4\:n0 VSS) capacitor c=5.85568e-17
C52 (\10\:Sb VSS) capacitor c=6.51573e-17
C53 (\13\:Sb VSS) capacitor c=6.4462e-17
C54 (\11\:B VSS) capacitor c=7.62995e-17
C55 (\12\:B VSS) capacitor c=8.56079e-17
C56 (\13\:B VSS) capacitor c=1.4363e-16
C57 (\14\:B VSS) capacitor c=4.15966e-17
C58 (\15\:B VSS) capacitor c=2.25996e-17
C59 (\16\:B VSS) capacitor c=8.03386e-17
C60 (\5\:n1 VSS) capacitor c=1.33612e-16
C61 (\5\:VDD VSS) capacitor c=7.62406e-17
C62 (\13\:VDD VSS) capacitor c=6.93528e-18
Rk15 (\11\:B \12\:B) resistor r=0.6681 c=0
Rk17 (\13\:B B) resistor r=1.0327 c=0
Rk16 (\12\:B \13\:B) resistor r=0.2242 c=0
Rk18 (B \14\:B) resistor r=0.06992 c=0
Rk19 (\12\:B \15\:B) resistor r=0.0529 c=0
Rk20 (\13\:B \16\:B) resistor r=0.3772 c=0
Rk4 (\2\:CO CO) resistor r=0.1079 c=0
Rk5 (CO \4\:CO) resistor r=0.4183 c=0
Rk24 (\1\:VDD \5\:VDD) resistor r=0.4715 c=0
Rk31 (\13\:VDD VDD) resistor r=0.06723 c=0
Rk29 (\1\:VDD \13\:VDD) resistor r=0.2335 c=0
Rk30 (\13\:VDD \15\:VDD) resistor r=0.3331 c=0
Rk6 (\8\:A A) resistor r=0.008457 c=0
Rk7 (A \9\:A) resistor r=0.6088 c=0
Rk13 (\2\:S S) resistor r=0.06584 c=0
Rk14 (S \4\:S) resistor r=0.1742 c=0
Rk34 (\1\:VSS \5\:VSS) resistor r=0.1167 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.3673 c=0
Rk38 (\8\:VSS VSS) resistor r=0.1 c=0
Rk37 (\6\:VSS \8\:VSS) resistor r=0.1477 c=0
Rk1 (\8\:COb \9\:COb) resistor r=0.1196 c=0
Rk2 (\9\:COb \11\:COb) resistor r=0.4804 c=0
Rk3 (\9\:COb \12\:COb) resistor r=0.4412 c=0
Rk8 (\4\:n0 \6\:n0) resistor r=0.5155 c=0
Rk9 (\6\:n0 \8\:n0) resistor r=0.3658 c=0
Rk10 (\9\:Sb \10\:Sb) resistor r=0.2687 c=0
Rk11 (\10\:Sb \12\:Sb) resistor r=0.1185 c=0
Rk12 (\10\:Sb \13\:Sb) resistor r=0.3284 c=0
Rk21 (\5\:n1 \7\:n1) resistor r=0.874 c=0
Rk22 (\7\:n1 \9\:n1) resistor r=0.2346 c=0
Rl26 (\8\:B \9\:B) resistor r=92.3077 c=0
Rl27 (\9\:B \10\:B) resistor r=44.9028 c=0
Rl14 (\6\:B \7\:B) resistor r=85.3072 c=0
Rl13 (\4\:B \5\:B) resistor r=31.8672 c=0
Rl1 (\1\:B \2\:B) resistor r=86.5385 c=0
Rl2 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl11 (\5\:A \6\:A) resistor r=143.15 c=0
Rl12 (\6\:A \7\:A) resistor r=39.2094 c=0
Rl5 (\2\:A \4\:A) resistor r=27.9498 c=0
Rl4 (\2\:A \3\:A) resistor r=120.314 c=0
Rl3 (\1\:A \2\:A) resistor r=17.3448 c=0
Rl18 (n0 \2\:n0) resistor r=141.873 c=0
Rl19 (\2\:n0 \3\:n0) resistor r=30.2349 c=0
Rl15 (n1 \2\:n1) resistor r=23.7402 c=0
Rl16 (\2\:n1 \3\:n1) resistor r=126.797 c=0
Rl17 (\2\:n1 \4\:n1) resistor r=5.1011 c=0
Rz2 (\4\:CO \3\:CO) resistor r=75 c=0
Rz9 (VDD \4\:VDD) resistor r=75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz7 (\5\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz5 (\2\:S \1\:S) resistor r=75 c=0
Rz1 (\11\:COb \10\:COb) resistor r=75 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz4 (\12\:Sb \11\:Sb) resistor r=75 c=0
Rz6 (\8\:n1 \9\:n1) resistor r=75 c=0
Ry2 (\2\:CO \1\:CO) resistor r=62 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry5 (\4\:S \3\:S) resistor r=62 c=0
Ry12 (\5\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry13 (\8\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry1 (\8\:COb \7\:COb) resistor r=62 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry4 (\9\:Sb \8\:Sb) resistor r=62 c=0
Ry6 (\6\:n1 \7\:n1) resistor r=62 c=0
Rx6 (\10\:B \11\:B) resistor r=45 c=0
Rx7 (\2\:B \14\:B) resistor r=45 c=0
Rx8 (\7\:B \15\:B) resistor r=45 c=0
Rx9 (\5\:B \16\:B) resistor r=45 c=0
Rx2 (\1\:A \8\:A) resistor r=45 c=0
Rx3 (\7\:A \9\:A) resistor r=45 c=0
Rx1 (\12\:COb COb) resistor r=45 c=0
Rx4 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx5 (\13\:Sb Sb) resistor r=45 c=0
Rx10 (\4\:n1 \5\:n1) resistor r=45 c=0
mn7 (\10\:COb \3\:B n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.755e-14 ps=7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (n4 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=2.973e-14 ps=1.6e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn8 (\3\:CO COb \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.375e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.98365e-07 sb=1.28125e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn0 (\7\:n0 \5\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=5.075e-14 ps=1.6e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=1.59e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\11\:Sb \3\:n1 \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.32e-14 ps=9.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.195e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\11\:Sb \6\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=9.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n2 n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=8.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn5 (\1\:S Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.058e-14 ad=4.16e-14 ps=1.61e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19058e-06 sb=5.11635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn1 (\8\:n1 \9\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.13e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp6 (\7\:COb \4\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=3.762e-14 ps=1.32e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.99709e-06 sd=160n sca=17.3029 \
        scb=0.01671 scc=0.000962068 m=(1)
mp8 (\1\:CO COb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.651e-14 ad=6.24e-14 ps=1.49e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.20833e-07 sb=1.14481e-06 sd=160n sca=13.4335 \
        scb=0.0117789 scc=0.000556063 m=(2)
mp0 (\5\:n0 \6\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.998e-14 ad=4.3e-14 ps=1.66e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.42337e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp4 (\8\:Sb \4\:B \5\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.052e-14 ps=8.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.17837e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp3 (\8\:Sb n1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.332e-14 \
        ad=5.052e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.555e-06 sb=8.98372e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp2 (n3 \2\:n0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.075e-14 ad=3.332e-14 ps=1.38e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=6.98372e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp5 (\3\:S Sb \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.233e-14 ad=6.24e-14 ps=1.415e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15641e-06 sb=4.35449e-07 sd=160n sca=31.0599 \
        scb=0.0204054 scc=0.00336104 m=(2)
mp1 (\6\:n1 \8\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12791e-06 sb=1.4e-07 sd=160n sca=50.7282 \
        scb=0.0349898 scc=0.00599471 m=(1)
ends ADDHX2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:01:35 2012 )
// Library name: gsclib045
// Cell name: ADDHX4
// View name: extracted

simulator lang=spectre

subckt ADDHX4 A B CO S VDD VSS
mp7 (\17\:COb \1\:B \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.95e-14 ad=7.02e-14 ps=1.34e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.58532e-06 sd=160n sca=31.1178 \
        scb=0.0283213 scc=0.00286476 m=(1)
C1 (B VSS) capacitor c=1.45023e-17
C2 (VDD VSS) capacitor c=1.93572e-16
C3 (A VSS) capacitor c=1.60471e-16
C4 (S VSS) capacitor c=1.69562e-16
C5 (CO VSS) capacitor c=1.57519e-17
C6 (n4 VSS) capacitor c=1.54183e-18
C7 (COb VSS) capacitor c=3.11111e-16
C8 (n0 VSS) capacitor c=7.6737e-17
C9 (Sb VSS) capacitor c=2.67973e-16
C10 (n1 VSS) capacitor c=4.10293e-17
C11 (n2 VSS) capacitor c=2.92218e-18
C12 (n3 VSS) capacitor c=2.24885e-18
C13 (\12\:B VSS) capacitor c=3.16165e-17
C14 (\3\:n1 VSS) capacitor c=7.45908e-17
C15 (\8\:B VSS) capacitor c=3.85727e-17
C16 (\4\:A VSS) capacitor c=5.02341e-17
C17 (\1\:A VSS) capacitor c=6.01858e-17
C18 (\1\:B VSS) capacitor c=2.45858e-17
C19 (\9\:B VSS) capacitor c=3.05525e-17
C20 (\3\:n0 VSS) capacitor c=6.39674e-17
C21 (\5\:B VSS) capacitor c=7.5169e-17
C22 (\6\:A VSS) capacitor c=2.59164e-17
C23 (\3\:A VSS) capacitor c=5.55598e-17
C24 (\4\:B VSS) capacitor c=5.76025e-17
C25 (\11\:B VSS) capacitor c=3.00028e-17
C26 (\8\:Sb VSS) capacitor c=3.28045e-17
C27 (\2\:n0 VSS) capacitor c=5.11359e-17
C28 (\4\:n1 VSS) capacitor c=5.45887e-17
C29 (\2\:n1 VSS) capacitor c=4.16338e-17
C30 (\7\:B VSS) capacitor c=4.13711e-17
C31 (\5\:A VSS) capacitor c=5.09659e-17
C32 (\2\:A VSS) capacitor c=5.51537e-17
C33 (\3\:B VSS) capacitor c=1.38928e-17
C34 (\5\:n1 VSS) capacitor c=4.11959e-17
C35 (\19\:Sb VSS) capacitor c=1.16048e-16
C36 (\8\:n0 VSS) capacitor c=2.55301e-17
C37 (\17\:COb VSS) capacitor c=8.36194e-17
C38 (\27\:VDD VSS) capacitor c=3.7269e-17
C39 (\1\:VDD VSS) capacitor c=1.40563e-16
C40 (\7\:n1 VSS) capacitor c=1.74325e-16
C41 (\16\:Sb VSS) capacitor c=8.69713e-17
C42 (\6\:n0 VSS) capacitor c=7.35355e-17
C43 (\1\:CO VSS) capacitor c=1.30025e-16
C44 (\19\:COb VSS) capacitor c=4.84211e-17
C45 (\2\:B VSS) capacitor c=2.25673e-17
C46 (\6\:B VSS) capacitor c=6.78275e-17
C47 (\16\:COb VSS) capacitor c=4.029e-17
C48 (\6\:CO VSS) capacitor c=1.18074e-16
C49 (\7\:A VSS) capacitor c=1.54556e-16
C50 (\8\:A VSS) capacitor c=3.37948e-17
C51 (\4\:n0 VSS) capacitor c=1.05761e-16
C52 (\5\:n0 VSS) capacitor c=9.11805e-17
C53 (\18\:Sb VSS) capacitor c=1.13552e-16
C54 (\5\:S VSS) capacitor c=1.14989e-16
C55 (\13\:B VSS) capacitor c=2.24506e-16
C56 (\14\:B VSS) capacitor c=3.46893e-16
C57 (\15\:B VSS) capacitor c=1.7567e-16
C58 (\16\:B VSS) capacitor c=4.01914e-17
C59 (\9\:n1 VSS) capacitor c=2.16466e-16
C60 (\10\:n1 VSS) capacitor c=5.63927e-17
C61 (\3\:VDD VSS) capacitor c=7.81872e-17
C62 (\16\:VDD VSS) capacitor c=7.83639e-17
C63 (\26\:VDD VSS) capacitor c=7.31595e-18
Rk53 (\1\:VSS \7\:VSS) resistor r=0.1417 c=0
Rk59 (\8\:VSS VSS) resistor r=0.2051 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.4059 c=0
Rk22 (\13\:B \14\:B) resistor r=1.8713 c=0
Rk24 (\15\:B B) resistor r=0.03023 c=0
Rk23 (\14\:B \15\:B) resistor r=1.527 c=0
Rk25 (\14\:B \16\:B) resistor r=0.3289 c=0
Rk29 (\2\:VDD \3\:VDD) resistor r=0.1006 c=0
Rk38 (\3\:VDD \15\:VDD) resistor r=0.3014 c=0
Rk39 (\15\:VDD \16\:VDD) resistor r=0.2555 c=0
Rk48 (\26\:VDD VDD) resistor r=0.03465 c=0
Rk46 (\16\:VDD \26\:VDD) resistor r=0.2665 c=0
Rk47 (\26\:VDD \28\:VDD) resistor r=0.2133 c=0
Rk9 (\7\:A A) resistor r=1.2891 c=0
Rk10 (A \8\:A) resistor r=0.04495 c=0
Rk18 (S \5\:S) resistor r=0.157 c=0
Rk5 (\1\:CO CO) resistor r=0.01536 c=0
Rk6 (CO \6\:CO) resistor r=0.1937 c=0
Rk1 (\16\:COb \18\:COb) resistor r=0.2544 c=0
Rk2 (\18\:COb \20\:COb) resistor r=0.3424 c=0
Rk11 (\4\:n0 \5\:n0) resistor r=0.5809 c=0
Rk12 (\5\:n0 \7\:n0) resistor r=0.4289 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.06399 c=0
Rk14 (\17\:Sb \18\:Sb) resistor r=0.4361 c=0
Rk15 (\18\:Sb \20\:Sb) resistor r=0.6442 c=0
Rk26 (\6\:n1 \8\:n1) resistor r=0.2725 c=0
Rk27 (\8\:n1 \9\:n1) resistor r=1.615 c=0
Rk28 (\9\:n1 \10\:n1) resistor r=0.2637 c=0
Rl1 (\1\:B \2\:B) resistor r=34.3295 c=0
Rl3 (\2\:B \4\:B) resistor r=65.0987 c=0
Rl2 (\2\:B \3\:B) resistor r=13.091 c=0
Rl25 (\6\:B \8\:B) resistor r=35.9003 c=0
Rl23 (\5\:B \6\:B) resistor r=133.089 c=0
Rl24 (\6\:B \7\:B) resistor r=156.691 c=0
Rl45 (\10\:B \12\:B) resistor r=34.4036 c=0
Rl43 (\9\:B \10\:B) resistor r=49.7882 c=0
Rl44 (\10\:B \11\:B) resistor r=4.5488 c=0
Rl20 (\4\:A \5\:A) resistor r=153.207 c=0
Rl21 (\5\:A \6\:A) resistor r=57.6695 c=0
Rl4 (\1\:A \2\:A) resistor r=57.6923 c=0
Rl5 (\2\:A \3\:A) resistor r=36.2311 c=0
Rl27 (n0 \2\:n0) resistor r=29.5379 c=0
Rl28 (\2\:n0 \3\:n0) resistor r=71.8456 c=0
Rl35 (Sb \8\:Sb) resistor r=6.6999 c=0
Rl26 (\3\:n1 \4\:n1) resistor r=24.2328 c=0
Rl22 (n1 \2\:n1) resistor r=24.2328 c=0
Rz17 (VDD \1\:VDD) resistor r=75 c=0
Rz9 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz13 (\3\:VDD \1\:VDD) resistor r=12.5 c=0
Rz14 (\15\:VDD \1\:VDD) resistor r=15 c=0
Rz16 (\16\:VDD \1\:VDD) resistor r=9.375 c=0
Rz1 (\20\:COb \19\:COb) resistor r=75 c=0
Rz4 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\17\:Sb \16\:Sb) resistor r=75 c=0
Rz8 (\7\:n1 \8\:n1) resistor r=75 c=0
Ry18 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry19 (\7\:VSS \3\:VSS) resistor r=7.75 c=0
Ry21 (\8\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry17 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry1 (\18\:COb \17\:COb) resistor r=62 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\20\:Sb \19\:Sb) resistor r=62 c=0
Ry9 (\5\:n1 \6\:n1) resistor r=62 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\3\:B \15\:B) resistor r=45 c=0
Rx8 (\7\:B \16\:B) resistor r=45 c=0
Rx2 (\5\:A \7\:A) resistor r=45 c=0
Rx3 (\2\:A \8\:A) resistor r=45 c=0
Rx1 (\16\:COb COb) resistor r=45 c=0
Rx4 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx5 (\18\:Sb \8\:Sb) resistor r=45 c=0
Rx9 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx10 (\4\:n1 \10\:n1) resistor r=45 c=0
mn7 (\19\:COb \4\:B n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67577e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn6 (n4 \3\:A \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=1.56e-14 ps=8.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.62529e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn8_1__rcx (\1\:CO COb \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.134e-14 ad=7.605e-14 ps=1.275e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=1.51712e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn0 (\6\:n0 \6\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.355e-14 ad=6.95e-14 ps=1.1e-06 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.67948e-06 sb=1.76845e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn4 (\16\:Sb n1 \6\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.95e-14 ad=5.46e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13038e-06 sb=1.40038e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn3 (\16\:Sb \5\:B n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25298e-06 sb=1.14538e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn2 (n2 \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.435e-14 ad=2.34e-14 ps=1.62e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31788e-06 sb=1.01038e-06 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn5_1__rcx (\5\:S Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.385e-14 ad=4.29e-14 ps=1.605e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17058e-06 sb=9.86058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn1 (\7\:n1 \9\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46276e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp6 (\17\:COb \1\:A \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.242e-13 ad=7.02e-14 ps=1.86e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.48436e-06 sd=160n sca=26.3799 \
        scb=0.0202838 scc=0.00260575 m=(1)
mp8_1__rcx (\6\:CO COb \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.225e-13 ad=8.287e-14 ps=1.8425e-06 pd=1.205e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.36545e-06 sd=160n sca=24.8553 \
        scb=0.0187947 scc=0.00260102 m=(4)
mp0 (\8\:n0 \4\:A \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.342e-13 ad=1.1748e-13 ps=1.79e-06 pd=1.71e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.96419e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp4 (\19\:Sb \8\:B \8\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1748e-13 ad=6.24e-14 ps=1.71e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=1.46006e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp3 (\19\:Sb \3\:n1 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23942e-06 sb=1.25506e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp2 (n3 n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2415e-13 ad=2.34e-14 ps=1.9e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28654e-06 sb=1.15006e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp5_1__rcx (S Sb \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1313e-13 ad=7.897e-14 ps=1.9e-06 pd=1.185e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35385e-06 sb=9.92308e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp1 (\5\:n1 \12\:B \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.515e-14 ad=3.118e-14 ps=1.9e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66547e-06 sb=1.45e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
ends ADDHX4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:02:12 2012 )
// Library name: gsclib045
// Cell name: ADDHXL
// View name: extracted

simulator lang=spectre

subckt ADDHXL A B CO S VDD VSS
mp8 (\3\:CO \4\:COb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=15.3248 \
        scb=0.0144711 scc=0.000289176 m=(1)
C1 (S VSS) capacitor c=4.64949e-17
C2 (CO VSS) capacitor c=3.95059e-17
C3 (A VSS) capacitor c=1.97979e-16
C4 (VDD VSS) capacitor c=1.93127e-16
C5 (B VSS) capacitor c=6.73069e-17
C6 (COb VSS) capacitor c=2.79238e-17
C7 (n4 VSS) capacitor c=1.34709e-18
C8 (n1 VSS) capacitor c=4.80225e-17
C9 (n0 VSS) capacitor c=1.00957e-16
C10 (Sb VSS) capacitor c=4.22309e-17
C11 (n2 VSS) capacitor c=7.95925e-19
C12 (n3 VSS) capacitor c=2.22487e-18
C13 (\3\:n1 VSS) capacitor c=6.02132e-17
C14 (\2\:B VSS) capacitor c=8.69494e-17
C15 (\5\:A VSS) capacitor c=6.31797e-17
C16 (\3\:B VSS) capacitor c=6.06363e-17
C17 (\8\:B VSS) capacitor c=3.13442e-17
C18 (\1\:A VSS) capacitor c=7.42503e-17
C19 (\4\:COb VSS) capacitor c=3.0629e-17
C20 (\3\:Sb VSS) capacitor c=3.58391e-17
C21 (\2\:n0 VSS) capacitor c=5.13833e-17
C22 (\1\:B VSS) capacitor c=8.77071e-17
C23 (\6\:A VSS) capacitor c=2.69568e-17
C24 (\7\:B VSS) capacitor c=2.70698e-17
C25 (\6\:B VSS) capacitor c=3.71209e-17
C26 (\4\:A VSS) capacitor c=3.19528e-17
C27 (\3\:COb VSS) capacitor c=5.9182e-17
C28 (\2\:Sb VSS) capacitor c=3.34295e-17
C29 (\3\:n0 VSS) capacitor c=2.82475e-17
C30 (\4\:n1 VSS) capacitor c=4.60078e-17
C31 (\2\:n1 VSS) capacitor c=4.27152e-17
C32 (\7\:A VSS) capacitor c=2.00038e-17
C33 (\5\:B VSS) capacitor c=4.83765e-17
C34 (\3\:A VSS) capacitor c=3.18205e-17
C35 (\10\:VDD VSS) capacitor c=5.18578e-18
C36 (\8\:Sb VSS) capacitor c=6.46753e-17
C37 (\7\:n0 VSS) capacitor c=8.4212e-17
C38 (\12\:VDD VSS) capacitor c=5.60272e-17
C39 (\11\:n1 VSS) capacitor c=1.15466e-17
C40 (\14\:VDD VSS) capacitor c=1.03777e-17
C41 (\7\:COb VSS) capacitor c=1.061e-16
C42 (\16\:VDD VSS) capacitor c=1.72526e-17
C43 (\3\:CO VSS) capacitor c=5.9724e-17
C44 (\1\:VDD VSS) capacitor c=5.2538e-17
C45 (\3\:S VSS) capacitor c=4.4038e-17
C46 (\6\:Sb VSS) capacitor c=8.46773e-17
C47 (\5\:n0 VSS) capacitor c=1.33372e-16
C48 (\8\:n1 VSS) capacitor c=8.4149e-17
C49 (\5\:COb VSS) capacitor c=1.32766e-16
C50 (\1\:CO VSS) capacitor c=2.76089e-17
C51 (\2\:COb VSS) capacitor c=2.9596e-17
C52 (\2\:A VSS) capacitor c=4.44974e-17
C53 (\4\:B VSS) capacitor c=3.54248e-17
C54 (\9\:B VSS) capacitor c=3.44238e-17
C55 (\9\:COb VSS) capacitor c=6.72491e-17
C56 (\9\:A VSS) capacitor c=2.11968e-16
C57 (\5\:n1 VSS) capacitor c=4.80217e-17
C58 (\6\:n1 VSS) capacitor c=1.13263e-16
C59 (\7\:n1 VSS) capacitor c=1.54993e-16
C60 (\10\:n1 VSS) capacitor c=4.05784e-17
C61 (\4\:n0 VSS) capacitor c=5.96843e-17
C62 (\4\:Sb VSS) capacitor c=2.05738e-17
C63 (\5\:Sb VSS) capacitor c=5.81715e-17
C64 (\3\:VDD VSS) capacitor c=1.24971e-17
C65 (\5\:VDD VSS) capacitor c=1.29482e-17
C66 (\6\:VDD VSS) capacitor c=6.43898e-18
C67 (\8\:VDD VSS) capacitor c=7.22825e-18
Rk18 (\2\:S S) resistor r=0.01796 c=0
Rk19 (S \4\:S) resistor r=0.4318 c=0
Rk1 (CO \2\:CO) resistor r=0.1018 c=0
Rk2 (CO \4\:CO) resistor r=0.3023 c=0
Rk6 (A \8\:A) resistor r=0.01427 c=0
Rk7 (\8\:A \9\:A) resistor r=1.4976 c=0
Rk28 (\2\:VDD \3\:VDD) resistor r=0.0875 c=0
Rk29 (\3\:VDD \4\:VDD) resistor r=0.3631 c=0
Rk30 (\4\:VDD \5\:VDD) resistor r=0.1727 c=0
Rk31 (\5\:VDD \6\:VDD) resistor r=0.2527 c=0
Rk32 (\6\:VDD \7\:VDD) resistor r=0.07498 c=0
Rk33 (\7\:VDD \8\:VDD) resistor r=0.1351 c=0
Rk35 (\9\:VDD VDD) resistor r=0.09998 c=0
Rk34 (\8\:VDD \9\:VDD) resistor r=0.1151 c=0
Rk36 (\3\:VDD \11\:VDD) resistor r=0.07334 c=0
Rk37 (\5\:VDD \13\:VDD) resistor r=0.3412 c=0
Rk38 (\6\:VDD \15\:VDD) resistor r=0.07334 c=0
Rk39 (\8\:VDD \17\:VDD) resistor r=0.07334 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.1008 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.5135 c=0
Rk22 (\4\:VSS \5\:VSS) resistor r=0.1376 c=0
Rk24 (\6\:VSS VSS) resistor r=0.215 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.3356 c=0
Rk25 (\3\:VSS \8\:VSS) resistor r=0.1194 c=0
Rk26 (\4\:VSS \10\:VSS) resistor r=0.3446 c=0
Rk27 (\6\:VSS \12\:VSS) resistor r=0.2982 c=0
Rk3 (\9\:B B) resistor r=0.03907 c=0
Rk4 (\6\:COb \8\:COb) resistor r=0.818 c=0
Rk5 (\8\:COb \9\:COb) resistor r=0.3443 c=0
Rk8 (\5\:n1 \6\:n1) resistor r=0.1722 c=0
Rk9 (\6\:n1 \7\:n1) resistor r=0.9338 c=0
Rk10 (\7\:n1 \9\:n1) resistor r=0.4559 c=0
Rk11 (\6\:n1 \10\:n1) resistor r=0.113 c=0
Rk12 (\7\:n1 \12\:n1) resistor r=0.05386 c=0
Rk13 (\4\:n0 \6\:n0) resistor r=0.5134 c=0
Rk14 (\6\:n0 \8\:n0) resistor r=0.4043 c=0
Rk15 (\4\:Sb \5\:Sb) resistor r=0.07708 c=0
Rk16 (\5\:Sb \7\:Sb) resistor r=0.4079 c=0
Rk17 (\5\:Sb \9\:Sb) resistor r=0.4143 c=0
Rl7 (\5\:A \6\:A) resistor r=165.385 c=0
Rl8 (\6\:A \7\:A) resistor r=26.1559 c=0
Rl4 (\1\:A \2\:A) resistor r=166.187 c=0
Rl6 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl5 (\2\:A \3\:A) resistor r=4.3551 c=0
Rl11 (\2\:B \3\:B) resistor r=351.489 c=0
Rl10 (\1\:B \2\:B) resistor r=224.238 c=0
Rl16 (\5\:B \8\:B) resistor r=83.4251 c=0
Rl14 (\5\:B \6\:B) resistor r=95.9489 c=0
Rl12 (\3\:B \4\:B) resistor r=47.8734 c=0
Rl15 (\4\:B \7\:B) resistor r=116.199 c=0
Rl13 (\4\:B \5\:B) resistor r=206.184 c=0
Rl1 (COb \2\:COb) resistor r=3.5213 c=0
Rl3 (\2\:COb \4\:COb) resistor r=34.3295 c=0
Rl2 (\2\:COb \3\:COb) resistor r=170.868 c=0
Rl17 (\3\:n1 \4\:n1) resistor r=41.0764 c=0
Rl9 (n1 \2\:n1) resistor r=26.1559 c=0
Rl18 (n0 \2\:n0) resistor r=165.385 c=0
Rl19 (\2\:n0 \3\:n0) resistor r=35.7713 c=0
Rl20 (Sb \2\:Sb) resistor r=101.156 c=0
Rl21 (\2\:Sb \3\:Sb) resistor r=35.7713 c=0
Rz6 (\3\:S \4\:S) resistor r=75 c=0
Rz1 (\1\:CO \2\:CO) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz11 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz12 (\1\:VDD \7\:VDD) resistor r=37.5 c=0
Rz13 (\1\:VDD \9\:VDD) resistor r=25 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz2 (\5\:COb \6\:COb) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz5 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry6 (\1\:S \2\:S) resistor r=62 c=0
Ry1 (\3\:CO \4\:CO) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry8 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry9 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry2 (\7\:COb \8\:COb) resistor r=62 c=0
Ry3 (\11\:n1 \12\:n1) resistor r=62 c=0
Ry4 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry5 (\8\:Sb \9\:Sb) resistor r=62 c=0
Rx3 (\3\:A \8\:A) resistor r=45 c=0
Rx4 (\7\:A \9\:A) resistor r=45 c=0
Rx1 (\5\:B \9\:B) resistor r=45 c=0
Rx2 (COb \9\:COb) resistor r=45 c=0
Rx5 (\4\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n1 \10\:n1) resistor r=45 c=0
Rx7 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Sb \4\:Sb) resistor r=45 c=0
mn8 (\1\:CO \3\:COb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn6 (n4 \4\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=1.523e-14 ps=6.3e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.05e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn7 (\5\:COb \6\:B n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.523e-14 ad=2.248e-14 ps=5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\8\:n1 \7\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.355e-06 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\5\:n0 \6\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.988e-14 ps=7.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.1e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn4 (\6\:Sb n1 \5\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=7.8e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn3 (\6\:Sb \1\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.32e-14 ps=6.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=5.75e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn2 (n2 \2\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.055e-14 ad=2.827e-14 ps=1.49e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=3.35e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn5 (\3\:S \3\:Sb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.055e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mp6 (\7\:COb \1\:A \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.02e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=3.05e-07 sd=160n sca=12.7491 \
        scb=0.0105457 scc=0.000240287 m=(1)
mp7 (\7\:COb \8\:B \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=1e-07 sd=160n sca=11.835 scb=0.00987003 \
        scc=0.000239311 m=(1)
mp1 (\11\:n1 \3\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.345e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp0 (\7\:n0 \5\:A \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.697e-14 ps=8.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.1e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp4 (\8\:Sb \2\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=6.558e-14 ps=9.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=7.9e-07 sd=160n sca=16.6855 \
        scb=0.0164031 scc=0.00112486 m=(1)
mp3 (\8\:Sb \3\:n1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=4.4e-07 sd=160n sca=18.5655 \
        scb=0.0181901 scc=0.00113112 m=(1)
mp2 (n3 n0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.065e-14 ad=1.29e-14 ps=1.67e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=3.35e-07 sd=160n sca=20.0958 \
        scb=0.0206924 scc=0.00116659 m=(1)
mp5 (\1\:S Sb \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.065e-14 ad=3.01e-14 ps=1.67e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.4e-07 sd=160n sca=29.0691 \
        scb=0.0342129 scc=0.00232071 m=(1)
ends ADDHXL
// End of subcircuit definition.

// Generated for: spectre (May  8 14:57:31 2012 )
// Library name: gsclib045
// Cell name: AND2X1
// View name: extracted

simulator lang=spectre

subckt AND2X1 A B VDD VSS Y
mp1 (\8\:n0 \4\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.548e-14 ps=1.37e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-07 sb=5.55e-07 sd=160n sca=28.7776 \
        scb=0.0317346 scc=0.0021577 m=(1)
C1 (Y VSS) capacitor c=5.39906e-17
C2 (VDD VSS) capacitor c=6.68074e-17
C3 (A VSS) capacitor c=7.98404e-17
C4 (n0 VSS) capacitor c=4.92759e-17
C5 (\1\:A VSS) capacitor c=4.91463e-17
C6 (\4\:B VSS) capacitor c=3.79444e-17
C7 (\3\:n0 VSS) capacitor c=4.0145e-17
C8 (\3\:A VSS) capacitor c=5.90945e-17
C9 (\1\:B VSS) capacitor c=5.24568e-17
C10 (\2\:n0 VSS) capacitor c=3.37586e-17
C11 (\2\:A VSS) capacitor c=6.63104e-17
C12 (\3\:B VSS) capacitor c=1.51302e-17
C13 (\1\:Y VSS) capacitor c=5.1574e-17
C14 (\1\:VDD VSS) capacitor c=4.55635e-17
C15 (\8\:n0 VSS) capacitor c=6.68434e-17
C16 (\5\:VDD VSS) capacitor c=5.77326e-18
C17 (\3\:Y VSS) capacitor c=3.03887e-17
C18 (\6\:n0 VSS) capacitor c=3.38024e-17
C19 (\2\:B VSS) capacitor c=4.60022e-17
C20 (\5\:B VSS) capacitor c=3.52401e-17
C21 (\7\:B VSS) capacitor c=3.91714e-17
C22 (\4\:A VSS) capacitor c=5.7719e-17
C23 (\4\:n0 VSS) capacitor c=7.37377e-17
C24 (\5\:n0 VSS) capacitor c=9.45846e-17
C25 (\4\:VDD VSS) capacitor c=2.24884e-17
Rk8 (\2\:Y Y) resistor r=0.3325 c=0
Rk9 (Y \4\:Y) resistor r=0.1462 c=0
Rk1 (\5\:B \6\:B) resistor r=0.001776 c=0
Rk2 (B \7\:B) resistor r=0.001658 c=0
Rk3 (\5\:B \7\:B) resistor r=0.03546 c=0
Rk14 (\4\:VSS VSS) resistor r=0.1503 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3451 c=0
Rk11 (\4\:VDD VDD) resistor r=0.151 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3363 c=0
Rk12 (VDD \6\:VDD) resistor r=0.06754 c=0
Rk4 (A \4\:A) resistor r=0.1436 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.2844 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.1371 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.4669 c=0
Rl3 (\2\:B \4\:B) resistor r=106.246 c=0
Rl1 (\1\:B \2\:B) resistor r=74.3274 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1529 c=0
Rl4 (\1\:A \2\:A) resistor r=89.5596 c=0
Rl5 (\2\:A \3\:A) resistor r=81.8672 c=0
Rl6 (n0 \2\:n0) resistor r=39.5596 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=64.5595 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (net127 \1\:B \6\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn1 (\1\:VSS \3\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.438e-14 ps=4.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn2 (\3\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.64e-14 ps=9.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32404e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp0 (\8\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.548e-14 ps=1.1e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=3.45e-07 sd=160n sca=18.926 \
        scb=0.0187755 scc=0.000316918 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.39808e-07 sb=1.4e-07 sd=160n sca=35.5228 \
        scb=0.0370147 scc=0.0033854 m=(1)
ends AND2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:58:19 2012 )
// Library name: gsclib045
// Cell name: AND2X2
// View name: extracted

simulator lang=spectre

subckt AND2X2 A B VDD VSS Y
mp1 (\11\:n0 \4\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.7e-07 sd=160n sca=30.8503 scb=0.0332284 \
        scc=0.00283483 m=(1)
C1 (B VSS) capacitor c=4.67429e-17
C2 (Y VSS) capacitor c=6.25486e-17
C3 (VDD VSS) capacitor c=6.63474e-17
C4 (A VSS) capacitor c=8.57922e-17
C5 (net73 VSS) capacitor c=1.40724e-18
C6 (n0 VSS) capacitor c=1.68998e-16
C7 (\1\:A VSS) capacitor c=5.7916e-17
C8 (\4\:B VSS) capacitor c=2.85901e-17
C9 (\3\:A VSS) capacitor c=5.4907e-17
C10 (\1\:B VSS) capacitor c=7.19542e-17
C11 (\2\:A VSS) capacitor c=6.60103e-17
C12 (\3\:B VSS) capacitor c=1.26608e-17
C13 (\1\:VDD VSS) capacitor c=8.89585e-17
C14 (\1\:Y VSS) capacitor c=8.99968e-17
C15 (\11\:n0 VSS) capacitor c=9.03189e-17
C16 (\7\:VDD VSS) capacitor c=4.99239e-18
C17 (\3\:VDD VSS) capacitor c=2.28762e-17
C18 (\3\:Y VSS) capacitor c=4.86384e-17
C19 (\9\:n0 VSS) capacitor c=1.85754e-17
C20 (\2\:B VSS) capacitor c=4.5993e-17
C21 (\5\:B VSS) capacitor c=3.58698e-17
C22 (\4\:A VSS) capacitor c=6.50433e-17
C23 (\7\:n0 VSS) capacitor c=8.42019e-17
C24 (\8\:n0 VSS) capacitor c=8.40119e-17
Rk1 (B \5\:B) resistor r=0.09314 c=0
Rk6 (\2\:Y Y) resistor r=0.3407 c=0
Rk7 (Y \4\:Y) resistor r=0.1684 c=0
Rk10 (\1\:VDD VDD) resistor r=0.1855 c=0
Rk12 (VDD \8\:VDD) resistor r=0.101 c=0
Rk2 (A \4\:A) resistor r=0.2134 c=0
Rk15 (\1\:VSS VSS) resistor r=0.2015 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3649 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.07427 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.5036 c=0
Rl3 (\2\:B \4\:B) resistor r=24.4619 c=0
Rl1 (\1\:B \2\:B) resistor r=189.894 c=0
Rl2 (\2\:B \3\:B) resistor r=4.5402 c=0
Rl4 (\1\:A \2\:A) resistor r=133.384 c=0
Rl5 (\2\:A \3\:A) resistor r=56.461 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz4 (VDD \3\:VDD) resistor r=75 c=0
Rz3 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz1 (\10\:n0 \9\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry4 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\12\:n0 \11\:n0) resistor r=62 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\9\:n0 \1\:B net73 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn0 (net73 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=8.7e-15 ps=1.41e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.65e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5e-14 \
        ad=4.16e-14 ps=1.105e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.14615e-07 sb=3.45e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(2)
mp0 (\11\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=3.44e-14 ps=1.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.65e-07 sd=160n sca=16.7744 \
        scb=0.0157078 scc=0.000273548 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=6.24e-14 ps=1.095e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.41026e-07 sb=3.45e-07 sd=160n sca=23.9894 \
        scb=0.0214998 scc=0.00175538 m=(2)
ends AND2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:04:02 2012 )
// Library name: gsclib045
// Cell name: AND2X4
// View name: extracted

simulator lang=spectre

subckt AND2X4 A B VDD VSS Y
mp1 (\19\:net61 \4\:B \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=7.8e-14 ps=1.06e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26e-06 sd=160n sca=25.0495 \
        scb=0.0285542 scc=0.00163822 m=(1)
C1 (Y VSS) capacitor c=3.37759e-17
C2 (B VSS) capacitor c=3.37277e-17
C3 (VDD VSS) capacitor c=9.91319e-17
C4 (A VSS) capacitor c=2.80325e-17
C5 (net61 VSS) capacitor c=3.62048e-16
C6 (\1\:A VSS) capacitor c=4.83246e-17
C7 (\4\:B VSS) capacitor c=5.12021e-17
C8 (\3\:A VSS) capacitor c=7.65536e-17
C9 (\1\:B VSS) capacitor c=6.61702e-17
C10 (\2\:A VSS) capacitor c=5.39207e-17
C11 (\3\:B VSS) capacitor c=1.23925e-17
C12 (\1\:Y VSS) capacitor c=1.84638e-16
C13 (\19\:net61 VSS) capacitor c=1.05609e-16
C14 (\13\:VDD VSS) capacitor c=4.47863e-17
C15 (\1\:VDD VSS) capacitor c=3.57343e-17
C16 (\17\:net61 VSS) capacitor c=2.16126e-17
C17 (\2\:B VSS) capacitor c=3.7623e-17
C18 (\5\:B VSS) capacitor c=3.60509e-17
C19 (\4\:A VSS) capacitor c=4.09231e-17
C20 (\15\:net61 VSS) capacitor c=1.01521e-16
C21 (\16\:net61 VSS) capacitor c=1.16615e-17
C22 (\4\:Y VSS) capacitor c=1.76842e-16
C23 (\3\:VDD VSS) capacitor c=1.68378e-16
Rk10 (\1\:Y Y) resistor r=0.3473 c=0
Rk11 (Y \4\:Y) resistor r=0.163 c=0
Rk1 (B \5\:B) resistor r=0.12 c=0
Rk30 (\3\:VSS VSS) resistor r=0.2003 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.03742 c=0
Rk22 (\3\:VDD VDD) resistor r=0.2006 c=0
Rk15 (\2\:VDD \3\:VDD) resistor r=0.03742 c=0
Rk23 (VDD \14\:VDD) resistor r=0.2871 c=0
Rk2 (A \4\:A) resistor r=0.135 c=0
Rk4 (net61 \15\:net61) resistor r=0.3696 c=0
Rk5 (\15\:net61 \16\:net61) resistor r=0.142 c=0
Rk6 (\16\:net61 \18\:net61) resistor r=0.1512 c=0
Rk7 (\15\:net61 \20\:net61) resistor r=0.4953 c=0
Rk8 (\16\:net61 \21\:net61) resistor r=0.03043 c=0
Rl3 (\2\:B \4\:B) resistor r=141.048 c=0
Rl1 (\1\:B \2\:B) resistor r=102.231 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rl4 (\1\:A \2\:A) resistor r=89.6174 c=0
Rl5 (\2\:A \3\:A) resistor r=105.002 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz1 (\18\:net61 \17\:net61) resistor r=75 c=0
Rz2 (\21\:net61 \17\:net61) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\3\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry7 (\14\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry1 (\20\:net61 \19\:net61) resistor r=20.6667 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
mn1 (\17\:net61 \1\:B net69 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn0 (net69 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=1.56e-14 ps=8.9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.015e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\4\:Y net61 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=7.85e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
mp0 (\19\:net61 \1\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=7.8e-14 ps=1.15e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.015e-06 sd=160n sca=14.3199 \
        scb=0.0126894 scc=0.000252227 m=(1)
mp2 (\1\:Y net61 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.728e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=7.85e-07 sd=160n sca=12.3494 \
        scb=0.00998202 scc=0.000232154 m=(4)
ends AND2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:04:41 2012 )
// Library name: gsclib045
// Cell name: AND2X6
// View name: extracted

simulator lang=spectre

subckt AND2X6 A B VDD VSS Y
mp0 (\19\:net61 \2\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.78e-06 sd=160n sca=29.498 \
        scb=0.0332632 scc=0.00250913 m=(2)
C1 (B VSS) capacitor c=3.17756e-17
C2 (Y VSS) capacitor c=1.41296e-17
C3 (VDD VSS) capacitor c=4.13472e-16
C4 (A VSS) capacitor c=1.41163e-17
C5 (net61 VSS) capacitor c=3.68833e-16
C6 (8 VSS) capacitor c=3.01608e-18
C7 (\1\:B VSS) capacitor c=1.22763e-16
C8 (\6\:A VSS) capacitor c=5.01529e-17
C9 (\5\:B VSS) capacitor c=3.8639e-17
C10 (\4\:B VSS) capacitor c=5.58512e-17
C11 (\1\:A VSS) capacitor c=5.69198e-17
C12 (\2\:A VSS) capacitor c=3.67579e-16
C13 (\1\:Y VSS) capacitor c=2.64899e-16
C14 (\14\:VDD VSS) capacitor c=6.72946e-17
C15 (\22\:net61 VSS) capacitor c=9.12928e-17
C16 (\8\:B VSS) capacitor c=4.37499e-17
C17 (\18\:net61 VSS) capacitor c=8.85732e-17
C18 (\19\:net61 VSS) capacitor c=2.28483e-16
C19 (\4\:Y VSS) capacitor c=2.08634e-16
Rk1 (\7\:B \8\:B) resistor r=0.005637 c=0
Rk2 (\9\:B B) resistor r=0.005637 c=0
Rk3 (\8\:B \9\:B) resistor r=0.04192 c=0
Rk13 (\1\:Y Y) resistor r=0.0274 c=0
Rk14 (Y \4\:Y) resistor r=0.1844 c=0
Rk30 (VDD \15\:VDD) resistor r=0.3078 c=0
Rk5 (\2\:A A) resistor r=0.02629 c=0
Rk35 (\7\:VSS VSS) resistor r=0.04971 c=0
Rk34 (\1\:VSS \7\:VSS) resistor r=0.3532 c=0
Rk39 (\7\:VSS \14\:VSS) resistor r=0.2777 c=0
Rk7 (net61 \18\:net61) resistor r=0.1702 c=0
Rk8 (\18\:net61 \19\:net61) resistor r=0.4053 c=0
Rk10 (\18\:net61 \23\:net61) resistor r=0.5215 c=0
Rl6 (\1\:B \5\:B) resistor r=76.1566 c=0
Rl5 (\1\:B \4\:B) resistor r=74.2328 c=0
Rl9 (\2\:A \6\:A) resistor r=29.9451 c=0
Rl1 (\2\:A \1\:A) resistor r=66.5539 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz1 (\23\:net61 \22\:net61) resistor r=37.5 c=0
Ry10 (\15\:VDD \14\:VDD) resistor r=31 c=0
Ry12 (VSS \4\:VSS) resistor r=62 c=0
Ry11 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Rx1 (\7\:B \1\:B) resistor r=45 c=0
mn1 (7 \1\:A \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.665e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn0 (\22\:net61 \4\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.56e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn0_1__rcx (\22\:net61 \5\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=4.16e-14 ps=7.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.355e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn1_1__rcx (8 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=2.73e-14 ps=1.02e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.205e-06 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(1)
mn2 (\4\:Y net61 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=4.836e-14 ps=9.56e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3129e-07 sb=9.6e-07 sd=160n sca=10.4852 \
        scb=0.00950193 scc=0.000416321 m=(5)
mp1 (\19\:net61 \1\:B \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.575e-06 sd=160n sca=19.4642 \
        scb=0.0185905 scc=0.00114451 m=(2)
mp2 (\1\:Y net61 VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.13617e-07 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:05:20 2012 )
// Library name: gsclib045
// Cell name: AND2X8
// View name: extracted

simulator lang=spectre

subckt AND2X8 A B VDD VSS Y
mp0 (\27\:n0 \2\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.612e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=25.31 scb=0.0290957 \
        scc=0.00167407 m=(2)
C1 (B VSS) capacitor c=9.43984e-17
C2 (Y VSS) capacitor c=1.65266e-17
C3 (VDD VSS) capacitor c=4.73295e-16
C4 (A VSS) capacitor c=2.6794e-17
C5 (n0 VSS) capacitor c=5.80687e-16
C6 (8 VSS) capacitor c=1.77389e-18
C7 (\1\:B VSS) capacitor c=1.35929e-16
C8 (\6\:A VSS) capacitor c=6.22648e-17
C9 (\6\:B VSS) capacitor c=5.73994e-17
C10 (\5\:B VSS) capacitor c=5.31912e-17
C11 (\1\:A VSS) capacitor c=4.75057e-17
C12 (\2\:A VSS) capacitor c=3.63526e-16
C13 (\1\:Y VSS) capacitor c=3.78623e-16
C14 (\21\:VDD VSS) capacitor c=6.7151e-17
C15 (\1\:VDD VSS) capacitor c=6.08039e-17
C16 (\30\:n0 VSS) capacitor c=8.96576e-17
C17 (\26\:n0 VSS) capacitor c=8.60718e-17
C18 (\27\:n0 VSS) capacitor c=2.18322e-16
C19 (\4\:Y VSS) capacitor c=3.93778e-16
Rk1 (\8\:B B) resistor r=0.003831 c=0
Rk12 (\1\:Y Y) resistor r=0.1251 c=0
Rk13 (Y \4\:Y) resistor r=0.08761 c=0
Rk25 (\2\:VDD VDD) resistor r=0.1077 c=0
Rk39 (VDD \22\:VDD) resistor r=0.2723 c=0
Rk3 (\2\:A A) resistor r=0.1048 c=0
Rk45 (\8\:VSS VSS) resistor r=0.04973 c=0
Rk44 (\1\:VSS \8\:VSS) resistor r=0.3509 c=0
Rk50 (\8\:VSS \17\:VSS) resistor r=0.2689 c=0
Rk6 (n0 \26\:n0) resistor r=0.2209 c=0
Rk7 (\26\:n0 \27\:n0) resistor r=0.3448 c=0
Rk9 (\26\:n0 \31\:n0) resistor r=0.532 c=0
Rl7 (\1\:B \6\:B) resistor r=97.7911 c=0
Rl6 (\1\:B \5\:B) resistor r=97.7911 c=0
Rl10 (\2\:A \6\:A) resistor r=32.0055 c=0
Rl1 (\2\:A \1\:A) resistor r=32.6923 c=0
Rz7 (VDD \1\:VDD) resistor r=6.8182 c=0
Rz6 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=37.5 c=0
Rz1 (\31\:n0 \30\:n0) resistor r=37.5 c=0
Ry12 (\22\:VDD \21\:VDD) resistor r=31 c=0
Ry14 (VSS \4\:VSS) resistor r=62 c=0
Ry13 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Rx1 (\8\:B \1\:B) resistor r=45 c=0
mn0 (7 \1\:A \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn1 (\30\:n0 \5\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.55e-07 sb=1.955e-06 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn1_1__rcx (\30\:n0 \6\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.75e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn0_1__rcx (8 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.47e-14 ad=1.56e-14 ps=1.05e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.645e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn2 (\4\:Y n0 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.97e-14 ad=4.636e-14 ps=9.3e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.56949e-07 sb=1.37e-06 sd=160n sca=10.0255 \
        scb=0.00888998 scc=0.000340749 m=(7)
mp1 (\27\:n0 \1\:B \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.1462 scb=0.0152434 \
        scc=0.000513123 m=(2)
mp2 (\1\:Y n0 VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.212e-14 \
        ad=6.993e-14 ps=1.21714e-06 pd=1.20429e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.75618e-07 sb=1.37e-06 sd=160n sca=15.1493 scb=0.013431 \
        scc=0.000976912 m=(7)
ends AND2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:06:01 2012 )
// Library name: gsclib045
// Cell name: AND2XL
// View name: extracted

simulator lang=spectre

subckt AND2XL A B VDD VSS Y
mp1 (\9\:net57 \4\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=1.47e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=31.2881 scb=0.0351388 \
        scc=0.00259704 m=(1)
C1 (Y VSS) capacitor c=4.82301e-17
C2 (VDD VSS) capacitor c=6.49293e-17
C3 (A VSS) capacitor c=3.65716e-17
C4 (net73 VSS) capacitor c=1.08081e-18
C5 (net57 VSS) capacitor c=4.57065e-17
C6 (\4\:A VSS) capacitor c=3.49708e-17
C7 (\4\:B VSS) capacitor c=3.93495e-17
C8 (\4\:net57 VSS) capacitor c=2.72043e-17
C9 (\3\:A VSS) capacitor c=6.69416e-17
C10 (\1\:B VSS) capacitor c=4.67037e-17
C11 (\3\:net57 VSS) capacitor c=2.60982e-17
C12 (\1\:A VSS) capacitor c=2.61179e-17
C13 (\3\:B VSS) capacitor c=1.04529e-17
C14 (\1\:Y VSS) capacitor c=4.38469e-17
C15 (\1\:VDD VSS) capacitor c=3.14118e-17
C16 (\9\:net57 VSS) capacitor c=4.70484e-17
C17 (\6\:VDD VSS) capacitor c=4.48878e-18
C18 (\3\:VDD VSS) capacitor c=2.01238e-17
C19 (\3\:Y VSS) capacitor c=1.80156e-17
C20 (\7\:net57 VSS) capacitor c=3.36656e-17
C21 (\2\:B VSS) capacitor c=3.38743e-17
C22 (\2\:A VSS) capacitor c=4.14626e-17
C23 (\2\:net57 VSS) capacitor c=2.90531e-17
C24 (\5\:B VSS) capacitor c=2.04154e-17
C25 (\7\:B VSS) capacitor c=3.62428e-17
C26 (\5\:A VSS) capacitor c=4.7682e-17
C27 (\5\:net57 VSS) capacitor c=4.77299e-17
C28 (\6\:net57 VSS) capacitor c=5.29464e-17
Rk8 (\2\:Y Y) resistor r=0.3123 c=0
Rk9 (Y \4\:Y) resistor r=0.06276 c=0
Rk1 (\5\:B \6\:B) resistor r=0.001154 c=0
Rk2 (B \7\:B) resistor r=0.001038 c=0
Rk3 (\5\:B \7\:B) resistor r=0.0269 c=0
Rk15 (\4\:VSS VSS) resistor r=0.1499 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.3677 c=0
Rk11 (\4\:VDD VDD) resistor r=0.2009 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3507 c=0
Rk13 (VDD \7\:VDD) resistor r=0.1408 c=0
Rk4 (A \5\:A) resistor r=0.05388 c=0
Rk5 (\5\:net57 \6\:net57) resistor r=0.1568 c=0
Rk6 (\6\:net57 \8\:net57) resistor r=0.1877 c=0
Rk7 (\6\:net57 \10\:net57) resistor r=0.3018 c=0
Rl3 (\2\:B \4\:B) resistor r=99.4619 c=0
Rl1 (\1\:B \2\:B) resistor r=76.4327 c=0
Rl2 (\2\:B \3\:B) resistor r=4.5402 c=0
Rl6 (\2\:A \4\:A) resistor r=52.7257 c=0
Rl5 (\2\:A \3\:A) resistor r=116.187 c=0
Rl4 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl7 (net57 \2\:net57) resistor r=121.957 c=0
Rl9 (\2\:net57 \4\:net57) resistor r=46.9565 c=0
Rl8 (\2\:net57 \3\:net57) resistor r=2.4801 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\3\:VDD VDD) resistor r=75 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\7\:net57 \8\:net57) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\9\:net57 \10\:net57) resistor r=62 c=0
Rx1 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx3 (\3\:net57 \5\:net57) resistor r=45 c=0
mn1 (\7\:net57 \1\:B net73 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=2.03e-14 ps=4.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn0 (net73 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.43e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn2 (\3\:Y \4\:net57 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mp0 (\9\:net57 \4\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.45e-07 sd=160n sca=20.7658 \
        scb=0.021645 scc=0.000601202 m=(1)
mp2 (\1\:Y net57 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=27.1972 \
        scb=0.0311782 scc=0.00169862 m=(1)
ends AND2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 13:06:39 2012 )
// Library name: gsclib045
// Cell name: AND3X1
// View name: extracted

simulator lang=spectre

subckt AND3X1 A B C VDD VSS Y
mp2 (\7\:net086 \4\:C \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.57e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=15.6848 \
        scb=0.0150605 scc=0.00022885 m=(1)
C1 (Y VSS) capacitor c=3.81897e-17
C2 (B VSS) capacitor c=5.51356e-17
C3 (C VSS) capacitor c=7.46266e-17
C4 (VDD VSS) capacitor c=1.39856e-16
C5 (A VSS) capacitor c=1.07267e-16
C6 (net0106 VSS) capacitor c=3.45924e-18
C7 (net086 VSS) capacitor c=5.02202e-17
C8 (net0102 VSS) capacitor c=7.37195e-18
C9 (\1\:A VSS) capacitor c=3.53338e-17
C10 (\1\:B VSS) capacitor c=4.96142e-17
C11 (\4\:C VSS) capacitor c=3.64815e-17
C12 (\3\:net086 VSS) capacitor c=3.25759e-17
C13 (\3\:A VSS) capacitor c=4.76223e-17
C14 (\3\:B VSS) capacitor c=4.26131e-17
C15 (\1\:C VSS) capacitor c=5.49272e-17
C16 (\2\:net086 VSS) capacitor c=2.94426e-17
C17 (\2\:A VSS) capacitor c=4.20506e-17
C18 (\2\:B VSS) capacitor c=5.67769e-17
C19 (\3\:C VSS) capacitor c=1.74217e-17
C20 (\3\:Y VSS) capacitor c=5.55298e-17
C21 (\1\:VDD VSS) capacitor c=3.19081e-17
C22 (\11\:net086 VSS) capacitor c=1.53313e-17
C23 (\7\:VDD VSS) capacitor c=1.63639e-17
C24 (\7\:net086 VSS) capacitor c=3.46703e-17
C25 (\3\:VDD VSS) capacitor c=2.99724e-17
C26 (\1\:Y VSS) capacitor c=1.80832e-17
C27 (\9\:net086 VSS) capacitor c=3.19328e-17
C28 (\2\:C VSS) capacitor c=5.23632e-17
C29 (\4\:B VSS) capacitor c=5.13495e-17
C30 (\4\:net086 VSS) capacitor c=6.42474e-17
C31 (\5\:net086 VSS) capacitor c=9.65089e-17
C32 (\6\:net086 VSS) capacitor c=8.44811e-17
C33 (\5\:VDD VSS) capacitor c=9.11082e-18
Rk9 (Y \2\:Y) resistor r=0.0806 c=0
Rk10 (Y \4\:Y) resistor r=0.3403 c=0
Rk2 (\4\:B B) resistor r=0.1521 c=0
Rk17 (\4\:VSS VSS) resistor r=0.2995 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.4236 c=0
Rk1 (\5\:C C) resistor r=0.003669 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.2957 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.2172 c=0
Rk14 (\6\:VDD VDD) resistor r=0.04971 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.1322 c=0
Rk15 (\5\:VDD \8\:VDD) resistor r=0.07288 c=0
Rk3 (\4\:A A) resistor r=0.002985 c=0
Rk4 (\4\:net086 \5\:net086) resistor r=0.3756 c=0
Rk5 (\5\:net086 \6\:net086) resistor r=0.524 c=0
Rk6 (\6\:net086 \8\:net086) resistor r=0.3158 c=0
Rk7 (\5\:net086 \10\:net086) resistor r=0.2639 c=0
Rk8 (\6\:net086 \12\:net086) resistor r=0.05686 c=0
Rl4 (\1\:B \2\:B) resistor r=127.615 c=0
Rl5 (\2\:B \3\:B) resistor r=87.2302 c=0
Rl3 (\2\:C \4\:C) resistor r=49.4619 c=0
Rl1 (\1\:C \2\:C) resistor r=191.817 c=0
Rl2 (\2\:C \3\:C) resistor r=23.4547 c=0
Rl6 (\1\:A \2\:A) resistor r=55.7692 c=0
Rl7 (\2\:A \3\:A) resistor r=160.714 c=0
Rl8 (net086 \2\:net086) resistor r=114.56 c=0
Rl9 (\2\:net086 \3\:net086) resistor r=26.098 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz1 (\9\:net086 \10\:net086) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (\7\:net086 \8\:net086) resistor r=62 c=0
Ry2 (\11\:net086 \12\:net086) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:net086 \4\:net086) resistor r=45 c=0
mn2 (\9\:net086 \1\:C net0106 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn1 (net0106 \3\:B net0102 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=7.3e-07 sd=160n sca=14.3814 scb=0.0152134 \
        scc=0.00088947 m=(1)
mn0 (net0102 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.452e-14 ad=3.19e-14 ps=1.05e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.65e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn3 (\1\:Y \3\:net086 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.452e-14 ad=4.03e-14 ps=1.05e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.49904e-07 sb=1.55e-07 sd=160n sca=11.5806 \
        scb=0.0111274 scc=0.000535497 m=(1)
mp1 (\11\:net086 \1\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.57e-14 ad=5.913e-14 ps=1.41e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.3e-07 sd=160n sca=11.8763 \
        scb=0.00832069 scc=7.33429e-05 m=(1)
mp0 (\11\:net086 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=5.913e-14 ps=1.2e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=4.1e-07 sd=160n sca=12.6661 \
        scb=0.00970078 scc=8.28205e-05 m=(1)
mp3 (\3\:Y net086 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=6.045e-14 ps=1.2e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85128e-07 sb=1.55e-07 sd=160n sca=23.7459 \
        scb=0.0272453 scc=0.00137918 m=(1)
ends AND3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:07:17 2012 )
// Library name: gsclib045
// Cell name: AND3X2
// View name: extracted

simulator lang=spectre

subckt AND3X2 A B C VDD VSS Y
mp2 (\12\:net95 \4\:C \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=14.6753 \
        scb=0.0132849 scc=0.000158573 m=(1)
C1 (B VSS) capacitor c=5.90659e-17
C2 (Y VSS) capacitor c=3.29436e-17
C3 (C VSS) capacitor c=7.26686e-17
C4 (VDD VSS) capacitor c=1.25921e-16
C5 (net111 VSS) capacitor c=2.9886e-18
C6 (net95 VSS) capacitor c=1.51349e-16
C7 (net103 VSS) capacitor c=4.94232e-18
C8 (\1\:A VSS) capacitor c=3.13026e-17
C9 (\1\:B VSS) capacitor c=6.16302e-17
C10 (\4\:C VSS) capacitor c=4.23682e-17
C11 (\3\:A VSS) capacitor c=6.7882e-17
C12 (\3\:B VSS) capacitor c=3.42178e-17
C13 (\1\:C VSS) capacitor c=4.8473e-17
C14 (\5\:net95 VSS) capacitor c=2.23875e-17
C15 (\2\:A VSS) capacitor c=4.43494e-17
C16 (\2\:B VSS) capacitor c=6.26436e-17
C17 (\3\:C VSS) capacitor c=1.8993e-17
C18 (\1\:VDD VSS) capacitor c=1.06589e-16
C19 (\1\:Y VSS) capacitor c=8.6637e-17
C20 (\16\:net95 VSS) capacitor c=2.73468e-17
C21 (\9\:VDD VSS) capacitor c=3.16734e-17
C22 (\12\:net95 VSS) capacitor c=4.14966e-17
C23 (\3\:Y VSS) capacitor c=2.20496e-17
C24 (\14\:net95 VSS) capacitor c=6.15557e-17
C25 (\2\:C VSS) capacitor c=5.57957e-17
C26 (\4\:B VSS) capacitor c=5.47015e-17
C27 (\4\:A VSS) capacitor c=1.09854e-16
C28 (\9\:net95 VSS) capacitor c=2.98447e-17
C29 (\10\:net95 VSS) capacitor c=7.675e-17
C30 (\11\:net95 VSS) capacitor c=5.60148e-17
C31 (\5\:VDD VSS) capacitor c=1.73876e-17
C32 (\6\:VDD VSS) capacitor c=1.37314e-17
Rk2 (B \4\:B) resistor r=0.1673 c=0
Rk9 (\2\:Y Y) resistor r=0.3831 c=0
Rk10 (Y \4\:Y) resistor r=0.1549 c=0
Rk1 (\5\:C C) resistor r=0.003669 c=0
Rk12 (\1\:VDD \5\:VDD) resistor r=0.1222 c=0
Rk14 (\6\:VDD VDD) resistor r=0.1844 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.1647 c=0
Rk16 (\6\:VDD \10\:VDD) resistor r=0.2114 c=0
Rk3 (A \4\:A) resistor r=0.009655 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.05976 c=0
Rk21 (\6\:VSS VSS) resistor r=0.1996 c=0
Rk20 (\3\:VSS \6\:VSS) resistor r=0.2346 c=0
Rk4 (\9\:net95 \10\:net95) resistor r=0.1692 c=0
Rk5 (\10\:net95 \11\:net95) resistor r=0.3417 c=0
Rk6 (\11\:net95 \13\:net95) resistor r=0.3168 c=0
Rk7 (\10\:net95 \15\:net95) resistor r=0.4695 c=0
Rk8 (\11\:net95 \17\:net95) resistor r=0.07812 c=0
Rl4 (\1\:B \2\:B) resistor r=212.23 c=0
Rl5 (\2\:B \3\:B) resistor r=39.1533 c=0
Rl3 (\2\:C \4\:C) resistor r=118.693 c=0
Rl1 (\1\:C \2\:C) resistor r=136.048 c=0
Rl2 (\2\:C \3\:C) resistor r=28.0599 c=0
Rl6 (\1\:A \2\:A) resistor r=41.0764 c=0
Rl7 (\2\:A \3\:A) resistor r=210.307 c=0
Rl11 (net95 \5\:net95) resistor r=9.7447 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz1 (\15\:net95 \14\:net95) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry6 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\6\:VSS \1\:VSS) resistor r=12.4 c=0
Ry1 (\13\:net95 \12\:net95) resistor r=62 c=0
Ry2 (\17\:net95 \16\:net95) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\9\:net95 \5\:net95) resistor r=45 c=0
mn2 (\14\:net95 \1\:C net111 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.005e-06 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn1 (net111 \3\:B net103 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=8.45e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn0 (net103 \3\:A \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.19e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=5.8e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn3 (\3\:Y net95 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.772e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.90385e-07 sb=3.45e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(2)
mp1 (\16\:net95 \1\:B \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=11.6912 \
        scb=0.00845015 scc=7.57653e-05 m=(1)
mp0 (\16\:net95 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.308e-14 ad=4.73e-14 ps=1.39e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.95e-07 sd=160n sca=10.953 \
        scb=0.00760955 scc=7.37526e-05 m=(1)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.884e-14 ad=6.24e-14 ps=1.225e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.74103e-07 sb=3.45e-07 sd=160n sca=16.4316 \
        scb=0.0156277 scc=0.000553705 m=(2)
ends AND3X2
// End of subcircuit definition.

// Generated for: spectre (May  9 13:07:55 2012 )
// Library name: gsclib045
// Cell name: AND3X4
// View name: extracted

simulator lang=spectre

subckt AND3X4 A B C VDD VSS Y
mp2 (\19\:net95 \4\:C \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.46e-06 sd=160n sca=20.2396 \
        scb=0.0225687 scc=0.000779912 m=(1)
C1 (Y VSS) capacitor c=3.32661e-17
C2 (B VSS) capacitor c=3.36491e-17
C3 (C VSS) capacitor c=3.59128e-17
C4 (A VSS) capacitor c=6.69587e-17
C5 (VDD VSS) capacitor c=1.30039e-16
C6 (net111 VSS) capacitor c=2.13561e-18
C7 (net95 VSS) capacitor c=3.41867e-16
C8 (net107 VSS) capacitor c=9.55355e-18
C9 (\1\:A VSS) capacitor c=3.6731e-17
C10 (\1\:B VSS) capacitor c=5.71462e-17
C11 (\4\:C VSS) capacitor c=4.48243e-17
C12 (\3\:A VSS) capacitor c=5.72284e-17
C13 (\3\:B VSS) capacitor c=5.41429e-17
C14 (\1\:C VSS) capacitor c=5.11795e-17
C15 (\2\:A VSS) capacitor c=3.41661e-17
C16 (\2\:B VSS) capacitor c=5.2321e-17
C17 (\3\:C VSS) capacitor c=1.55028e-17
C18 (\1\:VDD VSS) capacitor c=1.57156e-16
C19 (\24\:net95 VSS) capacitor c=3.27109e-17
C20 (\12\:VDD VSS) capacitor c=4.00487e-17
C21 (\19\:net95 VSS) capacitor c=4.28695e-17
C22 (\3\:VDD VSS) capacitor c=4.85679e-17
C23 (\2\:Y VSS) capacitor c=1.19849e-16
C24 (\22\:net95 VSS) capacitor c=5.25798e-17
C25 (\2\:C VSS) capacitor c=3.31876e-17
C26 (\5\:C VSS) capacitor c=5.04019e-17
C27 (\4\:B VSS) capacitor c=8.1194e-17
C28 (\4\:A VSS) capacitor c=4.74901e-17
C29 (\17\:net95 VSS) capacitor c=1.20631e-16
C30 (\18\:net95 VSS) capacitor c=5.4953e-17
C31 (\1\:Y VSS) capacitor c=3.11851e-17
C32 (\6\:Y VSS) capacitor c=1.8814e-16
C33 (\11\:VDD VSS) capacitor c=3.04466e-18
Rk11 (Y \1\:Y) resistor r=0.08517 c=0
Rk12 (\1\:Y \2\:Y) resistor r=0.242 c=0
Rk14 (\1\:Y \6\:Y) resistor r=0.2064 c=0
Rk2 (\4\:B B) resistor r=0.08928 c=0
Rk29 (\1\:VSS VSS) resistor r=0.3256 c=0
Rk1 (C \5\:C) resistor r=0.07811 c=0
Rk3 (\4\:A A) resistor r=0.09542 c=0
Rk21 (\1\:VDD \10\:VDD) resistor r=0.09763 c=0
Rk22 (\10\:VDD \11\:VDD) resistor r=0.1177 c=0
Rk23 (\11\:VDD \13\:VDD) resistor r=0.1912 c=0
Rk25 (\14\:VDD VDD) resistor r=0.04991 c=0
Rk24 (\11\:VDD \14\:VDD) resistor r=0.08258 c=0
Rk5 (net95 \17\:net95) resistor r=0.3732 c=0
Rk6 (\17\:net95 \18\:net95) resistor r=0.3431 c=0
Rk7 (\18\:net95 \20\:net95) resistor r=0.3361 c=0
Rk9 (\17\:net95 \23\:net95) resistor r=0.5116 c=0
Rk10 (\18\:net95 \25\:net95) resistor r=0.08444 c=0
Rl4 (\1\:B \2\:B) resistor r=107.432 c=0
Rl5 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl3 (\2\:C \4\:C) resistor r=108.144 c=0
Rl1 (\1\:C \2\:C) resistor r=50.452 c=0
Rl2 (\2\:C \3\:C) resistor r=17.6672 c=0
Rl6 (\1\:A \2\:A) resistor r=28.079 c=0
Rl7 (\2\:A \3\:A) resistor r=104.568 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=15 c=0
Rz5 (\10\:VDD \3\:VDD) resistor r=37.5 c=0
Rz6 (\14\:VDD \3\:VDD) resistor r=37.5 c=0
Rz1 (\23\:net95 \22\:net95) resistor r=75 c=0
Ry8 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\20\:net95 \19\:net95) resistor r=31 c=0
Ry2 (\25\:net95 \24\:net95) resistor r=31 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
mn2 (\22\:net95 \1\:C net111 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.415e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (net111 \3\:B net107 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.31e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn0 (net107 \3\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.045e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\2\:Y net95 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.582e-14 ad=4.355e-14 ps=8.725e-07 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=8.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp1 (\24\:net95 \1\:B \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.02e-14 ps=1.1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.255e-06 sd=160n sca=14.1782 \
        scb=0.0124204 scc=0.000272457 m=(1)
mp0 (\24\:net95 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=7.02e-14 ps=1.24e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.03e-06 sd=160n sca=12.3454 \
        scb=0.0101149 scc=0.000258484 m=(1)
mp3 (\6\:Y net95 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.727e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=7.55e-07 sd=160n sca=11.834 \
        scb=0.00982597 scc=0.000258275 m=(4)
ends AND3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 13:08:33 2012 )
// Library name: gsclib045
// Cell name: AND3X6
// View name: extracted

simulator lang=spectre

subckt AND3X6 A B C VDD VSS Y
mp0 (\20\:net95 \2\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.25e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.7336 scb=0.0242625 \
        scc=0.00139021 m=(2)
C1 (B VSS) capacitor c=3.06143e-17
C2 (Y VSS) capacitor c=1.87732e-17
C3 (C VSS) capacitor c=6.78343e-17
C4 (VDD VSS) capacitor c=9.32358e-17
C5 (A VSS) capacitor c=1.31881e-17
C6 (8 VSS) capacitor c=3.08927e-18
C7 (9 VSS) capacitor c=6.293e-18
C8 (net95 VSS) capacitor c=3.65198e-16
C9 (10 VSS) capacitor c=4.80329e-18
C10 (11 VSS) capacitor c=5.23142e-18
C11 (\1\:B VSS) capacitor c=3.84246e-16
C12 (\6\:A VSS) capacitor c=5.00827e-17
C13 (\6\:B VSS) capacitor c=5.54611e-17
C14 (\1\:C VSS) capacitor c=4.60939e-17
C15 (\4\:C VSS) capacitor c=2.93856e-17
C16 (\3\:B VSS) capacitor c=4.7469e-17
C17 (\1\:A VSS) capacitor c=3.73494e-17
C18 (\3\:C VSS) capacitor c=8.99033e-17
C19 (\2\:A VSS) capacitor c=4.66977e-16
C20 (\1\:Y VSS) capacitor c=2.65863e-16
C21 (\1\:VDD VSS) capacitor c=3.15715e-16
C22 (\20\:net95 VSS) capacitor c=2.45859e-16
C23 (\28\:net95 VSS) capacitor c=3.50324e-17
C24 (\25\:net95 VSS) capacitor c=1.04772e-16
C25 (\2\:C VSS) capacitor c=3.26221e-17
C26 (\7\:C VSS) capacitor c=7.59676e-17
C27 (\19\:net95 VSS) capacitor c=1.15636e-16
C28 (\4\:Y VSS) capacitor c=2.02034e-16
C29 (\13\:VDD VSS) capacitor c=8.49564e-17
Rk2 (B \1\:B) resistor r=0.08417 c=0
Rk15 (\1\:Y Y) resistor r=0.03946 c=0
Rk16 (Y \4\:Y) resistor r=0.1341 c=0
Rk1 (C \7\:C) resistor r=0.03078 c=0
Rk30 (\1\:VDD \12\:VDD) resistor r=0.1124 c=0
Rk36 (\13\:VDD \1\:VDD) resistor r=0.1024 c=0
Rk31 (\12\:VDD \13\:VDD) resistor r=0.09262 c=0
Rk5 (\2\:A A) resistor r=0.01856 c=0
Rk45 (\1\:VSS \8\:VSS) resistor r=0.2974 c=0
Rk47 (\9\:VSS VSS) resistor r=0.06729 c=0
Rk46 (\8\:VSS \9\:VSS) resistor r=0.2833 c=0
Rk51 (\9\:VSS \16\:VSS) resistor r=0.2202 c=0
Rk7 (net95 \19\:net95) resistor r=0.173 c=0
Rk8 (\19\:net95 \20\:net95) resistor r=0.3562 c=0
Rk11 (\19\:net95 \26\:net95) resistor r=0.7529 c=0
Rk13 (\20\:net95 \29\:net95) resistor r=0.06656 c=0
Rl11 (\1\:B \6\:B) resistor r=44.9225 c=0
Rl4 (\1\:B \3\:B) resistor r=33.3841 c=0
Rl5 (\2\:C \1\:C) resistor r=126.408 c=0
Rl7 (\2\:C \4\:C) resistor r=76.9865 c=0
Rl6 (\2\:C \3\:C) resistor r=6.3032 c=0
Rl13 (\2\:A \6\:A) resistor r=30.5643 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rz10 (VDD \1\:VDD) resistor r=0.04719 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\26\:net95 \25\:net95) resistor r=75 c=0
Ry17 (VSS \3\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry16 (\8\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry4 (\29\:net95 \28\:net95) resistor r=31 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0 (8 \1\:A \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.85615e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (8 \3\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.33e-14 \
        ad=2.34e-14 ps=9.3e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.82269e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (\25\:net95 \4\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.57269e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\25\:net95 \1\:C 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.36769e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (10 \6\:B 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.6e-14 ad=2.99e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.20769e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_1__rcx (11 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.12e-14 ad=2.6e-14 ps=1.59e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.06269e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3 (\4\:Y net95 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.792e-14 ad=4.836e-14 ps=1.07e-06 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.51613e-07 sb=9.6e-07 sd=160n sca=15.4364 \
        scb=0.0149022 scc=0.00127268 m=(5)
mp1 (\20\:net95 \1\:B \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.985e-06 sd=160n sca=18.0437 \
        scb=0.0162495 scc=0.00111028 m=(2)
mp2 (\28\:net95 \3\:C \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.78e-06 sd=160n sca=16.5772 \
        scb=0.0145683 scc=0.00110293 m=(2)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15383e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends AND3X6
// End of subcircuit definition.

// Generated for: spectre (May  9 13:09:11 2012 )
// Library name: gsclib045
// Cell name: AND3X8
// View name: extracted

simulator lang=spectre

subckt AND3X8 A B C VDD VSS Y
mp0 (\26\:net95 A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.125e-14 ad=6.24e-14 ps=1.135e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=21.5202 scb=0.022579 \
        scc=0.00122627 m=(2)
C1 (B VSS) capacitor c=2.57096e-17
C2 (Y VSS) capacitor c=1.38287e-17
C3 (C VSS) capacitor c=4.14522e-17
C4 (VDD VSS) capacitor c=1.08178e-16
C5 (A VSS) capacitor c=4.53785e-16
C6 (8 VSS) capacitor c=1.65755e-18
C7 (9 VSS) capacitor c=3.18662e-18
C8 (net95 VSS) capacitor c=4.78684e-16
C9 (10 VSS) capacitor c=4.80329e-18
C10 (11 VSS) capacitor c=4.63574e-18
C11 (\6\:A VSS) capacitor c=5.07269e-17
C12 (\6\:B VSS) capacitor c=5.80442e-17
C13 (\1\:C VSS) capacitor c=4.63633e-17
C14 (\4\:C VSS) capacitor c=4.10628e-17
C15 (\1\:B VSS) capacitor c=6.65424e-17
C16 (\1\:A VSS) capacitor c=7.06745e-17
C17 (\3\:C VSS) capacitor c=8.80619e-17
C18 (\2\:B VSS) capacitor c=3.65192e-16
C19 (\1\:Y VSS) capacitor c=3.78585e-16
C20 (\1\:VDD VSS) capacitor c=4.43417e-16
C21 (\26\:net95 VSS) capacitor c=2.34792e-16
C22 (\34\:net95 VSS) capacitor c=3.55002e-17
C23 (\4\:VDD VSS) capacitor c=4.36439e-17
C24 (\28\:net95 VSS) capacitor c=1.04467e-16
C25 (\2\:C VSS) capacitor c=3.87345e-17
C26 (\7\:C VSS) capacitor c=4.54116e-17
C27 (\25\:net95 VSS) capacitor c=1.08464e-16
C28 (\4\:Y VSS) capacitor c=1.9413e-16
Rk2 (B \2\:B) resistor r=0.08401 c=0
Rk16 (\1\:Y Y) resistor r=0.1808 c=0
Rk17 (Y \4\:Y) resistor r=0.01238 c=0
Rk1 (C \7\:C) resistor r=0.03357 c=0
Rk36 (\1\:VDD VDD) resistor r=0.05722 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.1126 c=0
Rk49 (\3\:VSS \8\:VSS) resistor r=0.5202 c=0
Rk51 (\9\:VSS VSS) resistor r=0.0499 c=0
Rk50 (\8\:VSS \9\:VSS) resistor r=0.08756 c=0
Rk56 (\8\:VSS \19\:VSS) resistor r=0.2193 c=0
Rk8 (net95 \25\:net95) resistor r=0.2269 c=0
Rk9 (\25\:net95 \26\:net95) resistor r=0.3525 c=0
Rk10 (\25\:net95 \29\:net95) resistor r=0.7173 c=0
Rk14 (\26\:net95 \35\:net95) resistor r=0.05786 c=0
Rl11 (\2\:B \6\:B) resistor r=44.9225 c=0
Rl3 (\2\:B \1\:B) resistor r=33.3841 c=0
Rl5 (\2\:C \1\:C) resistor r=128.331 c=0
Rl7 (\2\:C \4\:C) resistor r=78.9095 c=0
Rl6 (\2\:C \3\:C) resistor r=5.5053 c=0
Rl13 (A \6\:A) resistor r=29.2744 c=0
Rl1 (A \1\:A) resistor r=98.0541 c=0
Rz9 (VDD \4\:VDD) resistor r=75 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=5.3571 c=0
Rz14 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (\29\:net95 \28\:net95) resistor r=75 c=0
Ry16 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry17 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\9\:VSS \1\:VSS) resistor r=31 c=0
Ry4 (\35\:net95 \34\:net95) resistor r=31 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0 (8 \1\:A \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.75654e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (8 \1\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.73231e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (\28\:net95 \4\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.69538e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_1__rcx (11 \6\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=2.34e-14 ps=1.62e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.30692e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (\28\:net95 \1\:C 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.60192e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (10 \6\:B 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=2.99e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.44192e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn3 (\4\:Y net95 \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.379e-14 ad=4.636e-14 ps=1.01143e-06 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.32203e-07 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mp1 (\26\:net95 \2\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.4295 scb=0.0156155 \
        scc=0.00102793 m=(2)
mp2 (\34\:net95 \3\:C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=16.0917 scb=0.0141872 \
        scc=0.00102282 m=(2)
mp3 (\1\:Y net95 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21303e-06 sb=1.37e-06 sd=160n sca=20.7359 \
        scb=0.0165012 scc=0.00199728 m=(7)
ends AND3X8
// End of subcircuit definition.

// Generated for: spectre (May  9 13:09:49 2012 )
// Library name: gsclib045
// Cell name: AND3XL
// View name: extracted

simulator lang=spectre

subckt AND3XL A B C VDD VSS Y
mp2 (\7\:net87 \4\:C \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.75e-07 sd=160n sca=19.7407 \
        scb=0.0215266 scc=0.00071564 m=(1)
C1 (Y VSS) capacitor c=6.92203e-17
C2 (B VSS) capacitor c=4.3414e-17
C3 (C VSS) capacitor c=7.1219e-17
C4 (A VSS) capacitor c=4.06754e-17
C5 (VDD VSS) capacitor c=1.30905e-16
C6 (net107 VSS) capacitor c=1.81222e-18
C7 (net87 VSS) capacitor c=5.43966e-17
C8 (net103 VSS) capacitor c=6.25767e-18
C9 (\1\:A VSS) capacitor c=3.94242e-17
C10 (\1\:B VSS) capacitor c=5.11164e-17
C11 (\4\:C VSS) capacitor c=5.47496e-17
C12 (\3\:net87 VSS) capacitor c=2.63047e-17
C13 (\3\:A VSS) capacitor c=5.07261e-17
C14 (\3\:B VSS) capacitor c=5.92645e-17
C15 (\1\:C VSS) capacitor c=4.37681e-17
C16 (\2\:net87 VSS) capacitor c=4.60767e-17
C17 (\2\:A VSS) capacitor c=4.89836e-17
C18 (\2\:B VSS) capacitor c=5.84505e-17
C19 (\3\:C VSS) capacitor c=1.524e-17
C20 (\3\:Y VSS) capacitor c=6.49097e-17
C21 (\5\:VDD VSS) capacitor c=2.44604e-17
C22 (\4\:net87 VSS) capacitor c=2.15684e-17
C23 (\7\:VDD VSS) capacitor c=2.47297e-17
C24 (\7\:net87 VSS) capacitor c=4.76435e-17
C25 (\1\:VDD VSS) capacitor c=3.72797e-17
C26 (\10\:net87 VSS) capacitor c=3.3068e-17
C27 (\2\:C VSS) capacitor c=5.40877e-17
C28 (\4\:B VSS) capacitor c=6.52785e-17
C29 (\4\:A VSS) capacitor c=6.92858e-17
C30 (\6\:net87 VSS) capacitor c=6.10948e-17
C31 (\9\:net87 VSS) capacitor c=1.08712e-16
C32 (\12\:net87 VSS) capacitor c=5.02561e-17
C33 (\3\:VDD VSS) capacitor c=7.96798e-18
Rk9 (\2\:Y Y) resistor r=0.006001 c=0
Rk10 (Y \4\:Y) resistor r=0.5101 c=0
Rk2 (\4\:B B) resistor r=0.04707 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.08756 c=0
Rk18 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk17 (\3\:VSS \4\:VSS) resistor r=0.2129 c=0
Rk19 (\3\:VSS \6\:VSS) resistor r=0.274 c=0
Rk1 (\5\:C C) resistor r=0.003 c=0
Rk3 (\4\:A A) resistor r=0.09325 c=0
Rk11 (\2\:VDD \3\:VDD) resistor r=0.08756 c=0
Rk15 (\4\:VDD VDD) resistor r=0.1508 c=0
Rk12 (\3\:VDD \4\:VDD) resistor r=0.2129 c=0
Rk13 (\3\:VDD \6\:VDD) resistor r=0.1739 c=0
Rk14 (\4\:VDD \8\:VDD) resistor r=0.2202 c=0
Rk4 (\5\:net87 \6\:net87) resistor r=0.07419 c=0
Rk5 (\6\:net87 \8\:net87) resistor r=0.3205 c=0
Rk6 (\6\:net87 \9\:net87) resistor r=0.4655 c=0
Rk7 (\9\:net87 \11\:net87) resistor r=0.3828 c=0
Rk8 (\9\:net87 \12\:net87) resistor r=0.2172 c=0
Rl4 (\1\:B \2\:B) resistor r=148.077 c=0
Rl5 (\2\:B \3\:B) resistor r=112.637 c=0
Rl3 (\2\:C \4\:C) resistor r=214.846 c=0
Rl1 (\1\:C \2\:C) resistor r=47.5865 c=0
Rl2 (\2\:C \3\:C) resistor r=15.5599 c=0
Rl6 (\1\:A \2\:A) resistor r=89.1533 c=0
Rl7 (\2\:A \3\:A) resistor r=169.923 c=0
Rl8 (net87 \2\:net87) resistor r=219.923 c=0
Rl9 (\2\:net87 \3\:net87) resistor r=36.5184 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz1 (\10\:net87 \11\:net87) resistor r=75 c=0
Ry3 (\3\:Y \4\:Y) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (\4\:net87 \5\:net87) resistor r=62 c=0
Ry2 (\7\:net87 \8\:net87) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\2\:net87 \12\:net87) resistor r=45 c=0
mn2 (\10\:net87 \1\:C net107 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (net107 \3\:B net103 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (net103 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (\1\:Y \3\:net87 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mp1 (\4\:net87 \1\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.7e-07 sd=160n sca=13.7568 \
        scb=0.0109184 scc=0.000115551 m=(1)
mp0 (\4\:net87 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.73e-14 ps=8.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.05e-07 sd=160n sca=13.5637 \
        scb=0.0105289 scc=0.000110426 m=(1)
mp3 (\3\:Y net87 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.655e-14 ps=8.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.7e-07 sd=160n sca=20.4171 \
        scb=0.0224816 scc=0.000827904 m=(1)
ends AND3XL
// End of subcircuit definition.

// Generated for: spectre (May  8 14:59:05 2012 )
// Library name: gsclib045
// Cell name: AND4X1
// View name: extracted

simulator lang=spectre

subckt AND4X1 A B C D VDD VSS Y
mp3 (\10\:net116 \3\:D \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
C1 (B VSS) capacitor c=7.04196e-17
C2 (Y VSS) capacitor c=2.12728e-17
C3 (C VSS) capacitor c=4.30078e-17
C4 (VDD VSS) capacitor c=1.03867e-16
C5 (D VSS) capacitor c=2.1236e-17
C6 (A VSS) capacitor c=4.72002e-17
C7 (net132 VSS) capacitor c=3.16837e-18
C8 (net116 VSS) capacitor c=6.05617e-17
C9 (net128 VSS) capacitor c=6.54738e-18
C10 (net124 VSS) capacitor c=2.75199e-18
C11 (\1\:A VSS) capacitor c=5.75914e-17
C12 (\1\:B VSS) capacitor c=5.80786e-17
C13 (\1\:C VSS) capacitor c=5.91714e-17
C14 (\3\:D VSS) capacitor c=4.79567e-17
C15 (\4\:net116 VSS) capacitor c=3.62406e-17
C16 (\3\:A VSS) capacitor c=4.30628e-17
C17 (\4\:B VSS) capacitor c=3.5428e-17
C18 (\3\:C VSS) capacitor c=3.38115e-17
C19 (\1\:D VSS) capacitor c=3.09635e-17
C20 (\3\:net116 VSS) capacitor c=3.88505e-17
C21 (\2\:A VSS) capacitor c=5.91688e-17
C22 (\3\:B VSS) capacitor c=2.57789e-17
C23 (\2\:C VSS) capacitor c=6.11922e-17
C24 (\2\:D VSS) capacitor c=6.12554e-17
C25 (\1\:Y VSS) capacitor c=5.08163e-17
C26 (\9\:VDD VSS) capacitor c=4.09373e-17
C27 (\12\:net116 VSS) capacitor c=2.1275e-17
C28 (\11\:VDD VSS) capacitor c=2.27814e-17
C29 (\10\:net116 VSS) capacitor c=4.13664e-17
C30 (\7\:VDD VSS) capacitor c=1.99252e-17
C31 (\1\:VDD VSS) capacitor c=4.51337e-17
C32 (\3\:Y VSS) capacitor c=7.61779e-17
C33 (\7\:net116 VSS) capacitor c=5.93061e-17
C34 (\2\:B VSS) capacitor c=3.85602e-17
C35 (\4\:D VSS) capacitor c=4.18785e-17
C36 (\4\:C VSS) capacitor c=4.50811e-17
C37 (\5\:B VSS) capacitor c=8.62971e-17
C38 (\4\:A VSS) capacitor c=4.33136e-17
C39 (\5\:net116 VSS) capacitor c=7.97748e-17
C40 (\6\:net116 VSS) capacitor c=1.32441e-16
C41 (\9\:net116 VSS) capacitor c=8.23155e-17
C42 (\5\:VDD VSS) capacitor c=2.19644e-18
Rk3 (\5\:B B) resistor r=0.245 c=0
Rk10 (Y \2\:Y) resistor r=0.03962 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5007 c=0
Rk2 (\4\:C C) resistor r=0.1264 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.09004 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1301 c=0
Rk16 (\6\:VDD VDD) resistor r=0.1003 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.1201 c=0
Rk17 (VDD \8\:VDD) resistor r=0.2719 c=0
Rk18 (\3\:VDD \10\:VDD) resistor r=0.2732 c=0
Rk19 (\5\:VDD \12\:VDD) resistor r=0.1568 c=0
Rk1 (\4\:D D) resistor r=0.02417 c=0
Rk4 (\4\:A A) resistor r=0.07765 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.1101 c=0
Rk22 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.2404 c=0
Rk23 (\3\:VSS \6\:VSS) resistor r=0.2044 c=0
Rk5 (\5\:net116 \6\:net116) resistor r=0.3071 c=0
Rk6 (\6\:net116 \8\:net116) resistor r=0.4241 c=0
Rk7 (\6\:net116 \9\:net116) resistor r=0.5043 c=0
Rk8 (\9\:net116 \11\:net116) resistor r=0.2721 c=0
Rk9 (\9\:net116 \13\:net116) resistor r=0.06936 c=0
Rl5 (\1\:B \2\:B) resistor r=174.714 c=0
Rl7 (\2\:B \4\:B) resistor r=47.791 c=0
Rl6 (\2\:B \3\:B) resistor r=9.8995 c=0
Rl3 (\1\:C \2\:C) resistor r=168 c=0
Rl4 (\2\:C \3\:C) resistor r=37.2302 c=0
Rl2 (\2\:D \3\:D) resistor r=162.637 c=0
Rl1 (\1\:D \2\:D) resistor r=44.7751 c=0
Rl8 (\1\:A \2\:A) resistor r=150 c=0
Rl9 (\2\:A \3\:A) resistor r=56.8681 c=0
Rl10 (net116 \2\:net116) resistor r=120.868 c=0
Rl12 (\2\:net116 \4\:net116) resistor r=34.3295 c=0
Rl11 (\2\:net116 \3\:net116) resistor r=0.5166 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\7\:net116 \8\:net116) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry1 (\10\:net116 \11\:net116) resistor r=62 c=0
Ry2 (\12\:net116 \13\:net116) resistor r=62 c=0
Rx3 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\3\:net116 \5\:net116) resistor r=45 c=0
mn3 (\7\:net116 \1\:D net132 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net132 \3\:C net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=8.15e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn1 (net128 \4\:B net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=3.19e-14 ps=5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=5.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn0 (net124 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.727e-14 ad=1.522e-14 ps=9.5e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=4e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn4 (\3\:Y \4\:net116 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.728e-14 ad=3.64e-14 ps=9.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05673e-07 sb=1.4e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mp2 (\10\:net116 \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.15e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp1 (\12\:net116 \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.5e-07 sd=160n sca=12.5692 \
        scb=0.0096429 scc=0.000174148 m=(1)
mp0 (\12\:net116 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=3.45e-07 sd=160n sca=13.1799 \
        scb=0.0106657 scc=0.000178932 m=(1)
mp4 (\1\:Y net116 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.07179e-07 sb=1.4e-07 sd=160n sca=24.4649 \
        scb=0.024645 scc=0.00179971 m=(1)
ends AND4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 13:11:03 2012 )
// Library name: gsclib045
// Cell name: AND4X2
// View name: extracted

simulator lang=spectre

subckt AND4X2 A B C D VDD VSS Y
mp3 (\13\:net100 \3\:D \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=3.548e-14 ps=1.36e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.355e-06 sd=160n sca=19.3616 \
        scb=0.0212916 scc=0.000644055 m=(1)
C1 (B VSS) capacitor c=1.33287e-16
C2 (Y VSS) capacitor c=1.54623e-17
C3 (C VSS) capacitor c=5.88464e-17
C4 (VDD VSS) capacitor c=9.96755e-17
C5 (D VSS) capacitor c=3.51394e-17
C6 (A VSS) capacitor c=4.55971e-17
C7 (net132 VSS) capacitor c=2.90597e-18
C8 (net100 VSS) capacitor c=1.58105e-16
C9 (net124 VSS) capacitor c=5.97886e-18
C10 (net120 VSS) capacitor c=9.55244e-18
C11 (\1\:A VSS) capacitor c=4.12742e-17
C12 (\1\:B VSS) capacitor c=5.46728e-17
C13 (\1\:C VSS) capacitor c=6.27884e-17
C14 (\3\:D VSS) capacitor c=4.28039e-17
C15 (\3\:A VSS) capacitor c=4.07353e-17
