        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\9\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\15\:GatedVSS \2\:ison \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.081e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\1\:Y \3\:Ybint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
PM0 (\12\:Ybint \4\:Yint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM5 (\16\:ison \1\:ISO \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.91404 \
        scb=0.00557767 scc=4.88511e-05 m=(1)
PM1 (\11\:Yint Ybint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM3 (\19\:Ybint ison \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.42101 \
        scb=0.00673238 scc=0.000108878 m=(1)
mp0 (\3\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.1596 \
        scb=0.0161183 scc=0.000480878 m=(1)
ends LSLH_ISOL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 21:53:23 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONH_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ISOn VSS) capacitor c=1.948e-17
C2 (ExtVDD VSS) capacitor c=2.61434e-16
C3 (VDD VSS) capacitor c=1.18746e-16
C4 (A VSS) capacitor c=3.3149e-17
C5 (Y VSS) capacitor c=4.68504e-17
C6 (Yint VSS) capacitor c=3.5255e-17
C7 (Ab VSS) capacitor c=1.65406e-16
C8 (Ybint VSS) capacitor c=3.08413e-17
C9 (GatedVSS VSS) capacitor c=3.4232e-17
C10 (\6\:Ybint VSS) capacitor c=4.08762e-17
C11 (\7\:ISOn VSS) capacitor c=2.94738e-17
C12 (\4\:Yint VSS) capacitor c=2.73734e-17
C13 (\9\:A VSS) capacitor c=3.93394e-17
C14 (\3\:Ybint VSS) capacitor c=2.96253e-17
C15 (\1\:A VSS) capacitor c=2.32018e-16
C16 (\10\:A VSS) capacitor c=2.8859e-17
C17 (\1\:ISOn VSS) capacitor c=1.92199e-17
C18 (\5\:Ybint VSS) capacitor c=1.09108e-17
C19 (\1\:Y VSS) capacitor c=4.27034e-17
C20 (\2\:Y VSS) capacitor c=4.39893e-17
C21 (\1\:ExtVDD VSS) capacitor c=2.43515e-17
C22 (\2\:ExtVDD VSS) capacitor c=3.20879e-17
C23 (\2\:Ybint VSS) capacitor c=2.18082e-17
C24 (\3\:Yint VSS) capacitor c=2.30619e-17
C25 (\2\:GatedVSS VSS) capacitor c=3.18112e-17
C26 (\4\:Ab VSS) capacitor c=7.76865e-17
C27 (\6\:A VSS) capacitor c=1.67241e-17
C28 (\6\:Y VSS) capacitor c=6.98497e-17
C29 (\6\:ExtVDD VSS) capacitor c=6.96862e-17
C30 (\4\:Y VSS) capacitor c=5.58185e-17
C31 (\4\:ExtVDD VSS) capacitor c=5.32054e-17
C32 (\10\:ExtVDD VSS) capacitor c=1.21411e-16
C33 (\11\:Yint VSS) capacitor c=6.27864e-17
C34 (\12\:Ybint VSS) capacitor c=9.05028e-17
C35 (\12\:ExtVDD VSS) capacitor c=1.32742e-16
C36 (\9\:Ab VSS) capacitor c=6.07479e-17
C37 (\3\:VDD VSS) capacitor c=3.70827e-17
C38 (\9\:Y VSS) capacitor c=7.15127e-17
C39 (\9\:GatedVSS VSS) capacitor c=9.94326e-17
C40 (\3\:GatedVSS VSS) capacitor c=2.59099e-16
C41 (\7\:Ybint VSS) capacitor c=2.167e-16
C42 (\5\:Yint VSS) capacitor c=1.9738e-16
C43 (\11\:Ab VSS) capacitor c=3.98405e-17
C44 (\15\:GatedVSS VSS) capacitor c=9.83233e-17
C45 (VDD VSS) capacitor c=3.76108e-16
C46 (\2\:Yint VSS) capacitor c=1.86518e-17
C47 (\4\:A VSS) capacitor c=1.29512e-16
C48 (\5\:A VSS) capacitor c=2.14757e-17
C49 (ExtVDD VSS) capacitor c=7.37762e-17
C50 (\4\:Ybint VSS) capacitor c=1.71421e-17
C51 (\2\:ISOn VSS) capacitor c=1.91979e-17
C52 (\3\:ISOn VSS) capacitor c=1.21393e-16
C53 (\12\:A VSS) capacitor c=2.46915e-17
C54 (\7\:Ab VSS) capacitor c=1.00258e-17
C55 (\8\:Ab VSS) capacitor c=6.13579e-17
C56 (\8\:Yint VSS) capacitor c=3.9648e-17
C57 (\13\:Yint VSS) capacitor c=5.45674e-17
C58 (\3\:ExtVDD VSS) capacitor c=3.73552e-17
C59 (\6\:GatedVSS VSS) capacitor c=9.65195e-17
C60 (\3\:Y VSS) capacitor c=3.34535e-17
C61 (\11\:GatedVSS VSS) capacitor c=4.33508e-16
C62 (\14\:GatedVSS VSS) capacitor c=1.65347e-16
C63 (\23\:GatedVSS VSS) capacitor c=7.77529e-17
C64 (\8\:ExtVDD VSS) capacitor c=1.79618e-17
C65 (\9\:ExtVDD VSS) capacitor c=9.27324e-18
C66 (\11\:Ybint VSS) capacitor c=9.88481e-17
C67 (\14\:Ybint VSS) capacitor c=5.3638e-17
C68 (\11\:ISOn VSS) capacitor c=1.20249e-17
C69 (\8\:Y VSS) capacitor c=8.21412e-17
C70 (\2\:VDD VSS) capacitor c=1.47933e-17
Rk40 (ISOn \11\:ISOn) resistor r=0.03448 c=0
Rk33 (ExtVDD ExtVDD) resistor r=0.00571 c=0
Rk13 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2983 c=0
Rk31 (\8\:ExtVDD ExtVDD) resistor r=0.1916 c=0
Rk27 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.2771 c=0
Rk28 (\8\:ExtVDD \9\:ExtVDD) resistor r=0.1171 c=0
Rk29 (\8\:ExtVDD \11\:ExtVDD) resistor r=0.2598 c=0
Rk30 (\11\:ExtVDD \13\:ExtVDD) resistor r=0.9888 c=0
Rk57 (VDD VDD) resistor r=0.6001 c=0
Rk58 (VDD \2\:VDD) resistor r=0.2044 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.3304 c=0
Rk51 (VSS VSS) resistor r=0.1476 c=0
Rk50 (VSS VSS) resistor r=0.001 c=0
Rk49 (\3\:VSS VSS) resistor r=0.08072 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.2531 c=0
Rk53 (\8\:VSS VSS) resistor r=0.1077 c=0
Rk60 (\16\:VSS VSS) resistor r=0.59 c=0
Rk62 (\17\:VSS VSS) resistor r=0.1793 c=0
Rk61 (VSS \17\:VSS) resistor r=0.3937 c=0
Rk1 (A \11\:A) resistor r=0.01009 c=0
Rk3 (\12\:A A) resistor r=0.006056 c=0
Rk2 (\11\:A \12\:A) resistor r=0.003802 c=0
Rk17 (\3\:Y \5\:Y) resistor r=0.2947 c=0
Rk41 (Y \7\:Y) resistor r=0.04964 c=0
Rk42 (\7\:Y \8\:Y) resistor r=0.4706 c=0
Rk43 (Y \10\:Y) resistor r=0.4465 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2143 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2958 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04264 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4587 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1593 c=0
Rk36 (\7\:Ybint \11\:Ybint) resistor r=0.1762 c=0
Rk37 (\11\:Ybint \13\:Ybint) resistor r=0.632 c=0
Rk38 (\7\:Ybint \14\:Ybint) resistor r=0.2887 c=0
Rk15 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.4211 c=0
Rk18 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.5664 c=0
Rk21 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.4727 c=0
Rk22 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.6273 c=0
Rk26 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.7575 c=0
Rl30 (\2\:ISOn \7\:ISOn) resistor r=45.8958 c=0
Rl25 (\2\:ISOn \1\:ISOn) resistor r=100.588 c=0
Rl26 (\3\:ISOn \2\:ISOn) resistor r=49.6935 c=0
Rl20 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl18 (\4\:A \9\:A) resistor r=132.549 c=0
Rl13 (\4\:A \1\:A) resistor r=624.028 c=0
Rl19 (\5\:A \10\:A) resistor r=86.3858 c=0
Rl15 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl14 (\5\:A \4\:A) resistor r=27.3472 c=0
Rl21 (\1\:Y \2\:Y) resistor r=107.339 c=0
Rl7 (\2\:Yint Yint) resistor r=105.33 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=297.11 c=0
Rl10 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl24 (\4\:Ybint \6\:Ybint) resistor r=110.249 c=0
Rl22 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl23 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rz14 (\9\:Y \10\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz6 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz7 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Ry3 (\4\:ExtVDD \5\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=20.6667 c=0
Ry6 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry7 (\12\:ExtVDD \13\:ExtVDD) resistor r=62 c=0
Ry14 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry13 (\8\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry15 (\16\:VSS \15\:VSS) resistor r=7.75 c=0
Ry16 (\17\:VSS \15\:VSS) resistor r=5.1667 c=0
Ry4 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry9 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry8 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Rx12 (\11\:ISOn \1\:ISOn) resistor r=45 c=0
Rx5 (\2\:ExtVDD \3\:ExtVDD) resistor r=45 c=0
Rx9 (\1\:ExtVDD \9\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx7 (\2\:Y \3\:Y) resistor r=45 c=0
Rx13 (\1\:Y \8\:Y) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx10 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx11 (\14\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx8 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\7\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\3\:GatedVSS \3\:ISOn \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\9\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
PM0 (\12\:Ybint \4\:Yint \12\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM4 (\4\:Y \7\:ISOn \4\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=23.3418 \
        scb=0.0184105 scc=0.00243166 m=(1)
mp0 (\6\:Y \6\:Ybint \6\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.9449 \
        scb=0.0249757 scc=0.00165614 m=(1)
ends LSLH_ISONH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:16:18 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONH_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONH_X1_TO_ON A ExtVDD ISOn VDD VSS Y
PM2 (\7\:Ab \9\:A \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.4536 \
        scb=0.0294943 scc=0.001293 m=(1)
C1 (ISOn VSS) capacitor c=2.33042e-17
C2 (VDD VSS) capacitor c=3.63805e-16
C3 (Y VSS) capacitor c=2.95522e-17
C4 (A VSS) capacitor c=1.99638e-17
C5 (ExtVDD VSS) capacitor c=7.37963e-17
C6 (Yint VSS) capacitor c=3.6638e-17
C7 (Ab VSS) capacitor c=1.51785e-16
C8 (Ybint VSS) capacitor c=3.20161e-17
C9 (GatedVSS VSS) capacitor c=3.33903e-17
C10 (\6\:Ybint VSS) capacitor c=2.83141e-17
C11 (\1\:ISOn VSS) capacitor c=3.49278e-17
C12 (\4\:Yint VSS) capacitor c=2.96577e-17
C13 (\9\:A VSS) capacitor c=4.839e-17
C14 (\3\:Ybint VSS) capacitor c=2.54544e-17
C15 (\1\:A VSS) capacitor c=2.06455e-16
C16 (\10\:A VSS) capacitor c=2.43985e-17
C17 (\5\:Ybint VSS) capacitor c=7.50637e-18
C18 (\2\:Y VSS) capacitor c=3.19812e-17
C19 (\1\:Y VSS) capacitor c=3.12551e-17
C20 (\2\:ISOn VSS) capacitor c=2.22039e-17
C21 (\2\:Ybint VSS) capacitor c=2.38069e-17
C22 (\3\:Yint VSS) capacitor c=2.38248e-17
C23 (\2\:GatedVSS VSS) capacitor c=3.15366e-17
C24 (\4\:Ab VSS) capacitor c=6.12182e-17
C25 (\6\:A VSS) capacitor c=2.15167e-17
C26 (\6\:Y VSS) capacitor c=7.52764e-17
C27 (\1\:VDD VSS) capacitor c=9.0525e-17
C28 (\3\:Y VSS) capacitor c=5.42019e-17
C29 (\8\:VDD VSS) capacitor c=6.65668e-17
C30 (\3\:VDD VSS) capacitor c=5.16878e-17
C31 (\11\:Yint VSS) capacitor c=5.04569e-17
C32 (\11\:Ybint VSS) capacitor c=8.51311e-17
C33 (\10\:VDD VSS) capacitor c=5.23849e-17
C34 (\7\:Ab VSS) capacitor c=8.58252e-17
C35 (\4\:ExtVDD VSS) capacitor c=3.51946e-17
C36 (\9\:Y VSS) capacitor c=3.89279e-17
C37 (\9\:GatedVSS VSS) capacitor c=9.88195e-17
C38 (\3\:GatedVSS VSS) capacitor c=2.56126e-16
C39 (\5\:Yint VSS) capacitor c=1.88319e-16
C40 (\10\:Ab VSS) capacitor c=6.32966e-17
C41 (\15\:GatedVSS VSS) capacitor c=1.09061e-16
C42 (ExtVDD VSS) capacitor c=3.059e-17
C43 (VDD VSS) capacitor c=3.5451e-17
C44 (\2\:Yint VSS) capacitor c=2.44176e-17
C45 (\4\:A VSS) capacitor c=1.63455e-16
C46 (\5\:A VSS) capacitor c=2.18669e-17
C47 (\3\:ISOn VSS) capacitor c=1.2463e-16
C48 (\4\:Ybint VSS) capacitor c=8.78967e-18
C49 (\11\:A VSS) capacitor c=3.5142e-17
C50 (\3\:ExtVDD VSS) capacitor c=1.9335e-17
C51 (\9\:Ab VSS) capacitor c=1.05289e-16
C52 (\8\:Yint VSS) capacitor c=3.86538e-17
C53 (\13\:Yint VSS) capacitor c=3.22052e-17
C54 (\6\:GatedVSS VSS) capacitor c=8.02784e-17
C55 (\5\:Y VSS) capacitor c=4.62943e-17
C56 (\11\:GatedVSS VSS) capacitor c=4.0621e-16
C57 (\14\:GatedVSS VSS) capacitor c=1.87133e-16
C58 (\23\:GatedVSS VSS) capacitor c=1.03867e-16
C59 (\10\:ISOn VSS) capacitor c=2.66654e-17
C60 (\12\:ISOn VSS) capacitor c=1.15499e-17
C61 (\7\:Ybint VSS) capacitor c=5.5135e-17
C62 (\8\:Ybint VSS) capacitor c=1.79963e-16
C63 (\10\:Ybint VSS) capacitor c=6.19552e-17
C64 (\8\:Y VSS) capacitor c=6.6407e-17
C65 (\5\:VDD VSS) capacitor c=1.06084e-16
C66 (\7\:VDD VSS) capacitor c=3.43926e-17
Rk25 (\10\:ISOn \11\:ISOn) resistor r=0.003235 c=0
Rk26 (ISOn \12\:ISOn) resistor r=0.003235 c=0
Rk27 (\10\:ISOn \12\:ISOn) resistor r=0.0469 c=0
Rk28 (\13\:ISOn ISOn) resistor r=0.003235 c=0
Rk29 (\12\:ISOn \13\:ISOn) resistor r=0.009821 c=0
Rk55 (VDD VDD) resistor r=0.3021 c=0
Rk51 (\2\:VDD \4\:VDD) resistor r=0.5799 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.2406 c=0
Rk54 (\7\:VDD VDD) resistor r=0.2262 c=0
Rk53 (\5\:VDD \7\:VDD) resistor r=0.2183 c=0
Rk56 (\5\:VDD \9\:VDD) resistor r=0.561 c=0
Rk57 (VDD \11\:VDD) resistor r=0.2857 c=0
Rk46 (VSS VSS) resistor r=0.3143 c=0
Rk59 (VSS VSS) resistor r=0.275 c=0
Rk39 (\2\:VSS \3\:VSS) resistor r=0.1299 c=0
Rk45 (\8\:VSS VSS) resistor r=0.2453 c=0
Rk44 (\3\:VSS \8\:VSS) resistor r=0.05628 c=0
Rk47 (VSS \9\:VSS) resistor r=0.07882 c=0
Rk58 (\17\:VSS VSS) resistor r=0.589 c=0
Rk60 (VSS \18\:VSS) resistor r=0.1181 c=0
Rk15 (\4\:Y \5\:Y) resistor r=0.2695 c=0
Rk36 (Y \7\:Y) resistor r=0.211 c=0
Rk37 (\7\:Y \8\:Y) resistor r=0.5182 c=0
Rk38 (Y \10\:Y) resistor r=0.2216 c=0
Rk1 (\11\:A A) resistor r=0.02676 c=0
Rk4 (\3\:ExtVDD ExtVDD) resistor r=0.02412 c=0
Rk3 (ExtVDD \3\:ExtVDD) resistor r=0.03418 c=0
Rk5 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2887 c=0
Rk9 (\5\:Yint \8\:Yint) resistor r=0.201 c=0
Rk11 (\12\:Yint \13\:Yint) resistor r=0.2045 c=0
Rk6 (\8\:Ab \9\:Ab) resistor r=0.6827 c=0
Rk7 (\9\:Ab \11\:Ab) resistor r=0.4468 c=0
Rk30 (\7\:Ybint \8\:Ybint) resistor r=0.3012 c=0
Rk32 (\8\:Ybint \10\:Ybint) resistor r=0.1518 c=0
Rk33 (\10\:Ybint \12\:Ybint) resistor r=0.5775 c=0
Rk13 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.1963 c=0
Rk16 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.6479 c=0
Rk19 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.3558 c=0
Rk20 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.7651 c=0
Rk24 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.8113 c=0
Rl20 (\2\:ISOn \1\:ISOn) resistor r=67.8776 c=0
Rl21 (\3\:ISOn \2\:ISOn) resistor r=25.5508 c=0
Rl28 (\1\:Y \2\:Y) resistor r=105.578 c=0
Rl18 (\4\:A \9\:A) resistor r=239.672 c=0
Rl13 (\4\:A \1\:A) resistor r=494.483 c=0
Rl19 (\5\:A \10\:A) resistor r=59.022 c=0
Rl15 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl14 (\5\:A \4\:A) resistor r=192.732 c=0
Rl7 (\2\:Yint Yint) resistor r=148.662 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=178.013 c=0
Rl10 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl31 (\4\:Ybint \6\:Ybint) resistor r=53.5603 c=0
Rl29 (\4\:Ybint \3\:Ybint) resistor r=53.5603 c=0
Rl30 (\4\:Ybint \5\:Ybint) resistor r=2.0166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz14 (\9\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz7 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz8 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry13 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry14 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry15 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry10 (\8\:VSS \1\:VSS) resistor r=62 c=0
Ry11 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\17\:VSS \16\:VSS) resistor r=7.75 c=0
Ry17 (\18\:VSS \16\:VSS) resistor r=5.1667 c=0
Ry4 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry1 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry5 (\12\:Ybint \11\:Ybint) resistor r=62 c=0
Rx8 (\11\:ISOn \2\:ISOn) resistor r=45 c=0
Rx6 (\2\:Y \5\:Y) resistor r=45 c=0
Rx11 (\1\:Y \8\:Y) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx9 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx10 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
Rx5 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx7 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\8\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\3\:GatedVSS \3\:ISOn \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\9\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
PM0 (\11\:Ybint \4\:Yint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM1 (\11\:Yint Ybint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM4 (\3\:Y \1\:ISOn \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2869 \
        scb=0.0136758 scc=0.00109725 m=(1)
mp0 (\6\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.9112 \
        scb=0.0301573 scc=0.00234059 m=(1)
ends LSLH_ISONH_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:36:33 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONL_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ExtVDD VSS) capacitor c=2.72249e-16
C2 (ISOn VSS) capacitor c=2.01359e-17
C3 (Y VSS) capacitor c=4.93517e-17
C4 (A VSS) capacitor c=3.89629e-17
C5 (VDD VSS) capacitor c=1.19413e-16
C6 (Yint VSS) capacitor c=3.52641e-17
C7 (Ab VSS) capacitor c=1.65406e-16
C8 (Ybint VSS) capacitor c=3.09949e-17
C9 (GatedVSS VSS) capacitor c=3.4232e-17
C10 (\6\:Ybint VSS) capacitor c=4.46142e-17
C11 (\7\:ISOn VSS) capacitor c=2.4327e-17
C12 (\4\:Yint VSS) capacitor c=2.73734e-17
C13 (\9\:A VSS) capacitor c=3.93489e-17
C14 (\3\:Ybint VSS) capacitor c=2.89525e-17
C15 (\1\:ISOn VSS) capacitor c=1.26759e-16
C16 (\1\:A VSS) capacitor c=2.3019e-16
C17 (\10\:A VSS) capacitor c=2.84041e-17
C18 (\7\:Ybint VSS) capacitor c=3.50612e-17
C19 (\5\:Ybint VSS) capacitor c=1.0871e-17
C20 (\6\:ISOn VSS) capacitor c=2.10212e-17
C21 (\1\:ExtVDD VSS) capacitor c=1.33093e-17
C22 (\2\:ExtVDD VSS) capacitor c=1.72205e-17
C23 (\2\:Ybint VSS) capacitor c=2.21555e-17
C24 (\3\:Yint VSS) capacitor c=2.30619e-17
C25 (\2\:GatedVSS VSS) capacitor c=3.18112e-17
C26 (\4\:Ab VSS) capacitor c=7.73912e-17
C27 (\6\:A VSS) capacitor c=1.46443e-17
C28 (\1\:Y VSS) capacitor c=5.58689e-17
C29 (\6\:ExtVDD VSS) capacitor c=5.86837e-17
C30 (\19\:Ybint VSS) capacitor c=5.39341e-17
C31 (\4\:ExtVDD VSS) capacitor c=3.3987e-17
C32 (\9\:ExtVDD VSS) capacitor c=1.1654e-16
C33 (\11\:Yint VSS) capacitor c=6.28175e-17
C34 (\13\:Ybint VSS) capacitor c=9.04939e-17
C35 (\11\:ExtVDD VSS) capacitor c=1.32742e-16
C36 (\9\:Ab VSS) capacitor c=6.07479e-17
C37 (\3\:VDD VSS) capacitor c=3.7534e-17
C38 (\3\:Y VSS) capacitor c=7.13921e-17
C39 (\15\:GatedVSS VSS) capacitor c=2.76446e-16
C40 (\8\:Ybint VSS) capacitor c=2.08276e-16
C41 (\3\:GatedVSS VSS) capacitor c=3.89372e-16
C42 (\5\:Yint VSS) capacitor c=1.97378e-16
C43 (\11\:Ab VSS) capacitor c=3.98405e-17
C44 (\8\:GatedVSS VSS) capacitor c=9.9143e-17
C45 (VDD VSS) capacitor c=3.75931e-16
C46 (\2\:Yint VSS) capacitor c=1.86518e-17
C47 (\4\:A VSS) capacitor c=1.34986e-16
C48 (\5\:A VSS) capacitor c=2.0289e-17
C49 (ExtVDD VSS) capacitor c=7.48679e-17
C50 (\4\:Ybint VSS) capacitor c=1.91542e-17
C51 (\12\:A VSS) capacitor c=1.92402e-17
C52 (\7\:Ab VSS) capacitor c=1.00258e-17
C53 (\8\:Ab VSS) capacitor c=6.16615e-17
C54 (\8\:Yint VSS) capacitor c=3.96535e-17
C55 (\13\:Yint VSS) capacitor c=5.45674e-17
C56 (\7\:GatedVSS VSS) capacitor c=1.65325e-16
C57 (\14\:GatedVSS VSS) capacitor c=7.77839e-17
C58 (\3\:ExtVDD VSS) capacitor c=3.74223e-17
C59 (\18\:GatedVSS VSS) capacitor c=9.58871e-17
C60 (\10\:ISOn VSS) capacitor c=2.99614e-17
C61 (\12\:ISOn VSS) capacitor c=1.97083e-17
C62 (\8\:ExtVDD VSS) capacitor c=1.63715e-17
C63 (\13\:ExtVDD VSS) capacitor c=7.98939e-18
C64 (\12\:Ybint VSS) capacitor c=9.8845e-17
C65 (\15\:Ybint VSS) capacitor c=5.2598e-17
C66 (\18\:Ybint VSS) capacitor c=7.54285e-17
C67 (\2\:VDD VSS) capacitor c=1.52128e-17
Rk35 (ExtVDD ExtVDD) resistor r=0.005706 c=0
Rk20 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2586 c=0
Rk33 (\8\:ExtVDD ExtVDD) resistor r=0.1914 c=0
Rk29 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.3113 c=0
Rk30 (\8\:ExtVDD \10\:ExtVDD) resistor r=0.2596 c=0
Rk31 (\10\:ExtVDD \12\:ExtVDD) resistor r=0.9881 c=0
Rk32 (\8\:ExtVDD \13\:ExtVDD) resistor r=0.117 c=0
Rk58 (VSS VSS) resistor r=0.1474 c=0
Rk57 (VSS VSS) resistor r=0.001 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.2455 c=0
Rk47 (\4\:VSS VSS) resistor r=0.3438 c=0
Rk46 (\3\:VSS \4\:VSS) resistor r=0.1472 c=0
Rk49 (\5\:VSS VSS) resistor r=0.1791 c=0
Rk48 (VSS \5\:VSS) resistor r=0.3934 c=0
Rk50 (\3\:VSS \7\:VSS) resistor r=0.226 c=0
Rk56 (\10\:VSS VSS) resistor r=0.08065 c=0
Rk51 (\9\:VSS \10\:VSS) resistor r=0.2529 c=0
Rk59 (VSS \15\:VSS) resistor r=0.1076 c=0
Rk24 (\10\:ISOn \11\:ISOn) resistor r=0.003842 c=0
Rk25 (ISOn \12\:ISOn) resistor r=0.003842 c=0
Rk26 (\10\:ISOn \12\:ISOn) resistor r=0.03954 c=0
Rk27 (\13\:ISOn ISOn) resistor r=0.003842 c=0
Rk28 (\12\:ISOn \13\:ISOn) resistor r=0.02501 c=0
Rk43 (Y \2\:Y) resistor r=0.06961 c=0
Rk44 (Y \4\:Y) resistor r=0.4416 c=0
Rk1 (A \11\:A) resistor r=0.008637 c=0
Rk3 (\12\:A A) resistor r=0.005477 c=0
Rk2 (\11\:A \12\:A) resistor r=0.003026 c=0
Rk64 (VDD VDD) resistor r=0.5996 c=0
Rk65 (VDD \2\:VDD) resistor r=0.2042 c=0
Rk66 (\2\:VDD \4\:VDD) resistor r=0.3302 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2141 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2956 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.0426 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4575 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1592 c=0
Rk38 (\8\:Ybint \12\:Ybint) resistor r=0.176 c=0
Rk39 (\12\:Ybint \14\:Ybint) resistor r=0.6316 c=0
Rk40 (\8\:Ybint \15\:Ybint) resistor r=0.2885 c=0
Rk42 (\18\:Ybint \20\:Ybint) resistor r=0.4583 c=0
Rk15 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.4724 c=0
Rk16 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.6269 c=0
Rk19 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.757 c=0
Rk22 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.4202 c=0
Rl20 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl26 (\6\:ISOn \7\:ISOn) resistor r=44.2107 c=0
Rl25 (\1\:ISOn \6\:ISOn) resistor r=77.3687 c=0
Rl18 (\4\:A \9\:A) resistor r=126.472 c=0
Rl13 (\4\:A \1\:A) resistor r=624.028 c=0
Rl19 (\5\:A \10\:A) resistor r=82.9767 c=0
Rl15 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl14 (\5\:A \4\:A) resistor r=30.7563 c=0
Rl7 (\2\:Yint Yint) resistor r=105.33 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=297.11 c=0
Rl32 (\7\:Ybint \6\:Ybint) resistor r=141.321 c=0
Rl10 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl31 (\4\:Ybint \6\:Ybint) resistor r=132.409 c=0
Rl29 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl30 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rz14 (\7\:VSS \6\:VSS) resistor r=37.5 c=0
Rz13 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz5 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry3 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry4 (\6\:ExtVDD \7\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\9\:ExtVDD \10\:ExtVDD) resistor r=62 c=0
Ry6 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry11 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\9\:VSS \8\:VSS) resistor r=12.4 c=0
Ry14 (\10\:VSS \8\:VSS) resistor r=15.5 c=0
Ry16 (\15\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry9 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry17 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry7 (\14\:Ybint \13\:Ybint) resistor r=62 c=0
Ry8 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Rx6 (\2\:ExtVDD \3\:ExtVDD) resistor r=45 c=0
Rx9 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx8 (\11\:ISOn \6\:ISOn) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx10 (\12\:Ybint \2\:Ybint) resistor r=45 c=0
Rx11 (\15\:Ybint \5\:Ybint) resistor r=45 c=0
Rx12 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx5 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx7 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\8\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\15\:GatedVSS \1\:ISOn \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\3\:Y \3\:Ybint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\13\:Ybint \4\:Yint \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM3 (\19\:Ybint \7\:ISOn \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.0047 \
        scb=0.0122487 scc=0.000500332 m=(1)
mp0 (\1\:Y \6\:Ybint \6\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.532 scb=0.0217466 \
        scc=0.00133989 m=(1)
ends LSLH_ISONL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:37:19 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISONL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISONL_X1_TO_ON A ExtVDD ISOn VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4762 \
        scb=0.0265201 scc=0.001017 m=(1)
C1 (ISOn VSS) capacitor c=3.29524e-17
C2 (ExtVDD VSS) capacitor c=1.08421e-16
C3 (Y VSS) capacitor c=2.58453e-17
C4 (A VSS) capacitor c=1.71904e-17
C5 (VDD VSS) capacitor c=3.92566e-16
C6 (Yint VSS) capacitor c=3.78068e-17
C7 (Ab VSS) capacitor c=1.51782e-16
C8 (Ybint VSS) capacitor c=2.67784e-17
C9 (GatedVSS VSS) capacitor c=3.34551e-17
C10 (\6\:Ybint VSS) capacitor c=3.24279e-17
C11 (\1\:ISOn VSS) capacitor c=3.04514e-17
C12 (\4\:Yint VSS) capacitor c=2.69335e-17
C13 (\9\:A VSS) capacitor c=4.79921e-17
C14 (\3\:Ybint VSS) capacitor c=3.90115e-17
C15 (\1\:A VSS) capacitor c=2.01838e-16
C16 (\10\:A VSS) capacitor c=2.4381e-17
C17 (\7\:Ybint VSS) capacitor c=3.95107e-17
C18 (\5\:Ybint VSS) capacitor c=7.45139e-18
C19 (\2\:ISOn VSS) capacitor c=2.52053e-17
C20 (\2\:Ybint VSS) capacitor c=2.62202e-17
C21 (\3\:Yint VSS) capacitor c=2.38248e-17
C22 (\2\:GatedVSS VSS) capacitor c=3.09364e-17
C23 (\4\:Ab VSS) capacitor c=6.1308e-17
C24 (\6\:A VSS) capacitor c=2.21142e-17
C25 (\2\:Y VSS) capacitor c=3.4033e-17
C26 (\1\:VDD VSS) capacitor c=5.55557e-17
C27 (\8\:Ybint VSS) capacitor c=3.86213e-17
C28 (\7\:VDD VSS) capacitor c=3.28732e-17
C29 (\9\:VDD VSS) capacitor c=3.56191e-17
C30 (\11\:Yint VSS) capacitor c=5.52764e-17
C31 (\15\:Ybint VSS) capacitor c=8.50244e-17
C32 (\11\:VDD VSS) capacitor c=5.21861e-17
C33 (\7\:Ab VSS) capacitor c=8.91235e-17
C34 (\3\:ExtVDD VSS) capacitor c=3.52759e-17
C35 (\4\:Y VSS) capacitor c=4.59043e-17
C36 (\15\:GatedVSS VSS) capacitor c=2.2705e-16
C37 (\3\:GatedVSS VSS) capacitor c=3.67812e-16
C38 (\5\:Yint VSS) capacitor c=1.88002e-16
C39 (\10\:Ab VSS) capacitor c=6.66614e-17
C40 (\8\:GatedVSS VSS) capacitor c=1.10818e-16
C41 (ExtVDD VSS) capacitor c=4.36338e-17
C42 (VDD VSS) capacitor c=4.14305e-17
C43 (\2\:Yint VSS) capacitor c=2.45022e-17
C44 (\4\:A VSS) capacitor c=1.63748e-16
C45 (\5\:A VSS) capacitor c=2.30476e-17
C46 (\3\:ISOn VSS) capacitor c=1.45038e-16
C47 (\4\:Ybint VSS) capacitor c=2.03968e-17
C48 (\12\:A VSS) capacitor c=4.36627e-18
C49 (\13\:A VSS) capacitor c=4.29675e-17
C50 (\9\:Ab VSS) capacitor c=1.06192e-16
C51 (\8\:Yint VSS) capacitor c=3.90312e-17
C52 (\13\:Yint VSS) capacitor c=3.2125e-17
C53 (\7\:GatedVSS VSS) capacitor c=1.87133e-16
C54 (\14\:GatedVSS VSS) capacitor c=1.03867e-16
C55 (\18\:GatedVSS VSS) capacitor c=7.32061e-17
C56 (\10\:Ybint VSS) capacitor c=4.76346e-17
C57 (\11\:Ybint VSS) capacitor c=3.9809e-17
C58 (\12\:Ybint VSS) capacitor c=1.8525e-16
C59 (\14\:Ybint VSS) capacitor c=5.99036e-17
C60 (\10\:ISOn VSS) capacitor c=2.25156e-17
C61 (\1\:Y VSS) capacitor c=5.55152e-17
C62 (\3\:VDD VSS) capacitor c=6.7534e-17
C63 (\4\:VDD VSS) capacitor c=1.69854e-17
C64 (\6\:VDD VSS) capacitor c=4.30207e-17
Rk31 (ISOn \10\:ISOn) resistor r=0.04068 c=0
Rk54 (VSS VSS) resistor r=0.3214 c=0
Rk37 (VSS VSS) resistor r=0.2821 c=0
Rk36 (\4\:VSS VSS) resistor r=0.5886 c=0
Rk35 (\2\:VSS \4\:VSS) resistor r=0.3532 c=0
Rk38 (VSS \5\:VSS) resistor r=0.1106 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.1372 c=0
Rk53 (\13\:VSS VSS) resistor r=0.2451 c=0
Rk52 (\8\:VSS \13\:VSS) resistor r=0.04887 c=0
Rk55 (VSS \14\:VSS) resistor r=0.07139 c=0
Rk5 (ExtVDD ExtVDD) resistor r=0.02314 c=0
Rk7 (ExtVDD \4\:ExtVDD) resistor r=0.321 c=0
Rk32 (Y \1\:Y) resistor r=0.002001 c=0
Rk33 (\1\:Y \3\:Y) resistor r=0.2712 c=0
Rk34 (\1\:Y \5\:Y) resistor r=0.4419 c=0
Rk1 (\11\:A A) resistor r=0.002027 c=0
Rk2 (A \12\:A) resistor r=0.002027 c=0
Rk3 (\11\:A \12\:A) resistor r=0.03576 c=0
Rk4 (\12\:A \13\:A) resistor r=0.02298 c=0
Rk43 (VDD VDD) resistor r=0.3093 c=0
Rk39 (\2\:VDD \3\:VDD) resistor r=0.3988 c=0
Rk40 (\3\:VDD \4\:VDD) resistor r=0.1591 c=0
Rk42 (\6\:VDD VDD) resistor r=0.2185 c=0
Rk41 (\4\:VDD \6\:VDD) resistor r=0.2182 c=0
Rk44 (\3\:VDD \8\:VDD) resistor r=0.2637 c=0
Rk45 (\4\:VDD \10\:VDD) resistor r=0.2404 c=0
Rk46 (VDD \12\:VDD) resistor r=0.2855 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2009 c=0
Rk13 (\12\:Yint \13\:Yint) resistor r=0.2043 c=0
Rk8 (\8\:Ab \9\:Ab) resistor r=0.6822 c=0
Rk9 (\9\:Ab \11\:Ab) resistor r=0.4465 c=0
Rk24 (\9\:Ybint \10\:Ybint) resistor r=0.1874 c=0
Rk25 (\11\:Ybint \12\:Ybint) resistor r=0.2117 c=0
Rk27 (\12\:Ybint \14\:Ybint) resistor r=0.06776 c=0
Rk28 (\14\:Ybint \16\:Ybint) resistor r=0.577 c=0
Rk16 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.3555 c=0
Rk17 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.7646 c=0
Rk20 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.8107 c=0
Rk22 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.1309 c=0
Rl20 (\2\:ISOn \1\:ISOn) resistor r=42.9995 c=0
Rl21 (\3\:ISOn \2\:ISOn) resistor r=106.578 c=0
Rl18 (\4\:A \9\:A) resistor r=239.672 c=0
Rl13 (\4\:A \1\:A) resistor r=494.483 c=0
Rl19 (\5\:A \10\:A) resistor r=59.022 c=0
Rl15 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl14 (\5\:A \4\:A) resistor r=192.732 c=0
Rl7 (\2\:Yint Yint) resistor r=148.662 c=0
Rl9 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl8 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl4 (Ab \4\:Ab) resistor r=178.013 c=0
Rl31 (\7\:Ybint \6\:Ybint) resistor r=138.8 c=0
Rl10 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl30 (\4\:Ybint \6\:Ybint) resistor r=53.7923 c=0
Rl28 (\4\:Ybint \3\:Ybint) resistor r=146.045 c=0
Rl29 (\4\:Ybint \5\:Ybint) resistor r=1.2666 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz14 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz13 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz6 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry7 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry8 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry13 (\7\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry15 (\8\:VSS \6\:VSS) resistor r=15.5 c=0
Ry16 (\13\:VSS \6\:VSS) resistor r=62 c=0
Ry17 (\14\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry6 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry10 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry11 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry12 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\9\:Ybint \8\:Ybint) resistor r=62 c=0
Ry5 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx10 (\10\:ISOn \2\:ISOn) resistor r=45 c=0
Rx1 (\13\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx7 (\10\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\11\:Ybint \5\:Ybint) resistor r=45 c=0
Rx9 (\14\:Ybint \2\:Ybint) resistor r=45 c=0
Rx5 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx6 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\12\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\15\:GatedVSS \3\:ISOn \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\4\:Y \3\:Ybint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.51051 scb=0.00656948 \
        scc=0.000151659 m=(1)
PM0 (\15\:Ybint \4\:Yint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM1 (\11\:Yint Ybint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM3 (\8\:Ybint \1\:ISOn \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.25814 \
        scb=0.0047964 scc=4.57111e-05 m=(1)
mp0 (\2\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2649 scb=0.011266 \
        scc=0.000235246 m=(1)
ends LSLH_ISONL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  9 15:23:48 2012 )
// Library name: gsclib045
// Cell name: MDFFHQX1
// View name: extracted

simulator lang=spectre

subckt MDFFHQX1 CK D0 D1 Q S0 VDD VSS
mp55 (\1\:Q \4\:qbint \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.98462e-07 sd=160n sca=19.586 \
        scb=0.0215989 scc=0.000684683 m=(1)
C1 (Q VSS) capacitor c=1.52714e-17
C2 (D0 VSS) capacitor c=4.35084e-17
C3 (CK VSS) capacitor c=1.13847e-16
C4 (S0 VSS) capacitor c=4.41301e-17
C5 (VDD VSS) capacitor c=2.85211e-16
C6 (D1 VSS) capacitor c=6.08059e-17
C7 (qbint VSS) capacitor c=1.77947e-17
C8 (CKb VSS) capacitor c=2.14623e-17
C9 (n30 VSS) capacitor c=3.13465e-17
C10 (n35 VSS) capacitor c=5.82309e-18
C11 (mout VSS) capacitor c=5.57271e-17
C12 (CKbb VSS) capacitor c=3.3655e-17
C13 (n20 VSS) capacitor c=3.67409e-17
C14 (n25 VSS) capacitor c=9.11373e-19
C15 (D0b VSS) capacitor c=8.98579e-17
C16 (n10 VSS) capacitor c=8.55872e-18
C17 (S0b VSS) capacitor c=3.81113e-17
C18 (n36 VSS) capacitor c=6.50403e-18
C19 (n26 VSS) capacitor c=5.33809e-18
C20 (n11 VSS) capacitor c=2.75167e-18
C21 (n13 VSS) capacitor c=6.08103e-18
C22 (\7\:S0 VSS) capacitor c=4.04378e-17
C23 (\3\:D1 VSS) capacitor c=4.8669e-17
C24 (\2\:S0 VSS) capacitor c=6.57718e-17
C25 (\1\:D0 VSS) capacitor c=8.96482e-17
C26 (\5\:CKb VSS) capacitor c=4.6278e-17
C27 (\7\:CKbb VSS) capacitor c=3.89853e-17
C28 (\8\:CKb VSS) capacitor c=4.13827e-17
C29 (\5\:qbint VSS) capacitor c=4.5929e-17
C30 (\3\:n30 VSS) capacitor c=3.9376e-17
C31 (\3\:CK VSS) capacitor c=4.49303e-17
C32 (\4\:qbint VSS) capacitor c=6.26211e-17
C33 (\5\:S0 VSS) capacitor c=2.40379e-17
C34 (\1\:D1 VSS) capacitor c=7.51328e-17
C35 (\3\:S0 VSS) capacitor c=6.94746e-17
C36 (\3\:S0b VSS) capacitor c=5.97054e-17
C37 (\4\:D0 VSS) capacitor c=3.74139e-17
C38 (\10\:CKb VSS) capacitor c=3.34568e-17
C39 (\11\:CKb VSS) capacitor c=2.40778e-17
C40 (\5\:CKbb VSS) capacitor c=5.89019e-17
C41 (\4\:mout VSS) capacitor c=6.61139e-17
C42 (\3\:n20 VSS) capacitor c=3.76564e-17
C43 (\3\:CKbb VSS) capacitor c=3.08296e-17
C44 (\3\:CKb VSS) capacitor c=6.7033e-17
C45 (\8\:qbint VSS) capacitor c=3.68112e-17
C46 (\1\:CK VSS) capacitor c=4.93966e-17
C47 (\3\:qbint VSS) capacitor c=2.95076e-17
C48 (\6\:S0 VSS) capacitor c=3.03284e-17
C49 (\2\:D1 VSS) capacitor c=4.75795e-17
C50 (\4\:S0 VSS) capacitor c=4.42107e-17
C51 (\2\:S0b VSS) capacitor c=5.49608e-17
C52 (\1\:S0 VSS) capacitor c=5.17208e-17
C53 (\3\:D0 VSS) capacitor c=2.64492e-17
C54 (\8\:CKbb VSS) capacitor c=4.15456e-17
C55 (\9\:CKb VSS) capacitor c=2.7875e-17
C56 (\6\:CKbb VSS) capacitor c=4.03023e-17
C57 (\3\:mout VSS) capacitor c=2.5529e-17
C58 (\2\:n20 VSS) capacitor c=4.34279e-17
C59 (\4\:CKb VSS) capacitor c=1.62168e-17
C60 (\4\:CKbb VSS) capacitor c=4.13288e-17
C61 (\2\:CKbb VSS) capacitor c=4.16128e-17
C62 (\7\:qbint VSS) capacitor c=2.49986e-17
C63 (\2\:n30 VSS) capacitor c=4.26709e-17
C64 (\2\:CK VSS) capacitor c=4.54577e-17
C65 (\6\:S0b VSS) capacitor c=1.03415e-16
C66 (\5\:VDD VSS) capacitor c=3.14666e-17
C67 (\7\:D0b VSS) capacitor c=6.7784e-17
C68 (\7\:VDD VSS) capacitor c=5.23037e-17
C69 (\9\:CKbb VSS) capacitor c=1.02258e-16
C70 (\5\:D0b VSS) capacitor c=1.04772e-16
C71 (\4\:n20 VSS) capacitor c=3.4328e-17
C72 (\10\:VDD VSS) capacitor c=3.47137e-17
C73 (\9\:mout VSS) capacitor c=7.43026e-17
C74 (\8\:n30 VSS) capacitor c=5.19174e-17
C75 (\14\:VDD VSS) capacitor c=4.188e-17
C76 (\14\:qbint VSS) capacitor c=7.14121e-17
C77 (\18\:CKb VSS) capacitor c=2.53523e-17
C78 (\17\:VDD VSS) capacitor c=2.69069e-17
C79 (\1\:Q VSS) capacitor c=5.47054e-17
C80 (\1\:VDD VSS) capacitor c=8.51025e-17
C81 (\4\:S0b VSS) capacitor c=5.50775e-17
C82 (\15\:CKbb VSS) capacitor c=4.24914e-17
C83 (\9\:D0b VSS) capacitor c=6.89013e-17
C84 (\8\:n20 VSS) capacitor c=8.29575e-17
C85 (\7\:mout VSS) capacitor c=5.47759e-17
C86 (\4\:n30 VSS) capacitor c=7.27734e-17
C87 (\11\:qbint VSS) capacitor c=8.05222e-17
C88 (\15\:CKb VSS) capacitor c=9.33902e-17
C89 (\3\:Q VSS) capacitor c=5.61639e-17
C90 (\2\:qbint VSS) capacitor c=2.1853e-17
C91 (\6\:qbint VSS) capacitor c=2.38326e-17
C92 (\2\:CKb VSS) capacitor c=4.46223e-17
C93 (\2\:mout VSS) capacitor c=2.85626e-17
C94 (\6\:CKb VSS) capacitor c=5.72862e-17
C95 (\7\:CKb VSS) capacitor c=6.75539e-17
C96 (\2\:D0 VSS) capacitor c=2.86216e-17
C97 (\9\:qbint VSS) capacitor c=7.16079e-17
C98 (\10\:qbint VSS) capacitor c=6.70756e-17
C99 (\13\:qbint VSS) capacitor c=1.10592e-16
C100 (\6\:n30 VSS) capacitor c=1.03114e-16
C101 (\7\:n30 VSS) capacitor c=7.07733e-17
C102 (\5\:mout VSS) capacitor c=6.47005e-17
C103 (\6\:mout VSS) capacitor c=5.89137e-17
C104 (\12\:CKb VSS) capacitor c=6.14877e-17
C105 (\13\:CKb VSS) capacitor c=1.48887e-16
C106 (\14\:CKb VSS) capacitor c=1.65924e-16
C107 (\17\:CKb VSS) capacitor c=8.14787e-17
C108 (\6\:n20 VSS) capacitor c=7.88714e-17
C109 (\7\:n20 VSS) capacitor c=8.5285e-17
C110 (\11\:CKbb VSS) capacitor c=1.16991e-16
C111 (\12\:CKbb VSS) capacitor c=7.61505e-17
C112 (\13\:CKbb VSS) capacitor c=1.02156e-16
C113 (\14\:CKbb VSS) capacitor c=1.36742e-16
C114 (\17\:CKbb VSS) capacitor c=6.14671e-17
C115 (\18\:CKbb VSS) capacitor c=5.30923e-17
C116 (\5\:D0 VSS) capacitor c=6.56193e-17
C117 (\3\:D0b VSS) capacitor c=1.3372e-16
C118 (\4\:D1 VSS) capacitor c=7.60628e-17
C119 (\8\:S0 VSS) capacitor c=7.45004e-17
C120 (\9\:S0 VSS) capacitor c=7.39991e-17
C121 (\10\:S0 VSS) capacitor c=2.61193e-17
C122 (\8\:S0b VSS) capacitor c=9.69349e-17
C123 (\3\:VDD VSS) capacitor c=2.03193e-17
C124 (\9\:VDD VSS) capacitor c=4.32212e-17
C125 (\13\:VDD VSS) capacitor c=1.33131e-17
C126 (\16\:VDD VSS) capacitor c=1.75695e-17
Rk2 (\4\:Q Q) resistor r=0.02908 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.4952 c=0
Rk29 (\5\:D0 D0) resistor r=0.08856 c=0
Rk37 (\9\:S0 S0) resistor r=0.3377 c=0
Rk36 (\8\:S0 \9\:S0) resistor r=0.3554 c=0
Rk38 (S0 \10\:S0) resistor r=0.02105 c=0
Rk56 (\2\:VDD \3\:VDD) resistor r=0.223 c=0
Rk57 (\3\:VDD \4\:VDD) resistor r=0.4292 c=0
Rk58 (\3\:VDD \6\:VDD) resistor r=0.2039 c=0
Rk59 (\4\:VDD \8\:VDD) resistor r=0.2986 c=0
Rk60 (\4\:VDD \9\:VDD) resistor r=0.6041 c=0
Rk61 (\9\:VDD \11\:VDD) resistor r=0.1859 c=0
Rk62 (\9\:VDD \12\:VDD) resistor r=0.4988 c=0
Rk63 (\12\:VDD \13\:VDD) resistor r=0.1302 c=0
Rk64 (\13\:VDD \15\:VDD) resistor r=0.236 c=0
Rk65 (\13\:VDD \16\:VDD) resistor r=0.3832 c=0
Rk66 (\16\:VDD \18\:VDD) resistor r=0.1817 c=0
Rk68 (\19\:VDD VDD) resistor r=0.0499 c=0
Rk67 (\16\:VDD \19\:VDD) resistor r=0.08756 c=0
Rk35 (\4\:D1 D1) resistor r=0.03273 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1452 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4334 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.07252 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.5539 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.2982 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3032 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.1979 c=0
Rk48 (\9\:VSS \10\:VSS) resistor r=0.2129 c=0
Rk50 (\11\:VSS VSS) resistor r=0.0499 c=0
Rk49 (\10\:VSS \11\:VSS) resistor r=0.08756 c=0
Rk51 (\3\:VSS \13\:VSS) resistor r=0.2907 c=0
Rk52 (\4\:VSS \15\:VSS) resistor r=0.2194 c=0
Rk53 (\6\:VSS \17\:VSS) resistor r=0.1225 c=0
Rk54 (\8\:VSS \19\:VSS) resistor r=0.271 c=0
Rk55 (\10\:VSS \21\:VSS) resistor r=0.2933 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.3153 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06062 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6904 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.3182 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2788 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9711 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4234 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.5459 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.1224 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.4975 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.3813 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1685 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3192 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.145 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3096 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.6368 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3322 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3239 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.5248 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.235 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2608 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.08271 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.4677 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.3854 c=0
Rk30 (\2\:D0b \3\:D0b) resistor r=0.6465 c=0
Rk31 (\3\:D0b \4\:D0b) resistor r=0.417 c=0
Rk32 (\4\:D0b \6\:D0b) resistor r=0.04616 c=0
Rk33 (\3\:D0b \8\:D0b) resistor r=0.2642 c=0
Rk34 (\4\:D0b \10\:D0b) resistor r=0.3646 c=0
Rk39 (\5\:S0b \7\:S0b) resistor r=0.5139 c=0
Rk40 (\7\:S0b \8\:S0b) resistor r=0.6394 c=0
Rl29 (\1\:D0 \2\:D0) resistor r=123.88 c=0
Rl31 (\2\:D0 \4\:D0) resistor r=54.6488 c=0
Rl30 (\2\:D0 \3\:D0) resistor r=6.9867 c=0
Rl5 (\2\:CK \3\:CK) resistor r=96.3431 c=0
Rl4 (\1\:CK \2\:CK) resistor r=109.615 c=0
Rl39 (\6\:S0 \7\:S0) resistor r=126.099 c=0
Rl38 (\5\:S0 \6\:S0) resistor r=40.3846 c=0
Rl35 (\3\:S0 \4\:S0) resistor r=48.6653 c=0
Rl32 (\1\:S0 \2\:S0) resistor r=55.6561 c=0
Rl37 (\2\:D1 \3\:D1) resistor r=64.5604 c=0
Rl36 (\1\:D1 \2\:D1) resistor r=100 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=120.868 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=42.0218 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=38.143 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=174.543 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=36.87 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=139.618 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=89.6181 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=32.3738 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=31.8681 c=0
Rl18 (mout \2\:mout) resistor r=48.8796 c=0
Rl20 (\2\:mout \4\:mout) resistor r=75.8027 c=0
Rl19 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=24.2328 c=0
Rl11 (CKbb \2\:CKbb) resistor r=30.0021 c=0
Rl16 (n20 \2\:n20) resistor r=29.5379 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=79.5379 c=0
Rl33 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl34 (\2\:S0b \3\:S0b) resistor r=135.771 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \12\:VDD) resistor r=7.5 c=0
Rz19 (\1\:VDD \19\:VDD) resistor r=37.5 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (D0b \2\:D0b) resistor r=75 c=0
Rz9 (\9\:D0b \10\:D0b) resistor r=75 c=0
Rz10 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry17 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry18 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry19 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry12 (\1\:VSS \5\:VSS) resistor r=5.6364 c=0
Ry13 (\1\:VSS \7\:VSS) resistor r=10.3333 c=0
Ry14 (\1\:VSS \9\:VSS) resistor r=15.5 c=0
Ry15 (\1\:VSS \11\:VSS) resistor r=31 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\5\:D0b \6\:D0b) resistor r=62 c=0
Ry9 (\7\:D0b \8\:D0b) resistor r=20.6667 c=0
Ry10 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK CK) resistor r=45 c=0
Rx15 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\15\:CKb \1\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.972e-14 ps=9.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\11\:qbint n30 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(1)
mn50 (n35 \8\:qbint \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.383e-14 ad=4.408e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.945e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (\4\:n30 \3\:CKb n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.535e-14 ps=8.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.685e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.535e-14 ad=7.585e-14 ps=9.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.37e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=7.585e-14 ps=1.27e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=9.55e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (n25 \4\:mout \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=6.9e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (\9\:D0b \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=6.458e-14 ps=8.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=3.15e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.613e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=5.85e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09879e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (n10 \4\:D0 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=7.93e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=9.99808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.03365e-07 sb=6.49808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.08365e-07 sb=4.44808e-07 sd=160n sca=9.89531 scb=0.00874901 \
        scc=0.000299334 m=(1)
mn13 (n12 \1\:D1 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=1.56e-14 ps=1.15e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13365e-07 sb=3.39808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn10 (\4\:S0b \5\:S0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=2.465e-14 ps=1.15e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18638e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\18\:CKb \3\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.483e-14 ps=1.1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=12.8361 \
        scb=0.0101573 scc=0.000104788 m=(1)
mp45 (\14\:qbint \3\:n30 \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.56e-14 ad=4.315e-14 ps=1.35e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39194e-07 sb=2e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp50 (n36 \5\:qbint \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.56e-14 ad=5.27e-14 ps=1.35e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04194e-07 sb=1.915e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\8\:n30 CKbb n36 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.145e-14 ps=9.6e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19194e-07 sb=1.7e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.209e-13 ad=9.145e-14 ps=1.4e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59194e-07 sb=1.36e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:D0b VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=26.7199 scb=0.0211429 \
        scc=0.00304348 m=(1)
mp30 (\9\:mout n20 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=1.209e-13 ps=1.5e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39419e-06 sb=9.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (n26 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=4.805e-14 ps=1.5e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65919e-06 sb=6.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85919e-06 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp21 (\9\:CKbb \5\:CKb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34e-06 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp11 (n11 \1\:D0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.12e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.43462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp12 (\7\:D0b \2\:S0 n11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=7.02e-14 ps=9.4e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.94551e-07 sb=8.18462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp14 (\7\:D0b S0b n13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.02e-14 ps=1.2e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19551e-07 sb=5.93462e-07 sd=160n sca=12.4887 \
        scb=0.0108489 scc=0.000412416 m=(1)
mp13 (n13 \3\:D1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=8.19e-14 ps=1.41e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.74551e-07 sb=3.38462e-07 sd=160n sca=13.4085 \
        scb=0.011387 scc=0.000412933 m=(1)
mp10 (\6\:S0b \7\:S0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=1.4e-07 sd=160n sca=21.6088 \
        scb=0.0245661 scc=0.00103605 m=(1)
ends MDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:24:25 2012 )
// Library name: gsclib045
// Cell name: MDFFHQX2
// View name: extracted

simulator lang=spectre

subckt MDFFHQX2 CK D0 D1 Q S0 VDD VSS
mp55_1__rcx (\1\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=30.9465 \
        scb=0.0329575 scc=0.002778 m=(2)
C1 (Q VSS) capacitor c=3.45491e-17
C2 (D0 VSS) capacitor c=5.85955e-17
C3 (CK VSS) capacitor c=5.84087e-17
C4 (VDD VSS) capacitor c=3.16794e-16
C5 (D1 VSS) capacitor c=1.10962e-16
C6 (qbint VSS) capacitor c=1.39124e-16
C7 (CKb VSS) capacitor c=1.71024e-17
C8 (n30 VSS) capacitor c=3.48248e-17
C9 (mout VSS) capacitor c=5.9794e-17
C10 (CKbb VSS) capacitor c=3.42642e-17
C11 (n20 VSS) capacitor c=3.95258e-17
C12 (n25 VSS) capacitor c=1.65965e-18
C13 (D0b VSS) capacitor c=1.0724e-16
C14 (n10 VSS) capacitor c=1.17545e-17
C15 (S0b VSS) capacitor c=4.52363e-17
C16 (n12 VSS) capacitor c=1.47994e-18
C17 (n36 VSS) capacitor c=9.04161e-18
C18 (n26 VSS) capacitor c=6.19945e-18
C19 (n11 VSS) capacitor c=5.59536e-18
C20 (n13 VSS) capacitor c=3.91527e-18
C21 (\7\:S0 VSS) capacitor c=3.09855e-17
C22 (\3\:D1 VSS) capacitor c=5.10005e-17
C23 (\1\:S0 VSS) capacitor c=4.90247e-17
C24 (\1\:D0 VSS) capacitor c=6.50136e-17
C25 (\10\:CKb VSS) capacitor c=4.79797e-17
C26 (\7\:CKbb VSS) capacitor c=3.99169e-17
C27 (\8\:CKb VSS) capacitor c=4.35806e-17
C28 (\4\:CKb VSS) capacitor c=2.12298e-17
C29 (\8\:qbint VSS) capacitor c=4.67457e-17
C30 (\3\:n30 VSS) capacitor c=4.23954e-17
C31 (\3\:CK VSS) capacitor c=3.7808e-17
C32 (\5\:S0 VSS) capacitor c=2.94341e-17
C33 (\1\:D1 VSS) capacitor c=7.44934e-17
C34 (\3\:S0 VSS) capacitor c=6.56106e-17
C35 (\3\:S0b VSS) capacitor c=5.86906e-17
C36 (\4\:D0 VSS) capacitor c=4.22846e-17
C37 (\5\:CKb VSS) capacitor c=3.17219e-17
C38 (\11\:CKb VSS) capacitor c=2.44902e-17
C39 (\5\:CKbb VSS) capacitor c=5.22482e-17
C40 (\4\:mout VSS) capacitor c=5.45502e-17
C41 (\3\:n20 VSS) capacitor c=4.24488e-17
C42 (\3\:CKbb VSS) capacitor c=3.01112e-17
C43 (\3\:CKb VSS) capacitor c=6.76524e-17
C44 (\11\:qbint VSS) capacitor c=3.53238e-17
C45 (\1\:CK VSS) capacitor c=4.09456e-17
C46 (\6\:S0 VSS) capacitor c=2.65585e-17
C47 (\2\:D1 VSS) capacitor c=5.01425e-17
C48 (\4\:S0 VSS) capacitor c=4.74003e-17
C49 (\2\:S0b VSS) capacitor c=6.65582e-17
C50 (\2\:S0 VSS) capacitor c=3.85634e-17
C51 (\3\:D0 VSS) capacitor c=2.76772e-17
C52 (\8\:CKbb VSS) capacitor c=3.97049e-17
C53 (\9\:CKb VSS) capacitor c=2.41653e-17
C54 (\6\:CKbb VSS) capacitor c=4.74902e-17
C55 (\3\:mout VSS) capacitor c=1.84103e-17
C56 (\2\:n20 VSS) capacitor c=3.53071e-17
C57 (\4\:CKbb VSS) capacitor c=3.88618e-17
C58 (\2\:CKbb VSS) capacitor c=4.35829e-17
C59 (\10\:qbint VSS) capacitor c=2.49612e-17
C60 (\2\:n30 VSS) capacitor c=4.33813e-17
C61 (\2\:CK VSS) capacitor c=3.6198e-17
C62 (\6\:qbint VSS) capacitor c=2.44162e-17
C63 (\5\:S0b VSS) capacitor c=1.06304e-16
C64 (\1\:VDD VSS) capacitor c=3.83653e-17
C65 (\6\:D0b VSS) capacitor c=6.56961e-17
C66 (\7\:VDD VSS) capacitor c=5.47932e-17
C67 (\9\:CKbb VSS) capacitor c=7.42978e-17
C68 (\4\:D0b VSS) capacitor c=9.12862e-17
C69 (\4\:n20 VSS) capacitor c=6.13157e-17
C70 (\9\:VDD VSS) capacitor c=3.52365e-17
C71 (\9\:mout VSS) capacitor c=6.69154e-17
C72 (\6\:n30 VSS) capacitor c=5.91297e-17
C73 (\12\:VDD VSS) capacitor c=2.87066e-17
C74 (\14\:qbint VSS) capacitor c=7.55677e-17
C75 (\15\:CKb VSS) capacitor c=3.65383e-17
C76 (\1\:Q VSS) capacitor c=8.11633e-17
C77 (\3\:VDD VSS) capacitor c=9.85218e-17
C78 (\7\:S0b VSS) capacitor c=6.87153e-17
C79 (\15\:CKbb VSS) capacitor c=5.92902e-17
C80 (\8\:D0b VSS) capacitor c=7.23922e-17
C81 (\8\:n20 VSS) capacitor c=6.66301e-17
C82 (\7\:mout VSS) capacitor c=5.96049e-17
C83 (\8\:n30 VSS) capacitor c=8.92952e-17
C84 (\16\:qbint VSS) capacitor c=7.57636e-17
C85 (\18\:CKb VSS) capacitor c=8.97571e-17
C86 (\3\:Q VSS) capacitor c=1.5202e-17
C87 (\9\:qbint VSS) capacitor c=2.45183e-17
C88 (\2\:CKb VSS) capacitor c=4.31786e-17
C89 (\2\:mout VSS) capacitor c=3.33344e-17
C90 (\6\:CKb VSS) capacitor c=7.5044e-17
C91 (\7\:CKb VSS) capacitor c=6.9748e-17
C92 (\2\:D0 VSS) capacitor c=2.49828e-17
C93 (\4\:CK VSS) capacitor c=7.24612e-17
C94 (\12\:qbint VSS) capacitor c=6.77187e-17
C95 (\13\:qbint VSS) capacitor c=6.07745e-17
C96 (\18\:qbint VSS) capacitor c=9.50368e-17
C97 (\4\:n30 VSS) capacitor c=7.30885e-17
C98 (\5\:n30 VSS) capacitor c=9.07728e-17
C99 (\5\:mout VSS) capacitor c=5.13199e-17
C100 (\6\:mout VSS) capacitor c=4.82668e-17
C101 (\12\:CKb VSS) capacitor c=5.43264e-17
C102 (\13\:CKb VSS) capacitor c=1.43553e-16
C103 (\14\:CKb VSS) capacitor c=1.42582e-16
C104 (\17\:CKb VSS) capacitor c=8.11055e-17
C105 (\6\:n20 VSS) capacitor c=7.25046e-17
C106 (\7\:n20 VSS) capacitor c=6.65653e-17
C107 (\11\:CKbb VSS) capacitor c=1.29191e-16
C108 (\12\:CKbb VSS) capacitor c=7.69544e-17
C109 (\13\:CKbb VSS) capacitor c=1.27966e-16
C110 (\14\:CKbb VSS) capacitor c=1.33147e-16
C111 (\17\:CKbb VSS) capacitor c=4.68611e-17
C112 (\18\:CKbb VSS) capacitor c=6.10134e-17
C113 (\5\:D0 VSS) capacitor c=5.46774e-17
C114 (\3\:D0b VSS) capacitor c=1.48264e-16
C115 (\8\:S0 VSS) capacitor c=1.44649e-17
C116 (\9\:S0 VSS) capacitor c=1.20918e-16
C117 (\10\:S0 VSS) capacitor c=5.65479e-17
C118 (\11\:S0 VSS) capacitor c=9.86258e-17
C119 (\4\:S0b VSS) capacitor c=9.19403e-17
C120 (\5\:VDD VSS) capacitor c=3.39158e-17
C121 (\11\:VDD VSS) capacitor c=2.85755e-17
Rk1 (\2\:Q Q) resistor r=0.2051 c=0
Rk2 (Q \4\:Q) resistor r=0.166 c=0
Rk29 (\5\:D0 D0) resistor r=0.1122 c=0
Rk3 (\4\:CK CK) resistor r=0.1297 c=0
Rk35 (\8\:S0 \9\:S0) resistor r=0.04037 c=0
Rk36 (\9\:S0 \10\:S0) resistor r=0.4299 c=0
Rk38 (\11\:S0 S0) resistor r=0.004282 c=0
Rk37 (\9\:S0 \11\:S0) resistor r=0.6809 c=0
Rk56 (\2\:VDD \4\:VDD) resistor r=0.3008 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.3482 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.6546 c=0
Rk59 (\5\:VDD \8\:VDD) resistor r=0.3102 c=0
Rk60 (\6\:VDD \10\:VDD) resistor r=0.2882 c=0
Rk61 (\6\:VDD \11\:VDD) resistor r=0.6164 c=0
Rk62 (\11\:VDD \13\:VDD) resistor r=0.2266 c=0
Rk64 (\14\:VDD VDD) resistor r=0.08252 c=0
Rk63 (\11\:VDD \14\:VDD) resistor r=0.3357 c=0
Rk34 (\4\:D1 D1) resistor r=0.003482 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1677 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4307 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.05244 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.5487 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.3031 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3532 c=0
Rk48 (\9\:VSS VSS) resistor r=0.08252 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.3482 c=0
Rk51 (\3\:VSS \14\:VSS) resistor r=0.2067 c=0
Rk52 (\4\:VSS \16\:VSS) resistor r=0.2111 c=0
Rk53 (\6\:VSS \18\:VSS) resistor r=0.1222 c=0
Rk54 (\8\:VSS \20\:VSS) resistor r=0.237 c=0
Rk4 (\12\:qbint \13\:qbint) resistor r=0.3074 c=0
Rk5 (\13\:qbint \15\:qbint) resistor r=0.3138 c=0
Rk6 (\13\:qbint \17\:qbint) resistor r=0.05799 c=0
Rk7 (\17\:qbint \18\:qbint) resistor r=0.7082 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2506 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9254 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.1459 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.6495 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.4111 c=0
Rk8 (\4\:n30 \5\:n30) resistor r=0.3724 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.1741 c=0
Rk10 (\5\:n30 \9\:n30) resistor r=0.5381 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.241 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1153 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2348 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.5667 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3076 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3291 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.858 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2539 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1934 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3963 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2531 c=0
Rk30 (\2\:D0b \3\:D0b) resistor r=0.6822 c=0
Rk31 (\3\:D0b \5\:D0b) resistor r=0.3925 c=0
Rk32 (\3\:D0b \7\:D0b) resistor r=0.3379 c=0
Rk33 (\5\:D0b \9\:D0b) resistor r=0.3871 c=0
Rk39 (\4\:S0b \6\:S0b) resistor r=0.649 c=0
Rk40 (\6\:S0b \8\:S0b) resistor r=0.5281 c=0
Rl32 (\1\:D0 \2\:D0) resistor r=101.637 c=0
Rl34 (\2\:D0 \4\:D0) resistor r=59.3295 c=0
Rl33 (\2\:D0 \3\:D0) resistor r=8.3038 c=0
Rl8 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl7 (\1\:CK \2\:CK) resistor r=96.1338 c=0
Rl42 (\6\:S0 \7\:S0) resistor r=39.5604 c=0
Rl41 (\5\:S0 \6\:S0) resistor r=105.769 c=0
Rl38 (\3\:S0 \4\:S0) resistor r=29.4849 c=0
Rl35 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl40 (\2\:D1 \3\:D1) resistor r=48.0541 c=0
Rl39 (\1\:D1 \2\:D1) resistor r=99.7951 c=0
Rl5 (qbint \6\:qbint) resistor r=9.5287 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=49.7141 c=0
Rl13 (\9\:qbint \11\:qbint) resistor r=84.3295 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl16 (CKb \2\:CKb) resistor r=37.675 c=0
Rl18 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl17 (\2\:CKb \3\:CKb) resistor r=178.39 c=0
Rl30 (\6\:CKb \10\:CKb) resistor r=199.259 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=76.0085 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=143.774 c=0
Rl31 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=198.915 c=0
Rl9 (n30 \2\:n30) resistor r=84.6154 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=33.7912 c=0
Rl21 (mout \2\:mout) resistor r=99.7141 c=0
Rl23 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl22 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=39.6174 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=33.8482 c=0
Rl14 (CKbb \2\:CKbb) resistor r=37.6944 c=0
Rl19 (n20 \2\:n20) resistor r=29.5379 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=87.2302 c=0
Rl36 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl37 (\2\:S0b \3\:S0b) resistor r=131.73 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz18 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz19 (\14\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (D0b \2\:D0b) resistor r=75 c=0
Rz9 (\8\:D0b \9\:D0b) resistor r=75 c=0
Rz10 (\7\:S0b \8\:S0b) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \7\:VDD) resistor r=31 c=0
Ry17 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry18 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=6.2 c=0
Ry13 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry14 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry2 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\6\:n30 \7\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry9 (\6\:D0b \7\:D0b) resistor r=20.6667 c=0
Ry10 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\18\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \4\:S0b) resistor r=45 c=0
mn55 (\3\:Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.73654e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\18\:CKb \1\:CK VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.567e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\16\:qbint n30 \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=8.61e-14 ps=1.18e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.95e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn50 (n35 \11\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=5.432e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\8\:n30 \3\:CKb n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=4.51e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.725e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=8.61e-14 ps=8.5e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.46e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (n25 \4\:mout \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=1.435e-14 ps=1.18e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=7.3e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=6.15e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn25 (\8\:D0b \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn21 (\15\:CKbb \5\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10552e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn11 (n10 \4\:D0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=7.67e-14 ps=8.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.07942e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=7.39423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.69e-14 \
        ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.81635e-07 sb=5.34423e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn13 (n12 \1\:D1 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=1.69e-14 ps=1.33e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91635e-07 sb=4.24423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn10 (\7\:S0b \5\:S0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=2.9e-14 ps=1.33e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25569e-06 sb=2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mp20 (\15\:CKb \3\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.3324 \
        scb=0.00994664 scc=0.000204208 m=(1)
mp45 (\14\:qbint \3\:n30 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.1e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp50 (n36 \8\:qbint \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.1e-14 ad=5.27e-14 ps=1.44e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.92871e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\6\:n30 CKbb n36 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.765e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.71597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\6\:n30 \4\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.302e-13 ad=9.765e-14 ps=1.46e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.35597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout n20 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.302e-13 ps=1.38e-06 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=8.90968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (n26 mout \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.045e-14 ps=1.38e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=6.25968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.58e-14 ps=1.01e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=3.85968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:D0b VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.60968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\9\:CKbb \10\:CKb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05465e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp11 (n11 \1\:D0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.85833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (\6\:D0b \1\:S0 n11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.59551e-07 sb=7.95833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp14 (\6\:D0b S0b n13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.84551e-07 sb=5.70833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (n13 \3\:D1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=5.265e-14 ps=1.6e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.64551e-07 sb=3.90833e-07 sd=160n sca=16.239 \
        scb=0.0143727 scc=0.00110279 m=(1)
mp10 (\5\:S0b \7\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23372e-06 sb=1.4e-07 sd=160n sca=25.6683 \
        scb=0.0269847 scc=0.00206824 m=(1)
ends MDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:25:04 2012 )
// Library name: gsclib045
// Cell name: MDFFHQX4
// View name: extracted

simulator lang=spectre

subckt MDFFHQX4 CK D0 D1 Q S0 VDD VSS
mp20 (\14\:CKb \4\:CK \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.8563 scb=0.0365862 \
        scc=0.0028968 m=(1)
C1 (D0 VSS) capacitor c=5.34416e-17
C2 (CK VSS) capacitor c=6.7592e-17
C3 (Q VSS) capacitor c=1.90258e-16
C4 (S0 VSS) capacitor c=6.2983e-17
C5 (VDD VSS) capacitor c=3.30697e-16
C6 (D1 VSS) capacitor c=1.016e-16
C7 (CKb VSS) capacitor c=2.26939e-17
C8 (qbint VSS) capacitor c=3.01683e-16
C9 (n30 VSS) capacitor c=1.82758e-16
C10 (n35 VSS) capacitor c=5.33374e-18
C11 (mout VSS) capacitor c=6.81624e-17
C12 (CKbb VSS) capacitor c=4.78294e-17
C13 (n20 VSS) capacitor c=3.85698e-17
C14 (n25 VSS) capacitor c=1.08109e-18
C15 (D0b VSS) capacitor c=8.99774e-17
C16 (n10 VSS) capacitor c=6.92234e-18
C17 (S0b VSS) capacitor c=4.29579e-17
C18 (n36 VSS) capacitor c=5.48591e-18
C19 (n26 VSS) capacitor c=2.64832e-18
C20 (n11 VSS) capacitor c=1.91748e-18
C21 (n13 VSS) capacitor c=4.24869e-18
C22 (\5\:S0 VSS) capacitor c=4.42466e-17
C23 (\3\:D1 VSS) capacitor c=5.39846e-17
C24 (\2\:S0 VSS) capacitor c=7.19901e-17
C25 (\1\:D0 VSS) capacitor c=8.84908e-17
C26 (\5\:CKb VSS) capacitor c=6.48657e-17
C27 (\7\:CKbb VSS) capacitor c=3.96514e-17
C28 (\8\:CKb VSS) capacitor c=5.76856e-17
C29 (\4\:CKb VSS) capacitor c=2.71594e-17
C30 (\15\:qbint VSS) capacitor c=6.36695e-17
C31 (\4\:CK VSS) capacitor c=3.71103e-17
C32 (\7\:S0 VSS) capacitor c=3.22674e-17
C33 (\1\:D1 VSS) capacitor c=8.47987e-17
C34 (\3\:S0 VSS) capacitor c=7.00522e-17
C35 (\3\:S0b VSS) capacitor c=5.87496e-17
C36 (\4\:D0 VSS) capacitor c=4.22189e-17
C37 (\10\:CKb VSS) capacitor c=2.53318e-17
C38 (\11\:CKb VSS) capacitor c=2.46459e-17
C39 (\5\:CKbb VSS) capacitor c=4.379e-17
C40 (\4\:mout VSS) capacitor c=4.38761e-17
C41 (\3\:n20 VSS) capacitor c=4.5498e-17
C42 (\3\:CKbb VSS) capacitor c=3.02372e-17
C43 (\3\:CKb VSS) capacitor c=5.11864e-17
C44 (\18\:qbint VSS) capacitor c=2.94429e-17
C45 (\3\:CK VSS) capacitor c=2.96838e-17
C46 (\6\:S0 VSS) capacitor c=3.57097e-17
C47 (\2\:D1 VSS) capacitor c=5.7603e-17
C48 (\4\:S0 VSS) capacitor c=4.32043e-17
C49 (\1\:S0 VSS) capacitor c=4.89444e-17
C50 (\3\:D0 VSS) capacitor c=3.16702e-17
C51 (\8\:CKbb VSS) capacitor c=3.79749e-17
C52 (\9\:CKb VSS) capacitor c=2.90483e-17
C53 (\6\:CKbb VSS) capacitor c=3.87894e-17
C54 (\3\:mout VSS) capacitor c=1.618e-17
C55 (\2\:n20 VSS) capacitor c=3.8782e-17
C56 (\4\:CKbb VSS) capacitor c=3.63133e-17
C57 (\2\:CKbb VSS) capacitor c=4.59307e-17
C58 (\17\:qbint VSS) capacitor c=2.97465e-17
C59 (\1\:CK VSS) capacitor c=2.61002e-17
C60 (\7\:S0b VSS) capacitor c=9.30929e-17
C61 (\1\:VDD VSS) capacitor c=3.2305e-17
C62 (\4\:D0b VSS) capacitor c=6.78284e-17
C63 (\15\:VDD VSS) capacitor c=3.38837e-17
C64 (\9\:CKbb VSS) capacitor c=8.41114e-17
C65 (\6\:D0b VSS) capacitor c=1.25699e-16
C66 (\4\:n20 VSS) capacitor c=5.868e-17
C67 (\17\:VDD VSS) capacitor c=3.29441e-17
C68 (\9\:mout VSS) capacitor c=6.30943e-17
C69 (\11\:n30 VSS) capacitor c=5.63104e-17
C70 (\19\:qbint VSS) capacitor c=4.8374e-17
C71 (\14\:CKb VSS) capacitor c=2.25269e-16
C72 (\3\:VDD VSS) capacitor c=1.2103e-16
C73 (\5\:S0b VSS) capacitor c=4.88933e-17
C74 (\15\:CKbb VSS) capacitor c=5.67017e-17
C75 (\8\:D0b VSS) capacitor c=7.32177e-17
C76 (\8\:n20 VSS) capacitor c=6.62503e-17
C77 (\7\:mout VSS) capacitor c=4.87607e-17
C78 (\7\:n30 VSS) capacitor c=6.00855e-17
C79 (\24\:qbint VSS) capacitor c=2.429e-17
C80 (\16\:CKb VSS) capacitor c=4.30312e-17
C81 (\2\:CK VSS) capacitor c=1.82014e-17
C82 (\16\:qbint VSS) capacitor c=2.50108e-17
C83 (\2\:CKb VSS) capacitor c=5.55847e-17
C84 (\2\:mout VSS) capacitor c=3.64582e-17
C85 (\6\:CKb VSS) capacitor c=5.1824e-17
C86 (\7\:CKb VSS) capacitor c=5.3503e-17
C87 (\2\:D0 VSS) capacitor c=3.53919e-17
C88 (\2\:S0b VSS) capacitor c=5.6635e-17
C89 (\5\:CK VSS) capacitor c=5.77103e-17
C90 (\21\:qbint VSS) capacitor c=2.42396e-17
C91 (\22\:qbint VSS) capacitor c=4.09929e-17
C92 (\23\:qbint VSS) capacitor c=1.42324e-17
C93 (\26\:qbint VSS) capacitor c=4.78171e-17
C94 (\9\:n30 VSS) capacitor c=8.14931e-17
C95 (\10\:n30 VSS) capacitor c=5.0766e-17
C96 (\5\:mout VSS) capacitor c=4.98762e-17
C97 (\6\:mout VSS) capacitor c=5.61253e-17
C98 (\12\:CKb VSS) capacitor c=5.15258e-17
C99 (\13\:CKb VSS) capacitor c=2.3528e-16
C100 (\18\:CKb VSS) capacitor c=7.76845e-17
C101 (\6\:n20 VSS) capacitor c=6.57831e-17
C102 (\7\:n20 VSS) capacitor c=6.57543e-17
C103 (\11\:CKbb VSS) capacitor c=1.41121e-16
C104 (\12\:CKbb VSS) capacitor c=7.68733e-17
C105 (\13\:CKbb VSS) capacitor c=1.1084e-16
C106 (\14\:CKbb VSS) capacitor c=1.02102e-16
C107 (\17\:CKbb VSS) capacitor c=5.45126e-17
C108 (\18\:CKbb VSS) capacitor c=6.09275e-17
C109 (\5\:D0 VSS) capacitor c=5.97187e-17
C110 (\3\:D0b VSS) capacitor c=1.24198e-16
C111 (\8\:S0 VSS) capacitor c=7.33748e-17
C112 (\9\:S0 VSS) capacitor c=5.94531e-17
C113 (\9\:S0b VSS) capacitor c=8.48796e-17
C114 (\5\:VDD VSS) capacitor c=1.00012e-17
C115 (\7\:VDD VSS) capacitor c=2.86579e-17
C116 (\9\:VDD VSS) capacitor c=1.63872e-16
Rk31 (\5\:D0 D0) resistor r=0.1545 c=0
Rk1 (CK \5\:CK) resistor r=0.1707 c=0
Rk38 (\8\:S0 \9\:S0) resistor r=0.3401 c=0
Rk40 (\10\:S0 S0) resistor r=0.003095 c=0
Rk39 (\9\:S0 \10\:S0) resistor r=0.2335 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.3134 c=0
Rk60 (\4\:VDD \5\:VDD) resistor r=0.2905 c=0
Rk61 (\5\:VDD \6\:VDD) resistor r=0.1602 c=0
Rk62 (\6\:VDD \7\:VDD) resistor r=0.5111 c=0
Rk63 (\7\:VDD \8\:VDD) resistor r=0.2404 c=0
Rk69 (\9\:VDD VDD) resistor r=0.1003 c=0
Rk64 (\8\:VDD \9\:VDD) resistor r=0.3607 c=0
Rk71 (\5\:VDD \16\:VDD) resistor r=0.2396 c=0
Rk72 (\7\:VDD \18\:VDD) resistor r=0.1619 c=0
Rk37 (\4\:D1 D1) resistor r=0.007054 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.09003 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.4616 c=0
Rk45 (\3\:VSS \6\:VSS) resistor r=0.2894 c=0
Rk46 (\4\:VSS \7\:VSS) resistor r=0.5812 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.471 c=0
Rk52 (\9\:VSS VSS) resistor r=0.1507 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.1602 c=0
Rk53 (\4\:VSS \14\:VSS) resistor r=0.3621 c=0
Rk54 (\7\:VSS \16\:VSS) resistor r=0.1253 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2989 c=0
Rk18 (\13\:CKb \15\:CKb) resistor r=1.7741 c=0
Rk19 (\15\:CKb \17\:CKb) resistor r=0.392 c=0
Rk20 (\13\:CKb \18\:CKb) resistor r=0.5387 c=0
Rk6 (\20\:qbint \21\:qbint) resistor r=0.3027 c=0
Rk7 (\21\:qbint \22\:qbint) resistor r=0.2096 c=0
Rk8 (\21\:qbint \23\:qbint) resistor r=0.07797 c=0
Rk9 (\23\:qbint \25\:qbint) resistor r=0.07084 c=0
Rk10 (\23\:qbint \26\:qbint) resistor r=0.1852 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.4493 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.2117 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.3038 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.2333 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.1994 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.2599 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.6608 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.3715 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.2829 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.8171 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.3533 c=0
Rk29 (\13\:CKbb \17\:CKbb) resistor r=0.2213 c=0
Rk30 (\14\:CKbb \18\:CKbb) resistor r=0.2549 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.171 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3369 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.286 c=0
Rk32 (\2\:D0b \3\:D0b) resistor r=0.6162 c=0
Rk33 (\3\:D0b \5\:D0b) resistor r=0.1478 c=0
Rk34 (\3\:D0b \7\:D0b) resistor r=0.5202 c=0
Rk35 (\7\:D0b \9\:D0b) resistor r=0.3715 c=0
Rk36 (\5\:D0b \10\:D0b) resistor r=0.1569 c=0
Rk41 (\6\:S0b \8\:S0b) resistor r=0.4631 c=0
Rk42 (\8\:S0b \9\:S0b) resistor r=0.533 c=0
Rl43 (\1\:D0 \2\:D0) resistor r=50.8027 c=0
Rl45 (\2\:D0 \4\:D0) resistor r=98.8796 c=0
Rl44 (\2\:D0 \3\:D0) resistor r=12.2499 c=0
Rl3 (\2\:CK \4\:CK) resistor r=82.4064 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.3295 c=0
Rl1 (\1\:CK \2\:CK) resistor r=3.5213 c=0
Rl53 (\5\:S0 \6\:S0) resistor r=104.538 c=0
Rl54 (\6\:S0 \7\:S0) resistor r=39.1533 c=0
Rl50 (\3\:S0 \4\:S0) resistor r=28.079 c=0
Rl46 (\1\:S0 \2\:S0) resistor r=37.7189 c=0
Rl52 (\2\:D1 \3\:D1) resistor r=43.6813 c=0
Rl51 (\1\:D1 \2\:D1) resistor r=92.3077 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl27 (CKb \2\:CKb) resistor r=84.5407 c=0
Rl29 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl28 (\2\:CKb \3\:CKb) resistor r=145.697 c=0
Rl37 (\5\:CKb \6\:CKb) resistor r=185.338 c=0
Rl41 (\6\:CKb \10\:CKb) resistor r=47.3105 c=0
Rl39 (\7\:CKb \8\:CKb) resistor r=170.697 c=0
Rl42 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl38 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl22 (\16\:qbint \15\:qbint) resistor r=103.56 c=0
Rl24 (\16\:qbint \18\:qbint) resistor r=34.3295 c=0
Rl23 (\16\:qbint \17\:qbint) resistor r=11.4953 c=0
Rl32 (mout \2\:mout) resistor r=98.8796 c=0
Rl34 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl33 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl36 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl35 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl26 (\3\:CKbb \4\:CKbb) resistor r=33.3841 c=0
Rl25 (CKbb \2\:CKbb) resistor r=41.0764 c=0
Rl30 (n20 \2\:n20) resistor r=26.098 c=0
Rl31 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl47 (S0b \2\:S0b) resistor r=67.4757 c=0
Rl48 (\2\:S0b \3\:S0b) resistor r=147.664 c=0
Rl49 (\2\:S0b \4\:S0b) resistor r=1.2666 c=0
Rz24 (VDD \3\:VDD) resistor r=75 c=0
Rz19 (\4\:VDD \3\:VDD) resistor r=12.5 c=0
Rz20 (\6\:VDD \3\:VDD) resistor r=25 c=0
Rz21 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\9\:VDD \3\:VDD) resistor r=15 c=0
Rz12 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz6 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz3 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (D0b \2\:D0b) resistor r=75 c=0
Rz10 (\8\:D0b \9\:D0b) resistor r=75 c=0
Rz11 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\4\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry15 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\20\:qbint \19\:qbint) resistor r=62 c=0
Ry4 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry10 (\6\:D0b \7\:D0b) resistor r=62 c=0
Ry11 (\4\:D0b \10\:D0b) resistor r=62 c=0
Ry12 (\7\:S0b \8\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx15 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx17 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \18\:CKb) resistor r=45 c=0
Rx2 (\22\:qbint qbint) resistor r=45 c=0
Rx3 (\26\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:S0b \9\:S0b) resistor r=45 c=0
mn20 (\16\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.42e-14 ps=9.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=1.74721e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45_1__rcx (\24\:qbint n30 \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.273e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16317e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn50 (n35 \18\:qbint \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=3.28e-14 ps=8.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63317e-06 sb=1.94e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\7\:n30 \3\:CKb n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.92e-14 ps=7.3e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83817e-06 sb=1.735e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:mout \3\:CKbb \7\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=8.2e-14 ps=8.9e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.45e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=8.2e-14 ps=1.32e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (n25 \4\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.358e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.4e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=4.51e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.8e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:D0b \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=6.458e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn21 (\15\:CKbb \10\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (n10 \4\:D0 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=9.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75673e-07 sb=8.70673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.60673e-07 sb=5.85673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.65673e-07 sb=3.80673e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn13 (n12 \1\:D1 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70673e-07 sb=2.75673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\5\:S0b \7\:S0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.045e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16069e-06 sb=2.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=6.24e-14 ps=1.605e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.40577e-07 sb=1.76308e-06 sd=160n sca=18.6093 \
        scb=0.0174808 scc=0.00104939 m=(4)
mp45_1__rcx (\19\:qbint n30 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.96e-14 ad=4.96e-14 ps=1.55e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21685e-06 sb=2e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(2)
mp50 (n36 \15\:qbint \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.76e-14 ad=3.875e-14 ps=1.55e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68685e-06 sb=1.78685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\11\:n30 CKbb n36 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85685e-06 sb=1.61685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\11\:n30 \4\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.5965e-13 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.41185e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\9\:mout n20 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=1.5965e-13 ps=1.45e-06 pd=1.65e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.51855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (n26 mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.86855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=5.58e-14 ps=9.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.96855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:D0b VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.328e-14 ad=5.58e-14 ps=1.15e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.71855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp21 (\9\:CKbb \5\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.17093e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp11 (n11 \1\:D0 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.14359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp12 (\4\:D0b \2\:S0 n11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.09359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp14 (\4\:D0b S0b n13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.84359e-07 sd=160n sca=15.6414 \
        scb=0.0138242 scc=0.000948215 m=(1)
mp13 (n13 \3\:D1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=5.655e-14 ps=1.25e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55064e-07 sb=2.94359e-07 sd=160n sca=16.7327 \
        scb=0.0148635 scc=0.000950884 m=(1)
mp10 (\7\:S0b \5\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=3.01e-14 ps=1.25e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45581e-07 sb=1.4e-07 sd=160n sca=26.9589 \
        scb=0.0303196 scc=0.00206685 m=(1)
ends MDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:25:42 2012 )
// Library name: gsclib045
// Cell name: MDFFHQX8
// View name: extracted

simulator lang=spectre

subckt MDFFHQX8 CK D0 D1 Q S0 VDD VSS
mp55_1__rcx (Q qbint \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.271e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.92213e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D0 VSS) capacitor c=6.44793e-17
C2 (CK VSS) capacitor c=7.56189e-17
C3 (S0 VSS) capacitor c=4.48235e-17
C4 (VDD VSS) capacitor c=2.96924e-16
C5 (D1 VSS) capacitor c=5.28077e-17
C6 (Q VSS) capacitor c=4.96309e-16
C7 (qbint VSS) capacitor c=3.63125e-16
C8 (n30 VSS) capacitor c=2.0137e-16
C9 (CKb VSS) capacitor c=4.68954e-17
C10 (n35 VSS) capacitor c=2.75049e-18
C11 (mout VSS) capacitor c=6.58911e-17
C12 (CKbb VSS) capacitor c=2.503e-17
C13 (n20 VSS) capacitor c=3.87573e-17
C14 (n25 VSS) capacitor c=1.12961e-18
C15 (D0b VSS) capacitor c=9.71031e-17
C16 (n10 VSS) capacitor c=5.74422e-18
C17 (S0b VSS) capacitor c=3.45398e-17
C18 (n36 VSS) capacitor c=3.48222e-18
C19 (n26 VSS) capacitor c=3.30937e-18
C20 (n11 VSS) capacitor c=1.73603e-18
C21 (n13 VSS) capacitor c=7.01633e-18
C22 (\8\:S0 VSS) capacitor c=4.83304e-17
C23 (\1\:D1 VSS) capacitor c=5.11311e-17
C24 (\2\:S0 VSS) capacitor c=7.17901e-17
C25 (\4\:D0 VSS) capacitor c=9.24691e-17
C26 (\10\:CKb VSS) capacitor c=6.15941e-17
C27 (\7\:CKbb VSS) capacitor c=3.78504e-17
C28 (\8\:CKb VSS) capacitor c=3.96787e-17
C29 (\3\:CKb VSS) capacitor c=2.40718e-17
C30 (\3\:CKbb VSS) capacitor c=6.54663e-17
C31 (\22\:qbint VSS) capacitor c=4.87132e-17
C32 (\1\:CK VSS) capacitor c=3.2684e-17
C33 (\7\:S0 VSS) capacitor c=3.1088e-17
C34 (\3\:D1 VSS) capacitor c=7.97902e-17
C35 (\3\:S0 VSS) capacitor c=7.00577e-17
C36 (\3\:S0b VSS) capacitor c=6.75249e-17
C37 (\1\:D0 VSS) capacitor c=4.68776e-17
C38 (\5\:CKb VSS) capacitor c=2.57088e-17
C39 (\11\:CKb VSS) capacitor c=2.5299e-17
C40 (\5\:CKbb VSS) capacitor c=6.02422e-17
C41 (\4\:mout VSS) capacitor c=5.83414e-17
C42 (\3\:n20 VSS) capacitor c=4.54417e-17
C43 (\24\:qbint VSS) capacitor c=5.82509e-17
C44 (\3\:CK VSS) capacitor c=3.64996e-17
C45 (\5\:S0 VSS) capacitor c=1.69852e-17
C46 (\2\:D1 VSS) capacitor c=4.72656e-17
C47 (\4\:S0 VSS) capacitor c=4.39177e-17
C48 (\2\:S0b VSS) capacitor c=5.17593e-17
C49 (\1\:S0 VSS) capacitor c=5.5647e-17
C50 (\3\:D0 VSS) capacitor c=2.93562e-17
C51 (\8\:CKbb VSS) capacitor c=4.1696e-17
C52 (\9\:CKb VSS) capacitor c=2.73525e-17
C53 (\6\:CKbb VSS) capacitor c=3.98525e-17
C54 (\3\:mout VSS) capacitor c=1.73126e-17
C55 (\2\:n20 VSS) capacitor c=3.51673e-17
C56 (\4\:CKbb VSS) capacitor c=2.5985e-17
C57 (\4\:CKb VSS) capacitor c=3.7326e-17
C58 (\2\:CKb VSS) capacitor c=3.89957e-17
C59 (\23\:qbint VSS) capacitor c=4.73342e-17
C60 (\2\:CK VSS) capacitor c=3.19215e-17
C61 (\6\:S0b VSS) capacitor c=1.11895e-16
C62 (\1\:VDD VSS) capacitor c=2.78983e-17
C63 (\8\:D0b VSS) capacitor c=5.02858e-17
C64 (\16\:VDD VSS) capacitor c=4.1642e-17
C65 (\15\:CKbb VSS) capacitor c=8.05496e-17
C66 (\4\:D0b VSS) capacitor c=1.12748e-16
C67 (\4\:n20 VSS) capacitor c=6.06092e-17
C68 (\18\:VDD VSS) capacitor c=3.50566e-17
C69 (\9\:mout VSS) capacitor c=5.79449e-17
C70 (\14\:n30 VSS) capacitor c=1.09135e-16
C71 (\20\:VDD VSS) capacitor c=1.03068e-17
C72 (\18\:CKb VSS) capacitor c=1.03494e-16
C73 (\26\:qbint VSS) capacitor c=3.76922e-16
C74 (\3\:VDD VSS) capacitor c=1.29631e-16
C75 (\4\:S0b VSS) capacitor c=8.99442e-17
C76 (\9\:CKbb VSS) capacitor c=6.43183e-17
C77 (\6\:D0b VSS) capacitor c=7.68061e-17
C78 (\8\:n20 VSS) capacitor c=7.05413e-17
C79 (\7\:mout VSS) capacitor c=5.25977e-17
C80 (\12\:n30 VSS) capacitor c=2.09147e-16
C81 (\15\:CKb VSS) capacitor c=1.54372e-16
C82 (\2\:CKbb VSS) capacitor c=4.83315e-17
C83 (\2\:mout VSS) capacitor c=3.63156e-17
C84 (\6\:CKb VSS) capacitor c=6.35927e-17
C85 (\7\:CKb VSS) capacitor c=6.53101e-17
C86 (\2\:D0 VSS) capacitor c=4.58936e-17
C87 (\6\:S0 VSS) capacitor c=2.50977e-17
C88 (\4\:CK VSS) capacitor c=3.80823e-17
C89 (\25\:qbint VSS) capacitor c=1.19277e-16
C90 (\31\:qbint VSS) capacitor c=3.49523e-17
C91 (\11\:n30 VSS) capacitor c=1.5533e-16
C92 (\5\:mout VSS) capacitor c=5.39584e-17
C93 (\6\:mout VSS) capacitor c=5.5928e-17
C94 (\12\:CKb VSS) capacitor c=5.31803e-17
C95 (\13\:CKb VSS) capacitor c=1.31025e-16
C96 (\14\:CKb VSS) capacitor c=1.59367e-16
C97 (\17\:CKb VSS) capacitor c=1.01634e-16
C98 (\6\:n20 VSS) capacitor c=7.46218e-17
C99 (\7\:n20 VSS) capacitor c=7.58195e-17
C100 (\11\:CKbb VSS) capacitor c=9.04386e-17
C101 (\12\:CKbb VSS) capacitor c=1.12123e-16
C102 (\13\:CKbb VSS) capacitor c=1.19223e-16
C103 (\14\:CKbb VSS) capacitor c=1.31347e-16
C104 (\17\:CKbb VSS) capacitor c=6.76507e-17
C105 (\5\:D0 VSS) capacitor c=4.66694e-17
C106 (\3\:D0b VSS) capacitor c=1.17544e-16
C107 (\4\:D1 VSS) capacitor c=7.88508e-17
C108 (\9\:S0 VSS) capacitor c=6.48937e-17
C109 (\10\:S0 VSS) capacitor c=8.25297e-17
C110 (\11\:S0 VSS) capacitor c=3.03312e-17
C111 (\8\:S0b VSS) capacitor c=8.57522e-17
C112 (\5\:VDD VSS) capacitor c=4.39476e-17
C113 (\7\:VDD VSS) capacitor c=1.73011e-17
C114 (\10\:VDD VSS) capacitor c=4.96581e-16
Rk74 (\2\:VSS \4\:VSS) resistor r=0.4882 c=0
Rk75 (\4\:VSS \5\:VSS) resistor r=0.1829 c=0
Rk76 (\5\:VSS \6\:VSS) resistor r=0.6107 c=0
Rk77 (\6\:VSS \7\:VSS) resistor r=0.2572 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.3726 c=0
Rk85 (\9\:VSS VSS) resistor r=0.1024 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.4552 c=0
Rk86 (\5\:VSS \16\:VSS) resistor r=0.2341 c=0
Rk87 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk88 (\8\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk42 (\5\:D0 D0) resistor r=0.05403 c=0
Rk14 (\4\:CK CK) resistor r=0.1318 c=0
Rk49 (\10\:S0 S0) resistor r=0.3407 c=0
Rk48 (\9\:S0 \10\:S0) resistor r=0.3756 c=0
Rk50 (S0 \11\:S0) resistor r=0.03909 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.2684 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.3685 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5341 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.05749 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.564 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.2306 c=0
Rk65 (\10\:VDD VDD) resistor r=0.1024 c=0
Rk59 (\9\:VDD \10\:VDD) resistor r=0.2632 c=0
Rk66 (\5\:VDD \17\:VDD) resistor r=0.2268 c=0
Rk67 (\7\:VDD \19\:VDD) resistor r=0.2199 c=0
Rk68 (\8\:VDD \21\:VDD) resistor r=0.07405 c=0
Rk47 (\4\:D1 D1) resistor r=0.0251 c=0
Rk15 (\25\:qbint \26\:qbint) resistor r=0.8718 c=0
Rk19 (\26\:qbint \31\:qbint) resistor r=0.1663 c=0
Rk23 (\11\:n30 \13\:n30) resistor r=1.2398 c=0
Rk24 (\13\:n30 \15\:n30) resistor r=0.4642 c=0
Rk28 (\12\:CKb \13\:CKb) resistor r=0.2504 c=0
Rk29 (\13\:CKb \14\:CKb) resistor r=0.687 c=0
Rk30 (\14\:CKb \16\:CKb) resistor r=0.637 c=0
Rk31 (\13\:CKb \17\:CKb) resistor r=0.7147 c=0
Rk32 (\16\:CKb \19\:CKb) resistor r=0.5734 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2281 c=0
Rk26 (\6\:mout \8\:mout) resistor r=0.193 c=0
Rk27 (\6\:mout \10\:mout) resistor r=0.2421 c=0
Rk36 (\10\:CKbb \11\:CKbb) resistor r=0.3958 c=0
Rk37 (\11\:CKbb \12\:CKbb) resistor r=0.2849 c=0
Rk38 (\12\:CKbb \13\:CKbb) resistor r=0.8474 c=0
Rk39 (\11\:CKbb \14\:CKbb) resistor r=0.3429 c=0
Rk40 (\14\:CKbb \16\:CKbb) resistor r=0.6275 c=0
Rk41 (\12\:CKbb \17\:CKbb) resistor r=0.2249 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.1647 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3859 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.3046 c=0
Rk43 (\2\:D0b \3\:D0b) resistor r=0.6476 c=0
Rk44 (\3\:D0b \5\:D0b) resistor r=0.4237 c=0
Rk45 (\5\:D0b \7\:D0b) resistor r=0.4045 c=0
Rk46 (\3\:D0b \9\:D0b) resistor r=0.2015 c=0
Rk51 (\5\:S0b \7\:S0b) resistor r=0.7143 c=0
Rk52 (\7\:S0b \8\:S0b) resistor r=0.5705 c=0
Rl54 (\2\:D0 \4\:D0) resistor r=58.495 c=0
Rl52 (\1\:D0 \2\:D0) resistor r=109.984 c=0
Rl53 (\2\:D0 \3\:D0) resistor r=9.6183 c=0
Rl30 (\1\:CK \2\:CK) resistor r=96.1538 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl58 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl55 (\1\:S0 \2\:S0) resistor r=36.4253 c=0
Rl63 (\6\:S0 \8\:S0) resistor r=121.957 c=0
Rl62 (\6\:S0 \7\:S0) resistor r=46.9565 c=0
Rl61 (\5\:S0 \6\:S0) resistor r=13.569 c=0
Rl59 (\1\:D1 \2\:D1) resistor r=55.0021 c=0
Rl60 (\2\:D1 \3\:D1) resistor r=85.7713 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=65.3618 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=80.5643 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=193.478 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=61.5164 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=41.9892 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=185.006 c=0
Rl41 (mout \2\:mout) resistor r=102.726 c=0
Rl43 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl42 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=37.2302 c=0
Rl36 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=138.005 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=92.233 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=94.9225 c=0
Rl56 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl57 (\2\:S0b \3\:S0b) resistor r=121.943 c=0
Rz19 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=12.5 c=0
Rz16 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=15 c=0
Rz18 (\10\:VDD \3\:VDD) resistor r=7.5 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\7\:mout \8\:mout) resistor r=75 c=0
Rz11 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (D0b \2\:D0b) resistor r=75 c=0
Rz13 (\6\:D0b \7\:D0b) resistor r=75 c=0
Rz14 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (\4\:D0b \5\:D0b) resistor r=62 c=0
Ry13 (\8\:D0b \9\:D0b) resistor r=31 c=0
Ry14 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx13 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\1\:S0 \9\:S0) resistor r=45 c=0
Rx16 (\4\:S0 \10\:S0) resistor r=45 c=0
Rx17 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx14 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\31\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\26\:qbint n30 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn50 (n35 \24\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.95e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\12\:n30 CKb n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=3.895e-14 ps=6.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.79e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\7\:mout CKbb \12\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.895e-14 ad=1.1377e-13 ps=7.9e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3378e-07 sb=1.555e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.63e-14 ad=1.1377e-13 ps=1.37e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43378e-06 sb=9.55e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (n25 \4\:mout \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.23e-14 ps=1.37e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69878e-06 sb=6.9e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\6\:D0b \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=6.458e-14 ps=8.6e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.94293e-06 sb=3.15e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (\8\:n20 \5\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.612e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80378e-06 sb=5.85e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn21 (\9\:CKbb \5\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10759e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (n10 \1\:D0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.94e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=7.98365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn12 (D0b \3\:S0b n10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.06058e-07 sb=5.63365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (D0b \3\:S0 n12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.11058e-07 sb=3.58365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn13 (n12 \3\:D1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16058e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\4\:S0b \7\:S0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11448e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45_1__rcx (\26\:qbint n30 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.887e-14 ad=5.98e-14 ps=1.15667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.01e-14 ps=1.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99814e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n36 \22\:qbint \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.1e-14 ps=1.93e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67661e-07 sb=1.75185e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp51 (\14\:n30 \3\:CKbb n36 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.12661e-07 sb=1.60685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp40 (\14\:n30 \3\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.82661e-07 sb=1.33685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp30 (\9\:mout n20 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25766e-06 sb=8.61855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp35 (n26 mout \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.805e-14 ps=1.38e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52266e-06 sb=5.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp36 (\4\:n20 \8\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72266e-06 sb=3.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:D0b VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.328e-14 ad=5.58e-14 ps=1.15e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=1.71855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp21 (\15\:CKbb \10\:CKb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (n11 \4\:D0 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\8\:D0b \2\:S0 n11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\8\:D0b S0b n13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=13.6902 \
        scb=0.0122097 scc=0.000647516 m=(1)
mp13 (n13 \1\:D1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=14.7912 \
        scb=0.012924 scc=0.00064842 m=(1)
mp10 (\6\:S0b \8\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=20.6301 \
        scb=0.0216347 scc=0.00118997 m=(1)
ends MDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:11:00 2012 )
// Library name: gsclib045
// Cell name: MX2X1
// View name: extracted

simulator lang=spectre

subckt MX2X1 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=23.8245 \
        scb=0.0263954 scc=0.00148173 m=(1)
C1 (S0 VSS) capacitor c=5.03414e-17
C2 (A VSS) capacitor c=4.19903e-17
C3 (Y VSS) capacitor c=5.41874e-17
C4 (VDD VSS) capacitor c=1.27411e-16
C5 (B VSS) capacitor c=4.10649e-17
C6 (S0b VSS) capacitor c=5.91851e-17
C7 (n0 VSS) capacitor c=5.95815e-17
C8 (n5 VSS) capacitor c=1.32841e-18
C9 (n6 VSS) capacitor c=2.03262e-18
C10 (\4\:B VSS) capacitor c=8.26617e-17
C11 (\3\:S0b VSS) capacitor c=5.61232e-17
C12 (\6\:S0 VSS) capacitor c=7.23692e-17
C13 (\1\:A VSS) capacitor c=7.77538e-17
C14 (\1\:S0 VSS) capacitor c=3.35608e-17
C15 (\4\:n0 VSS) capacitor c=3.45138e-17
C16 (\3\:B VSS) capacitor c=7.57168e-17
C17 (\4\:S0 VSS) capacitor c=1.00101e-16
C18 (\3\:A VSS) capacitor c=8.1486e-17
C19 (\3\:S0 VSS) capacitor c=5.84874e-17
C20 (\3\:n0 VSS) capacitor c=2.70933e-17
C21 (\1\:B VSS) capacitor c=3.11238e-17
C22 (\4\:S0b VSS) capacitor c=5.45625e-17
C23 (\2\:S0b VSS) capacitor c=5.97554e-17
C24 (\5\:S0 VSS) capacitor c=1.16203e-16
C25 (\2\:A VSS) capacitor c=9.20297e-17
C26 (\2\:S0 VSS) capacitor c=5.55754e-17
C27 (\1\:Y VSS) capacitor c=7.82357e-17
C28 (\1\:VDD VSS) capacitor c=6.15552e-17
C29 (\9\:n0 VSS) capacitor c=9.6856e-17
C30 (\6\:VDD VSS) capacitor c=4.14264e-17
C31 (\10\:S0b VSS) capacitor c=7.72939e-17
C32 (\3\:Y VSS) capacitor c=3.72244e-17
C33 (\7\:n0 VSS) capacitor c=6.64172e-17
C34 (\8\:S0b VSS) capacitor c=2.0315e-17
C35 (\2\:B VSS) capacitor c=8.07846e-17
C36 (\2\:n0 VSS) capacitor c=2.94215e-17
C37 (\4\:A VSS) capacitor c=3.12278e-17
C38 (\7\:S0 VSS) capacitor c=5.19026e-17
C39 (\8\:S0 VSS) capacitor c=7.1921e-17
C40 (\5\:S0b VSS) capacitor c=8.3814e-17
C41 (\6\:S0b VSS) capacitor c=1.2294e-16
C42 (\7\:S0b VSS) capacitor c=7.82852e-17
C43 (\5\:n0 VSS) capacitor c=3.30365e-17
C44 (\6\:n0 VSS) capacitor c=1.38174e-16
C45 (\5\:B VSS) capacitor c=7.27039e-17
C46 (\4\:VDD VSS) capacitor c=4.04361e-17
C47 (\5\:VDD VSS) capacitor c=9.42726e-18
Rk2 (\7\:S0 S0) resistor r=0.1251 c=0
Rk3 (S0 \8\:S0) resistor r=0.3191 c=0
Rk1 (A \4\:A) resistor r=0.02702 c=0
Rk12 (\2\:Y Y) resistor r=0.6143 c=0
Rk13 (Y \4\:Y) resistor r=0.04477 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.4498 c=0
Rk16 (\5\:VDD VDD) resistor r=0.1029 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1485 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2261 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.3444 c=0
Rk20 (\5\:VSS VSS) resistor r=0.1029 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.1485 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.1819 c=0
Rk11 (B \5\:B) resistor r=0.07529 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4035 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.387 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.1398 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6367 c=0
Rk8 (\5\:n0 \6\:n0) resistor r=0.1099 c=0
Rk9 (\6\:n0 \8\:n0) resistor r=0.3304 c=0
Rk10 (\6\:n0 \10\:n0) resistor r=0.7659 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=103.079 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=248.616 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=243 c=0
Rl3 (\1\:A \2\:A) resistor r=121.846 c=0
Rl4 (\2\:A \3\:A) resistor r=169.923 c=0
Rl11 (\2\:B \4\:B) resistor r=157.406 c=0
Rl10 (\2\:B \3\:B) resistor r=151.637 c=0
Rl9 (\1\:B \2\:B) resistor r=6.7128 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=35.7134 c=0
Rl5 (S0b \2\:S0b) resistor r=89.5596 c=0
Rl12 (n0 \2\:n0) resistor r=163.176 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=34.3295 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=5.9102 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (n3 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.85e-07 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=8.7e-15 ps=1.2e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=3.64e-14 ps=1.2e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.99135e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (n4 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=13.7907 \
        scb=0.0117228 scc=0.000117112 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.85e-07 sd=160n sca=12.4179 \
        scb=0.00925643 scc=8.16416e-05 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=11.7188 \
        scb=0.00807876 scc=7.57808e-05 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=1.29e-14 ps=1.59e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=11.9962 \
        scb=0.00852763 scc=7.72908e-05 m=(1)
mp5 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=5.46e-14 ps=1.59e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.93397e-07 sb=1.4e-07 sd=160n sca=18.3406 \
        scb=0.0188689 scc=0.000687762 m=(1)
ends MX2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:26:57 2012 )
// Library name: gsclib045
// Cell name: MX2X2
// View name: extracted

simulator lang=spectre

subckt MX2X2 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=15.5214 \
        scb=0.0147757 scc=0.000215748 m=(1)
C1 (S0 VSS) capacitor c=2.91092e-17
C2 (A VSS) capacitor c=5.58985e-17
C3 (Y VSS) capacitor c=2.80361e-17
C4 (VDD VSS) capacitor c=1.74236e-16
C5 (S0b VSS) capacitor c=6.69807e-17
C6 (n0 VSS) capacitor c=1.64943e-16
C7 (n5 VSS) capacitor c=5.81197e-18
C8 (n6 VSS) capacitor c=1.60173e-18
C9 (\4\:B VSS) capacitor c=6.8063e-17
C10 (\3\:S0b VSS) capacitor c=4.75274e-17
C11 (\6\:S0 VSS) capacitor c=3.98795e-17
C12 (\1\:A VSS) capacitor c=4.08451e-17
C13 (\1\:S0 VSS) capacitor c=3.14955e-17
C14 (\3\:B VSS) capacitor c=5.48489e-17
C15 (\4\:S0 VSS) capacitor c=5.95684e-17
C16 (\3\:A VSS) capacitor c=9.12679e-17
C17 (\3\:S0 VSS) capacitor c=5.51852e-17
C18 (\4\:n0 VSS) capacitor c=4.27849e-17
C19 (\1\:B VSS) capacitor c=2.36277e-17
C20 (\4\:S0b VSS) capacitor c=4.56261e-17
C21 (\5\:S0 VSS) capacitor c=8.05547e-17
C22 (\2\:S0b VSS) capacitor c=5.5911e-17
C23 (\2\:A VSS) capacitor c=7.17473e-17
C24 (\2\:S0 VSS) capacitor c=5.50919e-17
C25 (\1\:VDD VSS) capacitor c=1.07652e-16
C26 (\4\:Y VSS) capacitor c=1.01119e-16
C27 (\12\:n0 VSS) capacitor c=9.40393e-17
C28 (\10\:VDD VSS) capacitor c=3.89249e-17
C29 (\10\:S0b VSS) capacitor c=9.36025e-17
C30 (\4\:VDD VSS) capacitor c=2.54193e-17
C31 (\2\:Y VSS) capacitor c=3.02148e-17
C32 (\10\:n0 VSS) capacitor c=5.55217e-17
C33 (\8\:S0b VSS) capacitor c=2.07595e-17
C34 (\2\:B VSS) capacitor c=5.0803e-17
C35 (\4\:A VSS) capacitor c=6.08979e-17
C36 (\7\:S0 VSS) capacitor c=8.21499e-17
C37 (\8\:S0 VSS) capacitor c=7.29225e-17
C38 (\5\:S0b VSS) capacitor c=7.65749e-17
C39 (\6\:S0b VSS) capacitor c=1.2174e-16
C40 (\7\:S0b VSS) capacitor c=8.11883e-17
C41 (\5\:B VSS) capacitor c=1.23536e-16
C42 (\8\:n0 VSS) capacitor c=3.63116e-17
C43 (\9\:n0 VSS) capacitor c=1.11003e-16
C44 (\1\:Y VSS) capacitor c=5.12165e-17
C45 (\6\:VDD VSS) capacitor c=1.4654e-17
Rk3 (\8\:S0 S0) resistor r=0.02104 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.417 c=0
Rk1 (A \4\:A) resistor r=0.07467 c=0
Rk12 (Y \1\:Y) resistor r=0.111 c=0
Rk13 (\1\:Y \3\:Y) resistor r=0.1478 c=0
Rk14 (\1\:Y \5\:Y) resistor r=0.502 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.09513 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.3309 c=0
Rk19 (\7\:VDD VDD) resistor r=0.04992 c=0
Rk18 (\6\:VDD \7\:VDD) resistor r=0.1202 c=0
Rk21 (\6\:VDD \11\:VDD) resistor r=0.2093 c=0
Rk23 (\1\:VSS \5\:VSS) resistor r=0.09513 c=0
Rk24 (\5\:VSS \6\:VSS) resistor r=0.3309 c=0
Rk26 (\7\:VSS VSS) resistor r=0.04992 c=0
Rk25 (\6\:VSS \7\:VSS) resistor r=0.1202 c=0
Rk28 (\6\:VSS \11\:VSS) resistor r=0.194 c=0
Rk8 (B \5\:B) resistor r=0.006762 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4511 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3941 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09765 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.7268 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.1576 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.4052 c=0
Rk11 (\9\:n0 \13\:n0) resistor r=0.5968 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=236.093 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=41.0764 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=248.769 c=0
Rl3 (\1\:A \2\:A) resistor r=76.1559 c=0
Rl4 (\2\:A \3\:A) resistor r=210.771 c=0
Rl11 (\2\:B \4\:B) resistor r=128.56 c=0
Rl10 (\2\:B \3\:B) resistor r=178.56 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=62.9746 c=0
Rl5 (S0b \2\:S0b) resistor r=83.8482 c=0
Rl14 (n0 \4\:n0) resistor r=4.1351 c=0
Rz3 (\3\:Y \2\:Y) resistor r=75 c=0
Rz4 (\5\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz5 (\7\:VDD \4\:VDD) resistor r=37.5 c=0
Rz8 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry3 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Ry6 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\5\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry8 (\7\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\8\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn1 (n3 \3\:A \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=8.7e-15 ps=6.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=1.075e-06 sd=160n sca=7.00131 scb=0.00386446 \
        scc=3.38236e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=8.7e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn5 (\2\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.555e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.10673e-07 sb=3.45e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mp1 (n4 \1\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.977e-14 ps=7.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18e-06 sd=160n sca=11.7983 \
        scb=0.00857189 scc=7.47494e-05 m=(1)
mp2 (\12\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=9.5e-07 sd=160n sca=10.5655 \
        scb=0.0074576 scc=7.20375e-05 m=(1)
mp4 (\12\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=4.73e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.85e-07 sd=160n sca=10.707 \
        scb=0.00753257 scc=7.20801e-05 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.935e-14 ps=1.1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.5e-07 sd=160n sca=11.3858 \
        scb=0.0080918 scc=7.29969e-05 m=(1)
mp5 (\4\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.03654e-07 sb=3.45e-07 sd=160n sca=15.9948 \
        scb=0.0151656 scc=0.000454155 m=(2)
ends MX2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:27:35 2012 )
// Library name: gsclib045
// Cell name: MX2X4
// View name: extracted

simulator lang=spectre

subckt MX2X4 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=3.01e-14 ps=9.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=15.7679 \
        scb=0.0152453 scc=0.000242201 m=(1)
C1 (S0 VSS) capacitor c=1.1464e-16
C2 (A VSS) capacitor c=3.65329e-17
C3 (Y VSS) capacitor c=4.08591e-17
C4 (VDD VSS) capacitor c=1.96706e-16
C5 (B VSS) capacitor c=6.43648e-17
C6 (S0b VSS) capacitor c=4.64825e-17
C7 (n0 VSS) capacitor c=3.13989e-16
C8 (n5 VSS) capacitor c=2.39347e-18
C9 (n4 VSS) capacitor c=3.92428e-18
C10 (n6 VSS) capacitor c=3.57588e-18
C11 (\3\:B VSS) capacitor c=5.13054e-17
C12 (\3\:S0b VSS) capacitor c=4.36168e-17
C13 (\6\:S0 VSS) capacitor c=5.09658e-17
C14 (\3\:A VSS) capacitor c=5.3938e-17
C15 (\1\:S0 VSS) capacitor c=4.20603e-17
C16 (\1\:B VSS) capacitor c=7.18775e-17
C17 (\4\:S0 VSS) capacitor c=8.97059e-17
C18 (\2\:S0b VSS) capacitor c=4.30819e-17
C19 (\1\:A VSS) capacitor c=6.64737e-17
C20 (\3\:S0 VSS) capacitor c=5.51277e-17
C21 (\4\:B VSS) capacitor c=2.80304e-17
C22 (\4\:S0b VSS) capacitor c=4.73041e-17
C23 (\5\:S0 VSS) capacitor c=9.01801e-17
C24 (\2\:A VSS) capacitor c=7.04855e-17
C25 (\2\:S0 VSS) capacitor c=5.63445e-17
C26 (\1\:Y VSS) capacitor c=1.56112e-16
C27 (\16\:n0 VSS) capacitor c=8.95888e-17
C28 (\15\:VDD VSS) capacitor c=3.97207e-17
C29 (\10\:S0b VSS) capacitor c=1.03849e-16
C30 (\1\:VDD VSS) capacitor c=3.80134e-17
C31 (\18\:n0 VSS) capacitor c=6.0584e-17
C32 (\8\:S0b VSS) capacitor c=1.32496e-17
C33 (\2\:B VSS) capacitor c=4.69763e-17
C34 (\4\:A VSS) capacitor c=8.18438e-17
C35 (\8\:S0 VSS) capacitor c=9.47144e-17
C36 (\5\:S0b VSS) capacitor c=6.51765e-17
C37 (\6\:S0b VSS) capacitor c=9.58619e-17
C38 (\7\:S0b VSS) capacitor c=9.91965e-17
C39 (\5\:B VSS) capacitor c=5.32193e-17
C40 (\14\:n0 VSS) capacitor c=5.26735e-17
C41 (\15\:n0 VSS) capacitor c=1.09488e-16
C42 (\4\:Y VSS) capacitor c=8.53662e-17
C43 (\3\:VDD VSS) capacitor c=1.79739e-16
C44 (\8\:VDD VSS) capacitor c=1.87878e-17
Rk4 (\7\:S0 S0) resistor r=0.002995 c=0
Rk5 (S0 \8\:S0) resistor r=0.6145 c=0
Rk3 (\4\:A A) resistor r=0.005989 c=0
Rk15 (\1\:Y Y) resistor r=0.001906 c=0
Rk16 (Y \4\:Y) resistor r=0.3586 c=0
Rk20 (\2\:VDD \3\:VDD) resistor r=0.06496 c=0
Rk24 (\3\:VDD \7\:VDD) resistor r=0.1853 c=0
Rk26 (\8\:VDD VDD) resistor r=0.1765 c=0
Rk25 (\7\:VDD \8\:VDD) resistor r=0.2219 c=0
Rk30 (\8\:VDD \16\:VDD) resistor r=0.1185 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.06496 c=0
Rk36 (\3\:VSS \8\:VSS) resistor r=0.3206 c=0
Rk38 (\9\:VSS VSS) resistor r=0.185 c=0
Rk37 (\8\:VSS \9\:VSS) resistor r=0.06496 c=0
Rk42 (\9\:VSS \17\:VSS) resistor r=0.1864 c=0
Rk10 (\5\:B B) resistor r=0.06791 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.3117 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.4883 c=0
Rk8 (\7\:S0b \9\:S0b) resistor r=0.05422 c=0
Rk9 (\7\:S0b \11\:S0b) resistor r=0.7841 c=0
Rk11 (\14\:n0 \15\:n0) resistor r=0.2366 c=0
Rk12 (\15\:n0 \17\:n0) resistor r=0.5687 c=0
Rk13 (\15\:n0 \19\:n0) resistor r=0.348 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=266.862 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=73.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=212.23 c=0
Rl4 (\2\:A \3\:A) resistor r=52.1808 c=0
Rl3 (\1\:A \2\:A) resistor r=206.148 c=0
Rl10 (\2\:B \3\:B) resistor r=78.3537 c=0
Rl9 (\1\:B \2\:B) resistor r=187.375 c=0
Rl11 (\2\:B \4\:B) resistor r=5.7469 c=0
Rl5 (S0b \2\:S0b) resistor r=60.6943 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=41.3047 c=0
Rz5 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz7 (\7\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz11 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry8 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry9 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\3\:VSS \1\:VSS) resistor r=12.4 c=0
Ry12 (\8\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\17\:n0 \16\:n0) resistor r=62 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\4\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (S0b \6\:S0b) resistor r=45 c=0
Rx7 (\14\:n0 n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (n3 \1\:A \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=3.69e-14 ps=7.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=1.635e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn2 (\18\:n0 \2\:S0b n3 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.28e-14 ps=7.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3122e-07 sb=1.41e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn4 (\18\:n0 \4\:S0 n5 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=3.28e-14 ps=6.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3622e-07 sb=1.205e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn3 (n5 \1\:B \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.46e-14 ps=8.4e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0122e-07 sb=1.04e-06 sd=160n sca=7.55029 \
        scb=0.00489727 scc=6.6688e-05 m=(1)
mn5 (\4\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.948e-14 ad=5.2e-14 ps=8.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93365e-07 sb=8.35e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(4)
mp1 (n4 \3\:A \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=4.185e-14 ps=9.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.80323e-07 sb=1.65e-06 sd=160n sca=12.241 \
        scb=0.00942952 scc=0.00011999 m=(1)
mp2 (\16\:n0 \6\:S0 n4 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60323e-07 sb=1.47e-06 sd=160n sca=11.1885 \
        scb=0.00841332 scc=0.000117337 m=(1)
mp4 (\16\:n0 \3\:S0b n6 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65323e-07 sb=1.265e-06 sd=160n sca=10.6105 \
        scb=0.00818197 scc=0.000117242 m=(1)
mp3 (n6 \3\:B \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.65e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.60323e-07 sb=1.07e-06 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp5 (\1\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.238e-14 ad=7.8e-14 ps=1.105e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99359e-07 sb=8.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(4)
ends MX2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:28:12 2012 )
// Library name: gsclib045
// Cell name: MX2X6
// View name: extracted

simulator lang=spectre

subckt MX2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \3\:S0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=4.085e-14 ps=1.24e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=16.964 scb=0.0172681 \
        scc=0.000351906 m=(1)
C1 (S0 VSS) capacitor c=5.94555e-17
C2 (A VSS) capacitor c=4.15369e-17
C3 (Y VSS) capacitor c=5.27604e-16
C4 (VDD VSS) capacitor c=1.48814e-16
C5 (B VSS) capacitor c=1.07512e-16
C6 (S0b VSS) capacitor c=6.79041e-17
C7 (n0 VSS) capacitor c=3.22079e-16
C8 (n5 VSS) capacitor c=4.72889e-18
C9 (n4 VSS) capacitor c=4.33011e-18
C10 (n6 VSS) capacitor c=2.50176e-18
C11 (\1\:B VSS) capacitor c=4.8996e-17
C12 (\3\:S0b VSS) capacitor c=4.28647e-17
C13 (\6\:S0 VSS) capacitor c=4.14711e-17
C14 (\1\:A VSS) capacitor c=5.57812e-17
C15 (\3\:S0 VSS) capacitor c=3.12704e-17
C16 (\3\:B VSS) capacitor c=5.29058e-17
C17 (\4\:S0 VSS) capacitor c=6.25961e-17
C18 (\3\:A VSS) capacitor c=8.37484e-17
C19 (\1\:S0 VSS) capacitor c=4.54596e-17
C20 (\2\:B VSS) capacitor c=4.3285e-17
C21 (\4\:S0b VSS) capacitor c=4.30341e-17
C22 (\5\:S0 VSS) capacitor c=9.06394e-17
C23 (\2\:S0b VSS) capacitor c=5.57777e-17
C24 (\2\:A VSS) capacitor c=6.14835e-17
C25 (\2\:S0 VSS) capacitor c=4.37726e-17
C26 (\1\:VDD VSS) capacitor c=2.66516e-16
C27 (\23\:n0 VSS) capacitor c=9.79654e-17
C28 (\11\:VDD VSS) capacitor c=3.12776e-17
C29 (\8\:S0b VSS) capacitor c=7.34478e-17
C30 (\4\:VDD VSS) capacitor c=2.95793e-17
C31 (\21\:n0 VSS) capacitor c=4.24567e-17
C32 (\10\:S0b VSS) capacitor c=1.21011e-17
C33 (\4\:A VSS) capacitor c=7.6583e-17
C34 (\7\:S0 VSS) capacitor c=8.73056e-17
C35 (\8\:S0 VSS) capacitor c=3.64648e-17
C36 (\5\:S0b VSS) capacitor c=7.24098e-17
C37 (\6\:S0b VSS) capacitor c=8.59123e-17
C38 (\7\:S0b VSS) capacitor c=7.73268e-17
C39 (\19\:n0 VSS) capacitor c=6.19494e-17
C40 (\20\:n0 VSS) capacitor c=1.10471e-16
C41 (\10\:VDD VSS) capacitor c=1.96916e-17
Rk2 (\7\:S0 S0) resistor r=0.424 c=0
Rk3 (S0 \8\:S0) resistor r=0.03791 c=0
Rk1 (A \4\:A) resistor r=0.03583 c=0
Rk25 (\1\:VDD \10\:VDD) resistor r=0.5496 c=0
Rk26 (\10\:VDD \12\:VDD) resistor r=0.231 c=0
Rk28 (\13\:VDD VDD) resistor r=0.04991 c=0
Rk27 (\10\:VDD \13\:VDD) resistor r=0.1026 c=0
Rk32 (\1\:VSS \7\:VSS) resistor r=0.3333 c=0
Rk34 (\8\:VSS VSS) resistor r=0.2278 c=0
Rk33 (\7\:VSS \8\:VSS) resistor r=0.07253 c=0
Rk37 (\8\:VSS \14\:VSS) resistor r=0.1775 c=0
Rk8 (B \4\:B) resistor r=0.003002 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.337 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5013 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.6219 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.05463 c=0
Rk9 (\19\:n0 \20\:n0) resistor r=0.3487 c=0
Rk10 (\20\:n0 \22\:n0) resistor r=0.3306 c=0
Rk11 (\20\:n0 \24\:n0) resistor r=0.5496 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=29.5379 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=229.104 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=66.4835 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=194.231 c=0
Rl3 (\1\:A \2\:A) resistor r=77.6148 c=0
Rl4 (\2\:A \3\:A) resistor r=144.923 c=0
Rl9 (\1\:B \2\:B) resistor r=73.7687 c=0
Rl10 (\2\:B \3\:B) resistor r=148.769 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=55.2823 c=0
Rl5 (S0b \2\:S0b) resistor r=68.4636 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz7 (\13\:VDD \4\:VDD) resistor r=37.5 c=0
Rz11 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\22\:n0 \21\:n0) resistor r=75 c=0
Ry9 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry11 (\7\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\24\:n0 \23\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\19\:n0 n0) resistor r=45 c=0
mn0 (\10\:S0b \1\:S0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.79977 scb=0.00524357 \
        scc=6.87485e-05 m=(1)
mn1 (n3 \3\:A \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52195e-07 sb=1.84e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn2 (\21\:n0 S0b n3 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 as=1.23e-14 \
        ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.57195e-07 sb=1.735e-06 sd=160n sca=7.24218 scb=0.00437101 \
        scc=5.12051e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.74e-14 ad=5.125e-14 ps=9.8e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57195e-07 sb=1.235e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn4 (\21\:n0 \4\:S0 n5 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.28e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.62195e-07 sb=1.53e-06 sd=160n sca=7.24218 \
        scb=0.00437101 scc=5.12051e-05 m=(1)
mn5 (Y n0 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.916e-14 \
        ad=5.456e-14 ps=9.48e-07 pd=9.72e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.15645e-07 sb=1.01e-06 sd=160n sca=8.89324 scb=0.00718666 \
        scc=0.00021338 m=(5)
mp1 (n4 \1\:A \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.615e-14 ad=3.875e-14 ps=1.24e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08629e-07 sb=1.865e-06 sd=160n sca=12.5498 \
        scb=0.0102845 scc=0.000266006 m=(1)
mp2 (\23\:n0 \6\:S0 n4 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=6.2e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.78629e-07 sb=1.695e-06 sd=160n sca=11.8758 \
        scb=0.0098568 scc=0.000265591 m=(1)
mp4 (\23\:n0 \3\:S0b n6 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=6.2e-14 ps=9.1e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=1.45e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01363e-06 sb=1.26e-06 sd=160n sca=11.5623 \
        scb=0.0097692 scc=0.000265575 m=(1)
mp5 (Y n0 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.917e-14 \
        ad=7.332e-14 ps=1.298e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.00479e-07 sb=9.6e-07 sd=160n sca=21.0172 scb=0.0163249 \
        scc=0.00202715 m=(5)
ends MX2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 15:28:49 2012 )
// Library name: gsclib045
// Cell name: MX2X8
// View name: extracted

simulator lang=spectre

subckt MX2X8 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.837e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.0095 scb=0.0106782 \
        scc=0.000192315 m=(1)
C1 (S0 VSS) capacitor c=5.04731e-17
C2 (Y VSS) capacitor c=4.66661e-16
C3 (VDD VSS) capacitor c=2.10059e-16
C4 (B VSS) capacitor c=3.45381e-17
C5 (S0b VSS) capacitor c=3.58743e-17
C6 (n0 VSS) capacitor c=3.45918e-16
C7 (n5 VSS) capacitor c=3.99956e-18
C8 (n4 VSS) capacitor c=5.92273e-18
C9 (n6 VSS) capacitor c=4.68461e-18
C10 (\1\:B VSS) capacitor c=3.68376e-17
C11 (\6\:S0 VSS) capacitor c=4.37212e-17
C12 (\1\:A VSS) capacitor c=6.20872e-17
C13 (\1\:S0 VSS) capacitor c=3.55211e-17
C14 (\3\:B VSS) capacitor c=4.44063e-17
C15 (\4\:S0 VSS) capacitor c=7.05579e-17
C16 (\3\:S0b VSS) capacitor c=3.01833e-17
C17 (\3\:A VSS) capacitor c=4.20689e-17
C18 (\3\:S0 VSS) capacitor c=5.0664e-17
C19 (\2\:B VSS) capacitor c=3.8918e-17
C20 (\2\:S0b VSS) capacitor c=3.89366e-17
C21 (\4\:S0b VSS) capacitor c=4.42893e-17
C22 (\5\:S0 VSS) capacitor c=8.2789e-17
C23 (\2\:A VSS) capacitor c=4.87445e-17
C24 (\2\:S0 VSS) capacitor c=3.80996e-17
C25 (\1\:VDD VSS) capacitor c=2.96065e-16
C26 (\26\:n0 VSS) capacitor c=8.32103e-17
C27 (\17\:VDD VSS) capacitor c=3.96936e-17
C28 (\8\:S0b VSS) capacitor c=9.63338e-17
C29 (\4\:VDD VSS) capacitor c=5.70676e-17
C30 (\23\:n0 VSS) capacitor c=4.38947e-17
C31 (\5\:S0b VSS) capacitor c=1.19487e-17
C32 (\4\:A VSS) capacitor c=4.64474e-17
C33 (\6\:A VSS) capacitor c=6.82596e-17
C34 (\7\:S0 VSS) capacitor c=9.96392e-17
C35 (\8\:S0 VSS) capacitor c=8.68902e-17
C36 (\7\:S0b VSS) capacitor c=1.06645e-16
C37 (\10\:S0b VSS) capacitor c=7.66225e-17
C38 (\11\:S0b VSS) capacitor c=5.47622e-17
C39 (\4\:B VSS) capacitor c=5.91086e-17
C40 (\25\:n0 VSS) capacitor c=1.13858e-16
C41 (\28\:n0 VSS) capacitor c=6.14614e-17
C42 (\9\:VDD VSS) capacitor c=1.71013e-18
Rk4 (S0 \7\:S0) resistor r=0.07534 c=0
Rk5 (\7\:S0 \8\:S0) resistor r=0.6924 c=0
Rk1 (\4\:A \5\:A) resistor r=0.003456 c=0
Rk2 (A \6\:A) resistor r=0.003369 c=0
Rk3 (\4\:A \6\:A) resistor r=0.1037 c=0
Rk29 (\1\:VDD \8\:VDD) resistor r=0.2953 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.2828 c=0
Rk32 (\10\:VDD VDD) resistor r=0.09993 c=0
Rk31 (\9\:VDD \10\:VDD) resistor r=0.1676 c=0
Rk36 (\9\:VDD \18\:VDD) resistor r=0.1979 c=0
Rk41 (\1\:VSS \8\:VSS) resistor r=0.403 c=0
Rk43 (\9\:VSS VSS) resistor r=0.2826 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.06743 c=0
Rk47 (\9\:VSS \17\:VSS) resistor r=0.2422 c=0
Rk10 (B \4\:B) resistor r=0.1626 c=0
Rk6 (\6\:S0b \7\:S0b) resistor r=0.05402 c=0
Rk7 (\7\:S0b \9\:S0b) resistor r=0.7964 c=0
Rk8 (\7\:S0b \10\:S0b) resistor r=0.5536 c=0
Rk9 (\10\:S0b \11\:S0b) resistor r=0.2331 c=0
Rk11 (\24\:n0 \25\:n0) resistor r=0.3054 c=0
Rk12 (\25\:n0 \27\:n0) resistor r=0.5835 c=0
Rk13 (\25\:n0 \28\:n0) resistor r=0.3686 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=74.2328 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=169.923 c=0
Rl3 (\1\:A \2\:A) resistor r=133.384 c=0
Rl4 (\2\:A \3\:A) resistor r=66.0764 c=0
Rl9 (\1\:B \2\:B) resistor r=81.461 c=0
Rl10 (\2\:B \3\:B) resistor r=117.999 c=0
Rl5 (S0b \2\:S0b) resistor r=33.8482 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=66.8207 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz8 (\8\:VDD \4\:VDD) resistor r=12.5 c=0
Rz9 (\10\:VDD \4\:VDD) resistor r=25 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\5\:S0b \6\:S0b) resistor r=75 c=0
Rz2 (\24\:n0 \23\:n0) resistor r=75 c=0
Ry11 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry13 (\8\:VSS \4\:VSS) resistor r=7.75 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\27\:n0 \26\:n0) resistor r=31 c=0
Rx2 (\2\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\5\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\4\:S0b \10\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \11\:S0b) resistor r=45 c=0
Rx7 (\28\:n0 n0) resistor r=45 c=0
mn0 (\5\:S0b \3\:S0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.1906 scb=0.0108717 \
        scc=0.000387468 m=(1)
mn1 (n3 \3\:A \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=4.817e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.0622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn2 (\23\:n0 \3\:S0b n3 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.715e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8622e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn4 (\23\:n0 \4\:S0 n5 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=4.715e-14 ps=7.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6122e-07 sb=2e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.357e-14 ad=3.382e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07122e-06 sb=1.8e-06 sd=160n sca=10.1075 \
        scb=0.00913344 scc=0.000289639 m=(1)
mn5 (Y n0 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=5.097e-14 \
        ad=5.226e-14 ps=9.5429e-07 pd=9.4429e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.02508e-06 sb=1.44e-06 sd=160n sca=13.5379 scb=0.0132414 \
        scc=0.000904444 m=(7)
mp1 (n4 \1\:A \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=5.735e-14 ps=1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61935e-07 sb=2e-06 sd=160n sca=11.3406 \
        scb=0.00879396 scc=0.000154509 m=(1)
mp2 (\26\:n0 \6\:S0 n4 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.425e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.91935e-07 sb=2e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp4 (\26\:n0 S0b n6 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 as=8.37e-14 \
        ad=5.425e-14 ps=1.16e-06 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.11935e-07 sb=2e-06 sd=160n sca=10.8361 scb=0.00861907 \
        scc=0.000154455 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=8.37e-14 ps=1.52e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12694e-06 sb=1.8e-06 sd=160n sca=10.8361 \
        scb=0.00861907 scc=0.000154455 m=(1)
mp5 (Y n0 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.691e-14 \
        ad=7.883e-14 ps=1.25429e-06 pd=1.24429e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.06618e-06 sb=1.44e-06 sd=160n sca=14.4925 scb=0.0129103 \
        scc=0.000843152 m=(7)
ends MX2X8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:11:47 2012 )
// Library name: gsclib045
// Cell name: MX2XL
// View name: extracted

simulator lang=spectre

subckt MX2XL A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
C1 (Y VSS) capacitor c=5.9833e-17
C2 (S0 VSS) capacitor c=4.22417e-17
C3 (B VSS) capacitor c=4.11387e-17
C4 (VDD VSS) capacitor c=1.37194e-16
C5 (S0b VSS) capacitor c=4.98589e-17
C6 (n0 VSS) capacitor c=2.85034e-17
C7 (n5 VSS) capacitor c=2.31926e-18
C8 (n6 VSS) capacitor c=3.29693e-18
C9 (\4\:B VSS) capacitor c=8.00686e-17
C10 (\3\:S0b VSS) capacitor c=4.32757e-17
C11 (\6\:S0 VSS) capacitor c=5.76235e-17
C12 (\1\:A VSS) capacitor c=7.14246e-17
C13 (\1\:S0 VSS) capacitor c=3.02709e-17
C14 (\4\:n0 VSS) capacitor c=6.16692e-17
C15 (\3\:B VSS) capacitor c=3.56018e-17
C16 (\4\:S0 VSS) capacitor c=6.19987e-17
C17 (\3\:A VSS) capacitor c=5.96314e-17
C18 (\3\:S0 VSS) capacitor c=4.88372e-17
C19 (\3\:n0 VSS) capacitor c=2.6889e-17
C20 (\1\:B VSS) capacitor c=2.7807e-17
C21 (\4\:S0b VSS) capacitor c=4.70346e-17
C22 (\2\:S0b VSS) capacitor c=3.92753e-17
C23 (\5\:S0 VSS) capacitor c=8.72706e-17
C24 (\2\:A VSS) capacitor c=6.89695e-17
C25 (\2\:S0 VSS) capacitor c=4.44761e-17
C26 (\1\:Y VSS) capacitor c=7.24625e-17
C27 (\6\:VDD VSS) capacitor c=3.64852e-17
C28 (\9\:n0 VSS) capacitor c=2.75004e-17
C29 (\8\:VDD VSS) capacitor c=3.8398e-17
C30 (\10\:S0b VSS) capacitor c=7.1918e-17
C31 (\1\:VDD VSS) capacitor c=3.49665e-17
C32 (\3\:Y VSS) capacitor c=1.96508e-17
C33 (\7\:n0 VSS) capacitor c=1.2058e-16
C34 (\8\:S0b VSS) capacitor c=1.93394e-17
C35 (\2\:B VSS) capacitor c=4.36703e-17
C36 (\2\:n0 VSS) capacitor c=2.87131e-17
C37 (\4\:A VSS) capacitor c=4.74817e-17
C38 (\6\:A VSS) capacitor c=4.10748e-17
C39 (\7\:S0 VSS) capacitor c=4.09718e-17
C40 (\8\:S0 VSS) capacitor c=7.11248e-17
C41 (\5\:S0b VSS) capacitor c=9.07773e-17
C42 (\6\:S0b VSS) capacitor c=1.10708e-16
C43 (\7\:S0b VSS) capacitor c=7.54767e-17
C44 (\5\:n0 VSS) capacitor c=4.46278e-17
C45 (\6\:n0 VSS) capacitor c=9.89288e-17
C46 (\5\:B VSS) capacitor c=4.78832e-17
C47 (\3\:VDD VSS) capacitor c=6.79654e-18
C48 (\5\:VDD VSS) capacitor c=3.14805e-18
Rk14 (\2\:Y Y) resistor r=0.5118 c=0
Rk15 (Y \4\:Y) resistor r=0.05349 c=0
Rk4 (\7\:S0 S0) resistor r=0.1314 c=0
Rk5 (S0 \8\:S0) resistor r=0.1615 c=0
Rk1 (\4\:A \5\:A) resistor r=0.01269 c=0
Rk2 (A \6\:A) resistor r=0.01254 c=0
Rk3 (\4\:A \6\:A) resistor r=0.03203 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.1052 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.2458 c=0
Rk25 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk24 (\4\:VSS \5\:VSS) resistor r=0.09771 c=0
Rk26 (\3\:VSS \7\:VSS) resistor r=0.2761 c=0
Rk27 (\5\:VSS \9\:VSS) resistor r=0.278 c=0
Rk13 (B \5\:B) resistor r=0.07283 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.1052 c=0
Rk17 (\3\:VDD \4\:VDD) resistor r=0.2458 c=0
Rk19 (\5\:VDD VDD) resistor r=0.1025 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.09771 c=0
Rk20 (\3\:VDD \7\:VDD) resistor r=0.2679 c=0
Rk21 (\5\:VDD \9\:VDD) resistor r=0.2712 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.3322 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.3175 c=0
Rk8 (\7\:S0b \9\:S0b) resistor r=0.1206 c=0
Rk9 (\7\:S0b \11\:S0b) resistor r=0.5113 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.1792 c=0
Rk11 (\6\:n0 \8\:n0) resistor r=0.6176 c=0
Rk12 (\6\:n0 \10\:n0) resistor r=0.2318 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=79.9442 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=169.15 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=26.098 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=176.098 c=0
Rl3 (\1\:A \2\:A) resistor r=129.538 c=0
Rl4 (\2\:A \3\:A) resistor r=79.5379 c=0
Rl11 (\2\:B \4\:B) resistor r=174.714 c=0
Rl10 (\2\:B \3\:B) resistor r=51.6372 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=42.9995 c=0
Rl5 (S0b \2\:S0b) resistor r=29.5379 c=0
Rl12 (n0 \2\:n0) resistor r=35.0798 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=190.849 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=0.8823 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry5 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (n3 \3\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.42e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=9.42e-15 \
        ad=2.32e-14 ps=4.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=7.15e-07 sd=160n sca=10.2779 scb=0.00944477 \
        scc=0.000275883 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=2.32e-14 ps=5.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=5.1e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn3 (n5 \3\:B \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn5 (\3\:Y \4\:n0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp1 (n4 \1\:A \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.613e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=3.548e-14 ps=5.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.05e-07 sd=160n sca=13.1421 \
        scb=0.0105991 scc=0.000178477 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=3.548e-14 ps=6.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.95e-07 sd=160n sca=12.581 \
        scb=0.00966143 scc=0.000174195 m=(1)
mp3 (n6 \4\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.258e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=13.2602 \
        scb=0.0108078 scc=0.000179977 m=(1)
mp5 (\1\:Y n0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=17.479 \
        scb=0.0182451 scc=0.000415696 m=(1)
ends MX2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:30:04 2012 )
// Library name: gsclib045
// Cell name: MX3X1
// View name: extracted

simulator lang=spectre

subckt MX3X1 A B C S0 S1 VDD VSS Y
mp9 (\1\:Y n1 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.46e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.53462e-07 sd=160n sca=27.0845 \
        scb=0.0288142 scc=0.0021178 m=(1)
C1 (A VSS) capacitor c=1.31729e-16
C2 (C VSS) capacitor c=3.07637e-17
C3 (B VSS) capacitor c=3.9497e-17
C4 (VDD VSS) capacitor c=2.06179e-16
C5 (S1 VSS) capacitor c=4.58299e-17
C6 (Y VSS) capacitor c=7.83678e-17
C7 (S0 VSS) capacitor c=4.72649e-17
C8 (n1 VSS) capacitor c=4.90282e-17
C9 (n0 VSS) capacitor c=9.75866e-17
C10 (S1b VSS) capacitor c=4.99978e-17
C11 (net234 VSS) capacitor c=3.56205e-18
C12 (S0b VSS) capacitor c=3.92161e-17
C13 (\6\:S0 VSS) capacitor c=2.66297e-17
C14 (\3\:A VSS) capacitor c=6.38049e-17
C15 (\1\:S0 VSS) capacitor c=4.70741e-17
C16 (\3\:B VSS) capacitor c=6.10399e-17
C17 (\6\:S1 VSS) capacitor c=4.65371e-17
C18 (\7\:S1 VSS) capacitor c=3.35304e-17
C19 (\2\:S1b VSS) capacitor c=6.87592e-17
C20 (\1\:C VSS) capacitor c=5.45086e-17
C21 (\4\:S0 VSS) capacitor c=4.70293e-17
C22 (\1\:A VSS) capacitor c=6.51343e-17
C23 (\3\:S0b VSS) capacitor c=6.47447e-17
C24 (\3\:S0 VSS) capacitor c=6.73806e-17
C25 (\1\:B VSS) capacitor c=3.7181e-17
C26 (\1\:S1 VSS) capacitor c=2.44112e-17
C27 (\3\:S1b VSS) capacitor c=2.25718e-17
C28 (\5\:S1 VSS) capacitor c=9.5109e-17
C29 (\3\:C VSS) capacitor c=7.61318e-17
C30 (\3\:n1 VSS) capacitor c=3.25009e-17
C31 (\5\:S0 VSS) capacitor c=4.35454e-17
C32 (\2\:A VSS) capacitor c=6.84229e-17
C33 (\4\:S0b VSS) capacitor c=5.15292e-17
C34 (\2\:S0 VSS) capacitor c=7.04271e-17
C35 (\2\:S0b VSS) capacitor c=4.54833e-17
C36 (\2\:B VSS) capacitor c=5.67563e-17
C37 (\3\:S1 VSS) capacitor c=2.30126e-17
C38 (\4\:S1b VSS) capacitor c=4.75607e-17
C39 (\2\:C VSS) capacitor c=6.10438e-17
C40 (\2\:n1 VSS) capacitor c=3.01498e-17
C41 (\10\:S0b VSS) capacitor c=7.66193e-17
C42 (\9\:VDD VSS) capacitor c=3.06203e-17
C43 (\6\:n0 VSS) capacitor c=4.70132e-17
C44 (\11\:VDD VSS) capacitor c=4.18603e-17
C45 (\10\:S1b VSS) capacitor c=9.4925e-17
C46 (\4\:n0 VSS) capacitor c=1.35206e-16
C47 (\8\:n1 VSS) capacitor c=7.89351e-17
C48 (\13\:VDD VSS) capacitor c=3.53007e-17
C49 (\1\:Y VSS) capacitor c=5.00931e-17
C50 (\1\:VDD VSS) capacitor c=1.04768e-16
C51 (\5\:S0b VSS) capacitor c=2.24314e-17
C52 (\5\:S1b VSS) capacitor c=1.32597e-16
C53 (\8\:n0 VSS) capacitor c=1.05816e-16
C54 (\6\:n1 VSS) capacitor c=3.24577e-17
C55 (\2\:S1 VSS) capacitor c=5.00316e-17
C56 (\4\:S1 VSS) capacitor c=7.88052e-17
C57 (\4\:C VSS) capacitor c=6.68197e-17
C58 (\4\:n1 VSS) capacitor c=7.322e-17
C59 (\5\:n1 VSS) capacitor c=6.69931e-17
C60 (\8\:S1 VSS) capacitor c=7.0349e-17
C61 (\7\:S1b VSS) capacitor c=1.39556e-16
C62 (\9\:S1b VSS) capacitor c=1.17815e-16
C63 (\4\:B VSS) capacitor c=7.33618e-17
C64 (\3\:n0 VSS) capacitor c=1.28567e-16
C65 (\7\:S0 VSS) capacitor c=4.62691e-17
C66 (\8\:S0 VSS) capacitor c=5.78135e-17
C67 (\7\:S0b VSS) capacitor c=8.28786e-17
C68 (\8\:S0b VSS) capacitor c=1.0948e-16
C69 (\9\:S0b VSS) capacitor c=6.44766e-17
Rk17 (\4\:A A) resistor r=0.004385 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.1252 c=0
Rk25 (\3\:VSS \4\:VSS) resistor r=0.3883 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.238 c=0
Rk28 (\6\:VSS VSS) resistor r=0.1174 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.4336 c=0
Rk29 (\3\:VSS \8\:VSS) resistor r=0.2699 c=0
Rk30 (\4\:VSS \10\:VSS) resistor r=0.2948 c=0
Rk31 (\6\:VSS \12\:VSS) resistor r=0.1993 c=0
Rk3 (C \4\:C) resistor r=0.114 c=0
Rk12 (\4\:B B) resistor r=0.09819 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.1578 c=0
Rk33 (\3\:VDD \4\:VDD) resistor r=0.1929 c=0
Rk34 (\4\:VDD \5\:VDD) resistor r=0.2004 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.3007 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.3182 c=0
Rk38 (\8\:VDD VDD) resistor r=0.0499 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.08255 c=0
Rk39 (\3\:VDD \10\:VDD) resistor r=0.254 c=0
Rk40 (\5\:VDD \12\:VDD) resistor r=0.2584 c=0
Rk41 (\7\:VDD \14\:VDD) resistor r=0.2684 c=0
Rk7 (S1 \8\:S1) resistor r=0.111 c=0
Rk1 (\2\:Y Y) resistor r=0.5031 c=0
Rk2 (Y \4\:Y) resistor r=0.01452 c=0
Rk18 (S0 \7\:S0) resistor r=0.08731 c=0
Rk19 (\7\:S0 \8\:S0) resistor r=0.2524 c=0
Rk4 (\4\:n1 \5\:n1) resistor r=0.3394 c=0
Rk5 (\5\:n1 \7\:n1) resistor r=0.09065 c=0
Rk6 (\5\:n1 \9\:n1) resistor r=0.4248 c=0
Rk13 (\2\:n0 \3\:n0) resistor r=0.7164 c=0
Rk14 (\3\:n0 \5\:n0) resistor r=0.5029 c=0
Rk15 (\3\:n0 \7\:n0) resistor r=0.2271 c=0
Rk16 (\5\:n0 \9\:n0) resistor r=0.6093 c=0
Rk8 (\6\:S1b \7\:S1b) resistor r=0.8529 c=0
Rk9 (\7\:S1b \8\:S1b) resistor r=0.2218 c=0
Rk10 (\8\:S1b \9\:S1b) resistor r=0.01531 c=0
Rk11 (\8\:S1b \11\:S1b) resistor r=0.7038 c=0
Rk20 (\6\:S0b \7\:S0b) resistor r=0.2634 c=0
Rk21 (\7\:S0b \8\:S0b) resistor r=0.486 c=0
Rk22 (\8\:S0b \9\:S0b) resistor r=0.3832 c=0
Rk23 (\7\:S0b \11\:S0b) resistor r=0.5822 c=0
Rl20 (\2\:A \3\:A) resistor r=101.718 c=0
Rl19 (\1\:A \2\:A) resistor r=109.879 c=0
Rl3 (\1\:C \2\:C) resistor r=24.2328 c=0
Rl4 (\2\:C \3\:C) resistor r=147.31 c=0
Rl14 (\2\:B \3\:B) resistor r=128.207 c=0
Rl13 (\1\:B \2\:B) resistor r=111.516 c=0
Rl11 (\2\:S1 \6\:S1) resistor r=170.387 c=0
Rl7 (\1\:S1 \2\:S1) resistor r=75.7223 c=0
Rl8 (\2\:S1 \3\:S1) resistor r=59.9887 c=0
Rl12 (\4\:S1 \7\:S1) resistor r=91.9892 c=0
Rl10 (\4\:S1 \5\:S1) resistor r=234.593 c=0
Rl9 (\3\:S1 \4\:S1) resistor r=94.1561 c=0
Rl22 (\5\:S0 \6\:S0) resistor r=29.9451 c=0
Rl21 (\4\:S0 \5\:S0) resistor r=184.615 c=0
Rl16 (\1\:S0 \2\:S0) resistor r=34.6154 c=0
Rl17 (\2\:S0 \3\:S0) resistor r=183.738 c=0
Rl1 (n1 \2\:n1) resistor r=108.848 c=0
Rl2 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl5 (S1b \2\:S1b) resistor r=105.282 c=0
Rl6 (\3\:S1b \4\:S1b) resistor r=51.2042 c=0
Rl18 (\3\:S0b \4\:S0b) resistor r=32.5403 c=0
Rl15 (S0b \2\:S0b) resistor r=74.2328 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz11 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz12 (\1\:VDD \6\:VDD) resistor r=12.5 c=0
Rz13 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz6 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry8 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry6 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx7 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\3\:S1 \8\:S1) resistor r=45 c=0
Rx8 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx9 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\4\:S1b \7\:S1b) resistor r=45 c=0
Rx5 (S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\3\:Y \3\:n1 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=3.64e-14 ps=9.6e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.42885e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn7 (net245 \3\:C \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.4e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn8 (\6\:n1 \5\:S1 net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.857e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.2e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn6 (\6\:n1 \3\:S1b \8\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.857e-14 ps=5.7e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn1 (\5\:S1b \1\:S1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (net234 \1\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.552e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.552e-14 ad=2.32e-14 ps=7.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=6.55e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.5e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (net229 \1\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\5\:S0b \4\:S0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp7 (net202 \1\:C \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=1.29e-14 ps=1.22e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=26.7541 \
        scb=0.0241209 scc=0.00281164 m=(1)
mp8 (\8\:n1 \2\:S1b net202 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.095e-14 ps=5.5e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.2e-07 sd=160n sca=25.94 scb=0.0231463 \
        scc=0.00280756 m=(1)
mp6 (\4\:n0 \7\:S1 \8\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.095e-14 ad=3.118e-14 ps=1.09e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.45e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp1 (\10\:S1b \6\:S1 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.17e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp4 (net190 \3\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.65e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp5 (\6\:n0 S0b net190 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=4.515e-14 ps=7.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.55e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp3 (\6\:n0 \1\:S0 net189 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.515e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=5e-07 sd=160n sca=11.0172 scb=0.0085015 \
        scc=0.000138145 m=(1)
mp2 (net189 \3\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=1.505e-14 ps=8.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=3.85e-07 sd=160n sca=11.4166 \
        scb=0.00871068 scc=0.00013827 m=(1)
mp0 (\10\:S0b \6\:S0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=1.4e-07 sd=160n sca=13.294 \
        scb=0.0109881 scc=0.000151098 m=(1)
ends MX3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:30:42 2012 )
// Library name: gsclib045
// Cell name: MX3X2
// View name: extracted

simulator lang=spectre

subckt MX3X2 A B C S0 S1 VDD VSS Y
mp9 (\1\:Y n1 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.594e-14 ad=9.36e-14 ps=1.105e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.26026e-07 sd=160n sca=18.9913 \
        scb=0.020688 scc=0.00060344 m=(2)
C1 (A VSS) capacitor c=2.90199e-17
C2 (C VSS) capacitor c=7.32851e-17
C3 (B VSS) capacitor c=6.54308e-17
C4 (VDD VSS) capacitor c=2.29511e-16
C5 (S1 VSS) capacitor c=6.21172e-17
C6 (Y VSS) capacitor c=1.43573e-17
C7 (n1 VSS) capacitor c=1.76937e-16
C8 (net245 VSS) capacitor c=4.24668e-18
C9 (n0 VSS) capacitor c=1.07662e-16
C10 (S1b VSS) capacitor c=5.31768e-17
C11 (net234 VSS) capacitor c=7.85343e-18
C12 (S0b VSS) capacitor c=3.98973e-17
C13 (net202 VSS) capacitor c=2.25497e-18
C14 (net190 VSS) capacitor c=5.78225e-18
C15 (\4\:S0 VSS) capacitor c=2.98887e-17
C16 (\1\:A VSS) capacitor c=5.62399e-17
C17 (\1\:S0 VSS) capacitor c=3.36722e-17
C18 (\1\:B VSS) capacitor c=6.12353e-17
C19 (\1\:S1 VSS) capacitor c=3.59682e-17
C20 (\7\:S1 VSS) capacitor c=3.40878e-17
C21 (\2\:S1b VSS) capacitor c=3.93679e-17
C22 (\3\:C VSS) capacitor c=5.11345e-17
C23 (\6\:S0 VSS) capacitor c=5.44695e-17
C24 (\3\:A VSS) capacitor c=6.94525e-17
C25 (\3\:S0b VSS) capacitor c=5.92036e-17
C26 (\3\:S0 VSS) capacitor c=5.9874e-17
C27 (\3\:B VSS) capacitor c=2.8958e-17
C28 (\6\:S1 VSS) capacitor c=5.33842e-17
C29 (\3\:S1b VSS) capacitor c=3.30653e-17
C30 (\5\:S1 VSS) capacitor c=5.73126e-17
C31 (\1\:C VSS) capacitor c=3.83476e-17
C32 (\5\:S0 VSS) capacitor c=5.14789e-17
C33 (\2\:A VSS) capacitor c=7.067e-17
C34 (\4\:S0b VSS) capacitor c=6.51308e-17
C35 (\2\:S0 VSS) capacitor c=8.33074e-17
C36 (\2\:S0b VSS) capacitor c=4.19019e-17
C37 (\2\:B VSS) capacitor c=4.85846e-17
C38 (\3\:S1 VSS) capacitor c=2.04138e-17
C39 (\4\:S1b VSS) capacitor c=3.8812e-17
C40 (\2\:C VSS) capacitor c=4.38684e-17
C41 (\10\:S0b VSS) capacitor c=7.99407e-17
C42 (\9\:VDD VSS) capacitor c=3.46794e-17
C43 (\7\:n0 VSS) capacitor c=3.21396e-17
C44 (\11\:VDD VSS) capacitor c=3.73045e-17
C45 (\5\:S1b VSS) capacitor c=8.28118e-17
C46 (\5\:n0 VSS) capacitor c=2.74349e-17
C47 (\11\:n1 VSS) capacitor c=8.23048e-17
C48 (\1\:Y VSS) capacitor c=8.19572e-17
C49 (\1\:VDD VSS) capacitor c=4.47004e-17
C50 (\5\:S0b VSS) capacitor c=3.27963e-17
C51 (\10\:S1b VSS) capacitor c=7.67904e-17
C52 (\9\:n0 VSS) capacitor c=7.9566e-17
C53 (\7\:n1 VSS) capacitor c=4.08002e-17
C54 (\4\:Y VSS) capacitor c=4.44261e-17
C55 (\2\:S1 VSS) capacitor c=3.44406e-17
C56 (\4\:S1 VSS) capacitor c=7.30369e-17
C57 (\3\:Y VSS) capacitor c=5.77238e-17
C58 (\4\:C VSS) capacitor c=3.95709e-17
C59 (\9\:n1 VSS) capacitor c=6.25139e-17
C60 (\10\:n1 VSS) capacitor c=6.55119e-17
C61 (\7\:S1b VSS) capacitor c=7.19852e-17
C62 (\8\:S1b VSS) capacitor c=7.83067e-17
C63 (\9\:S1b VSS) capacitor c=3.4523e-17
C64 (\8\:S1 VSS) capacitor c=6.71705e-17
C65 (\4\:B VSS) capacitor c=5.25235e-17
C66 (\3\:n0 VSS) capacitor c=1.53732e-16
C67 (\4\:n0 VSS) capacitor c=9.41525e-17
C68 (\4\:A VSS) capacitor c=8.67229e-17
C69 (\7\:S0 VSS) capacitor c=7.48537e-17
C70 (\8\:S0 VSS) capacitor c=4.34198e-17
C71 (\7\:S0b VSS) capacitor c=5.34553e-17
C72 (\8\:S0b VSS) capacitor c=1.13455e-16
C73 (\9\:S0b VSS) capacitor c=6.90402e-17
C74 (\3\:VDD VSS) capacitor c=2.37655e-17
C75 (\4\:VDD VSS) capacitor c=3.07593e-17
C76 (\6\:VDD VSS) capacitor c=1.22393e-16
Rk19 (A \4\:A) resistor r=0.05431 c=0
Rk37 (\2\:VSS \3\:VSS) resistor r=0.1728 c=0
Rk38 (\3\:VSS \4\:VSS) resistor r=0.4433 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=0.0349 c=0
Rk43 (\6\:VSS VSS) resistor r=0.03967 c=0
Rk40 (\5\:VSS \6\:VSS) resistor r=0.5814 c=0
Rk45 (\3\:VSS \11\:VSS) resistor r=0.2229 c=0
Rk46 (\4\:VSS \13\:VSS) resistor r=0.2247 c=0
Rk4 (\4\:C C) resistor r=0.1387 c=0
Rk13 (\4\:B B) resistor r=0.1633 c=0
Rk26 (\2\:VDD \3\:VDD) resistor r=0.07251 c=0
Rk27 (\3\:VDD \4\:VDD) resistor r=0.4433 c=0
Rk28 (\4\:VDD \5\:VDD) resistor r=0.2355 c=0
Rk31 (\6\:VDD VDD) resistor r=0.03967 c=0
Rk29 (\5\:VDD \6\:VDD) resistor r=0.3658 c=0
Rk33 (\3\:VDD \10\:VDD) resistor r=0.2295 c=0
Rk34 (\4\:VDD \12\:VDD) resistor r=0.227 c=0
Rk12 (S1 \8\:S1) resistor r=0.1439 c=0
Rk3 (\3\:Y Y) resistor r=0.006072 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.4965 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.1492 c=0
Rk20 (S0 \7\:S0) resistor r=0.003678 c=0
Rk21 (\7\:S0 \8\:S0) resistor r=0.2739 c=0
Rk5 (\8\:n1 \9\:n1) resistor r=0.1339 c=0
Rk6 (\9\:n1 \10\:n1) resistor r=0.3252 c=0
Rk7 (\9\:n1 \12\:n1) resistor r=0.4177 c=0
Rk14 (\2\:n0 \3\:n0) resistor r=0.7843 c=0
Rk15 (\3\:n0 \4\:n0) resistor r=0.4274 c=0
Rk16 (\4\:n0 \6\:n0) resistor r=0.06409 c=0
Rk17 (\3\:n0 \8\:n0) resistor r=0.253 c=0
Rk18 (\4\:n0 \10\:n0) resistor r=0.4005 c=0
Rk8 (\6\:S1b \7\:S1b) resistor r=0.553 c=0
Rk9 (\7\:S1b \8\:S1b) resistor r=0.1773 c=0
Rk10 (\7\:S1b \9\:S1b) resistor r=0.1128 c=0
Rk11 (\8\:S1b \11\:S1b) resistor r=0.6017 c=0
Rk22 (\6\:S0b \7\:S0b) resistor r=0.2086 c=0
Rk23 (\7\:S0b \8\:S0b) resistor r=0.3729 c=0
Rk24 (\8\:S0b \9\:S0b) resistor r=0.4497 c=0
Rk25 (\7\:S0b \11\:S0b) resistor r=0.5381 c=0
Rl22 (\1\:A \2\:A) resistor r=146.846 c=0
Rl23 (\2\:A \3\:A) resistor r=112.23 c=0
Rl7 (\2\:C \3\:C) resistor r=81.9251 c=0
Rl6 (\1\:C \2\:C) resistor r=53.4495 c=0
Rl16 (\1\:B \2\:B) resistor r=219.923 c=0
Rl17 (\2\:B \3\:B) resistor r=39.1533 c=0
Rl10 (\1\:S1 \2\:S1) resistor r=103.56 c=0
Rl14 (\2\:S1 \6\:S1) resistor r=172.791 c=0
Rl11 (\2\:S1 \3\:S1) resistor r=1.2666 c=0
Rl15 (\4\:S1 \7\:S1) resistor r=58.8489 c=0
Rl13 (\4\:S1 \5\:S1) resistor r=162.261 c=0
Rl12 (\3\:S1 \4\:S1) resistor r=171.264 c=0
Rl24 (\4\:S0 \5\:S0) resistor r=29.5379 c=0
Rl25 (\5\:S0 \6\:S0) resistor r=229.538 c=0
Rl19 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl20 (\2\:S0 \3\:S0) resistor r=235.337 c=0
Rl8 (S1b \2\:S1b) resistor r=57.6695 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=37.2302 c=0
Rl21 (\3\:S0b \4\:S0b) resistor r=39.1533 c=0
Rl18 (S0b \2\:S0b) resistor r=73.7687 c=0
Rz10 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz9 (VDD \1\:VDD) resistor r=75 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz8 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\5\:Y \4\:Y) resistor r=75 c=0
Rz2 (\8\:n1 \7\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz6 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry14 (VSS \1\:VSS) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry13 (\6\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry8 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry2 (\12\:n1 \11\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry5 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry6 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx7 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx5 (\3\:S1 \8\:S1) resistor r=45 c=0
Rx8 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx9 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\10\:n1 n1) resistor r=45 c=0
Rx3 (\4\:S1b \8\:S1b) resistor r=45 c=0
Rx4 (S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\4\:Y n1 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.002e-14 ad=6.24e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.68365e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn7 (net245 \1\:C \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.393e-14 ps=9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn8 (\7\:n1 \5\:S1 net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.77e-14 ps=6.2e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (\7\:n1 \3\:S1b \9\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=3.77e-14 ps=6.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\10\:S1b \6\:S1 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn4 (net234 \3\:B \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.712e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03e-06 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.712e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.6e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=4.55e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (net229 \3\:A \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=8.7e-15 ps=6.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.5e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn0 (\5\:S0b \6\:S0 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=1.4e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mp7 (net202 \3\:C \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=2.795e-14 ps=1.15e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.7e-07 sd=160n sca=12.5284 \
        scb=0.0109224 scc=0.000332139 m=(1)
mp8 (\11\:n1 \2\:S1b net202 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=4.193e-14 ps=6.9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=4.95e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp6 (\5\:n0 \7\:S1 \11\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.193e-14 ad=5.483e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2.55e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (\5\:S1b \1\:S1 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp4 (net190 \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.03e-06 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=7.65e-07 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp0 (\10\:S0b \4\:S0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=1.4e-07 sd=160n sca=15.6354 \
        scb=0.0149943 scc=0.000227751 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.44e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=5.6e-07 sd=160n sca=10.7836 \
        scb=0.00772993 scc=8.40702e-05 m=(1)
mp2 (net189 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.548e-14 ps=7.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.5e-07 sd=160n sca=11.9995 \
        scb=0.0089032 scc=8.73074e-05 m=(1)
ends MX3X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:31:21 2012 )
// Library name: gsclib045
// Cell name: MX3X4
// View name: extracted

simulator lang=spectre

subckt MX3X4 A B C S0 S1 VDD VSS Y
mp9 (\1\:Y n1 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.289e-14 ad=7.8e-14 ps=1.1025e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.53e-06 sd=160n sca=16.3392 \
        scb=0.0152106 scc=0.000622257 m=(4)
C1 (A VSS) capacitor c=3.16864e-17
C2 (C VSS) capacitor c=5.54855e-17
C3 (B VSS) capacitor c=8.66155e-17
C4 (VDD VSS) capacitor c=2.1395e-16
C5 (S1 VSS) capacitor c=7.50296e-17
C6 (Y VSS) capacitor c=1.94886e-17
C7 (n1 VSS) capacitor c=2.42982e-16
C8 (net245 VSS) capacitor c=5.3414e-18
C9 (n0 VSS) capacitor c=1.06872e-16
C10 (S1b VSS) capacitor c=5.02343e-17
C11 (net234 VSS) capacitor c=1.83395e-19
C12 (S0b VSS) capacitor c=4.25771e-17
C13 (net190 VSS) capacitor c=3.7823e-18
C14 (\4\:S0 VSS) capacitor c=2.54402e-17
C15 (\1\:A VSS) capacitor c=5.0152e-17
C16 (\1\:S0 VSS) capacitor c=3.06742e-17
C17 (\1\:B VSS) capacitor c=5.95088e-17
C18 (\5\:S1 VSS) capacitor c=3.63489e-17
C19 (\6\:S1 VSS) capacitor c=3.00744e-17
C20 (\2\:S1b VSS) capacitor c=7.17241e-17
C21 (\1\:C VSS) capacitor c=6.84501e-17
C22 (\6\:S0 VSS) capacitor c=4.96163e-17
C23 (\3\:A VSS) capacitor c=5.40159e-17
C24 (\3\:S0b VSS) capacitor c=5.88006e-17
C25 (\3\:S0 VSS) capacitor c=6.0267e-17
C26 (\3\:B VSS) capacitor c=3.31453e-17
C27 (\1\:S1 VSS) capacitor c=5.36308e-17
C28 (\3\:S1b VSS) capacitor c=3.04249e-17
C29 (\4\:S1 VSS) capacitor c=6.41518e-17
C30 (\3\:C VSS) capacitor c=3.51104e-17
C31 (\5\:S0 VSS) capacitor c=4.49568e-17
C32 (\2\:A VSS) capacitor c=6.12915e-17
C33 (\4\:S0b VSS) capacitor c=4.91007e-17
C34 (\2\:S0 VSS) capacitor c=7.78502e-17
C35 (\2\:S0b VSS) capacitor c=4.60694e-17
C36 (\2\:B VSS) capacitor c=5.32638e-17
C37 (\2\:S1 VSS) capacitor c=5.8123e-17
C38 (\4\:S1b VSS) capacitor c=4.63797e-17
C39 (\2\:C VSS) capacitor c=4.06117e-17
C40 (\10\:S0b VSS) capacitor c=5.03906e-17
C41 (\11\:VDD VSS) capacitor c=2.45003e-17
C42 (\7\:n0 VSS) capacitor c=2.51704e-17
C43 (\1\:VDD VSS) capacitor c=3.82014e-17
C44 (\5\:S1b VSS) capacitor c=8.89546e-17
C45 (\5\:n0 VSS) capacitor c=4.34954e-17
C46 (\17\:n1 VSS) capacitor c=1.04537e-16
C47 (\1\:Y VSS) capacitor c=1.60012e-16
C48 (\4\:VDD VSS) capacitor c=9.74705e-17
C49 (\5\:S0b VSS) capacitor c=1.95583e-17
C50 (\10\:S1b VSS) capacitor c=7.38116e-17
C51 (\9\:n0 VSS) capacitor c=9.90921e-17
C52 (\13\:n1 VSS) capacitor c=4.12723e-17
C53 (\4\:Y VSS) capacitor c=9.54343e-17
C54 (\3\:S1 VSS) capacitor c=7.3955e-17
C55 (\4\:C VSS) capacitor c=4.67878e-17
C56 (\15\:n1 VSS) capacitor c=6.76222e-17
C57 (\16\:n1 VSS) capacitor c=6.54051e-17
C58 (\8\:S1b VSS) capacitor c=9.46147e-17
C59 (\9\:S1b VSS) capacitor c=8.11765e-17
C60 (\12\:S1b VSS) capacitor c=2.26552e-17
C61 (\7\:S1 VSS) capacitor c=5.63116e-17
C62 (\4\:B VSS) capacitor c=3.62702e-17
C63 (\3\:n0 VSS) capacitor c=1.40694e-16
C64 (\4\:n0 VSS) capacitor c=9.10638e-17
C65 (\7\:S0 VSS) capacitor c=6.95088e-17
C66 (\8\:S0 VSS) capacitor c=4.66415e-17
C67 (\4\:A VSS) capacitor c=8.54444e-17
C68 (\7\:S0b VSS) capacitor c=8.20064e-17
C69 (\8\:S0b VSS) capacitor c=1.11767e-16
C70 (\9\:S0b VSS) capacitor c=6.73151e-17
C71 (\3\:VDD VSS) capacitor c=1.30407e-17
C72 (\6\:VDD VSS) capacitor c=1.6663e-16
Rk26 (A \4\:A) resistor r=0.07281 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.1727 c=0
Rk32 (\3\:VSS \4\:VSS) resistor r=0.479 c=0
Rk33 (\3\:VSS \6\:VSS) resistor r=0.1961 c=0
Rk38 (\7\:VSS VSS) resistor r=0.1198 c=0
Rk34 (\4\:VSS \7\:VSS) resistor r=0.5811 c=0
Rk39 (\4\:VSS \12\:VSS) resistor r=0.2466 c=0
Rk6 (C \4\:C) resistor r=0.03635 c=0
Rk18 (\4\:B B) resistor r=0.01496 c=0
Rk43 (\2\:VDD \3\:VDD) resistor r=0.2492 c=0
Rk44 (\3\:VDD \5\:VDD) resistor r=0.3205 c=0
Rk49 (\6\:VDD VDD) resistor r=0.1148 c=0
Rk45 (\5\:VDD \6\:VDD) resistor r=0.2804 c=0
Rk50 (\3\:VDD \10\:VDD) resistor r=0.3306 c=0
Rk51 (\10\:VDD \12\:VDD) resistor r=0.3771 c=0
Rk15 (S1 \7\:S1) resistor r=0.1437 c=0
Rk2 (\1\:Y Y) resistor r=0.265 c=0
Rk3 (Y \4\:Y) resistor r=0.04446 c=0
Rk24 (S0 \7\:S0) resistor r=0.005081 c=0
Rk25 (\7\:S0 \8\:S0) resistor r=0.2852 c=0
Rk7 (\14\:n1 \15\:n1) resistor r=0.1246 c=0
Rk8 (\15\:n1 \16\:n1) resistor r=0.3577 c=0
Rk9 (\15\:n1 \18\:n1) resistor r=0.4624 c=0
Rk19 (\2\:n0 \3\:n0) resistor r=0.7805 c=0
Rk20 (\3\:n0 \4\:n0) resistor r=0.3842 c=0
Rk21 (\4\:n0 \6\:n0) resistor r=0.1486 c=0
Rk22 (\3\:n0 \8\:n0) resistor r=0.2267 c=0
Rk23 (\4\:n0 \10\:n0) resistor r=0.4084 c=0
Rk10 (\6\:S1b \7\:S1b) resistor r=0.5988 c=0
Rk11 (\7\:S1b \8\:S1b) resistor r=0.04598 c=0
Rk12 (\7\:S1b \9\:S1b) resistor r=0.1976 c=0
Rk13 (\9\:S1b \11\:S1b) resistor r=0.5988 c=0
Rk14 (\9\:S1b \12\:S1b) resistor r=0.02782 c=0
Rk27 (\6\:S0b \7\:S0b) resistor r=0.1368 c=0
Rk28 (\7\:S0b \8\:S0b) resistor r=0.4793 c=0
Rk29 (\8\:S0b \9\:S0b) resistor r=0.3825 c=0
Rk30 (\7\:S0b \11\:S0b) resistor r=0.4507 c=0
Rl27 (\1\:A \2\:A) resistor r=160.307 c=0
Rl28 (\2\:A \3\:A) resistor r=98.7687 c=0
Rl12 (\1\:C \2\:C) resistor r=74.2328 c=0
Rl13 (\2\:C \3\:C) resistor r=43.4636 c=0
Rl21 (\1\:B \2\:B) resistor r=181.925 c=0
Rl22 (\2\:B \3\:B) resistor r=74.2328 c=0
Rl19 (\2\:S1 \5\:S1) resistor r=77.6559 c=0
Rl16 (\1\:S1 \2\:S1) resistor r=171.32 c=0
Rl20 (\3\:S1 \6\:S1) resistor r=28.0797 c=0
Rl18 (\3\:S1 \4\:S1) resistor r=179.568 c=0
Rl17 (\2\:S1 \3\:S1) resistor r=162.376 c=0
Rl29 (\4\:S0 \5\:S0) resistor r=29.5379 c=0
Rl30 (\5\:S0 \6\:S0) resistor r=229.538 c=0
Rl24 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl25 (\2\:S0 \3\:S0) resistor r=233.414 c=0
Rl14 (S1b \2\:S1b) resistor r=98.0541 c=0
Rl15 (\3\:S1b \4\:S1b) resistor r=48.7687 c=0
Rl26 (\3\:S0b \4\:S0b) resistor r=80.0021 c=0
Rl23 (S0b \2\:S0b) resistor r=90.1003 c=0
Rz8 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\5\:VDD \4\:VDD) resistor r=12.5 c=0
Rz14 (\6\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\10\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz3 (\14\:n1 \13\:n1) resistor r=75 c=0
Rz5 (n0 \2\:n0) resistor r=75 c=0
Rz6 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz4 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz7 (\5\:S0b \6\:S0b) resistor r=75 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry10 (\7\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry11 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\18\:n1 \17\:n1) resistor r=20.6667 c=0
Ry5 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry6 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry4 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry7 (\10\:S0b \11\:S0b) resistor r=62 c=0
Rx9 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx5 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx8 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\16\:n1 n1) resistor r=45 c=0
Rx3 (S1b \8\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \12\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\4\:Y n1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.127e-14 ad=5.2e-14 ps=8.375e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.635e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn7 (net245 \3\:C \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=5.59e-14 ps=8.7e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=7.2e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn8 (\13\:n1 \4\:S1 net245 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=7.15e-14 ps=9.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn6 (\13\:n1 \3\:S1b \9\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=7.15e-14 ps=8e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=1.4e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (\10\:S1b \1\:S1 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.365e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn4 (net234 \3\:B \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.785e-14 ps=6.1e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.16e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=2.32e-14 ps=9.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=7.85e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=2.32e-14 ps=4.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=5.8e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (net229 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.16e-14 ps=7.3e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=4.55e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn0 (\5\:S0b \6\:S0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.755e-14 ps=7.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.9e-07 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mp7 (net202 \1\:C \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=3.12e-14 ps=1.13e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=6.15e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp8 (\17\:n1 \2\:S1b net202 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=1.1895e-13 ps=9.4e-07 pd=1.39e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=4.9e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp6 (\5\:n0 \6\:S1 \17\:n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1895e-13 ad=5.46e-14 ps=1.39e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp1 (\5\:S1b \5\:S1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp4 (net190 \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.19e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=9.7e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp0 (\10\:S0b \4\:S0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.73e-14 ps=8.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=2.2e-07 sd=160n sca=18.2413 \
        scb=0.0194209 scc=0.000499991 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=7.65e-07 sd=160n sca=10.9501 \
        scb=0.00835862 scc=0.000128423 m=(1)
mp2 (net189 \1\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.052e-14 ps=8.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=4.85e-07 sd=160n sca=12.393 \
        scb=0.00963865 scc=0.000131709 m=(1)
ends MX3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:31:58 2012 )
// Library name: gsclib045
// Cell name: MX3XL
// View name: extracted

simulator lang=spectre

subckt MX3XL A B C S0 S1 VDD VSS Y
mp9 (\1\:Y \3\:n1 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=8.5e-07 sd=160n sca=20.5682 \
        scb=0.0225705 scc=0.000868063 m=(1)
C1 (A VSS) capacitor c=3.29202e-17
C2 (C VSS) capacitor c=6.34746e-17
C3 (Y VSS) capacitor c=8.03652e-17
C4 (B VSS) capacitor c=3.62034e-17
C5 (S1 VSS) capacitor c=6.61348e-17
C6 (S0 VSS) capacitor c=7.83659e-17
C7 (VDD VSS) capacitor c=2.4328e-16
C8 (n1 VSS) capacitor c=2.59854e-17
C9 (n0 VSS) capacitor c=1.08405e-16
C10 (S1b VSS) capacitor c=5.47776e-17
C11 (net234 VSS) capacitor c=6.47174e-18
C12 (S0b VSS) capacitor c=3.91944e-17
C13 (net202 VSS) capacitor c=1.41866e-18
C14 (net190 VSS) capacitor c=5.16041e-18
C15 (\4\:S0 VSS) capacitor c=3.25953e-17
C16 (\1\:A VSS) capacitor c=5.33871e-17
C17 (\1\:S0 VSS) capacitor c=4.82175e-17
C18 (\1\:B VSS) capacitor c=6.30581e-17
C19 (\1\:S1 VSS) capacitor c=3.33451e-17
C20 (\6\:S1 VSS) capacitor c=3.29887e-17
C21 (\2\:S1b VSS) capacitor c=4.81535e-17
C22 (\4\:C VSS) capacitor c=6.7581e-17
C23 (\3\:n1 VSS) capacitor c=5.46428e-17
C24 (\6\:S0 VSS) capacitor c=4.704e-17
C25 (\3\:A VSS) capacitor c=4.05113e-17
C26 (\3\:S0b VSS) capacitor c=4.73018e-17
C27 (\3\:S0 VSS) capacitor c=4.88916e-17
C28 (\4\:B VSS) capacitor c=3.48521e-17
C29 (\5\:S1 VSS) capacitor c=5.87386e-17
C30 (\3\:S1b VSS) capacitor c=3.38076e-17
C31 (\4\:S1 VSS) capacitor c=5.55373e-17
C32 (\1\:C VSS) capacitor c=4.83299e-17
C33 (\5\:S0 VSS) capacitor c=4.89421e-17
C34 (\2\:A VSS) capacitor c=5.77501e-17
C35 (\4\:S0b VSS) capacitor c=4.247e-17
C36 (\2\:S0 VSS) capacitor c=7.38557e-17
C37 (\2\:S0b VSS) capacitor c=3.99229e-17
C38 (\3\:B VSS) capacitor c=2.18448e-17
C39 (\2\:S1 VSS) capacitor c=5.49529e-17
C40 (\4\:S1b VSS) capacitor c=2.5651e-17
C41 (\3\:C VSS) capacitor c=7.15707e-17
C42 (\5\:S0b VSS) capacitor c=6.00038e-17
C43 (\7\:VDD VSS) capacitor c=2.57136e-17
C44 (\7\:n0 VSS) capacitor c=3.29203e-17
C45 (\9\:VDD VSS) capacitor c=3.55373e-17
C46 (\5\:S1b VSS) capacitor c=8.47067e-17
C47 (\5\:n0 VSS) capacitor c=3.09306e-17
C48 (\9\:n1 VSS) capacitor c=8.08787e-17
C49 (\11\:VDD VSS) capacitor c=2.6686e-17
C50 (\1\:Y VSS) capacitor c=6.567e-17
C51 (\1\:VDD VSS) capacitor c=4.9295e-17
C52 (\10\:S0b VSS) capacitor c=1.6636e-17
C53 (\10\:S1b VSS) capacitor c=8.26277e-17
C54 (\9\:n0 VSS) capacitor c=1.10415e-16
C55 (\5\:n1 VSS) capacitor c=5.95247e-17
C56 (\2\:n1 VSS) capacitor c=6.39073e-17
C57 (\3\:S1 VSS) capacitor c=7.60729e-17
C58 (\2\:B VSS) capacitor c=3.54721e-17
C59 (\5\:C VSS) capacitor c=7.29763e-17
C60 (\7\:n1 VSS) capacitor c=6.16486e-17
C61 (\8\:n1 VSS) capacitor c=4.76581e-17
C62 (\7\:S1b VSS) capacitor c=9.02312e-17
C63 (\8\:S1b VSS) capacitor c=3.29346e-17
C64 (\9\:S1b VSS) capacitor c=1.15887e-16
C65 (\7\:S1 VSS) capacitor c=7.03343e-17
C66 (\5\:B VSS) capacitor c=1.03064e-16
C67 (\3\:n0 VSS) capacitor c=1.51507e-16
C68 (\4\:n0 VSS) capacitor c=1.14016e-16
C69 (\8\:S0 VSS) capacitor c=9.42448e-17
C70 (\4\:A VSS) capacitor c=8.50525e-17
C71 (\7\:S0b VSS) capacitor c=7.71636e-17
C72 (\8\:S0b VSS) capacitor c=1.2047e-16
C73 (\9\:S0b VSS) capacitor c=7.94099e-17
C74 (\3\:VDD VSS) capacitor c=1.96401e-17
C75 (\4\:VDD VSS) capacitor c=2.84972e-17
C76 (\6\:VDD VSS) capacitor c=2.54905e-17
Rk20 (A \4\:A) resistor r=0.05447 c=0
Rk33 (\2\:VSS \3\:VSS) resistor r=0.1077 c=0
Rk34 (\3\:VSS \4\:VSS) resistor r=0.4487 c=0
Rk35 (\4\:VSS \5\:VSS) resistor r=0.04496 c=0
Rk36 (\5\:VSS \6\:VSS) resistor r=0.5216 c=0
Rk38 (\7\:VSS VSS) resistor r=0.04992 c=0
Rk37 (\6\:VSS \7\:VSS) resistor r=0.08008 c=0
Rk39 (\3\:VSS \9\:VSS) resistor r=0.2585 c=0
Rk40 (\4\:VSS \11\:VSS) resistor r=0.2707 c=0
Rk41 (\6\:VSS \13\:VSS) resistor r=0.2802 c=0
Rk3 (\5\:C C) resistor r=0.1532 c=0
Rk1 (\2\:Y Y) resistor r=0.5594 c=0
Rk2 (Y \4\:Y) resistor r=0.002711 c=0
Rk12 (B \5\:B) resistor r=0.02911 c=0
Rk11 (S1 \7\:S1) resistor r=0.2063 c=0
Rk18 (\7\:S0 S0) resistor r=0.003006 c=0
Rk19 (S0 \8\:S0) resistor r=0.46 c=0
Rk25 (\2\:VDD \3\:VDD) resistor r=0.1077 c=0
Rk26 (\3\:VDD \4\:VDD) resistor r=0.4487 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.1453 c=0
Rk29 (\6\:VDD VDD) resistor r=0.12 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.4313 c=0
Rk30 (\3\:VDD \8\:VDD) resistor r=0.1948 c=0
Rk31 (\4\:VDD \10\:VDD) resistor r=0.1993 c=0
Rk32 (\6\:VDD \12\:VDD) resistor r=0.2182 c=0
Rk4 (\6\:n1 \7\:n1) resistor r=0.2815 c=0
Rk5 (\7\:n1 \8\:n1) resistor r=0.1706 c=0
Rk6 (\7\:n1 \10\:n1) resistor r=0.4986 c=0
Rk13 (\2\:n0 \3\:n0) resistor r=0.7347 c=0
Rk14 (\3\:n0 \4\:n0) resistor r=0.3683 c=0
Rk15 (\4\:n0 \6\:n0) resistor r=0.1019 c=0
Rk16 (\3\:n0 \8\:n0) resistor r=0.2158 c=0
Rk17 (\4\:n0 \10\:n0) resistor r=0.5591 c=0
Rk7 (\6\:S1b \7\:S1b) resistor r=0.5426 c=0
Rk8 (\7\:S1b \8\:S1b) resistor r=0.1133 c=0
Rk9 (\7\:S1b \9\:S1b) resistor r=0.3033 c=0
Rk10 (\9\:S1b \11\:S1b) resistor r=0.6316 c=0
Rk21 (\6\:S0b \7\:S0b) resistor r=0.4896 c=0
Rk22 (\7\:S0b \8\:S0b) resistor r=0.4543 c=0
Rk23 (\8\:S0b \9\:S0b) resistor r=0.4612 c=0
Rk24 (\7\:S0b \11\:S0b) resistor r=0.1248 c=0
Rl21 (\1\:A \2\:A) resistor r=164.617 c=0
Rl22 (\2\:A \3\:A) resistor r=89.6174 c=0
Rl6 (\2\:C \4\:C) resistor r=145.872 c=0
Rl4 (\1\:C \2\:C) resistor r=115.103 c=0
Rl5 (\2\:C \3\:C) resistor r=7.2644 c=0
Rl14 (\1\:B \2\:B) resistor r=195.868 c=0
Rl16 (\2\:B \4\:B) resistor r=78.5603 c=0
Rl15 (\2\:B \3\:B) resistor r=4.3144 c=0
Rl9 (\1\:S1 \2\:S1) resistor r=78.8233 c=0
Rl12 (\2\:S1 \5\:S1) resistor r=180.13 c=0
Rl13 (\3\:S1 \6\:S1) resistor r=56.9258 c=0
Rl11 (\3\:S1 \4\:S1) resistor r=244.953 c=0
Rl10 (\2\:S1 \3\:S1) resistor r=162.376 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=62.2302 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=194.923 c=0
Rl18 (\1\:S0 \2\:S0) resistor r=133.848 c=0
Rl19 (\2\:S0 \3\:S0) resistor r=148.616 c=0
Rl1 (n1 \2\:n1) resistor r=42.0262 c=0
Rl2 (\2\:n1 \3\:n1) resistor r=218.949 c=0
Rl3 (\2\:n1 \4\:n1) resistor r=7.2644 c=0
Rl7 (S1b \2\:S1b) resistor r=60.5801 c=0
Rl8 (\3\:S1b \4\:S1b) resistor r=48.7687 c=0
Rl20 (\3\:S0b \4\:S0b) resistor r=48.7687 c=0
Rl17 (S0b \2\:S0b) resistor r=68.2278 c=0
Rz9 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz8 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz2 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\10\:S1b \11\:S1b) resistor r=75 c=0
Rz6 (\10\:S0b \11\:S0b) resistor r=75 c=0
Ry10 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry11 (\1\:VSS \5\:VSS) resistor r=6.2 c=0
Ry12 (\1\:VSS \7\:VSS) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry2 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry5 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry3 (\5\:S1b \6\:S1b) resistor r=62 c=0
Ry6 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx9 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx6 (\3\:B \5\:B) resistor r=45 c=0
Rx5 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx8 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\4\:n1 \8\:n1) resistor r=45 c=0
Rx3 (S1b \8\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx10 (\4\:S0b \8\:S0b) resistor r=45 c=0
Rx11 (\2\:S0b \9\:S0b) resistor r=45 c=0
mn9 (\3\:Y n1 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=8.65e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn7 (net245 \1\:C \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=6.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn8 (\5\:n1 \4\:S1 net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=3.335e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.6e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn6 (\5\:n1 \3\:S1b \9\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.335e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.85e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\10\:S1b \5\:S1 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn4 (net234 \4\:B \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.262e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn5 (n0 \3\:S0 net234 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.262e-14 ad=2.392e-14 ps=7.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=8.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn3 (n0 \3\:S0b net229 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.392e-14 ps=6.2e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=6.35e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (net229 \3\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.392e-14 ps=6.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.25e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\10\:S0b \6\:S0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.755e-14 ps=6.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.9e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mp7 (net202 \4\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.72e-14 ps=7.5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.45e-07 sd=160n sca=13.1728 \
        scb=0.010661 scc=9.76612e-05 m=(1)
mp8 (\9\:n1 \2\:S1b net202 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.73e-14 ps=5.9e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=5.2e-07 sd=160n sca=11.7475 \
        scb=0.00853026 scc=7.76573e-05 m=(1)
mp6 (\5\:n0 \6\:S1 \9\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.483e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.55e-07 sd=160n sca=10.4608 \
        scb=0.00746151 scc=7.53855e-05 m=(1)
mp1 (\5\:S1b \1\:S1 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp4 (net190 \1\:B \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp5 (\7\:n0 S0b net190 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.762e-14 ps=7.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=8.95e-07 sd=160n sca=10.1615 \
        scb=0.00737933 scc=7.53706e-05 m=(1)
mp3 (\7\:n0 \1\:S0 net189 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.762e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=6.75e-07 sd=160n sca=10.666 \
        scb=0.00755422 scc=7.54245e-05 m=(1)
mp2 (net189 \1\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.407e-14 ps=8.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=4.25e-07 sd=160n sca=12.2076 \
        scb=0.00914458 scc=8.10906e-05 m=(1)
mp0 (\5\:S0b \4\:S0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.085e-14 ps=8.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.9e-07 sd=160n sca=17.7662 \
        scb=0.0185292 scc=0.000446955 m=(1)
ends MX3XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:32:36 2012 )
// Library name: gsclib045
// Cell name: MX4X1
// View name: extracted

simulator lang=spectre

subckt MX4X1 A B C D S0 S1 VDD VSS Y
mp12 (\1\:Y n2 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=5.46e-14 ps=1.41e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.38462e-07 sd=160n sca=26.2357 \
        scb=0.0296246 scc=0.00188388 m=(1)
C1 (S1 VSS) capacitor c=3.50771e-17
C2 (B VSS) capacitor c=7.96348e-17
C3 (C VSS) capacitor c=4.9195e-17
C4 (S0 VSS) capacitor c=5.67462e-17
C5 (VDD VSS) capacitor c=2.62119e-16
C6 (D VSS) capacitor c=5.23669e-17
C7 (A VSS) capacitor c=1.42927e-16
C8 (n2 VSS) capacitor c=4.83059e-17
C9 (S1b VSS) capacitor c=4.46999e-17
C10 (n1 VSS) capacitor c=4.69463e-17
C11 (n0 VSS) capacitor c=7.06192e-17
C12 (n9 VSS) capacitor c=1.7621e-18
C13 (S0b VSS) capacitor c=6.19714e-17
C14 (n5 VSS) capacitor c=1.40393e-18
C15 (n3 VSS) capacitor c=1.13596e-18
C16 (n10 VSS) capacitor c=2.34734e-18
C17 (n8 VSS) capacitor c=4.79338e-18
C18 (n6 VSS) capacitor c=5.18414e-18
C19 (n4 VSS) capacitor c=2.08453e-18
C20 (\7\:S0 VSS) capacitor c=2.69292e-17
C21 (\1\:A VSS) capacitor c=5.39029e-17
C22 (\4\:S0 VSS) capacitor c=2.94034e-17
C23 (\5\:S0b VSS) capacitor c=4.25684e-17
C24 (\1\:B VSS) capacitor c=4.16363e-17
C25 (\3\:C VSS) capacitor c=4.02708e-17
C26 (\2\:S0 VSS) capacitor c=5.25058e-17
C27 (\2\:S0b VSS) capacitor c=5.92504e-17
C28 (\4\:D VSS) capacitor c=4.01657e-17
C29 (\1\:S1 VSS) capacitor c=4.92158e-17
C30 (\6\:S1 VSS) capacitor c=3.20684e-17
C31 (\9\:S0 VSS) capacitor c=3.99522e-17
C32 (\3\:A VSS) capacitor c=3.3989e-17
C33 (\7\:S0b VSS) capacitor c=6.22191e-17
C34 (\6\:S0 VSS) capacitor c=7.92057e-17
C35 (\3\:B VSS) capacitor c=4.08297e-17
C36 (\1\:C VSS) capacitor c=6.75386e-17
C37 (\3\:S0b VSS) capacitor c=6.3095e-17
C38 (\1\:S0 VSS) capacitor c=8.85083e-17
C39 (\1\:D VSS) capacitor c=7.1323e-17
C40 (\3\:S1b VSS) capacitor c=3.91078e-17
C41 (\4\:S1 VSS) capacitor c=2.79377e-17
C42 (\5\:S1 VSS) capacitor c=2.00989e-17
C43 (\3\:n2 VSS) capacitor c=2.77154e-17
C44 (\8\:S0 VSS) capacitor c=3.43672e-17
C45 (\2\:A VSS) capacitor c=5.07318e-17
C46 (\5\:S0 VSS) capacitor c=6.64343e-17
C47 (\8\:S0b VSS) capacitor c=2.24373e-17
C48 (\6\:S0b VSS) capacitor c=4.41487e-17
C49 (\2\:B VSS) capacitor c=4.44142e-17
C50 (\2\:C VSS) capacitor c=5.19342e-17
C51 (\4\:S0b VSS) capacitor c=4.33418e-17
C52 (\3\:S0 VSS) capacitor c=2.57092e-17
C53 (\3\:D VSS) capacitor c=1.89183e-17
C54 (\4\:S1b VSS) capacitor c=2.70469e-17
C55 (\2\:S1b VSS) capacitor c=1.87783e-17
C56 (\3\:S1 VSS) capacitor c=4.45641e-17
C57 (\2\:n2 VSS) capacitor c=2.90687e-17
C58 (\15\:S0b VSS) capacitor c=9.47515e-17
C59 (\1\:VDD VSS) capacitor c=4.95809e-17
C60 (\3\:n0 VSS) capacitor c=2.48246e-16
C61 (\9\:VDD VSS) capacitor c=2.40057e-17
C62 (\4\:n1 VSS) capacitor c=8.29008e-17
C63 (\11\:VDD VSS) capacitor c=3.61402e-17
C64 (\5\:n0 VSS) capacitor c=2.41566e-16
C65 (\5\:n2 VSS) capacitor c=2.59798e-16
C66 (\8\:n1 VSS) capacitor c=7.90141e-17
C67 (\7\:S1b VSS) capacitor c=1.11891e-16
C68 (\13\:VDD VSS) capacitor c=5.4207e-17
C69 (\1\:Y VSS) capacitor c=5.53136e-17
C70 (\3\:VDD VSS) capacitor c=8.59051e-17
C71 (\9\:S0b VSS) capacitor c=1.35179e-16
C72 (\7\:n0 VSS) capacitor c=8.46774e-17
C73 (\7\:n2 VSS) capacitor c=7.88825e-17
C74 (\6\:n1 VSS) capacitor c=1.49386e-16
C75 (\5\:S1b VSS) capacitor c=9.31582e-17
C76 (\3\:Y VSS) capacitor c=6.64982e-17
C77 (\2\:S1 VSS) capacitor c=5.47437e-17
C78 (\2\:D VSS) capacitor c=3.87196e-17
C79 (\7\:S1 VSS) capacitor c=7.48986e-17
C80 (\4\:n2 VSS) capacitor c=2.36971e-16
C81 (\9\:S1b VSS) capacitor c=1.15923e-16
C82 (\10\:S1b VSS) capacitor c=1.16449e-16
C83 (\5\:D VSS) capacitor c=7.04325e-17
C84 (\3\:n1 VSS) capacitor c=1.69908e-16
C85 (\4\:C VSS) capacitor c=6.46041e-17
C86 (\4\:B VSS) capacitor c=3.51796e-17
C87 (\10\:S0 VSS) capacitor c=1.70475e-16
C88 (\11\:S0 VSS) capacitor c=1.4885e-16
C89 (\12\:S0 VSS) capacitor c=5.00355e-17
C90 (\11\:S0b VSS) capacitor c=1.21259e-16
C91 (\12\:S0b VSS) capacitor c=7.00512e-17
C92 (\13\:S0b VSS) capacitor c=6.31465e-17
C93 (\14\:S0b VSS) capacitor c=5.13039e-17
C94 (\17\:S0b VSS) capacitor c=3.02234e-17
C95 (\5\:VDD VSS) capacitor c=3.64379e-17
C96 (\6\:VDD VSS) capacitor c=2.51575e-17
C97 (\8\:VDD VSS) capacitor c=1.55289e-17
Rk3 (\7\:S1 S1) resistor r=0.05938 c=0
Rk15 (\4\:B B) resistor r=0.0927 c=0
Rk29 (\2\:VSS \3\:VSS) resistor r=0.1704 c=0
Rk30 (\3\:VSS \4\:VSS) resistor r=0.3811 c=0
Rk31 (\4\:VSS \5\:VSS) resistor r=0.07757 c=0
Rk32 (\5\:VSS \6\:VSS) resistor r=0.3408 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.5342 c=0
Rk35 (\8\:VSS VSS) resistor r=0.1024 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.3987 c=0
Rk36 (\3\:VSS \10\:VSS) resistor r=0.2087 c=0
Rk37 (\5\:VSS \12\:VSS) resistor r=0.292 c=0
Rk38 (\6\:VSS \14\:VSS) resistor r=0.2035 c=0
Rk39 (\8\:VSS \16\:VSS) resistor r=0.2016 c=0
Rk14 (\4\:C C) resistor r=0.2112 c=0
Rk20 (\10\:S0 \11\:S0) resistor r=1.1716 c=0
Rk22 (\12\:S0 S0) resistor r=0.1892 c=0
Rk21 (\11\:S0 \12\:S0) resistor r=0.2512 c=0
Rk40 (\2\:VDD \4\:VDD) resistor r=0.5672 c=0
Rk41 (\4\:VDD \5\:VDD) resistor r=0.2924 c=0
Rk42 (\5\:VDD \6\:VDD) resistor r=0.4452 c=0
Rk43 (\6\:VDD \7\:VDD) resistor r=0.3636 c=0
Rk45 (\8\:VDD VDD) resistor r=0.1175 c=0
Rk44 (\7\:VDD \8\:VDD) resistor r=0.4338 c=0
Rk46 (\5\:VDD \10\:VDD) resistor r=0.04333 c=0
Rk47 (\6\:VDD \12\:VDD) resistor r=0.235 c=0
Rk48 (\8\:VDD \14\:VDD) resistor r=0.3147 c=0
Rk9 (\5\:D D) resistor r=0.1182 c=0
Rk19 (\4\:A A) resistor r=0.02718 c=0
Rk1 (\2\:Y Y) resistor r=0.4944 c=0
Rk2 (Y \4\:Y) resistor r=0.003006 c=0
Rk4 (\4\:n2 \6\:n2) resistor r=1.7328 c=0
Rk5 (\6\:n2 \8\:n2) resistor r=0.3971 c=0
Rk6 (\6\:S1b \8\:S1b) resistor r=0.551 c=0
Rk7 (\8\:S1b \9\:S1b) resistor r=0.5008 c=0
Rk8 (\9\:S1b \10\:S1b) resistor r=0.6589 c=0
Rk10 (\2\:n1 \3\:n1) resistor r=0.2905 c=0
Rk11 (\3\:n1 \5\:n1) resistor r=0.4164 c=0
Rk12 (\3\:n1 \7\:n1) resistor r=0.9758 c=0
Rk13 (\7\:n1 \9\:n1) resistor r=0.3686 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.4084 c=0
Rk17 (\4\:n0 \6\:n0) resistor r=1.5563 c=0
Rk18 (\6\:n0 \8\:n0) resistor r=0.4897 c=0
Rk23 (\10\:S0b \11\:S0b) resistor r=0.6473 c=0
Rk24 (\11\:S0b \12\:S0b) resistor r=0.5164 c=0
Rk25 (\12\:S0b \13\:S0b) resistor r=0.3326 c=0
Rk26 (\13\:S0b \14\:S0b) resistor r=0.2974 c=0
Rk27 (\10\:S0b \16\:S0b) resistor r=0.8032 c=0
Rk28 (\12\:S0b \17\:S0b) resistor r=0.08726 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=101.718 c=0
Rl7 (\3\:S1 \5\:S1) resistor r=36.3335 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=124.543 c=0
Rl6 (\2\:S1 \4\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=248.466 c=0
Rl19 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl20 (\2\:B \3\:B) resistor r=108.384 c=0
Rl18 (\2\:C \3\:C) resistor r=30.2198 c=0
Rl17 (\1\:C \2\:C) resistor r=109.615 c=0
Rl14 (\1\:S0 \2\:S0) resistor r=161.909 c=0
Rl27 (\7\:S0 \8\:S0) resistor r=29.5379 c=0
Rl28 (\8\:S0 \9\:S0) resistor r=108.384 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=24.2328 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=195.274 c=0
Rl15 (\2\:S0 \3\:S0) resistor r=58.3841 c=0
Rl12 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl10 (\1\:D \2\:D) resistor r=202.291 c=0
Rl11 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl25 (\1\:A \2\:A) resistor r=94.0258 c=0
Rl26 (\2\:A \3\:A) resistor r=44.208 c=0
Rl1 (n2 \2\:n2) resistor r=110.771 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=33.8482 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=26.1559 c=0
Rl3 (S1b \2\:S1b) resistor r=58.3841 c=0
Rl13 (S0b \2\:S0b) resistor r=84.5926 c=0
Rl22 (\7\:S0b \8\:S0b) resistor r=56.9251 c=0
Rl21 (\5\:S0b \6\:S0b) resistor r=58.3841 c=0
Rl16 (\3\:S0b \4\:S0b) resistor r=33.8482 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz12 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz14 (\3\:VDD \7\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\7\:n2 \8\:n2) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (n0 \2\:n0) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz8 (\9\:S0b \10\:S0b) resistor r=75 c=0
Ry9 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry10 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry11 (\1\:VSS \7\:VSS) resistor r=5.6364 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry14 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry15 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\5\:n2 \6\:n2) resistor r=62 c=0
Ry3 (\7\:S1b \8\:S1b) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry6 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry7 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry8 (\15\:S0b \16\:S0b) resistor r=62 c=0
Rx1 (\3\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx6 (\2\:C \4\:C) resistor r=45 c=0
Rx9 (\3\:S0 \10\:S0) resistor r=45 c=0
Rx10 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx11 (\8\:S0 \12\:S0) resistor r=45 c=0
Rx5 (\3\:D \5\:D) resistor r=45 c=0
Rx8 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:n2 \4\:n2) resistor r=45 c=0
Rx3 (\2\:S1b \9\:S1b) resistor r=45 c=0
Rx4 (\4\:S1b \10\:S1b) resistor r=45 c=0
Rx12 (\8\:S0b \11\:S0b) resistor r=45 c=0
Rx13 (\4\:S0b \13\:S0b) resistor r=45 c=0
Rx14 (S0b \14\:S0b) resistor r=45 c=0
Rx15 (\6\:S0b \17\:S0b) resistor r=45 c=0
mn12 (\3\:Y \3\:n2 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.177e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.51923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (\5\:S1b \5\:S1 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.177e-14 ad=2.32e-14 ps=1.15e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.6e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (\7\:n2 \4\:S1 \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn10 (\7\:n2 \3\:S1b \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn8 (n9 \1\:D \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=8.7e-15 ps=8.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.675e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn9 (n1 \1\:S0 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.57e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn5 (n0 \6\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.755e-14 \
        ad=2.32e-14 ps=6.7e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.025e-06 sb=8.2e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn7 (n1 \3\:S0b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=1.365e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn3 (n0 \7\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.393e-14 \
        ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.23e-06 sb=6.15e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn6 (n7 \1\:C \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.26e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (n5 \3\:B \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.755e-14 ps=6.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.055e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (n3 \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.393e-14 ps=9.9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=4.05e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\9\:S0b \9\:S0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp1 (\7\:S1b \6\:S1 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=1.4e-07 sd=160n sca=21.1359 scb=0.020206 \
        scc=0.00179608 m=(1)
mp11 (\8\:n1 S1b \5\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp10 (\5\:n2 \1\:S1 \5\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp8 (n10 \4\:D \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.505e-14 ps=1.17e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.945e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp9 (\4\:n1 \2\:S0b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.73e-14 ps=5.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.83e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp7 (\4\:n1 \2\:S0 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.977e-14 ad=4.73e-14 ps=8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.565e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp6 (n8 \3\:C \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.093e-14 ad=3.977e-14 ps=1.92e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=1.335e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp4 (n6 \1\:B \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.093e-14 ad=3.44e-14 ps=1.92e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.055e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp5 (\3\:n0 \5\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.805e-14 ps=7.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=8.5e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp3 (\3\:n0 \4\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=5.805e-14 ps=7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58e-06 sb=5.35e-07 sd=160n sca=21.2369 \
        scb=0.0203411 scc=0.00208843 m=(1)
mp2 (n4 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=2.902e-14 ps=7.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=3.55e-07 sd=160n sca=21.7372 \
        scb=0.0205342 scc=0.0020885 m=(1)
mp0 (\15\:S0b \7\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.01e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=1.4e-07 sd=160n sca=23.0263 \
        scb=0.0218192 scc=0.0020924 m=(1)
ends MX4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:33:14 2012 )
// Library name: gsclib045
// Cell name: MX4X2
// View name: extracted

simulator lang=spectre

subckt MX4X2 A B C D S0 S1 VDD VSS Y
mp10 (\9\:n2 \4\:S1 \4\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=3.45e-07 sd=160n sca=44.5479 \
        scb=0.0294091 scc=0.00553812 m=(1)
C1 (S1 VSS) capacitor c=3.03464e-17
C2 (C VSS) capacitor c=5.89669e-17
C3 (Y VSS) capacitor c=4.15364e-17
C4 (B VSS) capacitor c=5.35766e-17
C5 (S0 VSS) capacitor c=5.07424e-17
C6 (D VSS) capacitor c=7.52943e-17
C7 (A VSS) capacitor c=4.54264e-17
C8 (VDD VSS) capacitor c=3.46305e-16
C9 (n2 VSS) capacitor c=1.63837e-16
C10 (S1b VSS) capacitor c=3.22105e-17
C11 (n0 VSS) capacitor c=1.38317e-16
C12 (n1 VSS) capacitor c=3.58096e-16
C13 (n3 VSS) capacitor c=7.1827e-18
C14 (S0b VSS) capacitor c=2.59494e-17
C15 (n5 VSS) capacitor c=4.71509e-19
C16 (n7 VSS) capacitor c=1.02311e-17
C17 (n4 VSS) capacitor c=8.22888e-18
C18 (n6 VSS) capacitor c=5.46742e-18
C19 (n10 VSS) capacitor c=1.44701e-19
C20 (\9\:S0 VSS) capacitor c=3.58182e-17
C21 (\1\:D VSS) capacitor c=6.11491e-17
C22 (\6\:S0b VSS) capacitor c=5.08289e-17
C23 (\8\:S0 VSS) capacitor c=3.69894e-17
C24 (\1\:C VSS) capacitor c=3.69585e-17
C25 (\3\:B VSS) capacitor c=2.99647e-17
C26 (\1\:S0 VSS) capacitor c=3.53458e-17
C27 (\1\:A VSS) capacitor c=4.85379e-17
C28 (\1\:S1 VSS) capacitor c=4.16383e-17
C29 (\5\:S1b VSS) capacitor c=3.41288e-17
C30 (\4\:S1 VSS) capacitor c=5.6389e-17
C31 (\11\:S0 VSS) capacitor c=1.74366e-17
C32 (\3\:D VSS) capacitor c=4.00523e-17
C33 (\5\:S0 VSS) capacitor c=3.17922e-17
C34 (\4\:S0b VSS) capacitor c=4.01551e-17
C35 (\3\:C VSS) capacitor c=4.0327e-17
C36 (\1\:B VSS) capacitor c=8.19535e-17
C37 (\3\:S0 VSS) capacitor c=6.5678e-17
C38 (\3\:S0b VSS) capacitor c=5.28263e-17
C39 (\3\:A VSS) capacitor c=2.68862e-17
C40 (\5\:S1 VSS) capacitor c=2.36958e-17
C41 (\6\:S1 VSS) capacitor c=2.34026e-17
C42 (\10\:S0 VSS) capacitor c=2.90046e-17
C43 (\2\:D VSS) capacitor c=4.37791e-17
C44 (\7\:S0b VSS) capacitor c=3.39388e-17
C45 (\6\:S0 VSS) capacitor c=6.51617e-17
C46 (\5\:S0b VSS) capacitor c=3.80151e-17
C47 (\7\:S0 VSS) capacitor c=6.20389e-17
C48 (\2\:C VSS) capacitor c=4.67924e-17
C49 (\2\:B VSS) capacitor c=4.40951e-17
C50 (\4\:S0 VSS) capacitor c=3.99706e-17
C51 (\2\:S0b VSS) capacitor c=4.6744e-17
C52 (\2\:S0 VSS) capacitor c=3.11882e-17
C53 (\2\:A VSS) capacitor c=3.25886e-17
C54 (\2\:S1 VSS) capacitor c=5.5086e-17
C55 (\3\:S1b VSS) capacitor c=4.43356e-17
C56 (\4\:S1b VSS) capacitor c=4.78573e-17
C57 (\2\:S1b VSS) capacitor c=2.34723e-17
C58 (\8\:S0b VSS) capacitor c=8.88236e-18
C59 (\9\:VDD VSS) capacitor c=4.34302e-17
C60 (\7\:n1 VSS) capacitor c=1.17031e-16
C61 (\11\:VDD VSS) capacitor c=3.22545e-17
C62 (\6\:n0 VSS) capacitor c=3.28726e-17
C63 (\1\:Y VSS) capacitor c=7.1832e-17
C64 (\8\:S1b VSS) capacitor c=5.81346e-17
C65 (\5\:n1 VSS) capacitor c=8.91558e-17
C66 (\9\:n2 VSS) capacitor c=1.89205e-16
C67 (\4\:n0 VSS) capacitor c=2.18739e-16
C68 (\1\:VDD VSS) capacitor c=8.63199e-17
C69 (\14\:S0b VSS) capacitor c=5.74375e-17
C70 (\3\:Y VSS) capacitor c=3.32888e-17
C71 (\11\:S1b VSS) capacitor c=6.34133e-17
C72 (\3\:n1 VSS) capacitor c=3.42197e-16
C73 (\11\:n2 VSS) capacitor c=9.08598e-17
C74 (\8\:n0 VSS) capacitor c=6.20962e-17
C75 (\3\:S1 VSS) capacitor c=5.55898e-17
C76 (\6\:S1b VSS) capacitor c=1.4958e-16
C77 (\7\:S1b VSS) capacitor c=1.18471e-16
C78 (\10\:S1b VSS) capacitor c=5.74153e-17
C79 (\7\:S1 VSS) capacitor c=7.8975e-17
C80 (\8\:n2 VSS) capacitor c=1.48671e-16
C81 (\4\:A VSS) capacitor c=5.15577e-17
C82 (\3\:n0 VSS) capacitor c=2.81905e-16
C83 (\4\:B VSS) capacitor c=5.6628e-17
C84 (\4\:C VSS) capacitor c=2.46195e-17
C85 (\12\:S0 VSS) capacitor c=8.2574e-17
C86 (\13\:S0 VSS) capacitor c=9.16707e-17
C87 (\14\:S0 VSS) capacitor c=6.9359e-17
C88 (\4\:D VSS) capacitor c=4.51868e-17
C89 (\15\:S0 VSS) capacitor c=6.41775e-17
C90 (\16\:S0 VSS) capacitor c=8.20291e-17
C91 (\10\:S0b VSS) capacitor c=7.46911e-17
C92 (\11\:S0b VSS) capacitor c=1.07955e-16
C93 (\12\:S0b VSS) capacitor c=1.74297e-16
C94 (\13\:S0b VSS) capacitor c=1.33876e-16
C95 (\16\:S0b VSS) capacitor c=2.47422e-17
C96 (\17\:S0b VSS) capacitor c=9.54051e-17
C97 (\3\:VDD VSS) capacitor c=2.72542e-17
C98 (\5\:VDD VSS) capacitor c=4.13604e-17
C99 (\6\:VDD VSS) capacitor c=1.0529e-16
Rk4 (S1 \7\:S1) resistor r=0.01942 c=0
Rk15 (\4\:C C) resistor r=0.09804 c=0
Rk7 (\2\:Y Y) resistor r=0.1971 c=0
Rk8 (Y \4\:Y) resistor r=0.1065 c=0
Rk42 (\2\:VSS \3\:VSS) resistor r=0.2007 c=0
Rk43 (\3\:VSS \5\:VSS) resistor r=0.2857 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.2807 c=0
Rk48 (\9\:VSS VSS) resistor r=0.3007 c=0
Rk47 (\6\:VSS \9\:VSS) resistor r=0.3409 c=0
Rk49 (\3\:VSS \10\:VSS) resistor r=0.4663 c=0
Rk50 (\10\:VSS \12\:VSS) resistor r=0.4063 c=0
Rk14 (B \4\:B) resistor r=0.01225 c=0
Rk16 (\12\:S0 \13\:S0) resistor r=0.5455 c=0
Rk17 (\13\:S0 \14\:S0) resistor r=0.4359 c=0
Rk22 (S0 \15\:S0) resistor r=0.143 c=0
Rk23 (\15\:S0 \16\:S0) resistor r=0.4525 c=0
Rk21 (D \4\:D) resistor r=0.01986 c=0
Rk9 (\4\:A A) resistor r=0.1913 c=0
Rk31 (\2\:VDD \3\:VDD) resistor r=0.2932 c=0
Rk32 (\3\:VDD \4\:VDD) resistor r=0.3584 c=0
Rk33 (\4\:VDD \5\:VDD) resistor r=0.2622 c=0
Rk34 (\5\:VDD \6\:VDD) resistor r=0.6056 c=0
Rk37 (\8\:VDD VDD) resistor r=0.5515 c=0
Rk36 (\6\:VDD \8\:VDD) resistor r=0.1117 c=0
Rk38 (\3\:VDD \10\:VDD) resistor r=0.2729 c=0
Rk39 (\5\:VDD \12\:VDD) resistor r=0.04331 c=0
Rk5 (\8\:n2 \10\:n2) resistor r=1.0286 c=0
Rk6 (\10\:n2 \12\:n2) resistor r=0.4267 c=0
Rk1 (\6\:S1b \7\:S1b) resistor r=0.8716 c=0
Rk2 (\9\:S1b \10\:S1b) resistor r=0.1566 c=0
Rk3 (\10\:S1b \12\:S1b) resistor r=0.1913 c=0
Rk10 (\2\:n0 \3\:n0) resistor r=0.8572 c=0
Rk11 (\3\:n0 \5\:n0) resistor r=1.6974 c=0
Rk12 (\3\:n0 \7\:n0) resistor r=0.1728 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.4869 c=0
Rk18 (\2\:n1 \4\:n1) resistor r=2.6238 c=0
Rk19 (\4\:n1 \6\:n1) resistor r=0.4302 c=0
Rk20 (\2\:n1 \8\:n1) resistor r=0.6204 c=0
Rk24 (\9\:S0b \10\:S0b) resistor r=0.04795 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.5069 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.4962 c=0
Rk27 (\12\:S0b \13\:S0b) resistor r=0.9893 c=0
Rk28 (\10\:S0b \15\:S0b) resistor r=0.5141 c=0
Rk29 (\11\:S0b \16\:S0b) resistor r=0.1247 c=0
Rk30 (\12\:S0b \17\:S0b) resistor r=0.5379 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=72.3097 c=0
Rl7 (\2\:S1 \5\:S1) resistor r=37.6944 c=0
Rl6 (\3\:S1 \4\:S1) resistor r=124.611 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=211.505 c=0
Rl23 (\1\:C \2\:C) resistor r=77.6148 c=0
Rl24 (\2\:C \3\:C) resistor r=123.769 c=0
Rl22 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl21 (\1\:B \2\:B) resistor r=173.077 c=0
Rl32 (\9\:S0 \10\:S0) resistor r=171.846 c=0
Rl33 (\10\:S0 \11\:S0) resistor r=29.5379 c=0
Rl27 (\5\:S0 \6\:S0) resistor r=26.1559 c=0
Rl29 (\7\:S0 \8\:S0) resistor r=116.54 c=0
Rl28 (\6\:S0 \7\:S0) resistor r=201.031 c=0
Rl20 (\3\:S0 \4\:S0) resistor r=39.1533 c=0
Rl17 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl30 (\1\:D \2\:D) resistor r=112.23 c=0
Rl31 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl15 (\1\:A \2\:A) resistor r=148.769 c=0
Rl16 (\2\:A \3\:A) resistor r=52.6149 c=0
Rl3 (\4\:S1b \5\:S1b) resistor r=26.1559 c=0
Rl2 (\3\:S1b \4\:S1b) resistor r=92.2733 c=0
Rl1 (S1b \2\:S1b) resistor r=29.5379 c=0
Rl26 (\6\:S0b \7\:S0b) resistor r=29.5379 c=0
Rl25 (\4\:S0b \5\:S0b) resistor r=39.1533 c=0
Rl18 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl19 (\2\:S0b \3\:S0b) resistor r=172.68 c=0
Rz3 (\4\:Y \3\:Y) resistor r=75 c=0
Rz12 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz10 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz11 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\12\:n2 \11\:n2) resistor r=75 c=0
Rz1 (\11\:S1b \12\:S1b) resistor r=75 c=0
Rz4 (n0 \2\:n0) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz6 (n1 \2\:n1) resistor r=75 c=0
Rz7 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz8 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry3 (\2\:Y \1\:Y) resistor r=62 c=0
Ry13 (\5\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry14 (\6\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry15 (\9\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry16 (\10\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry9 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry2 (\10\:n2 \9\:n2) resistor r=62 c=0
Ry1 (\8\:S1b \9\:S1b) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry7 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry8 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx4 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx9 (\7\:S0 \12\:S0) resistor r=45 c=0
Rx10 (\4\:S0 \13\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \14\:S0) resistor r=45 c=0
Rx13 (\10\:S0 \15\:S0) resistor r=45 c=0
Rx14 (\6\:S0 \16\:S0) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx6 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\8\:n2 n2) resistor r=45 c=0
Rx1 (\4\:S1b \6\:S1b) resistor r=45 c=0
Rx2 (\2\:S1b \7\:S1b) resistor r=45 c=0
Rx3 (\3\:S1b \10\:S1b) resistor r=45 c=0
Rx15 (\2\:S0b \13\:S0b) resistor r=45 c=0
Rx16 (\7\:S0b \16\:S0b) resistor r=45 c=0
Rx17 (\5\:S0b \17\:S0b) resistor r=45 c=0
mn10 (\11\:n2 S1b \8\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=3.553e-14 ps=6.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.45e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn11 (\11\:n2 \6\:S1 \3\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=3.553e-14 ps=8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\11\:S1b \5\:S1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0468e-13 ad=2.61e-14 ps=1.63e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn12 (\3\:Y n2 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.0401e-13 ad=4.16e-14 ps=1.605e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.33462e-07 sb=1.32769e-06 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn2 (n3 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0335e-13 ad=6.815e-14 ps=1.58e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn3 (n0 \3\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=6.815e-14 \
        ad=2.32e-14 ps=1.23e-06 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.665e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn5 (n0 \3\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.87e-06 sb=1.995e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn4 (n5 \1\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.418e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=1.89e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (n7 \3\:C \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.418e-14 ad=5.148e-14 ps=1.22e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.51e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn7 (n1 \4\:S0b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=5.148e-14 \
        ad=3.045e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=1.11e-06 sd=160n sca=11.4452 scb=0.0112553 scc=0.00042156 m=(1)
mn9 (n1 \5\:S0 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.958e-14 \
        ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.55e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn8 (n9 \3\:D \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.873e-14 ad=1.958e-14 ps=1.1e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.75e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn0 (\14\:S0b \11\:S0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.873e-14 ad=3.263e-14 ps=1.1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mp11 (\5\:n1 \5\:S1b \9\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.4e-07 sd=160n sca=43.2688 \
        scb=0.0280932 scc=0.00553387 m=(1)
mp1 (\8\:S1b \1\:S1 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.093e-13 ad=3.01e-14 ps=2.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.6e-07 sd=160n sca=42.6522 \
        scb=0.0278545 scc=0.00553378 m=(1)
mp12 (\1\:Y n2 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0641e-13 ad=6.24e-14 ps=1.955e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17756e-07 sb=1.00038e-06 sd=160n sca=28.7024 \
        scb=0.0198217 scc=0.00315848 m=(2)
mp2 (n4 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0353e-13 ad=4.73e-14 ps=1.7e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.12674e-07 sb=2e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp3 (\6\:n0 \1\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.515e-14 ps=8.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.77674e-07 sb=2e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp5 (\6\:n0 S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.408e-14 \
        ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.13267e-06 sb=2e-06 sd=160n sca=10.9013 scb=0.00874909 \
        scc=0.000160703 m=(1)
mp4 (n6 \3\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1745e-13 ad=4.408e-14 ps=1.77e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38267e-06 sb=1.86e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp6 (n8 \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1745e-13 ad=3.763e-14 ps=1.77e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81767e-06 sb=1.425e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp7 (\7\:n1 \8\:S0 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=9.783e-14 ps=7.8e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.93349e-06 sb=1.205e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp9 (\7\:n1 \6\:S0b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=9.783e-14 ps=5.7e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.05e-07 sd=160n sca=11.0244 \
        scb=0.00877578 scc=0.000160706 m=(1)
mp8 (n10 \1\:D \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.708e-14 ad=1.505e-14 ps=1.24e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.9e-07 sd=160n sca=11.3376 scb=0.00888972 \
        scc=0.00016074 m=(1)
mp0 (\8\:S0b \9\:S0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.708e-14 ad=3.01e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=16.2936 scb=0.0162078 \
        scc=0.00030445 m=(1)
ends MX4X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:33:52 2012 )
// Library name: gsclib045
// Cell name: MX4X4
// View name: extracted

simulator lang=spectre

subckt MX4X4 A B C D S0 S1 VDD VSS Y
mp10 (\17\:n2 \4\:S1 \4\:n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=6.24e-14 ps=1.21e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=3.7e-07 sd=160n sca=32.1279 \
        scb=0.0214025 scc=0.00336348 m=(1)
C1 (S1 VSS) capacitor c=5.97295e-17
C2 (C VSS) capacitor c=5.28808e-17
C3 (Y VSS) capacitor c=2.17979e-16
C4 (B VSS) capacitor c=5.14883e-17
C5 (S0 VSS) capacitor c=4.63883e-17
C6 (D VSS) capacitor c=4.77777e-17
C7 (A VSS) capacitor c=3.31868e-17
C8 (VDD VSS) capacitor c=3.4016e-16
C9 (n2 VSS) capacitor c=2.70268e-16
C10 (S1b VSS) capacitor c=2.89077e-17
C11 (n0 VSS) capacitor c=1.44365e-16
C12 (n1 VSS) capacitor c=3.66937e-16
C13 (n3 VSS) capacitor c=5.40749e-18
C14 (S0b VSS) capacitor c=3.70591e-17
C15 (n5 VSS) capacitor c=1.48975e-18
C16 (n7 VSS) capacitor c=8.48361e-18
C17 (n9 VSS) capacitor c=7.08461e-20
C18 (n4 VSS) capacitor c=5.34832e-18
C19 (n6 VSS) capacitor c=5.45315e-18
C20 (n8 VSS) capacitor c=1.13715e-17
C21 (\10\:S0 VSS) capacitor c=3.57011e-17
C22 (\1\:D VSS) capacitor c=5.36264e-17
C23 (\6\:S0b VSS) capacitor c=5.36718e-17
C24 (\9\:S0 VSS) capacitor c=3.63076e-17
C25 (\3\:C VSS) capacitor c=3.7817e-17
C26 (\3\:B VSS) capacitor c=4.66442e-17
C27 (\1\:S0 VSS) capacitor c=3.66115e-17
C28 (\1\:A VSS) capacitor c=5.42672e-17
C29 (\1\:S1 VSS) capacitor c=3.872e-17
C30 (\3\:S1b VSS) capacitor c=4.57e-17
C31 (\4\:S1 VSS) capacitor c=5.76975e-17
C32 (\12\:S0 VSS) capacitor c=1.91023e-17
C33 (\3\:D VSS) capacitor c=3.72416e-17
C34 (\5\:S0 VSS) capacitor c=2.83787e-17
C35 (\4\:S0b VSS) capacitor c=4.1374e-17
C36 (\1\:C VSS) capacitor c=3.91692e-17
C37 (\1\:B VSS) capacitor c=6.7449e-17
C38 (\3\:S0 VSS) capacitor c=6.74926e-17
C39 (\3\:S0b VSS) capacitor c=6.47095e-17
C40 (\3\:A VSS) capacitor c=2.98639e-17
C41 (\5\:S1 VSS) capacitor c=3.24016e-17
C42 (\6\:S1 VSS) capacitor c=3.23109e-17
C43 (\11\:S0 VSS) capacitor c=3.14124e-17
C44 (\2\:D VSS) capacitor c=4.21955e-17
C45 (\7\:S0b VSS) capacitor c=3.31883e-17
C46 (\6\:S0 VSS) capacitor c=4.34677e-17
C47 (\5\:S0b VSS) capacitor c=3.68684e-17
C48 (\8\:S0 VSS) capacitor c=3.62967e-17
C49 (\2\:C VSS) capacitor c=5.83709e-17
C50 (\2\:B VSS) capacitor c=6.37096e-17
C51 (\4\:S0 VSS) capacitor c=4.78508e-17
C52 (\2\:S0b VSS) capacitor c=5.62619e-17
C53 (\2\:S0 VSS) capacitor c=3.35061e-17
C54 (\2\:A VSS) capacitor c=3.92171e-17
C55 (\8\:n2 VSS) capacitor c=1.33017e-17
C56 (\2\:S1 VSS) capacitor c=5.99467e-17
C57 (\6\:S1b VSS) capacitor c=4.00376e-17
C58 (\5\:S1b VSS) capacitor c=3.08778e-17
C59 (\2\:S1b VSS) capacitor c=2.78877e-17
C60 (\8\:S0b VSS) capacitor c=8.84239e-18
C61 (\10\:VDD VSS) capacitor c=3.51472e-17
C62 (\5\:n1 VSS) capacitor c=1.05943e-16
C63 (\12\:VDD VSS) capacitor c=3.91991e-17
C64 (\8\:n0 VSS) capacitor c=4.76084e-17
C65 (\9\:S1b VSS) capacitor c=6.60814e-17
C66 (\7\:n1 VSS) capacitor c=9.52719e-17
C67 (\17\:n2 VSS) capacitor c=1.90675e-16
C68 (\4\:n0 VSS) capacitor c=2.42076e-16
C69 (\1\:VDD VSS) capacitor c=8.44631e-17
C70 (\14\:S0b VSS) capacitor c=9.6249e-17
C71 (\13\:S1b VSS) capacitor c=5.34998e-17
C72 (\3\:n1 VSS) capacitor c=3.54558e-16
C73 (\19\:n2 VSS) capacitor c=9.54176e-17
C74 (\6\:n0 VSS) capacitor c=6.78917e-17
C75 (\4\:S1b VSS) capacitor c=2.29473e-17
C76 (\3\:S1 VSS) capacitor c=6.97231e-17
C77 (\7\:S0 VSS) capacitor c=4.29787e-17
C78 (\7\:S1b VSS) capacitor c=1.4927e-16
C79 (\8\:S1b VSS) capacitor c=1.21936e-16
C80 (\12\:S1b VSS) capacitor c=6.82902e-17
C81 (\7\:S1 VSS) capacitor c=6.43275e-17
C82 (\16\:n2 VSS) capacitor c=1.42981e-16
C83 (\4\:A VSS) capacitor c=7.46042e-17
C84 (\3\:n0 VSS) capacitor c=3.08386e-16
C85 (\5\:B VSS) capacitor c=5.27405e-17
C86 (\13\:S0 VSS) capacitor c=1.06652e-16
C87 (\14\:S0 VSS) capacitor c=1.05723e-16
C88 (\15\:S0 VSS) capacitor c=7.94409e-17
C89 (\4\:C VSS) capacitor c=6.74426e-17
C90 (\4\:D VSS) capacitor c=4.47471e-17
C91 (\17\:S0 VSS) capacitor c=8.1725e-17
C92 (\18\:S0 VSS) capacitor c=6.02724e-17
C93 (\10\:S0b VSS) capacitor c=8.70827e-17
C94 (\11\:S0b VSS) capacitor c=9.53787e-17
C95 (\12\:S0b VSS) capacitor c=1.62555e-16
C96 (\13\:S0b VSS) capacitor c=1.25946e-16
C97 (\16\:S0b VSS) capacitor c=2.40498e-17
C98 (\17\:S0b VSS) capacitor c=8.36151e-17
C99 (\3\:VDD VSS) capacitor c=2.86116e-17
C100 (\5\:VDD VSS) capacitor c=2.18319e-17
C101 (\6\:VDD VSS) capacitor c=1.48983e-16
Rk5 (\7\:S1 S1) resistor r=0.1159 c=0
Rk24 (C \4\:C) resistor r=0.2114 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.3107 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.4411 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.0675 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.5362 c=0
Rk59 (\9\:VSS VSS) resistor r=0.5514 c=0
Rk58 (\6\:VSS \9\:VSS) resistor r=0.1267 c=0
Rk60 (\3\:VSS \11\:VSS) resistor r=0.2894 c=0
Rk61 (\5\:VSS \13\:VSS) resistor r=0.2171 c=0
Rk19 (\4\:B \5\:B) resistor r=0.003606 c=0
Rk20 (\6\:B B) resistor r=0.003709 c=0
Rk21 (\5\:B \6\:B) resistor r=0.1016 c=0
Rk22 (\13\:S0 \14\:S0) resistor r=0.4736 c=0
Rk23 (\14\:S0 \15\:S0) resistor r=0.4382 c=0
Rk29 (S0 \16\:S0) resistor r=0.1443 c=0
Rk30 (\16\:S0 \17\:S0) resistor r=0.5237 c=0
Rk31 (\16\:S0 \18\:S0) resistor r=0.02672 c=0
Rk28 (D \4\:D) resistor r=0.1552 c=0
Rk14 (A \4\:A) resistor r=0.027 c=0
Rk39 (\2\:VDD \3\:VDD) resistor r=0.2957 c=0
Rk40 (\3\:VDD \4\:VDD) resistor r=0.4562 c=0
Rk41 (\4\:VDD \5\:VDD) resistor r=0.1352 c=0
Rk42 (\5\:VDD \6\:VDD) resistor r=0.4835 c=0
Rk46 (\9\:VDD VDD) resistor r=0.5514 c=0
Rk45 (\6\:VDD \9\:VDD) resistor r=0.1267 c=0
Rk47 (\3\:VDD \11\:VDD) resistor r=0.244 c=0
Rk48 (\5\:VDD \13\:VDD) resistor r=0.1792 c=0
Rk6 (\16\:n2 \18\:n2) resistor r=0.9507 c=0
Rk7 (\18\:n2 \20\:n2) resistor r=0.4982 c=0
Rk1 (\7\:S1b \8\:S1b) resistor r=0.8625 c=0
Rk2 (\10\:S1b \11\:S1b) resistor r=0.1861 c=0
Rk3 (\11\:S1b \12\:S1b) resistor r=0.01531 c=0
Rk4 (\11\:S1b \14\:S1b) resistor r=0.1821 c=0
Rk15 (\2\:n0 \3\:n0) resistor r=0.8047 c=0
Rk16 (\3\:n0 \5\:n0) resistor r=1.8858 c=0
Rk17 (\5\:n0 \7\:n0) resistor r=0.5293 c=0
Rk18 (\3\:n0 \9\:n0) resistor r=0.1867 c=0
Rk25 (\2\:n1 \4\:n1) resistor r=2.4956 c=0
Rk26 (\2\:n1 \6\:n1) resistor r=0.566 c=0
Rk27 (\4\:n1 \8\:n1) resistor r=0.4539 c=0
Rk32 (\9\:S0b \10\:S0b) resistor r=0.04786 c=0
Rk33 (\10\:S0b \11\:S0b) resistor r=0.4929 c=0
Rk34 (\11\:S0b \12\:S0b) resistor r=0.552 c=0
Rk35 (\12\:S0b \13\:S0b) resistor r=0.7466 c=0
Rk36 (\10\:S0b \15\:S0b) resistor r=0.8241 c=0
Rk37 (\11\:S0b \16\:S0b) resistor r=0.05728 c=0
Rk38 (\12\:S0b \17\:S0b) resistor r=0.4298 c=0
Rl5 (\1\:S1 \2\:S1) resistor r=65.1797 c=0
Rl8 (\2\:S1 \5\:S1) resistor r=33.4251 c=0
Rl7 (\3\:S1 \4\:S1) resistor r=119.209 c=0
Rl9 (\3\:S1 \6\:S1) resistor r=30.4507 c=0
Rl6 (\2\:S1 \3\:S1) resistor r=233.082 c=0
Rl33 (\2\:C \3\:C) resistor r=102.615 c=0
Rl32 (\1\:C \2\:C) resistor r=109.98 c=0
Rl31 (\2\:B \3\:B) resistor r=103.297 c=0
Rl30 (\1\:B \2\:B) resistor r=107.692 c=0
Rl42 (\10\:S0 \11\:S0) resistor r=169.923 c=0
Rl43 (\11\:S0 \12\:S0) resistor r=39.1533 c=0
Rl35 (\5\:S0 \6\:S0) resistor r=26.1559 c=0
Rl29 (\3\:S0 \4\:S0) resistor r=31.9251 c=0
Rl26 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl38 (\7\:S0 \9\:S0) resistor r=115.066 c=0
Rl36 (\6\:S0 \7\:S0) resistor r=114.917 c=0
Rl37 (\7\:S0 \8\:S0) resistor r=92.233 c=0
Rl40 (\1\:D \2\:D) resistor r=98.7687 c=0
Rl41 (\2\:D \3\:D) resistor r=110.307 c=0
Rl24 (\1\:A \2\:A) resistor r=162.23 c=0
Rl25 (\2\:A \3\:A) resistor r=46.8456 c=0
Rl16 (n2 \8\:n2) resistor r=1.2301 c=0
Rl1 (S1b \2\:S1b) resistor r=26.1559 c=0
Rl2 (\3\:S1b \4\:S1b) resistor r=27.5863 c=0
Rl4 (\4\:S1b \6\:S1b) resistor r=85.3353 c=0
Rl3 (\4\:S1b \5\:S1b) resistor r=5.8511 c=0
Rl39 (\6\:S0b \7\:S0b) resistor r=28.079 c=0
Rl34 (\4\:S0b \5\:S0b) resistor r=44.9225 c=0
Rl27 (S0b \2\:S0b) resistor r=56.9251 c=0
Rl28 (\2\:S0b \3\:S0b) resistor r=149.816 c=0
Rz13 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\4\:VDD \1\:VDD) resistor r=6.25 c=0
Rz12 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz2 (\20\:n2 \19\:n2) resistor r=75 c=0
Rz1 (\13\:S1b \14\:S1b) resistor r=75 c=0
Rz5 (n0 \2\:n0) resistor r=75 c=0
Rz6 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz7 (n1 \2\:n1) resistor r=75 c=0
Rz8 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz9 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry16 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry10 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry2 (\18\:n2 \17\:n2) resistor r=31 c=0
Ry1 (\9\:S1b \10\:S1b) resistor r=62 c=0
Ry5 (\4\:n0 \5\:n0) resistor r=20.6667 c=0
Ry6 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry7 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry8 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry9 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx4 (\2\:S1 \7\:S1) resistor r=45 c=0
Rx11 (\2\:C \4\:C) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx8 (\8\:S0 \13\:S0) resistor r=45 c=0
Rx9 (\4\:S0 \14\:S0) resistor r=45 c=0
Rx10 (\2\:S0 \15\:S0) resistor r=45 c=0
Rx13 (\6\:S0 \17\:S0) resistor r=45 c=0
Rx14 (\11\:S0 \18\:S0) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx6 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\16\:n2 \8\:n2) resistor r=45 c=0
Rx1 (\5\:S1b \7\:S1b) resistor r=45 c=0
Rx2 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx3 (\6\:S1b \12\:S1b) resistor r=45 c=0
Rx15 (\2\:S0b \13\:S0b) resistor r=45 c=0
Rx16 (\7\:S0b \16\:S0b) resistor r=45 c=0
Rx17 (\5\:S0b \17\:S0b) resistor r=45 c=0
mn10 (\19\:n2 S1b \6\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.8e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn11 (\19\:n2 \6\:S1 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=4.68e-14 ps=1.03e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.55e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(1)
mn1 (\13\:S1b \5\:S1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.523e-14 ad=2.9e-14 ps=1.5e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn12_1__rcx (Y n2 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.844e-14 ad=4.16e-14 ps=1.4525e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65192e-07 sb=1.45817e-06 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn2 (n3 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=5.945e-14 ps=1.53e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn0 (\14\:S0b \12\:S0 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=2.03e-14 ps=1.19e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn3 (n0 \3\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=5.945e-14 \
        ad=2.465e-14 ps=1.11e-06 pd=6.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.915e-06 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn5 (n0 \3\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.845e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn4 (n5 \1\:B \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.57e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.74e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn6 (n7 \1\:C \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.57e-14 ad=4.495e-14 ps=9.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.475e-06 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn7 (n1 \4\:S0b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=4.495e-14 \
        ad=3.045e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.12e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn9 (n1 \5\:S0 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.683e-14 \
        ad=3.045e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.65e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn8 (n9 \3\:D \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=2.683e-14 ps=1.19e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mp11 (\7\:n1 \3\:S1b \17\:n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.65e-07 sd=160n sca=31.0054 \
        scb=0.0203755 scc=0.00336103 m=(1)
mp1 (\9\:S1b \1\:S1 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1785e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp12 (Y n2 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.509e-14 \
        ad=6.24e-14 ps=1.525e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.99551e-07 sb=1.16763e-06 sd=160n sca=30.5009 scb=0.0202006 \
        scc=0.00336097 m=(4)
mp2 (n4 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.93e-14 ad=4.945e-14 ps=1.4e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.16512e-07 sb=2e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp0 (\8\:S0b \10\:S0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.6973 scb=0.00997937 \
        scc=0.000112947 m=(1)
mp3 (\8\:n0 \1\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.655e-14 ps=8.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.91512e-07 sb=2e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp5 (\8\:n0 S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.548e-14 \
        ad=3.655e-14 ps=7.6e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.20651e-06 sb=2e-06 sd=160n sca=10.4315 scb=0.0078915 \
        scc=0.00010471 m=(1)
mp4 (n6 \3\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=3.548e-14 ps=1.14e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41651e-06 sb=1.815e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp6 (n8 \3\:C \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=8.493e-14 ps=1.14e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65884e-06 sb=1.5e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp7 (\5\:n1 \9\:S0 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.493e-14 ad=5.483e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84302e-06 sb=1.06e-06 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp9 (\5\:n1 \6\:S0b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.483e-14 ps=5.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9686e-06 sb=7.6e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp8 (n10 \1\:D \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=1.72e-14 ps=1.33e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=10.4315 scb=0.0078915 \
        scc=0.00010471 m=(1)
ends MX4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:34:29 2012 )
// Library name: gsclib045
// Cell name: MX4XL
// View name: extracted

simulator lang=spectre

subckt MX4XL A B C D S0 S1 VDD VSS Y
mp12 (\3\:Y n2 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.623e-14 ad=3.87e-14 ps=1.46e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.35e-07 sd=160n sca=53.9205 \
        scb=0.0402944 scc=0.00632464 m=(1)
C1 (S1 VSS) capacitor c=4.50353e-17
C2 (Y VSS) capacitor c=2.43904e-17
C3 (C VSS) capacitor c=6.56242e-17
C4 (S0 VSS) capacitor c=2.87956e-17
C5 (VDD VSS) capacitor c=2.62011e-16
C6 (D VSS) capacitor c=7.67394e-17
C7 (A VSS) capacitor c=9.15705e-17
C8 (n2 VSS) capacitor c=4.36333e-17
C9 (S1b VSS) capacitor c=4.62485e-17
C10 (n1 VSS) capacitor c=4.55134e-17
C11 (n0 VSS) capacitor c=8.61143e-17
C12 (n9 VSS) capacitor c=3.69657e-18
C13 (S0b VSS) capacitor c=5.76988e-17
C14 (n5 VSS) capacitor c=1.47257e-18
C15 (n3 VSS) capacitor c=3.08146e-20
C16 (n10 VSS) capacitor c=1.03247e-18
C17 (n8 VSS) capacitor c=8.51558e-19
C18 (n4 VSS) capacitor c=2.23739e-18
C19 (\8\:S0 VSS) capacitor c=2.58372e-17
C20 (\1\:A VSS) capacitor c=4.54549e-17
C21 (\7\:S0 VSS) capacitor c=2.5395e-17
C22 (\5\:S0b VSS) capacitor c=4.67198e-17
C23 (\1\:B VSS) capacitor c=4.34423e-17
C24 (\3\:C VSS) capacitor c=3.45035e-17
C25 (\2\:S0 VSS) capacitor c=6.43467e-17
C26 (\2\:S0b VSS) capacitor c=5.78002e-17
C27 (\4\:D VSS) capacitor c=4.69167e-17
C28 (\1\:S1 VSS) capacitor c=5.93757e-17
C29 (\4\:S1 VSS) capacitor c=3.14006e-17
C30 (\10\:S0 VSS) capacitor c=4.27481e-17
C31 (\3\:A VSS) capacitor c=5.74412e-17
C32 (\7\:S0b VSS) capacitor c=8.70149e-17
C33 (\6\:S0 VSS) capacitor c=5.44174e-17
C34 (\3\:B VSS) capacitor c=3.88154e-17
C35 (\1\:C VSS) capacitor c=6.52813e-17
C36 (\3\:S0b VSS) capacitor c=6.75416e-17
C37 (\1\:S0 VSS) capacitor c=8.38131e-17
C38 (\1\:D VSS) capacitor c=2.92874e-17
C39 (\3\:S1b VSS) capacitor c=3.77422e-17
C40 (\5\:S1 VSS) capacitor c=3.1894e-17
C41 (\6\:S1 VSS) capacitor c=3.16854e-17
C42 (\3\:n2 VSS) capacitor c=2.07904e-17
C43 (\9\:S0 VSS) capacitor c=3.92108e-17
C44 (\2\:A VSS) capacitor c=6.04315e-17
C45 (\4\:S0 VSS) capacitor c=3.35853e-17
C46 (\8\:S0b VSS) capacitor c=3.11579e-17
C47 (\6\:S0b VSS) capacitor c=4.04455e-17
C48 (\2\:B VSS) capacitor c=4.34725e-17
C49 (\2\:C VSS) capacitor c=6.01269e-17
C50 (\4\:S0b VSS) capacitor c=5.83151e-17
C51 (\3\:S0 VSS) capacitor c=2.40018e-17
C52 (\3\:D VSS) capacitor c=1.80539e-17
C53 (\4\:S1b VSS) capacitor c=3.61765e-17
C54 (\2\:S1b VSS) capacitor c=1.99077e-17
C55 (\3\:S1 VSS) capacitor c=3.94435e-17
C56 (\2\:n2 VSS) capacitor c=2.9244e-17
C57 (\13\:S0b VSS) capacitor c=6.05909e-17
C58 (\1\:VDD VSS) capacitor c=5.62804e-17
C59 (\3\:n0 VSS) capacitor c=2.55344e-16
C60 (\10\:VDD VSS) capacitor c=3.39744e-17
C61 (\4\:n1 VSS) capacitor c=8.06986e-17
C62 (\12\:VDD VSS) capacitor c=3.18957e-17
C63 (\5\:n0 VSS) capacitor c=1.98453e-16
C64 (\4\:n2 VSS) capacitor c=2.59803e-16
C65 (\8\:n1 VSS) capacitor c=7.49795e-17
C66 (\7\:S1b VSS) capacitor c=1.127e-16
C67 (\14\:VDD VSS) capacitor c=1.74791e-17
C68 (\3\:Y VSS) capacitor c=2.26859e-17
C69 (\3\:VDD VSS) capacitor c=1.33232e-16
C70 (\9\:S0b VSS) capacitor c=1.21985e-17
C71 (\7\:n0 VSS) capacitor c=6.93926e-17
C72 (\7\:n2 VSS) capacitor c=6.51163e-17
C73 (\6\:n1 VSS) capacitor c=1.31617e-16
C74 (\9\:S1b VSS) capacitor c=8.95214e-17
C75 (\1\:Y VSS) capacitor c=6.09e-17
C76 (\2\:S1 VSS) capacitor c=5.2605e-17
C77 (\2\:D VSS) capacitor c=4.09492e-17
C78 (\5\:S0 VSS) capacitor c=5.83632e-17
C79 (\7\:S1 VSS) capacitor c=6.79413e-17
C80 (\6\:n2 VSS) capacitor c=2.28149e-16
C81 (\5\:S1b VSS) capacitor c=1.2231e-16
C82 (\6\:S1b VSS) capacitor c=1.30477e-16
C83 (\5\:D VSS) capacitor c=3.7027e-17
C84 (\3\:n1 VSS) capacitor c=1.80402e-16
C85 (\4\:C VSS) capacitor c=4.46482e-17
C86 (\4\:B VSS) capacitor c=1.14268e-16
C87 (\11\:S0 VSS) capacitor c=3.32061e-17
C88 (\12\:S0 VSS) capacitor c=1.34821e-16
C89 (\13\:S0 VSS) capacitor c=2.09279e-16
C90 (\4\:A VSS) capacitor c=5.30503e-17
C91 (\11\:S0b VSS) capacitor c=1.15594e-16
C92 (\12\:S0b VSS) capacitor c=1.36034e-16
C93 (\15\:S0b VSS) capacitor c=7.85713e-17
C94 (\16\:S0b VSS) capacitor c=7.72675e-17
C95 (\17\:S0b VSS) capacitor c=5.65955e-17
C96 (\18\:S0b VSS) capacitor c=2.26978e-17
C97 (\5\:VDD VSS) capacitor c=1.85102e-17
C98 (\7\:VDD VSS) capacitor c=2.40688e-17
C99 (\9\:VDD VSS) capacitor c=1.83745e-17
Rk3 (\7\:S1 S1) resistor r=0.1247 c=0
Rk1 (\2\:Y Y) resistor r=0.2486 c=0
Rk2 (Y \4\:Y) resistor r=0.06089 c=0
Rk15 (B \4\:B) resistor r=0.008026 c=0
Rk14 (C \4\:C) resistor r=0.1893 c=0
Rk20 (\11\:S0 S0) resistor r=0.02706 c=0
Rk19 (\11\:S0 \12\:S0) resistor r=0.2477 c=0
Rk21 (\12\:S0 \13\:S0) resistor r=1.314 c=0
Rk32 (\2\:VDD \4\:VDD) resistor r=0.5361 c=0
Rk33 (\4\:VDD \5\:VDD) resistor r=0.3501 c=0
Rk34 (\5\:VDD \6\:VDD) resistor r=0.0992 c=0
Rk35 (\6\:VDD \7\:VDD) resistor r=0.346 c=0
Rk36 (\7\:VDD \8\:VDD) resistor r=0.356 c=0
Rk38 (\9\:VDD VDD) resistor r=0.1175 c=0
Rk37 (\8\:VDD \9\:VDD) resistor r=0.4338 c=0
Rk39 (\5\:VDD \11\:VDD) resistor r=0.04333 c=0
Rk40 (\7\:VDD \13\:VDD) resistor r=0.1278 c=0
Rk41 (\9\:VDD \15\:VDD) resistor r=0.225 c=0
Rk9 (D \5\:D) resistor r=0.07516 c=0
Rk24 (\4\:A A) resistor r=0.05441 c=0
Rk42 (\2\:VSS \4\:VSS) resistor r=0.5197 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.1754 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.3809 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.3962 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.4338 c=0
Rk48 (\9\:VSS VSS) resistor r=0.04992 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.06754 c=0
Rk49 (\5\:VSS \11\:VSS) resistor r=0.235 c=0
Rk50 (\6\:VSS \13\:VSS) resistor r=0.2303 c=0
Rk51 (\8\:VSS \15\:VSS) resistor r=0.07416 c=0
Rk4 (\5\:n2 \6\:n2) resistor r=1.721 c=0
Rk5 (\5\:n2 \8\:n2) resistor r=0.3677 c=0
Rk6 (\5\:S1b \6\:S1b) resistor r=0.6762 c=0
Rk7 (\6\:S1b \8\:S1b) resistor r=0.5886 c=0
Rk8 (\8\:S1b \10\:S1b) resistor r=0.4207 c=0
Rk10 (\2\:n1 \3\:n1) resistor r=0.3281 c=0
Rk11 (\3\:n1 \5\:n1) resistor r=0.4304 c=0
Rk12 (\3\:n1 \7\:n1) resistor r=0.944 c=0
Rk13 (\7\:n1 \9\:n1) resistor r=0.3878 c=0
Rk16 (\2\:n0 \4\:n0) resistor r=0.5144 c=0
Rk17 (\4\:n0 \6\:n0) resistor r=1.5187 c=0
Rk18 (\6\:n0 \8\:n0) resistor r=0.3984 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.04478 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.5759 c=0
Rk27 (\11\:S0b \14\:S0b) resistor r=0.5839 c=0
Rk28 (\12\:S0b \15\:S0b) resistor r=0.591 c=0
Rk29 (\15\:S0b \16\:S0b) resistor r=0.4074 c=0
Rk30 (\16\:S0b \17\:S0b) resistor r=0.2894 c=0
Rk31 (\15\:S0b \18\:S0b) resistor r=0.06119 c=0
Rl6 (\3\:S1 \4\:S1) resistor r=22.4021 c=0
Rl8 (\3\:S1 \6\:S1) resistor r=82.5403 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=139.928 c=0
Rl7 (\2\:S1 \5\:S1) resistor r=30.4507 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=219.844 c=0
Rl19 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl20 (\2\:B \3\:B) resistor r=133.384 c=0
Rl18 (\2\:C \3\:C) resistor r=37.6944 c=0
Rl17 (\1\:C \2\:C) resistor r=134.169 c=0
Rl14 (\1\:S0 \2\:S0) resistor r=193.864 c=0
Rl28 (\8\:S0 \9\:S0) resistor r=30.7692 c=0
Rl29 (\9\:S0 \10\:S0) resistor r=132.881 c=0
Rl15 (\2\:S0 \3\:S0) resistor r=98.7687 c=0
Rl25 (\5\:S0 \7\:S0) resistor r=34.3295 c=0
Rl24 (\5\:S0 \6\:S0) resistor r=197.357 c=0
Rl23 (\4\:S0 \5\:S0) resistor r=14.6916 c=0
Rl12 (\2\:D \4\:D) resistor r=81.5719 c=0
Rl10 (\1\:D \2\:D) resistor r=109.984 c=0
Rl11 (\2\:D \3\:D) resistor r=10.9341 c=0
Rl26 (\1\:A \2\:A) resistor r=103.846 c=0
Rl27 (\2\:A \3\:A) resistor r=60.989 c=0
Rl1 (n2 \2\:n2) resistor r=79.5379 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=29.5379 c=0
Rl9 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl3 (S1b \2\:S1b) resistor r=60.3072 c=0
Rl13 (S0b \2\:S0b) resistor r=60.819 c=0
Rl22 (\7\:S0b \8\:S0b) resistor r=31.9251 c=0
Rl21 (\5\:S0b \6\:S0b) resistor r=71.8456 c=0
Rl16 (\3\:S0b \4\:S0b) resistor r=58.8482 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz10 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz11 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz2 (\7\:n2 \8\:n2) resistor r=75 c=0
Rz3 (\9\:S1b \10\:S1b) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz6 (n0 \2\:n0) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz8 (\9\:S0b \10\:S0b) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry9 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry14 (\3\:VSS \7\:VSS) resistor r=7.75 c=0
Ry15 (\3\:VSS \9\:VSS) resistor r=31 c=0
Ry2 (\4\:n2 \5\:n2) resistor r=62 c=0
Ry3 (\7\:S1b \8\:S1b) resistor r=62 c=0
Ry4 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry5 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry6 (\3\:n0 \4\:n0) resistor r=62 c=0
Ry7 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry8 (\13\:S0b \14\:S0b) resistor r=62 c=0
Rx1 (\3\:S1 \7\:S1) resistor r=45 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx6 (\2\:C \4\:C) resistor r=45 c=0
Rx8 (\9\:S0 \11\:S0) resistor r=45 c=0
Rx9 (\4\:S0 \12\:S0) resistor r=45 c=0
Rx10 (\3\:S0 \13\:S0) resistor r=45 c=0
Rx5 (\3\:D \5\:D) resistor r=45 c=0
Rx11 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:n2 \6\:n2) resistor r=45 c=0
Rx3 (\4\:S1b \5\:S1b) resistor r=45 c=0
Rx4 (\2\:S1b \6\:S1b) resistor r=45 c=0
Rx12 (\8\:S0b \12\:S0b) resistor r=45 c=0
Rx13 (\4\:S0b \16\:S0b) resistor r=45 c=0
Rx14 (S0b \17\:S0b) resistor r=45 c=0
Rx15 (\6\:S0b \18\:S0b) resistor r=45 c=0
mn12 (\1\:Y \3\:n2 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=2.03e-14 ps=1.54e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.35e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (\9\:S1b \6\:S1 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.8e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\7\:n2 \5\:S1 \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn10 (\7\:n2 \3\:S1b \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.61e-14 ps=7.6e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn8 (n9 \1\:D \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.465e-14 ps=5.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn9 (n1 \1\:S0 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.465e-14 \
        ad=2.32e-14 ps=6.3e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.55e-07 sb=1.64e-06 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn0 (\9\:S0b \10\:S0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.73e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1.4e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn7 (n1 \3\:S0b n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.6e-07 sb=1.435e-06 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn6 (n7 \1\:C \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=8.7e-15 ps=7.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.33e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn4 (n5 \3\:B \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.827e-14 ps=7.9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.035e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn5 (n0 \6\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.827e-14 \
        ad=3.48e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.2e-06 sb=7.95e-07 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn3 (n0 \7\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=3.48e-14 ps=4.1e-07 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.485e-06 sb=5.1e-07 sd=160n sca=8.42104 scb=0.00632542 \
        scc=0.000106623 m=(1)
mn2 (n3 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.73e-14 ad=8.7e-15 ps=8.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=4.05e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mp1 (\7\:S1b \4\:S1 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.623e-14 ad=5.053e-14 ps=1.46e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2.35e-07 sd=160n sca=48.3666 \
        scb=0.0308994 scc=0.00589713 m=(1)
mp11 (\8\:n1 S1b \4\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp10 (\4\:n2 \1\:S1 \5\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.483e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp8 (n10 \4\:D \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.505e-14 ps=1.53e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.985e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp9 (\4\:n1 \2\:S0b n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.87e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp7 (\4\:n1 \2\:S0 n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.665e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp3 (\3\:n0 \7\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.73e-14 ps=9.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=6.65e-07 sd=160n sca=25.0948 \
        scb=0.0225758 scc=0.00280689 m=(1)
mp6 (n8 \3\:C \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=4.085e-14 ps=2.09e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.43e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp5 (\3\:n0 \5\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=4.73e-14 ps=6.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=9.3e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp4 (n6 \1\:B \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=2.365e-14 ps=2.09e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.085e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp2 (n4 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=5.16e-14 ps=8.2e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=3.8e-07 sd=160n sca=26.5217 \
        scb=0.023809 scc=0.00280989 m=(1)
mp0 (\13\:S0b \8\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=3.01e-14 ps=8.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=31.0858 scb=0.0314787 \
        scc=0.00302884 m=(1)
ends MX4XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:35:07 2012 )
// Library name: gsclib045
// Cell name: MXI2X1
// View name: extracted

simulator lang=spectre

subckt MXI2X1 A B S0 VDD VSS Y
mp1 (n4 \1\:A \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.265e-14 ps=1.06e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.60064e-07 sd=160n sca=20.3163 \
        scb=0.0196633 scc=0.0012482 m=(1)
mp3 (n6 \3\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.265e-14 ps=1.1e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.35064e-07 sd=160n sca=17.6981 \
        scb=0.0155463 scc=0.00119019 m=(1)
C1 (A VSS) capacitor c=3.3333e-17
C2 (Y VSS) capacitor c=7.67994e-17
C3 (S0 VSS) capacitor c=3.55451e-17
C4 (VDD VSS) capacitor c=9.007e-17
C5 (B VSS) capacitor c=9.15547e-17
C6 (n3 VSS) capacitor c=1.35888e-17
C7 (S0b VSS) capacitor c=4.17524e-17
C8 (n5 VSS) capacitor c=2.2582e-18
C9 (n4 VSS) capacitor c=5.69432e-20
C10 (n6 VSS) capacitor c=4.31185e-18
C11 (\7\:S0 VSS) capacitor c=5.50654e-17
C12 (\3\:B VSS) capacitor c=6.15938e-17
C13 (\1\:S0 VSS) capacitor c=4.31004e-17
C14 (\1\:A VSS) capacitor c=5.1579e-17
C15 (\5\:S0 VSS) capacitor c=3.16395e-17
C16 (\1\:B VSS) capacitor c=8.45537e-17
C17 (\3\:S0 VSS) capacitor c=6.4925e-17
C18 (\3\:S0b VSS) capacitor c=6.24053e-17
C19 (\4\:A VSS) capacitor c=2.22342e-17
C20 (\6\:S0 VSS) capacitor c=5.05051e-17
C21 (\2\:B VSS) capacitor c=6.11864e-17
C22 (\4\:S0 VSS) capacitor c=4.6533e-17
C23 (\2\:S0b VSS) capacitor c=5.21444e-17
C24 (\2\:S0 VSS) capacitor c=3.42022e-17
C25 (\3\:A VSS) capacitor c=1.2991e-17
C26 (\8\:S0b VSS) capacitor c=1.32618e-17
C27 (\1\:VDD VSS) capacitor c=3.53604e-17
C28 (\3\:Y VSS) capacitor c=5.50149e-17
C29 (\6\:VDD VSS) capacitor c=3.88308e-17
C30 (\4\:S0b VSS) capacitor c=8.09681e-17
C31 (\1\:Y VSS) capacitor c=7.15251e-17
C32 (\2\:A VSS) capacitor c=2.19001e-17
C33 (\6\:A VSS) capacitor c=5.94846e-17
C34 (\8\:S0 VSS) capacitor c=2.94426e-17
C35 (\9\:S0 VSS) capacitor c=1.16612e-16
C36 (\10\:S0 VSS) capacitor c=1.31284e-16
C37 (\11\:S0 VSS) capacitor c=3.66049e-17
C38 (\4\:B VSS) capacitor c=4.48397e-17
C39 (\6\:S0b VSS) capacitor c=1.0269e-16
C40 (\7\:S0b VSS) capacitor c=8.42535e-17
C41 (\4\:VDD VSS) capacitor c=3.80932e-17
C42 (\5\:VDD VSS) capacitor c=8.75683e-18
Rk3 (A \6\:A) resistor r=0.01196 c=0
Rk4 (\2\:Y Y) resistor r=0.319 c=0
Rk5 (Y \4\:Y) resistor r=0.2225 c=0
Rk6 (\8\:S0 \9\:S0) resistor r=0.0744 c=0
Rk7 (\9\:S0 \10\:S0) resistor r=0.8995 c=0
Rk9 (\11\:S0 S0) resistor r=0.04523 c=0
Rk8 (\9\:S0 \11\:S0) resistor r=0.1786 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.4078 c=0
Rk20 (\5\:VDD VDD) resistor r=0.09222 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.2578 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.2853 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4799 c=0
Rk16 (\5\:VSS VSS) resistor r=0.09222 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2578 c=0
Rk17 (\5\:VSS \7\:VSS) resistor r=0.2294 c=0
Rk10 (\4\:B B) resistor r=0.01392 c=0
Rk11 (\5\:S0b \6\:S0b) resistor r=0.7007 c=0
Rk12 (\6\:S0b \7\:S0b) resistor r=0.5033 c=0
Rk13 (\6\:S0b \9\:S0b) resistor r=0.0474 c=0
Rl1 (\1\:A \2\:A) resistor r=106.572 c=0
Rl3 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl2 (\2\:A \3\:A) resistor r=3.7301 c=0
Rl11 (\6\:S0 \7\:S0) resistor r=163.441 c=0
Rl10 (\5\:S0 \6\:S0) resistor r=39.1533 c=0
Rl7 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl4 (\1\:S0 \2\:S0) resistor r=24.2328 c=0
Rl9 (\2\:B \3\:B) resistor r=37.7434 c=0
Rl8 (\1\:B \2\:B) resistor r=86.3335 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl6 (\2\:S0b \3\:S0b) resistor r=129.889 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
Rx2 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx4 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx5 (\2\:B \4\:B) resistor r=45 c=0
Rx6 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn1 (n3 \4\:A \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=6.76e-14 ps=8e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.87212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (\1\:Y \3\:S0b n3 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.94e-14 ps=1.04e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=5.82212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (\1\:Y \3\:S0 n5 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 sa=6.8e-07 \
        sb=3.47212e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 \
        m=(1)
mn3 (n5 \1\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:S0b \5\:S0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.4e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mp2 (\3\:Y \1\:S0 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.58e-14 ps=1.05e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=6.80064e-07 sd=160n sca=17.8529 \
        scb=0.0157306 scc=0.0011909 m=(1)
mp4 (\3\:Y S0b n6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=8.58e-14 ps=1.05e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.85e-07 sb=4.15064e-07 sd=160n sca=17.0707 scb=0.0148367 \
        scc=0.00118868 m=(1)
mp0 (\8\:S0b \7\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=14.8 scb=0.0135568 \
        scc=0.000193521 m=(1)
ends MXI2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:35:45 2012 )
// Library name: gsclib045
// Cell name: MXI2X2
// View name: extracted

simulator lang=spectre

subckt MXI2X2 A B S0 VDD VSS Y
mp0 (\7\:S0b \1\:S0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.74e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.80058e-06 sd=160n sca=16.624 \
        scb=0.0167866 scc=0.000347328 m=(1)
C1 (Y VSS) capacitor c=4.93924e-17
C2 (S0 VSS) capacitor c=7.24591e-17
C3 (VDD VSS) capacitor c=1.68749e-16
C4 (A VSS) capacitor c=5.28692e-17
C5 (S0b VSS) capacitor c=6.3165e-17
C6 (n0 VSS) capacitor c=2.03887e-17
C7 (n5 VSS) capacitor c=3.92499e-18
C8 (n1 VSS) capacitor c=1.57153e-16
C9 (n6 VSS) capacitor c=5.64219e-19
C10 (\3\:n0 VSS) capacitor c=4.64479e-17
C11 (\1\:B VSS) capacitor c=3.82599e-17
C12 (\4\:S0 VSS) capacitor c=4.88298e-17
C13 (\1\:A VSS) capacitor c=5.64797e-17
C14 (\1\:S0 VSS) capacitor c=2.34793e-17
C15 (\2\:n0 VSS) capacitor c=3.38909e-17
C16 (\3\:B VSS) capacitor c=3.90577e-17
C17 (\6\:S0 VSS) capacitor c=3.98525e-17
C18 (\3\:S0b VSS) capacitor c=2.9125e-17
C19 (\3\:A VSS) capacitor c=3.29453e-17
C20 (\3\:S0 VSS) capacitor c=4.06884e-17
C21 (\6\:n1 VSS) capacitor c=2.20469e-17
C22 (\2\:B VSS) capacitor c=4.47215e-17
C23 (\7\:S0 VSS) capacitor c=5.65526e-17
C24 (\2\:S0b VSS) capacitor c=7.85964e-17
C25 (\5\:S0 VSS) capacitor c=4.94355e-17
C26 (\2\:A VSS) capacitor c=4.97721e-17
C27 (\2\:S0 VSS) capacitor c=3.66501e-17
C28 (\8\:n1 VSS) capacitor c=2.02292e-17
C29 (\1\:VDD VSS) capacitor c=1.00559e-16
C30 (\1\:Y VSS) capacitor c=7.03883e-17
C31 (\7\:n0 VSS) capacitor c=9.19985e-17
C32 (\10\:VDD VSS) capacitor c=4.17424e-17
C33 (\7\:S0b VSS) capacitor c=7.6696e-17
C34 (\4\:VDD VSS) capacitor c=2.29071e-17
C35 (\12\:n1 VSS) capacitor c=2.6093e-17
C36 (\3\:Y VSS) capacitor c=3.54317e-17
C37 (\4\:n0 VSS) capacitor c=3.11462e-17
C38 (\4\:S0b VSS) capacitor c=1.94579e-17
C39 (\4\:A VSS) capacitor c=6.02194e-17
C40 (\6\:S0b VSS) capacitor c=8.58027e-17
C41 (\9\:S0b VSS) capacitor c=6.22206e-17
C42 (\8\:S0 VSS) capacitor c=5.80664e-17
C43 (\9\:S0 VSS) capacitor c=8.87522e-17
C44 (\10\:S0 VSS) capacitor c=2.4459e-17
C45 (\4\:B VSS) capacitor c=1.01221e-16
C46 (\6\:n0 VSS) capacitor c=1.69243e-16
C47 (\9\:n0 VSS) capacitor c=1.14659e-16
C48 (\10\:n1 VSS) capacitor c=2.31458e-17
C49 (\11\:n1 VSS) capacitor c=3.04978e-17
C50 (\6\:VDD VSS) capacitor c=1.74744e-17
Rk8 (B \4\:B) resistor r=0.001511 c=0
Rk9 (\2\:Y Y) resistor r=0.317 c=0
Rk10 (Y \4\:Y) resistor r=0.0913 c=0
Rk6 (\9\:S0 S0) resistor r=0.5672 c=0
Rk5 (\8\:S0 \9\:S0) resistor r=0.2739 c=0
Rk7 (S0 \10\:S0) resistor r=0.0209 c=0
Rk27 (\1\:VDD \5\:VDD) resistor r=0.09224 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.5294 c=0
Rk30 (\7\:VDD VDD) resistor r=0.04971 c=0
Rk29 (\6\:VDD \7\:VDD) resistor r=0.1197 c=0
Rk32 (\6\:VDD \11\:VDD) resistor r=0.2719 c=0
Rk1 (\4\:A A) resistor r=0.1204 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.1447 c=0
Rk19 (\3\:VSS \5\:VSS) resistor r=0.1272 c=0
Rk20 (\5\:VSS \6\:VSS) resistor r=0.4295 c=0
Rk22 (\7\:VSS VSS) resistor r=0.04971 c=0
Rk21 (\6\:VSS \7\:VSS) resistor r=0.1197 c=0
Rk25 (\6\:VSS \13\:VSS) resistor r=0.2338 c=0
Rk2 (\5\:S0b \6\:S0b) resistor r=0.09588 c=0
Rk3 (\6\:S0b \8\:S0b) resistor r=0.6018 c=0
Rk4 (\6\:S0b \9\:S0b) resistor r=0.5047 c=0
Rk11 (\5\:n0 \6\:n0) resistor r=0.2474 c=0
Rk12 (\6\:n0 \8\:n0) resistor r=0.6275 c=0
Rk13 (\6\:n0 \9\:n0) resistor r=0.8381 c=0
Rk14 (\9\:n1 \10\:n1) resistor r=0.2095 c=0
Rk15 (\10\:n1 \11\:n1) resistor r=0.13 c=0
Rk16 (\10\:n1 \13\:n1) resistor r=0.1223 c=0
Rl9 (\1\:B \2\:B) resistor r=105.002 c=0
Rl10 (\2\:B \3\:B) resistor r=118.464 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=99.2328 c=0
Rl5 (\4\:S0 \5\:S0) resistor r=71.8456 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=29.5379 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=196.846 c=0
Rl3 (\1\:A \2\:A) resistor r=125.692 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl6 (S0b \2\:S0b) resistor r=220.344 c=0
Rl7 (\2\:S0b \3\:S0b) resistor r=39.6664 c=0
Rl17 (n0 \2\:n0) resistor r=31.9846 c=0
Rl18 (\2\:n0 \3\:n0) resistor r=140.385 c=0
Rl15 (n1 \6\:n1) resistor r=13.9496 c=0
Rz2 (\4\:Y \3\:Y) resistor r=75 c=0
Rz8 (\5\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz9 (\7\:VDD \4\:VDD) resistor r=37.5 c=0
Rz7 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\4\:S0b \5\:S0b) resistor r=75 c=0
Rz3 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz4 (\13\:n1 \12\:n1) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry10 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry6 (\5\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry7 (\7\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\7\:S0b \8\:S0b) resistor r=62 c=0
Ry3 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry4 (\9\:n1 \8\:n1) resistor r=62 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\7\:S0 \8\:S0) resistor r=45 c=0
Rx4 (\5\:S0 \9\:S0) resistor r=45 c=0
Rx5 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:S0b \9\:S0b) resistor r=45 c=0
Rx7 (n0 \9\:n0) resistor r=45 c=0
Rx8 (\11\:n1 \6\:n1) resistor r=45 c=0
mn0 (\4\:S0b \3\:S0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=2.03e-14 ps=1.01e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.84931e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn1 (n3 \3\:A \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=3.118e-14 ps=1.01e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.45362e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn2 (\4\:n0 \3\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.32e-14 ps=7.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.19362e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn4 (\4\:n0 \6\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=9.88621e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn3 (n5 \3\:B \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=2.9e-14 ps=1.07e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.43621e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn6 (\3\:Y n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.581e-14 ad=4.16e-14 ps=1.255e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.22596e-07 sb=5.06058e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mn5 (\12\:n1 \2\:n0 \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.025e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65862e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp1 (n4 \1\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.74e-14 ad=1.72e-14 ps=1.15e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.40395e-06 sd=160n sca=11.8288 \
        scb=0.0095548 scc=0.000203669 m=(1)
mp2 (\7\:n0 \4\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.267e-14 ps=5.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.27895e-06 sd=160n sca=11.4379 \
        scb=0.00937809 scc=0.000203588 m=(1)
mp4 (\7\:n0 S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=5.375e-14 \
        ad=5.267e-14 ps=9.3e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.6e-07 sb=9.88953e-07 sd=160n sca=11.2317 scb=0.00932789 \
        scc=0.000203581 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.985e-14 ad=5.375e-14 ps=1.36e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=6.93953e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp6 (\1\:Y n1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=6.24e-14 ps=1.275e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2141e-07 sb=4.64872e-07 sd=160n sca=20.0881 \
        scb=0.0168391 scc=0.00184274 m=(2)
mp5 (\8\:n1 \3\:n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.157e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.23837e-07 sb=1.4e-07 sd=160n sca=31.9266 \
        scb=0.030013 scc=0.00334115 m=(1)
ends MXI2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:36:23 2012 )
// Library name: gsclib045
// Cell name: MXI2X4
// View name: extracted

simulator lang=spectre

subckt MXI2X4 A B S0 VDD VSS Y
mp0 (\6\:S0b \3\:S0 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=3.655e-14 ps=8.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=18.506 scb=0.019899 \
        scc=0.000532288 m=(1)
C1 (Y VSS) capacitor c=2.17044e-16
C2 (VDD VSS) capacitor c=1.68443e-16
C3 (A VSS) capacitor c=6.21468e-17
C4 (S0b VSS) capacitor c=4.12779e-17
C5 (n0 VSS) capacitor c=3.46748e-17
C6 (n5 VSS) capacitor c=3.47383e-18
C7 (n1 VSS) capacitor c=3.07511e-16
C8 (n6 VSS) capacitor c=1.14139e-17
C9 (\3\:n0 VSS) capacitor c=5.654e-17
C10 (\1\:B VSS) capacitor c=4.06219e-17
C11 (\4\:S0 VSS) capacitor c=4.37418e-17
C12 (\1\:A VSS) capacitor c=5.08777e-17
C13 (\3\:S0 VSS) capacitor c=2.37359e-17
C14 (\3\:B VSS) capacitor c=5.89778e-17
C15 (\6\:S0 VSS) capacitor c=5.41704e-17
C16 (\3\:S0b VSS) capacitor c=4.12084e-17
C17 (\3\:A VSS) capacitor c=3.87401e-17
C18 (\1\:S0 VSS) capacitor c=5.58661e-17
C19 (\2\:n0 VSS) capacitor c=5.09053e-17
C20 (\2\:B VSS) capacitor c=5.92155e-17
C21 (\7\:S0 VSS) capacitor c=4.05201e-17
C22 (\2\:S0b VSS) capacitor c=5.09693e-17
C23 (\5\:S0 VSS) capacitor c=2.72897e-17
C24 (\2\:A VSS) capacitor c=5.2113e-17
C25 (\2\:S0 VSS) capacitor c=5.16492e-17
C26 (\20\:n1 VSS) capacitor c=4.50133e-17
C27 (\6\:n0 VSS) capacitor c=9.64501e-17
C28 (\18\:VDD VSS) capacitor c=3.69403e-17
C29 (\6\:S0b VSS) capacitor c=5.97763e-17
C30 (\1\:VDD VSS) capacitor c=8.99552e-17
C31 (\16\:n1 VSS) capacitor c=4.77844e-17
C32 (\1\:Y VSS) capacitor c=1.2842e-16
C33 (\8\:n0 VSS) capacitor c=3.14449e-17
C34 (\8\:S0b VSS) capacitor c=2.07528e-17
C35 (\4\:A VSS) capacitor c=5.50151e-17
C36 (\4\:S0b VSS) capacitor c=9.31742e-17
C37 (\5\:S0b VSS) capacitor c=1.19546e-16
C38 (\8\:S0 VSS) capacitor c=8.7344e-17
C39 (\9\:S0 VSS) capacitor c=1.07756e-16
C40 (\10\:S0 VSS) capacitor c=7.09605e-17
C41 (\4\:B VSS) capacitor c=1.12462e-16
C42 (\4\:n0 VSS) capacitor c=1.85976e-16
C43 (\5\:n0 VSS) capacitor c=2.73106e-16
C44 (\18\:n1 VSS) capacitor c=4.60601e-17
C45 (\19\:n1 VSS) capacitor c=3.43684e-17
C46 (\3\:VDD VSS) capacitor c=1.99547e-16
C47 (\9\:VDD VSS) capacitor c=1.65485e-18
Rk8 (B \4\:B) resistor r=0.002509 c=0
Rk10 (\1\:Y Y) resistor r=0.2301 c=0
Rk6 (\9\:S0 S0) resistor r=0.4955 c=0
Rk5 (\8\:S0 \9\:S0) resistor r=0.4997 c=0
Rk7 (S0 \10\:S0) resistor r=0.01199 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.1402 c=0
Rk37 (\3\:VDD \8\:VDD) resistor r=0.2881 c=0
Rk38 (\8\:VDD \9\:VDD) resistor r=0.3082 c=0
Rk40 (\10\:VDD VDD) resistor r=0.04989 c=0
Rk39 (\9\:VDD \10\:VDD) resistor r=0.09256 c=0
Rk45 (\9\:VDD \19\:VDD) resistor r=0.2606 c=0
Rk1 (\4\:A A) resistor r=0.03938 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.09507 c=0
Rk25 (\3\:VSS \7\:VSS) resistor r=0.5211 c=0
Rk27 (\8\:VSS VSS) resistor r=0.04989 c=0
Rk26 (\7\:VSS \8\:VSS) resistor r=0.1201 c=0
Rk31 (\7\:VSS \16\:VSS) resistor r=0.1962 c=0
Rk2 (\4\:S0b \5\:S0b) resistor r=0.7698 c=0
Rk3 (\5\:S0b \7\:S0b) resistor r=0.5832 c=0
Rk4 (\5\:S0b \9\:S0b) resistor r=0.097 c=0
Rk15 (\4\:n0 \5\:n0) resistor r=1.2614 c=0
Rk16 (\5\:n0 \7\:n0) resistor r=0.807 c=0
Rk17 (\5\:n0 \9\:n0) resistor r=0.263 c=0
Rk18 (\17\:n1 \18\:n1) resistor r=0.4226 c=0
Rk19 (\18\:n1 \19\:n1) resistor r=0.1829 c=0
Rk20 (\18\:n1 \21\:n1) resistor r=0.2118 c=0
Rl9 (\1\:B \2\:B) resistor r=91.5405 c=0
Rl10 (\2\:B \3\:B) resistor r=189.939 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=81.9251 c=0
Rl5 (\4\:S0 \5\:S0) resistor r=44.9225 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=29.9451 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=226.923 c=0
Rl3 (\1\:A \2\:A) resistor r=154.538 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl6 (S0b \2\:S0b) resistor r=107.692 c=0
Rl7 (\2\:S0b \3\:S0b) resistor r=149.176 c=0
Rl25 (n0 \2\:n0) resistor r=96.6933 c=0
Rl26 (\2\:n0 \3\:n0) resistor r=106.925 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz12 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz13 (\8\:VDD \1\:VDD) resistor r=12.5 c=0
Rz14 (\10\:VDD \1\:VDD) resistor r=37.5 c=0
Rz9 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz4 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz5 (\17\:n1 \16\:n1) resistor r=75 c=0
Ry13 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry7 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry8 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\6\:S0b \7\:S0b) resistor r=62 c=0
Ry4 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry5 (\21\:n1 \20\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\7\:S0 \8\:S0) resistor r=45 c=0
Rx4 (\5\:S0 \9\:S0) resistor r=45 c=0
Rx5 (\2\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:S0b \4\:S0b) resistor r=45 c=0
Rx7 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\19\:n1 n1) resistor r=45 c=0
mn0 (\8\:S0b \1\:S0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.09016 scb=0.00401586 \
        scc=3.69756e-05 m=(1)
mn1 (n3 \3\:A \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.582e-14 ps=6.1e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn2 (\8\:n0 \3\:S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.582e-14 ad=2.61e-14 ps=1.06e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.95e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn4 (\8\:n0 \6\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.61e-14 ps=5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.725e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn3 (n5 \3\:B \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.007e-14 ad=1.522e-14 ps=1.19e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.575e-06 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn6 (\1\:Y n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.522e-14 ad=4.355e-14 ps=1.2475e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.975e-07 sb=1.195e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(4)
mn5 (\16\:n1 n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.32e-14 ad=3.64e-14 ps=1.16e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62625e-06 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mp1 (n4 \1\:A \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.623e-14 ad=4.837e-14 ps=8.6e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=12.703 scb=0.0101766 \
        scc=0.000164323 m=(1)
mp2 (\6\:n0 \4\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=3.655e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.85e-06 sd=160n sca=11.2588 \
        scb=0.00885445 scc=0.000160725 m=(1)
mp4 (\6\:n0 S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=7.955e-14 \
        ad=3.655e-14 ps=1.17e-06 pd=7.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.15e-07 sb=1.635e-06 sd=160n sca=10.9013 scb=0.00874909 \
        scc=0.000160703 m=(1)
mp3 (n6 \1\:B \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=7.955e-14 ps=1.16e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.33e-06 sb=1.22e-06 sd=160n sca=10.9013 \
        scb=0.00874909 scc=0.000160703 m=(1)
mp6 (Y n1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.139e-14 \
        ad=6.728e-14 ps=1.115e-06 pd=1.125e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.07628e-07 sb=9.85e-07 sd=160n sca=17.7856 scb=0.015626 \
        scc=0.00148402 m=(4)
mp5 (\20\:n1 \3\:n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5266e-06 sb=1.4e-07 sd=160n sca=20.2961 \
        scb=0.018091 scc=0.00149586 m=(1)
ends MXI2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:37:01 2012 )
// Library name: gsclib045
// Cell name: MXI2X6
// View name: extracted

simulator lang=spectre

subckt MXI2X6 A B S0 VDD VSS Y
mp0 (\8\:S0b \1\:S0 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=15.1724 scb=0.0141966 \
        scc=0.000199699 m=(1)
C1 (B VSS) capacitor c=7.98751e-17
C2 (S0 VSS) capacitor c=3.46592e-17
C3 (VDD VSS) capacitor c=2.12314e-16
C4 (A VSS) capacitor c=4.13541e-17
C5 (Y VSS) capacitor c=5.1775e-16
C6 (S0b VSS) capacitor c=6.05487e-17
C7 (n0 VSS) capacitor c=2.11779e-16
C8 (n5 VSS) capacitor c=5.13251e-18
C9 (n1 VSS) capacitor c=3.10083e-16
C10 (n4 VSS) capacitor c=2.35833e-20
C11 (n6 VSS) capacitor c=1.6215e-18
C12 (\1\:B VSS) capacitor c=6.25935e-17
C13 (\3\:S0b VSS) capacitor c=4.15135e-17
C14 (\6\:S0 VSS) capacitor c=4.12793e-17
C15 (\1\:A VSS) capacitor c=4.96853e-17
C16 (\1\:S0 VSS) capacitor c=3.21454e-17
C17 (\3\:B VSS) capacitor c=4.45064e-17
C18 (\4\:S0 VSS) capacitor c=6.48705e-17
C19 (\3\:A VSS) capacitor c=7.83418e-17
C20 (\3\:S0 VSS) capacitor c=5.69085e-17
C21 (\7\:n1 VSS) capacitor c=1.7142e-17
C22 (\2\:B VSS) capacitor c=5.53532e-17
C23 (\4\:S0b VSS) capacitor c=4.52716e-17
C24 (\5\:S0 VSS) capacitor c=7.60416e-17
C25 (\2\:S0b VSS) capacitor c=4.97687e-17
C26 (\2\:A VSS) capacitor c=6.28957e-17
C27 (\2\:S0 VSS) capacitor c=5.45322e-17
C28 (\1\:VDD VSS) capacitor c=3.60445e-16
C29 (\21\:n1 VSS) capacitor c=9.03242e-17
C30 (\7\:n0 VSS) capacitor c=9.27753e-17
C31 (\16\:VDD VSS) capacitor c=2.4534e-17
C32 (\8\:S0b VSS) capacitor c=7.99545e-17
C33 (\4\:VDD VSS) capacitor c=3.4354e-17
C34 (\19\:n1 VSS) capacitor c=3.97712e-17
C35 (\10\:n0 VSS) capacitor c=5.65265e-17
C36 (\10\:S0b VSS) capacitor c=3.37598e-17
C37 (\4\:A VSS) capacitor c=6.51772e-17
C38 (\7\:S0 VSS) capacitor c=6.95502e-17
C39 (\8\:S0 VSS) capacitor c=8.03142e-17
C40 (\5\:S0b VSS) capacitor c=8.837e-17
C41 (\6\:S0b VSS) capacitor c=1.35507e-16
C42 (\7\:S0b VSS) capacitor c=5.52366e-17
C43 (\4\:B VSS) capacitor c=2.70954e-17
C44 (\9\:n0 VSS) capacitor c=1.37379e-16
C45 (\12\:n0 VSS) capacitor c=5.11327e-17
C46 (\17\:n1 VSS) capacitor c=2.00037e-17
C47 (\18\:n1 VSS) capacitor c=5.48134e-17
C48 (\9\:VDD VSS) capacitor c=1.53463e-17
Rk10 (\4\:B B) resistor r=0.02104 c=0
Rk3 (\8\:S0 S0) resistor r=0.03714 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.5576 c=0
Rk30 (\1\:VDD \8\:VDD) resistor r=0.3485 c=0
Rk32 (\9\:VDD VDD) resistor r=0.1802 c=0
Rk31 (\8\:VDD \9\:VDD) resistor r=0.1202 c=0
Rk36 (\9\:VDD \17\:VDD) resistor r=0.1747 c=0
Rk1 (A \4\:A) resistor r=0.007123 c=0
Rk41 (\1\:VSS \8\:VSS) resistor r=0.3335 c=0
Rk43 (\9\:VSS VSS) resistor r=0.1802 c=0
Rk42 (\8\:VSS \9\:VSS) resistor r=0.1202 c=0
Rk47 (\9\:VSS \17\:VSS) resistor r=0.2175 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4999 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4517 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.5592 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.2257 c=0
Rk11 (\8\:n0 \9\:n0) resistor r=0.6162 c=0
Rk12 (\9\:n0 \11\:n0) resistor r=0.3903 c=0
Rk13 (\9\:n0 \12\:n0) resistor r=0.2571 c=0
Rk14 (\17\:n1 \18\:n1) resistor r=0.1017 c=0
Rk15 (\18\:n1 \20\:n1) resistor r=0.2507 c=0
Rk16 (\18\:n1 \22\:n1) resistor r=0.4472 c=0
Rl9 (\1\:B \2\:B) resistor r=158.384 c=0
Rl10 (\2\:B \3\:B) resistor r=135.307 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=80.0021 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=239.939 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=46.8456 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=246.846 c=0
Rl3 (\1\:A \2\:A) resistor r=146.846 c=0
Rl4 (\2\:A \3\:A) resistor r=146.846 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=57.0048 c=0
Rl5 (S0b \2\:S0b) resistor r=66.8207 c=0
Rl21 (n1 \7\:n1) resistor r=9.5197 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz8 (\8\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz13 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\10\:S0b \11\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\20\:n1 \19\:n1) resistor r=75 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry13 (\8\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry1 (\8\:S0b \9\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\22\:n1 \21\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\12\:n0 n0) resistor r=45 c=0
Rx8 (\17\:n1 \7\:n1) resistor r=45 c=0
mn0 (\10\:S0b \3\:S0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn1 (n3 \3\:A \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=2e-06 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=3.19e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.985e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=4.133e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.655e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn5 (\19\:n1 n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.933e-14 ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.58077e-07 sb=1.42e-06 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn6 (Y n1 \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=5.16e-14 \
        ad=4.836e-14 ps=9.6e-07 pd=9.32e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.03774e-06 sb=9.6e-07 sd=160n sca=11.2536 scb=0.0105131 \
        scc=0.000532331 m=(5)
mp1 (n4 \1\:A \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.945e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=2e-06 sd=160n sca=12.0026 scb=0.00898843 \
        scc=0.000100961 m=(1)
mp2 (\7\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=4.515e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=2e-06 sd=160n sca=10.6609 \
        scb=0.00786354 scc=9.84678e-05 m=(1)
mp4 (\7\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.515e-14 ps=6.8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.825e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.835e-14 ad=2.687e-14 ps=1.16e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=1.655e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp5 (\21\:n1 n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.412e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.97372e-07 sb=1.42e-06 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(2)
mp6 (Y n1 \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 as=7.814e-14 \
        ad=7.332e-14 ps=1.28e-06 pd=1.252e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.06037e-06 sb=9.6e-07 sd=160n sca=13.3727 scb=0.0119208 \
        scc=0.000609828 m=(5)
ends MXI2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 15:37:40 2012 )
// Library name: gsclib045
// Cell name: MXI2X8
// View name: extracted

simulator lang=spectre

subckt MXI2X8 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.9313 scb=0.0137374 \
        scc=0.000173804 m=(1)
C1 (S0 VSS) capacitor c=9.93871e-17
C2 (VDD VSS) capacitor c=2.18803e-16
C3 (A VSS) capacitor c=6.08832e-17
C4 (Y VSS) capacitor c=4.69581e-16
C5 (S0b VSS) capacitor c=4.71417e-17
C6 (n0 VSS) capacitor c=2.00591e-16
C7 (n5 VSS) capacitor c=5.72279e-18
C8 (n1 VSS) capacitor c=3.88736e-16
C9 (n6 VSS) capacitor c=6.08665e-18
C10 (\1\:B VSS) capacitor c=4.66438e-17
C11 (\3\:S0b VSS) capacitor c=4.38091e-17
C12 (\6\:S0 VSS) capacitor c=4.38994e-17
C13 (\1\:A VSS) capacitor c=5.85892e-17
C14 (\1\:S0 VSS) capacitor c=3.36003e-17
C15 (\3\:B VSS) capacitor c=4.68533e-17
C16 (\4\:S0 VSS) capacitor c=5.72158e-17
C17 (\3\:A VSS) capacitor c=4.70244e-17
C18 (\3\:S0 VSS) capacitor c=5.80546e-17
C19 (\9\:n1 VSS) capacitor c=1.79325e-17
C20 (\2\:B VSS) capacitor c=5.05336e-17
C21 (\4\:S0b VSS) capacitor c=4.19511e-17
C22 (\5\:S0 VSS) capacitor c=8.37464e-17
C23 (\2\:S0b VSS) capacitor c=4.47637e-17
C24 (\2\:A VSS) capacitor c=6.15999e-17
C25 (\2\:S0 VSS) capacitor c=5.43822e-17
C26 (\1\:VDD VSS) capacitor c=4.04571e-16
C27 (\27\:n1 VSS) capacitor c=9.17117e-17
C28 (\7\:n0 VSS) capacitor c=9.60839e-17
C29 (\19\:VDD VSS) capacitor c=4.00511e-17
C30 (\10\:S0b VSS) capacitor c=8.8517e-17
C31 (\4\:VDD VSS) capacitor c=4.07251e-17
C32 (\25\:n1 VSS) capacitor c=3.78598e-17
C33 (\10\:n0 VSS) capacitor c=4.17413e-17
C34 (\8\:S0b VSS) capacitor c=3.19658e-17
C35 (\4\:A VSS) capacitor c=5.68948e-17
C36 (\7\:S0 VSS) capacitor c=8.82554e-17
C37 (\5\:S0b VSS) capacitor c=6.58376e-17
C38 (\6\:S0b VSS) capacitor c=1.14625e-16
C39 (\7\:S0b VSS) capacitor c=8.59623e-17
C40 (\4\:B VSS) capacitor c=1.04917e-16
C41 (\9\:n0 VSS) capacitor c=1.42848e-16
C42 (\12\:n0 VSS) capacitor c=4.72659e-17
C43 (\23\:n1 VSS) capacitor c=2.27105e-17
C44 (\24\:n1 VSS) capacitor c=5.46969e-17
C45 (\10\:VDD VSS) capacitor c=1.26101e-17
Rk8 (\4\:B B) resistor r=0.002995 c=0
Rk3 (\8\:S0 S0) resistor r=0.002702 c=0
Rk2 (\7\:S0 \8\:S0) resistor r=0.4715 c=0
Rk32 (\1\:VDD \9\:VDD) resistor r=0.3632 c=0
Rk34 (\10\:VDD VDD) resistor r=0.18 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.1201 c=0
Rk39 (\10\:VDD \20\:VDD) resistor r=0.2141 c=0
Rk1 (\4\:A A) resistor r=0.04728 c=0
Rk45 (\1\:VSS \9\:VSS) resistor r=0.3331 c=0
Rk47 (\10\:VSS VSS) resistor r=0.18 c=0
Rk46 (\9\:VSS \10\:VSS) resistor r=0.1201 c=0
Rk52 (\10\:VSS \20\:VSS) resistor r=0.2008 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.3979 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.5535 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.2007 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6499 c=0
Rk9 (\8\:n0 \9\:n0) resistor r=0.7092 c=0
Rk10 (\9\:n0 \11\:n0) resistor r=0.3288 c=0
Rk11 (\9\:n0 \12\:n0) resistor r=0.2772 c=0
Rk12 (\23\:n1 \24\:n1) resistor r=0.1007 c=0
Rk13 (\24\:n1 \26\:n1) resistor r=0.2117 c=0
Rk14 (\24\:n1 \28\:n1) resistor r=0.4765 c=0
Rl9 (\1\:B \2\:B) resistor r=125.692 c=0
Rl10 (\2\:B \3\:B) resistor r=156.461 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=92.1028 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=221.131 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=233.384 c=0
Rl3 (\1\:A \2\:A) resistor r=181.461 c=0
Rl4 (\2\:A \3\:A) resistor r=100.692 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=56.461 c=0
Rl5 (S0b \2\:S0b) resistor r=85.3072 c=0
Rl23 (n1 \9\:n1) resistor r=9.5287 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz9 (\9\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\26\:n1 \25\:n1) resistor r=75 c=0
Ry13 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry14 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry15 (\9\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\28\:n1 \27\:n1) resistor r=20.6667 c=0
Rx6 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx7 (\12\:n0 n0) resistor r=45 c=0
Rx8 (\23\:n1 \9\:n1) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn1 (n3 \3\:A \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn2 (\10\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=3.625e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2e-06 sd=160n sca=7.18188 \
        scb=0.00417289 scc=4.04165e-05 m=(1)
mn4 (\10\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=2e-06 sd=160n sca=7.18188 scb=0.00417289 \
        scc=4.04165e-05 m=(1)
mn5 (\25\:n1 n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=4.16e-14 ps=9.85e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74808e-07 sb=1.83e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn6 (Y n1 \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.876e-14 \
        ad=4.636e-14 ps=9.2429e-07 pd=9.0429e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.10017e-06 sb=1.37e-06 sd=160n sca=8.43155 scb=0.00645789 \
        scc=0.000159377 m=(7)
mp1 (n4 \1\:A \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.7616 \
        scb=0.00852924 scc=7.50663e-05 m=(1)
mp2 (\7\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.655e-14 ps=7.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=10.5874 \
        scb=0.00747601 scc=7.25996e-05 m=(1)
mp4 (\7\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.655e-14 ps=8.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2e-06 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp3 (n6 \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=4.73e-14 ps=1.22e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2e-06 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp5 (\27\:n1 n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.96e-14 ad=6.24e-14 ps=1.265e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.83e-06 sd=160n sca=12.7076 \
        scb=0.0112318 scc=0.000478212 m=(2)
mp6 (Y n1 \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=7.351e-14 \
        ad=6.993e-14 ps=1.22429e-06 pd=1.20429e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.10348e-06 sb=1.37e-06 sd=160n sca=15.1493 scb=0.013431 \
        scc=0.000976912 m=(7)
ends MXI2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 15:38:17 2012 )
// Library name: gsclib045
// Cell name: MXI2XL
// View name: extracted

simulator lang=spectre

subckt MXI2XL A B S0 VDD VSS Y
mp1 (n4 \1\:A \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.055e-06 sd=160n sca=19.4817 \
        scb=0.0210827 scc=0.000690865 m=(1)
C1 (A VSS) capacitor c=1.54961e-17
C2 (Y VSS) capacitor c=1.07222e-16
C3 (S0 VSS) capacitor c=4.55491e-17
C4 (B VSS) capacitor c=9.79765e-17
C5 (VDD VSS) capacitor c=1.29006e-16
C6 (n3 VSS) capacitor c=9.13172e-18
C7 (S0b VSS) capacitor c=6.03706e-17
C8 (n4 VSS) capacitor c=1.13249e-17
C9 (\4\:S0 VSS) capacitor c=4.34737e-17
C10 (\1\:B VSS) capacitor c=4.15245e-17
C11 (\3\:S0b VSS) capacitor c=5.03262e-17
C12 (\3\:S0 VSS) capacitor c=6.56734e-17
C13 (\1\:A VSS) capacitor c=3.12078e-17
C14 (\6\:S0 VSS) capacitor c=3.48938e-17
C15 (\3\:B VSS) capacitor c=7.56648e-17
C16 (\1\:S0 VSS) capacitor c=5.15271e-17
C17 (\4\:A VSS) capacitor c=5.90863e-17
C18 (\5\:S0 VSS) capacitor c=4.41251e-17
C19 (\2\:B VSS) capacitor c=6.50385e-17
C20 (\2\:S0 VSS) capacitor c=7.60388e-17
C21 (\4\:S0b VSS) capacitor c=4.26212e-17
C22 (\2\:S0b VSS) capacitor c=2.75751e-17
C23 (\3\:A VSS) capacitor c=1.24588e-17
C24 (\5\:S0b VSS) capacitor c=5.65583e-17
C25 (\6\:VDD VSS) capacitor c=3.03117e-17
C26 (\3\:Y VSS) capacitor c=8.4672e-17
C27 (\8\:VDD VSS) capacitor c=1.98643e-17
C28 (\1\:VDD VSS) capacitor c=3.36333e-17
C29 (\10\:S0b VSS) capacitor c=1.57694e-17
C30 (\1\:Y VSS) capacitor c=4.18267e-17
C31 (\2\:A VSS) capacitor c=3.69714e-17
C32 (\5\:A VSS) capacitor c=7.51391e-17
C33 (\7\:S0 VSS) capacitor c=6.29141e-17
C34 (\8\:S0 VSS) capacitor c=6.98687e-17
C35 (\7\:S0b VSS) capacitor c=9.15526e-17
C36 (\8\:S0b VSS) capacitor c=9.83866e-17
C37 (\9\:S0b VSS) capacitor c=8.34948e-17
C38 (\12\:S0b VSS) capacitor c=7.26519e-17
C39 (\3\:VDD VSS) capacitor c=1.13148e-17
C40 (\5\:VDD VSS) capacitor c=5.4064e-18
Rk1 (\5\:A A) resistor r=0.01024 c=0
Rk2 (\2\:Y Y) resistor r=0.2037 c=0
Rk3 (Y \4\:Y) resistor r=0.5727 c=0
Rk19 (\3\:VSS VSS) resistor r=0.04468 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.07369 c=0
Rk21 (\3\:VSS \6\:VSS) resistor r=0.3057 c=0
Rk22 (\6\:VSS \8\:VSS) resistor r=0.4003 c=0
Rk5 (S0 \7\:S0) resistor r=0.1109 c=0
Rk6 (\7\:S0 \8\:S0) resistor r=0.2269 c=0
Rk4 (\4\:B B) resistor r=0.001659 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.1201 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.2304 c=0
Rk15 (\5\:VDD VDD) resistor r=0.02462 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1753 c=0
Rk16 (\3\:VDD \7\:VDD) resistor r=0.2136 c=0
Rk17 (\5\:VDD \9\:VDD) resistor r=0.2136 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.4994 c=0
Rk8 (\7\:S0b \8\:S0b) resistor r=0.4095 c=0
Rk9 (\8\:S0b \9\:S0b) resistor r=0.4314 c=0
Rk10 (\7\:S0b \11\:S0b) resistor r=0.07479 c=0
Rk11 (\8\:S0b \12\:S0b) resistor r=0.4225 c=0
Rl1 (\1\:A \2\:A) resistor r=112.341 c=0
Rl3 (\2\:A \4\:A) resistor r=112.341 c=0
Rl2 (\2\:A \3\:A) resistor r=6.9867 c=0
Rl10 (\4\:S0 \5\:S0) resistor r=119.922 c=0
Rl11 (\5\:S0 \6\:S0) resistor r=89.1533 c=0
Rl7 (\2\:S0 \3\:S0) resistor r=192.847 c=0
Rl6 (\1\:S0 \2\:S0) resistor r=83.8482 c=0
Rl8 (\1\:B \2\:B) resistor r=49.2328 c=0
Rl9 (\2\:B \3\:B) resistor r=156.925 c=0
Rl5 (\3\:S0b \4\:S0b) resistor r=49.2328 c=0
Rl4 (S0b \2\:S0b) resistor r=67.9995 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz2 (\10\:S0b \11\:S0b) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry5 (\4\:VSS VSS) resistor r=62 c=0
Ry6 (\4\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry2 (\5\:S0b \6\:S0b) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx4 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx5 (\2\:S0b \9\:S0b) resistor r=45 c=0
Rx6 (\4\:S0b \12\:S0b) resistor r=45 c=0
mn1 (n3 \4\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.14e-14 ad=8.7e-15 ps=1.37e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=9.5e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn2 (\1\:Y S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.05e-07 sb=8.45e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn4 (\1\:Y \1\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=6e-07 sb=4.5e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn3 (n5 \3\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=3.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn0 (\10\:S0b \6\:S0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mp2 (\3\:Y \3\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=8.35e-07 sd=160n sca=12.7904 \
        scb=0.00993072 scc=8.66491e-05 m=(1)
mp4 (\3\:Y \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=6.3e-07 sd=160n sca=11.7062 \
        scb=0.00805323 scc=7.41039e-05 m=(1)
mp3 (n6 \1\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=4.5e-07 sd=160n sca=12.1787 \
        scb=0.00883398 scc=7.73084e-05 m=(1)
mp0 (\5\:S0b \4\:S0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.268e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=2.45e-07 sd=160n sca=15.5376 \
        scb=0.0148069 scc=0.000217426 m=(1)
ends MXI2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:38:55 2012 )
// Library name: gsclib045
// Cell name: MXI3X1
// View name: extracted

simulator lang=spectre

subckt MXI3X1 A B C S0 S1 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.5351 scb=0.0231851 \
        scc=0.000811514 m=(1)
C1 (Y VSS) capacitor c=2.4542e-17
C2 (S0 VSS) capacitor c=8.46825e-17
C3 (C VSS) capacitor c=9.20054e-17
C4 (VDD VSS) capacitor c=2.7037e-16
C5 (A VSS) capacitor c=9.29183e-17
C6 (S0b VSS) capacitor c=4.603e-17
C7 (n2 VSS) capacitor c=1.71371e-19
C8 (n0 VSS) capacitor c=5.93184e-17
C9 (n4 VSS) capacitor c=1.01178e-17
C10 (n1 VSS) capacitor c=2.53044e-17
C11 (S1b VSS) capacitor c=4.63071e-17
C12 (n8 VSS) capacitor c=1.47936e-18
C13 (Cp VSS) capacitor c=2.74186e-17
C14 (n3 VSS) capacitor c=6.88945e-19
C15 (n5 VSS) capacitor c=4.75484e-18
C16 (n7 VSS) capacitor c=1.00082e-18
C17 (n9 VSS) capacitor c=4.25237e-18
C18 (\3\:C VSS) capacitor c=3.18623e-17
C19 (\6\:S1 VSS) capacitor c=3.88349e-17
C20 (\3\:Cp VSS) capacitor c=7.16696e-17
C21 (\3\:S1b VSS) capacitor c=4.30025e-17
C22 (\3\:S1 VSS) capacitor c=7.57671e-17
C23 (\1\:B VSS) capacitor c=3.23574e-17
C24 (\3\:S0b VSS) capacitor c=3.91084e-17
C25 (\4\:S0 VSS) capacitor c=2.66422e-17
C26 (\1\:A VSS) capacitor c=3.79312e-17
C27 (\1\:S0 VSS) capacitor c=3.2139e-17
C28 (\4\:n1 VSS) capacitor c=3.94881e-17
C29 (\1\:C VSS) capacitor c=3.02899e-17
C30 (\4\:S1 VSS) capacitor c=4.00595e-17
C31 (\4\:Cp VSS) capacitor c=3.6409e-17
C32 (\1\:S1 VSS) capacitor c=3.21764e-17
C33 (\3\:n0 VSS) capacitor c=3.37048e-17
C34 (\3\:B VSS) capacitor c=4.64359e-17
C35 (\6\:S0 VSS) capacitor c=5.2543e-17
C36 (\3\:A VSS) capacitor c=3.73109e-17
C37 (\3\:S0 VSS) capacitor c=4.12472e-17
C38 (\3\:n1 VSS) capacitor c=1.53571e-17
C39 (\2\:C VSS) capacitor c=2.94566e-17
C40 (\5\:S1 VSS) capacitor c=6.20862e-17
C41 (\2\:S1 VSS) capacitor c=7.29484e-17
C42 (\4\:S1b VSS) capacitor c=3.59769e-17
C43 (\2\:S1b VSS) capacitor c=2.23092e-17
C44 (\2\:n0 VSS) capacitor c=4.90269e-17
C45 (\2\:B VSS) capacitor c=4.90132e-17
C46 (\4\:S0b VSS) capacitor c=4.25815e-17
C47 (\5\:S0 VSS) capacitor c=4.66967e-17
C48 (\2\:S0b VSS) capacitor c=3.44533e-17
C49 (\2\:A VSS) capacitor c=4.57451e-17
C50 (\2\:S0 VSS) capacitor c=4.37572e-17
C51 (\3\:Y VSS) capacitor c=5.66874e-17
C52 (\10\:VDD VSS) capacitor c=2.60192e-17
C53 (\9\:Cp VSS) capacitor c=6.00863e-17
C54 (\10\:S1b VSS) capacitor c=9.87121e-17
C55 (\12\:VDD VSS) capacitor c=1.90504e-17
C56 (\6\:n1 VSS) capacitor c=2.38141e-16
C57 (\14\:VDD VSS) capacitor c=4.13705e-17
C58 (\8\:n0 VSS) capacitor c=5.72276e-17
C59 (\16\:VDD VSS) capacitor c=4.22816e-17
C60 (\10\:S0b VSS) capacitor c=6.64957e-17
C61 (\1\:VDD VSS) capacitor c=6.1046e-17
C62 (\1\:Y VSS) capacitor c=1.13628e-17
C63 (\5\:Cp VSS) capacitor c=6.72095e-17
C64 (\5\:S1b VSS) capacitor c=1.2185e-16
C65 (\8\:n1 VSS) capacitor c=7.80813e-17
C66 (\6\:n0 VSS) capacitor c=6.86101e-17
C67 (\8\:S0b VSS) capacitor c=1.92938e-17
C68 (\2\:Cp VSS) capacitor c=5.46244e-17
C69 (\2\:n1 VSS) capacitor c=1.25933e-17
C70 (\4\:A VSS) capacitor c=4.35273e-17
C71 (\7\:S0 VSS) capacitor c=6.24949e-17
C72 (\8\:S0 VSS) capacitor c=2.14257e-17
C73 (\5\:S0b VSS) capacitor c=7.65363e-17
C74 (\6\:S0b VSS) capacitor c=1.01285e-16
C75 (\7\:S0b VSS) capacitor c=9.24718e-17
C76 (\4\:n0 VSS) capacitor c=3.85818e-17
C77 (\5\:n0 VSS) capacitor c=1.08501e-16
C78 (\4\:B VSS) capacitor c=1.05029e-16
C79 (\7\:S1 VSS) capacitor c=6.83107e-17
C80 (\8\:S1 VSS) capacitor c=7.84418e-17
C81 (\7\:S1b VSS) capacitor c=9.05215e-17
C82 (\8\:S1b VSS) capacitor c=5.32822e-17
C83 (\9\:S1b VSS) capacitor c=1.36219e-16
C84 (\7\:Cp VSS) capacitor c=1.12874e-16
C85 (\8\:Cp VSS) capacitor c=6.92386e-17
C86 (\4\:C VSS) capacitor c=2.00694e-17
C87 (\5\:n1 VSS) capacitor c=1.97843e-16
C88 (\3\:VDD VSS) capacitor c=2.19286e-19
C89 (\5\:VDD VSS) capacitor c=2.65626e-17
C90 (\7\:VDD VSS) capacitor c=2.34508e-17
C91 (\8\:VDD VSS) capacitor c=1.68253e-17
Rk24 (Y \2\:Y) resistor r=0.03898 c=0
Rk25 (Y \4\:Y) resistor r=0.2579 c=0
Rk11 (\4\:B B) resistor r=0.01575 c=0
Rk2 (\7\:S0 S0) resistor r=0.3907 c=0
Rk3 (S0 \8\:S0) resistor r=0.08178 c=0
Rk21 (\4\:C C) resistor r=0.02497 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.08755 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.1628 c=0
Rk37 (\4\:VDD \5\:VDD) resistor r=0.3323 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.4175 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.04242 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.5737 c=0
Rk42 (\9\:VDD VDD) resistor r=0.04989 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.08504 c=0
Rk43 (\3\:VDD \11\:VDD) resistor r=0.199 c=0
Rk44 (\5\:VDD \13\:VDD) resistor r=0.04329 c=0
Rk45 (\7\:VDD \15\:VDD) resistor r=0.2903 c=0
Rk46 (\8\:VDD \17\:VDD) resistor r=0.2947 c=0
Rk12 (\7\:S1 S1) resistor r=0.2648 c=0
Rk13 (S1 \8\:S1) resistor r=0.0121 c=0
Rk1 (A \4\:A) resistor r=0.02686 c=0
Rk26 (\2\:VSS \4\:VSS) resistor r=0.4832 c=0
Rk27 (\4\:VSS \5\:VSS) resistor r=0.2831 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.511 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.1577 c=0
Rk31 (\8\:VSS VSS) resistor r=0.1199 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.431 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.2925 c=0
Rk33 (\6\:VSS \12\:VSS) resistor r=0.2872 c=0
Rk34 (\8\:VSS \14\:VSS) resistor r=0.2827 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4094 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.4976 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.09145 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.5395 c=0
Rk8 (\4\:n0 \5\:n0) resistor r=0.1904 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.4553 c=0
Rk10 (\5\:n0 \9\:n0) resistor r=0.5159 c=0
Rk22 (\5\:n1 \7\:n1) resistor r=1.5381 c=0
Rk23 (\7\:n1 \9\:n1) resistor r=0.5362 c=0
Rk14 (\6\:S1b \7\:S1b) resistor r=0.7859 c=0
Rk15 (\7\:S1b \8\:S1b) resistor r=0.2234 c=0
Rk16 (\7\:S1b \9\:S1b) resistor r=0.4751 c=0
Rk17 (\9\:S1b \11\:S1b) resistor r=0.5587 c=0
Rk18 (\6\:Cp \7\:Cp) resistor r=0.4613 c=0
Rk19 (\7\:Cp \8\:Cp) resistor r=0.2969 c=0
Rk20 (\7\:Cp \10\:Cp) resistor r=0.3676 c=0
Rl9 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl10 (\2\:B \3\:B) resistor r=156.925 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=24.2328 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=156.925 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=39.1533 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=144.923 c=0
Rl23 (\2\:C \3\:C) resistor r=72.2527 c=0
Rl22 (\1\:C \2\:C) resistor r=40.3846 c=0
Rl21 (\5\:S1 \6\:S1) resistor r=74.5541 c=0
Rl20 (\4\:S1 \5\:S1) resistor r=137.694 c=0
Rl16 (\2\:S1 \3\:S1) resistor r=238.016 c=0
Rl15 (\1\:S1 \2\:S1) resistor r=95.3867 c=0
Rl3 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl4 (\2\:A \3\:A) resistor r=87.2302 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=60.4896 c=0
Rl5 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl11 (n0 \2\:n0) resistor r=144.923 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rl24 (n1 \2\:n1) resistor r=34.3295 c=0
Rl26 (\2\:n1 \4\:n1) resistor r=49.7141 c=0
Rl25 (\2\:n1 \3\:n1) resistor r=1.2666 c=0
Rl14 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl13 (S1b \2\:S1b) resistor r=51.1559 c=0
Rl17 (Cp \2\:Cp) resistor r=2.0213 c=0
Rl18 (\2\:Cp \3\:Cp) resistor r=158.895 c=0
Rl19 (\2\:Cp \4\:Cp) resistor r=86.2526 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz11 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz13 (\1\:VDD \6\:VDD) resistor r=6.25 c=0
Rz14 (\1\:VDD \9\:VDD) resistor r=37.5 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (\5\:Cp \6\:Cp) resistor r=75 c=0
Ry6 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry11 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry12 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry4 (\9\:Cp \10\:Cp) resistor r=62 c=0
Rx7 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx13 (\2\:C \4\:C) resistor r=45 c=0
Rx8 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx9 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx10 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx11 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx12 (Cp \8\:Cp) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn2 (n2 \3\:A \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.842e-14 ps=6.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn3 (\6\:n0 S0b n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=3.842e-14 \
        ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.55e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn5 (\6\:n0 \6\:S0 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.82e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (n4 \3\:B \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.51e-14 ps=6.1e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.395e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn7 (n6 \3\:n0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.175e-14 ps=6.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=1.19e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn8 (\8\:n1 S1b n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.175e-14 \
        ad=5.8e-14 ps=5.9e-07 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.685e-06 sb=9.95e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn10 (\8\:n1 \1\:S1 n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.8e-14 ps=6.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn9 (n8 \4\:Cp \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn1 (\5\:S1b \4\:S1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn6 (\5\:Cp \1\:C \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=2.03e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn11 (\1\:Y \4\:n1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=3.64e-14 ps=8.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.39423e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp2 (n3 \1\:A \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.0105e-13 ps=7.5e-07 pd=1.37e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.7004 scb=0.0133656 \
        scc=0.000345077 m=(1)
mp3 (\8\:n0 \4\:S0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=3.44e-14 ps=1.37e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.72e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp5 (\8\:n0 \3\:S0b n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.515e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp4 (n5 \1\:B \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.295e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp7 (n7 n0 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=1.09e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp8 (\6\:n1 \3\:S1 n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=4.837e-14 ps=7.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=8.65e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp10 (\6\:n1 \3\:S1b n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.837e-14 ps=7.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.985e-06 sb=5.95e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp9 (n9 \3\:Cp \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.118e-14 ps=1.52e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp1 (\10\:S1b \6\:S1 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp6 (\9\:Cp \3\:C \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=3.655e-14 ps=1.51e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.05e-07 sd=160n sca=48.3011 \
        scb=0.0307957 scc=0.00589601 m=(1)
mp11 (\3\:Y n1 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.445e-14 ad=5.46e-14 ps=1.51e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.1609e-07 sb=1.4e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
ends MXI3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:39:33 2012 )
// Library name: gsclib045
// Cell name: MXI3X2
// View name: extracted

simulator lang=spectre

subckt MXI3X2 A B C S0 S1 VDD VSS Y
mp6 (\4\:Cp \1\:C \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.6e-07 sd=160n sca=19.7685 \
        scb=0.0219319 scc=0.000700056 m=(1)
C1 (A VSS) capacitor c=3.59545e-17
C2 (S1 VSS) capacitor c=3.85675e-17
C3 (S0 VSS) capacitor c=3.7401e-17
C4 (VDD VSS) capacitor c=2.26468e-16
C5 (Y VSS) capacitor c=3.65066e-17
C6 (C VSS) capacitor c=5.33538e-17
C7 (Cp VSS) capacitor c=2.63494e-17
C8 (S1b VSS) capacitor c=7.71564e-17
C9 (n1 VSS) capacitor c=1.74901e-16
C10 (n0 VSS) capacitor c=6.55668e-17
C11 (n2 VSS) capacitor c=7.7401e-18
C12 (S0b VSS) capacitor c=3.1114e-17
C13 (n9 VSS) capacitor c=2.60202e-18
C14 (n7 VSS) capacitor c=5.1603e-18
C15 (n3 VSS) capacitor c=4.46733e-18
C16 (\7\:S0 VSS) capacitor c=6.29616e-17
C17 (\1\:B VSS) capacitor c=4.27496e-17
C18 (\1\:S0 VSS) capacitor c=4.7173e-17
C19 (\1\:A VSS) capacitor c=5.24282e-17
C20 (\7\:S1 VSS) capacitor c=4.72055e-17
C21 (\4\:S1b VSS) capacitor c=3.69615e-17
C22 (\3\:Cp VSS) capacitor c=7.49381e-17
C23 (\4\:S1 VSS) capacitor c=3.48961e-17
C24 (\1\:C VSS) capacitor c=3.25651e-17
C25 (\5\:S0 VSS) capacitor c=2.20387e-17
C26 (\3\:B VSS) capacitor c=7.46075e-17
C27 (\3\:S0 VSS) capacitor c=6.19039e-17
C28 (\3\:S0b VSS) capacitor c=6.97964e-17
C29 (\4\:A VSS) capacitor c=4.28733e-17
C30 (\2\:n0 VSS) capacitor c=4.91192e-17
C31 (\5\:S1 VSS) capacitor c=4.79623e-17
C32 (\2\:Cp VSS) capacitor c=4.34065e-17
C33 (\3\:S1 VSS) capacitor c=4.78422e-17
C34 (\3\:C VSS) capacitor c=2.40137e-17
C35 (\6\:S0 VSS) capacitor c=5.18751e-17
C36 (\2\:B VSS) capacitor c=6.22333e-17
C37 (\4\:S0 VSS) capacitor c=6.01249e-17
C38 (\2\:S0b VSS) capacitor c=7.15875e-17
C39 (\2\:S0 VSS) capacitor c=4.51602e-17
C40 (\3\:A VSS) capacitor c=2.89482e-17
C41 (\4\:n1 VSS) capacitor c=1.72238e-17
C42 (\3\:n0 VSS) capacitor c=2.85195e-17
C43 (\8\:S1 VSS) capacitor c=4.04392e-17
C44 (\6\:S1 VSS) capacitor c=4.77133e-17
C45 (\3\:S1b VSS) capacitor c=3.11238e-17
C46 (\1\:S1 VSS) capacitor c=1.84513e-17
C47 (\2\:C VSS) capacitor c=2.5826e-17
C48 (\8\:S0b VSS) capacitor c=1.1834e-17
C49 (\12\:VDD VSS) capacitor c=3.08236e-17
C50 (\4\:n0 VSS) capacitor c=1.04126e-16
C51 (\3\:Y VSS) capacitor c=8.43736e-17
C52 (\8\:n1 VSS) capacitor c=7.30026e-17
C53 (\18\:VDD VSS) capacitor c=1.0182e-17
C54 (\9\:S1b VSS) capacitor c=4.8633e-17
C55 (\4\:Cp VSS) capacitor c=7.15705e-17
C56 (\20\:VDD VSS) capacitor c=2.26596e-17
C57 (\1\:VDD VSS) capacitor c=7.72294e-17
C58 (\4\:S0b VSS) capacitor c=8.75236e-17
C59 (\8\:n0 VSS) capacitor c=5.60939e-17
C60 (\1\:Y VSS) capacitor c=4.82195e-17
C61 (\11\:n1 VSS) capacitor c=3.83742e-17
C62 (\7\:S1b VSS) capacitor c=2.84371e-17
C63 (\6\:Cp VSS) capacitor c=1.13663e-16
C64 (\2\:S1 VSS) capacitor c=2.05141e-17
C65 (\2\:S1b VSS) capacitor c=5.50979e-17
C66 (\2\:A VSS) capacitor c=4.17106e-17
C67 (\4\:C VSS) capacitor c=3.49519e-17
C68 (\8\:Cp VSS) capacitor c=5.64112e-17
C69 (\5\:S1b VSS) capacitor c=7.02976e-17
C70 (\6\:S1b VSS) capacitor c=6.69165e-17
C71 (\9\:S1 VSS) capacitor c=5.42053e-17
C72 (\10\:S1 VSS) capacitor c=3.6989e-17
C73 (\11\:S1 VSS) capacitor c=4.82907e-17
C74 (\12\:S1 VSS) capacitor c=4.2521e-17
C75 (\10\:n1 VSS) capacitor c=6.70244e-17
C76 (\13\:n1 VSS) capacitor c=4.15231e-17
C77 (\5\:A VSS) capacitor c=9.58773e-17
C78 (\6\:n0 VSS) capacitor c=1.77956e-16
C79 (\7\:n0 VSS) capacitor c=7.68249e-17
C80 (\4\:B VSS) capacitor c=1.05328e-16
C81 (\8\:S0 VSS) capacitor c=1.18005e-17
C82 (\9\:S0 VSS) capacitor c=7.66872e-17
C83 (\10\:S0 VSS) capacitor c=5.74162e-17
C84 (\11\:S0 VSS) capacitor c=5.93151e-17
C85 (\6\:S0b VSS) capacitor c=9.18493e-17
C86 (\7\:S0b VSS) capacitor c=5.06326e-17
C87 (\3\:VDD VSS) capacitor c=9.52464e-18
C88 (\5\:VDD VSS) capacitor c=1.62959e-16
C89 (\8\:VDD VSS) capacitor c=5.98816e-18
C90 (\10\:VDD VSS) capacitor c=1.95446e-19
Rk16 (\5\:A A) resistor r=0.04353 c=0
Rk8 (\10\:S1 S1) resistor r=0.2464 c=0
Rk7 (\9\:S1 \10\:S1) resistor r=0.2684 c=0
Rk9 (S1 \11\:S1) resistor r=0.1675 c=0
Rk10 (\10\:S1 \12\:S1) resistor r=0.17 c=0
Rk21 (\8\:S0 \9\:S0) resistor r=0.05586 c=0
Rk24 (\10\:S0 S0) resistor r=0.06973 c=0
Rk22 (\9\:S0 \10\:S0) resistor r=0.4053 c=0
Rk23 (\9\:S0 \11\:S0) resistor r=0.4552 c=0
Rk28 (\2\:VDD \3\:VDD) resistor r=0.1451 c=0
Rk29 (\3\:VDD \4\:VDD) resistor r=0.3054 c=0
Rk30 (\4\:VDD \5\:VDD) resistor r=0.1426 c=0
Rk32 (\5\:VDD \7\:VDD) resistor r=0.2528 c=0
Rk33 (\7\:VDD \8\:VDD) resistor r=0.2878 c=0
Rk34 (\8\:VDD \9\:VDD) resistor r=0.1626 c=0
Rk36 (\10\:VDD VDD) resistor r=0.03211 c=0
Rk35 (\9\:VDD \10\:VDD) resistor r=0.1676 c=0
Rk38 (\3\:VDD \13\:VDD) resistor r=0.2687 c=0
Rk41 (\8\:VDD \19\:VDD) resistor r=0.07323 c=0
Rk42 (\10\:VDD \21\:VDD) resistor r=0.272 c=0
Rk14 (Y \2\:Y) resistor r=0.1477 c=0
Rk15 (Y \4\:Y) resistor r=0.1705 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.1451 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.4319 c=0
Rk47 (\4\:VSS \7\:VSS) resistor r=0.5246 c=0
Rk49 (\8\:VSS VSS) resistor r=0.1505 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.2127 c=0
Rk50 (VSS \10\:VSS) resistor r=0.362 c=0
Rk51 (\3\:VSS \12\:VSS) resistor r=0.1991 c=0
Rk54 (\7\:VSS \18\:VSS) resistor r=0.07323 c=0
Rk1 (\4\:C C) resistor r=0.1907 c=0
Rk20 (\4\:B B) resistor r=0.01192 c=0
Rk2 (\5\:Cp \7\:Cp) resistor r=0.4443 c=0
Rk3 (\7\:Cp \8\:Cp) resistor r=0.5282 c=0
Rk4 (\5\:S1b \6\:S1b) resistor r=0.3871 c=0
Rk5 (\6\:S1b \8\:S1b) resistor r=0.1189 c=0
Rk6 (\6\:S1b \10\:S1b) resistor r=0.2832 c=0
Rk11 (\9\:n1 \10\:n1) resistor r=0.469 c=0
Rk12 (\10\:n1 \12\:n1) resistor r=0.2827 c=0
Rk13 (\10\:n1 \13\:n1) resistor r=0.1751 c=0
Rk17 (\5\:n0 \6\:n0) resistor r=0.8156 c=0
Rk18 (\6\:n0 \7\:n0) resistor r=0.599 c=0
Rk19 (\6\:n0 \9\:n0) resistor r=0.2811 c=0
Rk25 (\5\:S0b \6\:S0b) resistor r=0.7703 c=0
Rk26 (\6\:S0b \7\:S0b) resistor r=0.4323 c=0
Rk27 (\6\:S0b \9\:S0b) resistor r=0.0474 c=0
Rl21 (\1\:A \2\:A) resistor r=129.649 c=0
Rl23 (\2\:A \4\:A) resistor r=131.572 c=0
Rl22 (\2\:A \3\:A) resistor r=10.9341 c=0
Rl12 (\7\:S1 \8\:S1) resistor r=29.5379 c=0
Rl8 (\5\:S1 \6\:S1) resistor r=29.5379 c=0
Rl5 (\2\:S1 \4\:S1) resistor r=34.3295 c=0
Rl4 (\2\:S1 \3\:S1) resistor r=103.56 c=0
Rl3 (\1\:S1 \2\:S1) resistor r=1.2713 c=0
Rl31 (\6\:S0 \7\:S0) resistor r=261.516 c=0
Rl30 (\5\:S0 \6\:S0) resistor r=24.7951 c=0
Rl27 (\3\:S0 \4\:S0) resistor r=69.4451 c=0
Rl24 (\1\:S0 \2\:S0) resistor r=71.8456 c=0
Rl1 (\1\:C \2\:C) resistor r=110.771 c=0
Rl2 (\2\:C \3\:C) resistor r=37.6944 c=0
Rl28 (\1\:B \2\:B) resistor r=91.0764 c=0
Rl29 (\2\:B \3\:B) resistor r=154.538 c=0
Rl6 (Cp \2\:Cp) resistor r=31.0981 c=0
Rl7 (\2\:Cp \3\:Cp) resistor r=146.154 c=0
Rl9 (S1b \2\:S1b) resistor r=217.124 c=0
Rl11 (\2\:S1b \4\:S1b) resistor r=51.8781 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=8.9152 c=0
Rl17 (n1 \4\:n1) resistor r=7.924 c=0
Rl13 (n0 \2\:n0) resistor r=146.154 c=0
Rl14 (\2\:n0 \3\:n0) resistor r=68.4636 c=0
Rl25 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl26 (\2\:S0b \3\:S0b) resistor r=228.4 c=0
Rz11 (VDD \1\:VDD) resistor r=75 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz8 (\4\:VDD \1\:VDD) resistor r=12.5 c=0
Rz9 (\7\:VDD \1\:VDD) resistor r=12.5 c=0
Rz10 (\9\:VDD \1\:VDD) resistor r=25 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz12 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\6\:Cp \7\:Cp) resistor r=75 c=0
Rz2 (\7\:S1b \8\:S1b) resistor r=75 c=0
Rz3 (\12\:n1 \11\:n1) resistor r=75 c=0
Rz5 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz6 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry7 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry10 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry4 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\8\:VSS \1\:VSS) resistor r=15.5 c=0
Ry1 (\4\:Cp \5\:Cp) resistor r=62 c=0
Ry2 (\9\:S1b \10\:S1b) resistor r=62 c=0
Ry3 (\9\:n1 \8\:n1) resistor r=62 c=0
Ry5 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry6 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx8 (\3\:A \5\:A) resistor r=45 c=0
Rx4 (\8\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\1\:S1 \11\:S1) resistor r=45 c=0
Rx6 (\6\:S1 \12\:S1) resistor r=45 c=0
Rx11 (\4\:S0 \8\:S0) resistor r=45 c=0
Rx12 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx13 (\2\:S0 \11\:S0) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx10 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (Cp \8\:Cp) resistor r=45 c=0
Rx3 (\3\:S1b \5\:S1b) resistor r=45 c=0
Rx7 (\13\:n1 \4\:n1) resistor r=45 c=0
Rx9 (\3\:n0 \7\:n0) resistor r=45 c=0
Rx14 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn6 (\6\:Cp \3\:C \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=1.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn1 (\7\:S1b \3\:S1 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.62e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn9 (n8 \2\:Cp \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=3.19e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.355e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\11\:n1 \5\:S1 n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.553e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.09e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn8 (\11\:n1 S1b n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn7 (n6 \2\:n0 \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=1.958e-14 ps=1.7e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=6.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (\1\:Y n1 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.49e-14 ad=4.16e-14 ps=1.65e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.86635e-07 sb=3.79712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn2 (n2 \4\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.18621e-07 sb=1.13e-06 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn3 (\8\:n0 \3\:S0b n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.38621e-07 sb=8.1e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn5 (\8\:n0 \3\:S0 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.43621e-07 sb=6.05e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn4 (n4 \3\:B \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=8.7e-15 ps=9.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.48621e-07 sb=5e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mn0 (\4\:S0b \5\:S0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.03e-14 ps=9.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20862e-06 sb=1.4e-07 sd=160n sca=7.27658 \
        scb=0.00433573 scc=4.41722e-05 m=(1)
mp1 (\9\:S1b \4\:S1 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87349e-06 sd=160n sca=15.3753 \
        scb=0.0145715 scc=0.000753786 m=(1)
mp9 (n9 \3\:Cp \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=2.472e-14 ps=1.62e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.77488e-06 sd=160n sca=14.5741 \
        scb=0.0142021 scc=0.000753562 m=(1)
mp10 (\8\:n1 \4\:S1b n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=8.17e-14 ps=6.6e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.71535e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp8 (\8\:n1 \7\:S1 n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.257e-14 ad=8.17e-14 ps=6.4e-07 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.5007e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp7 (n7 n0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.875e-14 ad=2.258e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.3507e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp11 (\3\:Y n1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.528e-14 ad=6.24e-14 ps=1.27e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.55192e-07 sb=9.5141e-07 sd=160n sca=19.7306 \
        scb=0.0167337 scc=0.00184272 m=(2)
mp2 (n3 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=2.472e-14 ps=1.22e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4357e-06 sb=9.75e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp3 (\4\:n0 \1\:S0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.44e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54233e-06 sb=8.15e-07 sd=160n sca=11.2317 \
        scb=0.00932789 scc=0.000203581 m=(1)
mp5 (\4\:n0 S0b n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.73e-14 \
        ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.6186e-06 sb=6.1e-07 sd=160n sca=11.2412 scb=0.00932961 \
        scc=0.000203582 m=(1)
mp4 (n5 \1\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71721e-06 sb=3.45e-07 sd=160n sca=12.0423 \
        scb=0.00969901 scc=0.000203806 m=(1)
mp0 (\8\:S0b \7\:S0 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79349e-06 sb=1.4e-07 sd=160n sca=13.6165 \
        scb=0.011597 scc=0.00021346 m=(1)
ends MXI3X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:40:11 2012 )
// Library name: gsclib045
// Cell name: MXI3X4
// View name: extracted

simulator lang=spectre

subckt MXI3X4 A B C S0 S1 VDD VSS Y
mp6 (\7\:Cp \1\:C \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=53.3953 \
        scb=0.0394806 scc=0.00625575 m=(1)
C1 (S1 VSS) capacitor c=2.10027e-17
C2 (S0 VSS) capacitor c=8.04662e-17
C3 (VDD VSS) capacitor c=2.19602e-16
C4 (Y VSS) capacitor c=1.52566e-17
C5 (C VSS) capacitor c=5.55413e-17
C6 (B VSS) capacitor c=7.12458e-17
C7 (Cp VSS) capacitor c=6.9756e-17
C8 (S1b VSS) capacitor c=6.60192e-17
C9 (n1 VSS) capacitor c=3.1077e-16
C10 (n0 VSS) capacitor c=1.98006e-17
C11 (n2 VSS) capacitor c=5.87324e-18
C12 (S0b VSS) capacitor c=3.0135e-17
C13 (n9 VSS) capacitor c=1.7435e-19
C14 (n7 VSS) capacitor c=4.44765e-18
C15 (n3 VSS) capacitor c=2.42348e-18
C16 (\7\:S0 VSS) capacitor c=4.79101e-17
C17 (\3\:B VSS) capacitor c=3.91522e-17
C18 (\2\:S0 VSS) capacitor c=4.49408e-17
C19 (\4\:A VSS) capacitor c=5.48097e-17
C20 (\4\:n0 VSS) capacitor c=6.86511e-17
C21 (\6\:S1 VSS) capacitor c=4.86336e-17
C22 (\3\:S1b VSS) capacitor c=4.10669e-17
C23 (\3\:Cp VSS) capacitor c=7.9185e-17
C24 (\1\:S1 VSS) capacitor c=4.01021e-17
C25 (\1\:C VSS) capacitor c=2.70874e-17
C26 (\5\:S0 VSS) capacitor c=2.64841e-17
C27 (\1\:B VSS) capacitor c=7.46121e-17
C28 (\3\:S0 VSS) capacitor c=6.14895e-17
C29 (\3\:S0b VSS) capacitor c=6.06027e-17
C30 (\1\:A VSS) capacitor c=4.7165e-17
C31 (\3\:n0 VSS) capacitor c=2.57402e-17
C32 (\4\:S1 VSS) capacitor c=6.43184e-17
C33 (\3\:S1 VSS) capacitor c=4.3709e-17
C34 (\4\:C VSS) capacitor c=1.6785e-17
C35 (\6\:S0 VSS) capacitor c=4.76819e-17
C36 (\2\:B VSS) capacitor c=6.16205e-17
C37 (\4\:S0 VSS) capacitor c=5.91143e-17
C38 (\2\:S0b VSS) capacitor c=6.62253e-17
C39 (\1\:S0 VSS) capacitor c=5.4888e-17
C40 (\3\:A VSS) capacitor c=2.50863e-17
C41 (\7\:S1 VSS) capacitor c=3.43389e-17
C42 (\2\:S1b VSS) capacitor c=5.80451e-17
C43 (\5\:S1 VSS) capacitor c=6.62638e-17
C44 (\2\:Cp VSS) capacitor c=7.56539e-17
C45 (\2\:S1 VSS) capacitor c=5.60466e-17
C46 (\3\:C VSS) capacitor c=1.10161e-17
C47 (\8\:S0b VSS) capacitor c=1.27971e-17
C48 (\1\:VDD VSS) capacitor c=4.76103e-17
C49 (\7\:n0 VSS) capacitor c=1.03758e-16
C50 (\23\:n1 VSS) capacitor c=5.31875e-17
C51 (\18\:VDD VSS) capacitor c=2.39159e-17
C52 (\8\:S1b VSS) capacitor c=1.37234e-17
C53 (\7\:Cp VSS) capacitor c=5.42226e-17
C54 (\20\:VDD VSS) capacitor c=2.55052e-17
C55 (\3\:VDD VSS) capacitor c=4.64165e-17
C56 (\4\:S0b VSS) capacitor c=4.8317e-17
C57 (\9\:n0 VSS) capacitor c=4.54411e-17
C58 (\1\:Y VSS) capacitor c=1.26338e-16
C59 (\21\:n1 VSS) capacitor c=5.69639e-17
C60 (\6\:S1b VSS) capacitor c=8.38191e-17
C61 (\5\:Cp VSS) capacitor c=1.29786e-16
C62 (\2\:C VSS) capacitor c=1.1309e-17
C63 (\2\:n0 VSS) capacitor c=2.98476e-17
C64 (\2\:A VSS) capacitor c=4.60501e-17
C65 (\5\:C VSS) capacitor c=3.96436e-17
C66 (\4\:Cp VSS) capacitor c=1.08992e-16
C67 (\4\:S1b VSS) capacitor c=6.38988e-17
C68 (\5\:S1b VSS) capacitor c=1.0655e-16
C69 (\8\:S1 VSS) capacitor c=7.66462e-17
C70 (\9\:S1 VSS) capacitor c=7.10053e-17
C71 (\10\:S1 VSS) capacitor c=5.83419e-17
C72 (\19\:n1 VSS) capacitor c=3.78851e-17
C73 (\20\:n1 VSS) capacitor c=1.2176e-16
C74 (\4\:Y VSS) capacitor c=1.89603e-16
C75 (\5\:A VSS) capacitor c=1.26789e-16
C76 (\5\:n0 VSS) capacitor c=1.37072e-16
C77 (\6\:n0 VSS) capacitor c=2.08517e-16
C78 (\8\:S0 VSS) capacitor c=4.81476e-17
C79 (\10\:S0 VSS) capacitor c=6.17726e-17
C80 (\4\:B VSS) capacitor c=6.15936e-17
C81 (\6\:S0b VSS) capacitor c=9.64304e-17
C82 (\7\:S0b VSS) capacitor c=6.37277e-17
C83 (\5\:VDD VSS) capacitor c=2.39069e-16
C84 (\9\:VDD VSS) capacitor c=1.01222e-17
C85 (\10\:VDD VSS) capacitor c=9.22574e-18
Rk20 (\5\:A A) resistor r=0.002995 c=0
Rk8 (\9\:S1 S1) resistor r=0.01708 c=0
Rk7 (\8\:S1 \9\:S1) resistor r=0.3487 c=0
Rk9 (\9\:S1 \10\:S1) resistor r=0.2158 c=0
Rk24 (\8\:S0 S0) resistor r=0.26 c=0
Rk25 (S0 \9\:S0) resistor r=0.002412 c=0
Rk26 (\9\:S0 \10\:S0) resistor r=0.381 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.5881 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.1201 c=0
Rk51 (\5\:VDD \8\:VDD) resistor r=0.3807 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.0374 c=0
Rk54 (\10\:VDD VDD) resistor r=0.03965 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.373 c=0
Rk59 (\9\:VDD \19\:VDD) resistor r=0.2595 c=0
Rk60 (\10\:VDD \21\:VDD) resistor r=0.4157 c=0
Rk19 (\4\:Y Y) resistor r=0.02589 c=0
Rk14 (\1\:Y \4\:Y) resistor r=0.2624 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.1126 c=0
Rk32 (\3\:VSS \4\:VSS) resistor r=0.2379 c=0
Rk33 (\4\:VSS \5\:VSS) resistor r=0.1567 c=0
Rk36 (\5\:VSS \8\:VSS) resistor r=0.1652 c=0
Rk37 (\8\:VSS \9\:VSS) resistor r=0.2329 c=0
Rk39 (\10\:VSS VSS) resistor r=0.0597 c=0
Rk38 (\9\:VSS \10\:VSS) resistor r=0.358 c=0
Rk41 (\3\:VSS \13\:VSS) resistor r=0.2894 c=0
Rk45 (\9\:VSS \21\:VSS) resistor r=0.2274 c=0
Rk46 (\10\:VSS \23\:VSS) resistor r=0.07346 c=0
Rk1 (\5\:C C) resistor r=0.1909 c=0
Rk27 (B \4\:B) resistor r=0.1568 c=0
Rk2 (\4\:Cp \6\:Cp) resistor r=0.7733 c=0
Rk3 (\6\:Cp \8\:Cp) resistor r=0.3027 c=0
Rk4 (\4\:S1b \5\:S1b) resistor r=0.3889 c=0
Rk5 (\5\:S1b \7\:S1b) resistor r=0.5109 c=0
Rk6 (\5\:S1b \9\:S1b) resistor r=0.06419 c=0
Rk10 (\19\:n1 \20\:n1) resistor r=0.1995 c=0
Rk11 (\20\:n1 \22\:n1) resistor r=0.4986 c=0
Rk12 (\20\:n1 \24\:n1) resistor r=0.4603 c=0
Rk21 (\5\:n0 \6\:n0) resistor r=1.0741 c=0
Rk22 (\6\:n0 \8\:n0) resistor r=0.6335 c=0
Rk23 (\6\:n0 \10\:n0) resistor r=0.2743 c=0
Rk28 (\5\:S0b \6\:S0b) resistor r=0.5308 c=0
Rk29 (\6\:S0b \7\:S0b) resistor r=0.4335 c=0
Rk30 (\6\:S0b \9\:S0b) resistor r=0.04758 c=0
Rl35 (\2\:A \4\:A) resistor r=82.1542 c=0
Rl33 (\1\:A \2\:A) resistor r=141.817 c=0
Rl34 (\2\:A \3\:A) resistor r=7.6652 c=0
Rl11 (\6\:S1 \7\:S1) resistor r=31.461 c=0
Rl8 (\4\:S1 \5\:S1) resistor r=86.5156 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=73.0769 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=108.791 c=0
Rl43 (\6\:S0 \7\:S0) resistor r=154.945 c=0
Rl42 (\5\:S0 \6\:S0) resistor r=36.5385 c=0
Rl39 (\3\:S0 \4\:S0) resistor r=49.9772 c=0
Rl36 (\1\:S0 \2\:S0) resistor r=53.733 c=0
Rl1 (\1\:C \2\:C) resistor r=59.3295 c=0
Rl3 (\2\:C \4\:C) resistor r=34.3295 c=0
Rl2 (\2\:C \3\:C) resistor r=1.2666 c=0
Rl41 (\2\:B \3\:B) resistor r=70.3297 c=0
Rl40 (\1\:B \2\:B) resistor r=121.154 c=0
Rl6 (Cp \2\:Cp) resistor r=78.8233 c=0
Rl7 (\2\:Cp \3\:Cp) resistor r=168.591 c=0
Rl9 (S1b \2\:S1b) resistor r=177.587 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=26.098 c=0
Rl12 (n0 \2\:n0) resistor r=8.3086 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=163.176 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=34.3295 c=0
Rl37 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl38 (\2\:S0b \3\:S0b) resistor r=162.694 c=0
Rz16 (VDD \3\:VDD) resistor r=75 c=0
Rz14 (\4\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz15 (\8\:VDD \3\:VDD) resistor r=9.375 c=0
Rz8 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz13 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz1 (\5\:Cp \6\:Cp) resistor r=75 c=0
Rz2 (\6\:S1b \7\:S1b) resistor r=75 c=0
Rz3 (\22\:n1 \21\:n1) resistor r=75 c=0
Rz6 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz7 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry12 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry11 (VSS \1\:VSS) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=12.4 c=0
Ry10 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\7\:Cp \8\:Cp) resistor r=62 c=0
Ry2 (\8\:S1b \9\:S1b) resistor r=62 c=0
Ry3 (\24\:n1 \23\:n1) resistor r=31 c=0
Ry6 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry7 (\8\:S0b \9\:S0b) resistor r=62 c=0
Rx8 (\3\:A \5\:A) resistor r=45 c=0
Rx4 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx5 (\5\:S1 \9\:S1) resistor r=45 c=0
Rx6 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx10 (\6\:S0 \8\:S0) resistor r=45 c=0
Rx11 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx12 (\1\:S0 \10\:S0) resistor r=45 c=0
Rx1 (\3\:C \5\:C) resistor r=45 c=0
Rx13 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:Cp \4\:Cp) resistor r=45 c=0
Rx3 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\19\:n1 n1) resistor r=45 c=0
Rx9 (n0 \5\:n0) resistor r=45 c=0
Rx14 (\2\:S0b \7\:S0b) resistor r=45 c=0
mn6 (\5\:Cp \4\:C \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.03e-14 ps=1.45e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn1 (\6\:S1b \3\:S1 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=2.755e-14 ps=9.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mn9 (n8 Cp \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.538e-14 ad=1.23e-14 ps=9.2e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.87561e-07 sb=1.88988e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn10 (\21\:n1 \4\:S1 n8 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.793e-14 ps=5.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92561e-07 sb=1.8361e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn8 (\21\:n1 S1b n6 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=3.793e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.22561e-07 sb=1.71829e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn7 (n6 \3\:n0 \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=4.305e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.77561e-07 sb=1.58768e-06 sd=160n sca=8.84876 \
        scb=0.0071018 scc=0.000159248 m=(1)
mn11_1__rcx (\1\:Y n1 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.733e-14 ad=4.355e-14 ps=1.325e-06 pd=8.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05606e-06 sb=1.47913e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(4)
mn2 (n2 \1\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.715e-14 ad=2.9e-14 ps=1.4e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70672e-06 sb=1.02e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (\9\:n0 \3\:S0b n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78276e-06 sb=7.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (\9\:n0 \3\:S0 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84638e-06 sb=5.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (n4 \1\:B \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87897e-06 sb=4.65e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\4\:S0b \5\:S0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.77e-14 ps=6.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94259e-06 sb=2.6e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp1 (\8\:S1b \1\:S1 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96907e-06 sd=160n sca=14.9846 \
        scb=0.0143333 scc=0.000753595 m=(1)
mp9 (n9 \3\:Cp \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.02984e-07 sb=1.89887e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp10 (\23\:n1 \3\:S1b n9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.07984e-07 sb=1.83605e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp8 (\23\:n1 \6\:S1 n7 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=4.96e-14 ps=9.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12984e-07 sb=1.77323e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp7 (n7 \4\:n0 \5\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.01e-14 ad=4.495e-14 ps=1.16e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02984e-07 sb=1.715e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp11_1__rcx (\4\:Y n1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.506e-14 ad=7.8e-14 ps=1.13e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.33269e-07 sb=1.42212e-06 sd=160n sca=17.7856 \
        scb=0.015626 scc=0.00148402 m=(4)
mp2 (n3 \4\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.15e-14 ps=1.16e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96907e-06 sb=9.7e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp4 (n5 \3\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=12.9609 scb=0.0107808 \
        scc=0.000241025 m=(1)
mp3 (\7\:n0 \2\:S0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp5 (\7\:n0 S0b n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.515e-14 \
        ad=3.87e-14 ps=8.5e-07 pd=7.9e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=6e-07 sd=160n sca=11.7777 scb=0.00984784 scc=0.000239304 m=(1)
mp0 (\8\:S0b \7\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.7738 scb=0.0152661 \
        scc=0.000310434 m=(1)
ends MXI3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:40:49 2012 )
// Library name: gsclib045
// Cell name: MXI3XL
// View name: extracted

simulator lang=spectre

subckt MXI3XL A B C S0 S1 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.0659 scb=0.012282 \
        scc=0.000178056 m=(1)
C1 (Y VSS) capacitor c=1.70517e-17
C2 (B VSS) capacitor c=5.14866e-17
C3 (S0 VSS) capacitor c=8.39065e-17
C4 (C VSS) capacitor c=6.31505e-17
C5 (VDD VSS) capacitor c=2.69577e-16
C6 (A VSS) capacitor c=4.0639e-17
C7 (S0b VSS) capacitor c=6.77169e-17
C8 (n0 VSS) capacitor c=8.59568e-17
C9 (n4 VSS) capacitor c=9.21411e-18
C10 (n1 VSS) capacitor c=2.37326e-17
C11 (S1b VSS) capacitor c=7.30061e-17
C12 (Cp VSS) capacitor c=2.74724e-17
C13 (n5 VSS) capacitor c=5.73212e-18
C14 (n7 VSS) capacitor c=2.94524e-19
C15 (n9 VSS) capacitor c=4.27668e-18
C16 (\3\:C VSS) capacitor c=3.84522e-17
C17 (\6\:S1 VSS) capacitor c=4.61639e-17
C18 (\3\:Cp VSS) capacitor c=6.64734e-17
C19 (\3\:S1b VSS) capacitor c=4.40681e-17
C20 (\3\:S1 VSS) capacitor c=9.36637e-17
C21 (\4\:B VSS) capacitor c=3.15291e-17
C22 (\3\:S0b VSS) capacitor c=4.0401e-17
C23 (\8\:S0 VSS) capacitor c=3.23763e-17
C24 (\1\:A VSS) capacitor c=4.56928e-17
C25 (\1\:S0 VSS) capacitor c=3.02896e-17
C26 (\2\:n1 VSS) capacitor c=3.67177e-17
C27 (\1\:C VSS) capacitor c=2.71845e-17
C28 (\4\:S1 VSS) capacitor c=4.10265e-17
C29 (\4\:Cp VSS) capacitor c=3.66129e-17
C30 (\1\:S1 VSS) capacitor c=3.22387e-17
C31 (\3\:n0 VSS) capacitor c=4.78167e-17
C32 (\3\:B VSS) capacitor c=4.80868e-17
C33 (\5\:S0 VSS) capacitor c=4.84118e-17
C34 (\3\:A VSS) capacitor c=6.28657e-17
C35 (\4\:S0 VSS) capacitor c=4.39091e-17
C36 (\3\:n1 VSS) capacitor c=1.81383e-17
C37 (\2\:C VSS) capacitor c=2.46825e-17
C38 (\5\:S1 VSS) capacitor c=6.347e-17
C39 (\2\:S1 VSS) capacitor c=6.49906e-17
C40 (\4\:S1b VSS) capacitor c=3.51389e-17
C41 (\2\:S1b VSS) capacitor c=2.96124e-17
C42 (\2\:n0 VSS) capacitor c=6.64875e-17
C43 (\1\:B VSS) capacitor c=2.72603e-17
C44 (\4\:S0b VSS) capacitor c=3.82406e-17
C45 (\7\:S0 VSS) capacitor c=6.7955e-17
C46 (\2\:S0b VSS) capacitor c=4.49321e-17
C47 (\2\:A VSS) capacitor c=6.1432e-17
C48 (\3\:S0 VSS) capacitor c=1.63217e-17
C49 (\3\:Y VSS) capacitor c=3.95492e-17
C50 (\5\:VDD VSS) capacitor c=4.42445e-17
C51 (\9\:Cp VSS) capacitor c=3.22811e-17
C52 (\10\:S1b VSS) capacitor c=9.66941e-17
C53 (\7\:VDD VSS) capacitor c=2.42375e-17
C54 (\5\:n1 VSS) capacitor c=2.29314e-16
C55 (\10\:VDD VSS) capacitor c=3.65837e-17
C56 (\8\:n0 VSS) capacitor c=5.97855e-17
C57 (\14\:VDD VSS) capacitor c=2.97207e-17
C58 (\10\:S0b VSS) capacitor c=9.01524e-17
C59 (\1\:VDD VSS) capacitor c=7.17738e-17
C60 (\1\:Y VSS) capacitor c=1.86524e-17
C61 (\5\:Cp VSS) capacitor c=4.35867e-17
C62 (\5\:S1b VSS) capacitor c=9.81455e-17
C63 (\7\:n1 VSS) capacitor c=8.41723e-17
C64 (\6\:n0 VSS) capacitor c=5.90191e-17
C65 (\8\:S0b VSS) capacitor c=1.90774e-17
C66 (\2\:S0 VSS) capacitor c=3.42852e-17
C67 (\2\:B VSS) capacitor c=3.61412e-17
C68 (\2\:Cp VSS) capacitor c=5.4989e-17
C69 (\9\:S0 VSS) capacitor c=6.06676e-17
C70 (\4\:A VSS) capacitor c=1.08528e-16
C71 (\5\:S0b VSS) capacitor c=7.52936e-17
C72 (\6\:S0b VSS) capacitor c=8.73733e-17
C73 (\7\:S0b VSS) capacitor c=7.53986e-17
C74 (\4\:n0 VSS) capacitor c=4.33834e-17
C75 (\5\:n0 VSS) capacitor c=1.07719e-16
C76 (\5\:B VSS) capacitor c=6.70611e-17
C77 (\7\:S1 VSS) capacitor c=6.06718e-17
C78 (\8\:S1 VSS) capacitor c=8.05093e-17
C79 (\7\:S1b VSS) capacitor c=8.66544e-17
C80 (\8\:S1b VSS) capacitor c=7.08078e-17
C81 (\9\:S1b VSS) capacitor c=1.15438e-16
C82 (\7\:Cp VSS) capacitor c=4.72319e-17
C83 (\8\:Cp VSS) capacitor c=7.67004e-17
C84 (\4\:C VSS) capacitor c=6.56395e-17
C85 (\4\:n1 VSS) capacitor c=1.58398e-16
C86 (\3\:VDD VSS) capacitor c=1.72098e-17
C87 (\9\:VDD VSS) capacitor c=2.87992e-17
C88 (\13\:VDD VSS) capacitor c=9.28866e-18
Rk24 (Y \2\:Y) resistor r=0.05101 c=0
Rk25 (Y \4\:Y) resistor r=0.177 c=0
Rk11 (B \5\:B) resistor r=0.0276 c=0
Rk26 (\2\:VSS \4\:VSS) resistor r=0.719 c=0
Rk27 (\4\:VSS \5\:VSS) resistor r=0.0324 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.481 c=0
Rk29 (\6\:VSS \7\:VSS) resistor r=0.3383 c=0
Rk31 (\8\:VSS VSS) resistor r=0.2152 c=0
Rk30 (\7\:VSS \8\:VSS) resistor r=0.08506 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.3029 c=0
Rk33 (\6\:VSS \12\:VSS) resistor r=0.3048 c=0
Rk34 (\8\:VSS \14\:VSS) resistor r=0.31 c=0
Rk1 (\9\:S0 S0) resistor r=0.323 c=0
Rk2 (S0 \10\:S0) resistor r=0.002758 c=0
Rk21 (C \4\:C) resistor r=0.03245 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.08756 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.4145 c=0
Rk37 (\3\:VDD \6\:VDD) resistor r=0.1993 c=0
Rk38 (\4\:VDD \8\:VDD) resistor r=0.07146 c=0
Rk39 (\4\:VDD \9\:VDD) resistor r=0.3985 c=0
Rk40 (\9\:VDD \11\:VDD) resistor r=0.2573 c=0
Rk41 (\9\:VDD \12\:VDD) resistor r=0.3533 c=0
Rk44 (\13\:VDD VDD) resistor r=0.2152 c=0
Rk42 (\12\:VDD \13\:VDD) resistor r=0.08506 c=0
Rk43 (\13\:VDD \15\:VDD) resistor r=0.2581 c=0
Rk13 (\8\:S1 S1) resistor r=0.0121 c=0
Rk12 (\7\:S1 \8\:S1) resistor r=0.2673 c=0
Rk3 (\4\:A A) resistor r=0.06271 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4039 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.3352 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.1005 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6663 c=0
Rk8 (\4\:n0 \5\:n0) resistor r=0.1725 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.4141 c=0
Rk10 (\5\:n0 \9\:n0) resistor r=0.5343 c=0
Rk22 (\4\:n1 \6\:n1) resistor r=1.2541 c=0
Rk23 (\6\:n1 \8\:n1) resistor r=0.5517 c=0
Rk14 (\6\:S1b \7\:S1b) resistor r=0.562 c=0
Rk15 (\7\:S1b \8\:S1b) resistor r=0.4261 c=0
Rk16 (\7\:S1b \9\:S1b) resistor r=0.3089 c=0
Rk17 (\9\:S1b \11\:S1b) resistor r=0.5595 c=0
Rk18 (\6\:Cp \7\:Cp) resistor r=0.2093 c=0
Rk19 (\7\:Cp \8\:Cp) resistor r=0.3341 c=0
Rk20 (\7\:Cp \10\:Cp) resistor r=0.1198 c=0
Rl13 (\2\:B \4\:B) resistor r=34.3295 c=0
Rl12 (\2\:B \3\:B) resistor r=174.714 c=0
Rl11 (\1\:B \2\:B) resistor r=3.5213 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=43.9449 c=0
Rl3 (\2\:S0 \4\:S0) resistor r=165.099 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=13.091 c=0
Rl9 (\6\:S0 \8\:S0) resistor r=73.2449 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=193.751 c=0
Rl8 (\6\:S0 \7\:S0) resistor r=1.2666 c=0
Rl26 (\2\:C \3\:C) resistor r=26.3736 c=0
Rl25 (\1\:C \2\:C) resistor r=42.3077 c=0
Rl24 (\5\:S1 \6\:S1) resistor r=82.2464 c=0
Rl23 (\4\:S1 \5\:S1) resistor r=137.694 c=0
Rl19 (\2\:S1 \3\:S1) resistor r=226.477 c=0
Rl18 (\1\:S1 \2\:S1) resistor r=103.079 c=0
Rl4 (\1\:A \2\:A) resistor r=100.692 c=0
Rl5 (\2\:A \3\:A) resistor r=91.0764 c=0
Rl10 (\3\:S0b \4\:S0b) resistor r=71.8456 c=0
Rl6 (S0b \2\:S0b) resistor r=29.5379 c=0
Rl14 (n0 \2\:n0) resistor r=159.79 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=29.5379 c=0
Rl27 (n1 \2\:n1) resistor r=92.3077 c=0
Rl28 (n1 \3\:n1) resistor r=24.2328 c=0
Rl17 (\3\:S1b \4\:S1b) resistor r=24.2328 c=0
Rl16 (S1b \2\:S1b) resistor r=48.7687 c=0
Rl20 (Cp \2\:Cp) resistor r=2.0213 c=0
Rl21 (\2\:Cp \3\:Cp) resistor r=166.588 c=0
Rl22 (\2\:Cp \4\:Cp) resistor r=86.2526 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz11 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\1\:VDD \12\:VDD) resistor r=10.7143 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz5 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\5\:S1b \6\:S1b) resistor r=75 c=0
Rz4 (\5\:Cp \6\:Cp) resistor r=75 c=0
Ry6 (\3\:Y \4\:Y) resistor r=62 c=0
Ry7 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry8 (\3\:VSS \7\:VSS) resistor r=8.8571 c=0
Ry9 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry10 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry11 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry3 (\10\:S1b \11\:S1b) resistor r=62 c=0
Ry4 (\9\:Cp \10\:Cp) resistor r=62 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx1 (\7\:S0 \9\:S0) resistor r=45 c=0
Rx2 (\3\:S0 \10\:S0) resistor r=45 c=0
Rx13 (\2\:C \4\:C) resistor r=45 c=0
Rx8 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx9 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx10 (\2\:S1b \8\:S1b) resistor r=45 c=0
Rx11 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx12 (Cp \8\:Cp) resistor r=45 c=0
mn0 (\8\:S0b \4\:S0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn2 (n2 \3\:A \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.975e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn3 (\6\:n0 S0b n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.87e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn5 (\6\:n0 \5\:S0 n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.665e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn4 (n4 \3\:B \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.567e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.305e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn7 (n6 \3\:n0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.1e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn8 (\7\:n1 S1b n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=5.365e-14 ps=4.1e-07 pd=1.03e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.325e-06 sb=9.95e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn10 (\7\:n1 \1\:S1 n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=5.365e-14 ps=6.7e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=5.8e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn9 (n8 \4\:Cp \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.755e-14 ps=6.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (\5\:S1b \4\:S1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn6 (\5\:Cp \1\:C \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (\1\:Y \2\:n1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp2 (n3 \1\:A \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.875e-06 sd=160n sca=11.9366 \
        scb=0.00922608 scc=0.000149558 m=(1)
mp3 (\8\:n0 \8\:S0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.63e-06 sd=160n sca=10.9876 \
        scb=0.00862138 scc=0.000148876 m=(1)
mp5 (\8\:n0 \3\:S0b n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.425e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp4 (n5 \4\:B \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.762e-14 ps=7.7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.205e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp7 (n7 n0 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.72e-14 ps=7.7e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=9.9e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp8 (\5\:n1 \3\:S1 n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.837e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=8.65e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp10 (\5\:n1 \3\:S1b n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.837e-14 ps=7.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=5.95e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp9 (n9 \3\:Cp \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=3.117e-14 ps=1.42e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=4.05e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp1 (\10\:S1b \6\:S1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.03e-14 ad=3.01e-14 ps=1.42e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.8061 scb=0.00857865 \
        scc=0.000148871 m=(1)
mp6 (\9\:Cp \3\:C \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.892e-14 ad=3.44e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.2e-07 sd=160n sca=48.1151 \
        scb=0.0305074 scc=0.00589319 m=(1)
mp11 (\3\:Y n1 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.892e-14 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.4e-07 sd=160n sca=58.393 scb=0.0461946 \
        scc=0.00708003 m=(1)
ends MXI3XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:41:28 2012 )
// Library name: gsclib045
// Cell name: MXI4X1
// View name: extracted

simulator lang=spectre

subckt MXI4X1 A B C D S0 S1 VDD VSS Y
mp14 (\1\:Y \4\:n2 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=5.46e-14 ps=1.3e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.47885e-07 sd=160n sca=26.6306 \
        scb=0.0275086 scc=0.00208721 m=(1)
C1 (Y VSS) capacitor c=1.46139e-17
C2 (C VSS) capacitor c=4.17402e-17
C3 (S0 VSS) capacitor c=2.55734e-17
C4 (D VSS) capacitor c=6.46324e-17
C5 (A VSS) capacitor c=3.77774e-17
C6 (VDD VSS) capacitor c=2.91058e-16
C7 (S1 VSS) capacitor c=7.8279e-17
C8 (B VSS) capacitor c=5.79221e-17
C9 (n2 VSS) capacitor c=2.31719e-17
C10 (S1b VSS) capacitor c=6.56408e-17
C11 (n1 VSS) capacitor c=8.41332e-17
C12 (net329 VSS) capacitor c=1.53557e-18
C13 (n0 VSS) capacitor c=6.46742e-17
C14 (net377 VSS) capacitor c=2.8562e-18
C15 (S0b VSS) capacitor c=6.48974e-17
C16 (net361 VSS) capacitor c=4.41776e-18
C17 (net284 VSS) capacitor c=2.09059e-18
C18 (net280 VSS) capacitor c=3.76654e-18
C19 (net320 VSS) capacitor c=2.0124e-18
C20 (net312 VSS) capacitor c=1.92492e-18
C21 (net304 VSS) capacitor c=3.33862e-18
C22 (\11\:S0 VSS) capacitor c=3.84606e-17
C23 (\3\:A VSS) capacitor c=4.92537e-17
C24 (\4\:S0 VSS) capacitor c=6.78954e-17
C25 (\5\:S0b VSS) capacitor c=3.87066e-17
C26 (\3\:B VSS) capacitor c=4.48255e-17
C27 (\1\:C VSS) capacitor c=3.94266e-17
C28 (\1\:S0 VSS) capacitor c=4.33944e-17
C29 (\1\:D VSS) capacitor c=6.3801e-17
C30 (\6\:S1 VSS) capacitor c=4.69681e-17
C31 (\3\:S1b VSS) capacitor c=4.5745e-17
C32 (\2\:n1 VSS) capacitor c=5.22034e-17
C33 (\1\:S1 VSS) capacitor c=3.60625e-17
C34 (\4\:n2 VSS) capacitor c=3.98375e-17
C35 (\9\:S0 VSS) capacitor c=3.34081e-17
C36 (\1\:A VSS) capacitor c=6.21812e-17
C37 (\7\:S0b VSS) capacitor c=5.03558e-17
C38 (\8\:S0 VSS) capacitor c=3.82815e-17
C39 (\1\:B VSS) capacitor c=6.01497e-17
C40 (\3\:C VSS) capacitor c=7.19817e-17
C41 (\3\:S0b VSS) capacitor c=6.32222e-17
C42 (\3\:S0 VSS) capacitor c=3.9472e-17
C43 (\4\:D VSS) capacitor c=3.05314e-17
C44 (\2\:n0 VSS) capacitor c=4.82207e-17
C45 (\4\:S1 VSS) capacitor c=8.9545e-17
C46 (\3\:S1 VSS) capacitor c=2.84743e-17
C47 (\3\:n2 VSS) capacitor c=3.12593e-17
C48 (\10\:S0 VSS) capacitor c=3.79353e-17
C49 (\2\:A VSS) capacitor c=7.05937e-17
C50 (\5\:S0 VSS) capacitor c=5.25595e-17
C51 (\8\:S0b VSS) capacitor c=1.98364e-17
C52 (\6\:S0b VSS) capacitor c=4.14867e-17
C53 (\7\:S0 VSS) capacitor c=4.9509e-17
C54 (\2\:B VSS) capacitor c=7.56854e-17
C55 (\2\:C VSS) capacitor c=5.18428e-17
C56 (\2\:S0 VSS) capacitor c=5.29292e-17
C57 (\4\:S0b VSS) capacitor c=2.67809e-17
C58 (\2\:S0b VSS) capacitor c=3.25552e-17
C59 (\3\:D VSS) capacitor c=1.09952e-17
C60 (\3\:n0 VSS) capacitor c=2.49549e-17
C61 (\7\:S1 VSS) capacitor c=4.34275e-17
C62 (\5\:S1 VSS) capacitor c=3.18733e-17
C63 (\2\:S1b VSS) capacitor c=6.80181e-17
C64 (\3\:n1 VSS) capacitor c=2.66161e-17
C65 (\2\:S1 VSS) capacitor c=3.40371e-17
C66 (\16\:S0b VSS) capacitor c=5.87918e-17
C67 (\7\:VDD VSS) capacitor c=3.19878e-17
C68 (\5\:n0 VSS) capacitor c=1.95786e-16
C69 (\9\:VDD VSS) capacitor c=3.13466e-17
C70 (\6\:n1 VSS) capacitor c=1.67729e-16
C71 (\11\:VDD VSS) capacitor c=3.03023e-17
C72 (\9\:n2 VSS) capacitor c=1.8223e-16
C73 (\14\:VDD VSS) capacitor c=4.18877e-17
C74 (\6\:S1b VSS) capacitor c=2.35007e-17
C75 (\17\:VDD VSS) capacitor c=4.418e-17
C76 (\1\:Y VSS) capacitor c=6.73344e-17
C77 (\1\:VDD VSS) capacitor c=1.27354e-16
C78 (\14\:S0b VSS) capacitor c=8.36678e-17
C79 (\7\:n0 VSS) capacitor c=9.49037e-17
C80 (\4\:n1 VSS) capacitor c=9.36941e-17
C81 (\5\:n2 VSS) capacitor c=6.86723e-17
C82 (\8\:S1b VSS) capacitor c=3.99959e-17
C83 (\3\:Y VSS) capacitor c=4.13448e-17
C84 (\2\:n2 VSS) capacitor c=1.67246e-17
C85 (\2\:D VSS) capacitor c=3.36258e-17
C86 (\6\:S0 VSS) capacitor c=3.21754e-17
C87 (\4\:S1b VSS) capacitor c=5.79068e-17
C88 (\5\:S1b VSS) capacitor c=4.7883e-17
C89 (\8\:n2 VSS) capacitor c=1.3942e-16
C90 (\8\:S1 VSS) capacitor c=8.60993e-17
C91 (\9\:S1 VSS) capacitor c=1.1713e-16
C92 (\10\:S1 VSS) capacitor c=4.24411e-17
C93 (\5\:D VSS) capacitor c=3.91028e-17
C94 (\8\:n1 VSS) capacitor c=1.29647e-16
C95 (\4\:C VSS) capacitor c=7.0827e-17
C96 (\5\:B VSS) capacitor c=3.38052e-17
C97 (\12\:S0 VSS) capacitor c=1.05912e-16
C98 (\13\:S0 VSS) capacitor c=8.95591e-17
C99 (\4\:n0 VSS) capacitor c=1.49655e-16
C100 (\4\:A VSS) capacitor c=7.85074e-17
C101 (\14\:S0 VSS) capacitor c=3.29994e-17
C102 (\15\:S0 VSS) capacitor c=4.69234e-17
C103 (\9\:S0b VSS) capacitor c=7.55301e-17
C104 (\10\:S0b VSS) capacitor c=1.30851e-16
C105 (\11\:S0b VSS) capacitor c=1.59029e-16
C106 (\12\:S0b VSS) capacitor c=1.01277e-16
C107 (\13\:S0b VSS) capacitor c=1.19835e-16
C108 (\3\:VDD VSS) capacitor c=1.45743e-18
C109 (\5\:VDD VSS) capacitor c=2.34e-17
C110 (\13\:VDD VSS) capacitor c=2.5175e-17
Rk2 (\4\:Y Y) resistor r=0.03725 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.3362 c=0
Rk15 (\4\:C C) resistor r=0.1378 c=0
Rk19 (\12\:S0 \13\:S0) resistor r=0.4155 c=0
Rk23 (\14\:S0 S0) resistor r=0.08682 c=0
Rk24 (S0 \15\:S0) resistor r=0.1415 c=0
Rk12 (\5\:D D) resistor r=0.1397 c=0
Rk22 (A \4\:A) resistor r=0.01935 c=0
Rk45 (\2\:VDD \3\:VDD) resistor r=0.1327 c=0
Rk46 (\3\:VDD \4\:VDD) resistor r=0.218 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.2005 c=0
Rk48 (\5\:VDD \6\:VDD) resistor r=0.5026 c=0
Rk49 (\3\:VDD \8\:VDD) resistor r=0.2213 c=0
Rk50 (\5\:VDD \10\:VDD) resistor r=0.1296 c=0
Rk51 (\6\:VDD \12\:VDD) resistor r=0.07149 c=0
Rk52 (\6\:VDD \13\:VDD) resistor r=0.509 c=0
Rk53 (\13\:VDD \15\:VDD) resistor r=0.2679 c=0
Rk56 (\16\:VDD VDD) resistor r=0.1509 c=0
Rk54 (\13\:VDD \16\:VDD) resistor r=0.1929 c=0
Rk55 (\16\:VDD \18\:VDD) resistor r=0.312 c=0
Rk10 (\9\:S1 S1) resistor r=0.5652 c=0
Rk9 (\8\:S1 \9\:S1) resistor r=0.5927 c=0
Rk11 (S1 \10\:S1) resistor r=0.2106 c=0
Rk31 (\2\:VSS \3\:VSS) resistor r=0.1302 c=0
Rk32 (\3\:VSS \4\:VSS) resistor r=0.2205 c=0
Rk33 (\4\:VSS \5\:VSS) resistor r=0.2632 c=0
Rk34 (\5\:VSS \6\:VSS) resistor r=0.08759 c=0
Rk35 (\6\:VSS \7\:VSS) resistor r=0.4538 c=0
Rk36 (\7\:VSS \8\:VSS) resistor r=0.2481 c=0
Rk37 (\8\:VSS \9\:VSS) resistor r=0.1493 c=0
Rk39 (\10\:VSS VSS) resistor r=0.1566 c=0
Rk38 (\9\:VSS \10\:VSS) resistor r=0.241 c=0
Rk40 (\3\:VSS \12\:VSS) resistor r=0.07405 c=0
Rk41 (\5\:VSS \14\:VSS) resistor r=0.1952 c=0
Rk42 (\7\:VSS \16\:VSS) resistor r=0.3204 c=0
Rk43 (\9\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk44 (\10\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk16 (\4\:B \5\:B) resistor r=0.004455 c=0
Rk17 (\6\:B B) resistor r=0.004583 c=0
Rk18 (\5\:B \6\:B) resistor r=0.02633 c=0
Rk6 (\6\:n2 \7\:n2) resistor r=0.464 c=0
Rk7 (\7\:n2 \8\:n2) resistor r=0.9623 c=0
Rk8 (\7\:n2 \10\:n2) resistor r=0.04435 c=0
Rk3 (\4\:S1b \5\:S1b) resistor r=0.3065 c=0
Rk4 (\5\:S1b \7\:S1b) resistor r=0.07551 c=0
Rk5 (\5\:S1b \9\:S1b) resistor r=0.2355 c=0
Rk13 (\5\:n1 \7\:n1) resistor r=0.5786 c=0
Rk14 (\7\:n1 \8\:n1) resistor r=1.0167 c=0
Rk20 (\4\:n0 \6\:n0) resistor r=1.1895 c=0
Rk21 (\6\:n0 \8\:n0) resistor r=0.6104 c=0
Rk25 (\9\:S0b \10\:S0b) resistor r=0.3971 c=0
Rk26 (\10\:S0b \11\:S0b) resistor r=0.7041 c=0
Rk27 (\11\:S0b \12\:S0b) resistor r=0.7498 c=0
Rk28 (\10\:S0b \13\:S0b) resistor r=0.4034 c=0
Rk29 (\13\:S0b \15\:S0b) resistor r=0.6977 c=0
Rk30 (\15\:S0b \17\:S0b) resistor r=0.5124 c=0
Rl21 (\1\:C \2\:C) resistor r=39.1533 c=0
Rl22 (\2\:C \3\:C) resistor r=112.23 c=0
Rl34 (\10\:S0 \11\:S0) resistor r=122.253 c=0
Rl33 (\9\:S0 \10\:S0) resistor r=59.6154 c=0
Rl27 (\4\:S0 \5\:S0) resistor r=112.694 c=0
Rl18 (\1\:S0 \2\:S0) resistor r=74.2328 c=0
Rl19 (\2\:S0 \3\:S0) resistor r=113.016 c=0
Rl30 (\6\:S0 \8\:S0) resistor r=91.9892 c=0
Rl28 (\5\:S0 \6\:S0) resistor r=82.6587 c=0
Rl29 (\6\:S0 \7\:S0) resistor r=92.233 c=0
Rl14 (\1\:D \2\:D) resistor r=38.1757 c=0
Rl16 (\2\:D \4\:D) resistor r=130.483 c=0
Rl15 (\2\:D \3\:D) resistor r=1.2666 c=0
Rl32 (\2\:A \3\:A) resistor r=26.3736 c=0
Rl31 (\1\:A \2\:A) resistor r=186.538 c=0
Rl11 (\6\:S1 \7\:S1) resistor r=67.9995 c=0
Rl8 (\4\:S1 \5\:S1) resistor r=47.3097 c=0
Rl4 (\1\:S1 \2\:S1) resistor r=37.2302 c=0
Rl5 (\2\:S1 \3\:S1) resistor r=29.5379 c=0
Rl24 (\2\:B \3\:B) resistor r=74.4505 c=0
Rl23 (\1\:B \2\:B) resistor r=175.704 c=0
Rl1 (n2 \2\:n2) resistor r=1.2713 c=0
Rl3 (\2\:n2 \4\:n2) resistor r=53.5603 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=49.7141 c=0
Rl9 (S1b \2\:S1b) resistor r=158.735 c=0
Rl10 (\2\:S1b \3\:S1b) resistor r=24.2328 c=0
Rl6 (n1 \2\:n1) resistor r=173.661 c=0
Rl7 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl12 (n0 \2\:n0) resistor r=173.077 c=0
Rl13 (n0 \3\:n0) resistor r=49.2328 c=0
Rl26 (\7\:S0b \8\:S0b) resistor r=77.6148 c=0
Rl25 (\5\:S0b \6\:S0b) resistor r=66.5405 c=0
Rl20 (\3\:S0b \4\:S0b) resistor r=86.8284 c=0
Rl17 (S0b \2\:S0b) resistor r=31.461 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz13 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz14 (\1\:VDD \6\:VDD) resistor r=7.5 c=0
Rz15 (\1\:VDD \16\:VDD) resistor r=18.75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz9 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz10 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz11 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz3 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz2 (\8\:S1b \9\:S1b) resistor r=75 c=0
Rz4 (\4\:n1 \5\:n1) resistor r=75 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz6 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry11 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry12 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry9 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry10 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry3 (\9\:n2 \10\:n2) resistor r=62 c=0
Ry2 (\6\:S1b \7\:S1b) resistor r=62 c=0
Ry4 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry5 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry6 (\16\:S0b \17\:S0b) resistor r=62 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx10 (\7\:S0 \12\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx14 (\10\:S0 \14\:S0) resistor r=45 c=0
Rx15 (\5\:S0 \15\:S0) resistor r=45 c=0
Rx6 (\3\:D \5\:D) resistor r=45 c=0
Rx13 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\5\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx9 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (n2 \8\:n2) resistor r=45 c=0
Rx1 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx12 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx16 (\6\:S0b \9\:S0b) resistor r=45 c=0
Rx17 (\4\:S0b \11\:S0b) resistor r=45 c=0
Rx18 (\2\:S0b \12\:S0b) resistor r=45 c=0
Rx19 (\8\:S0b \13\:S0b) resistor r=45 c=0
mn14 (\3\:Y \3\:n2 \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.64e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.97981e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (\8\:S1b \3\:S1 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.9e-14 ps=1.72e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn12 (net345 n1 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.725e-14 ad=8.7e-15 ps=1.34e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (\5\:n2 \4\:S1 net345 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn11 (\5\:n2 S1b net329 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn10 (net329 \2\:n0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=2.972e-14 ps=9.8e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn8 (net377 \4\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=3.625e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.8869e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn7 (\4\:n1 \3\:S0b net369 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62e-06 sb=1.42724e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (net349 \1\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.85e-14 ad=2.247e-14 ps=1.6e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.02241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn9 (\4\:n1 \3\:S0 net377 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.63224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn6 (net369 \3\:C \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.267e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=1.32224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn4 (net361 \1\:B \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.267e-14 ad=3.625e-14 ps=1.22e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.00224e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\7\:n0 \7\:S0b net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.02241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (\7\:n0 \8\:S0 net361 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.32e-14 ps=7.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.07241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\14\:S0b \9\:S0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.85e-14 ad=2.9e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.51724e-07 sb=2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\6\:S1b \1\:S1 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.26395e-07 sb=1.4e-07 sd=160n sca=47.6387 \
        scb=0.0298205 scc=0.00588813 m=(1)
mp12 (net284 \2\:n1 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=2.903e-14 ps=1.06e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27907e-07 sb=1.71581e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp13 (\9\:n2 \3\:S1b net284 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07907e-07 sb=1.57767e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp11 (\9\:n2 \6\:S1 net280 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.515e-14 ps=6.6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.62907e-07 sb=1.38198e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp10 (net280 n0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1842e-13 ad=2.473e-14 ps=1.89e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.22907e-07 sb=1.25919e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp8 (net320 \1\:D \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1842e-13 ad=1.29e-14 ps=1.89e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07035e-06 sb=1.05942e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp9 (\6\:n1 S0b net320 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.698e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17535e-06 sb=9.54419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp6 (net312 \1\:C \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.365e-14 ad=3.118e-14 ps=1.54e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67535e-06 sb=4.54419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp7 (\6\:n1 \1\:S0 net312 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=5.698e-14 ps=7.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=6.44419e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp4 (net304 \3\:B \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.365e-14 ad=2.795e-14 ps=1.54e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.38372e-07 sb=1.055e-06 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp5 (\5\:n0 \5\:S0b net304 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=6.558e-14 ps=6.9e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.72674e-07 sb=8.8e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp3 (\5\:n0 \4\:S0 net296 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.04128e-06 sb=5.3e-07 sd=160n sca=10.6702 \
        scb=0.0075867 scc=7.76926e-05 m=(1)
mp2 (net296 \3\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=1.29e-14 ps=9.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12186e-06 sb=4.25e-07 sd=160n sca=11.1175 \
        scb=0.00789061 scc=7.80015e-05 m=(1)
mp0 (\16\:S0b \11\:S0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.01e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34035e-06 sb=1.4e-07 sd=160n sca=14.3466 \
        scb=0.0127067 scc=0.000142758 m=(1)
ends MXI4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:42:07 2012 )
// Library name: gsclib045
// Cell name: MXI4X2
// View name: extracted

simulator lang=spectre

subckt MXI4X2 A B C D S0 S1 VDD VSS Y
mp0 (\19\:S0b \1\:S0 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.6555 scb=0.0150784 \
        scc=0.000248672 m=(1)
C1 (S1 VSS) capacitor c=1.97116e-16
C2 (C VSS) capacitor c=1.16847e-16
C3 (D VSS) capacitor c=1.14896e-16
C4 (Y VSS) capacitor c=4.66538e-17
C5 (B VSS) capacitor c=1.32316e-16
C6 (A VSS) capacitor c=2.41999e-17
C7 (S0 VSS) capacitor c=3.73678e-17
C8 (VDD VSS) capacitor c=3.98582e-16
C9 (S0b VSS) capacitor c=5.73522e-17
C10 (net349 VSS) capacitor c=9.72303e-19
C11 (n0 VSS) capacitor c=3.06494e-17
C12 (net369 VSS) capacitor c=1.35355e-21
C13 (n1 VSS) capacitor c=4.14176e-17
C14 (net377 VSS) capacitor c=1.27191e-17
C15 (net329 VSS) capacitor c=4.37195e-19
C16 (n2 VSS) capacitor c=1.1525e-16
C17 (S1b VSS) capacitor c=4.66997e-17
C18 (net345 VSS) capacitor c=5.0612e-18
C19 (net304 VSS) capacitor c=3.44319e-18
C20 (net312 VSS) capacitor c=3.14239e-18
C21 (net320 VSS) capacitor c=4.09697e-18
C22 (net280 VSS) capacitor c=7.08518e-18
C23 (net284 VSS) capacitor c=8.42929e-18
C24 (\6\:S1 VSS) capacitor c=1.64323e-17
C25 (\3\:S1b VSS) capacitor c=3.98738e-17
C26 (\3\:S1 VSS) capacitor c=2.69527e-17
C27 (\1\:D VSS) capacitor c=4.26111e-17
C28 (\10\:S0b VSS) capacitor c=3.42418e-17
C29 (\8\:S0 VSS) capacitor c=2.70964e-17
C30 (\1\:C VSS) capacitor c=2.46815e-17
C31 (\3\:B VSS) capacitor c=3.46248e-17
C32 (\3\:S0b VSS) capacitor c=3.83281e-17
C33 (\7\:S0 VSS) capacitor c=6.7312e-17
C34 (\1\:A VSS) capacitor c=5.6694e-17
C35 (\1\:S0 VSS) capacitor c=4.87231e-17
C36 (\4\:S1 VSS) capacitor c=2.23941e-17
C37 (\3\:n1 VSS) capacitor c=1.8782e-17
C38 (\1\:S1 VSS) capacitor c=5.32615e-17
C39 (\3\:n0 VSS) capacitor c=4.73088e-17
C40 (\3\:D VSS) capacitor c=3.67569e-17
C41 (\10\:S0 VSS) capacitor c=3.10589e-17
C42 (\6\:S0b VSS) capacitor c=1.55299e-17
C43 (\3\:C VSS) capacitor c=7.35971e-17
C44 (\1\:B VSS) capacitor c=5.99587e-17
C45 (\4\:S0 VSS) capacitor c=3.91101e-17
C46 (\3\:A VSS) capacitor c=7.95341e-17
C47 (\3\:S0 VSS) capacitor c=2.93255e-17
C48 (\5\:S1 VSS) capacitor c=2.27256e-17
C49 (\7\:n2 VSS) capacitor c=3.08084e-17
C50 (\2\:n1 VSS) capacitor c=3.95995e-17
C51 (\4\:S1b VSS) capacitor c=3.12598e-17
C52 (\2\:S1 VSS) capacitor c=4.74247e-17
C53 (\2\:S1b VSS) capacitor c=4.37195e-17
C54 (\2\:n0 VSS) capacitor c=3.3469e-17
C55 (\2\:D VSS) capacitor c=3.62988e-17
C56 (\11\:S0b VSS) capacitor c=1.78203e-17
C57 (\11\:S0 VSS) capacitor c=4.30691e-17
C58 (\8\:S0b VSS) capacitor c=4.49251e-17
C59 (\9\:S0b VSS) capacitor c=3.84902e-17
C60 (\9\:S0 VSS) capacitor c=3.98903e-17
C61 (\5\:S0b VSS) capacitor c=3.122e-17
C62 (\7\:S0b VSS) capacitor c=2.13811e-17
C63 (\2\:C VSS) capacitor c=4.39015e-17
C64 (\2\:B VSS) capacitor c=5.44055e-17
C65 (\5\:S0 VSS) capacitor c=6.35709e-17
C66 (\4\:S0b VSS) capacitor c=4.42548e-17
C67 (\6\:S0 VSS) capacitor c=6.49735e-17
C68 (\2\:S0b VSS) capacitor c=2.3185e-17
C69 (\2\:A VSS) capacitor c=7.57065e-17
C70 (\2\:S0 VSS) capacitor c=4.22499e-17
C71 (\5\:S1b VSS) capacitor c=4.74456e-17
C72 (\1\:Y VSS) capacitor c=2.87449e-17
C73 (\13\:n2 VSS) capacitor c=1.74745e-16
C74 (\16\:VDD VSS) capacitor c=2.46125e-17
C75 (\4\:n1 VSS) capacitor c=1.34965e-16
C76 (\18\:VDD VSS) capacitor c=2.70397e-17
C77 (\5\:n0 VSS) capacitor c=3.15309e-16
C78 (\20\:VDD VSS) capacitor c=3.78636e-17
C79 (\19\:S0b VSS) capacitor c=6.59572e-17
C80 (\1\:VDD VSS) capacitor c=2.13657e-16
C81 (\7\:S1b VSS) capacitor c=2.19818e-16
C82 (\3\:Y VSS) capacitor c=5.09414e-17
C83 (\10\:n2 VSS) capacitor c=1.37788e-16
C84 (\7\:n1 VSS) capacitor c=2.89803e-17
C85 (\7\:n0 VSS) capacitor c=1.0947e-16
C86 (\15\:S0b VSS) capacitor c=1.08157e-16
C87 (\12\:S0 VSS) capacitor c=8.23653e-17
C88 (\13\:S0 VSS) capacitor c=6.20343e-17
C89 (\4\:A VSS) capacitor c=8.20615e-17
C90 (\12\:S0b VSS) capacitor c=6.78586e-17
C91 (\13\:S0b VSS) capacitor c=9.7327e-17
C92 (\14\:S0b VSS) capacitor c=7.23136e-17
C93 (\17\:S0b VSS) capacitor c=9.2759e-17
C94 (\18\:S0b VSS) capacitor c=2.72663e-17
C95 (\21\:S0b VSS) capacitor c=4.83505e-17
C96 (\22\:S0b VSS) capacitor c=4.08577e-17
C97 (\14\:S0 VSS) capacitor c=1.54721e-17
C98 (\15\:S0 VSS) capacitor c=1.09071e-16
C99 (\16\:S0 VSS) capacitor c=5.98051e-17
C100 (\17\:S0 VSS) capacitor c=8.63598e-17
C101 (\23\:S0b VSS) capacitor c=7.38725e-17
C102 (\24\:S0b VSS) capacitor c=4.88515e-17
C103 (\4\:n0 VSS) capacitor c=2.50886e-16
C104 (\6\:n1 VSS) capacitor c=2.0321e-16
C105 (\9\:n1 VSS) capacitor c=1.64451e-16
C106 (\9\:n2 VSS) capacitor c=1.19199e-16
C107 (\12\:n2 VSS) capacitor c=1.68381e-16
C108 (\7\:S1 VSS) capacitor c=3.03728e-17
C109 (\8\:S1 VSS) capacitor c=2.53461e-16
C110 (\9\:S1b VSS) capacitor c=2.86105e-16
C111 (\10\:S1b VSS) capacitor c=6.13757e-17
C112 (\3\:VDD VSS) capacitor c=4.78746e-17
C113 (\9\:VDD VSS) capacitor c=1.71699e-17
C114 (\11\:VDD VSS) capacitor c=6.62762e-18
Rk27 (\7\:S1 S1) resistor r=0.02903 c=0
Rk28 (S1 \8\:S1) resistor r=1.8942 c=0
Rk11 (\4\:C C) resistor r=0.004024 c=0
Rk17 (\4\:D D) resistor r=0.003004 c=0
Rk25 (\2\:Y Y) resistor r=0.06314 c=0
Rk26 (Y \4\:Y) resistor r=0.1488 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.09261 c=0
Rk49 (\3\:VSS \5\:VSS) resistor r=0.06753 c=0
Rk50 (\5\:VSS \6\:VSS) resistor r=0.504 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.3986 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.3735 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.2782 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.2381 c=0
Rk56 (\11\:VSS VSS) resistor r=0.04991 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.1127 c=0
Rk59 (\6\:VSS \17\:VSS) resistor r=0.1276 c=0
Rk60 (\8\:VSS \19\:VSS) resistor r=0.07405 c=0
Rk61 (\10\:VSS \21\:VSS) resistor r=0.1384 c=0
