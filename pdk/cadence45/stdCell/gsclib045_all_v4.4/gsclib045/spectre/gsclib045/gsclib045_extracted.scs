        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net94 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n5g \3\:RTb net94 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp17 (\21\:n5 \4\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.7175 \
        scb=0.0182062 scc=0.00060472 m=(1)
mp20 (\7\:Qbint \3\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net103 \2\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\2\:Q \4\:Qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
mp15 (net103 \1\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.1035 \
        scb=0.0249499 scc=0.00160735 m=(1)
ends RTLATSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:56:25 2012 )
// Library name: gsclib045
// Cell name: RTLATX1
// View name: extracted

simulator lang=spectre

subckt RTLATX1 D ExtVDD G Q QN RT VDD VSS
mp1 (\8\:Gbb \3\:Gb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (QN VSS) capacitor c=3.7262e-17
C2 (VDD VSS) capacitor c=3.10746e-16
C3 (RT VSS) capacitor c=2.61402e-17
C4 (ExtVDD VSS) capacitor c=2.60613e-16
C5 (Q VSS) capacitor c=2.23222e-17
C6 (D VSS) capacitor c=5.58381e-17
C7 (Gb VSS) capacitor c=5.266e-17
C8 (Gbb VSS) capacitor c=1.20531e-16
C9 (Qbint VSS) capacitor c=2.99278e-17
C10 (n0 VSS) capacitor c=6.47334e-17
C11 (Qint VSS) capacitor c=8.13439e-17
C12 (n0g VSS) capacitor c=4.74086e-17
C13 (RTb VSS) capacitor c=4.20307e-17
C14 (net095 VSS) capacitor c=4.39292e-17
C15 (\4\:Qbint VSS) capacitor c=3.88878e-17
C16 (\2\:Qint VSS) capacitor c=1.16018e-16
C17 (\4\:Gbb VSS) capacitor c=1.15221e-16
C18 (\3\:Qint VSS) capacitor c=6.26148e-17
C19 (\10\:Qint VSS) capacitor c=2.21642e-17
C20 (\3\:RTb VSS) capacitor c=8.98845e-17
C21 (\12\:Qint VSS) capacitor c=6.54344e-17
C22 (\5\:RT VSS) capacitor c=5.28764e-17
C23 (\4\:n0g VSS) capacitor c=9.10741e-17
C24 (\7\:RT VSS) capacitor c=3.42877e-17
C25 (\4\:Gb VSS) capacitor c=5.88761e-17
C26 (\1\:G VSS) capacitor c=3.78432e-17
C27 (\3\:D VSS) capacitor c=7.29864e-17
C28 (\3\:Gb VSS) capacitor c=7.63078e-17
C29 (\8\:Gb VSS) capacitor c=1.12378e-16
C30 (\9\:Qint VSS) capacitor c=2.60833e-17
C31 (\11\:Qint VSS) capacitor c=2.49079e-17
C32 (\13\:Qint VSS) capacitor c=5.74163e-17
C33 (\9\:RT VSS) capacitor c=9.2617e-17
C34 (\1\:RT VSS) capacitor c=4.97783e-17
C35 (\3\:n0g VSS) capacitor c=2.34422e-17
C36 (\2\:RTb VSS) capacitor c=4.49876e-17
C37 (\3\:Gbb VSS) capacitor c=4.2823e-17
C38 (\1\:D VSS) capacitor c=7.05281e-17
C39 (\3\:G VSS) capacitor c=4.23814e-17
C40 (\5\:Gb VSS) capacitor c=6.09748e-17
C41 (\3\:Qbint VSS) capacitor c=2.75606e-17
C42 (\5\:Gbb VSS) capacitor c=7.06913e-17
C43 (\9\:Gb VSS) capacitor c=5.88198e-17
C44 (\8\:RT VSS) capacitor c=6.08119e-17
C45 (\4\:RTb VSS) capacitor c=7.7037e-17
C46 (\5\:RTb VSS) capacitor c=4.49791e-17
C47 (\6\:RT VSS) capacitor c=5.62346e-17
C48 (\2\:ExtVDD VSS) capacitor c=5.37023e-17
C49 (\1\:ExtVDD VSS) capacitor c=4.86404e-17
C50 (\5\:n0g VSS) capacitor c=1.01336e-16
C51 (\6\:Gb VSS) capacitor c=1.03458e-16
C52 (\8\:Qint VSS) capacitor c=7.77282e-17
C53 (\4\:RT VSS) capacitor c=3.40204e-17
C54 (\2\:n0 VSS) capacitor c=8.02412e-17
C55 (\7\:Gb VSS) capacitor c=4.72225e-17
C56 (\2\:Gbb VSS) capacitor c=1.0611e-16
C57 (\2\:D VSS) capacitor c=5.64234e-17
C58 (\2\:G VSS) capacitor c=4.64539e-17
C59 (\2\:Q VSS) capacitor c=4.83735e-17
C60 (\11\:VDD VSS) capacitor c=7.21782e-17
C61 (\1\:VDD VSS) capacitor c=2.27369e-17
C62 (\7\:Qbint VSS) capacitor c=8.17094e-17
C63 (\13\:VDD VSS) capacitor c=8.75208e-17
C64 (\1\:QN VSS) capacitor c=6.44283e-17
C65 (\11\:n0g VSS) capacitor c=1.19601e-16
C66 (\6\:ExtVDD VSS) capacitor c=6.4648e-17
C67 (\7\:RTb VSS) capacitor c=3.89729e-17
C68 (\3\:ExtVDD VSS) capacitor c=4.00327e-17
C69 (\10\:ExtVDD VSS) capacitor c=6.29562e-17
C70 (\17\:Qint VSS) capacitor c=4.86609e-17
C71 (\7\:n0g VSS) capacitor c=7.36607e-17
C72 (\9\:n0 VSS) capacitor c=1.08279e-16
C73 (\5\:n0 VSS) capacitor c=2.63234e-17
C74 (\15\:Gb VSS) capacitor c=3.46136e-17
C75 (\15\:VDD VSS) capacitor c=3.62136e-17
C76 (\17\:VDD VSS) capacitor c=5.42139e-17
C77 (\8\:Gbb VSS) capacitor c=5.09686e-17
C78 (\4\:Q VSS) capacitor c=3.49476e-17
C79 (\9\:Qbint VSS) capacitor c=5.58557e-17
C80 (\3\:net095 VSS) capacitor c=4.42255e-17
C81 (\3\:QN VSS) capacitor c=4.68238e-17
C82 (\12\:RTb VSS) capacitor c=2.26472e-17
C83 (\15\:n0g VSS) capacitor c=1.89851e-17
C84 (\14\:Qint VSS) capacitor c=3.90606e-17
C85 (\9\:n0g VSS) capacitor c=8.89139e-17
C86 (\12\:n0 VSS) capacitor c=6.09083e-17
C87 (\7\:n0 VSS) capacitor c=6.87804e-17
C88 (\7\:VDD VSS) capacitor c=2.71581e-16
C89 (\13\:Gb VSS) capacitor c=4.48926e-17
C90 (\10\:Gbb VSS) capacitor c=2.54969e-17
C91 (\2\:Gb VSS) capacitor c=7.93506e-17
C92 (ExtVDD VSS) capacitor c=3.85231e-17
C93 (\2\:n0g VSS) capacitor c=4.75933e-17
C94 (\2\:RT VSS) capacitor c=5.96165e-17
C95 (\3\:RT VSS) capacitor c=5.47053e-17
C96 (\4\:Qint VSS) capacitor c=2.47361e-17
C97 (\5\:Qint VSS) capacitor c=4.82551e-17
C98 (\6\:Qint VSS) capacitor c=6.32965e-17
C99 (\7\:Qint VSS) capacitor c=4.07601e-17
C100 (\2\:Qbint VSS) capacitor c=2.01924e-17
C101 (\4\:G VSS) capacitor c=3.46724e-17
C102 (\5\:G VSS) capacitor c=3.63295e-18
C103 (\6\:G VSS) capacitor c=2.93068e-17
C104 (\6\:Gbb VSS) capacitor c=5.37738e-17
C105 (\7\:Gbb VSS) capacitor c=5.85837e-17
C106 (\10\:Gb VSS) capacitor c=1.31957e-17
C107 (\11\:Gb VSS) capacitor c=3.36675e-17
C108 (\12\:Gb VSS) capacitor c=4.2165e-17
C109 (\17\:Gb VSS) capacitor c=6.40786e-18
C110 (\3\:n0 VSS) capacitor c=2.52068e-17
C111 (\4\:n0 VSS) capacitor c=5.67143e-17
C112 (\13\:RT VSS) capacitor c=2.31119e-17
C113 (\11\:n0 VSS) capacitor c=5.3389e-17
C114 (\16\:Qint VSS) capacitor c=5.85375e-17
C115 (\6\:n0g VSS) capacitor c=2.47889e-17
C116 (\5\:ExtVDD VSS) capacitor c=5.42887e-17
C117 (\12\:ExtVDD VSS) capacitor c=3.18539e-17
C118 (\6\:RTb VSS) capacitor c=2.20655e-17
C119 (\9\:RTb VSS) capacitor c=3.91535e-17
C120 (\10\:RTb VSS) capacitor c=6.0629e-17
C121 (\11\:RTb VSS) capacitor c=6.25043e-17
C122 (\13\:n0g VSS) capacitor c=9.86135e-17
C123 (\14\:n0g VSS) capacitor c=2.8793e-17
C124 (\14\:RT VSS) capacitor c=1.29706e-16
C125 (\15\:RT VSS) capacitor c=1.31871e-16
C126 (\18\:Gb VSS) capacitor c=7.87472e-17
C127 (\19\:Gb VSS) capacitor c=1.2152e-16
C128 (\12\:Gbb VSS) capacitor c=1.83878e-16
C129 (\13\:Gbb VSS) capacitor c=2.44377e-16
C130 (\5\:Qbint VSS) capacitor c=2.81148e-17
C131 (\1\:Q VSS) capacitor c=2.48116e-17
C132 (\3\:VDD VSS) capacitor c=3.8827e-17
C133 (\5\:VDD VSS) capacitor c=2.17314e-17
C134 (\6\:VDD VSS) capacitor c=2.82635e-16
Rk46 (QN \4\:QN) resistor r=0.09302 c=0
Rk45 (\2\:QN \4\:QN) resistor r=0.5711 c=0
Rk61 (VDD VDD) resistor r=0.1305 c=0
Rk54 (\2\:VDD \3\:VDD) resistor r=0.2736 c=0
Rk55 (\3\:VDD \5\:VDD) resistor r=0.1877 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.03919 c=0
Rk57 (\6\:VDD \8\:VDD) resistor r=1.7711 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.05305 c=0
Rk60 (\10\:VDD VDD) resistor r=0.04653 c=0
Rk59 (\9\:VDD \10\:VDD) resistor r=0.03158 c=0
Rk62 (\3\:VDD \12\:VDD) resistor r=0.4167 c=0
Rk63 (\6\:VDD \14\:VDD) resistor r=0.3716 c=0
Rk64 (\9\:VDD \16\:VDD) resistor r=0.2631 c=0
Rk65 (\10\:VDD \18\:VDD) resistor r=0.3272 c=0
Rk18 (\10\:RT RT) resistor r=0.003536 c=0
Rk19 (\11\:RT RT) resistor r=0.002122 c=0
Rk20 (\10\:RT \11\:RT) resistor r=0.01898 c=0
Rk22 (\11\:RT \13\:RT) resistor r=0.02088 c=0
Rk21 (\12\:RT \13\:RT) resistor r=0.003536 c=0
Rk42 (\14\:RT \15\:RT) resistor r=1.0351 c=0
Rk31 (ExtVDD ExtVDD) resistor r=0.001963 c=0
Rk29 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2255 c=0
Rk30 (\7\:ExtVDD ExtVDD) resistor r=0.1352 c=0
Rk33 (ExtVDD \11\:ExtVDD) resistor r=0.1516 c=0
Rk34 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.2295 c=0
Rk66 (\2\:VSS \3\:VSS) resistor r=0.07857 c=0
Rk68 (\4\:VSS VSS) resistor r=0.4924 c=0
Rk67 (\3\:VSS \4\:VSS) resistor r=0.561 c=0
Rk70 (\5\:VSS VSS) resistor r=0.1844 c=0
Rk69 (VSS \5\:VSS) resistor r=0.6404 c=0
Rk71 (VSS \7\:VSS) resistor r=0.5061 c=0
Rk72 (\3\:VSS \9\:VSS) resistor r=0.2882 c=0
Rk73 (VSS \11\:VSS) resistor r=0.3032 c=0
Rk74 (\13\:VSS \14\:VSS) resistor r=0.08103 c=0
Rk75 (\14\:VSS \15\:VSS) resistor r=0.1155 c=0
Rk76 (\15\:VSS \16\:VSS) resistor r=0.113 c=0
Rk77 (\16\:VSS \17\:VSS) resistor r=0.3296 c=0
Rk79 (\18\:VSS VSS) resistor r=0.2088 c=0
Rk78 (\17\:VSS \18\:VSS) resistor r=0.2829 c=0
Rk80 (VSS \19\:VSS) resistor r=0.2708 c=0
Rk82 (\20\:VSS VSS) resistor r=0.5762 c=0
Rk81 (\19\:VSS \20\:VSS) resistor r=0.1721 c=0
Rk83 (VSS \21\:VSS) resistor r=0.1136 c=0
Rk84 (\14\:VSS \23\:VSS) resistor r=0.2458 c=0
Rk85 (\16\:VSS \25\:VSS) resistor r=0.2575 c=0
Rk86 (\18\:VSS \27\:VSS) resistor r=0.2753 c=0
Rk87 (\19\:VSS \29\:VSS) resistor r=0.2415 c=0
Rk88 (VSS \31\:VSS) resistor r=0.3028 c=0
Rk1 (\4\:G G) resistor r=0.007228 c=0
Rk2 (G \5\:G) resistor r=0.007038 c=0
Rk3 (\4\:G \5\:G) resistor r=0.004546 c=0
Rk5 (\5\:G \6\:G) resistor r=0.007576 c=0
Rk4 (\6\:G \7\:G) resistor r=0.005136 c=0
Rk51 (Q \1\:Q) resistor r=0.005993 c=0
Rk52 (\1\:Q \3\:Q) resistor r=0.3099 c=0
Rk53 (\1\:Q \5\:Q) resistor r=0.2937 c=0
Rk10 (\10\:Gb \11\:Gb) resistor r=0.156 c=0
Rk11 (\11\:Gb \12\:Gb) resistor r=0.2411 c=0
Rk12 (\12\:Gb \14\:Gb) resistor r=0.2401 c=0
Rk13 (\11\:Gb \16\:Gb) resistor r=0.1464 c=0
Rk14 (\12\:Gb \17\:Gb) resistor r=0.1139 c=0
Rk43 (\18\:Gb \19\:Gb) resistor r=0.7236 c=0
Rk7 (\6\:Gbb \7\:Gbb) resistor r=0.2873 c=0
Rk8 (\7\:Gbb \9\:Gbb) resistor r=0.4402 c=0
Rk9 (\7\:Gbb \11\:Gbb) resistor r=0.168 c=0
Rk44 (\12\:Gbb \13\:Gbb) resistor r=1.605 c=0
Rk48 (\5\:Qbint \6\:Qbint) resistor r=0.02326 c=0
Rk49 (\6\:Qbint \8\:Qbint) resistor r=0.3083 c=0
Rk50 (\6\:Qbint \10\:Qbint) resistor r=0.2047 c=0
Rk15 (\3\:n0 \4\:n0) resistor r=0.3083 c=0
Rk16 (\4\:n0 \6\:n0) resistor r=0.1986 c=0
Rk17 (\4\:n0 \8\:n0) resistor r=0.4678 c=0
Rk23 (\10\:n0 \11\:n0) resistor r=0.4878 c=0
Rk24 (\10\:n0 \13\:n0) resistor r=0.5665 c=0
Rk25 (\15\:Qint \16\:Qint) resistor r=0.2099 c=0
Rk26 (\16\:Qint \18\:Qint) resistor r=0.4287 c=0
Rk27 (\6\:n0g \8\:n0g) resistor r=0.1078 c=0
Rk28 (\8\:n0g \10\:n0g) resistor r=0.5632 c=0
Rk39 (\12\:n0g \13\:n0g) resistor r=0.7323 c=0
Rk40 (\13\:n0g \14\:n0g) resistor r=0.1057 c=0
Rk41 (\13\:n0g \16\:n0g) resistor r=0.08816 c=0
Rk35 (\6\:RTb \8\:RTb) resistor r=0.1317 c=0
Rk36 (\9\:RTb \10\:RTb) resistor r=0.1666 c=0
Rk37 (\10\:RTb \11\:RTb) resistor r=0.327 c=0
Rk38 (\10\:RTb \13\:RTb) resistor r=0.09304 c=0
Rk47 (\2\:net095 \4\:net095) resistor r=0.5082 c=0
Rl27 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl23 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl22 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl19 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl24 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl21 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl20 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl8 (\3\:Gb \5\:Gb) resistor r=249.542 c=0
Rl29 (\8\:Gb \9\:Gb) resistor r=447.998 c=0
Rl12 (\6\:Gb \7\:Gb) resistor r=435.371 c=0
Rl5 (Gb \2\:Gb) resistor r=353.207 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=168.248 c=0
Rl28 (\4\:Gbb \5\:Gbb) resistor r=455.381 c=0
Rl10 (Gbb \2\:Gbb) resistor r=706.37 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl42 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl44 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl43 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl9 (n0 \2\:n0) resistor r=331.394 c=0
Rl30 (Qint \2\:Qint) resistor r=215.233 c=0
Rl31 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl32 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl37 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl38 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl39 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl33 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl40 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl34 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl41 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl36 (\7\:Qint \8\:Qint) resistor r=192.03 c=0
Rl35 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl18 (\4\:n0g \5\:n0g) resistor r=317.727 c=0
Rl15 (n0g \2\:n0g) resistor r=109.66 c=0
Rl17 (\2\:n0g \4\:n0g) resistor r=191.281 c=0
Rl16 (\2\:n0g \3\:n0g) resistor r=38.4366 c=0
Rl13 (RTb \2\:RTb) resistor r=124.916 c=0
Rl25 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl26 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\7\:VDD \8\:VDD) resistor r=37.5 c=0
Rz16 (\7\:VDD \10\:VDD) resistor r=75 c=0
Rz17 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz18 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz19 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz20 (\22\:VSS \23\:VSS) resistor r=37.5 c=0
Rz21 (\24\:VSS \25\:VSS) resistor r=37.5 c=0
Rz22 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz23 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz24 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz13 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz2 (\13\:Gb \14\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz4 (\12\:n0 \13\:n0) resistor r=75 c=0
Rz5 (\14\:Qint \15\:Qint) resistor r=75 c=0
Rz6 (\9\:n0g \10\:n0g) resistor r=75 c=0
Rz9 (\15\:n0g \16\:n0g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz11 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry12 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry16 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry17 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry18 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry19 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry7 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry8 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry9 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry21 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry23 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry24 (\12\:VSS \13\:VSS) resistor r=31 c=0
Ry25 (\12\:VSS \15\:VSS) resistor r=31 c=0
Ry26 (\12\:VSS \17\:VSS) resistor r=8.8571 c=0
Ry27 (\12\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry28 (\12\:VSS \21\:VSS) resistor r=31 c=0
Ry15 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry2 (\15\:Gb \16\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry14 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry5 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\7\:n0g \8\:n0g) resistor r=62 c=0
Ry11 (\11\:n0g \12\:n0g) resistor r=62 c=0
Ry10 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry13 (net095 \2\:net095) resistor r=62 c=0
Rx7 (\4\:RT \12\:RT) resistor r=45 c=0
Rx17 (\8\:RT \14\:RT) resistor r=45 c=0
Rx18 (\6\:RT \15\:RT) resistor r=45 c=0
Rx11 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx12 (\1\:ExtVDD \12\:ExtVDD) resistor r=45 c=0
Rx1 (\2\:G \7\:G) resistor r=45 c=0
Rx2 (\2\:D D) resistor r=45 c=0
Rx4 (Gb \10\:Gb) resistor r=45 c=0
Rx5 (\7\:Gb \17\:Gb) resistor r=45 c=0
Rx19 (\9\:Gb \18\:Gb) resistor r=45 c=0
Rx20 (\6\:Gb \19\:Gb) resistor r=45 c=0
Rx3 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx21 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx22 (Gbb \13\:Gbb) resistor r=45 c=0
Rx23 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx6 (n0 \3\:n0) resistor r=45 c=0
Rx8 (\2\:n0 \11\:n0) resistor r=45 c=0
Rx9 (\8\:Qint \16\:Qint) resistor r=45 c=0
Rx10 (\5\:n0g \6\:n0g) resistor r=45 c=0
Rx16 (n0g \14\:n0g) resistor r=45 c=0
Rx13 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx14 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx15 (RTb \11\:RTb) resistor r=45 c=0
mn1 (\10\:Gbb \5\:Gb \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\13\:Gb \3\:G \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net257 \1\:D \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\7\:n0 \3\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n0g \2\:RTb \12\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\14\:Qint \3\:n0g \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n0g \9\:RT net093 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net093 \13\:Qint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn20 (\9\:Qbint \9\:Qint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (\3\:net095 \8\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn15 (net245 Qint \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\4\:Q Qbint \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mp5 (net220 \3\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp0 (\15\:Gb \1\:G \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\5\:n0 \4\:Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n0g \7\:RT \9\:n0 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp11 (\17\:Qint \4\:n0g \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1365 \
        scb=0.0108856 scc=0.000154611 m=(1)
mp45 (\7\:RTb \5\:RT \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net145 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n0g \3\:RTb net145 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp20 (\7\:Qbint \3\:Qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net095 \4\:Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.1709 \
        scb=0.00798825 scc=9.08326e-05 m=(1)
mp15 (net212 \2\:Qint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\2\:Q \4\:Qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
ends RTLATX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:57:13 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX1 CK D Q RN SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.72308e-07 sd=160n sca=23.0036 \
        scb=0.0261368 scc=0.00127103 m=(1)
C1 (D VSS) capacitor c=5.76041e-17
C2 (Q VSS) capacitor c=1.32018e-17
C3 (RN VSS) capacitor c=4.92634e-17
C4 (SE VSS) capacitor c=6.11127e-17
C5 (VDD VSS) capacitor c=3.21119e-16
C6 (SI VSS) capacitor c=4.95414e-17
C7 (qbint VSS) capacitor c=1.8666e-17
C8 (CKb VSS) capacitor c=5.75641e-17
C9 (net337 VSS) capacitor c=4.46366e-18
C10 (n30 VSS) capacitor c=5.26161e-17
C11 (net405 VSS) capacitor c=2.68183e-18
C12 (mout VSS) capacitor c=5.78575e-17
C13 (CKbb VSS) capacitor c=2.14988e-17
C14 (n20 VSS) capacitor c=4.92579e-17
C15 (Db VSS) capacitor c=1.25186e-16
C16 (net450 VSS) capacitor c=7.12894e-18
C17 (SEb VSS) capacitor c=4.50029e-17
C18 (net326 VSS) capacitor c=3.58673e-18
C19 (net349 VSS) capacitor c=5.67054e-17
C20 (net381 VSS) capacitor c=2.20625e-18
C21 (net373 VSS) capacitor c=3.87332e-18
C22 (\5\:SE VSS) capacitor c=4.30832e-17
C23 (\3\:SI VSS) capacitor c=6.67713e-17
C24 (\2\:SE VSS) capacitor c=7.23328e-17
C25 (\1\:D VSS) capacitor c=1.06499e-16
C26 (\8\:CKb VSS) capacitor c=4.94166e-17
C27 (\7\:CKbb VSS) capacitor c=5.21121e-17
C28 (\5\:CKb VSS) capacitor c=5.31691e-17
C29 (\2\:RN VSS) capacitor c=1.35234e-16
C30 (\3\:n20 VSS) capacitor c=5.72446e-17
C31 (\3\:CKb VSS) capacitor c=4.39449e-17
C32 (\3\:CKbb VSS) capacitor c=8.76428e-17
C33 (\5\:qbint VSS) capacitor c=6.82722e-17
C34 (\3\:RN VSS) capacitor c=1.04194e-16
C35 (\1\:CK VSS) capacitor c=3.98388e-17
C36 (\4\:qbint VSS) capacitor c=5.68871e-17
C37 (\7\:SE VSS) capacitor c=3.24062e-17
C38 (\1\:SI VSS) capacitor c=7.95616e-17
C39 (\3\:SE VSS) capacitor c=5.76992e-17
C40 (\3\:SEb VSS) capacitor c=6.4097e-17
C41 (\4\:D VSS) capacitor c=3.69166e-17
C42 (\10\:CKb VSS) capacitor c=5.98499e-17
C43 (\7\:CKb VSS) capacitor c=4.71508e-17
C44 (\4\:CKbb VSS) capacitor c=4.60951e-17
C45 (\3\:mout VSS) capacitor c=6.53194e-17
C46 (\1\:RN VSS) capacitor c=8.87394e-17
C47 (\7\:qbint VSS) capacitor c=5.58413e-17
C48 (\5\:RN VSS) capacitor c=5.06381e-17
C49 (\3\:n30 VSS) capacitor c=2.89554e-17
C50 (\3\:CK VSS) capacitor c=4.8822e-17
C51 (\3\:qbint VSS) capacitor c=3.45397e-17
C52 (\6\:SE VSS) capacitor c=3.99111e-17
C53 (\2\:SI VSS) capacitor c=6.4459e-17
C54 (\4\:SE VSS) capacitor c=4.34702e-17
C55 (\2\:SEb VSS) capacitor c=5.75301e-17
C56 (\1\:SE VSS) capacitor c=5.18597e-17
C57 (\3\:D VSS) capacitor c=2.49986e-17
C58 (\9\:CKb VSS) capacitor c=2.71859e-17
C59 (\6\:CKbb VSS) capacitor c=3.78814e-17
C60 (\6\:CKb VSS) capacitor c=2.05214e-17
C61 (\5\:CKbb VSS) capacitor c=3.96094e-17
C62 (\2\:mout VSS) capacitor c=5.8223e-17
C63 (\2\:n20 VSS) capacitor c=4.8284e-17
C64 (\4\:CKb VSS) capacitor c=3.21145e-17
C65 (\2\:CKbb VSS) capacitor c=5.81635e-17
C66 (\2\:CKb VSS) capacitor c=5.74618e-17
C67 (\6\:qbint VSS) capacitor c=6.89973e-17
C68 (\6\:RN VSS) capacitor c=2.54588e-17
C69 (\2\:n30 VSS) capacitor c=3.91573e-17
C70 (\2\:CK VSS) capacitor c=4.49232e-17
C71 (\5\:SEb VSS) capacitor c=9.43329e-17
C72 (\13\:VDD VSS) capacitor c=3.576e-17
C73 (\4\:Db VSS) capacitor c=5.5414e-17
C74 (\15\:VDD VSS) capacitor c=1.57319e-17
C75 (\8\:CKbb VSS) capacitor c=7.06732e-17
C76 (\6\:Db VSS) capacitor c=1.7901e-16
C77 (\4\:n20 VSS) capacitor c=5.70402e-17
C78 (\17\:VDD VSS) capacitor c=3.4616e-17
C79 (\3\:net349 VSS) capacitor c=6.77142e-17
C80 (\19\:VDD VSS) capacitor c=4.55951e-17
C81 (\8\:mout VSS) capacitor c=8.76952e-17
C82 (\4\:n30 VSS) capacitor c=1.20802e-16
C83 (\21\:VDD VSS) capacitor c=4.95628e-17
C84 (\12\:qbint VSS) capacitor c=5.58073e-17
C85 (\23\:VDD VSS) capacitor c=3.75339e-17
C86 (\15\:CKb VSS) capacitor c=1.39363e-16
C87 (\25\:VDD VSS) capacitor c=6.90152e-17
C88 (\1\:Q VSS) capacitor c=6.4202e-17
C89 (\1\:VDD VSS) capacitor c=8.94928e-17
C90 (\7\:SEb VSS) capacitor c=7.52946e-17
C91 (\14\:CKbb VSS) capacitor c=1.72889e-17
C92 (\8\:Db VSS) capacitor c=1.06039e-16
C93 (\8\:n20 VSS) capacitor c=9.33367e-17
C94 (\6\:mout VSS) capacitor c=6.53961e-17
C95 (\6\:n30 VSS) capacitor c=1.54843e-16
C96 (\10\:qbint VSS) capacitor c=1.45283e-16
C97 (\19\:CKb VSS) capacitor c=1.12643e-16
C98 (\4\:Q VSS) capacitor c=3.18303e-17
C99 (\2\:qbint VSS) capacitor c=2.41912e-17
C100 (\4\:RN VSS) capacitor c=3.35984e-17
C101 (\2\:D VSS) capacitor c=2.70871e-17
C102 (\3\:Q VSS) capacitor c=5.01954e-17
C103 (\4\:CK VSS) capacitor c=5.3969e-17
C104 (\5\:CK VSS) capacitor c=4.39158e-17
C105 (\8\:RN VSS) capacitor c=4.94482e-17
C106 (\8\:qbint VSS) capacitor c=6.41981e-17
C107 (\9\:qbint VSS) capacitor c=1.0413e-16
C108 (\14\:qbint VSS) capacitor c=1.25451e-16
C109 (\8\:n30 VSS) capacitor c=1.20311e-16
C110 (\4\:mout VSS) capacitor c=8.76156e-17
C111 (\5\:mout VSS) capacitor c=1.06221e-16
C112 (\6\:n20 VSS) capacitor c=9.93722e-17
C113 (\7\:n20 VSS) capacitor c=8.07966e-17
C114 (\10\:CKbb VSS) capacitor c=4.34841e-17
C115 (\11\:CKbb VSS) capacitor c=9.873e-17
C116 (\12\:CKbb VSS) capacitor c=2.22169e-16
C117 (\13\:CKbb VSS) capacitor c=1.90129e-16
C118 (\16\:CKbb VSS) capacitor c=3.85165e-17
C119 (\11\:CKb VSS) capacitor c=8.0988e-17
C120 (\12\:CKb VSS) capacitor c=1.5e-16
C121 (\13\:CKb VSS) capacitor c=1.35122e-16
C122 (\14\:CKb VSS) capacitor c=1.65667e-16
C123 (\17\:CKb VSS) capacitor c=8.30345e-17
C124 (\18\:CKb VSS) capacitor c=5.23108e-17
C125 (\5\:D VSS) capacitor c=5.38722e-17
C126 (\3\:Db VSS) capacitor c=1.44449e-16
C127 (\4\:SI VSS) capacitor c=5.58424e-17
C128 (\8\:SE VSS) capacitor c=5.26052e-17
C129 (\9\:SE VSS) capacitor c=6.21989e-17
C130 (\10\:SE VSS) capacitor c=5.99946e-17
C131 (\4\:SEb VSS) capacitor c=8.11407e-17
C132 (\3\:VDD VSS) capacitor c=1.33767e-18
C133 (\5\:VDD VSS) capacitor c=2.63599e-17
C134 (\6\:VDD VSS) capacitor c=2.7281e-17
C135 (\8\:VDD VSS) capacitor c=3.14196e-17
C136 (\9\:VDD VSS) capacitor c=3.23475e-17
C137 (\11\:VDD VSS) capacitor c=9.39858e-18
Rk36 (D \5\:D) resistor r=0.08671 c=0
Rk2 (\3\:Q Q) resistor r=0.007258 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.4176 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1825 c=0
Rk7 (\7\:RN \8\:RN) resistor r=0.008733 c=0
Rk8 (\9\:RN RN) resistor r=0.008733 c=0
Rk9 (\8\:RN \9\:RN) resistor r=0.01996 c=0
Rk43 (\8\:SE SE) resistor r=0.2195 c=0
Rk44 (SE \9\:SE) resistor r=0.1608 c=0
Rk45 (\9\:SE \10\:SE) resistor r=0.2249 c=0
Rk57 (\2\:VDD \3\:VDD) resistor r=0.1178 c=0
Rk58 (\3\:VDD \4\:VDD) resistor r=0.1831 c=0
Rk59 (\4\:VDD \5\:VDD) resistor r=0.1906 c=0
Rk60 (\5\:VDD \6\:VDD) resistor r=0.4657 c=0
Rk61 (\6\:VDD \7\:VDD) resistor r=0.09426 c=0
Rk62 (\7\:VDD \8\:VDD) resistor r=0.1253 c=0
Rk63 (\8\:VDD \9\:VDD) resistor r=0.4741 c=0
Rk64 (\9\:VDD \10\:VDD) resistor r=0.1027 c=0
Rk65 (\10\:VDD \11\:VDD) resistor r=0.163 c=0
Rk74 (\12\:VDD VDD) resistor r=0.151 c=0
Rk66 (\11\:VDD \12\:VDD) resistor r=0.1881 c=0
Rk67 (\3\:VDD \14\:VDD) resistor r=0.203 c=0
Rk68 (\5\:VDD \16\:VDD) resistor r=0.07476 c=0
Rk69 (\6\:VDD \18\:VDD) resistor r=0.04338 c=0
Rk70 (\8\:VDD \20\:VDD) resistor r=0.1543 c=0
Rk71 (\9\:VDD \22\:VDD) resistor r=0.247 c=0
Rk72 (\11\:VDD \24\:VDD) resistor r=0.1543 c=0
Rk73 (\12\:VDD \26\:VDD) resistor r=0.3671 c=0
Rk4 (CK \4\:CK) resistor r=0.004654 c=0
Rk6 (\4\:CK \5\:CK) resistor r=0.07064 c=0
Rk5 (\5\:CK \6\:CK) resistor r=0.004654 c=0
Rk42 (SI \4\:SI) resistor r=0.02621 c=0
Rk48 (\2\:VSS \4\:VSS) resistor r=0.7354 c=0
Rk49 (\4\:VSS \5\:VSS) resistor r=0.6777 c=0
Rk50 (\5\:VSS \6\:VSS) resistor r=0.5277 c=0
Rk52 (\7\:VSS VSS) resistor r=0.1251 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.4266 c=0
Rk53 (\4\:VSS \9\:VSS) resistor r=0.3693 c=0
Rk54 (\5\:VSS \11\:VSS) resistor r=0.2545 c=0
Rk55 (\6\:VSS \13\:VSS) resistor r=0.1976 c=0
Rk56 (\7\:VSS \15\:VSS) resistor r=0.3086 c=0
Rk10 (\8\:qbint \9\:qbint) resistor r=0.3799 c=0
Rk11 (\9\:qbint \11\:qbint) resistor r=0.5415 c=0
Rk12 (\9\:qbint \13\:qbint) resistor r=0.2374 c=0
Rk13 (\11\:qbint \14\:qbint) resistor r=0.6457 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.3924 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8429 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3488 c=0
Rk32 (\14\:CKb \16\:CKb) resistor r=0.781 c=0
Rk33 (\13\:CKb \17\:CKb) resistor r=0.2949 c=0
Rk34 (\14\:CKb \18\:CKb) resistor r=0.326 c=0
Rk35 (\16\:CKb \20\:CKb) resistor r=0.5326 c=0
Rk14 (\5\:n30 \7\:n30) resistor r=0.588 c=0
Rk15 (\7\:n30 \8\:n30) resistor r=0.7398 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.473 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2059 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3244 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.3977 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1571 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.8393 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.0921 c=0
Rk27 (\10\:CKbb \15\:CKbb) resistor r=0.0921 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.07888 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2171 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5467 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3571 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.7005 c=0
Rk38 (\3\:Db \5\:Db) resistor r=0.09515 c=0
Rk39 (\3\:Db \7\:Db) resistor r=0.6752 c=0
Rk40 (\7\:Db \9\:Db) resistor r=0.6106 c=0
Rk41 (\5\:Db \10\:Db) resistor r=0.1632 c=0
Rk46 (\4\:SEb \6\:SEb) resistor r=0.5531 c=0
Rk47 (\6\:SEb \8\:SEb) resistor r=0.5391 c=0
Rk19 (\2\:net349 \4\:net349) resistor r=0.3075 c=0
Rl29 (\1\:D \2\:D) resistor r=127.726 c=0
Rl31 (\2\:D \4\:D) resistor r=45.0334 c=0
Rl30 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl17 (\2\:RN \3\:RN) resistor r=603.412 c=0
Rl16 (\1\:RN \2\:RN) resistor r=215.232 c=0
Rl18 (\3\:RN \4\:RN) resistor r=96.9565 c=0
Rl19 (\4\:RN \5\:RN) resistor r=106.572 c=0
Rl20 (\4\:RN \6\:RN) resistor r=5.013 c=0
Rl38 (\5\:SE \6\:SE) resistor r=119.922 c=0
Rl39 (\6\:SE \7\:SE) resistor r=46.8456 c=0
Rl35 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl32 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl4 (\1\:CK \2\:CK) resistor r=104.538 c=0
Rl5 (\2\:CK \3\:CK) resistor r=110.307 c=0
Rl37 (\2\:SI \3\:SI) resistor r=101.477 c=0
Rl36 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=160.771 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=24.2328 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=121.957 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=41.1873 c=0
Rl28 (\8\:CKb \10\:CKb) resistor r=182.692 c=0
Rl25 (\5\:CKb \7\:CKb) resistor r=150 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=52.1862 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=64.1533 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl10 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl6 (n30 \2\:n30) resistor r=158.384 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl21 (mout \2\:mout) resistor r=108.79 c=0
Rl22 (\2\:mout \3\:mout) resistor r=72.2519 c=0
Rl26 (\6\:CKbb \7\:CKbb) resistor r=99.2573 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=41.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=214.504 c=0
Rl14 (n20 \2\:n20) resistor r=138.462 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=51.0989 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.404 c=0
Rz1 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=6.8182 c=0
Rz19 (\1\:VDD \10\:VDD) resistor r=25 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=18.75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \26\:VDD) resistor r=20.6667 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry9 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\4\:Db \10\:Db) resistor r=62 c=0
Ry13 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\6\:RN \7\:RN) resistor r=45 c=0
Rx17 (\1\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\6\:SE \10\:SE) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx4 (qbint \14\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn55 (\4\:Q \3\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.73846e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn20 (\19\:CKb \3\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.103e-14 ps=9e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn46 (\10\:qbint \3\:n30 net337 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.793e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn45 (net337 \5\:RN \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.28e-14 ps=1.06e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.95e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (net405 \7\:qbint \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=1.23e-14 ps=1.06e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.685e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.58e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.945e-14 ad=5.228e-14 ps=9.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.28e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=4.613e-14 ps=7.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn30 (\6\:mout n20 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=5.945e-14 ps=1.24e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=9.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net426 \1\:RN \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=2.665e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=7.1e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=1.333e-14 ps=6.7e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.35e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.333e-14 ad=4.613e-14 ps=5.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.915e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\14\:CKbb \10\:CKb \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12276e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net450 \4\:D \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=6.76e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=8.51635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41635e-07 sb=5.46635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46635e-07 sb=3.41635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51635e-07 sb=2.36635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\7\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12276e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.118e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.6299 \
        scb=0.00978612 scc=8.84613e-05 m=(1)
mp46 (\12\:qbint n30 \23\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=12.1897 \
        scb=0.0106254 scc=0.000361908 m=(1)
mp45 (\21\:VDD \3\:RN \12\:qbint VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=6.82e-14 ps=9.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp50 (net326 \5\:qbint \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=4.805e-14 ps=1.06e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.265e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.065e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=8.6e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp30 (\8\:mout \3\:n20 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=5.85e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp35 (\3\:net349 \2\:RN \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=4.96e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.2e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp36 (\3\:net349 mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.883e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.15e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\8\:CKbb \8\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.98e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp11 (net381 \1\:D \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.98e-14 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.20897e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp12 (\4\:Db \2\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.15897e-07 sd=160n sca=12.2524 \
        scb=0.0106415 scc=0.00038358 m=(1)
mp14 (\4\:Db SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.90897e-07 sd=160n sca=12.9125 \
        scb=0.0109255 scc=0.000383719 m=(1)
mp13 (net373 \3\:SI \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=5.265e-14 ps=1.31e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45064e-07 sb=3.10897e-07 sd=160n sca=14.0619 \
        scb=0.0121239 scc=0.000387547 m=(1)
mp10 (\5\:SEb \5\:SE \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=3.01e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=25.1693 \
        scb=0.0296469 scc=0.00157586 m=(1)
ends SDFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:58:00 2012 )
// Library name: gsclib045
// Cell name: SRDFFNRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNRQX1 CKN D ExtVDD Q RN RT SE SI VDD VSS
mp22 (\10\:RNb \1\:RN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (SI VSS) capacitor c=8.72957e-17
C2 (RN VSS) capacitor c=8.17943e-17
C3 (RT VSS) capacitor c=3.75399e-17
C4 (Q VSS) capacitor c=2.28683e-17
C5 (VDD VSS) capacitor c=6.52423e-16
C6 (SE VSS) capacitor c=3.95426e-17
C7 (CKN VSS) capacitor c=3.77416e-17
C8 (ExtVDD VSS) capacitor c=2.3501e-16
C9 (D VSS) capacitor c=4.57199e-17
C10 (n20 VSS) capacitor c=3.89483e-17
C11 (CKNb VSS) capacitor c=4.45691e-17
C12 (mout VSS) capacitor c=4.94333e-17
C13 (CKNbb VSS) capacitor c=3.23187e-17
C14 (RNb VSS) capacitor c=2.7463e-16
C15 (SEb VSS) capacitor c=7.75108e-17
C16 (n35g VSS) capacitor c=1.7772e-17
C17 (qbint VSS) capacitor c=4.57473e-17
C18 (RTb VSS) capacitor c=5.17873e-17
C19 (n35 VSS) capacitor c=1.3462e-16
C20 (Db VSS) capacitor c=1.04956e-16
C21 (n10 VSS) capacitor c=6.36691e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:RNb VSS) capacitor c=1.00899e-16
C24 (\9\:qbint VSS) capacitor c=2.81705e-17
C25 (\10\:qbint VSS) capacitor c=2.20981e-16
C26 (\12\:CKNb VSS) capacitor c=9.86081e-17
C27 (\4\:RTb VSS) capacitor c=9.87178e-17
C28 (\6\:RT VSS) capacitor c=2.21451e-17
C29 (\4\:qbint VSS) capacitor c=5.35397e-17
C30 (\3\:n35g VSS) capacitor c=5.23114e-17
C31 (\5\:RT VSS) capacitor c=8.4067e-17
C32 (\3\:SE VSS) capacitor c=7.72718e-17
C33 (\7\:CKNbb VSS) capacitor c=3.23122e-17
C34 (\3\:SI VSS) capacitor c=9.47876e-17
C35 (\4\:SE VSS) capacitor c=1.22206e-16
C36 (\4\:D VSS) capacitor c=6.88408e-17
C37 (\5\:RNb VSS) capacitor c=6.65004e-17
C38 (\5\:n20 VSS) capacitor c=1.21049e-16
C39 (\4\:CKN VSS) capacitor c=5.39794e-17
C40 (\4\:CKNb VSS) capacitor c=4.53327e-17
C41 (\8\:CKNbb VSS) capacitor c=8.28499e-17
C42 (\3\:CKNb VSS) capacitor c=1.09071e-16
C43 (\1\:RN VSS) capacitor c=4.2139e-17
C44 (\8\:RNb VSS) capacitor c=8.56207e-17
C45 (\6\:qbint VSS) capacitor c=3.15639e-17
C46 (\11\:qbint VSS) capacitor c=8.89948e-17
C47 (\9\:CKNbb VSS) capacitor c=2.13298e-16
C48 (\8\:RT VSS) capacitor c=1.28609e-16
C49 (\2\:RT VSS) capacitor c=6.21538e-17
C50 (\5\:qbint VSS) capacitor c=3.87694e-17
C51 (\5\:n35g VSS) capacitor c=3.28917e-17
C52 (\2\:RTb VSS) capacitor c=4.79204e-17
C53 (\5\:SE VSS) capacitor c=5.7887e-17
C54 (\10\:CKNb VSS) capacitor c=2.52869e-17
C55 (\1\:SI VSS) capacitor c=4.91308e-17
C56 (\6\:SE VSS) capacitor c=8.62004e-17
C57 (\3\:SEb VSS) capacitor c=6.60658e-17
C58 (\1\:D VSS) capacitor c=4.95201e-17
C59 (\6\:RNb VSS) capacitor c=5.09058e-17
C60 (\3\:n20 VSS) capacitor c=8.28417e-17
C61 (\1\:CKN VSS) capacitor c=2.85144e-17
C62 (\3\:mout VSS) capacitor c=5.00666e-17
C63 (\11\:CKNb VSS) capacitor c=4.89185e-17
C64 (\4\:RN VSS) capacitor c=3.6922e-17
C65 (\8\:qbint VSS) capacitor c=1.041e-16
C66 (\13\:CKNb VSS) capacitor c=6.71982e-17
C67 (\9\:RNb VSS) capacitor c=6.11895e-17
C68 (\7\:RT VSS) capacitor c=1.51736e-16
C69 (\6\:CKNb VSS) capacitor c=1.64527e-16
C70 (\3\:RT VSS) capacitor c=5.4998e-17
C71 (\1\:RT VSS) capacitor c=5.27439e-17
C72 (\3\:RTb VSS) capacitor c=7.6147e-17
C73 (\3\:qbint VSS) capacitor c=4.44119e-17
C74 (\2\:n35 VSS) capacitor c=1.90399e-16
C75 (\4\:n35g VSS) capacitor c=6.72362e-17
C76 (\3\:CKNbb VSS) capacitor c=5.52799e-17
C77 (\10\:CKNbb VSS) capacitor c=2.07004e-16
C78 (\3\:n35 VSS) capacitor c=9.08061e-17
C79 (\1\:SE VSS) capacitor c=2.48251e-17
C80 (\2\:SI VSS) capacitor c=7.76783e-17
C81 (\2\:SEb VSS) capacitor c=7.74514e-17
C82 (\3\:D VSS) capacitor c=1.46671e-17
C83 (\3\:CKN VSS) capacitor c=2.40654e-17
C84 (\2\:mout VSS) capacitor c=3.7982e-17
C85 (\4\:mout VSS) capacitor c=4.33186e-17
C86 (\2\:CKNb VSS) capacitor c=7.99081e-17
C87 (\6\:CKNbb VSS) capacitor c=3.6548e-17
C88 (\6\:n20 VSS) capacitor c=1.04681e-16
C89 (\4\:n20 VSS) capacitor c=6.91974e-17
C90 (\2\:CKNbb VSS) capacitor c=5.81601e-17
C91 (\5\:CKNb VSS) capacitor c=7.97258e-17
C92 (\9\:CKNb VSS) capacitor c=2.72997e-17
C93 (\4\:RNb VSS) capacitor c=9.93053e-17
C94 (\2\:n20 VSS) capacitor c=4.55775e-17
C95 (\3\:RN VSS) capacitor c=4.82646e-17
C96 (\1\:VDD VSS) capacitor c=2.43855e-17
C97 (\10\:VDD VSS) capacitor c=4.39786e-17
C98 (\4\:Q VSS) capacitor c=6.2863e-17
C99 (\14\:n35 VSS) capacitor c=5.68374e-17
C100 (\15\:n35g VSS) capacitor c=5.76971e-17
C101 (\6\:RTb VSS) capacitor c=7.20391e-17
C102 (\1\:ExtVDD VSS) capacitor c=2.78003e-16
C103 (\9\:n35 VSS) capacitor c=6.15721e-17
C104 (\14\:qbint VSS) capacitor c=6.81232e-17
C105 (\6\:n35g VSS) capacitor c=9.40514e-17
C106 (\8\:SEb VSS) capacitor c=5.05319e-17
C107 (\4\:n35 VSS) capacitor c=6.36367e-17
C108 (\12\:VDD VSS) capacitor c=6.06936e-17
C109 (\5\:mout VSS) capacitor c=7.31091e-17
C110 (\3\:Db VSS) capacitor c=1.83498e-16
C111 (\14\:VDD VSS) capacitor c=2.98062e-17
C112 (\19\:VDD VSS) capacitor c=3.54032e-17
C113 (\13\:mout VSS) capacitor c=5.17159e-17
C114 (\20\:CKNb VSS) capacitor c=2.97998e-17
C115 (\17\:VDD VSS) capacitor c=4.24614e-17
C116 (\12\:CKNbb VSS) capacitor c=5.87913e-17
C117 (\12\:n20 VSS) capacitor c=6.24742e-17
C118 (\5\:Db VSS) capacitor c=2.27603e-16
C119 (\10\:RNb VSS) capacitor c=5.04134e-17
C120 (\9\:n20 VSS) capacitor c=6.33369e-17
C121 (\21\:VDD VSS) capacitor c=4.24098e-17
C122 (\3\:VDD VSS) capacitor c=2.3619e-16
C123 (\1\:Q VSS) capacitor c=3.39752e-17
C124 (\3\:n10 VSS) capacitor c=7.9996e-17
C125 (\17\:n35 VSS) capacitor c=7.30793e-17
C126 (\11\:n35g VSS) capacitor c=2.72594e-17
C127 (\10\:RTb VSS) capacitor c=5.79526e-17
C128 (\12\:n35 VSS) capacitor c=6.3485e-17
C129 (\16\:qbint VSS) capacitor c=2.43025e-17
C130 (\9\:n35g VSS) capacitor c=8.05092e-17
C131 (\4\:SEb VSS) capacitor c=3.82428e-17
C132 (\7\:n35 VSS) capacitor c=4.10685e-17
C133 (\11\:mout VSS) capacitor c=2.63954e-17
C134 (\15\:mout VSS) capacitor c=4.00685e-17
C135 (\16\:CKNb VSS) capacitor c=5.34643e-17
C136 (\15\:CKNbb VSS) capacitor c=5.93281e-17
C137 (\17\:n20 VSS) capacitor c=5.27563e-17
C138 (\7\:Db VSS) capacitor c=1.10338e-16
C139 (\13\:RNb VSS) capacitor c=7.34786e-17
C140 (\7\:n20 VSS) capacitor c=5.95553e-17
C141 (VDD VSS) capacitor c=7.17577e-17
C142 (\2\:CKN VSS) capacitor c=3.47054e-17
C143 (\2\:D VSS) capacitor c=3.53727e-17
C144 (\2\:SE VSS) capacitor c=2.51114e-17
C145 (\4\:CKNbb VSS) capacitor c=1.49551e-16
C146 (\5\:CKNbb VSS) capacitor c=8.72708e-17
C147 (\2\:n35g VSS) capacitor c=2.90794e-17
C148 (\4\:RT VSS) capacitor c=7.44104e-17
C149 (\2\:qbint VSS) capacitor c=4.14784e-17
C150 (\7\:CKNb VSS) capacitor c=1.22521e-16
C151 (\8\:CKNb VSS) capacitor c=8.12993e-17
C152 (\2\:RNb VSS) capacitor c=1.77701e-16
C153 (\3\:RNb VSS) capacitor c=1.03929e-16
C154 (\11\:n20 VSS) capacitor c=4.63635e-17
C155 (\7\:qbint VSS) capacitor c=3.87674e-17
C156 (\12\:RNb VSS) capacitor c=1.19811e-16
C157 (\14\:CKNb VSS) capacitor c=1.55474e-16
C158 (\15\:CKNb VSS) capacitor c=1.38098e-16
C159 (\14\:n20 VSS) capacitor c=7.54562e-17
C160 (\15\:n20 VSS) capacitor c=6.15157e-17
C161 (\16\:n20 VSS) capacitor c=5.98052e-17
C162 (\11\:CKNbb VSS) capacitor c=5.36369e-17
C163 (\14\:CKNbb VSS) capacitor c=8.14966e-17
C164 (\7\:CKN VSS) capacitor c=3.39728e-17
C165 (\18\:CKNb VSS) capacitor c=6.96727e-17
C166 (\19\:CKNb VSS) capacitor c=4.27993e-17
C167 (\6\:D VSS) capacitor c=4.80182e-17
C168 (\7\:mout VSS) capacitor c=8.27115e-17
C169 (\9\:mout VSS) capacitor c=6.46765e-17
C170 (\10\:mout VSS) capacitor c=5.26265e-17
C171 (\17\:mout VSS) capacitor c=4.53976e-17
C172 (\7\:SE VSS) capacitor c=5.24686e-17
C173 (\6\:SEb VSS) capacitor c=8.17114e-17
C174 (\7\:SEb VSS) capacitor c=6.72953e-17
C175 (\6\:n35 VSS) capacitor c=7.90922e-17
C176 (\17\:CKNbb VSS) capacitor c=3.96414e-17
C177 (\18\:CKNbb VSS) capacitor c=4.2063e-17
C178 (\8\:n35g VSS) capacitor c=3.48863e-17
C179 (\11\:n35 VSS) capacitor c=7.50013e-17
C180 (\12\:qbint VSS) capacitor c=8.77437e-17
C181 (\13\:qbint VSS) capacitor c=1.12023e-16
C182 (\13\:n35g VSS) capacitor c=1.04634e-16
C183 (\14\:n35g VSS) capacitor c=1.15912e-16
C184 (\5\:RTb VSS) capacitor c=4.92957e-17
C185 (\8\:RTb VSS) capacitor c=1.00061e-16
C186 (\9\:RTb VSS) capacitor c=9.13858e-17
C187 (\9\:RT VSS) capacitor c=1.19039e-16
C188 (\10\:RT VSS) capacitor c=1.18186e-16
C189 (\11\:RT VSS) capacitor c=3.80585e-17
C190 (\15\:RNb VSS) capacitor c=1.13564e-16
C191 (\16\:RNb VSS) capacitor c=1.13929e-16
C192 (\22\:CKNb VSS) capacitor c=1.5381e-16
C193 (\23\:CKNb VSS) capacitor c=1.43916e-16
C194 (\18\:qbint VSS) capacitor c=2.25365e-17
C195 (\19\:qbint VSS) capacitor c=3.20899e-17
C196 (\16\:n35 VSS) capacitor c=8.97661e-17
C197 (\3\:Q VSS) capacitor c=2.09829e-17
C198 (\6\:VDD VSS) capacitor c=1.99148e-16
C199 (\7\:VDD VSS) capacitor c=2.23268e-17
C200 (\9\:VDD VSS) capacitor c=2.85155e-17
C201 (\16\:VDD VSS) capacitor c=4.51087e-17
Rk35 (\4\:SI SI) resistor r=0.006943 c=0
Rk1 (\5\:RN RN) resistor r=0.006385 c=0
Rk62 (RT \9\:RT) resistor r=0.1847 c=0
Rk63 (\9\:RT \10\:RT) resistor r=0.6593 c=0
Rk64 (RT \11\:RT) resistor r=0.01483 c=0
Rk71 (\3\:Q Q) resistor r=0.02445 c=0
Rk70 (\2\:Q \3\:Q) resistor r=0.206 c=0
Rk72 (\3\:Q \5\:Q) resistor r=0.3713 c=0
Rk86 (VDD VDD) resistor r=0.2369 c=0
Rk74 (\2\:VDD \4\:VDD) resistor r=0.2907 c=0
Rk75 (\4\:VDD \5\:VDD) resistor r=0.1196 c=0
Rk76 (\5\:VDD \6\:VDD) resistor r=1.5124 c=0
Rk77 (\6\:VDD \7\:VDD) resistor r=0.2384 c=0
Rk78 (\7\:VDD \9\:VDD) resistor r=0.1024 c=0
Rk79 (\4\:VDD \11\:VDD) resistor r=0.3603 c=0
Rk80 (\6\:VDD \13\:VDD) resistor r=0.3682 c=0
Rk81 (\7\:VDD \15\:VDD) resistor r=0.2001 c=0
Rk85 (\16\:VDD VDD) resistor r=0.1961 c=0
Rk82 (\9\:VDD \16\:VDD) resistor r=0.1715 c=0
Rk83 (\16\:VDD \18\:VDD) resistor r=0.2027 c=0
Rk84 (\9\:VDD \20\:VDD) resistor r=0.2362 c=0
Rk87 (VDD \22\:VDD) resistor r=0.3797 c=0
Rk36 (SE \7\:SE) resistor r=0.04331 c=0
Rk14 (CKN \5\:CKN) resistor r=0.001978 c=0
Rk17 (\5\:CKN \6\:CKN) resistor r=0.01152 c=0
Rk16 (\6\:CKN \7\:CKN) resistor r=0.005219 c=0
Rk49 (ExtVDD ExtVDD) resistor r=0.002067 c=0
Rk47 (\2\:ExtVDD ExtVDD) resistor r=0.02221 c=0
Rk50 (ExtVDD \5\:ExtVDD) resistor r=0.02019 c=0
Rk51 (ExtVDD \6\:ExtVDD) resistor r=0.15 c=0
Rk21 (\5\:D D) resistor r=0.007222 c=0
Rk23 (\5\:D \7\:D) resistor r=0.01656 c=0
Rk22 (\6\:D \7\:D) resistor r=0.007222 c=0
Rk88 (\2\:VSS \3\:VSS) resistor r=0.0421 c=0
Rk89 (\3\:VSS \4\:VSS) resistor r=0.1068 c=0
Rk90 (\4\:VSS \5\:VSS) resistor r=0.6641 c=0
Rk91 (\5\:VSS \6\:VSS) resistor r=0.03215 c=0
Rk93 (\7\:VSS VSS) resistor r=0.2707 c=0
Rk92 (\6\:VSS \7\:VSS) resistor r=0.1764 c=0
Rk94 (VSS \8\:VSS) resistor r=0.3732 c=0
Rk95 (\8\:VSS \9\:VSS) resistor r=0.3081 c=0
Rk97 (\10\:VSS VSS) resistor r=0.1217 c=0
Rk96 (\9\:VSS \10\:VSS) resistor r=0.06449 c=0
Rk98 (VSS \12\:VSS) resistor r=0.3134 c=0
Rk99 (\3\:VSS \14\:VSS) resistor r=0.262 c=0
Rk100 (\5\:VSS \16\:VSS) resistor r=0.1902 c=0
Rk101 (\7\:VSS \18\:VSS) resistor r=0.1953 c=0
Rk102 (\8\:VSS \20\:VSS) resistor r=0.2547 c=0
Rk103 (\9\:VSS \22\:VSS) resistor r=0.2503 c=0
Rk104 (\24\:VSS \25\:VSS) resistor r=0.08688 c=0
Rk105 (\25\:VSS \26\:VSS) resistor r=0.311 c=0
Rk106 (\26\:VSS \27\:VSS) resistor r=0.3185 c=0
Rk108 (\28\:VSS VSS) resistor r=0.1988 c=0
Rk107 (\27\:VSS \28\:VSS) resistor r=0.3282 c=0
Rk109 (VSS \29\:VSS) resistor r=0.6817 c=0
Rk111 (\30\:VSS VSS) resistor r=0.1217 c=0
Rk110 (\29\:VSS \30\:VSS) resistor r=0.06449 c=0
Rk112 (VSS \31\:VSS) resistor r=0.01747 c=0
Rk113 (\31\:VSS \33\:VSS) resistor r=0.6655 c=0
Rk114 (\25\:VSS \35\:VSS) resistor r=0.2482 c=0
Rk115 (\27\:VSS \37\:VSS) resistor r=0.2448 c=0
Rk116 (\29\:VSS \39\:VSS) resistor r=0.2412 c=0
Rk117 (\31\:VSS \41\:VSS) resistor r=0.2412 c=0
Rk2 (\8\:n20 \10\:n20) resistor r=0.546 c=0
Rk3 (\10\:n20 \11\:n20) resistor r=0.2555 c=0
Rk7 (\13\:n20 \14\:n20) resistor r=0.3473 c=0
Rk8 (\13\:n20 \15\:n20) resistor r=0.2307 c=0
Rk9 (\15\:n20 \16\:n20) resistor r=0.2517 c=0
Rk10 (\16\:n20 \18\:n20) resistor r=0.2474 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8535 c=0
Rk18 (\17\:CKNb \18\:CKNb) resistor r=0.3246 c=0
Rk19 (\18\:CKNb \19\:CKNb) resistor r=0.1843 c=0
Rk20 (\18\:CKNb \21\:CKNb) resistor r=0.1875 c=0
Rk66 (\22\:CKNb \23\:CKNb) resistor r=0.9488 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.6054 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.5102 c=0
Rk29 (\8\:mout \9\:mout) resistor r=0.04826 c=0
Rk30 (\9\:mout \10\:mout) resistor r=0.198 c=0
Rk31 (\7\:mout \12\:mout) resistor r=0.1285 c=0
Rk32 (\8\:mout \14\:mout) resistor r=0.5423 c=0
Rk33 (\9\:mout \16\:mout) resistor r=0.1048 c=0
Rk34 (\10\:mout \17\:mout) resistor r=0.3958 c=0
Rk11 (\11\:CKNbb \13\:CKNbb) resistor r=0.1427 c=0
Rk12 (\13\:CKNbb \14\:CKNbb) resistor r=0.4231 c=0
Rk13 (\14\:CKNbb \16\:CKNbb) resistor r=0.2375 c=0
Rk42 (\17\:CKNbb \18\:CKNbb) resistor r=0.3735 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1643 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3826 c=0
Rk65 (\15\:RNb \16\:RNb) resistor r=0.6792 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.2181 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3488 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.3114 c=0
Rk43 (\7\:n35g \8\:n35g) resistor r=0.2748 c=0
Rk44 (\7\:n35g \10\:n35g) resistor r=0.6952 c=0
Rk55 (\12\:n35g \13\:n35g) resistor r=0.2443 c=0
Rk56 (\13\:n35g \14\:n35g) resistor r=0.5686 c=0
Rk57 (\13\:n35g \16\:n35g) resistor r=0.4343 c=0
Rk52 (\12\:qbint \13\:qbint) resistor r=0.4973 c=0
Rk53 (\13\:qbint \15\:qbint) resistor r=0.5702 c=0
Rk54 (\13\:qbint \17\:qbint) resistor r=0.1471 c=0
Rk67 (\18\:qbint \19\:qbint) resistor r=0.2424 c=0
Rk58 (\5\:RTb \7\:RTb) resistor r=0.2174 c=0
Rk59 (\7\:RTb \8\:RTb) resistor r=0.4188 c=0
Rk60 (\8\:RTb \9\:RTb) resistor r=0.6924 c=0
Rk61 (\8\:RTb \11\:RTb) resistor r=0.3083 c=0
Rk40 (\5\:n35 \6\:n35) resistor r=0.412 c=0
Rk41 (\6\:n35 \8\:n35) resistor r=0.2919 c=0
Rk45 (\10\:n35 \11\:n35) resistor r=0.4031 c=0
Rk46 (\11\:n35 \13\:n35) resistor r=0.3317 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.4129 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.3473 c=0
Rk24 (\2\:Db \4\:Db) resistor r=0.6398 c=0
Rk25 (\4\:Db \6\:Db) resistor r=1.363 c=0
Rk26 (\6\:Db \8\:Db) resistor r=0.6354 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.5717 c=0
Rl23 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl22 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl53 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl40 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl43 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl42 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl41 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl26 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl28 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl25 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl27 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl24 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl19 (\2\:D \4\:D) resistor r=115.099 c=0
Rl17 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl18 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl16 (\5\:n20 \6\:n20) resistor r=285.406 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=208.269 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\12\:CKNb \13\:CKNb) resistor r=213.245 c=0
Rl6 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl51 (\7\:CKNb \10\:CKNb) resistor r=65.3159 c=0
Rl48 (\6\:CKNb \7\:CKNb) resistor r=753.137 c=0
Rl52 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl50 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl49 (\7\:CKNb \8\:CKNb) resistor r=455.369 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\9\:CKNbb \10\:CKNbb) resistor r=804.248 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl32 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl29 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl33 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl31 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl30 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl68 (\7\:RNb \8\:RNb) resistor r=233.721 c=0
Rl69 (\8\:RNb \9\:RNb) resistor r=267.896 c=0
Rl54 (RNb \2\:RNb) resistor r=1075.02 c=0
Rl57 (\2\:RNb \5\:RNb) resistor r=114.179 c=0
Rl58 (\3\:RNb \6\:RNb) resistor r=153.384 c=0
Rl56 (\3\:RNb \4\:RNb) resistor r=293.646 c=0
Rl55 (\2\:RNb \3\:RNb) resistor r=46.238 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl36 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl37 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl67 (\10\:qbint \11\:qbint) resistor r=260.089 c=0
Rl66 (\8\:qbint \10\:qbint) resistor r=512.697 c=0
Rl47 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl44 (qbint \2\:qbint) resistor r=112.732 c=0
Rl46 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl45 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl65 (\7\:qbint \9\:qbint) resistor r=70.3116 c=0
Rl63 (\6\:qbint \7\:qbint) resistor r=76.2993 c=0
Rl64 (\7\:qbint \8\:qbint) resistor r=254.112 c=0
Rl38 (RTb \2\:RTb) resistor r=112.412 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (n35 \2\:n35) resistor r=442.189 c=0
Rl60 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz22 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz23 (\3\:VDD \5\:VDD) resistor r=25 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz27 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz28 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz11 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz20 (n10 \2\:n10) resistor r=75 c=0
Rz21 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry21 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\10\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry24 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry25 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry31 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry33 (\23\:VSS \24\:VSS) resistor r=31 c=0
Ry34 (\23\:VSS \26\:VSS) resistor r=10.3333 c=0
Ry35 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry36 (\23\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry3 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx28 (\3\:RT \9\:RT) resistor r=45 c=0
Rx29 (\1\:RT \10\:RT) resistor r=45 c=0
Rx30 (\7\:RT \11\:RT) resistor r=45 c=0
Rx17 (\1\:SE \7\:SE) resistor r=45 c=0
Rx11 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \11\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx7 (\6\:n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:n20 \16\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx12 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx33 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx34 (\6\:CKNb \23\:CKNb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx9 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx10 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx20 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx21 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx3 (\4\:RNb \12\:RNb) resistor r=45 c=0
Rx31 (RNb \15\:RNb) resistor r=45 c=0
Rx32 (\9\:RNb \16\:RNb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx35 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx36 (qbint \19\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\15\:mout \6\:RNb \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \10\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \11\:qbint \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n10 \8\:RNb \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\9\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\12\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.17022 \
        scb=0.00118687 scc=2.51048e-06 m=(1)
mp31 (n5 \5\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.5373 \
        scb=0.0297678 scc=0.00268647 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=19.3315 \
        scb=0.0212584 scc=0.000579348 m=(1)
mp55 (\4\:Q \9\:qbint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.4029 \
        scb=0.0248226 scc=0.000748112 m=(1)
mp51 (n9 \7\:RNb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=19.1728 \
        scb=0.0210507 scc=0.000546994 m=(1)
ends SRDFFNRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:58:47 2012 )
// Library name: gsclib045
// Cell name: SRDFFNRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNRX1 CKN D ExtVDD Q QN RN RT SE SI VDD VSS
mp22 (\8\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (ExtVDD VSS) capacitor c=2.30565e-16
C2 (RN VSS) capacitor c=8.36151e-17
C3 (RT VSS) capacitor c=2.13906e-17
C4 (SI VSS) capacitor c=5.24843e-17
C5 (Q VSS) capacitor c=6.20497e-17
C6 (VDD VSS) capacitor c=7.52642e-16
C7 (QN VSS) capacitor c=2.2552e-17
C8 (SE VSS) capacitor c=3.9618e-17
C9 (CKN VSS) capacitor c=3.89934e-17
C10 (D VSS) capacitor c=9.38582e-17
C11 (n20 VSS) capacitor c=3.89358e-17
C12 (CKNb VSS) capacitor c=4.45694e-17
C13 (mout VSS) capacitor c=4.79505e-17
C14 (CKNbb VSS) capacitor c=3.23553e-17
C15 (RNb VSS) capacitor c=5.78139e-17
C16 (SEb VSS) capacitor c=7.74985e-17
C17 (n35g VSS) capacitor c=1.77753e-17
C18 (qbint VSS) capacitor c=4.54407e-17
C19 (RTb VSS) capacitor c=5.18061e-17
C20 (net573 VSS) capacitor c=2.25772e-17
C21 (n35 VSS) capacitor c=1.5135e-16
C22 (Db VSS) capacitor c=1.05128e-16
C23 (n11 VSS) capacitor c=6.28931e-17
C24 (n10 VSS) capacitor c=7.48782e-17
C25 (n1 VSS) capacitor c=1.02126e-18
C26 (\7\:qbint VSS) capacitor c=3.36193e-17
C27 (\11\:qbint VSS) capacitor c=1.20293e-16
C28 (\2\:RNb VSS) capacitor c=3.6912e-16
C29 (\13\:qbint VSS) capacitor c=4.38863e-17
C30 (\3\:net573 VSS) capacitor c=5.86653e-17
C31 (\12\:CKNb VSS) capacitor c=5.65826e-17
C32 (\4\:RTb VSS) capacitor c=9.88373e-17
C33 (\6\:RT VSS) capacitor c=2.20693e-17
C34 (\4\:qbint VSS) capacitor c=5.36612e-17
C35 (\3\:n35g VSS) capacitor c=5.21926e-17
C36 (\5\:RT VSS) capacitor c=6.97914e-17
C37 (\3\:SE VSS) capacitor c=7.65277e-17
C38 (\7\:CKNbb VSS) capacitor c=3.4512e-17
C39 (\3\:SI VSS) capacitor c=9.47782e-17
C40 (\4\:SE VSS) capacitor c=1.22706e-16
C41 (\7\:RNb VSS) capacitor c=5.99721e-17
C42 (\4\:D VSS) capacitor c=7.03694e-17
C43 (\5\:n20 VSS) capacitor c=9.56816e-17
C44 (\4\:CKN VSS) capacitor c=5.39794e-17
C45 (\4\:CKNb VSS) capacitor c=4.53327e-17
C46 (\8\:CKNbb VSS) capacitor c=8.16286e-17
C47 (\3\:CKNb VSS) capacitor c=1.09095e-16
C48 (\1\:RN VSS) capacitor c=4.14282e-17
C49 (\6\:qbint VSS) capacitor c=3.78721e-17
C50 (\12\:qbint VSS) capacitor c=5.80945e-17
C51 (\14\:qbint VSS) capacitor c=4.63282e-17
C52 (\4\:net573 VSS) capacitor c=3.68408e-17
C53 (\9\:CKNbb VSS) capacitor c=2.02823e-16
C54 (\8\:RT VSS) capacitor c=1.21533e-16
C55 (\2\:RT VSS) capacitor c=6.23027e-17
C56 (\5\:qbint VSS) capacitor c=3.89021e-17
C57 (\5\:n35g VSS) capacitor c=3.28666e-17
C58 (\2\:RTb VSS) capacitor c=4.86582e-17
C59 (\5\:SE VSS) capacitor c=5.7887e-17
C60 (\6\:CKNb VSS) capacitor c=3.48485e-17
C61 (\1\:SI VSS) capacitor c=4.91308e-17
C62 (\6\:SE VSS) capacitor c=8.61913e-17
C63 (\6\:RNb VSS) capacitor c=5.26448e-17
C64 (\3\:SEb VSS) capacitor c=6.60658e-17
C65 (\1\:D VSS) capacitor c=4.95201e-17
C66 (\3\:n20 VSS) capacitor c=4.38664e-17
C67 (\1\:CKN VSS) capacitor c=2.85144e-17
C68 (\3\:mout VSS) capacitor c=5.01444e-17
C69 (\11\:CKNb VSS) capacitor c=4.92799e-17
C70 (\4\:RN VSS) capacitor c=3.68513e-17
C71 (\13\:CKNb VSS) capacitor c=5.16127e-17
C72 (\10\:qbint VSS) capacitor c=8.55902e-17
C73 (\7\:RT VSS) capacitor c=1.52967e-16
C74 (\10\:CKNb VSS) capacitor c=1.67535e-16
C75 (\3\:RT VSS) capacitor c=5.08271e-17
C76 (\1\:RT VSS) capacitor c=5.22705e-17
C77 (\3\:RTb VSS) capacitor c=7.59476e-17
C78 (\3\:qbint VSS) capacitor c=4.4406e-17
C79 (\2\:n35 VSS) capacitor c=2.32651e-16
C80 (\4\:n35g VSS) capacitor c=6.68789e-17
C81 (\3\:CKNbb VSS) capacitor c=5.97859e-17
C82 (\10\:CKNbb VSS) capacitor c=2.17818e-16
C83 (\3\:n35 VSS) capacitor c=1.06034e-16
C84 (\1\:SE VSS) capacitor c=2.48216e-17
C85 (\2\:SI VSS) capacitor c=7.76333e-17
C86 (\2\:SEb VSS) capacitor c=7.74478e-17
C87 (\3\:D VSS) capacitor c=1.4664e-17
C88 (\6\:n20 VSS) capacitor c=8.06263e-17
C89 (\4\:n20 VSS) capacitor c=3.85642e-17
C90 (\3\:CKN VSS) capacitor c=2.40654e-17
C91 (\2\:mout VSS) capacitor c=3.17706e-17
C92 (\4\:mout VSS) capacitor c=3.92547e-17
C93 (\2\:CKNb VSS) capacitor c=7.99058e-17
C94 (\6\:CKNbb VSS) capacitor c=3.65693e-17
C95 (\7\:n20 VSS) capacitor c=5.38331e-17
C96 (\2\:CKNbb VSS) capacitor c=5.81582e-17
C97 (\5\:CKNb VSS) capacitor c=7.92574e-17
C98 (\9\:CKNb VSS) capacitor c=2.73178e-17
C99 (\5\:RNb VSS) capacitor c=1.20485e-16
C100 (\2\:n20 VSS) capacitor c=4.55743e-17
C101 (\3\:RN VSS) capacitor c=4.74438e-17
C102 (\1\:VDD VSS) capacitor c=4.93951e-17
C103 (\3\:Q VSS) capacitor c=8.19591e-17
C104 (\11\:VDD VSS) capacitor c=4.90026e-17
C105 (\9\:net573 VSS) capacitor c=5.58219e-17
C106 (\13\:VDD VSS) capacitor c=7.97606e-17
C107 (\3\:n11 VSS) capacitor c=9.94421e-17
C108 (\4\:QN VSS) capacitor c=6.74361e-17
C109 (\14\:n35 VSS) capacitor c=5.24739e-17
C110 (\15\:n35g VSS) capacitor c=5.5909e-17
C111 (\6\:RTb VSS) capacitor c=7.2397e-17
C112 (\1\:ExtVDD VSS) capacitor c=2.78555e-16
C113 (\9\:n35 VSS) capacitor c=6.19273e-17
C114 (\17\:qbint VSS) capacitor c=6.81986e-17
C115 (\6\:n35g VSS) capacitor c=9.60383e-17
C116 (\8\:SEb VSS) capacitor c=5.06071e-17
C117 (\4\:n35 VSS) capacitor c=6.12731e-17
C118 (\15\:VDD VSS) capacitor c=6.07875e-17
C119 (\5\:mout VSS) capacitor c=7.76403e-17
C120 (\3\:Db VSS) capacitor c=1.85393e-16
C121 (\17\:VDD VSS) capacitor c=3.85232e-17
C122 (\22\:VDD VSS) capacitor c=3.54295e-17
C123 (\13\:mout VSS) capacitor c=5.83998e-17
C124 (\20\:CKNb VSS) capacitor c=2.98453e-17
C125 (\20\:VDD VSS) capacitor c=4.12536e-17
C126 (\12\:CKNbb VSS) capacitor c=5.8853e-17
C127 (\13\:n20 VSS) capacitor c=6.45242e-17
C128 (\5\:Db VSS) capacitor c=2.28145e-16
C129 (\8\:RNb VSS) capacitor c=5.40837e-17
C130 (\10\:n20 VSS) capacitor c=6.3429e-17
C131 (\24\:VDD VSS) capacitor c=4.25619e-17
C132 (\1\:Q VSS) capacitor c=5.2727e-17
C133 (\5\:net573 VSS) capacitor c=4.31693e-17
C134 (\3\:n10 VSS) capacitor c=7.9152e-17
C135 (\1\:QN VSS) capacitor c=3.72743e-17
C136 (\17\:n35 VSS) capacitor c=4.13331e-17
C137 (\11\:n35g VSS) capacitor c=2.96827e-17
C138 (\10\:RTb VSS) capacitor c=5.81982e-17
C139 (\12\:n35 VSS) capacitor c=6.35168e-17
C140 (\19\:qbint VSS) capacitor c=2.43447e-17
C141 (\9\:n35g VSS) capacitor c=7.72521e-17
C142 (\4\:SEb VSS) capacitor c=3.83048e-17
C143 (\7\:n35 VSS) capacitor c=3.77874e-17
C144 (\11\:mout VSS) capacitor c=3.75653e-17
C145 (\15\:mout VSS) capacitor c=2.97046e-17
C146 (\16\:CKNb VSS) capacitor c=5.3617e-17
C147 (\15\:CKNbb VSS) capacitor c=5.89602e-17
C148 (\17\:n20 VSS) capacitor c=8.30467e-17
C149 (\7\:Db VSS) capacitor c=1.10549e-16
C150 (\11\:RNb VSS) capacitor c=7.0859e-17
C151 (\8\:n20 VSS) capacitor c=5.96395e-17
C152 (VDD VSS) capacitor c=5.17174e-17
C153 (\2\:CKN VSS) capacitor c=3.47094e-17
C154 (\2\:D VSS) capacitor c=3.53727e-17
C155 (\2\:SE VSS) capacitor c=2.57292e-17
C156 (\4\:CKNbb VSS) capacitor c=1.47583e-16
C157 (\5\:CKNbb VSS) capacitor c=7.62941e-17
C158 (\2\:n35g VSS) capacitor c=2.90849e-17
C159 (\4\:RT VSS) capacitor c=5.2386e-17
C160 (\2\:qbint VSS) capacitor c=4.13065e-17
C161 (\7\:CKNb VSS) capacitor c=1.28162e-16
C162 (\8\:CKNb VSS) capacitor c=6.57182e-17
C163 (\2\:net573 VSS) capacitor c=1.53336e-17
C164 (\12\:n20 VSS) capacitor c=4.63088e-17
C165 (\3\:RNb VSS) capacitor c=2.91833e-16
C166 (\4\:RNb VSS) capacitor c=1.1855e-16
C167 (\10\:RNb VSS) capacitor c=1.20254e-16
C168 (\14\:CKNb VSS) capacitor c=1.55458e-16
C169 (\15\:CKNb VSS) capacitor c=1.38277e-16
C170 (\15\:n20 VSS) capacitor c=7.50124e-17
C171 (\16\:n20 VSS) capacitor c=9.27968e-17
C172 (\8\:qbint VSS) capacitor c=5.09962e-17
C173 (\9\:qbint VSS) capacitor c=7.73566e-17
C174 (\11\:CKNbb VSS) capacitor c=5.37364e-17
C175 (\14\:CKNbb VSS) capacitor c=8.16587e-17
C176 (\5\:CKN VSS) capacitor c=4.07744e-18
C177 (\6\:CKN VSS) capacitor c=2.88047e-17
C178 (\19\:n20 VSS) capacitor c=4.89495e-17
C179 (\20\:n20 VSS) capacitor c=4.84792e-17
C180 (\18\:CKNb VSS) capacitor c=6.97672e-17
C181 (\19\:CKNb VSS) capacitor c=4.29678e-17
C182 (\7\:mout VSS) capacitor c=8.35937e-17
C183 (\8\:mout VSS) capacitor c=5.3233e-17
C184 (\9\:mout VSS) capacitor c=1.90246e-17
C185 (\10\:mout VSS) capacitor c=7.58994e-17
C186 (\17\:mout VSS) capacitor c=7.39082e-17
C187 (\5\:SI VSS) capacitor c=3.48426e-17
C188 (\7\:SE VSS) capacitor c=5.23082e-17
C189 (\6\:n35 VSS) capacitor c=7.11534e-17
C190 (\6\:SEb VSS) capacitor c=8.23114e-17
C191 (\7\:SEb VSS) capacitor c=6.72658e-17
C192 (\17\:CKNbb VSS) capacitor c=3.49327e-17
C193 (\18\:CKNbb VSS) capacitor c=3.64971e-17
C194 (\8\:n35g VSS) capacitor c=3.39835e-17
C195 (\11\:n35 VSS) capacitor c=7.49055e-17
C196 (\15\:qbint VSS) capacitor c=8.78471e-17
C197 (\16\:qbint VSS) capacitor c=1.11964e-16
C198 (\13\:n35g VSS) capacitor c=1.02785e-16
C199 (\14\:n35g VSS) capacitor c=1.1611e-16
C200 (\5\:RTb VSS) capacitor c=4.9153e-17
C201 (\8\:RTb VSS) capacitor c=9.96219e-17
C202 (\9\:RTb VSS) capacitor c=9.1018e-17
C203 (\9\:RT VSS) capacitor c=1.0533e-16
C204 (\10\:RT VSS) capacitor c=1.18336e-16
C205 (\11\:RT VSS) capacitor c=3.8175e-17
C206 (\21\:qbint VSS) capacitor c=2.43468e-17
C207 (\22\:qbint VSS) capacitor c=3.00163e-17
C208 (\22\:CKNb VSS) capacitor c=9.67046e-17
C209 (\23\:CKNb VSS) capacitor c=1.00377e-16
C210 (\3\:QN VSS) capacitor c=3.36463e-17
C211 (\16\:n35 VSS) capacitor c=4.45599e-17
C212 (\7\:net573 VSS) capacitor c=5.66165e-17
C213 (\8\:net573 VSS) capacitor c=3.48112e-17
C214 (\3\:VDD VSS) capacitor c=5.02005e-17
C215 (\5\:VDD VSS) capacitor c=9.96254e-18
C216 (\6\:VDD VSS) capacitor c=2.20274e-16
C217 (\7\:VDD VSS) capacitor c=2.06628e-16
C218 (\8\:VDD VSS) capacitor c=2.3561e-17
C219 (\10\:VDD VSS) capacitor c=3.25234e-17
C220 (\19\:VDD VSS) capacitor c=6.3277e-17
Rk54 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk52 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk55 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk56 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk1 (\5\:RN RN) resistor r=0.006381 c=0
Rk67 (RT \9\:RT) resistor r=0.1845 c=0
Rk68 (\9\:RT \10\:RT) resistor r=0.6434 c=0
Rk69 (RT \11\:RT) resistor r=0.01482 c=0
Rk36 (SI \4\:SI) resistor r=0.01024 c=0
Rk40 (\5\:SI SI) resistor r=0.01024 c=0
Rk37 (\5\:SI \4\:SI) resistor r=0.001853 c=0
Rk81 (\2\:Q Q) resistor r=0.1646 c=0
Rk82 (Q \4\:Q) resistor r=0.3291 c=0
Rk116 (VDD VDD) resistor r=0.1321 c=0
Rk102 (\2\:VDD \3\:VDD) resistor r=0.578 c=0
Rk103 (\3\:VDD \5\:VDD) resistor r=0.06692 c=0
Rk104 (\5\:VDD \6\:VDD) resistor r=0.05201 c=0
Rk105 (\6\:VDD \7\:VDD) resistor r=1.5259 c=0
Rk106 (\7\:VDD \8\:VDD) resistor r=0.186 c=0
Rk107 (\8\:VDD \10\:VDD) resistor r=0.1545 c=0
Rk108 (\3\:VDD \12\:VDD) resistor r=0.294 c=0
Rk109 (\6\:VDD \14\:VDD) resistor r=0.3757 c=0
Rk110 (\7\:VDD \16\:VDD) resistor r=0.3677 c=0
Rk111 (\8\:VDD \18\:VDD) resistor r=0.2024 c=0
Rk115 (\19\:VDD VDD) resistor r=0.2929 c=0
Rk112 (\10\:VDD \19\:VDD) resistor r=0.1713 c=0
Rk113 (\19\:VDD \21\:VDD) resistor r=0.1998 c=0
Rk114 (\10\:VDD \23\:VDD) resistor r=0.2359 c=0
Rk117 (VDD \25\:VDD) resistor r=0.3801 c=0
Rk73 (\3\:QN QN) resistor r=0.02726 c=0
Rk72 (\2\:QN \3\:QN) resistor r=0.204 c=0
Rk74 (\3\:QN \5\:QN) resistor r=0.353 c=0
Rk41 (SE \7\:SE) resistor r=0.04328 c=0
Rk13 (CKN \5\:CKN) resistor r=0.002292 c=0
Rk16 (\5\:CKN \6\:CKN) resistor r=0.00987 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.007821 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk90 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk91 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk92 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk93 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk95 (\13\:VSS VSS) resistor r=0.2481 c=0
Rk94 (\12\:VSS \13\:VSS) resistor r=0.1589 c=0
Rk96 (\5\:VSS \15\:VSS) resistor r=0.2678 c=0
Rk97 (\7\:VSS \17\:VSS) resistor r=0.19 c=0
Rk98 (\9\:VSS \19\:VSS) resistor r=0.1951 c=0
Rk99 (\10\:VSS \21\:VSS) resistor r=0.2543 c=0
Rk100 (\11\:VSS \23\:VSS) resistor r=0.2499 c=0
Rk101 (\13\:VSS \25\:VSS) resistor r=0.2374 c=0
Rk118 (\27\:VSS \28\:VSS) resistor r=0.08432 c=0
Rk119 (\28\:VSS \29\:VSS) resistor r=0.1142 c=0
Rk120 (\29\:VSS \30\:VSS) resistor r=0.0893 c=0
Rk121 (\30\:VSS \31\:VSS) resistor r=0.3578 c=0
Rk123 (\32\:VSS VSS) resistor r=0.3774 c=0
Rk122 (\31\:VSS \32\:VSS) resistor r=0.3679 c=0
Rk124 (VSS \33\:VSS) resistor r=0.1494 c=0
Rk125 (\33\:VSS \34\:VSS) resistor r=0.5417 c=0
Rk126 (\34\:VSS \35\:VSS) resistor r=0.3427 c=0
Rk128 (\36\:VSS VSS) resistor r=0.2037 c=0
Rk127 (\35\:VSS \36\:VSS) resistor r=0.05947 c=0
Rk129 (VSS \38\:VSS) resistor r=0.4016 c=0
Rk130 (\28\:VSS \40\:VSS) resistor r=0.2409 c=0
Rk131 (\30\:VSS \42\:VSS) resistor r=0.2472 c=0
Rk132 (\32\:VSS \44\:VSS) resistor r=0.2445 c=0
Rk133 (\34\:VSS \46\:VSS) resistor r=0.2409 c=0
Rk134 (\35\:VSS \48\:VSS) resistor r=0.2409 c=0
Rk21 (\5\:D D) resistor r=0.007217 c=0
Rk22 (D \6\:D) resistor r=0.007217 c=0
Rk24 (\5\:D \6\:D) resistor r=0.01655 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3469 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2525 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4762 c=0
Rk17 (\19\:n20 \20\:n20) resistor r=0.2144 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8523 c=0
Rk18 (\17\:CKNb \18\:CKNb) resistor r=0.3242 c=0
Rk19 (\18\:CKNb \19\:CKNb) resistor r=0.184 c=0
Rk20 (\18\:CKNb \21\:CKNb) resistor r=0.1872 c=0
Rk71 (\22\:CKNb \23\:CKNb) resistor r=0.7635 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.6076 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3647 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1128 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.2021 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.1352 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.525 c=0
Rk34 (\9\:mout \16\:mout) resistor r=0.09784 c=0
Rk35 (\10\:mout \17\:mout) resistor r=0.426 c=0
Rk10 (\11\:CKNbb \13\:CKNbb) resistor r=0.1426 c=0
Rk11 (\13\:CKNbb \14\:CKNbb) resistor r=0.4225 c=0
Rk12 (\14\:CKNbb \16\:CKNbb) resistor r=0.2372 c=0
Rk47 (\17\:CKNbb \18\:CKNbb) resistor r=0.3729 c=0
Rk4 (\9\:RNb \10\:RNb) resistor r=0.193 c=0
Rk5 (\10\:RNb \12\:RNb) resistor r=0.3636 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.3482 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk48 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk49 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk60 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk61 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk62 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk57 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk58 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk59 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk70 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk63 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk64 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk65 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk66 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk77 (\6\:net573 \7\:net573) resistor r=0.238 c=0
Rk78 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk79 (\7\:net573 \10\:net573) resistor r=0.2849 c=0
Rk42 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk43 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk50 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk51 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk75 (\15\:n35 \16\:n35) resistor r=0.3075 c=0
Rk76 (\16\:n35 \18\:n35) resistor r=0.2886 c=0
Rk25 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk26 (\4\:Db \6\:Db) resistor r=1.3611 c=0
Rk27 (\6\:Db \8\:Db) resistor r=0.6346 c=0
Rk83 (\2\:n11 \4\:n11) resistor r=0.71 c=0
Rk80 (\2\:n10 \4\:n10) resistor r=0.6281 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl54 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl41 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl44 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl43 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl42 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl20 (\2\:D \4\:D) resistor r=115.099 c=0
Rl18 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl19 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl16 (\5\:n20 \6\:n20) resistor r=190.564 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=90.3645 c=0
Rl17 (\6\:n20 \7\:n20) resistor r=117.486 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl57 (\12\:CKNb \13\:CKNb) resistor r=137.716 c=0
Rl6 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl49 (\6\:CKNb \7\:CKNb) resistor r=65.0422 c=0
Rl52 (\7\:CKNb \10\:CKNb) resistor r=808.345 c=0
Rl53 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl51 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl50 (\7\:CKNb \8\:CKNb) resistor r=416.829 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl58 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl33 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl30 (\3\:CKNbb \4\:CKNbb) resistor r=395.821 c=0
Rl34 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl32 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl31 (\4\:CKNbb \5\:CKNbb) resistor r=407.602 c=0
Rl62 (RNb \2\:RNb) resistor r=234.8 c=0
Rl63 (\2\:RNb \3\:RNb) resistor r=1469.68 c=0
Rl66 (\3\:RNb \6\:RNb) resistor r=180.888 c=0
Rl67 (\4\:RNb \7\:RNb) resistor r=75.8186 c=0
Rl65 (\4\:RNb \5\:RNb) resistor r=424.798 c=0
Rl64 (\3\:RNb \4\:RNb) resistor r=83.4088 c=0
Rl21 (SEb \2\:SEb) resistor r=101.718 c=0
Rl22 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl37 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl35 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl36 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl38 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl68 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl73 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl75 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl69 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl72 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl74 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl71 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl70 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl39 (RTb \2\:RTb) resistor r=112.412 c=0
Rl40 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (net573 \2\:net573) resistor r=3.1216 c=0
Rl60 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl61 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl55 (n35 \2\:n35) resistor r=508.667 c=0
Rl56 (\2\:n35 \3\:n35) resistor r=380.826 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz18 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz24 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz25 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz26 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz27 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz28 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz29 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz30 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz33 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz34 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz35 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz36 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz37 (\45\:VSS \46\:VSS) resistor r=75 c=0
Rz38 (\47\:VSS \48\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz2 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz11 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz20 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz19 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry32 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry33 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry34 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry37 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\26\:VSS \27\:VSS) resistor r=31 c=0
Ry39 (\26\:VSS \29\:VSS) resistor r=31 c=0
Ry40 (\26\:VSS \31\:VSS) resistor r=8.8571 c=0
Ry41 (\26\:VSS \33\:VSS) resistor r=5.6364 c=0
Ry42 (\26\:VSS \36\:VSS) resistor r=7.75 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry2 (\8\:RNb \9\:RNb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry24 (n11 \2\:n11) resistor r=62 c=0
Ry25 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx10 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx14 (\3\:D D) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\7\:n20 \16\:n20) resistor r=45 c=0
Rx11 (\6\:n20 \19\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx13 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \17\:mout) resistor r=45 c=0
Rx8 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx3 (\5\:RNb \10\:RNb) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx32 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx33 (qbint \22\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx37 (net573 \8\:net573) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx36 (n35 \16\:n35) resistor r=45 c=0
mn22 (\11\:RNb \4\:RN \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 RNb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp31 (n5 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.74828 \
        scb=0.00141025 scc=2.59727e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0497 \
        scb=0.0111987 scc=0.000289961 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \2\:RNb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:59:37 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSQX1 CKN D ExtVDD Q RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=1.77014e-17
C2 (D VSS) capacitor c=4.48601e-17
C3 (ExtVDD VSS) capacitor c=2.25518e-16
C4 (SI VSS) capacitor c=4.98312e-17
C5 (RT VSS) capacitor c=2.31186e-17
C6 (CKN VSS) capacitor c=3.89748e-17
C7 (SN VSS) capacitor c=5.01634e-17
C8 (VDD VSS) capacitor c=7.05436e-16
C9 (SE VSS) capacitor c=3.52476e-17
C10 (n20 VSS) capacitor c=3.87782e-17
C11 (CKNb VSS) capacitor c=4.44575e-17
C12 (mout VSS) capacitor c=4.83533e-17
C13 (CKNbb VSS) capacitor c=3.22874e-17
C14 (SEb VSS) capacitor c=7.76341e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.60571e-17
C17 (RTb VSS) capacitor c=5.17974e-17
C18 (n35 VSS) capacitor c=1.72429e-16
C19 (Db VSS) capacitor c=1.04826e-16
C20 (n11 VSS) capacitor c=8.1482e-17
C21 (n1 VSS) capacitor c=8.87983e-19
C22 (\7\:SN VSS) capacitor c=8.82435e-17
C23 (\7\:qbint VSS) capacitor c=3.74556e-17
C24 (\10\:qbint VSS) capacitor c=1.01698e-16
C25 (\12\:CKNb VSS) capacitor c=4.77557e-17
C26 (\4\:RTb VSS) capacitor c=9.76746e-17
C27 (\6\:RT VSS) capacitor c=2.23208e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.21809e-17
C30 (\5\:RT VSS) capacitor c=6.48326e-17
C31 (\3\:SE VSS) capacitor c=7.77317e-17
C32 (\7\:CKNbb VSS) capacitor c=2.96146e-17
C33 (\3\:SI VSS) capacitor c=9.47325e-17
C34 (\4\:SE VSS) capacitor c=1.24595e-16
C35 (\4\:D VSS) capacitor c=6.91354e-17
C36 (\3\:n20 VSS) capacitor c=3.30128e-17
C37 (\1\:SN VSS) capacitor c=3.07805e-17
C38 (\4\:CKN VSS) capacitor c=5.5011e-17
C39 (\4\:CKNb VSS) capacitor c=4.53925e-17
C40 (\8\:CKNbb VSS) capacitor c=8.31595e-17
C41 (\3\:CKNb VSS) capacitor c=1.11663e-16
C42 (\6\:qbint VSS) capacitor c=4.18392e-17
C43 (\8\:SN VSS) capacitor c=1.46965e-16
C44 (\11\:qbint VSS) capacitor c=1.49802e-16
C45 (\9\:CKNbb VSS) capacitor c=2.55237e-16
C46 (\8\:RT VSS) capacitor c=1.20729e-16
C47 (\2\:RT VSS) capacitor c=6.21869e-17
C48 (\5\:qbint VSS) capacitor c=3.87334e-17
C49 (\5\:n35g VSS) capacitor c=3.28666e-17
C50 (\2\:RTb VSS) capacitor c=4.65075e-17
C51 (\5\:SE VSS) capacitor c=5.78865e-17
C52 (\6\:CKNb VSS) capacitor c=2.73311e-17
C53 (\1\:SI VSS) capacitor c=4.91308e-17
C54 (\6\:SE VSS) capacitor c=8.61373e-17
C55 (\3\:SEb VSS) capacitor c=6.59521e-17
C56 (\1\:D VSS) capacitor c=4.95122e-17
C57 (\7\:n20 VSS) capacitor c=6.12287e-17
C58 (\6\:SN VSS) capacitor c=6.63573e-17
C59 (\1\:CKN VSS) capacitor c=2.85077e-17
C60 (\3\:mout VSS) capacitor c=4.54948e-17
C61 (\11\:CKNb VSS) capacitor c=4.83019e-17
C62 (\9\:qbint VSS) capacitor c=8.55895e-17
C63 (\13\:CKNb VSS) capacitor c=5.13348e-17
C64 (\3\:SN VSS) capacitor c=2.95001e-16
C65 (\9\:SN VSS) capacitor c=6.35258e-17
C66 (\7\:RT VSS) capacitor c=1.46839e-16
C67 (\10\:CKNb VSS) capacitor c=1.6785e-16
C68 (\3\:RT VSS) capacitor c=3.94579e-17
C69 (\1\:RT VSS) capacitor c=5.29002e-17
C70 (\3\:RTb VSS) capacitor c=7.57803e-17
C71 (\3\:qbint VSS) capacitor c=4.37709e-17
C72 (\2\:n35 VSS) capacitor c=2.52896e-16
C73 (\4\:n35g VSS) capacitor c=6.63939e-17
C74 (\3\:CKNbb VSS) capacitor c=5.0436e-17
C75 (\10\:CKNbb VSS) capacitor c=2.17891e-16
C76 (\3\:n35 VSS) capacitor c=1.15146e-16
C77 (\1\:SE VSS) capacitor c=2.4385e-17
C78 (\2\:SI VSS) capacitor c=7.76842e-17
C79 (\2\:SEb VSS) capacitor c=7.70146e-17
C80 (\4\:n20 VSS) capacitor c=9.8532e-17
C81 (\6\:n20 VSS) capacitor c=5.8782e-17
C82 (\3\:D VSS) capacitor c=1.46144e-17
C83 (\2\:SN VSS) capacitor c=4.74269e-17
C84 (\5\:SN VSS) capacitor c=1.95572e-17
C85 (\3\:CKN VSS) capacitor c=2.36967e-17
C86 (\2\:mout VSS) capacitor c=4.33326e-17
C87 (\4\:mout VSS) capacitor c=3.05301e-17
C88 (\2\:CKNb VSS) capacitor c=7.93794e-17
C89 (\6\:CKNbb VSS) capacitor c=3.65502e-17
C90 (\5\:n20 VSS) capacitor c=6.33877e-17
C91 (\2\:CKNbb VSS) capacitor c=5.80986e-17
C92 (\5\:CKNb VSS) capacitor c=7.21331e-17
C93 (\9\:CKNb VSS) capacitor c=2.45444e-17
C94 (\2\:n20 VSS) capacitor c=3.95417e-17
C95 (\1\:VDD VSS) capacitor c=2.80666e-17
C96 (\11\:VDD VSS) capacitor c=5.0035e-17
C97 (\4\:Q VSS) capacitor c=5.92469e-17
C98 (\13\:VDD VSS) capacitor c=5.29409e-17
C99 (\3\:n11 VSS) capacitor c=8.3971e-17
C100 (\14\:n35 VSS) capacitor c=5.13832e-17
C101 (\15\:n35g VSS) capacitor c=5.69979e-17
C102 (\6\:RTb VSS) capacitor c=7.27978e-17
C103 (\1\:ExtVDD VSS) capacitor c=2.78233e-16
C104 (\9\:n35 VSS) capacitor c=6.21565e-17
C105 (\14\:qbint VSS) capacitor c=6.82817e-17
C106 (\6\:n35g VSS) capacitor c=9.41384e-17
C107 (\8\:SEb VSS) capacitor c=4.18037e-17
C108 (\4\:n35 VSS) capacitor c=6.39896e-17
C109 (\15\:VDD VSS) capacitor c=5.71768e-17
C110 (\5\:mout VSS) capacitor c=7.57577e-17
C111 (\3\:Db VSS) capacitor c=1.82398e-16
C112 (\17\:VDD VSS) capacitor c=3.6346e-17
C113 (\22\:VDD VSS) capacitor c=3.87362e-17
C114 (\15\:mout VSS) capacitor c=1.02067e-16
C115 (\20\:VDD VSS) capacitor c=6.72881e-17
C116 (\20\:CKNb VSS) capacitor c=2.73411e-17
C117 (\12\:CKNbb VSS) capacitor c=5.8186e-17
C118 (\13\:n20 VSS) capacitor c=6.163e-17
C119 (\5\:Db VSS) capacitor c=2.32229e-16
C120 (\10\:n20 VSS) capacitor c=6.35211e-17
C121 (\1\:Q VSS) capacitor c=3.36497e-17
C122 (\17\:n35 VSS) capacitor c=3.93544e-17
C123 (\11\:n35g VSS) capacitor c=2.63056e-17
C124 (\10\:RTb VSS) capacitor c=5.83059e-17
C125 (\12\:n35 VSS) capacitor c=6.37112e-17
C126 (\16\:qbint VSS) capacitor c=2.43869e-17
C127 (\9\:n35g VSS) capacitor c=8.056e-17
C128 (\4\:SEb VSS) capacitor c=3.83409e-17
C129 (\7\:n35 VSS) capacitor c=4.10332e-17
C130 (\11\:mout VSS) capacitor c=2.23063e-17
C131 (\13\:mout VSS) capacitor c=1.74521e-17
C132 (\16\:CKNb VSS) capacitor c=6.06223e-17
C133 (\15\:CKNbb VSS) capacitor c=5.95344e-17
C134 (\17\:n20 VSS) capacitor c=8.70381e-17
C135 (\7\:Db VSS) capacitor c=1.10759e-16
C136 (\8\:n20 VSS) capacitor c=5.97236e-17
C137 (VDD VSS) capacitor c=4.47907e-17
C138 (\2\:CKN VSS) capacitor c=3.47033e-17
C139 (\2\:D VSS) capacitor c=3.54463e-17
C140 (\2\:SE VSS) capacitor c=2.58121e-17
C141 (\4\:CKNbb VSS) capacitor c=1.50506e-16
C142 (\5\:CKNbb VSS) capacitor c=8.65692e-17
C143 (\2\:n35g VSS) capacitor c=2.90051e-17
C144 (\4\:RT VSS) capacitor c=4.60846e-17
C145 (\2\:qbint VSS) capacitor c=4.11428e-17
C146 (\7\:CKNb VSS) capacitor c=1.23198e-16
C147 (\8\:CKNb VSS) capacitor c=7.82348e-17
C148 (\4\:SN VSS) capacitor c=2.45202e-16
C149 (\12\:n20 VSS) capacitor c=4.64596e-17
C150 (\8\:qbint VSS) capacitor c=8.89785e-17
C151 (\14\:CKNb VSS) capacitor c=9.93287e-17
C152 (\15\:CKNb VSS) capacitor c=9.7321e-17
C153 (\15\:n20 VSS) capacitor c=5.22414e-17
C154 (\16\:n20 VSS) capacitor c=9.23136e-17
C155 (\11\:CKNbb VSS) capacitor c=5.50998e-17
C156 (\14\:CKNbb VSS) capacitor c=8.20651e-17
C157 (\5\:CKN VSS) capacitor c=4.00044e-18
C158 (\6\:CKN VSS) capacitor c=3.50068e-17
C159 (\18\:CKNb VSS) capacitor c=6.50609e-17
C160 (\19\:CKNb VSS) capacitor c=4.3158e-17
C161 (\10\:SN VSS) capacitor c=3.66203e-17
C162 (\11\:SN VSS) capacitor c=4.37567e-17
C163 (\7\:D VSS) capacitor c=4.70532e-17
C164 (\19\:n20 VSS) capacitor c=5.02893e-17
C165 (\20\:n20 VSS) capacitor c=5.63541e-17
C166 (\7\:mout VSS) capacitor c=7.80368e-17
C167 (\8\:mout VSS) capacitor c=3.68573e-17
C168 (\9\:mout VSS) capacitor c=1.17075e-16
C169 (\10\:mout VSS) capacitor c=8.75115e-17
C170 (\17\:mout VSS) capacitor c=7.18559e-17
C171 (\5\:SI VSS) capacitor c=3.47443e-17
C172 (\6\:SI VSS) capacitor c=2.61267e-18
C173 (\7\:SE VSS) capacitor c=3.97926e-17
C174 (\6\:SEb VSS) capacitor c=8.2462e-17
C175 (\7\:SEb VSS) capacitor c=6.79045e-17
C176 (\6\:n35 VSS) capacitor c=7.82284e-17
C177 (\17\:CKNbb VSS) capacitor c=3.92018e-17
C178 (\18\:CKNbb VSS) capacitor c=4.23649e-17
C179 (\8\:n35g VSS) capacitor c=3.46579e-17
C180 (\11\:n35 VSS) capacitor c=7.51701e-17
C181 (\12\:qbint VSS) capacitor c=8.80722e-17
C182 (\13\:qbint VSS) capacitor c=1.12231e-16
C183 (\13\:n35g VSS) capacitor c=9.96714e-17
C184 (\14\:n35g VSS) capacitor c=1.16309e-16
C185 (\5\:RTb VSS) capacitor c=4.95471e-17
C186 (\8\:RTb VSS) capacitor c=9.95036e-17
C187 (\9\:RTb VSS) capacitor c=9.15287e-17
C188 (\9\:RT VSS) capacitor c=1.10081e-16
C189 (\10\:RT VSS) capacitor c=1.18363e-16
C190 (\11\:RT VSS) capacitor c=4.01135e-17
C191 (\12\:SN VSS) capacitor c=8.31748e-17
C192 (\13\:SN VSS) capacitor c=7.95664e-17
C193 (\22\:CKNb VSS) capacitor c=1.29813e-16
C194 (\23\:CKNb VSS) capacitor c=1.34586e-16
C195 (\18\:qbint VSS) capacitor c=1.95257e-17
C196 (\19\:qbint VSS) capacitor c=3.00557e-17
C197 (\16\:n35 VSS) capacitor c=4.52132e-17
C198 (\3\:Q VSS) capacitor c=1.86139e-17
C199 (\3\:VDD VSS) capacitor c=2.57292e-17
C200 (\4\:VDD VSS) capacitor c=2.83405e-17
C201 (\6\:VDD VSS) capacitor c=2.03522e-16
C202 (\7\:VDD VSS) capacitor c=2.08673e-16
C203 (\8\:VDD VSS) capacitor c=2.39094e-17
C204 (\10\:VDD VSS) capacitor c=2.23051e-17
C205 (\19\:VDD VSS) capacitor c=1.66031e-17
C206 (\24\:VDD VSS) capacitor c=3.53949e-17
Rk75 (\3\:Q Q) resistor r=0.01828 c=0
Rk74 (\2\:Q \3\:Q) resistor r=0.208 c=0
Rk76 (\3\:Q \5\:Q) resistor r=0.3657 c=0
Rk19 (\5\:D D) resistor r=0.007198 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01668 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007198 c=0
Rk95 (\2\:VSS \3\:VSS) resistor r=0.1014 c=0
Rk96 (\3\:VSS \4\:VSS) resistor r=0.1955 c=0
Rk97 (\4\:VSS \5\:VSS) resistor r=0.7604 c=0
Rk98 (\5\:VSS \6\:VSS) resistor r=0.03202 c=0
Rk100 (\7\:VSS VSS) resistor r=0.121 c=0
Rk99 (\6\:VSS \7\:VSS) resistor r=0.1757 c=0
Rk101 (VSS \8\:VSS) resistor r=0.5204 c=0
Rk102 (\8\:VSS \9\:VSS) resistor r=0.3068 c=0
Rk104 (\10\:VSS VSS) resistor r=0.1212 c=0
Rk103 (\9\:VSS \10\:VSS) resistor r=0.06422 c=0
Rk105 (VSS \12\:VSS) resistor r=0.3116 c=0
Rk106 (\3\:VSS \14\:VSS) resistor r=0.2602 c=0
Rk107 (\5\:VSS \16\:VSS) resistor r=0.189 c=0
Rk108 (\7\:VSS \18\:VSS) resistor r=0.194 c=0
Rk109 (\8\:VSS \20\:VSS) resistor r=0.253 c=0
Rk110 (\9\:VSS \22\:VSS) resistor r=0.2486 c=0
Rk111 (\24\:VSS \25\:VSS) resistor r=0.1807 c=0
Rk112 (\25\:VSS \26\:VSS) resistor r=0.364 c=0
Rk113 (\26\:VSS \27\:VSS) resistor r=0.3668 c=0
Rk115 (\28\:VSS VSS) resistor r=0.0493 c=0
Rk114 (\27\:VSS \28\:VSS) resistor r=0.3269 c=0
Rk117 (\29\:VSS VSS) resistor r=0.1212 c=0
Rk116 (VSS \29\:VSS) resistor r=0.8922 c=0
Rk118 (\25\:VSS \31\:VSS) resistor r=0.2345 c=0
Rk119 (\27\:VSS \33\:VSS) resistor r=0.2432 c=0
Rk120 (VSS \35\:VSS) resistor r=0.3078 c=0
Rk53 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk51 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk54 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk55 (ExtVDD \6\:ExtVDD) resistor r=0.1495 c=0
Rk34 (SI \4\:SI) resistor r=0.01021 c=0
Rk35 (\5\:SI \4\:SI) resistor r=0.001848 c=0
Rk36 (SI \6\:SI) resistor r=0.001848 c=0
Rk37 (\5\:SI \6\:SI) resistor r=0.01021 c=0
Rk38 (\7\:SI SI) resistor r=0.001848 c=0
Rk39 (\6\:SI \7\:SI) resistor r=0.009883 c=0
Rk66 (RT \9\:RT) resistor r=0.1837 c=0
Rk67 (\9\:RT \10\:RT) resistor r=0.6456 c=0
Rk68 (RT \11\:RT) resistor r=0.01478 c=0
Rk10 (CKN \5\:CKN) resistor r=0.001943 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.01016 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.004796 c=0
Rk17 (\10\:SN SN) resistor r=0.02545 c=0
Rk18 (SN \11\:SN) resistor r=0.2163 c=0
Rk69 (\12\:SN \13\:SN) resistor r=0.5353 c=0
Rk94 (VDD VDD) resistor r=0.2354 c=0
Rk78 (\2\:VDD \3\:VDD) resistor r=0.3366 c=0
Rk79 (\3\:VDD \4\:VDD) resistor r=0.1656 c=0
Rk80 (\4\:VDD \6\:VDD) resistor r=0.1163 c=0
Rk81 (\6\:VDD \7\:VDD) resistor r=1.5235 c=0
Rk82 (\7\:VDD \8\:VDD) resistor r=0.23 c=0
Rk83 (\8\:VDD \10\:VDD) resistor r=0.1094 c=0
Rk84 (\3\:VDD \12\:VDD) resistor r=0.3561 c=0
Rk85 (\4\:VDD \14\:VDD) resistor r=0.301 c=0
Rk86 (\7\:VDD \16\:VDD) resistor r=0.3658 c=0
Rk87 (\8\:VDD \18\:VDD) resistor r=0.2067 c=0
Rk88 (\10\:VDD \19\:VDD) resistor r=0.09396 c=0
Rk89 (\19\:VDD \21\:VDD) resistor r=0.2286 c=0
Rk90 (\10\:VDD \23\:VDD) resistor r=0.2347 c=0
Rk93 (\24\:VDD VDD) resistor r=0.1953 c=0
Rk91 (\19\:VDD \24\:VDD) resistor r=0.07642 c=0
Rk92 (\24\:VDD \25\:VDD) resistor r=0.2186 c=0
Rk40 (SE \7\:SE) resistor r=0.05519 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5425 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2539 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3399 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2292 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4959 c=0
Rk22 (\19\:n20 \20\:n20) resistor r=0.2604 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7504 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3243 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.183 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1863 c=0
Rk70 (\22\:CKNb \23\:CKNb) resistor r=0.8238 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.6015 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3501 c=0
Rk28 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk29 (\9\:mout \10\:mout) resistor r=0.3407 c=0
Rk30 (\7\:mout \12\:mout) resistor r=0.1277 c=0
Rk31 (\8\:mout \14\:mout) resistor r=0.09184 c=0
Rk32 (\9\:mout \16\:mout) resistor r=0.6351 c=0
Rk33 (\10\:mout \17\:mout) resistor r=0.4247 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.1419 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4204 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.236 c=0
Rk46 (\17\:CKNbb \18\:CKNbb) resistor r=0.3711 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.2167 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.3464 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.3048 c=0
Rk47 (\7\:n35g \8\:n35g) resistor r=0.273 c=0
Rk48 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk59 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk60 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk61 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk56 (\12\:qbint \13\:qbint) resistor r=0.494 c=0
Rk57 (\13\:qbint \15\:qbint) resistor r=0.5666 c=0
Rk58 (\13\:qbint \17\:qbint) resistor r=0.1462 c=0
Rk71 (\18\:qbint \19\:qbint) resistor r=0.2116 c=0
Rk62 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk63 (\7\:RTb \8\:RTb) resistor r=0.4161 c=0
Rk64 (\8\:RTb \9\:RTb) resistor r=0.6878 c=0
Rk65 (\8\:RTb \11\:RTb) resistor r=0.3063 c=0
Rk44 (\5\:n35 \6\:n35) resistor r=0.4094 c=0
Rk45 (\6\:n35 \8\:n35) resistor r=0.29 c=0
Rk49 (\10\:n35 \11\:n35) resistor r=0.4005 c=0
Rk50 (\11\:n35 \13\:n35) resistor r=0.3296 c=0
Rk72 (\15\:n35 \16\:n35) resistor r=0.3034 c=0
Rk73 (\16\:n35 \18\:n35) resistor r=0.2669 c=0
Rk23 (\2\:Db \4\:Db) resistor r=0.635 c=0
Rk24 (\4\:Db \6\:Db) resistor r=1.316 c=0
Rk25 (\6\:Db \8\:Db) resistor r=0.6314 c=0
Rk77 (\2\:n11 \4\:n11) resistor r=0.6522 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl52 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl39 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl42 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl41 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl40 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl65 (\7\:SN \8\:SN) resistor r=366.394 c=0
Rl66 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl12 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl55 (\4\:SN \6\:SN) resistor r=106.74 c=0
Rl53 (\3\:SN \4\:SN) resistor r=1145.23 c=0
Rl54 (\4\:SN \5\:SN) resistor r=8.9604 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=56.7001 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=98.0144 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=249.192 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl59 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl3 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl47 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl50 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl51 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl49 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl48 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl58 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl31 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl28 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl32 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl30 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl29 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl35 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl33 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl34 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl60 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl64 (\10\:qbint \11\:qbint) resistor r=343.229 c=0
Rl46 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl43 (qbint \2\:qbint) resistor r=112.732 c=0
Rl45 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl44 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl61 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl63 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl62 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl37 (RTb \2\:RTb) resistor r=112.412 c=0
Rl38 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl56 (n35 \2\:n35) resistor r=508.667 c=0
Rl57 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz18 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz28 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz29 (\34\:VSS \35\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry20 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry31 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry32 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry33 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry34 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry35 (\23\:VSS \24\:VSS) resistor r=15.5 c=0
Ry36 (\23\:VSS \26\:VSS) resistor r=8.8571 c=0
Ry37 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry38 (\23\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry24 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry25 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry26 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry28 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry29 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\15\:mout \16\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry19 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry21 (n11 \2\:n11) resistor r=62 c=0
Ry22 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\5\:SN \10\:SN) resistor r=45 c=0
Rx11 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\6\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \17\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx36 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx37 (qbint \19\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0118 \6\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \7\:n20 net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net0119 \11\:qbint net0117 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0117 \8\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.05e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=3.45e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp32 (\15\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=5.45048 \
        scb=0.00126552 scc=2.52508e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp52 (n11 \10\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\4\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0167 \
        scb=0.00981108 scc=0.000312648 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
ends SRDFFNSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:00:27 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSRX1 CKN D ExtVDD Q QN RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (QN VSS) capacitor c=1.85273e-17
C2 (VDD VSS) capacitor c=7.82628e-16
C3 (Q VSS) capacitor c=6.71226e-17
C4 (SE VSS) capacitor c=3.3841e-17
C5 (D VSS) capacitor c=4.00569e-17
C6 (ExtVDD VSS) capacitor c=2.42466e-16
C7 (CKN VSS) capacitor c=4.35855e-17
C8 (RN VSS) capacitor c=7.43973e-17
C9 (RT VSS) capacitor c=2.37203e-17
C10 (SI VSS) capacitor c=8.71604e-17
C11 (SN VSS) capacitor c=3.96554e-17
C12 (n20 VSS) capacitor c=3.89425e-17
C13 (CKNb VSS) capacitor c=4.68243e-17
C14 (mout VSS) capacitor c=5.41376e-17
C15 (RNb VSS) capacitor c=3.91539e-17
C16 (CKNbb VSS) capacitor c=3.22863e-17
C17 (SEb VSS) capacitor c=7.77632e-17
C18 (n35g VSS) capacitor c=1.7772e-17
C19 (qbint VSS) capacitor c=4.54322e-17
C20 (RTb VSS) capacitor c=5.17974e-17
C21 (net573 VSS) capacitor c=2.25772e-17
C22 (n35 VSS) capacitor c=1.71935e-16
C23 (Db VSS) capacitor c=1.02053e-16
C24 (n11 VSS) capacitor c=8.43539e-17
C25 (n8 VSS) capacitor c=7.92568e-17
C26 (n10 VSS) capacitor c=8.42863e-17
C27 (n4 VSS) capacitor c=8.69277e-17
C28 (n1 VSS) capacitor c=1.02126e-18
C29 (\7\:SN VSS) capacitor c=7.05736e-17
C30 (\7\:qbint VSS) capacitor c=3.43295e-17
C31 (\11\:qbint VSS) capacitor c=1.41633e-16
C32 (\4\:RNb VSS) capacitor c=4.03735e-16
C33 (\13\:qbint VSS) capacitor c=4.40896e-17
C34 (\3\:net573 VSS) capacitor c=5.86653e-17
C35 (\12\:CKNb VSS) capacitor c=5.76361e-17
C36 (\4\:RTb VSS) capacitor c=9.88373e-17
C37 (\6\:RT VSS) capacitor c=2.20615e-17
C38 (\4\:qbint VSS) capacitor c=5.36612e-17
C39 (\3\:n35g VSS) capacitor c=5.22477e-17
C40 (\5\:RT VSS) capacitor c=8.2554e-17
C41 (\3\:SE VSS) capacitor c=7.72951e-17
C42 (\7\:CKNbb VSS) capacitor c=3.84202e-17
C43 (\3\:SI VSS) capacitor c=9.74944e-17
C44 (\9\:RNb VSS) capacitor c=6.01657e-17
C45 (\4\:SE VSS) capacitor c=1.2213e-16
C46 (\3\:n20 VSS) capacitor c=4.73671e-17
C47 (\4\:D VSS) capacitor c=6.87696e-17
C48 (\1\:SN VSS) capacitor c=3.03254e-17
C49 (\4\:CKN VSS) capacitor c=5.61144e-17
C50 (\4\:CKNb VSS) capacitor c=4.42171e-17
C51 (\8\:CKNbb VSS) capacitor c=8.24748e-17
C52 (\3\:CKNb VSS) capacitor c=1.09064e-16
C53 (\1\:RN VSS) capacitor c=4.24586e-17
C54 (\8\:SN VSS) capacitor c=1.32242e-16
C55 (\6\:qbint VSS) capacitor c=3.80033e-17
C56 (\12\:qbint VSS) capacitor c=8.06262e-17
C57 (\3\:RNb VSS) capacitor c=6.80787e-17
C58 (\14\:qbint VSS) capacitor c=4.6006e-17
C59 (\4\:net573 VSS) capacitor c=3.67833e-17
C60 (\9\:CKNbb VSS) capacitor c=2.22471e-16
C61 (\8\:RT VSS) capacitor c=1.21318e-16
C62 (\2\:RT VSS) capacitor c=6.21972e-17
C63 (\5\:qbint VSS) capacitor c=3.89021e-17
C64 (\5\:n35g VSS) capacitor c=3.28666e-17
C65 (\2\:RTb VSS) capacitor c=4.66333e-17
C66 (\5\:SE VSS) capacitor c=5.7887e-17
C67 (\6\:CKNb VSS) capacitor c=3.24964e-17
C68 (\1\:SI VSS) capacitor c=4.91308e-17
C69 (\6\:SE VSS) capacitor c=8.62004e-17
C70 (\3\:SEb VSS) capacitor c=6.60115e-17
C71 (\1\:D VSS) capacitor c=4.95122e-17
C72 (\6\:n20 VSS) capacitor c=6.12355e-17
C73 (\6\:SN VSS) capacitor c=4.59773e-17
C74 (\1\:CKN VSS) capacitor c=2.85189e-17
C75 (\3\:mout VSS) capacitor c=4.57969e-17
C76 (\11\:CKNb VSS) capacitor c=4.92133e-17
C77 (\4\:RN VSS) capacitor c=3.69343e-17
C78 (\10\:qbint VSS) capacitor c=8.56302e-17
C79 (\13\:CKNb VSS) capacitor c=7.94667e-17
C80 (\3\:SN VSS) capacitor c=3.75346e-16
C81 (\9\:SN VSS) capacitor c=9.14336e-17
C82 (\7\:RT VSS) capacitor c=1.53093e-16
C83 (\10\:CKNb VSS) capacitor c=1.67463e-16
C84 (\3\:RT VSS) capacitor c=5.78489e-17
C85 (\1\:RT VSS) capacitor c=5.2908e-17
C86 (\3\:RTb VSS) capacitor c=7.59476e-17
C87 (\3\:qbint VSS) capacitor c=4.44018e-17
C88 (\2\:n35 VSS) capacitor c=2.52896e-16
C89 (\4\:n35g VSS) capacitor c=6.71758e-17
C90 (\3\:CKNbb VSS) capacitor c=5.53018e-17
C91 (\10\:CKNbb VSS) capacitor c=2.1752e-16
C92 (\3\:n35 VSS) capacitor c=1.16124e-16
C93 (\1\:SE VSS) capacitor c=2.37301e-17
C94 (\2\:SI VSS) capacitor c=7.7714e-17
C95 (\2\:RNb VSS) capacitor c=3.31472e-17
C96 (\8\:RNb VSS) capacitor c=1.24508e-17
C97 (\2\:SEb VSS) capacitor c=7.77825e-17
C98 (\7\:n20 VSS) capacitor c=5.31162e-17
C99 (\4\:n20 VSS) capacitor c=1.14989e-16
C100 (\3\:D VSS) capacitor c=1.38488e-17
C101 (\2\:SN VSS) capacitor c=4.19768e-17
C102 (\5\:SN VSS) capacitor c=2.64542e-17
C103 (\3\:CKN VSS) capacitor c=2.3447e-17
C104 (\2\:mout VSS) capacitor c=4.65098e-17
C105 (\4\:mout VSS) capacitor c=3.16539e-17
C106 (\2\:CKNb VSS) capacitor c=7.96153e-17
C107 (\6\:CKNbb VSS) capacitor c=3.65314e-17
C108 (\5\:n20 VSS) capacitor c=1.1488e-16
C109 (\2\:CKNbb VSS) capacitor c=5.80807e-17
C110 (\5\:CKNb VSS) capacitor c=7.9745e-17
C111 (\9\:CKNb VSS) capacitor c=2.68274e-17
C112 (\7\:RNb VSS) capacitor c=1.32993e-16
C113 (\2\:n20 VSS) capacitor c=4.56024e-17
C114 (\3\:RN VSS) capacitor c=4.74049e-17
C115 (\1\:VDD VSS) capacitor c=2.99193e-17
C116 (\12\:VDD VSS) capacitor c=4.47012e-17
C117 (\3\:Q VSS) capacitor c=6.8661e-17
C118 (\14\:VDD VSS) capacitor c=4.89178e-17
C119 (\9\:net573 VSS) capacitor c=5.67387e-17
C120 (\16\:VDD VSS) capacitor c=7.94605e-17
C121 (\3\:n11 VSS) capacitor c=9.91812e-17
C122 (\4\:QN VSS) capacitor c=6.83589e-17
C123 (\14\:n35 VSS) capacitor c=5.34268e-17
C124 (\15\:n35g VSS) capacitor c=5.57509e-17
C125 (\6\:RTb VSS) capacitor c=7.20069e-17
C126 (\1\:ExtVDD VSS) capacitor c=2.78003e-16
C127 (\9\:n35 VSS) capacitor c=6.16151e-17
C128 (\17\:qbint VSS) capacitor c=6.80388e-17
C129 (\6\:n35g VSS) capacitor c=9.38837e-17
C130 (\8\:SEb VSS) capacitor c=4.91792e-17
C131 (\4\:n35 VSS) capacitor c=7.2232e-17
C132 (\18\:VDD VSS) capacitor c=5.87264e-17
C133 (\5\:mout VSS) capacitor c=1.33608e-16
C134 (\20\:VDD VSS) capacitor c=4.3269e-17
C135 (\3\:Db VSS) capacitor c=1.83582e-16
C136 (\19\:mout VSS) capacitor c=3.68247e-17
C137 (\25\:VDD VSS) capacitor c=3.53113e-17
C138 (\16\:mout VSS) capacitor c=4.36959e-17
C139 (\20\:CKNb VSS) capacitor c=2.93335e-17
C140 (\23\:VDD VSS) capacitor c=4.82067e-17
C141 (\12\:CKNbb VSS) capacitor c=5.93105e-17
C142 (\13\:n20 VSS) capacitor c=6.21861e-17
C143 (\5\:Db VSS) capacitor c=2.28932e-16
C144 (\10\:RNb VSS) capacitor c=5.0321e-17
C145 (\10\:n20 VSS) capacitor c=6.32549e-17
C146 (\27\:VDD VSS) capacitor c=3.98447e-17
C147 (\1\:Q VSS) capacitor c=5.28055e-17
C148 (\5\:net573 VSS) capacitor c=4.29385e-17
C149 (\3\:n8 VSS) capacitor c=8.08245e-17
C150 (\3\:n10 VSS) capacitor c=8.12131e-17
C151 (\1\:QN VSS) capacitor c=3.92176e-17
C152 (\17\:n35 VSS) capacitor c=4.81229e-17
C153 (\11\:n35g VSS) capacitor c=2.95879e-17
C154 (\10\:RTb VSS) capacitor c=5.7983e-17
C155 (\12\:n35 VSS) capacitor c=6.33278e-17
C156 (\19\:qbint VSS) capacitor c=2.42602e-17
C157 (\9\:n35g VSS) capacitor c=7.99627e-17
C158 (\4\:SEb VSS) capacitor c=3.81809e-17
C159 (\7\:n35 VSS) capacitor c=4.88653e-17
C160 (\11\:mout VSS) capacitor c=3.70935e-17
C161 (\13\:mout VSS) capacitor c=3.8164e-17
C162 (\3\:n4 VSS) capacitor c=1.00022e-16
C163 (\16\:CKNb VSS) capacitor c=6.31727e-17
C164 (\15\:CKNbb VSS) capacitor c=5.92313e-17
C165 (\17\:n20 VSS) capacitor c=8.56888e-17
C166 (\7\:Db VSS) capacitor c=1.10127e-16
C167 (\13\:RNb VSS) capacitor c=7.3362e-17
C168 (\8\:n20 VSS) capacitor c=5.94711e-17
C169 (VDD VSS) capacitor c=7.16216e-17
C170 (\2\:CKN VSS) capacitor c=3.31216e-17
C171 (\2\:D VSS) capacitor c=3.56137e-17
C172 (\2\:SE VSS) capacitor c=2.63409e-17
C173 (\4\:CKNbb VSS) capacitor c=1.54262e-16
C174 (\5\:CKNbb VSS) capacitor c=8.60489e-17
C175 (\2\:n35g VSS) capacitor c=2.90531e-17
C176 (\4\:RT VSS) capacitor c=7.42727e-17
C177 (\2\:qbint VSS) capacitor c=4.13305e-17
C178 (\7\:CKNb VSS) capacitor c=1.37045e-16
C179 (\8\:CKNb VSS) capacitor c=7.33368e-17
C180 (\4\:SN VSS) capacitor c=3.61036e-16
C181 (\2\:net573 VSS) capacitor c=1.52656e-17
C182 (\12\:n20 VSS) capacitor c=4.63155e-17
C183 (\5\:RNb VSS) capacitor c=3.89503e-16
C184 (\6\:RNb VSS) capacitor c=1.80962e-16
C185 (\12\:RNb VSS) capacitor c=1.1597e-16
C186 (\14\:CKNb VSS) capacitor c=1.55351e-16
C187 (\15\:CKNb VSS) capacitor c=1.3771e-16
C188 (\8\:qbint VSS) capacitor c=5.10295e-17
C189 (\9\:qbint VSS) capacitor c=7.71449e-17
C190 (\15\:n20 VSS) capacitor c=7.52847e-17
C191 (\16\:n20 VSS) capacitor c=9.23154e-17
C192 (\11\:CKNbb VSS) capacitor c=5.35039e-17
C193 (\14\:CKNbb VSS) capacitor c=7.93765e-17
C194 (\5\:CKN VSS) capacitor c=3.45146e-18
C195 (\6\:CKN VSS) capacitor c=3.41317e-17
C196 (\18\:CKNb VSS) capacitor c=6.51076e-17
C197 (\19\:CKNb VSS) capacitor c=3.73972e-17
C198 (\10\:SN VSS) capacitor c=4.4102e-17
C199 (\11\:SN VSS) capacitor c=4.55806e-17
C200 (\7\:D VSS) capacitor c=4.36106e-17
C201 (\19\:n20 VSS) capacitor c=8.0144e-17
C202 (\20\:n20 VSS) capacitor c=8.09807e-17
C203 (\15\:RNb VSS) capacitor c=7.07283e-17
C204 (\16\:RNb VSS) capacitor c=8.29616e-17
C205 (\7\:SE VSS) capacitor c=5.08663e-17
C206 (\7\:mout VSS) capacitor c=1.55818e-16
C207 (\8\:mout VSS) capacitor c=5.28652e-17
C208 (\9\:mout VSS) capacitor c=1.02948e-16
C209 (\10\:mout VSS) capacitor c=8.85809e-17
C210 (\15\:mout VSS) capacitor c=6.04063e-17
C211 (\18\:mout VSS) capacitor c=7.23255e-17
C212 (\6\:SEb VSS) capacitor c=8.38053e-17
C213 (\7\:SEb VSS) capacitor c=6.33247e-17
C214 (\6\:n35 VSS) capacitor c=1.06598e-16
C215 (\17\:CKNbb VSS) capacitor c=3.86002e-17
C216 (\18\:CKNbb VSS) capacitor c=4.1645e-17
C217 (\8\:n35g VSS) capacitor c=3.50411e-17
C218 (\11\:n35 VSS) capacitor c=7.53442e-17
C219 (\15\:qbint VSS) capacitor c=8.75403e-17
C220 (\16\:qbint VSS) capacitor c=1.11665e-16
C221 (\13\:n35g VSS) capacitor c=1.02151e-16
C222 (\14\:n35g VSS) capacitor c=1.15714e-16
C223 (\5\:RTb VSS) capacitor c=4.91988e-17
C224 (\8\:RTb VSS) capacitor c=1.00362e-16
C225 (\9\:RTb VSS) capacitor c=9.12712e-17
C226 (\9\:RT VSS) capacitor c=1.10625e-16
C227 (\10\:RT VSS) capacitor c=1.17695e-16
C228 (\11\:RT VSS) capacitor c=3.8089e-17
C229 (\12\:SN VSS) capacitor c=8.24211e-17
C230 (\13\:SN VSS) capacitor c=8.01901e-17
C231 (\22\:CKNb VSS) capacitor c=1.3101e-16
C232 (\23\:CKNb VSS) capacitor c=1.33492e-16
C233 (\21\:qbint VSS) capacitor c=2.4274e-17
C234 (\22\:qbint VSS) capacitor c=2.9991e-17
C235 (\3\:QN VSS) capacitor c=3.14959e-17
C236 (\16\:n35 VSS) capacitor c=5.05282e-17
C237 (\7\:net573 VSS) capacitor c=4.93937e-17
C238 (\8\:net573 VSS) capacitor c=3.49056e-17
C239 (\3\:VDD VSS) capacitor c=3.04314e-17
C240 (\4\:VDD VSS) capacitor c=3.03611e-17
C241 (\6\:VDD VSS) capacitor c=9.94689e-18
C242 (\7\:VDD VSS) capacitor c=2.1959e-16
C243 (\8\:VDD VSS) capacitor c=2.02712e-16
C244 (\9\:VDD VSS) capacitor c=2.83639e-17
C245 (\11\:VDD VSS) capacitor c=5.16114e-17
C246 (\22\:VDD VSS) capacitor c=4.90843e-17
Rk76 (\3\:QN QN) resistor r=0.03438 c=0
Rk75 (\2\:QN \3\:QN) resistor r=0.1966 c=0
Rk77 (\3\:QN \5\:QN) resistor r=0.3483 c=0
Rk116 (VDD VDD) resistor r=0.2375 c=0
Rk100 (\2\:VDD \3\:VDD) resistor r=0.3396 c=0
Rk101 (\3\:VDD \4\:VDD) resistor r=0.2191 c=0
Rk102 (\4\:VDD \6\:VDD) resistor r=0.06715 c=0
Rk103 (\6\:VDD \7\:VDD) resistor r=0.05218 c=0
Rk104 (\7\:VDD \8\:VDD) resistor r=1.531 c=0
Rk105 (\8\:VDD \9\:VDD) resistor r=0.1193 c=0
Rk106 (\9\:VDD \11\:VDD) resistor r=0.2224 c=0
Rk107 (\3\:VDD \13\:VDD) resistor r=0.36 c=0
Rk108 (\4\:VDD \15\:VDD) resistor r=0.2957 c=0
Rk109 (\7\:VDD \17\:VDD) resistor r=0.3778 c=0
Rk110 (\8\:VDD \19\:VDD) resistor r=0.3698 c=0
Rk111 (\9\:VDD \21\:VDD) resistor r=0.2036 c=0
Rk115 (\22\:VDD VDD) resistor r=0.1966 c=0
Rk112 (\11\:VDD \22\:VDD) resistor r=0.1719 c=0
Rk113 (\22\:VDD \24\:VDD) resistor r=0.209 c=0
Rk114 (\11\:VDD \26\:VDD) resistor r=0.2372 c=0
Rk117 (VDD \28\:VDD) resistor r=0.3813 c=0
Rk84 (\2\:Q Q) resistor r=0.1739 c=0
Rk85 (Q \4\:Q) resistor r=0.3037 c=0
Rk33 (SE \7\:SE) resistor r=0.04878 c=0
Rk22 (\5\:D D) resistor r=0.007236 c=0
Rk24 (\5\:D \7\:D) resistor r=0.0211 c=0
Rk23 (\6\:D \7\:D) resistor r=0.007236 c=0
Rk56 (ExtVDD ExtVDD) resistor r=0.002071 c=0
Rk54 (\2\:ExtVDD ExtVDD) resistor r=0.02225 c=0
Rk57 (ExtVDD \5\:ExtVDD) resistor r=0.02024 c=0
Rk58 (ExtVDD \6\:ExtVDD) resistor r=0.1503 c=0
Rk88 (\2\:VSS \3\:VSS) resistor r=0.03223 c=0
Rk89 (\3\:VSS \4\:VSS) resistor r=0.5161 c=0
Rk90 (\4\:VSS \5\:VSS) resistor r=0.5189 c=0
Rk92 (\6\:VSS VSS) resistor r=0.04963 c=0
Rk91 (\5\:VSS \6\:VSS) resistor r=0.329 c=0
Rk94 (\7\:VSS VSS) resistor r=0.122 c=0
Rk93 (VSS \7\:VSS) resistor r=0.8981 c=0
Rk95 (VSS \8\:VSS) resistor r=0.01751 c=0
Rk96 (\8\:VSS \10\:VSS) resistor r=0.6675 c=0
Rk97 (\3\:VSS \12\:VSS) resistor r=0.251 c=0
Rk98 (\5\:VSS \14\:VSS) resistor r=0.2459 c=0
Rk99 (\8\:VSS \16\:VSS) resistor r=0.2535 c=0
Rk118 (\18\:VSS \20\:VSS) resistor r=0.3643 c=0
Rk119 (\20\:VSS \21\:VSS) resistor r=0.2392 c=0
Rk120 (\21\:VSS \22\:VSS) resistor r=0.05966 c=0
Rk121 (\22\:VSS \23\:VSS) resistor r=0.6158 c=0
Rk122 (\23\:VSS \24\:VSS) resistor r=0.03223 c=0
Rk124 (\25\:VSS VSS) resistor r=0.1218 c=0
Rk123 (\24\:VSS \25\:VSS) resistor r=0.1769 c=0
Rk125 (VSS \26\:VSS) resistor r=0.5238 c=0
Rk126 (\26\:VSS \27\:VSS) resistor r=0.3089 c=0
Rk128 (\28\:VSS VSS) resistor r=0.122 c=0
Rk127 (\27\:VSS \28\:VSS) resistor r=0.06465 c=0
Rk129 (VSS \30\:VSS) resistor r=0.3145 c=0
Rk130 (\21\:VSS \32\:VSS) resistor r=0.2694 c=0
Rk131 (\23\:VSS \34\:VSS) resistor r=0.1911 c=0
Rk132 (\25\:VSS \36\:VSS) resistor r=0.1962 c=0
Rk133 (\26\:VSS \38\:VSS) resistor r=0.2558 c=0
Rk134 (\27\:VSS \40\:VSS) resistor r=0.2514 c=0
Rk13 (CKN \5\:CKN) resistor r=0.001729 c=0
Rk16 (\5\:CKN \6\:CKN) resistor r=0.008633 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.003644 c=0
Rk1 (\5\:RN RN) resistor r=0.007312 c=0
Rk69 (RT \9\:RT) resistor r=0.1853 c=0
Rk70 (\9\:RT \10\:RT) resistor r=0.6525 c=0
Rk71 (RT \11\:RT) resistor r=0.01486 c=0
Rk32 (\4\:SI SI) resistor r=0.001105 c=0
Rk20 (SN \10\:SN) resistor r=0.008882 c=0
Rk21 (SN \11\:SN) resistor r=0.2636 c=0
Rk72 (\12\:SN \13\:SN) resistor r=0.541 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5483 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2565 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3488 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2316 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.5012 c=0
Rk28 (\19\:n20 \20\:n20) resistor r=0.4658 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8571 c=0
Rk17 (\17\:CKNb \18\:CKNb) resistor r=0.3475 c=0
Rk18 (\18\:CKNb \19\:CKNb) resistor r=0.1811 c=0
Rk19 (\18\:CKNb \21\:CKNb) resistor r=0.1685 c=0
Rk73 (\22\:CKNb \23\:CKNb) resistor r=0.8325 c=0
Rk34 (\6\:mout \7\:mout) resistor r=0.7692 c=0
Rk35 (\7\:mout \8\:mout) resistor r=0.3559 c=0
Rk36 (\8\:mout \9\:mout) resistor r=0.1726 c=0
Rk37 (\9\:mout \10\:mout) resistor r=0.3464 c=0
Rk38 (\7\:mout \12\:mout) resistor r=0.1242 c=0
Rk39 (\8\:mout \14\:mout) resistor r=0.1007 c=0
Rk40 (\9\:mout \15\:mout) resistor r=0.5295 c=0
Rk41 (\15\:mout \17\:mout) resistor r=0.04502 c=0
Rk42 (\10\:mout \18\:mout) resistor r=0.4291 c=0
Rk43 (\15\:mout \20\:mout) resistor r=0.03478 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.165 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3842 c=0
Rk30 (\15\:RNb \16\:RNb) resistor r=0.3498 c=0
Rk10 (\11\:CKNbb \13\:CKNbb) resistor r=0.1433 c=0
Rk11 (\13\:CKNbb \14\:CKNbb) resistor r=0.4267 c=0
Rk12 (\14\:CKNbb \16\:CKNbb) resistor r=0.2384 c=0
Rk49 (\17\:CKNbb \18\:CKNbb) resistor r=0.375 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.219 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.3481 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.3125 c=0
Rk50 (\7\:n35g \8\:n35g) resistor r=0.2759 c=0
Rk51 (\7\:n35g \10\:n35g) resistor r=0.6982 c=0
Rk62 (\12\:n35g \13\:n35g) resistor r=0.2453 c=0
Rk63 (\13\:n35g \14\:n35g) resistor r=0.5711 c=0
Rk64 (\13\:n35g \16\:n35g) resistor r=0.4361 c=0
Rk59 (\15\:qbint \16\:qbint) resistor r=0.4995 c=0
Rk60 (\16\:qbint \18\:qbint) resistor r=0.5726 c=0
Rk61 (\16\:qbint \20\:qbint) resistor r=0.1477 c=0
Rk74 (\21\:qbint \22\:qbint) resistor r=0.2138 c=0
Rk65 (\5\:RTb \7\:RTb) resistor r=0.2183 c=0
Rk66 (\7\:RTb \8\:RTb) resistor r=0.4206 c=0
Rk67 (\8\:RTb \9\:RTb) resistor r=0.6954 c=0
Rk68 (\8\:RTb \11\:RTb) resistor r=0.3096 c=0
Rk80 (\6\:net573 \7\:net573) resistor r=0.2391 c=0
Rk81 (\7\:net573 \8\:net573) resistor r=0.1666 c=0
Rk82 (\7\:net573 \10\:net573) resistor r=0.2949 c=0
Rk47 (\5\:n35 \6\:n35) resistor r=0.4331 c=0
Rk48 (\6\:n35 \8\:n35) resistor r=0.3056 c=0
Rk52 (\10\:n35 \11\:n35) resistor r=0.4048 c=0
Rk53 (\11\:n35 \13\:n35) resistor r=0.3331 c=0
Rk78 (\15\:n35 \16\:n35) resistor r=0.3067 c=0
Rk79 (\16\:n35 \18\:n35) resistor r=0.2902 c=0
Rk25 (\2\:Db \4\:Db) resistor r=0.6418 c=0
Rk26 (\4\:Db \6\:Db) resistor r=1.3687 c=0
Rk27 (\6\:Db \8\:Db) resistor r=0.6405 c=0
Rk86 (\2\:n11 \4\:n11) resistor r=0.7206 c=0
Rk87 (\2\:n8 \4\:n8) resistor r=0.5353 c=0
Rk83 (\2\:n10 \4\:n10) resistor r=0.6316 c=0
Rk29 (\2\:n4 \4\:n4) resistor r=0.5575 c=0
Rl29 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl31 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl28 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl30 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl27 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\2\:D \4\:D) resistor r=115.099 c=0
Rl16 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl17 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl43 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl46 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl45 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl44 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl26 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl25 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl81 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl82 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl15 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl59 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl57 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl58 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl21 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl19 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl20 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl6 (CKNb \2\:CKNb) resistor r=132.176 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=51.7181 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl51 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl54 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl55 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl53 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl52 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl67 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl24 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl68 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl71 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl72 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl70 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl69 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl63 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl35 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl32 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl36 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl34 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl33 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl22 (SEb \2\:SEb) resistor r=101.718 c=0
Rl23 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl39 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl37 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl38 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl40 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl73 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl78 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl80 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl50 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl47 (qbint \2\:qbint) resistor r=112.732 c=0
Rl49 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl48 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl74 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl77 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl79 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl76 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl75 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl41 (RTb \2\:RTb) resistor r=112.412 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl64 (net573 \2\:net573) resistor r=3.1216 c=0
Rl65 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl66 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl60 (n35 \2\:n35) resistor r=508.667 c=0
Rl61 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz25 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz28 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz29 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz30 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz31 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz34 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz35 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz36 (\31\:VSS \32\:VSS) resistor r=37.5 c=0
Rz37 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz38 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz39 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz40 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz22 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz21 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz26 (n8 \2\:n8) resistor r=75 c=0
Rz27 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz23 (n10 \2\:n10) resistor r=75 c=0
Rz24 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry21 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry31 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry32 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry33 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry34 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry35 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry36 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry37 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry38 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry39 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry27 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry28 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry30 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry41 (\19\:VSS \22\:VSS) resistor r=62 c=0
Ry42 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry43 (\19\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry23 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry22 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry25 (n11 \2\:n11) resistor r=62 c=0
Ry26 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx20 (\1\:SE \7\:SE) resistor r=45 c=0
Rx14 (\3\:D \6\:D) resistor r=45 c=0
Rx10 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx33 (\3\:RT \9\:RT) resistor r=45 c=0
Rx34 (\1\:RT \10\:RT) resistor r=45 c=0
Rx35 (\7\:RT \11\:RT) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx12 (\5\:SN \10\:SN) resistor r=45 c=0
Rx13 (\2\:SN \11\:SN) resistor r=45 c=0
Rx36 (\3\:SN \12\:SN) resistor r=45 c=0
Rx37 (\9\:SN \13\:SN) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx15 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx16 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx11 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx38 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx39 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx21 (\4\:mout \10\:mout) resistor r=45 c=0
Rx22 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx17 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx18 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx8 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx25 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx26 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx27 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx30 (n35g \14\:n35g) resistor r=45 c=0
Rx29 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx40 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx41 (qbint \22\:qbint) resistor r=45 c=0
Rx31 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx32 (RTb \9\:RTb) resistor r=45 c=0
Rx43 (net573 \8\:net573) resistor r=45 c=0
Rx24 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx28 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx42 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \4\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:01:20 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSX1 CKN D ExtVDD Q QN RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=6.50503e-17
C2 (D VSS) capacitor c=4.29856e-17
C3 (QN VSS) capacitor c=2.72399e-17
C4 (SI VSS) capacitor c=5.24843e-17
C5 (RT VSS) capacitor c=2.31033e-17
C6 (CKN VSS) capacitor c=4.0004e-17
C7 (ExtVDD VSS) capacitor c=2.26731e-16
C8 (SN VSS) capacitor c=4.3895e-17
C9 (VDD VSS) capacitor c=7.29086e-16
C10 (SE VSS) capacitor c=3.95958e-17
C11 (n20 VSS) capacitor c=3.87782e-17
C12 (CKNb VSS) capacitor c=4.67654e-17
C13 (mout VSS) capacitor c=5.40676e-17
C14 (CKNbb VSS) capacitor c=3.2283e-17
C15 (SEb VSS) capacitor c=7.7527e-17
C16 (n35g VSS) capacitor c=1.77753e-17
C17 (qbint VSS) capacitor c=4.57835e-17
C18 (RTb VSS) capacitor c=5.17974e-17
C19 (net573 VSS) capacitor c=2.25505e-17
C20 (n35 VSS) capacitor c=1.72516e-16
C21 (Db VSS) capacitor c=1.04332e-16
C22 (n11 VSS) capacitor c=7.99274e-17
C23 (n1 VSS) capacitor c=1.02126e-18
C24 (\7\:qbint VSS) capacitor c=3.39567e-17
C25 (\7\:SN VSS) capacitor c=8.59805e-17
C26 (\11\:qbint VSS) capacitor c=1.07051e-16
C27 (\13\:qbint VSS) capacitor c=4.4202e-17
C28 (\3\:net573 VSS) capacitor c=5.86782e-17
C29 (\12\:CKNb VSS) capacitor c=4.51801e-17
C30 (\4\:RTb VSS) capacitor c=9.88373e-17
C31 (\6\:RT VSS) capacitor c=2.23208e-17
C32 (\4\:qbint VSS) capacitor c=5.36612e-17
C33 (\3\:n35g VSS) capacitor c=5.21237e-17
C34 (\5\:RT VSS) capacitor c=6.48597e-17
C35 (\3\:SE VSS) capacitor c=7.72467e-17
C36 (\7\:CKNbb VSS) capacitor c=3.10427e-17
C37 (\3\:SI VSS) capacitor c=9.47876e-17
C38 (\4\:SE VSS) capacitor c=1.22143e-16
C39 (\3\:n20 VSS) capacitor c=2.47551e-17
C40 (\4\:D VSS) capacitor c=7.06284e-17
C41 (\1\:SN VSS) capacitor c=3.02849e-17
C42 (\4\:CKN VSS) capacitor c=5.6388e-17
C43 (\4\:CKNb VSS) capacitor c=4.40687e-17
C44 (\8\:CKNbb VSS) capacitor c=8.28807e-17
C45 (\3\:CKNb VSS) capacitor c=1.11535e-16
C46 (\6\:qbint VSS) capacitor c=3.77007e-17
C47 (\14\:qbint VSS) capacitor c=4.5993e-17
C48 (\8\:SN VSS) capacitor c=1.45704e-16
C49 (\12\:qbint VSS) capacitor c=1.48984e-16
C50 (\4\:net573 VSS) capacitor c=3.69215e-17
C51 (\9\:CKNbb VSS) capacitor c=2.53723e-16
C52 (\8\:RT VSS) capacitor c=1.22171e-16
C53 (\2\:RT VSS) capacitor c=6.21869e-17
C54 (\5\:qbint VSS) capacitor c=3.89021e-17
C55 (\5\:n35g VSS) capacitor c=3.28666e-17
C56 (\2\:RTb VSS) capacitor c=4.64921e-17
C57 (\5\:SE VSS) capacitor c=5.7887e-17
C58 (\6\:CKNb VSS) capacitor c=2.72722e-17
C59 (\1\:SI VSS) capacitor c=4.91308e-17
C60 (\6\:SE VSS) capacitor c=8.61913e-17
C61 (\3\:SEb VSS) capacitor c=6.60115e-17
C62 (\1\:D VSS) capacitor c=4.95122e-17
C63 (\6\:n20 VSS) capacitor c=8.23106e-17
C64 (\6\:SN VSS) capacitor c=7.01056e-17
C65 (\1\:CKN VSS) capacitor c=2.85207e-17
C66 (\3\:mout VSS) capacitor c=4.47479e-17
C67 (\11\:CKNb VSS) capacitor c=4.84288e-17
C68 (\10\:qbint VSS) capacitor c=8.39937e-17
C69 (\13\:CKNb VSS) capacitor c=5.14498e-17
C70 (\3\:SN VSS) capacitor c=2.84655e-16
C71 (\9\:SN VSS) capacitor c=6.35258e-17
C72 (\7\:RT VSS) capacitor c=1.44518e-16
C73 (\10\:CKNb VSS) capacitor c=1.6785e-16
C74 (\3\:RT VSS) capacitor c=3.94579e-17
C75 (\1\:RT VSS) capacitor c=5.29002e-17
C76 (\3\:RTb VSS) capacitor c=7.59476e-17
C77 (\3\:qbint VSS) capacitor c=4.43247e-17
C78 (\2\:n35 VSS) capacitor c=2.52896e-16
C79 (\4\:n35g VSS) capacitor c=6.67497e-17
C80 (\3\:CKNbb VSS) capacitor c=5.04575e-17
C81 (\10\:CKNbb VSS) capacitor c=2.18493e-16
C82 (\3\:n35 VSS) capacitor c=1.16031e-16
C83 (\1\:SE VSS) capacitor c=2.48251e-17
C84 (\2\:SI VSS) capacitor c=7.76389e-17
C85 (\2\:SEb VSS) capacitor c=7.74449e-17
C86 (\7\:n20 VSS) capacitor c=4.70827e-17
C87 (\4\:n20 VSS) capacitor c=7.26936e-17
C88 (\3\:D VSS) capacitor c=1.46913e-17
C89 (\2\:SN VSS) capacitor c=4.20045e-17
C90 (\5\:SN VSS) capacitor c=2.61163e-17
C91 (\3\:CKN VSS) capacitor c=2.33622e-17
C92 (\2\:mout VSS) capacitor c=4.67069e-17
C93 (\4\:mout VSS) capacitor c=2.82052e-17
C94 (\2\:CKNb VSS) capacitor c=7.90776e-17
C95 (\6\:CKNbb VSS) capacitor c=3.65273e-17
C96 (\5\:n20 VSS) capacitor c=7.82352e-17
C97 (\2\:CKNbb VSS) capacitor c=5.80279e-17
C98 (\5\:CKNb VSS) capacitor c=7.21011e-17
C99 (\9\:CKNb VSS) capacitor c=2.45443e-17
C100 (\2\:n20 VSS) capacitor c=3.96202e-17
C101 (\1\:VDD VSS) capacitor c=4.33505e-17
C102 (\12\:VDD VSS) capacitor c=2.78404e-17
C103 (\3\:Q VSS) capacitor c=7.0259e-17
C104 (\14\:VDD VSS) capacitor c=5.29375e-17
C105 (\9\:net573 VSS) capacitor c=5.55826e-17
C106 (\16\:VDD VSS) capacitor c=7.96636e-17
C107 (\3\:n11 VSS) capacitor c=8.48924e-17
C108 (\4\:QN VSS) capacitor c=5.93204e-17
C109 (\14\:n35 VSS) capacitor c=5.21976e-17
C110 (\15\:n35g VSS) capacitor c=5.5909e-17
C111 (\6\:RTb VSS) capacitor c=7.26849e-17
C112 (\1\:ExtVDD VSS) capacitor c=2.7779e-16
C113 (\9\:n35 VSS) capacitor c=6.20489e-17
C114 (\17\:qbint VSS) capacitor c=6.81911e-17
C115 (\6\:n35g VSS) capacitor c=9.39178e-17
C116 (\8\:SEb VSS) capacitor c=5.06012e-17
C117 (\4\:n35 VSS) capacitor c=6.29062e-17
C118 (\18\:VDD VSS) capacitor c=6.07875e-17
C119 (\5\:mout VSS) capacitor c=8.78996e-17
C120 (\3\:Db VSS) capacitor c=1.8619e-16
C121 (\20\:VDD VSS) capacitor c=5.06609e-17
C122 (\19\:mout VSS) capacitor c=3.95707e-17
C123 (\25\:VDD VSS) capacitor c=3.53683e-17
C124 (\16\:mout VSS) capacitor c=4.36372e-17
C125 (\20\:CKNb VSS) capacitor c=2.92262e-17
C126 (\23\:VDD VSS) capacitor c=4.83128e-17
C127 (\12\:CKNbb VSS) capacitor c=5.98405e-17
C128 (\13\:n20 VSS) capacitor c=6.09786e-17
C129 (\5\:Db VSS) capacitor c=2.2971e-16
C130 (\10\:n20 VSS) capacitor c=6.34251e-17
C131 (\1\:Q VSS) capacitor c=5.32881e-17
C132 (\5\:net573 VSS) capacitor c=4.31413e-17
C133 (\1\:QN VSS) capacitor c=3.78417e-17
C134 (\17\:n35 VSS) capacitor c=3.9291e-17
C135 (\11\:n35g VSS) capacitor c=2.96827e-17
C136 (\10\:RTb VSS) capacitor c=5.81982e-17
C137 (\12\:n35 VSS) capacitor c=6.35981e-17
C138 (\19\:qbint VSS) capacitor c=2.43447e-17
C139 (\9\:n35g VSS) capacitor c=8.04088e-17
C140 (\4\:SEb VSS) capacitor c=3.83048e-17
C141 (\7\:n35 VSS) capacitor c=4.09459e-17
C142 (\11\:mout VSS) capacitor c=2.19228e-17
C143 (\13\:mout VSS) capacitor c=1.77684e-17
C144 (\16\:CKNb VSS) capacitor c=6.41451e-17
C145 (\15\:CKNbb VSS) capacitor c=5.94392e-17
C146 (\17\:n20 VSS) capacitor c=8.69142e-17
C147 (\7\:Db VSS) capacitor c=1.10549e-16
C148 (\8\:n20 VSS) capacitor c=5.96395e-17
C149 (VDD VSS) capacitor c=4.4744e-17
C150 (\2\:CKN VSS) capacitor c=3.30964e-17
C151 (\2\:D VSS) capacitor c=3.55501e-17
C152 (\2\:SE VSS) capacitor c=2.51114e-17
C153 (\4\:CKNbb VSS) capacitor c=1.50528e-16
C154 (\5\:CKNbb VSS) capacitor c=8.61647e-17
C155 (\2\:n35g VSS) capacitor c=2.9092e-17
C156 (\4\:RT VSS) capacitor c=4.60748e-17
C157 (\2\:qbint VSS) capacitor c=4.11016e-17
C158 (\7\:CKNb VSS) capacitor c=1.2768e-16
C159 (\8\:CKNb VSS) capacitor c=7.193e-17
C160 (\4\:SN VSS) capacitor c=2.48256e-16
C161 (\2\:net573 VSS) capacitor c=1.5367e-17
C162 (\12\:n20 VSS) capacitor c=4.64116e-17
C163 (\14\:CKNb VSS) capacitor c=9.90312e-17
C164 (\15\:CKNb VSS) capacitor c=9.72819e-17
C165 (\15\:n20 VSS) capacitor c=5.22164e-17
C166 (\16\:n20 VSS) capacitor c=9.21181e-17
C167 (\8\:qbint VSS) capacitor c=4.4941e-17
C168 (\9\:qbint VSS) capacitor c=6.5228e-17
C169 (\11\:CKNbb VSS) capacitor c=5.37096e-17
C170 (\14\:CKNbb VSS) capacitor c=7.92324e-17
C171 (\5\:CKN VSS) capacitor c=3.94114e-18
C172 (\6\:CKN VSS) capacitor c=3.37944e-17
C173 (\18\:CKNb VSS) capacitor c=6.62094e-17
C174 (\19\:CKNb VSS) capacitor c=3.5191e-17
C175 (\10\:SN VSS) capacitor c=4.03234e-17
C176 (\11\:SN VSS) capacitor c=4.60269e-17
C177 (\7\:D VSS) capacitor c=4.73861e-17
C178 (\19\:n20 VSS) capacitor c=6.57619e-17
C179 (\20\:n20 VSS) capacitor c=7.69525e-17
C180 (\7\:mout VSS) capacitor c=8.21686e-17
C181 (\8\:mout VSS) capacitor c=4.27767e-17
C182 (\9\:mout VSS) capacitor c=1.00916e-16
C183 (\10\:mout VSS) capacitor c=8.60033e-17
C184 (\15\:mout VSS) capacitor c=6.24879e-17
C185 (\18\:mout VSS) capacitor c=7.41618e-17
C186 (\5\:SI VSS) capacitor c=3.48426e-17
C187 (\7\:SE VSS) capacitor c=5.25549e-17
C188 (\6\:SEb VSS) capacitor c=8.18258e-17
C189 (\7\:SEb VSS) capacitor c=6.73963e-17
C190 (\6\:n35 VSS) capacitor c=7.82109e-17
C191 (\17\:CKNbb VSS) capacitor c=3.91478e-17
C192 (\18\:CKNbb VSS) capacitor c=4.23519e-17
C193 (\8\:n35g VSS) capacitor c=3.45284e-17
C194 (\11\:n35 VSS) capacitor c=7.50221e-17
C195 (\15\:qbint VSS) capacitor c=8.78471e-17
C196 (\16\:qbint VSS) capacitor c=1.11964e-16
C197 (\13\:n35g VSS) capacitor c=1.02811e-16
C198 (\14\:n35g VSS) capacitor c=1.1611e-16
C199 (\5\:RTb VSS) capacitor c=4.94791e-17
C200 (\8\:RTb VSS) capacitor c=9.93242e-17
C201 (\9\:RTb VSS) capacitor c=9.14752e-17
C202 (\9\:RT VSS) capacitor c=1.09863e-16
C203 (\10\:RT VSS) capacitor c=1.1814e-16
C204 (\11\:RT VSS) capacitor c=4.00867e-17
C205 (\12\:SN VSS) capacitor c=8.30194e-17
C206 (\13\:SN VSS) capacitor c=7.94276e-17
C207 (\22\:CKNb VSS) capacitor c=1.29586e-16
C208 (\23\:CKNb VSS) capacitor c=1.34343e-16
C209 (\21\:qbint VSS) capacitor c=2.41935e-17
C210 (\22\:qbint VSS) capacitor c=3.00163e-17
C211 (\3\:QN VSS) capacitor c=3.62446e-17
C212 (\16\:n35 VSS) capacitor c=4.52226e-17
C213 (\7\:net573 VSS) capacitor c=5.22192e-17
C214 (\8\:net573 VSS) capacitor c=3.64969e-17
C215 (\3\:VDD VSS) capacitor c=2.73956e-17
C216 (\4\:VDD VSS) capacitor c=2.44925e-17
C217 (\6\:VDD VSS) capacitor c=9.10299e-18
C218 (\7\:VDD VSS) capacitor c=2.14363e-16
C219 (\8\:VDD VSS) capacitor c=2.06872e-16
C220 (\9\:VDD VSS) capacitor c=2.63757e-17
C221 (\11\:VDD VSS) capacitor c=4.54166e-17
C222 (\22\:VDD VSS) capacitor c=4.95461e-17
Rk82 (\2\:Q Q) resistor r=0.1765 c=0
Rk83 (Q \4\:Q) resistor r=0.303 c=0
Rk19 (\5\:D D) resistor r=0.007217 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01719 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007217 c=0
Rk74 (\3\:QN QN) resistor r=0.0152 c=0
Rk73 (\2\:QN \3\:QN) resistor r=0.2924 c=0
Rk75 (\3\:QN \5\:QN) resistor r=0.3233 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk90 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk91 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk92 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk94 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk93 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk95 (VSS \14\:VSS) resistor r=0.313 c=0
Rk96 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk97 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk98 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk99 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk100 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk118 (\26\:VSS \27\:VSS) resistor r=0.1813 c=0
Rk119 (\27\:VSS \28\:VSS) resistor r=0.3652 c=0
Rk120 (\28\:VSS \29\:VSS) resistor r=0.3681 c=0
Rk122 (\30\:VSS VSS) resistor r=0.04947 c=0
Rk121 (\29\:VSS \30\:VSS) resistor r=0.3279 c=0
Rk124 (\31\:VSS VSS) resistor r=0.1216 c=0
Rk123 (VSS \31\:VSS) resistor r=0.8951 c=0
Rk125 (VSS \33\:VSS) resistor r=0.3043 c=0
Rk126 (\27\:VSS \35\:VSS) resistor r=0.2357 c=0
Rk127 (\29\:VSS \37\:VSS) resistor r=0.2445 c=0
Rk128 (\33\:VSS \38\:VSS) resistor r=0.1028 c=0
Rk36 (SI \4\:SI) resistor r=0.01024 c=0
Rk40 (\5\:SI SI) resistor r=0.01024 c=0
Rk37 (\4\:SI \5\:SI) resistor r=0.001853 c=0
Rk67 (RT \9\:RT) resistor r=0.1845 c=0
Rk68 (\9\:RT \10\:RT) resistor r=0.6488 c=0
Rk69 (RT \11\:RT) resistor r=0.01482 c=0
Rk10 (CKN \5\:CKN) resistor r=0.001998 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.01106 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.004543 c=0
Rk54 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk52 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk55 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk56 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk17 (SN \10\:SN) resistor r=0.01189 c=0
Rk18 (\10\:SN \11\:SN) resistor r=0.3257 c=0
Rk70 (\12\:SN \13\:SN) resistor r=0.538 c=0
Rk117 (VDD VDD) resistor r=0.2362 c=0
Rk101 (\2\:VDD \3\:VDD) resistor r=0.3819 c=0
Rk102 (\3\:VDD \4\:VDD) resistor r=0.1963 c=0
Rk103 (\4\:VDD \6\:VDD) resistor r=0.06692 c=0
Rk104 (\6\:VDD \7\:VDD) resistor r=0.05201 c=0
Rk105 (\7\:VDD \8\:VDD) resistor r=1.5259 c=0
Rk106 (\8\:VDD \9\:VDD) resistor r=0.1711 c=0
Rk107 (\9\:VDD \11\:VDD) resistor r=0.1695 c=0
Rk108 (\3\:VDD \13\:VDD) resistor r=0.32 c=0
Rk109 (\4\:VDD \15\:VDD) resistor r=0.3026 c=0
Rk110 (\7\:VDD \17\:VDD) resistor r=0.3757 c=0
Rk111 (\8\:VDD \19\:VDD) resistor r=0.3677 c=0
Rk112 (\9\:VDD \21\:VDD) resistor r=0.2078 c=0
Rk116 (\22\:VDD VDD) resistor r=0.1959 c=0
Rk113 (\11\:VDD \22\:VDD) resistor r=0.1713 c=0
Rk114 (\22\:VDD \24\:VDD) resistor r=0.2078 c=0
Rk115 (\11\:VDD \26\:VDD) resistor r=0.2359 c=0
Rk41 (SE \7\:SE) resistor r=0.04328 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3416 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2303 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4984 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4375 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7542 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3503 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.1789 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1643 c=0
Rk71 (\22\:CKNb \23\:CKNb) resistor r=0.8279 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.6045 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3058 c=0
Rk28 (\8\:mout \9\:mout) resistor r=0.1684 c=0
Rk29 (\9\:mout \10\:mout) resistor r=0.3469 c=0
Rk30 (\7\:mout \12\:mout) resistor r=0.1284 c=0
Rk31 (\8\:mout \14\:mout) resistor r=0.09239 c=0
Rk32 (\9\:mout \15\:mout) resistor r=0.5264 c=0
Rk33 (\15\:mout \17\:mout) resistor r=0.0449 c=0
Rk34 (\10\:mout \18\:mout) resistor r=0.4268 c=0
Rk35 (\15\:mout \20\:mout) resistor r=0.03469 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.1426 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4248 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.2372 c=0
Rk47 (\17\:CKNbb \18\:CKNbb) resistor r=0.3729 c=0
Rk42 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk43 (\6\:SEb \7\:SEb) resistor r=0.3482 c=0
Rk44 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk48 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk49 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk60 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk61 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk62 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk57 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk58 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk59 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk72 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk63 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk64 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk65 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk66 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk78 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk79 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk80 (\7\:net573 \10\:net573) resistor r=0.2925 c=0
Rk45 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk46 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk50 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk51 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk76 (\15\:n35 \16\:n35) resistor r=0.305 c=0
Rk77 (\16\:n35 \18\:n35) resistor r=0.2683 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.3611 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.6375 c=0
Rk81 (\2\:n11 \4\:n11) resistor r=0.6555 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl52 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl39 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl42 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl41 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl40 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl63 (\7\:SN \8\:SN) resistor r=367.487 c=0
Rl64 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl12 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl55 (\4\:SN \6\:SN) resistor r=115.884 c=0
Rl53 (\3\:SN \4\:SN) resistor r=1092.88 c=0
Rl54 (\4\:SN \5\:SN) resistor r=66.1252 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl58 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl3 (CKNb \2\:CKNb) resistor r=135.348 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=49.7951 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl47 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl50 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl51 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl49 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl48 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl59 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl31 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl28 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl32 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl30 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl29 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl35 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl33 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl34 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl65 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl72 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl70 (\11\:qbint \12\:qbint) resistor r=343.448 c=0
Rl46 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl43 (qbint \2\:qbint) resistor r=112.732 c=0
Rl45 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl44 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl66 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl69 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl71 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl68 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl67 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl37 (RTb \2\:RTb) resistor r=112.412 c=0
Rl38 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl60 (net573 \2\:net573) resistor r=3.1216 c=0
Rl61 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl62 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl56 (n35 \2\:n35) resistor r=508.667 c=0
Rl57 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz33 (\32\:VSS \38\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry25 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=15.5 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry37 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry9 (\19\:mout \20\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\5\:SN \10\:SN) resistor r=45 c=0
Rx11 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \18\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx39 (net573 \8\:net573) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.307e-14 ad=8.7e-15 ps=1.16e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0118 \6\:SN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn52 (net0119 \12\:qbint net0117 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0117 \8\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (n11 \11\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n11 \7\:SN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:02:10 2012 )
// Library name: gsclib045
// Cell name: SRDFFNX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNX1 CKN D ExtVDD Q QN RT SE SI VDD VSS
mp25 (\9\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (QN VSS) capacitor c=3.25897e-17
C2 (SI VSS) capacitor c=5.17102e-17
C3 (RT VSS) capacitor c=2.14731e-17
C4 (ExtVDD VSS) capacitor c=2.18855e-16
C5 (VDD VSS) capacitor c=6.95097e-16
C6 (SE VSS) capacitor c=3.96872e-17
C7 (CKN VSS) capacitor c=4.40464e-17
C8 (Q VSS) capacitor c=6.2483e-17
C9 (D VSS) capacitor c=3.84273e-17
C10 (n20 VSS) capacitor c=3.87782e-17
C11 (CKNb VSS) capacitor c=4.69e-17
C12 (mout VSS) capacitor c=5.3657e-17
C13 (CKNbb VSS) capacitor c=3.23206e-17
C14 (SEb VSS) capacitor c=7.7527e-17
C15 (n35g VSS) capacitor c=1.77753e-17
C16 (qbint VSS) capacitor c=4.54323e-17
C17 (RTb VSS) capacitor c=5.18061e-17
C18 (net573 VSS) capacitor c=2.25505e-17
C19 (n35 VSS) capacitor c=1.45617e-16
C20 (Db VSS) capacitor c=1.05348e-16
C21 (net0107 VSS) capacitor c=6.33869e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:qbint VSS) capacitor c=3.41196e-17
C24 (\11\:qbint VSS) capacitor c=8.24646e-17
C25 (\13\:qbint VSS) capacitor c=4.42321e-17
C26 (\3\:net573 VSS) capacitor c=5.8728e-17
C27 (\12\:CKNb VSS) capacitor c=4.91023e-17
C28 (\4\:RTb VSS) capacitor c=9.88373e-17
C29 (\6\:RT VSS) capacitor c=2.23385e-17
C30 (\4\:qbint VSS) capacitor c=5.36612e-17
C31 (\3\:n35g VSS) capacitor c=5.24051e-17
C32 (\5\:RT VSS) capacitor c=5.86041e-17
C33 (\3\:SE VSS) capacitor c=7.73518e-17
C34 (\7\:CKNbb VSS) capacitor c=2.48722e-17
C35 (\3\:SI VSS) capacitor c=9.47876e-17
C36 (\4\:SE VSS) capacitor c=1.22444e-16
C37 (\4\:D VSS) capacitor c=6.88417e-17
C38 (\3\:n20 VSS) capacitor c=4.48935e-17
C39 (\4\:CKN VSS) capacitor c=5.63594e-17
C40 (\4\:CKNb VSS) capacitor c=4.40132e-17
C41 (\8\:CKNbb VSS) capacitor c=8.18976e-17
C42 (\3\:CKNb VSS) capacitor c=1.11548e-16
C43 (\6\:qbint VSS) capacitor c=3.77521e-17
C44 (\14\:qbint VSS) capacitor c=4.59617e-17
C45 (\12\:qbint VSS) capacitor c=8.5727e-17
C46 (\4\:net573 VSS) capacitor c=3.68336e-17
C47 (\9\:CKNbb VSS) capacitor c=2.33512e-16
C48 (\8\:RT VSS) capacitor c=1.2267e-16
C49 (\2\:RT VSS) capacitor c=6.22925e-17
C50 (\5\:qbint VSS) capacitor c=3.89021e-17
C51 (\5\:n35g VSS) capacitor c=3.28666e-17
C52 (\2\:RTb VSS) capacitor c=4.65527e-17
C53 (\5\:SE VSS) capacitor c=5.78737e-17
C54 (\6\:CKNb VSS) capacitor c=2.45241e-17
C55 (\1\:SI VSS) capacitor c=4.91308e-17
C56 (\6\:SE VSS) capacitor c=8.62134e-17
C57 (\3\:SEb VSS) capacitor c=6.60184e-17
C58 (\1\:D VSS) capacitor c=4.95201e-17
C59 (\6\:n20 VSS) capacitor c=6.51408e-17
C60 (\1\:CKN VSS) capacitor c=2.85194e-17
C61 (\3\:mout VSS) capacitor c=5.00546e-17
C62 (\11\:CKNb VSS) capacitor c=4.86151e-17
C63 (\10\:qbint VSS) capacitor c=8.38458e-17
C64 (\13\:CKNb VSS) capacitor c=3.90987e-17
C65 (\7\:RT VSS) capacitor c=1.43994e-16
C66 (\10\:CKNb VSS) capacitor c=1.55951e-16
C67 (\3\:RT VSS) capacitor c=3.31029e-17
C68 (\1\:RT VSS) capacitor c=5.2467e-17
C69 (\3\:RTb VSS) capacitor c=7.59476e-17
C70 (\3\:qbint VSS) capacitor c=4.43507e-17
C71 (\2\:n35 VSS) capacitor c=1.89205e-16
C72 (\4\:n35g VSS) capacitor c=6.64118e-17
C73 (\3\:CKNbb VSS) capacitor c=4.82614e-17
C74 (\10\:CKNbb VSS) capacitor c=2.21201e-16
C75 (\3\:n35 VSS) capacitor c=7.66801e-17
C76 (\1\:SE VSS) capacitor c=2.48251e-17
C77 (\2\:SI VSS) capacitor c=7.76315e-17
C78 (\2\:SEb VSS) capacitor c=7.74399e-17
C79 (\3\:D VSS) capacitor c=1.47339e-17
C80 (\3\:CKN VSS) capacitor c=2.39858e-17
C81 (\2\:mout VSS) capacitor c=3.80639e-17
C82 (\4\:mout VSS) capacitor c=3.80927e-17
C83 (\2\:CKNb VSS) capacitor c=7.90457e-17
C84 (\6\:CKNbb VSS) capacitor c=3.65314e-17
C85 (\5\:n20 VSS) capacitor c=3.72724e-17
C86 (\2\:CKNbb VSS) capacitor c=5.81271e-17
C87 (\5\:CKNb VSS) capacitor c=7.20093e-17
C88 (\9\:CKNb VSS) capacitor c=2.45672e-17
C89 (\2\:n20 VSS) capacitor c=3.96406e-17
C90 (\1\:VDD VSS) capacitor c=4.94752e-17
C91 (\3\:Q VSS) capacitor c=7.28849e-17
C92 (\10\:VDD VSS) capacitor c=5.38945e-17
C93 (\9\:net573 VSS) capacitor c=5.56984e-17
C94 (\12\:VDD VSS) capacitor c=7.99107e-17
C95 (\3\:net0107 VSS) capacitor c=8.53421e-17
C96 (\3\:QN VSS) capacitor c=8.02102e-17
C97 (\14\:n35 VSS) capacitor c=5.08213e-17
C98 (\15\:n35g VSS) capacitor c=5.5988e-17
C99 (\6\:RTb VSS) capacitor c=7.29535e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.78288e-16
C101 (\9\:n35 VSS) capacitor c=6.22363e-17
C102 (\17\:qbint VSS) capacitor c=6.84723e-17
C103 (\6\:n35g VSS) capacitor c=9.31898e-17
C104 (\8\:SEb VSS) capacitor c=5.08032e-17
C105 (\4\:n35 VSS) capacitor c=6.41853e-17
C106 (\14\:VDD VSS) capacitor c=6.08814e-17
C107 (\5\:mout VSS) capacitor c=6.55783e-17
C108 (\3\:Db VSS) capacitor c=1.8386e-16
C109 (\19\:VDD VSS) capacitor c=3.54629e-17
C110 (\14\:mout VSS) capacitor c=4.55773e-17
C111 (\20\:CKNb VSS) capacitor c=2.92857e-17
C112 (\17\:VDD VSS) capacitor c=4.83231e-17
C113 (\12\:CKNbb VSS) capacitor c=5.95986e-17
C114 (\12\:n20 VSS) capacitor c=6.80226e-17
C115 (\5\:Db VSS) capacitor c=2.29718e-16
C116 (\9\:n20 VSS) capacitor c=6.35172e-17
C117 (\1\:Q VSS) capacitor c=5.36599e-17
C118 (\5\:net573 VSS) capacitor c=4.32247e-17
C119 (\1\:QN VSS) capacitor c=4.97053e-17
C120 (\17\:n35 VSS) capacitor c=3.68796e-17
C121 (\11\:n35g VSS) capacitor c=2.97301e-17
C122 (\10\:RTb VSS) capacitor c=5.83059e-17
C123 (\12\:n35 VSS) capacitor c=6.37635e-17
C124 (\19\:qbint VSS) capacitor c=2.43869e-17
C125 (\9\:n35g VSS) capacitor c=8.1299e-17
C126 (\4\:SEb VSS) capacitor c=3.83661e-17
C127 (\7\:n35 VSS) capacitor c=4.17234e-17
C128 (\10\:mout VSS) capacitor c=2.32392e-17
C129 (\12\:mout VSS) capacitor c=2.62247e-17
C130 (\16\:CKNb VSS) capacitor c=6.14357e-17
C131 (\15\:CKNbb VSS) capacitor c=5.95408e-17
C132 (\16\:n20 VSS) capacitor c=8.21191e-17
C133 (\7\:Db VSS) capacitor c=1.10759e-16
C134 (\7\:n20 VSS) capacitor c=5.97236e-17
C135 (VDD VSS) capacitor c=4.47907e-17
C136 (\2\:CKN VSS) capacitor c=3.35648e-17
C137 (\4\:n20 VSS) capacitor c=5.44302e-17
C138 (\2\:D VSS) capacitor c=3.55113e-17
C139 (\2\:SE VSS) capacitor c=2.51114e-17
C140 (\4\:CKNbb VSS) capacitor c=1.56164e-16
C141 (\5\:CKNbb VSS) capacitor c=8.80784e-17
C142 (\2\:n35g VSS) capacitor c=2.90596e-17
C143 (\4\:RT VSS) capacitor c=3.78115e-17
C144 (\2\:qbint VSS) capacitor c=4.11644e-17
C145 (\7\:CKNb VSS) capacitor c=1.29623e-16
C146 (\8\:CKNb VSS) capacitor c=7.25941e-17
C147 (\2\:net573 VSS) capacitor c=1.56394e-17
C148 (\11\:n20 VSS) capacitor c=4.64596e-17
C149 (\14\:CKNb VSS) capacitor c=9.84346e-17
C150 (\15\:CKNb VSS) capacitor c=9.76079e-17
C151 (\8\:qbint VSS) capacitor c=4.58679e-17
C152 (\9\:qbint VSS) capacitor c=6.58366e-17
C153 (\14\:n20 VSS) capacitor c=5.21092e-17
C154 (\15\:n20 VSS) capacitor c=8.8179e-17
C155 (\11\:CKNbb VSS) capacitor c=5.38163e-17
C156 (\14\:CKNbb VSS) capacitor c=7.98266e-17
C157 (\5\:CKN VSS) capacitor c=4.05153e-18
C158 (\6\:CKN VSS) capacitor c=2.99345e-17
C159 (\18\:CKNb VSS) capacitor c=6.43535e-17
C160 (\19\:CKNb VSS) capacitor c=3.81347e-17
C161 (\7\:D VSS) capacitor c=4.86018e-17
C162 (\7\:mout VSS) capacitor c=8.2704e-17
C163 (\8\:mout VSS) capacitor c=5.7118e-17
C164 (\9\:mout VSS) capacitor c=5.30418e-17
C165 (\16\:mout VSS) capacitor c=4.50927e-17
C166 (\5\:SI VSS) capacitor c=3.4559e-17
C167 (\7\:SE VSS) capacitor c=5.26482e-17
C168 (\6\:SEb VSS) capacitor c=8.19603e-17
C169 (\7\:SEb VSS) capacitor c=6.6855e-17
C170 (\6\:n35 VSS) capacitor c=7.67648e-17
C171 (\17\:CKNbb VSS) capacitor c=3.8227e-17
C172 (\18\:CKNbb VSS) capacitor c=4.1869e-17
C173 (\8\:n35g VSS) capacitor c=3.40218e-17
C174 (\11\:n35 VSS) capacitor c=7.40109e-17
C175 (\15\:qbint VSS) capacitor c=8.80005e-17
C176 (\16\:qbint VSS) capacitor c=1.12149e-16
C177 (\13\:n35g VSS) capacitor c=1.02575e-16
C178 (\14\:n35g VSS) capacitor c=1.16309e-16
C179 (\5\:RTb VSS) capacitor c=4.9331e-17
C180 (\8\:RTb VSS) capacitor c=1.01992e-16
C181 (\9\:RTb VSS) capacitor c=9.17318e-17
C182 (\9\:RT VSS) capacitor c=1.04101e-16
C183 (\10\:RT VSS) capacitor c=1.18785e-16
C184 (\11\:RT VSS) capacitor c=4.0205e-17
C185 (\22\:CKNb VSS) capacitor c=9.31035e-17
C186 (\23\:CKNb VSS) capacitor c=1.00507e-16
C187 (\21\:qbint VSS) capacitor c=2.4264e-17
C188 (\22\:qbint VSS) capacitor c=3.00557e-17
C189 (\16\:n35 VSS) capacitor c=3.71648e-17
C190 (\7\:net573 VSS) capacitor c=5.05996e-17
C191 (\8\:net573 VSS) capacitor c=3.48572e-17
C192 (\3\:VDD VSS) capacitor c=4.29107e-17
C193 (\5\:VDD VSS) capacitor c=9.3079e-18
C194 (\6\:VDD VSS) capacitor c=2.14745e-16
C195 (\7\:VDD VSS) capacitor c=2.13145e-16
C196 (\9\:VDD VSS) capacitor c=3.65725e-17
C197 (\16\:VDD VSS) capacitor c=4.7621e-17
Rk66 (\2\:QN QN) resistor r=0.1752 c=0
Rk67 (QN \4\:QN) resistor r=0.2568 c=0
Rk30 (SI \4\:SI) resistor r=0.01682 c=0
Rk34 (\5\:SI SI) resistor r=0.01682 c=0
Rk31 (\5\:SI \4\:SI) resistor r=0.001885 c=0
Rk61 (RT \9\:RT) resistor r=0.1838 c=0
Rk62 (\9\:RT \10\:RT) resistor r=0.6407 c=0
Rk63 (RT \11\:RT) resistor r=0.01479 c=0
Rk48 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk46 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk49 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk50 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk105 (VDD VDD) resistor r=0.2356 c=0
Rk93 (\2\:VDD \3\:VDD) resistor r=0.5761 c=0
Rk94 (\3\:VDD \5\:VDD) resistor r=0.06676 c=0
Rk95 (\5\:VDD \6\:VDD) resistor r=0.05188 c=0
Rk96 (\6\:VDD \7\:VDD) resistor r=1.5221 c=0
Rk97 (\7\:VDD \9\:VDD) resistor r=0.3401 c=0
Rk98 (\3\:VDD \11\:VDD) resistor r=0.3013 c=0
Rk99 (\6\:VDD \13\:VDD) resistor r=0.3741 c=0
Rk100 (\7\:VDD \15\:VDD) resistor r=0.3661 c=0
Rk104 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk101 (\9\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk102 (\16\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk103 (\9\:VDD \20\:VDD) resistor r=0.2349 c=0
Rk35 (SE \7\:SE) resistor r=0.0432 c=0
Rk10 (CKN \5\:CKN) resistor r=0.002322 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.009981 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.007911 c=0
Rk74 (\2\:Q Q) resistor r=0.1744 c=0
Rk75 (Q \4\:Q) resistor r=0.3044 c=0
Rk17 (\5\:D D) resistor r=0.007628 c=0
Rk19 (\5\:D \7\:D) resistor r=0.01716 c=0
Rk18 (\6\:D \7\:D) resistor r=0.007628 c=0
Rk76 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk77 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk78 (\5\:VSS \6\:VSS) resistor r=0.05932 c=0
Rk79 (\6\:VSS \7\:VSS) resistor r=0.6123 c=0
Rk80 (\7\:VSS \8\:VSS) resistor r=0.03204 c=0
Rk82 (\9\:VSS VSS) resistor r=0.1211 c=0
Rk81 (\8\:VSS \9\:VSS) resistor r=0.1759 c=0
Rk83 (VSS \10\:VSS) resistor r=0.5208 c=0
Rk84 (\10\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk86 (\12\:VSS VSS) resistor r=0.1213 c=0
Rk85 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk87 (VSS \14\:VSS) resistor r=0.3119 c=0
Rk88 (\5\:VSS \16\:VSS) resistor r=0.2667 c=0
Rk89 (\7\:VSS \18\:VSS) resistor r=0.1891 c=0
Rk90 (\9\:VSS \20\:VSS) resistor r=0.1942 c=0
Rk91 (\10\:VSS \22\:VSS) resistor r=0.2532 c=0
Rk92 (\11\:VSS \24\:VSS) resistor r=0.2488 c=0
Rk106 (\26\:VSS \28\:VSS) resistor r=0.3487 c=0
Rk107 (\28\:VSS \29\:VSS) resistor r=0.5654 c=0
Rk109 (\30\:VSS VSS) resistor r=0.04935 c=0
Rk108 (\29\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk111 (\31\:VSS VSS) resistor r=0.1213 c=0
Rk110 (VSS \31\:VSS) resistor r=0.8929 c=0
Rk112 (VSS \33\:VSS) resistor r=0.2968 c=0
Rk113 (\29\:VSS \35\:VSS) resistor r=0.2434 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2662 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4595 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7511 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3507 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.1799 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1637 c=0
Rk64 (\22\:CKNb \23\:CKNb) resistor r=0.7115 c=0
Rk23 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk24 (\7\:mout \8\:mout) resistor r=0.5259 c=0
Rk25 (\8\:mout \9\:mout) resistor r=0.1904 c=0
Rk26 (\7\:mout \11\:mout) resistor r=0.1278 c=0
Rk27 (\8\:mout \13\:mout) resistor r=0.1169 c=0
Rk28 (\8\:mout \15\:mout) resistor r=0.5475 c=0
Rk29 (\9\:mout \16\:mout) resistor r=0.3936 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.142 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4226 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.2362 c=0
Rk41 (\17\:CKNbb \18\:CKNbb) resistor r=0.3714 c=0
Rk36 (\5\:SEb \6\:SEb) resistor r=0.2169 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.3459 c=0
Rk38 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk42 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk43 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk54 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk55 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk56 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk51 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk52 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk53 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk65 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk57 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk58 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk59 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk60 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk70 (\6\:net573 \7\:net573) resistor r=0.2363 c=0
Rk71 (\7\:net573 \8\:net573) resistor r=0.1648 c=0
Rk72 (\7\:net573 \10\:net573) resistor r=0.2913 c=0
Rk39 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk40 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk44 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk45 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk20 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk21 (\4\:Db \6\:Db) resistor r=1.3554 c=0
Rk22 (\6\:Db \8\:Db) resistor r=0.6342 c=0
Rk73 (\2\:net0107 \4\:net0107) resistor r=0.6451 c=0
Rl21 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl20 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl51 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl38 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl41 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl40 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl39 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl24 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl26 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl23 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl25 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl22 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl17 (\2\:D \4\:D) resistor r=115.099 c=0
Rl15 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl16 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=100.163 c=0
Rl14 (\4\:n20 \6\:n20) resistor r=179.184 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=123.391 c=0
Rl54 (\12\:CKNb \13\:CKNb) resistor r=163.284 c=0
Rl3 (CKNb \2\:CKNb) resistor r=135.348 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=49.7951 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl46 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl49 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl50 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl48 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl47 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl55 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl30 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl27 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl31 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl29 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl28 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl18 (SEb \2\:SEb) resistor r=101.718 c=0
Rl19 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl34 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl32 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl33 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl35 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl59 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl66 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl64 (\11\:qbint \12\:qbint) resistor r=337.984 c=0
Rl45 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl42 (qbint \2\:qbint) resistor r=112.732 c=0
Rl44 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl43 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl60 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl63 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl65 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl62 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl61 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl36 (RTb \2\:RTb) resistor r=112.412 c=0
Rl37 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl56 (net573 \2\:net573) resistor r=3.1216 c=0
Rl57 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl58 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl52 (n35 \2\:n35) resistor r=508.667 c=0
Rl53 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\12\:mout \13\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry19 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry30 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry35 (\27\:VSS \28\:VSS) resistor r=5.6364 c=0
Ry36 (\27\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry37 (\27\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry21 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry22 (net0107 \2\:net0107) resistor r=62 c=0
Ry23 (\3\:net0107 \4\:net0107) resistor r=62 c=0
Rx13 (\2\:SI \4\:SI) resistor r=45 c=0
Rx25 (\3\:RT \9\:RT) resistor r=45 c=0
Rx26 (\1\:RT \10\:RT) resistor r=45 c=0
Rx27 (\7\:RT \11\:RT) resistor r=45 c=0
Rx14 (\1\:SE \7\:SE) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\3\:D \6\:D) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx28 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx29 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx11 (\4\:mout \9\:mout) resistor r=45 c=0
Rx12 (\2\:mout \16\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx17 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx18 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx15 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx19 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx22 (n35g \14\:n35g) resistor r=45 c=0
Rx21 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx30 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx31 (qbint \22\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (RTb \9\:RTb) resistor r=45 c=0
Rx33 (net573 \8\:net573) resistor r=45 c=0
Rx16 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx20 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx32 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\12\:mout \6\:n20 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn52 (net0119 \12\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\14\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:net0107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\3\:QN \3\:net573 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (net0107 \11\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:03:01 2012 )
// Library name: gsclib045
// Cell name: SRDFFRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFRQX1 CK D ExtVDD Q RN RT SE SI VDD VSS
mp22 (\10\:RNb \1\:RN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (SI VSS) capacitor c=8.71917e-17
C2 (RN VSS) capacitor c=8.17943e-17
C3 (RT VSS) capacitor c=3.75399e-17
C4 (Q VSS) capacitor c=2.16972e-17
C5 (VDD VSS) capacitor c=6.60999e-16
C6 (SE VSS) capacitor c=3.95426e-17
C7 (ExtVDD VSS) capacitor c=2.34537e-16
C8 (D VSS) capacitor c=4.57153e-17
C9 (n20 VSS) capacitor c=3.92762e-17
C10 (CKbb VSS) capacitor c=3.00292e-17
C11 (mout VSS) capacitor c=4.95495e-17
C12 (CKb VSS) capacitor c=5.52799e-17
C13 (RNb VSS) capacitor c=2.7463e-16
C14 (SEb VSS) capacitor c=7.75211e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.57473e-17
C17 (RTb VSS) capacitor c=5.17873e-17
C18 (n35 VSS) capacitor c=1.3462e-16
C19 (Db VSS) capacitor c=1.04956e-16
C20 (n10 VSS) capacitor c=6.36691e-17
C21 (n1 VSS) capacitor c=1.02126e-18
C22 (\7\:RNb VSS) capacitor c=1.00899e-16
C23 (\9\:qbint VSS) capacitor c=2.81783e-17
C24 (\10\:qbint VSS) capacitor c=2.20934e-16
C25 (\11\:CKbb VSS) capacitor c=9.86081e-17
C26 (\4\:RTb VSS) capacitor c=9.87178e-17
C27 (\6\:RT VSS) capacitor c=2.21451e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.21168e-17
C30 (\5\:RT VSS) capacitor c=8.4067e-17
C31 (\3\:SE VSS) capacitor c=7.72547e-17
C32 (\7\:CKb VSS) capacitor c=3.23122e-17
C33 (\3\:SI VSS) capacitor c=9.47876e-17
C34 (\4\:SE VSS) capacitor c=1.2264e-16
C35 (\4\:D VSS) capacitor c=7.01011e-17
C36 (\5\:RNb VSS) capacitor c=6.66155e-17
C37 (\5\:n20 VSS) capacitor c=1.21055e-16
C38 (\4\:CK VSS) capacitor c=6.01774e-17
C39 (\4\:CKb VSS) capacitor c=4.53192e-17
C40 (\8\:CKb VSS) capacitor c=8.35802e-17
C41 (\3\:CKbb VSS) capacitor c=2.89617e-17
C42 (\1\:RN VSS) capacitor c=4.2139e-17
C43 (\8\:RNb VSS) capacitor c=8.56207e-17
C44 (\6\:qbint VSS) capacitor c=3.17649e-17
C45 (\11\:qbint VSS) capacitor c=8.89948e-17
C46 (\11\:CKb VSS) capacitor c=2.13298e-16
C47 (\8\:RT VSS) capacitor c=1.28278e-16
C48 (\2\:RT VSS) capacitor c=6.21538e-17
C49 (\5\:qbint VSS) capacitor c=3.87694e-17
C50 (\5\:n35g VSS) capacitor c=3.28917e-17
C51 (\2\:RTb VSS) capacitor c=4.79204e-17
C52 (\5\:SE VSS) capacitor c=5.7887e-17
C53 (\9\:CKbb VSS) capacitor c=2.52869e-17
C54 (\1\:SI VSS) capacitor c=4.91308e-17
C55 (\6\:SE VSS) capacitor c=8.61913e-17
C56 (\3\:SEb VSS) capacitor c=6.60462e-17
C57 (\1\:D VSS) capacitor c=4.94494e-17
C58 (\6\:RNb VSS) capacitor c=5.09058e-17
C59 (\3\:n20 VSS) capacitor c=8.28417e-17
C60 (\1\:CK VSS) capacitor c=2.87619e-17
C61 (\3\:mout VSS) capacitor c=5.00666e-17
C62 (\9\:CKb VSS) capacitor c=3.90899e-17
C63 (\10\:CKbb VSS) capacitor c=4.89185e-17
C64 (\6\:CKb VSS) capacitor c=5.34296e-17
C65 (\4\:RN VSS) capacitor c=3.6922e-17
C66 (\8\:qbint VSS) capacitor c=1.04092e-16
C67 (\12\:CKbb VSS) capacitor c=6.71982e-17
C68 (\9\:RNb VSS) capacitor c=6.11895e-17
C69 (\7\:RT VSS) capacitor c=1.51736e-16
C70 (\5\:CKbb VSS) capacitor c=1.64527e-16
C71 (\3\:RT VSS) capacitor c=5.4998e-17
C72 (\1\:RT VSS) capacitor c=5.27439e-17
C73 (\3\:RTb VSS) capacitor c=7.6147e-17
C74 (\3\:qbint VSS) capacitor c=4.43509e-17
C75 (\2\:n35 VSS) capacitor c=1.90399e-16
C76 (\4\:n35g VSS) capacitor c=6.72291e-17
C77 (\12\:CKb VSS) capacitor c=2.07004e-16
C78 (\3\:n35 VSS) capacitor c=9.08061e-17
C79 (\1\:SE VSS) capacitor c=2.48251e-17
C80 (\2\:SI VSS) capacitor c=7.76389e-17
C81 (\2\:SEb VSS) capacitor c=7.74415e-17
C82 (\3\:D VSS) capacitor c=1.46469e-17
C83 (\3\:CK VSS) capacitor c=2.33567e-17
C84 (\2\:mout VSS) capacitor c=3.79422e-17
C85 (\4\:mout VSS) capacitor c=4.33186e-17
C86 (\10\:CKb VSS) capacitor c=2.11774e-17
C87 (\6\:n20 VSS) capacitor c=1.05145e-16
C88 (\4\:n20 VSS) capacitor c=6.91974e-17
C89 (\4\:CKbb VSS) capacitor c=7.10829e-17
C90 (\8\:CKbb VSS) capacitor c=2.74016e-17
C91 (\4\:RNb VSS) capacitor c=9.81903e-17
C92 (\2\:n20 VSS) capacitor c=4.55207e-17
C93 (\3\:RN VSS) capacitor c=4.82646e-17
C94 (\1\:VDD VSS) capacitor c=2.43855e-17
C95 (\10\:VDD VSS) capacitor c=4.39786e-17
C96 (\4\:Q VSS) capacitor c=6.38054e-17
C97 (\14\:n35 VSS) capacitor c=5.68374e-17
C98 (\15\:n35g VSS) capacitor c=5.76971e-17
C99 (\6\:RTb VSS) capacitor c=7.20391e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.77981e-16
C101 (\9\:n35 VSS) capacitor c=6.15721e-17
C102 (\14\:qbint VSS) capacitor c=6.81232e-17
C103 (\6\:n35g VSS) capacitor c=9.40514e-17
C104 (\8\:SEb VSS) capacitor c=5.05319e-17
C105 (\4\:n35 VSS) capacitor c=6.36368e-17
C106 (\12\:VDD VSS) capacitor c=6.07503e-17
C107 (\5\:mout VSS) capacitor c=7.31091e-17
C108 (\3\:Db VSS) capacitor c=1.88508e-16
C109 (\14\:VDD VSS) capacitor c=2.98062e-17
C110 (\19\:VDD VSS) capacitor c=3.4302e-17
C111 (\13\:mout VSS) capacitor c=5.17159e-17
C112 (\17\:CKb VSS) capacitor c=2.91338e-17
C113 (\17\:VDD VSS) capacitor c=4.24614e-17
C114 (\17\:CKbb VSS) capacitor c=6.74654e-17
C115 (\12\:n20 VSS) capacitor c=6.1008e-17
C116 (\5\:Db VSS) capacitor c=2.23494e-16
C117 (\10\:RNb VSS) capacitor c=5.0493e-17
C118 (\9\:n20 VSS) capacitor c=6.35945e-17
C119 (\21\:VDD VSS) capacitor c=4.24098e-17
C120 (\3\:VDD VSS) capacitor c=2.36204e-16
C121 (\1\:Q VSS) capacitor c=3.47098e-17
C122 (\3\:n10 VSS) capacitor c=7.9996e-17
C123 (\17\:n35 VSS) capacitor c=7.30793e-17
C124 (\11\:n35g VSS) capacitor c=2.72594e-17
C125 (\10\:RTb VSS) capacitor c=5.79526e-17
C126 (\12\:n35 VSS) capacitor c=6.3485e-17
C127 (\16\:qbint VSS) capacitor c=2.43025e-17
C128 (\9\:n35g VSS) capacitor c=8.05092e-17
C129 (\4\:SEb VSS) capacitor c=3.82428e-17
C130 (\7\:n35 VSS) capacitor c=4.10685e-17
C131 (\11\:mout VSS) capacitor c=2.63954e-17
C132 (\15\:mout VSS) capacitor c=4.00685e-17
C133 (\13\:CKb VSS) capacitor c=6.69783e-17
C134 (\15\:CKbb VSS) capacitor c=8.30493e-17
C135 (\17\:n20 VSS) capacitor c=5.27563e-17
C136 (\7\:Db VSS) capacitor c=7.75866e-17
C137 (\13\:RNb VSS) capacitor c=7.34786e-17
C138 (\7\:n20 VSS) capacitor c=5.89089e-17
C139 (VDD VSS) capacitor c=6.92418e-17
C140 (\2\:CKbb VSS) capacitor c=6.11803e-17
C141 (\2\:CK VSS) capacitor c=3.41706e-17
C142 (\2\:D VSS) capacitor c=3.5271e-17
C143 (\2\:SE VSS) capacitor c=2.51114e-17
C144 (\2\:CKb VSS) capacitor c=1.45267e-16
C145 (\3\:CKb VSS) capacitor c=8.91815e-17
C146 (\5\:CKb VSS) capacitor c=5.62737e-17
C147 (\2\:n35g VSS) capacitor c=2.90794e-17
C148 (\4\:RT VSS) capacitor c=7.44104e-17
C149 (\2\:qbint VSS) capacitor c=4.14972e-17
C150 (\6\:CKbb VSS) capacitor c=1.22521e-16
C151 (\7\:CKbb VSS) capacitor c=8.12993e-17
C152 (\2\:RNb VSS) capacitor c=1.77688e-16
C153 (\3\:RNb VSS) capacitor c=1.03929e-16
C154 (\11\:n20 VSS) capacitor c=4.44679e-17
C155 (\7\:qbint VSS) capacitor c=3.84393e-17
C156 (\12\:RNb VSS) capacitor c=1.19795e-16
C157 (\13\:CKbb VSS) capacitor c=1.55474e-16
C158 (\14\:CKbb VSS) capacitor c=1.38098e-16
C159 (\14\:n20 VSS) capacitor c=7.52999e-17
C160 (\15\:n20 VSS) capacitor c=6.1545e-17
C161 (\16\:n20 VSS) capacitor c=5.98052e-17
C162 (\19\:CKbb VSS) capacitor c=5.61218e-17
C163 (\7\:CK VSS) capacitor c=8.4105e-17
C164 (\15\:CKb VSS) capacitor c=6.28153e-17
C165 (\16\:CKb VSS) capacitor c=4.09685e-17
C166 (\6\:D VSS) capacitor c=4.80153e-17
C167 (\7\:mout VSS) capacitor c=8.26205e-17
C168 (\9\:mout VSS) capacitor c=6.4648e-17
C169 (\10\:mout VSS) capacitor c=5.26265e-17
C170 (\17\:mout VSS) capacitor c=4.55409e-17
C171 (\7\:SE VSS) capacitor c=5.24686e-17
C172 (\6\:SEb VSS) capacitor c=8.17114e-17
C173 (\7\:SEb VSS) capacitor c=6.71871e-17
C174 (\6\:n35 VSS) capacitor c=7.90922e-17
C175 (\19\:CKb VSS) capacitor c=3.96414e-17
C176 (\20\:CKb VSS) capacitor c=4.2063e-17
C177 (\8\:n35g VSS) capacitor c=3.48863e-17
C178 (\11\:n35 VSS) capacitor c=7.50013e-17
C179 (\12\:qbint VSS) capacitor c=8.77437e-17
C180 (\13\:qbint VSS) capacitor c=1.12023e-16
C181 (\13\:n35g VSS) capacitor c=1.03947e-16
C182 (\14\:n35g VSS) capacitor c=1.15912e-16
C183 (\5\:RTb VSS) capacitor c=4.92957e-17
C184 (\8\:RTb VSS) capacitor c=1.00061e-16
C185 (\9\:RTb VSS) capacitor c=9.13858e-17
C186 (\9\:RT VSS) capacitor c=1.19039e-16
C187 (\10\:RT VSS) capacitor c=1.18186e-16
C188 (\11\:RT VSS) capacitor c=3.80585e-17
C189 (\15\:RNb VSS) capacitor c=1.13564e-16
C190 (\16\:RNb VSS) capacitor c=1.13929e-16
C191 (\20\:CKbb VSS) capacitor c=1.5381e-16
C192 (\21\:CKbb VSS) capacitor c=1.43916e-16
C193 (\18\:qbint VSS) capacitor c=2.25365e-17
C194 (\19\:qbint VSS) capacitor c=3.20899e-17
C195 (\16\:n35 VSS) capacitor c=8.97661e-17
C196 (\3\:Q VSS) capacitor c=1.78346e-17
C197 (\6\:VDD VSS) capacitor c=1.99067e-16
C198 (\7\:VDD VSS) capacitor c=2.17233e-17
C199 (\9\:VDD VSS) capacitor c=2.94541e-17
C200 (\16\:VDD VSS) capacitor c=5.08481e-17
Rk33 (SI \4\:SI) resistor r=0.001854 c=0
Rk34 (\4\:SI \5\:SI) resistor r=0.001854 c=0
Rk35 (\6\:SI SI) resistor r=0.001854 c=0
Rk36 (\4\:SI \6\:SI) resistor r=0.01025 c=0
Rk1 (\5\:RN RN) resistor r=0.006385 c=0
Rk63 (RT \9\:RT) resistor r=0.1847 c=0
Rk64 (\9\:RT \10\:RT) resistor r=0.6593 c=0
Rk65 (RT \11\:RT) resistor r=0.01483 c=0
Rk72 (\3\:Q Q) resistor r=0.02782 c=0
Rk71 (\2\:Q \3\:Q) resistor r=0.1934 c=0
Rk73 (\3\:Q \5\:Q) resistor r=0.3685 c=0
Rk13 (CK \5\:CK) resistor r=0.003455 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01476 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.003637 c=0
Rk87 (VDD VDD) resistor r=0.2369 c=0
Rk75 (\2\:VDD \4\:VDD) resistor r=0.2907 c=0
Rk76 (\4\:VDD \5\:VDD) resistor r=0.1196 c=0
Rk77 (\5\:VDD \6\:VDD) resistor r=1.5124 c=0
Rk78 (\6\:VDD \7\:VDD) resistor r=0.2384 c=0
Rk79 (\7\:VDD \9\:VDD) resistor r=0.1024 c=0
Rk80 (\4\:VDD \11\:VDD) resistor r=0.3603 c=0
Rk81 (\6\:VDD \13\:VDD) resistor r=0.3682 c=0
Rk82 (\7\:VDD \15\:VDD) resistor r=0.2001 c=0
Rk86 (\16\:VDD VDD) resistor r=0.1961 c=0
Rk83 (\9\:VDD \16\:VDD) resistor r=0.1715 c=0
Rk84 (\16\:VDD \18\:VDD) resistor r=0.2027 c=0
Rk85 (\9\:VDD \20\:VDD) resistor r=0.2388 c=0
Rk88 (VDD \22\:VDD) resistor r=0.3797 c=0
Rk37 (SE \7\:SE) resistor r=0.04331 c=0
Rk50 (ExtVDD ExtVDD) resistor r=0.002067 c=0
Rk48 (\2\:ExtVDD ExtVDD) resistor r=0.02221 c=0
Rk51 (ExtVDD \5\:ExtVDD) resistor r=0.02019 c=0
Rk52 (ExtVDD \6\:ExtVDD) resistor r=0.15 c=0
Rk19 (\5\:D D) resistor r=0.007222 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01656 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007222 c=0
Rk89 (\2\:VSS \3\:VSS) resistor r=0.0421 c=0
Rk90 (\3\:VSS \4\:VSS) resistor r=0.1068 c=0
Rk91 (\4\:VSS \5\:VSS) resistor r=0.6641 c=0
Rk92 (\5\:VSS \6\:VSS) resistor r=0.03215 c=0
Rk94 (\7\:VSS VSS) resistor r=0.2707 c=0
Rk93 (\6\:VSS \7\:VSS) resistor r=0.1764 c=0
Rk95 (VSS \8\:VSS) resistor r=0.3732 c=0
Rk96 (\8\:VSS \9\:VSS) resistor r=0.3081 c=0
Rk98 (\10\:VSS VSS) resistor r=0.1217 c=0
Rk97 (\9\:VSS \10\:VSS) resistor r=0.06449 c=0
Rk99 (VSS \12\:VSS) resistor r=0.3134 c=0
Rk100 (\3\:VSS \14\:VSS) resistor r=0.262 c=0
Rk101 (\5\:VSS \16\:VSS) resistor r=0.1902 c=0
Rk102 (\7\:VSS \18\:VSS) resistor r=0.1953 c=0
Rk103 (\8\:VSS \20\:VSS) resistor r=0.2547 c=0
Rk104 (\9\:VSS \22\:VSS) resistor r=0.2503 c=0
Rk105 (\24\:VSS \25\:VSS) resistor r=0.08688 c=0
Rk106 (\25\:VSS \26\:VSS) resistor r=0.311 c=0
Rk107 (\26\:VSS \27\:VSS) resistor r=0.3185 c=0
Rk109 (\28\:VSS VSS) resistor r=0.1988 c=0
Rk108 (\27\:VSS \28\:VSS) resistor r=0.3282 c=0
Rk110 (VSS \29\:VSS) resistor r=0.6817 c=0
Rk112 (\30\:VSS VSS) resistor r=0.1217 c=0
Rk111 (\29\:VSS \30\:VSS) resistor r=0.06449 c=0
Rk113 (VSS \31\:VSS) resistor r=0.01747 c=0
Rk114 (\31\:VSS \33\:VSS) resistor r=0.6655 c=0
Rk115 (\25\:VSS \35\:VSS) resistor r=0.2482 c=0
Rk116 (\27\:VSS \37\:VSS) resistor r=0.2448 c=0
Rk117 (\29\:VSS \39\:VSS) resistor r=0.2412 c=0
Rk118 (\31\:VSS \41\:VSS) resistor r=0.2412 c=0
Rk2 (\8\:n20 \10\:n20) resistor r=0.546 c=0
Rk3 (\10\:n20 \11\:n20) resistor r=0.2555 c=0
Rk7 (\13\:n20 \14\:n20) resistor r=0.3473 c=0
Rk8 (\13\:n20 \15\:n20) resistor r=0.2307 c=0
Rk9 (\15\:n20 \16\:n20) resistor r=0.2517 c=0
Rk10 (\16\:n20 \18\:n20) resistor r=0.2474 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8535 c=0
Rk11 (\16\:CKbb \18\:CKbb) resistor r=0.5348 c=0
Rk12 (\18\:CKbb \19\:CKbb) resistor r=0.2047 c=0
Rk67 (\20\:CKbb \21\:CKbb) resistor r=0.9488 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.6054 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.5102 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.04826 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.198 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1285 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.5423 c=0
Rk31 (\9\:mout \16\:mout) resistor r=0.1048 c=0
Rk32 (\10\:mout \17\:mout) resistor r=0.3958 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3527 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1588 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.1646 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.3735 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1643 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3826 c=0
Rk66 (\15\:RNb \16\:RNb) resistor r=0.6792 c=0
Rk38 (\5\:SEb \6\:SEb) resistor r=0.2181 c=0
Rk39 (\6\:SEb \7\:SEb) resistor r=0.3488 c=0
Rk40 (\6\:SEb \9\:SEb) resistor r=0.3114 c=0
Rk44 (\7\:n35g \8\:n35g) resistor r=0.2748 c=0
Rk45 (\7\:n35g \10\:n35g) resistor r=0.6952 c=0
Rk56 (\12\:n35g \13\:n35g) resistor r=0.2443 c=0
Rk57 (\13\:n35g \14\:n35g) resistor r=0.5686 c=0
Rk58 (\13\:n35g \16\:n35g) resistor r=0.4343 c=0
Rk53 (\12\:qbint \13\:qbint) resistor r=0.4973 c=0
Rk54 (\13\:qbint \15\:qbint) resistor r=0.5702 c=0
Rk55 (\13\:qbint \17\:qbint) resistor r=0.1471 c=0
Rk68 (\18\:qbint \19\:qbint) resistor r=0.2424 c=0
Rk59 (\5\:RTb \7\:RTb) resistor r=0.2174 c=0
Rk60 (\7\:RTb \8\:RTb) resistor r=0.4188 c=0
Rk61 (\8\:RTb \9\:RTb) resistor r=0.6924 c=0
Rk62 (\8\:RTb \11\:RTb) resistor r=0.3083 c=0
Rk41 (\5\:n35 \6\:n35) resistor r=0.412 c=0
Rk42 (\6\:n35 \8\:n35) resistor r=0.2919 c=0
Rk46 (\10\:n35 \11\:n35) resistor r=0.4031 c=0
Rk47 (\11\:n35 \13\:n35) resistor r=0.3317 c=0
Rk69 (\15\:n35 \16\:n35) resistor r=0.4129 c=0
Rk70 (\16\:n35 \18\:n35) resistor r=0.3473 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6398 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.4053 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5681 c=0
Rk74 (\2\:n10 \4\:n10) resistor r=0.5717 c=0
Rl21 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl20 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl55 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl42 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl45 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl44 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl43 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl24 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl26 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl23 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl25 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl22 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl17 (\2\:D \4\:D) resistor r=115.099 c=0
Rl15 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl16 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\5\:n20 \6\:n20) resistor r=285.406 c=0
Rl13 (\3\:n20 \4\:n20) resistor r=208.269 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=213.245 c=0
Rl5 (CKbb \2\:CKbb) resistor r=38.8525 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=66.575 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=264.436 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=65.3159 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=753.137 c=0
Rl54 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=455.369 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl63 (\11\:CKb \12\:CKb) resistor r=804.248 c=0
Rl27 (CKb \2\:CKb) resistor r=349.798 c=0
Rl32 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl29 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl33 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl28 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl30 (\4\:CKb \5\:CKb) resistor r=61.3849 c=0
Rl34 (\5\:CKb \9\:CKb) resistor r=146 c=0
Rl31 (\5\:CKb \6\:CKb) resistor r=271.541 c=0
Rl35 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl70 (\7\:RNb \8\:RNb) resistor r=233.721 c=0
Rl71 (\8\:RNb \9\:RNb) resistor r=267.896 c=0
Rl56 (RNb \2\:RNb) resistor r=1075.02 c=0
Rl59 (\2\:RNb \5\:RNb) resistor r=114.179 c=0
Rl60 (\3\:RNb \6\:RNb) resistor r=153.384 c=0
Rl58 (\3\:RNb \4\:RNb) resistor r=293.646 c=0
Rl57 (\2\:RNb \3\:RNb) resistor r=46.238 c=0
Rl18 (SEb \2\:SEb) resistor r=101.718 c=0
Rl19 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl38 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl36 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl37 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl39 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl69 (\10\:qbint \11\:qbint) resistor r=260.089 c=0
Rl68 (\8\:qbint \10\:qbint) resistor r=512.697 c=0
Rl49 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl46 (qbint \2\:qbint) resistor r=112.732 c=0
Rl48 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl47 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl67 (\7\:qbint \9\:qbint) resistor r=70.3116 c=0
Rl65 (\6\:qbint \7\:qbint) resistor r=76.2993 c=0
Rl66 (\7\:qbint \8\:qbint) resistor r=254.112 c=0
Rl40 (RTb \2\:RTb) resistor r=112.412 c=0
Rl41 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl61 (n35 \2\:n35) resistor r=442.189 c=0
Rl62 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz22 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz23 (\3\:VDD \5\:VDD) resistor r=25 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz27 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz28 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz11 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz20 (n10 \2\:n10) resistor r=75 c=0
Rz21 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry21 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\10\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry24 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry25 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry31 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry33 (\23\:VSS \24\:VSS) resistor r=31 c=0
Ry34 (\23\:VSS \26\:VSS) resistor r=10.3333 c=0
Ry35 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry36 (\23\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry3 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Rx15 (\2\:SI \5\:SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx27 (\3\:RT \9\:RT) resistor r=45 c=0
Rx28 (\1\:RT \10\:RT) resistor r=45 c=0
Rx29 (\7\:RT \11\:RT) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx16 (\1\:SE \7\:SE) resistor r=45 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \11\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx7 (\6\:n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:n20 \16\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx9 (CKbb \19\:CKbb) resistor r=45 c=0
Rx32 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx33 (\5\:CKbb \21\:CKbb) resistor r=45 c=0
Rx13 (\4\:mout \10\:mout) resistor r=45 c=0
Rx14 (\2\:mout \17\:mout) resistor r=45 c=0
Rx11 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx19 (CKb \19\:CKb) resistor r=45 c=0
Rx20 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx3 (\4\:RNb \12\:RNb) resistor r=45 c=0
Rx30 (RNb \15\:RNb) resistor r=45 c=0
Rx31 (\9\:RNb \16\:RNb) resistor r=45 c=0
Rx17 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx21 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx24 (n35g \14\:n35g) resistor r=45 c=0
Rx23 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx34 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx35 (qbint \19\:qbint) resistor r=45 c=0
Rx25 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx26 (RTb \9\:RTb) resistor r=45 c=0
Rx18 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx22 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx36 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\15\:mout \6\:RNb \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \9\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \11\:qbint \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n10 \8\:RNb \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\9\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\12\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.17022 \
        scb=0.00118687 scc=2.51048e-06 m=(1)
mp31 (n5 \5\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.5373 \
        scb=0.0297678 scc=0.00268647 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=19.3315 \
        scb=0.0212584 scc=0.000579348 m=(1)
mp55 (\4\:Q \9\:qbint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.4029 \
        scb=0.0248226 scc=0.000748112 m=(1)
mp51 (n9 \7\:RNb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=19.1728 \
        scb=0.0210507 scc=0.000546994 m=(1)
ends SRDFFRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:03:52 2012 )
// Library name: gsclib045
// Cell name: SRDFFRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFRX1 CK D ExtVDD Q QN RN RT SE SI VDD VSS
mp22 (\8\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (Q VSS) capacitor c=6.77488e-17
C2 (ExtVDD VSS) capacitor c=2.30193e-16
C3 (SI VSS) capacitor c=9.04304e-17
C4 (RN VSS) capacitor c=8.36082e-17
C5 (RT VSS) capacitor c=6.00722e-17
C6 (QN VSS) capacitor c=2.76152e-17
C7 (VDD VSS) capacitor c=7.54776e-16
C8 (SE VSS) capacitor c=9.23296e-17
C9 (D VSS) capacitor c=3.83522e-17
C10 (n20 VSS) capacitor c=3.92699e-17
C11 (CKbb VSS) capacitor c=2.88856e-17
C12 (mout VSS) capacitor c=4.80664e-17
C13 (CKb VSS) capacitor c=5.97859e-17
C14 (RNb VSS) capacitor c=5.78139e-17
C15 (SEb VSS) capacitor c=7.75136e-17
C16 (n35g VSS) capacitor c=1.77753e-17
C17 (qbint VSS) capacitor c=4.54407e-17
C18 (RTb VSS) capacitor c=5.18061e-17
C19 (net573 VSS) capacitor c=2.25772e-17
C20 (n35 VSS) capacitor c=1.5135e-16
C21 (Db VSS) capacitor c=1.058e-16
C22 (n11 VSS) capacitor c=6.29546e-17
C23 (n10 VSS) capacitor c=7.48782e-17
C24 (n1 VSS) capacitor c=1.02126e-18
C25 (\7\:qbint VSS) capacitor c=3.36523e-17
C26 (\11\:qbint VSS) capacitor c=1.20328e-16
C27 (\2\:RNb VSS) capacitor c=3.69147e-16
C28 (\13\:qbint VSS) capacitor c=4.40915e-17
C29 (\3\:net573 VSS) capacitor c=5.86778e-17
C30 (\11\:CKbb VSS) capacitor c=5.65953e-17
C31 (\4\:RTb VSS) capacitor c=9.88373e-17
C32 (\6\:RT VSS) capacitor c=2.20693e-17
C33 (\4\:qbint VSS) capacitor c=5.36612e-17
C34 (\3\:n35g VSS) capacitor c=5.19979e-17
C35 (\5\:RT VSS) capacitor c=6.97914e-17
C36 (\3\:SE VSS) capacitor c=7.6545e-17
C37 (\7\:CKb VSS) capacitor c=3.4512e-17
C38 (\3\:SI VSS) capacitor c=9.47782e-17
C39 (\4\:SE VSS) capacitor c=1.23145e-16
C40 (\7\:RNb VSS) capacitor c=5.99721e-17
C41 (\4\:D VSS) capacitor c=7.03535e-17
C42 (\5\:n20 VSS) capacitor c=9.42183e-17
C43 (\4\:CK VSS) capacitor c=5.9719e-17
C44 (\4\:CKb VSS) capacitor c=4.61759e-17
C45 (\8\:CKb VSS) capacitor c=8.21133e-17
C46 (\3\:CKbb VSS) capacitor c=2.54163e-17
C47 (\1\:RN VSS) capacitor c=4.14282e-17
C48 (\6\:qbint VSS) capacitor c=3.74891e-17
C49 (\12\:qbint VSS) capacitor c=5.80945e-17
C50 (\14\:qbint VSS) capacitor c=4.60218e-17
C51 (\4\:net573 VSS) capacitor c=3.68027e-17
C52 (\11\:CKb VSS) capacitor c=2.02821e-16
C53 (\8\:RT VSS) capacitor c=1.22101e-16
C54 (\2\:RT VSS) capacitor c=6.23027e-17
C55 (\5\:qbint VSS) capacitor c=3.89021e-17
C56 (\5\:n35g VSS) capacitor c=3.28666e-17
C57 (\2\:RTb VSS) capacitor c=4.86582e-17
C58 (\5\:SE VSS) capacitor c=5.77695e-17
C59 (\5\:CKbb VSS) capacitor c=3.48485e-17
C60 (\1\:SI VSS) capacitor c=4.91308e-17
C61 (\6\:SE VSS) capacitor c=8.62193e-17
C62 (\6\:RNb VSS) capacitor c=5.26448e-17
C63 (\3\:SEb VSS) capacitor c=6.59873e-17
C64 (\1\:D VSS) capacitor c=4.94494e-17
C65 (\3\:n20 VSS) capacitor c=4.38664e-17
C66 (\1\:CK VSS) capacitor c=2.87619e-17
C67 (\3\:mout VSS) capacitor c=5.01444e-17
C68 (\9\:CKb VSS) capacitor c=3.86211e-17
C69 (\10\:CKbb VSS) capacitor c=4.92772e-17
C70 (\6\:CKb VSS) capacitor c=4.9159e-17
C71 (\4\:RN VSS) capacitor c=3.68513e-17
C72 (\12\:CKbb VSS) capacitor c=5.16127e-17
C73 (\10\:qbint VSS) capacitor c=8.53651e-17
C74 (\7\:RT VSS) capacitor c=1.52948e-16
C75 (\9\:CKbb VSS) capacitor c=1.67521e-16
C76 (\3\:RT VSS) capacitor c=5.08277e-17
C77 (\1\:RT VSS) capacitor c=5.22705e-17
C78 (\3\:RTb VSS) capacitor c=7.5942e-17
C79 (\3\:qbint VSS) capacitor c=4.42891e-17
C80 (\2\:n35 VSS) capacitor c=2.32651e-16
C81 (\4\:n35g VSS) capacitor c=6.68719e-17
C82 (\12\:CKb VSS) capacitor c=2.17818e-16
C83 (\3\:n35 VSS) capacitor c=1.06034e-16
C84 (\1\:SE VSS) capacitor c=2.48216e-17
C85 (\2\:SI VSS) capacitor c=7.769e-17
C86 (\2\:SEb VSS) capacitor c=7.74591e-17
C87 (\3\:D VSS) capacitor c=1.47465e-17
C88 (\6\:n20 VSS) capacitor c=8.05878e-17
C89 (\4\:n20 VSS) capacitor c=3.85621e-17
C90 (\3\:CK VSS) capacitor c=2.32859e-17
C91 (\2\:mout VSS) capacitor c=3.17302e-17
C92 (\4\:mout VSS) capacitor c=3.92547e-17
C93 (\7\:n20 VSS) capacitor c=5.4197e-17
C94 (\4\:CKbb VSS) capacitor c=7.10193e-17
C95 (\8\:CKbb VSS) capacitor c=2.70288e-17
C96 (\5\:RNb VSS) capacitor c=1.19217e-16
C97 (\2\:n20 VSS) capacitor c=4.55346e-17
C98 (\3\:RN VSS) capacitor c=4.75117e-17
C99 (\1\:VDD VSS) capacitor c=4.93951e-17
C100 (\3\:Q VSS) capacitor c=7.29834e-17
C101 (\11\:VDD VSS) capacitor c=4.90276e-17
C102 (\9\:net573 VSS) capacitor c=5.58518e-17
C103 (\13\:VDD VSS) capacitor c=7.96787e-17
C104 (\3\:n11 VSS) capacitor c=9.94421e-17
C105 (\4\:QN VSS) capacitor c=5.9451e-17
C106 (\14\:n35 VSS) capacitor c=5.24739e-17
C107 (\15\:n35g VSS) capacitor c=5.5909e-17
C108 (\6\:RTb VSS) capacitor c=7.24208e-17
C109 (\1\:ExtVDD VSS) capacitor c=2.78533e-16
C110 (\9\:n35 VSS) capacitor c=6.19273e-17
C111 (\17\:qbint VSS) capacitor c=6.81986e-17
C112 (\6\:n35g VSS) capacitor c=9.60383e-17
C113 (\8\:SEb VSS) capacitor c=5.06071e-17
C114 (\4\:n35 VSS) capacitor c=6.12731e-17
C115 (\15\:VDD VSS) capacitor c=6.10012e-17
C116 (\5\:mout VSS) capacitor c=7.76403e-17
C117 (\3\:Db VSS) capacitor c=1.90964e-16
C118 (\17\:VDD VSS) capacitor c=3.85232e-17
C119 (\22\:VDD VSS) capacitor c=3.52556e-17
C120 (\13\:mout VSS) capacitor c=5.83998e-17
C121 (\17\:CKb VSS) capacitor c=2.91722e-17
C122 (\20\:VDD VSS) capacitor c=4.12536e-17
C123 (\17\:CKbb VSS) capacitor c=6.76195e-17
C124 (\13\:n20 VSS) capacitor c=6.3032e-17
C125 (\5\:Db VSS) capacitor c=2.18772e-16
C126 (\8\:RNb VSS) capacitor c=5.40837e-17
C127 (\10\:n20 VSS) capacitor c=6.3646e-17
C128 (\24\:VDD VSS) capacitor c=4.25619e-17
C129 (\1\:Q VSS) capacitor c=5.32881e-17
C130 (\5\:net573 VSS) capacitor c=4.31427e-17
C131 (\3\:n10 VSS) capacitor c=7.9152e-17
C132 (\1\:QN VSS) capacitor c=3.75793e-17
C133 (\17\:n35 VSS) capacitor c=4.13331e-17
C134 (\11\:n35g VSS) capacitor c=2.96827e-17
C135 (\10\:RTb VSS) capacitor c=5.81982e-17
C136 (\12\:n35 VSS) capacitor c=6.35168e-17
C137 (\19\:qbint VSS) capacitor c=2.43447e-17
C138 (\9\:n35g VSS) capacitor c=7.72521e-17
C139 (\4\:SEb VSS) capacitor c=3.862e-17
C140 (\7\:n35 VSS) capacitor c=3.77874e-17
C141 (\11\:mout VSS) capacitor c=3.75653e-17
C142 (\15\:mout VSS) capacitor c=2.97046e-17
C143 (\13\:CKb VSS) capacitor c=6.50014e-17
C144 (\15\:CKbb VSS) capacitor c=8.31141e-17
C145 (\17\:n20 VSS) capacitor c=8.30467e-17
C146 (\7\:Db VSS) capacitor c=7.74174e-17
C147 (\11\:RNb VSS) capacitor c=7.08116e-17
C148 (\8\:n20 VSS) capacitor c=5.88674e-17
C149 (VDD VSS) capacitor c=6.97221e-17
C150 (\2\:CKbb VSS) capacitor c=6.16702e-17
C151 (\2\:CK VSS) capacitor c=3.36601e-17
C152 (\2\:D VSS) capacitor c=3.55457e-17
C153 (\2\:SE VSS) capacitor c=2.57292e-17
C154 (\2\:CKb VSS) capacitor c=1.43171e-16
C155 (\3\:CKb VSS) capacitor c=7.50789e-17
C156 (\5\:CKb VSS) capacitor c=7.54648e-17
C157 (\2\:n35g VSS) capacitor c=2.91124e-17
C158 (\4\:RT VSS) capacitor c=5.2386e-17
C159 (\2\:qbint VSS) capacitor c=4.11016e-17
C160 (\6\:CKbb VSS) capacitor c=1.28162e-16
C161 (\7\:CKbb VSS) capacitor c=6.52723e-17
C162 (\2\:net573 VSS) capacitor c=1.5367e-17
C163 (\12\:n20 VSS) capacitor c=4.40692e-17
C164 (\3\:RNb VSS) capacitor c=2.91833e-16
C165 (\4\:RNb VSS) capacitor c=1.1855e-16
C166 (\10\:RNb VSS) capacitor c=1.20246e-16
C167 (\13\:CKbb VSS) capacitor c=1.55458e-16
C168 (\14\:CKbb VSS) capacitor c=1.38277e-16
C169 (\15\:n20 VSS) capacitor c=7.5196e-17
C170 (\16\:n20 VSS) capacitor c=9.28307e-17
C171 (\8\:qbint VSS) capacitor c=5.11452e-17
C172 (\9\:qbint VSS) capacitor c=7.72727e-17
C173 (\19\:CKbb VSS) capacitor c=5.16846e-17
C174 (\5\:CK VSS) capacitor c=4.77117e-17
C175 (\6\:CK VSS) capacitor c=3.67433e-17
C176 (\19\:n20 VSS) capacitor c=4.89495e-17
C177 (\20\:n20 VSS) capacitor c=4.84792e-17
C178 (\15\:CKb VSS) capacitor c=6.11815e-17
C179 (\16\:CKb VSS) capacitor c=4.13179e-17
C180 (\7\:D VSS) capacitor c=4.85056e-17
C181 (\7\:mout VSS) capacitor c=8.35937e-17
C182 (\8\:mout VSS) capacitor c=5.28295e-17
C183 (\9\:mout VSS) capacitor c=1.90246e-17
C184 (\10\:mout VSS) capacitor c=7.5834e-17
C185 (\17\:mout VSS) capacitor c=7.40516e-17
C186 (\6\:n35 VSS) capacitor c=7.11534e-17
C187 (\6\:SEb VSS) capacitor c=8.35365e-17
C188 (\7\:SEb VSS) capacitor c=6.80475e-17
C189 (\19\:CKb VSS) capacitor c=3.49327e-17
C190 (\20\:CKb VSS) capacitor c=3.64971e-17
C191 (\8\:n35g VSS) capacitor c=3.39835e-17
C192 (\11\:n35 VSS) capacitor c=7.49055e-17
C193 (\15\:qbint VSS) capacitor c=8.78471e-17
C194 (\16\:qbint VSS) capacitor c=1.11964e-16
C195 (\13\:n35g VSS) capacitor c=1.02815e-16
C196 (\14\:n35g VSS) capacitor c=1.1611e-16
C197 (\5\:RTb VSS) capacitor c=4.9153e-17
C198 (\8\:RTb VSS) capacitor c=9.96219e-17
C199 (\9\:RTb VSS) capacitor c=9.1018e-17
C200 (\10\:RT VSS) capacitor c=1.04967e-16
C201 (\11\:RT VSS) capacitor c=1.18336e-16
C202 (\21\:qbint VSS) capacitor c=2.43468e-17
C203 (\22\:qbint VSS) capacitor c=3.00163e-17
C204 (\20\:CKbb VSS) capacitor c=9.70534e-17
C205 (\21\:CKbb VSS) capacitor c=1.00377e-16
C206 (\3\:QN VSS) capacitor c=3.73666e-17
C207 (\16\:n35 VSS) capacitor c=4.45599e-17
C208 (\7\:net573 VSS) capacitor c=5.35006e-17
C209 (\8\:net573 VSS) capacitor c=3.44553e-17
C210 (\3\:VDD VSS) capacitor c=5.03511e-17
C211 (\5\:VDD VSS) capacitor c=9.96254e-18
C212 (\6\:VDD VSS) capacitor c=2.20714e-16
C213 (\7\:VDD VSS) capacitor c=2.06079e-16
C214 (\8\:VDD VSS) capacitor c=2.3561e-17
C215 (\10\:VDD VSS) capacitor c=3.18808e-17
C216 (\19\:VDD VSS) capacitor c=5.20684e-17
Rk74 (\2\:Q Q) resistor r=0.1701 c=0
Rk75 (Q \4\:Q) resistor r=0.2885 c=0
Rk47 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk45 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk48 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk49 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk1 (\5\:RN RN) resistor r=0.006381 c=0
Rk61 (RT \10\:RT) resistor r=0.1993 c=0
Rk62 (\10\:RT \11\:RT) resistor r=0.6434 c=0
Rk12 (CK \5\:CK) resistor r=0.004361 c=0
Rk14 (\5\:CK \6\:CK) resistor r=0.01475 c=0
Rk13 (\6\:CK \7\:CK) resistor r=0.004543 c=0
Rk66 (\3\:QN QN) resistor r=0.01499 c=0
Rk65 (\2\:QN \3\:QN) resistor r=0.2917 c=0
Rk67 (\3\:QN \5\:QN) resistor r=0.3259 c=0
Rk108 (VDD VDD) resistor r=0.2367 c=0
Rk94 (\2\:VDD \3\:VDD) resistor r=0.578 c=0
Rk95 (\3\:VDD \5\:VDD) resistor r=0.06692 c=0
Rk96 (\5\:VDD \6\:VDD) resistor r=0.05201 c=0
Rk97 (\6\:VDD \7\:VDD) resistor r=1.5259 c=0
Rk98 (\7\:VDD \8\:VDD) resistor r=0.186 c=0
Rk99 (\8\:VDD \10\:VDD) resistor r=0.1545 c=0
Rk100 (\3\:VDD \12\:VDD) resistor r=0.294 c=0
Rk101 (\6\:VDD \14\:VDD) resistor r=0.3757 c=0
Rk102 (\7\:VDD \16\:VDD) resistor r=0.3677 c=0
Rk103 (\8\:VDD \18\:VDD) resistor r=0.2024 c=0
Rk107 (\19\:VDD VDD) resistor r=0.1959 c=0
Rk104 (\10\:VDD \19\:VDD) resistor r=0.1713 c=0
Rk105 (\19\:VDD \21\:VDD) resistor r=0.1998 c=0
Rk106 (\10\:VDD \23\:VDD) resistor r=0.2381 c=0
Rk109 (VDD \25\:VDD) resistor r=0.3792 c=0
Rk19 (\5\:D D) resistor r=0.006794 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01719 c=0
Rk20 (\6\:D \7\:D) resistor r=0.006794 c=0
Rk77 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk78 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk79 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk80 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk81 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk83 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk82 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk84 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk85 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk87 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk86 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk88 (VSS \14\:VSS) resistor r=0.313 c=0
Rk89 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk90 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk91 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk92 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk93 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk110 (\26\:VSS \27\:VSS) resistor r=0.08432 c=0
Rk111 (\27\:VSS \28\:VSS) resistor r=0.1142 c=0
Rk112 (\28\:VSS \29\:VSS) resistor r=0.0893 c=0
Rk113 (\29\:VSS \30\:VSS) resistor r=0.3578 c=0
Rk115 (\31\:VSS VSS) resistor r=0.3774 c=0
Rk114 (\30\:VSS \31\:VSS) resistor r=0.3679 c=0
Rk116 (VSS \32\:VSS) resistor r=0.1494 c=0
Rk118 (\33\:VSS VSS) resistor r=0.3252 c=0
Rk117 (\32\:VSS \33\:VSS) resistor r=0.5417 c=0
Rk119 (VSS \34\:VSS) resistor r=0.01745 c=0
Rk120 (\34\:VSS \35\:VSS) resistor r=0.05947 c=0
Rk121 (\35\:VSS \37\:VSS) resistor r=0.6053 c=0
Rk122 (\27\:VSS \39\:VSS) resistor r=0.2409 c=0
Rk123 (\29\:VSS \41\:VSS) resistor r=0.2472 c=0
Rk124 (\31\:VSS \43\:VSS) resistor r=0.2445 c=0
Rk125 (\33\:VSS \45\:VSS) resistor r=0.2409 c=0
Rk126 (\34\:VSS \47\:VSS) resistor r=0.2409 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3469 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2525 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4762 c=0
Rk15 (\19\:n20 \20\:n20) resistor r=0.2144 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8523 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.5355 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.194 c=0
Rk64 (\20\:CKbb \21\:CKbb) resistor r=0.7635 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.6076 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.3647 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.1128 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.2021 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1352 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.525 c=0
Rk31 (\9\:mout \16\:mout) resistor r=0.09784 c=0
Rk32 (\10\:mout \17\:mout) resistor r=0.426 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3503 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1622 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.1643 c=0
Rk40 (\19\:CKb \20\:CKb) resistor r=0.3729 c=0
Rk4 (\9\:RNb \10\:RNb) resistor r=0.193 c=0
Rk5 (\10\:RNb \12\:RNb) resistor r=0.3636 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3502 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk41 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk42 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk53 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk54 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk55 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk50 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk51 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk52 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk63 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk56 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk57 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk58 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk59 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk70 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk71 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk72 (\7\:net573 \10\:net573) resistor r=0.2923 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk43 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk44 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.3075 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.2886 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.3936 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5673 c=0
Rk76 (\2\:n11 \4\:n11) resistor r=0.71 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.6281 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl43 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl46 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl45 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl44 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\2\:D \4\:D) resistor r=115.099 c=0
Rl16 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl17 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\5\:n20 \6\:n20) resistor r=190.564 c=0
Rl13 (\3\:n20 \4\:n20) resistor r=90.3645 c=0
Rl15 (\6\:n20 \7\:n20) resistor r=117.486 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl59 (\11\:CKbb \12\:CKbb) resistor r=137.716 c=0
Rl5 (CKbb \2\:CKbb) resistor r=39.6682 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=65.0422 c=0
Rl54 (\6\:CKbb \9\:CKbb) resistor r=808.345 c=0
Rl55 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl53 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl52 (\6\:CKbb \7\:CKbb) resistor r=416.829 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl60 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl28 (CKb \2\:CKb) resistor r=395.821 c=0
Rl33 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl30 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl34 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl29 (\2\:CKb \3\:CKb) resistor r=385.443 c=0
Rl31 (\4\:CKb \5\:CKb) resistor r=58.0449 c=0
Rl35 (\5\:CKb \9\:CKb) resistor r=133.091 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=268.582 c=0
Rl36 (\5\:CKb \10\:CKb) resistor r=4.0748 c=0
Rl64 (RNb \2\:RNb) resistor r=234.8 c=0
Rl65 (\2\:RNb \3\:RNb) resistor r=1469.68 c=0
Rl68 (\3\:RNb \6\:RNb) resistor r=180.888 c=0
Rl69 (\4\:RNb \7\:RNb) resistor r=75.8186 c=0
Rl67 (\4\:RNb \5\:RNb) resistor r=424.798 c=0
Rl66 (\3\:RNb \4\:RNb) resistor r=83.4088 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl39 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl37 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl38 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl40 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl70 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl75 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl77 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl50 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl47 (qbint \2\:qbint) resistor r=112.732 c=0
Rl49 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl48 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl71 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl74 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl76 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl73 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl72 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl41 (RTb \2\:RTb) resistor r=112.412 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl61 (net573 \2\:net573) resistor r=3.1216 c=0
Rl62 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl63 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl57 (n35 \2\:n35) resistor r=508.667 c=0
Rl58 (\2\:n35 \3\:n35) resistor r=380.826 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz18 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz24 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz25 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz26 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz27 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz28 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz30 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz36 (\42\:VSS \43\:VSS) resistor r=75 c=0
Rz37 (\44\:VSS \45\:VSS) resistor r=75 c=0
Rz38 (\46\:VSS \47\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz2 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz11 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz20 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz19 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry23 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry32 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry33 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry34 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry37 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=31 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=31 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \32\:VSS) resistor r=5.6364 c=0
Ry42 (\25\:VSS \35\:VSS) resistor r=7.75 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry2 (\8\:RNb \9\:RNb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry24 (n11 \2\:n11) resistor r=62 c=0
Ry25 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\3\:CK \7\:CK) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\7\:n20 \16\:n20) resistor r=45 c=0
Rx10 (\6\:n20 \19\:n20) resistor r=45 c=0
Rx11 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx12 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (CKb \19\:CKb) resistor r=45 c=0
Rx21 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx3 (\5\:RNb \10\:RNb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx31 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx32 (qbint \22\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx36 (net573 \8\:net573) resistor r=45 c=0
Rx18 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx35 (n35 \16\:n35) resistor r=45 c=0
mn22 (\11\:RNb \4\:RN \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb \44\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \42\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 RNb \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp31 (n5 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.74828 \
        scb=0.00141025 scc=2.59727e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0497 \
        scb=0.0111987 scc=0.000289961 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \2\:RNb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:04:47 2012 )
// Library name: gsclib045
// Cell name: SRDFFSQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSQX1 CK D ExtVDD Q RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=1.95048e-17
C2 (D VSS) capacitor c=7.90325e-17
C3 (ExtVDD VSS) capacitor c=2.25481e-16
C4 (CK VSS) capacitor c=6.15029e-17
C5 (SI VSS) capacitor c=8.75259e-17
C6 (RT VSS) capacitor c=6.46434e-17
C7 (SN VSS) capacitor c=4.79525e-17
C8 (VDD VSS) capacitor c=7.18071e-16
C9 (SE VSS) capacitor c=9.26878e-17
C10 (n20 VSS) capacitor c=3.84704e-17
C11 (CKbb VSS) capacitor c=3.2382e-17
C12 (mout VSS) capacitor c=4.84697e-17
C13 (CKb VSS) capacitor c=5.0436e-17
C14 (SEb VSS) capacitor c=7.76244e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.60369e-17
C17 (RTb VSS) capacitor c=5.17974e-17
C18 (n35 VSS) capacitor c=1.72427e-16
C19 (Db VSS) capacitor c=1.02921e-16
C20 (n11 VSS) capacitor c=8.1482e-17
C21 (n1 VSS) capacitor c=8.87983e-19
C22 (\7\:SN VSS) capacitor c=8.82435e-17
C23 (\7\:qbint VSS) capacitor c=3.7351e-17
C24 (\10\:qbint VSS) capacitor c=1.01692e-16
C25 (\11\:CKbb VSS) capacitor c=4.77402e-17
C26 (\4\:RTb VSS) capacitor c=9.76746e-17
C27 (\6\:RT VSS) capacitor c=2.23208e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.19228e-17
C30 (\5\:RT VSS) capacitor c=6.48326e-17
C31 (\3\:SE VSS) capacitor c=7.71436e-17
C32 (\8\:CKb VSS) capacitor c=2.96146e-17
C33 (\3\:SI VSS) capacitor c=9.43059e-17
C34 (\4\:SE VSS) capacitor c=1.25071e-16
C35 (\4\:D VSS) capacitor c=6.94903e-17
C36 (\3\:n20 VSS) capacitor c=3.30664e-17
C37 (\1\:SN VSS) capacitor c=3.07428e-17
C38 (\4\:CK VSS) capacitor c=6.33781e-17
C39 (\4\:CKb VSS) capacitor c=4.34245e-17
C40 (\9\:CKb VSS) capacitor c=8.38868e-17
C41 (\3\:CKbb VSS) capacitor c=2.64181e-17
C42 (\6\:qbint VSS) capacitor c=4.17716e-17
C43 (\8\:SN VSS) capacitor c=1.46965e-16
C44 (\11\:qbint VSS) capacitor c=1.49802e-16
C45 (\12\:CKb VSS) capacitor c=2.55236e-16
C46 (\8\:RT VSS) capacitor c=1.20655e-16
C47 (\2\:RT VSS) capacitor c=6.21869e-17
C48 (\5\:qbint VSS) capacitor c=3.87334e-17
C49 (\5\:n35g VSS) capacitor c=3.28693e-17
C50 (\2\:RTb VSS) capacitor c=4.65075e-17
C51 (\5\:SE VSS) capacitor c=5.7365e-17
C52 (\5\:CKbb VSS) capacitor c=2.73311e-17
C53 (\1\:SI VSS) capacitor c=4.90982e-17
C54 (\6\:SE VSS) capacitor c=8.63749e-17
C55 (\3\:SEb VSS) capacitor c=6.59314e-17
C56 (\1\:D VSS) capacitor c=4.94601e-17
C57 (\7\:n20 VSS) capacitor c=6.12287e-17
C58 (\6\:SN VSS) capacitor c=6.63573e-17
C59 (\1\:CK VSS) capacitor c=2.87786e-17
C60 (\3\:mout VSS) capacitor c=4.54948e-17
C61 (\11\:CKb VSS) capacitor c=3.86863e-17
C62 (\10\:CKbb VSS) capacitor c=4.83019e-17
C63 (\7\:CKb VSS) capacitor c=5.09176e-17
C64 (\9\:qbint VSS) capacitor c=8.50195e-17
C65 (\12\:CKbb VSS) capacitor c=5.13348e-17
C66 (\3\:SN VSS) capacitor c=2.94979e-16
C67 (\9\:SN VSS) capacitor c=6.35258e-17
C68 (\7\:RT VSS) capacitor c=1.46821e-16
C69 (\9\:CKbb VSS) capacitor c=1.67836e-16
C70 (\3\:RT VSS) capacitor c=3.94588e-17
C71 (\1\:RT VSS) capacitor c=5.29002e-17
C72 (\3\:RTb VSS) capacitor c=7.57746e-17
C73 (\3\:qbint VSS) capacitor c=4.37709e-17
C74 (\2\:n35 VSS) capacitor c=2.52896e-16
C75 (\4\:n35g VSS) capacitor c=6.63869e-17
C76 (\13\:CKb VSS) capacitor c=2.17891e-16
C77 (\3\:n35 VSS) capacitor c=1.15146e-16
C78 (\1\:SE VSS) capacitor c=2.47752e-17
C79 (\2\:SI VSS) capacitor c=7.74104e-17
C80 (\2\:SEb VSS) capacitor c=7.79882e-17
C81 (\4\:n20 VSS) capacitor c=9.8643e-17
C82 (\6\:n20 VSS) capacitor c=5.87967e-17
C83 (\3\:D VSS) capacitor c=1.47417e-17
C84 (\2\:SN VSS) capacitor c=4.72396e-17
C85 (\5\:SN VSS) capacitor c=1.95507e-17
C86 (\3\:CK VSS) capacitor c=2.22345e-17
C87 (\2\:mout VSS) capacitor c=4.32831e-17
C88 (\4\:mout VSS) capacitor c=3.05301e-17
C89 (\10\:CKb VSS) capacitor c=2.18385e-17
C90 (\5\:n20 VSS) capacitor c=6.33008e-17
C91 (\4\:CKbb VSS) capacitor c=6.32907e-17
C92 (\8\:CKbb VSS) capacitor c=2.46391e-17
C93 (\2\:n20 VSS) capacitor c=3.94849e-17
C94 (\1\:VDD VSS) capacitor c=2.80666e-17
C95 (\11\:VDD VSS) capacitor c=5.0035e-17
C96 (\4\:Q VSS) capacitor c=5.45787e-17
C97 (\13\:VDD VSS) capacitor c=5.29634e-17
C98 (\3\:n11 VSS) capacitor c=8.3971e-17
C99 (\14\:n35 VSS) capacitor c=5.13832e-17
C100 (\15\:n35g VSS) capacitor c=5.69979e-17
C101 (\6\:RTb VSS) capacitor c=7.28217e-17
C102 (\1\:ExtVDD VSS) capacitor c=2.78211e-16
C103 (\9\:n35 VSS) capacitor c=6.21565e-17
C104 (\14\:qbint VSS) capacitor c=6.82755e-17
C105 (\6\:n35g VSS) capacitor c=9.41385e-17
C106 (\8\:SEb VSS) capacitor c=5.06833e-17
C107 (\4\:n35 VSS) capacitor c=6.39896e-17
C108 (\15\:VDD VSS) capacitor c=6.13069e-17
C109 (\5\:mout VSS) capacitor c=7.57577e-17
C110 (\3\:Db VSS) capacitor c=1.90673e-16
C111 (\17\:VDD VSS) capacitor c=3.6346e-17
C112 (\22\:VDD VSS) capacitor c=3.78681e-17
C113 (\15\:mout VSS) capacitor c=1.02067e-16
C114 (\20\:VDD VSS) capacitor c=6.72915e-17
C115 (\18\:CKb VSS) capacitor c=2.48584e-17
C116 (\17\:CKbb VSS) capacitor c=7.93677e-17
C117 (\13\:n20 VSS) capacitor c=6.11956e-17
C118 (\5\:Db VSS) capacitor c=2.33931e-16
C119 (\10\:n20 VSS) capacitor c=6.36453e-17
C120 (\1\:Q VSS) capacitor c=3.73986e-17
C121 (\17\:n35 VSS) capacitor c=3.93544e-17
C122 (\11\:n35g VSS) capacitor c=2.63056e-17
C123 (\10\:RTb VSS) capacitor c=5.83059e-17
C124 (\12\:n35 VSS) capacitor c=6.37112e-17
C125 (\16\:qbint VSS) capacitor c=2.43869e-17
C126 (\9\:n35g VSS) capacitor c=8.056e-17
C127 (\4\:SEb VSS) capacitor c=3.95357e-17
C128 (\7\:n35 VSS) capacitor c=4.10332e-17
C129 (\11\:mout VSS) capacitor c=2.23063e-17
C130 (\13\:mout VSS) capacitor c=1.74521e-17
C131 (\14\:CKb VSS) capacitor c=6.8952e-17
C132 (\15\:CKbb VSS) capacitor c=9.22274e-17
C133 (\17\:n20 VSS) capacitor c=8.70381e-17
C134 (\7\:Db VSS) capacitor c=7.79427e-17
C135 (\8\:n20 VSS) capacitor c=5.89516e-17
C136 (VDD VSS) capacitor c=4.2649e-17
C137 (\2\:CKbb VSS) capacitor c=6.28793e-17
C138 (\2\:CK VSS) capacitor c=3.17677e-17
C139 (\2\:D VSS) capacitor c=3.57107e-17
C140 (\2\:SE VSS) capacitor c=2.50121e-17
C141 (\2\:CKb VSS) capacitor c=1.46221e-16
C142 (\3\:CKb VSS) capacitor c=8.7622e-17
C143 (\5\:CKb VSS) capacitor c=5.84869e-17
C144 (\2\:n35g VSS) capacitor c=2.91068e-17
C145 (\4\:RT VSS) capacitor c=4.60846e-17
C146 (\2\:qbint VSS) capacitor c=4.11428e-17
C147 (\6\:CKbb VSS) capacitor c=1.23198e-16
C148 (\7\:CKbb VSS) capacitor c=7.82294e-17
C149 (\4\:SN VSS) capacitor c=2.43808e-16
C150 (\12\:n20 VSS) capacitor c=4.40883e-17
C151 (\8\:qbint VSS) capacitor c=8.88011e-17
C152 (\13\:CKbb VSS) capacitor c=9.93286e-17
C153 (\14\:CKbb VSS) capacitor c=9.7321e-17
C154 (\15\:n20 VSS) capacitor c=5.21932e-17
C155 (\16\:n20 VSS) capacitor c=9.23421e-17
C156 (\19\:CKbb VSS) capacitor c=4.82477e-17
C157 (\6\:CK VSS) capacitor c=4.1533e-17
C158 (\16\:CKb VSS) capacitor c=5.95117e-17
C159 (\17\:CKb VSS) capacitor c=4.43352e-17
C160 (\10\:SN VSS) capacitor c=3.71238e-17
C161 (\11\:SN VSS) capacitor c=4.54966e-17
C162 (\19\:n20 VSS) capacitor c=5.04696e-17
C163 (\20\:n20 VSS) capacitor c=5.63541e-17
C164 (\7\:mout VSS) capacitor c=7.80368e-17
C165 (\8\:mout VSS) capacitor c=3.68573e-17
C166 (\9\:mout VSS) capacitor c=1.17266e-16
C167 (\10\:mout VSS) capacitor c=8.75638e-17
C168 (\17\:mout VSS) capacitor c=7.17464e-17
C169 (\6\:SEb VSS) capacitor c=8.38168e-17
C170 (\7\:SEb VSS) capacitor c=6.95868e-17
C171 (\6\:n35 VSS) capacitor c=7.82284e-17
C172 (\20\:CKb VSS) capacitor c=3.92018e-17
C173 (\21\:CKb VSS) capacitor c=4.23649e-17
C174 (\8\:n35g VSS) capacitor c=3.46579e-17
C175 (\11\:n35 VSS) capacitor c=7.51701e-17
C176 (\12\:qbint VSS) capacitor c=8.80722e-17
C177 (\13\:qbint VSS) capacitor c=1.12231e-16
C178 (\13\:n35g VSS) capacitor c=9.95615e-17
C179 (\14\:n35g VSS) capacitor c=1.16309e-16
C180 (\5\:RTb VSS) capacitor c=4.95471e-17
C181 (\8\:RTb VSS) capacitor c=9.95035e-17
C182 (\9\:RTb VSS) capacitor c=9.15287e-17
C183 (\10\:RT VSS) capacitor c=1.09721e-16
C184 (\11\:RT VSS) capacitor c=1.18363e-16
C185 (\12\:SN VSS) capacitor c=8.31748e-17
C186 (\13\:SN VSS) capacitor c=7.95664e-17
C187 (\20\:CKbb VSS) capacitor c=1.31062e-16
C188 (\21\:CKbb VSS) capacitor c=1.34586e-16
C189 (\18\:qbint VSS) capacitor c=1.95257e-17
C190 (\19\:qbint VSS) capacitor c=3.00557e-17
C191 (\16\:n35 VSS) capacitor c=4.52132e-17
C192 (\3\:Q VSS) capacitor c=1.70107e-17
C193 (\3\:VDD VSS) capacitor c=2.57292e-17
C194 (\4\:VDD VSS) capacitor c=2.86246e-17
C195 (\6\:VDD VSS) capacitor c=2.03314e-16
C196 (\7\:VDD VSS) capacitor c=2.09015e-16
C197 (\8\:VDD VSS) capacitor c=2.40069e-17
C198 (\10\:VDD VSS) capacitor c=2.27281e-17
C199 (\19\:VDD VSS) capacitor c=2.05808e-17
C200 (\24\:VDD VSS) capacitor c=4.46418e-17
Rk65 (\3\:Q Q) resistor r=0.01117 c=0
Rk64 (\2\:Q \3\:Q) resistor r=0.2899 c=0
Rk66 (\3\:Q \5\:Q) resistor r=0.3337 c=0
Rk85 (\2\:VSS \3\:VSS) resistor r=0.1015 c=0
Rk86 (\3\:VSS \4\:VSS) resistor r=0.1957 c=0
Rk87 (\4\:VSS \5\:VSS) resistor r=0.7611 c=0
Rk88 (\5\:VSS \6\:VSS) resistor r=0.03204 c=0
Rk90 (\7\:VSS VSS) resistor r=0.1211 c=0
Rk89 (\6\:VSS \7\:VSS) resistor r=0.1759 c=0
Rk91 (VSS \8\:VSS) resistor r=0.5208 c=0
Rk92 (\8\:VSS \9\:VSS) resistor r=0.3071 c=0
Rk94 (\10\:VSS VSS) resistor r=0.1213 c=0
Rk93 (\9\:VSS \10\:VSS) resistor r=0.06428 c=0
Rk95 (VSS \12\:VSS) resistor r=0.3119 c=0
Rk96 (\3\:VSS \14\:VSS) resistor r=0.2605 c=0
Rk97 (\5\:VSS \16\:VSS) resistor r=0.1891 c=0
Rk98 (\7\:VSS \18\:VSS) resistor r=0.1942 c=0
Rk99 (\8\:VSS \20\:VSS) resistor r=0.2532 c=0
Rk100 (\9\:VSS \22\:VSS) resistor r=0.2488 c=0
Rk101 (\24\:VSS \25\:VSS) resistor r=0.1808 c=0
Rk102 (\25\:VSS \26\:VSS) resistor r=0.3643 c=0
Rk103 (\26\:VSS \27\:VSS) resistor r=0.3671 c=0
Rk105 (\28\:VSS VSS) resistor r=0.04935 c=0
Rk104 (\27\:VSS \28\:VSS) resistor r=0.3271 c=0
Rk107 (\29\:VSS VSS) resistor r=0.1213 c=0
Rk106 (VSS \29\:VSS) resistor r=0.8929 c=0
Rk108 (\25\:VSS \31\:VSS) resistor r=0.2347 c=0
Rk109 (\27\:VSS \33\:VSS) resistor r=0.2434 c=0
Rk110 (VSS \35\:VSS) resistor r=0.3081 c=0
Rk43 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk41 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk44 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk45 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk10 (CK \6\:CK) resistor r=0.01219 c=0
Rk9 (\5\:CK \6\:CK) resistor r=0.003336 c=0
Rk57 (RT \10\:RT) resistor r=0.1986 c=0
Rk58 (\10\:RT \11\:RT) resistor r=0.6461 c=0
Rk14 (\10\:SN SN) resistor r=0.02012 c=0
Rk15 (SN \11\:SN) resistor r=0.221 c=0
Rk59 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk84 (VDD VDD) resistor r=0.2356 c=0
Rk68 (\2\:VDD \3\:VDD) resistor r=0.3368 c=0
Rk69 (\3\:VDD \4\:VDD) resistor r=0.1658 c=0
Rk70 (\4\:VDD \6\:VDD) resistor r=0.1164 c=0
Rk71 (\6\:VDD \7\:VDD) resistor r=1.5248 c=0
Rk72 (\7\:VDD \8\:VDD) resistor r=0.2302 c=0
Rk73 (\8\:VDD \10\:VDD) resistor r=0.1095 c=0
Rk74 (\3\:VDD \12\:VDD) resistor r=0.3564 c=0
Rk75 (\4\:VDD \14\:VDD) resistor r=0.3013 c=0
Rk76 (\7\:VDD \16\:VDD) resistor r=0.3661 c=0
Rk77 (\8\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk78 (\10\:VDD \19\:VDD) resistor r=0.09403 c=0
Rk79 (\19\:VDD \21\:VDD) resistor r=0.2288 c=0
Rk80 (\10\:VDD \23\:VDD) resistor r=0.2389 c=0
Rk83 (\24\:VDD VDD) resistor r=0.1955 c=0
Rk81 (\19\:VDD \24\:VDD) resistor r=0.07648 c=0
Rk82 (\24\:VDD \25\:VDD) resistor r=0.2188 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.543 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2541 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3402 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2294 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4963 c=0
Rk17 (\19\:n20 \20\:n20) resistor r=0.2606 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7511 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.5421 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.2243 c=0
Rk60 (\20\:CKbb \21\:CKbb) resistor r=0.8245 c=0
Rk21 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk22 (\7\:mout \8\:mout) resistor r=0.3504 c=0
Rk23 (\8\:mout \9\:mout) resistor r=0.1025 c=0
Rk24 (\9\:mout \10\:mout) resistor r=0.3414 c=0
Rk25 (\7\:mout \12\:mout) resistor r=0.1278 c=0
Rk26 (\8\:mout \14\:mout) resistor r=0.09193 c=0
Rk27 (\9\:mout \16\:mout) resistor r=0.6357 c=0
Rk28 (\10\:mout \17\:mout) resistor r=0.425 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.3782 c=0
Rk12 (\16\:CKb \17\:CKb) resistor r=0.1578 c=0
Rk13 (\16\:CKb \19\:CKb) resistor r=0.1343 c=0
Rk36 (\20\:CKb \21\:CKb) resistor r=0.3714 c=0
Rk31 (\5\:SEb \6\:SEb) resistor r=0.2161 c=0
Rk32 (\6\:SEb \7\:SEb) resistor r=0.3544 c=0
Rk33 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk37 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk38 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk49 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk50 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk51 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk46 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk47 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk48 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk61 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk52 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk53 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk54 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk55 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk34 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk35 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk39 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk40 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk62 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk63 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk18 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk19 (\4\:Db \6\:Db) resistor r=1.384 c=0
Rk20 (\6\:Db \8\:Db) resistor r=0.5649 c=0
Rk67 (\2\:n11 \4\:n11) resistor r=0.6527 c=0
Rl13 (\2\:D \4\:D) resistor r=115.099 c=0
Rl11 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl12 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl20 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl19 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl55 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl42 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl45 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl44 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl43 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl68 (\7\:SN \8\:SN) resistor r=366.394 c=0
Rl69 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl10 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl58 (\4\:SN \6\:SN) resistor r=106.74 c=0
Rl56 (\3\:SN \4\:SN) resistor r=1145.23 c=0
Rl57 (\4\:SN \5\:SN) resistor r=8.9604 c=0
Rl23 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl25 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl22 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl24 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl21 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=56.7001 c=0
Rl16 (\6\:n20 \7\:n20) resistor r=98.0144 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=249.192 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl2 (CKbb \2\:CKbb) resistor r=43.9661 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.6212 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl54 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\12\:CKb \13\:CKb) resistor r=870.726 c=0
Rl26 (CKb \2\:CKb) resistor r=349.798 c=0
Rl32 (\2\:CKb \8\:CKb) resistor r=127.816 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl33 (\3\:CKb \9\:CKb) resistor r=147.793 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=45.0334 c=0
Rl34 (\5\:CKb \10\:CKb) resistor r=1.2301 c=0
Rl35 (\6\:CKb \11\:CKb) resistor r=135.772 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=263.829 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=25.0362 c=0
Rl17 (SEb \2\:SEb) resistor r=101.718 c=0
Rl18 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl38 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl36 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl37 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl39 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl63 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl67 (\10\:qbint \11\:qbint) resistor r=343.229 c=0
Rl49 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl46 (qbint \2\:qbint) resistor r=112.732 c=0
Rl48 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl47 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl64 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl66 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl65 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl40 (RTb \2\:RTb) resistor r=112.412 c=0
Rl41 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (n35 \2\:n35) resistor r=508.667 c=0
Rl60 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz18 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz28 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz29 (\34\:VSS \35\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry20 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry31 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry32 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry33 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry34 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry35 (\23\:VSS \24\:VSS) resistor r=15.5 c=0
Ry36 (\23\:VSS \26\:VSS) resistor r=8.8571 c=0
Ry37 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry38 (\23\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry24 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry25 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry26 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry28 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry29 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\15\:mout \16\:mout) resistor r=62 c=0
Ry4 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry19 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry21 (n11 \2\:n11) resistor r=62 c=0
Ry22 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx11 (\3\:D D) resistor r=45 c=0
Rx7 (\3\:CK \5\:CK) resistor r=45 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx31 (\3\:SN \12\:SN) resistor r=45 c=0
Rx32 (\9\:SN \13\:SN) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\6\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \17\:CKb) resistor r=45 c=0
Rx20 (CKb \20\:CKb) resistor r=45 c=0
Rx21 (\13\:CKb \21\:CKb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx35 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx36 (qbint \19\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \7\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \11\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\14\:CKb \1\:CK \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0119 \6\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \7\:n20 net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \12\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net0118 \11\:qbint net0116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0116 \8\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \9\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.05e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\18\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=3.45e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp32 (\15\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=5.45048 \
        scb=0.00126552 scc=2.52508e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp52 (n11 \10\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\4\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0167 \
        scb=0.00981108 scc=0.000312648 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
ends SRDFFSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:05:36 2012 )
// Library name: gsclib045
// Cell name: SRDFFSRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSRQX1 CK D ExtVDD Q RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (ExtVDD VSS) capacitor c=2.41014e-16
C2 (D VSS) capacitor c=4.29321e-17
C3 (VDD VSS) capacitor c=7.82202e-16
C4 (SE VSS) capacitor c=9.36226e-17
C5 (Q VSS) capacitor c=3.75183e-17
C6 (CK VSS) capacitor c=6.00247e-17
C7 (SN VSS) capacitor c=3.63977e-17
C8 (SI VSS) capacitor c=8.72108e-17
C9 (RN VSS) capacitor c=8.90831e-17
C10 (RT VSS) capacitor c=6.2503e-17
C11 (n20 VSS) capacitor c=3.92699e-17
C12 (CKbb VSS) capacitor c=2.9956e-17
C13 (mout VSS) capacitor c=5.42535e-17
C14 (RNb VSS) capacitor c=3.91539e-17
C15 (CKb VSS) capacitor c=5.53018e-17
C16 (SEb VSS) capacitor c=7.75745e-17
C17 (n35g VSS) capacitor c=1.7772e-17
C18 (qbint VSS) capacitor c=4.57429e-17
C19 (RTb VSS) capacitor c=5.17974e-17
C20 (n35 VSS) capacitor c=1.71934e-16
C21 (Db VSS) capacitor c=1.05441e-16
C22 (n11 VSS) capacitor c=8.44886e-17
C23 (n8 VSS) capacitor c=7.938e-17
C24 (n10 VSS) capacitor c=8.44144e-17
C25 (n4 VSS) capacitor c=8.7069e-17
C26 (n1 VSS) capacitor c=1.02126e-18
C27 (\7\:SN VSS) capacitor c=7.05736e-17
C28 (\7\:qbint VSS) capacitor c=3.83819e-17
C29 (\10\:qbint VSS) capacitor c=1.41633e-16
C30 (\4\:RNb VSS) capacitor c=4.00602e-16
C31 (\11\:CKbb VSS) capacitor c=5.76934e-17
C32 (\4\:RTb VSS) capacitor c=9.76746e-17
C33 (\6\:RT VSS) capacitor c=2.20615e-17
C34 (\4\:qbint VSS) capacitor c=5.35397e-17
C35 (\3\:n35g VSS) capacitor c=5.2053e-17
C36 (\5\:RT VSS) capacitor c=8.2554e-17
C37 (\3\:SE VSS) capacitor c=7.72314e-17
C38 (\7\:CKb VSS) capacitor c=3.84202e-17
C39 (\3\:SI VSS) capacitor c=9.59651e-17
C40 (\9\:RNb VSS) capacitor c=6.01657e-17
C41 (\4\:SE VSS) capacitor c=1.22448e-16
C42 (\3\:n20 VSS) capacitor c=4.73671e-17
C43 (\4\:D VSS) capacitor c=7.00534e-17
C44 (\1\:SN VSS) capacitor c=3.03399e-17
C45 (\4\:CK VSS) capacitor c=6.08222e-17
C46 (\4\:CKb VSS) capacitor c=4.72846e-17
C47 (\8\:CKb VSS) capacitor c=8.3205e-17
C48 (\3\:CKbb VSS) capacitor c=2.56782e-17
C49 (\1\:RN VSS) capacitor c=4.24515e-17
C50 (\8\:SN VSS) capacitor c=1.32242e-16
C51 (\6\:qbint VSS) capacitor c=4.25639e-17
C52 (\11\:qbint VSS) capacitor c=8.06262e-17
C53 (\3\:RNb VSS) capacitor c=6.80787e-17
C54 (\11\:CKb VSS) capacitor c=2.22469e-16
C55 (\8\:RT VSS) capacitor c=1.20208e-16
C56 (\2\:RT VSS) capacitor c=6.21971e-17
C57 (\5\:qbint VSS) capacitor c=3.87528e-17
C58 (\5\:n35g VSS) capacitor c=3.28693e-17
C59 (\2\:RTb VSS) capacitor c=4.66333e-17
C60 (\5\:SE VSS) capacitor c=5.7365e-17
C61 (\5\:CKbb VSS) capacitor c=3.24964e-17
C62 (\1\:SI VSS) capacitor c=4.90982e-17
C63 (\6\:SE VSS) capacitor c=8.63749e-17
C64 (\3\:SEb VSS) capacitor c=6.60023e-17
C65 (\1\:D VSS) capacitor c=4.94877e-17
C66 (\6\:n20 VSS) capacitor c=6.12355e-17
C67 (\6\:SN VSS) capacitor c=4.59773e-17
C68 (\1\:CK VSS) capacitor c=2.87585e-17
C69 (\3\:mout VSS) capacitor c=4.57969e-17
C70 (\9\:CKb VSS) capacitor c=3.92875e-17
C71 (\10\:CKbb VSS) capacitor c=4.92133e-17
C72 (\6\:CKb VSS) capacitor c=4.97881e-17
C73 (\4\:RN VSS) capacitor c=3.69343e-17
C74 (\9\:qbint VSS) capacitor c=9.41633e-17
C75 (\12\:CKbb VSS) capacitor c=7.94667e-17
C76 (\3\:SN VSS) capacitor c=3.75362e-16
C77 (\9\:SN VSS) capacitor c=9.14336e-17
C78 (\7\:RT VSS) capacitor c=1.55207e-16
C79 (\9\:CKbb VSS) capacitor c=1.67449e-16
C80 (\3\:RT VSS) capacitor c=5.78494e-17
C81 (\1\:RT VSS) capacitor c=5.2908e-17
C82 (\3\:RTb VSS) capacitor c=7.57746e-17
C83 (\3\:qbint VSS) capacitor c=4.37709e-17
C84 (\2\:n35 VSS) capacitor c=2.52896e-16
C85 (\4\:n35g VSS) capacitor c=6.71687e-17
C86 (\12\:CKb VSS) capacitor c=2.1752e-16
C87 (\3\:n35 VSS) capacitor c=1.16125e-16
C88 (\1\:SE VSS) capacitor c=2.47732e-17
C89 (\2\:SI VSS) capacitor c=7.74104e-17
C90 (\2\:RNb VSS) capacitor c=3.31472e-17
C91 (\8\:RNb VSS) capacitor c=1.24868e-17
C92 (\2\:SEb VSS) capacitor c=7.84485e-17
C93 (\7\:n20 VSS) capacitor c=5.31155e-17
C94 (\4\:n20 VSS) capacitor c=1.14939e-16
C95 (\3\:D VSS) capacitor c=1.47127e-17
C96 (\2\:SN VSS) capacitor c=4.19842e-17
C97 (\5\:SN VSS) capacitor c=2.63859e-17
C98 (\3\:CK VSS) capacitor c=2.59385e-17
C99 (\2\:mout VSS) capacitor c=4.64695e-17
C100 (\4\:mout VSS) capacitor c=3.16539e-17
C101 (\10\:CKb VSS) capacitor c=2.16773e-17
C102 (\5\:n20 VSS) capacitor c=1.14457e-16
C103 (\4\:CKbb VSS) capacitor c=7.14888e-17
C104 (\8\:CKbb VSS) capacitor c=2.69454e-17
C105 (\7\:RNb VSS) capacitor c=1.31525e-16
C106 (\2\:n20 VSS) capacitor c=4.55398e-17
C107 (\3\:RN VSS) capacitor c=4.64202e-17
C108 (\1\:VDD VSS) capacitor c=2.99681e-17
C109 (\11\:VDD VSS) capacitor c=4.72134e-17
C110 (\3\:Q VSS) capacitor c=5.29163e-17
C111 (\13\:VDD VSS) capacitor c=4.90394e-17
C112 (\3\:n11 VSS) capacitor c=9.83748e-17
C113 (\14\:n35 VSS) capacitor c=5.35185e-17
C114 (\15\:n35g VSS) capacitor c=5.68608e-17
C115 (\6\:RTb VSS) capacitor c=7.21465e-17
C116 (\1\:ExtVDD VSS) capacitor c=2.78454e-16
C117 (\9\:n35 VSS) capacitor c=6.17256e-17
C118 (\14\:qbint VSS) capacitor c=6.81232e-17
C119 (\6\:n35g VSS) capacitor c=9.40263e-17
C120 (\8\:SEb VSS) capacitor c=5.05319e-17
C121 (\4\:n35 VSS) capacitor c=7.23682e-17
C122 (\15\:VDD VSS) capacitor c=6.09072e-17
C123 (\5\:mout VSS) capacitor c=1.33866e-16
C124 (\17\:VDD VSS) capacitor c=4.33457e-17
C125 (\3\:Db VSS) capacitor c=1.90445e-16
C126 (\19\:mout VSS) capacitor c=3.68829e-17
C127 (\22\:VDD VSS) capacitor c=3.51828e-17
C128 (\16\:mout VSS) capacitor c=4.35597e-17
C129 (\17\:CKb VSS) capacitor c=2.91358e-17
C130 (\20\:VDD VSS) capacitor c=4.82871e-17
C131 (\17\:CKbb VSS) capacitor c=6.64212e-17
C132 (\13\:n20 VSS) capacitor c=6.09021e-17
C133 (\5\:Db VSS) capacitor c=2.1604e-16
C134 (\10\:RNb VSS) capacitor c=5.04168e-17
C135 (\10\:n20 VSS) capacitor c=6.34584e-17
C136 (\24\:VDD VSS) capacitor c=4.7501e-17
C137 (\1\:Q VSS) capacitor c=3.65642e-17
C138 (\3\:n8 VSS) capacitor c=8.0956e-17
C139 (\3\:n10 VSS) capacitor c=8.13502e-17
C140 (\17\:n35 VSS) capacitor c=4.82161e-17
C141 (\11\:n35g VSS) capacitor c=2.62261e-17
C142 (\10\:RTb VSS) capacitor c=5.80906e-17
C143 (\12\:n35 VSS) capacitor c=6.34409e-17
C144 (\16\:qbint VSS) capacitor c=2.43025e-17
C145 (\9\:n35g VSS) capacitor c=8.00873e-17
C146 (\4\:SEb VSS) capacitor c=3.94072e-17
C147 (\7\:n35 VSS) capacitor c=4.89445e-17
C148 (\11\:mout VSS) capacitor c=3.71624e-17
C149 (\13\:mout VSS) capacitor c=3.82409e-17
C150 (\3\:n4 VSS) capacitor c=1.00173e-16
C151 (\13\:CKb VSS) capacitor c=6.60839e-17
C152 (\15\:CKbb VSS) capacitor c=9.62315e-17
C153 (\17\:n20 VSS) capacitor c=8.58437e-17
C154 (\7\:Db VSS) capacitor c=7.72667e-17
C155 (\13\:RNb VSS) capacitor c=7.34902e-17
C156 (\8\:n20 VSS) capacitor c=5.87832e-17
C157 (VDD VSS) capacitor c=6.96261e-17
C158 (\2\:CKbb VSS) capacitor c=6.21539e-17
C159 (\2\:CK VSS) capacitor c=3.37747e-17
C160 (\2\:D VSS) capacitor c=3.54972e-17
C161 (\2\:SE VSS) capacitor c=2.50121e-17
C162 (\2\:CKb VSS) capacitor c=1.511e-16
C163 (\3\:CKb VSS) capacitor c=8.58211e-17
C164 (\5\:CKb VSS) capacitor c=5.69698e-17
C165 (\2\:n35g VSS) capacitor c=2.91068e-17
C166 (\4\:RT VSS) capacitor c=7.42812e-17
C167 (\2\:qbint VSS) capacitor c=4.11428e-17
C168 (\6\:CKbb VSS) capacitor c=1.37045e-16
C169 (\7\:CKbb VSS) capacitor c=7.33353e-17
C170 (\4\:SN VSS) capacitor c=3.61113e-16
C171 (\12\:n20 VSS) capacitor c=4.40558e-17
C172 (\5\:RNb VSS) capacitor c=3.89507e-16
C173 (\6\:RNb VSS) capacitor c=1.80962e-16
C174 (\12\:RNb VSS) capacitor c=1.19782e-16
C175 (\13\:CKbb VSS) capacitor c=1.55652e-16
C176 (\14\:CKbb VSS) capacitor c=1.37959e-16
C177 (\8\:qbint VSS) capacitor c=1.0665e-16
C178 (\15\:n20 VSS) capacitor c=7.55281e-17
C179 (\16\:n20 VSS) capacitor c=9.2527e-17
C180 (\19\:CKbb VSS) capacitor c=4.95421e-17
C181 (\6\:CK VSS) capacitor c=4.64788e-17
C182 (\15\:CKb VSS) capacitor c=6.20893e-17
C183 (\16\:CKb VSS) capacitor c=4.46235e-17
C184 (\10\:SN VSS) capacitor c=4.36376e-17
C185 (\11\:SN VSS) capacitor c=4.60909e-17
C186 (\7\:D VSS) capacitor c=4.7322e-17
C187 (\19\:n20 VSS) capacitor c=8.03059e-17
C188 (\20\:n20 VSS) capacitor c=8.11054e-17
C189 (\15\:RNb VSS) capacitor c=7.08611e-17
C190 (\16\:RNb VSS) capacitor c=8.31202e-17
C191 (\7\:mout VSS) capacitor c=1.56129e-16
C192 (\8\:mout VSS) capacitor c=5.29694e-17
C193 (\9\:mout VSS) capacitor c=1.00196e-16
C194 (\10\:mout VSS) capacitor c=8.87294e-17
C195 (\15\:mout VSS) capacitor c=6.05008e-17
C196 (\18\:mout VSS) capacitor c=7.26103e-17
C197 (\6\:SEb VSS) capacitor c=8.35718e-17
C198 (\7\:SEb VSS) capacitor c=6.93987e-17
C199 (\6\:n35 VSS) capacitor c=1.06844e-16
C200 (\19\:CKb VSS) capacitor c=3.86723e-17
C201 (\20\:CKb VSS) capacitor c=4.17163e-17
C202 (\8\:n35g VSS) capacitor c=3.50808e-17
C203 (\11\:n35 VSS) capacitor c=7.54758e-17
C204 (\12\:qbint VSS) capacitor c=8.77654e-17
C205 (\13\:qbint VSS) capacitor c=1.11932e-16
C206 (\13\:n35g VSS) capacitor c=9.94617e-17
C207 (\14\:n35g VSS) capacitor c=1.15912e-16
C208 (\5\:RTb VSS) capacitor c=4.92668e-17
C209 (\8\:RTb VSS) capacitor c=1.00536e-16
C210 (\9\:RTb VSS) capacitor c=9.1424e-17
C211 (\10\:RT VSS) capacitor c=1.10449e-16
C212 (\11\:RT VSS) capacitor c=1.17918e-16
C213 (\12\:SN VSS) capacitor c=8.25765e-17
C214 (\13\:SN VSS) capacitor c=8.03267e-17
C215 (\20\:CKbb VSS) capacitor c=1.3168e-16
C216 (\21\:CKbb VSS) capacitor c=1.33733e-16
C217 (\18\:qbint VSS) capacitor c=1.9502e-17
C218 (\19\:qbint VSS) capacitor c=3.00427e-17
C219 (\16\:n35 VSS) capacitor c=5.06065e-17
C220 (\3\:VDD VSS) capacitor c=3.242e-17
C221 (\4\:VDD VSS) capacitor c=2.63582e-17
C222 (\6\:VDD VSS) capacitor c=2.01956e-16
C223 (\7\:VDD VSS) capacitor c=2.1195e-16
C224 (\8\:VDD VSS) capacitor c=2.90348e-17
C225 (\10\:VDD VSS) capacitor c=5.22206e-17
C226 (\19\:VDD VSS) capacitor c=5.45052e-17
Rk52 (ExtVDD ExtVDD) resistor r=0.002069 c=0
Rk50 (\2\:ExtVDD ExtVDD) resistor r=0.02222 c=0
Rk53 (ExtVDD \5\:ExtVDD) resistor r=0.02021 c=0
Rk54 (ExtVDD \6\:ExtVDD) resistor r=0.1501 c=0
Rk19 (\5\:D D) resistor r=0.007226 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01721 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007226 c=0
Rk104 (VDD VDD) resistor r=0.2371 c=0
Rk90 (\2\:VDD \3\:VDD) resistor r=0.3387 c=0
Rk91 (\3\:VDD \4\:VDD) resistor r=0.2187 c=0
Rk92 (\4\:VDD \6\:VDD) resistor r=0.06703 c=0
Rk93 (\6\:VDD \7\:VDD) resistor r=1.5809 c=0
Rk94 (\7\:VDD \8\:VDD) resistor r=0.1191 c=0
Rk95 (\8\:VDD \10\:VDD) resistor r=0.222 c=0
Rk96 (\3\:VDD \12\:VDD) resistor r=0.3589 c=0
Rk97 (\4\:VDD \14\:VDD) resistor r=0.2948 c=0
Rk98 (\7\:VDD \16\:VDD) resistor r=0.3688 c=0
Rk99 (\8\:VDD \18\:VDD) resistor r=0.203 c=0
Rk103 (\19\:VDD VDD) resistor r=0.1963 c=0
Rk100 (\10\:VDD \19\:VDD) resistor r=0.1716 c=0
Rk101 (\19\:VDD \21\:VDD) resistor r=0.2084 c=0
Rk102 (\10\:VDD \23\:VDD) resistor r=0.2388 c=0
Rk105 (VDD \25\:VDD) resistor r=0.3802 c=0
Rk74 (\2\:Q Q) resistor r=0.1691 c=0
Rk75 (Q \4\:Q) resistor r=0.2939 c=0
Rk13 (CK \6\:CK) resistor r=0.01224 c=0
Rk12 (\5\:CK \6\:CK) resistor r=0.003439 c=0
Rk78 (\2\:VSS \3\:VSS) resistor r=0.03217 c=0
Rk79 (\3\:VSS \4\:VSS) resistor r=0.5152 c=0
Rk80 (\4\:VSS \5\:VSS) resistor r=0.5181 c=0
Rk82 (\6\:VSS VSS) resistor r=0.04955 c=0
Rk81 (\5\:VSS \6\:VSS) resistor r=0.3285 c=0
Rk84 (\7\:VSS VSS) resistor r=0.1218 c=0
Rk83 (VSS \7\:VSS) resistor r=0.8966 c=0
Rk85 (VSS \8\:VSS) resistor r=0.01748 c=0
Rk86 (\8\:VSS \10\:VSS) resistor r=0.6662 c=0
Rk87 (\3\:VSS \12\:VSS) resistor r=0.2503 c=0
Rk88 (\5\:VSS \14\:VSS) resistor r=0.2452 c=0
Rk89 (\8\:VSS \16\:VSS) resistor r=0.2528 c=0
Rk106 (\18\:VSS \20\:VSS) resistor r=0.4133 c=0
Rk107 (\20\:VSS \21\:VSS) resistor r=0.8638 c=0
Rk108 (\21\:VSS \22\:VSS) resistor r=0.03217 c=0
Rk110 (\23\:VSS VSS) resistor r=0.1216 c=0
Rk109 (\22\:VSS \23\:VSS) resistor r=0.1766 c=0
Rk111 (VSS \24\:VSS) resistor r=0.5229 c=0
Rk112 (\24\:VSS \25\:VSS) resistor r=0.3084 c=0
Rk114 (\26\:VSS VSS) resistor r=0.1218 c=0
Rk113 (\25\:VSS \26\:VSS) resistor r=0.06454 c=0
Rk115 (VSS \28\:VSS) resistor r=0.3138 c=0
Rk116 (\21\:VSS \30\:VSS) resistor r=0.1905 c=0
Rk117 (\23\:VSS \32\:VSS) resistor r=0.1956 c=0
Rk118 (\24\:VSS \34\:VSS) resistor r=0.255 c=0
Rk119 (\25\:VSS \36\:VSS) resistor r=0.2506 c=0
Rk17 (SN \10\:SN) resistor r=0.008773 c=0
Rk18 (SN \11\:SN) resistor r=0.2654 c=0
Rk68 (\12\:SN \13\:SN) resistor r=0.5395 c=0
Rk1 (\5\:RN RN) resistor r=0.006372 c=0
Rk66 (RT \10\:RT) resistor r=0.1997 c=0
Rk67 (\10\:RT \11\:RT) resistor r=0.6506 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5468 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2558 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3478 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.231 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4998 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4645 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8547 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.544 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.1872 c=0
Rk69 (\20\:CKbb \21\:CKbb) resistor r=0.8302 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.7671 c=0
Rk31 (\7\:mout \8\:mout) resistor r=0.3549 c=0
Rk32 (\8\:mout \9\:mout) resistor r=0.1721 c=0
Rk33 (\9\:mout \10\:mout) resistor r=0.3451 c=0
Rk34 (\7\:mout \12\:mout) resistor r=0.1239 c=0
Rk35 (\8\:mout \14\:mout) resistor r=0.1004 c=0
Rk36 (\9\:mout \15\:mout) resistor r=0.5279 c=0
Rk37 (\15\:mout \17\:mout) resistor r=0.04496 c=0
Rk38 (\10\:mout \18\:mout) resistor r=0.4279 c=0
Rk39 (\15\:mout \20\:mout) resistor r=0.03474 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1645 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3831 c=0
Rk27 (\15\:RNb \16\:RNb) resistor r=0.3488 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3522 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.159 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.1648 c=0
Rk45 (\19\:CKb \20\:CKb) resistor r=0.374 c=0
Rk40 (\5\:SEb \6\:SEb) resistor r=0.2176 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.357 c=0
Rk42 (\6\:SEb \9\:SEb) resistor r=0.3118 c=0
Rk46 (\7\:n35g \8\:n35g) resistor r=0.2752 c=0
Rk47 (\7\:n35g \10\:n35g) resistor r=0.6962 c=0
Rk58 (\12\:n35g \13\:n35g) resistor r=0.2446 c=0
Rk59 (\13\:n35g \14\:n35g) resistor r=0.5695 c=0
Rk60 (\13\:n35g \16\:n35g) resistor r=0.4349 c=0
Rk55 (\12\:qbint \13\:qbint) resistor r=0.498 c=0
Rk56 (\13\:qbint \15\:qbint) resistor r=0.571 c=0
Rk57 (\13\:qbint \17\:qbint) resistor r=0.1473 c=0
Rk70 (\18\:qbint \19\:qbint) resistor r=0.2132 c=0
Rk61 (\5\:RTb \7\:RTb) resistor r=0.2177 c=0
Rk62 (\7\:RTb \8\:RTb) resistor r=0.4194 c=0
Rk63 (\8\:RTb \9\:RTb) resistor r=0.6934 c=0
Rk64 (\8\:RTb \11\:RTb) resistor r=0.3087 c=0
Rk43 (\5\:n35 \6\:n35) resistor r=0.4319 c=0
Rk44 (\6\:n35 \8\:n35) resistor r=0.3048 c=0
Rk48 (\10\:n35 \11\:n35) resistor r=0.4037 c=0
Rk49 (\11\:n35 \13\:n35) resistor r=0.3322 c=0
Rk71 (\15\:n35 \16\:n35) resistor r=0.3058 c=0
Rk72 (\16\:n35 \18\:n35) resistor r=0.2894 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6407 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.395 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5689 c=0
Rk76 (\2\:n11 \4\:n11) resistor r=0.7185 c=0
Rk77 (\2\:n8 \4\:n8) resistor r=0.5338 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.6299 c=0
Rk26 (\2\:n4 \4\:n4) resistor r=0.556 c=0
Rl16 (\2\:D \4\:D) resistor r=115.099 c=0
Rl14 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl15 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl77 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl78 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl13 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl61 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl59 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl60 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl58 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl45 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl48 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl47 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl46 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl19 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl17 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl5 (CKbb \2\:CKbb) resistor r=43.0773 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl56 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl57 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl55 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl66 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl67 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl70 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl71 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl69 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl68 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl65 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl30 (CKb \2\:CKb) resistor r=349.798 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=58.0449 c=0
Rl37 (\5\:CKb \9\:CKb) resistor r=133.091 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=267.802 c=0
Rl38 (\5\:CKb \10\:CKb) resistor r=4.6486 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl41 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl39 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl40 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl42 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl72 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl76 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl52 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl49 (qbint \2\:qbint) resistor r=112.732 c=0
Rl51 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl50 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl73 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl75 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl74 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl43 (RTb \2\:RTb) resistor r=112.412 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl62 (n35 \2\:n35) resistor r=508.667 c=0
Rl63 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz26 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz27 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz28 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz29 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz32 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz33 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz34 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz35 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz36 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz37 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz20 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz24 (n8 \2\:n8) resistor r=75 c=0
Rz25 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry30 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry31 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry32 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry35 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry36 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry22 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry26 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry27 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry28 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=10.3333 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry39 (\19\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx19 (\1\:SE SE) resistor r=45 c=0
Rx9 (\3\:CK \5\:CK) resistor r=45 c=0
Rx11 (\5\:SN \10\:SN) resistor r=45 c=0
Rx12 (\2\:SN \11\:SN) resistor r=45 c=0
Rx35 (\3\:SN \12\:SN) resistor r=45 c=0
Rx36 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx32 (\7\:RT RT) resistor r=45 c=0
Rx33 (\3\:RT \10\:RT) resistor r=45 c=0
Rx34 (\1\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx37 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx38 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx20 (\4\:mout \10\:mout) resistor r=45 c=0
Rx21 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx10 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx24 (CKb \19\:CKb) resistor r=45 c=0
Rx25 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx26 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx29 (n35g \14\:n35g) resistor r=45 c=0
Rx28 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx39 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx40 (qbint \19\:qbint) resistor r=45 c=0
Rx30 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (RTb \9\:RTb) resistor r=45 c=0
Rx23 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx27 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx41 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \11\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n9 \4\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:06:27 2012 )
// Library name: gsclib045
// Cell name: SRDFFSRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSRX1 CK D ExtVDD Q QN RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (Q VSS) capacitor c=5.1606e-17
C2 (D VSS) capacitor c=4.28787e-17
C3 (QN VSS) capacitor c=2.21785e-17
C4 (VDD VSS) capacitor c=7.9263e-16
C5 (SE VSS) capacitor c=9.34843e-17
C6 (ExtVDD VSS) capacitor c=2.42324e-16
C7 (CK VSS) capacitor c=4.5608e-17
C8 (SN VSS) capacitor c=4.12743e-17
C9 (SI VSS) capacitor c=8.70533e-17
C10 (RN VSS) capacitor c=6.78794e-17
C11 (RT VSS) capacitor c=4.08272e-17
C12 (n20 VSS) capacitor c=3.86301e-17
C13 (CKbb VSS) capacitor c=3.31954e-17
C14 (mout VSS) capacitor c=5.42548e-17
C15 (RNb VSS) capacitor c=3.91539e-17
C16 (CKb VSS) capacitor c=5.53018e-17
C17 (SEb VSS) capacitor c=7.75904e-17
C18 (n35g VSS) capacitor c=1.77753e-17
C19 (qbint VSS) capacitor c=4.54322e-17
C20 (RTb VSS) capacitor c=5.17974e-17
C21 (net573 VSS) capacitor c=2.25772e-17
C22 (n35 VSS) capacitor c=1.71705e-16
C23 (Db VSS) capacitor c=1.05264e-16
C24 (n11 VSS) capacitor c=8.44491e-17
C25 (n8 VSS) capacitor c=7.92568e-17
C26 (n10 VSS) capacitor c=8.42863e-17
C27 (n4 VSS) capacitor c=8.69277e-17
C28 (n1 VSS) capacitor c=1.02126e-18
C29 (\7\:SN VSS) capacitor c=7.05736e-17
C30 (\7\:qbint VSS) capacitor c=3.31318e-17
C31 (\11\:qbint VSS) capacitor c=1.41624e-16
C32 (\4\:RNb VSS) capacitor c=4.06878e-16
C33 (\13\:qbint VSS) capacitor c=4.39115e-17
C34 (\3\:net573 VSS) capacitor c=5.86653e-17
C35 (\11\:CKbb VSS) capacitor c=5.94746e-17
C36 (\4\:RTb VSS) capacitor c=9.88373e-17
C37 (\6\:RT VSS) capacitor c=2.19082e-17
C38 (\4\:qbint VSS) capacitor c=5.36612e-17
C39 (\3\:n35g VSS) capacitor c=5.2053e-17
C40 (\5\:RT VSS) capacitor c=8.2554e-17
C41 (\3\:SE VSS) capacitor c=7.72314e-17
C42 (\7\:CKb VSS) capacitor c=3.84202e-17
C43 (\3\:SI VSS) capacitor c=9.59651e-17
C44 (\9\:RNb VSS) capacitor c=6.01657e-17
C45 (\4\:SE VSS) capacitor c=1.22612e-16
C46 (\3\:n20 VSS) capacitor c=4.73671e-17
C47 (\4\:D VSS) capacitor c=7.012e-17
C48 (\1\:SN VSS) capacitor c=3.03656e-17
C49 (\4\:CK VSS) capacitor c=5.83505e-17
C50 (\4\:CKb VSS) capacitor c=4.94815e-17
C51 (\8\:CKb VSS) capacitor c=8.3205e-17
C52 (\3\:CKbb VSS) capacitor c=2.59536e-17
C53 (\1\:RN VSS) capacitor c=4.24621e-17
C54 (\8\:SN VSS) capacitor c=1.32242e-16
C55 (\6\:qbint VSS) capacitor c=3.77911e-17
C56 (\12\:qbint VSS) capacitor c=8.06262e-17
C57 (\3\:RNb VSS) capacitor c=6.80787e-17
C58 (\14\:qbint VSS) capacitor c=4.60843e-17
C59 (\4\:net573 VSS) capacitor c=3.68535e-17
C60 (\11\:CKb VSS) capacitor c=2.22561e-16
C61 (\8\:RT VSS) capacitor c=1.21595e-16
C62 (\2\:RT VSS) capacitor c=6.21972e-17
C63 (\5\:qbint VSS) capacitor c=3.89021e-17
C64 (\5\:n35g VSS) capacitor c=3.28693e-17
C65 (\2\:RTb VSS) capacitor c=4.66333e-17
C66 (\5\:SE VSS) capacitor c=5.7365e-17
C67 (\5\:CKbb VSS) capacitor c=3.24964e-17
C68 (\1\:SI VSS) capacitor c=4.90982e-17
C69 (\6\:SE VSS) capacitor c=8.63749e-17
C70 (\3\:SEb VSS) capacitor c=6.60023e-17
C71 (\1\:D VSS) capacitor c=4.94494e-17
C72 (\6\:n20 VSS) capacitor c=6.12355e-17
C73 (\6\:SN VSS) capacitor c=4.59773e-17
C74 (\1\:CK VSS) capacitor c=2.87544e-17
C75 (\3\:mout VSS) capacitor c=4.57969e-17
C76 (\9\:CKb VSS) capacitor c=3.74186e-17
C77 (\10\:CKbb VSS) capacitor c=4.92133e-17
C78 (\6\:CKb VSS) capacitor c=4.97881e-17
C79 (\4\:RN VSS) capacitor c=3.69395e-17
C80 (\10\:qbint VSS) capacitor c=8.46484e-17
C81 (\12\:CKbb VSS) capacitor c=8.24974e-17
C82 (\3\:SN VSS) capacitor c=3.75168e-16
C83 (\9\:SN VSS) capacitor c=9.15257e-17
C84 (\7\:RT VSS) capacitor c=1.51246e-16
C85 (\9\:CKbb VSS) capacitor c=1.67463e-16
C86 (\3\:RT VSS) capacitor c=5.77115e-17
C87 (\1\:RT VSS) capacitor c=5.2908e-17
C88 (\3\:RTb VSS) capacitor c=7.61041e-17
C89 (\3\:qbint VSS) capacitor c=4.43778e-17
C90 (\2\:n35 VSS) capacitor c=2.52896e-16
C91 (\4\:n35g VSS) capacitor c=6.71687e-17
C92 (\12\:CKb VSS) capacitor c=2.1752e-16
C93 (\3\:n35 VSS) capacitor c=1.16129e-16
C94 (\1\:SE VSS) capacitor c=2.47732e-17
C95 (\2\:SI VSS) capacitor c=7.74104e-17
C96 (\2\:RNb VSS) capacitor c=3.31472e-17
C97 (\8\:RNb VSS) capacitor c=1.24868e-17
C98 (\2\:SEb VSS) capacitor c=7.84493e-17
C99 (\7\:n20 VSS) capacitor c=5.31281e-17
C100 (\4\:n20 VSS) capacitor c=1.14993e-16
C101 (\3\:D VSS) capacitor c=1.47669e-17
C102 (\2\:SN VSS) capacitor c=4.20268e-17
C103 (\5\:SN VSS) capacitor c=2.77004e-17
C104 (\3\:CK VSS) capacitor c=2.33906e-17
C105 (\2\:mout VSS) capacitor c=4.64603e-17
C106 (\4\:mout VSS) capacitor c=3.16539e-17
C107 (\10\:CKb VSS) capacitor c=7.51537e-17
C108 (\5\:n20 VSS) capacitor c=1.14861e-16
C109 (\4\:CKbb VSS) capacitor c=7.14894e-17
C110 (\8\:CKbb VSS) capacitor c=2.69454e-17
C111 (\7\:RNb VSS) capacitor c=1.31852e-16
C112 (\2\:n20 VSS) capacitor c=4.55367e-17
C113 (\3\:RN VSS) capacitor c=4.53768e-17
C114 (\1\:VDD VSS) capacitor c=2.99202e-17
C115 (\12\:VDD VSS) capacitor c=4.47866e-17
C116 (\3\:Q VSS) capacitor c=8.26827e-17
C117 (\14\:VDD VSS) capacitor c=4.92886e-17
C118 (\9\:net573 VSS) capacitor c=5.55923e-17
C119 (\16\:VDD VSS) capacitor c=7.94605e-17
C120 (\3\:n11 VSS) capacitor c=9.90547e-17
C121 (\4\:QN VSS) capacitor c=6.79898e-17
C122 (\14\:n35 VSS) capacitor c=5.58386e-17
C123 (\15\:n35g VSS) capacitor c=5.57509e-17
C124 (\6\:RTb VSS) capacitor c=7.20782e-17
C125 (\1\:ExtVDD VSS) capacitor c=2.77989e-16
C126 (\9\:n35 VSS) capacitor c=6.16225e-17
C127 (\17\:qbint VSS) capacitor c=6.80388e-17
C128 (\6\:n35g VSS) capacitor c=9.38837e-17
C129 (\8\:SEb VSS) capacitor c=5.04498e-17
C130 (\4\:n35 VSS) capacitor c=7.2232e-17
C131 (\18\:VDD VSS) capacitor c=6.08131e-17
C132 (\5\:mout VSS) capacitor c=1.33608e-16
C133 (\20\:VDD VSS) capacitor c=4.3269e-17
C134 (\3\:Db VSS) capacitor c=1.94165e-16
C135 (\19\:mout VSS) capacitor c=3.68281e-17
C136 (\25\:VDD VSS) capacitor c=3.44737e-17
C137 (\16\:mout VSS) capacitor c=4.36959e-17
C138 (\17\:CKb VSS) capacitor c=2.98973e-17
C139 (\23\:VDD VSS) capacitor c=4.82067e-17
C140 (\17\:CKbb VSS) capacitor c=6.70114e-17
C141 (\13\:n20 VSS) capacitor c=6.10909e-17
C142 (\5\:Db VSS) capacitor c=2.21397e-16
C143 (\10\:RNb VSS) capacitor c=5.0321e-17
C144 (\10\:n20 VSS) capacitor c=6.33513e-17
C145 (\27\:VDD VSS) capacitor c=3.89039e-17
C146 (\1\:Q VSS) capacitor c=5.41875e-17
C147 (\5\:net573 VSS) capacitor c=4.29547e-17
C148 (\3\:n8 VSS) capacitor c=8.08245e-17
C149 (\3\:n10 VSS) capacitor c=8.12131e-17
C150 (\1\:QN VSS) capacitor c=3.68722e-17
C151 (\17\:n35 VSS) capacitor c=4.81229e-17
C152 (\11\:n35g VSS) capacitor c=2.95879e-17
C153 (\10\:RTb VSS) capacitor c=5.7983e-17
C154 (\12\:n35 VSS) capacitor c=6.33278e-17
C155 (\19\:qbint VSS) capacitor c=2.42602e-17
C156 (\9\:n35g VSS) capacitor c=7.99627e-17
C157 (\4\:SEb VSS) capacitor c=3.93429e-17
C158 (\7\:n35 VSS) capacitor c=4.88653e-17
C159 (\11\:mout VSS) capacitor c=3.70935e-17
C160 (\13\:mout VSS) capacitor c=3.8164e-17
C161 (\3\:n4 VSS) capacitor c=1.00022e-16
C162 (\13\:CKb VSS) capacitor c=6.24114e-17
C163 (\15\:CKbb VSS) capacitor c=8.91749e-17
C164 (\17\:n20 VSS) capacitor c=8.56888e-17
C165 (\7\:Db VSS) capacitor c=7.7131e-17
C166 (\13\:RNb VSS) capacitor c=7.3362e-17
C167 (\8\:n20 VSS) capacitor c=5.86991e-17
