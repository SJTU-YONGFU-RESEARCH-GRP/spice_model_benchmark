        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp52 (n41 \10\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp55 (\4\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.3389 \
        scb=0.0172052 scc=0.000547772 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.7978 \
        scb=0.0191816 scc=0.000889993 m=(1)
ends RDFFSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:51:31 2012 )
// Library name: gsclib045
// Cell name: RDFFSRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFSRQX1 CK D ExtVDD Q RN RT SN VDD VSS
mp25 (n22 \3\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RN VSS) capacitor c=1.108e-16
C2 (RT VSS) capacitor c=2.31666e-17
C3 (SN VSS) capacitor c=4.11311e-17
C4 (D VSS) capacitor c=5.44676e-17
C5 (VDD VSS) capacitor c=7.07526e-16
C6 (Q VSS) capacitor c=3.68013e-17
C7 (ExtVDD VSS) capacitor c=1.98222e-16
C8 (CKbb VSS) capacitor c=5.54361e-17
C9 (mout VSS) capacitor c=5.33797e-17
C10 (n20 VSS) capacitor c=8.26482e-17
C11 (RNb VSS) capacitor c=3.91539e-17
C12 (CKb VSS) capacitor c=2.35786e-17
C13 (n35g VSS) capacitor c=1.7772e-17
C14 (qbint VSS) capacitor c=4.57429e-17
C15 (RTb VSS) capacitor c=5.17974e-17
C16 (n35 VSS) capacitor c=1.71933e-16
C17 (n41 VSS) capacitor c=8.47445e-17
C18 (n42 VSS) capacitor c=7.96264e-17
C19 (n40 VSS) capacitor c=8.46705e-17
C20 (net426 VSS) capacitor c=8.73516e-17
C21 (\7\:SN VSS) capacitor c=7.05736e-17
C22 (\7\:qbint VSS) capacitor c=3.83498e-17
C23 (\10\:qbint VSS) capacitor c=1.41633e-16
C24 (\4\:RNb VSS) capacitor c=3.12604e-16
C25 (\10\:CKbb VSS) capacitor c=5.76814e-17
C26 (\4\:RTb VSS) capacitor c=9.8167e-17
C27 (\6\:RT VSS) capacitor c=2.20496e-17
C28 (\4\:qbint VSS) capacitor c=5.35384e-17
C29 (\3\:n35g VSS) capacitor c=6.18561e-17
C30 (\5\:RT VSS) capacitor c=8.43931e-17
C31 (\9\:CKb VSS) capacitor c=1.11866e-16
C32 (\4\:RN VSS) capacitor c=3.2184e-17
C33 (\7\:RNb VSS) capacitor c=6.92464e-17
C34 (\3\:n20 VSS) capacitor c=4.64244e-17
C35 (\4\:CK VSS) capacitor c=5.66376e-17
C36 (\1\:SN VSS) capacitor c=2.99882e-17
C37 (\5\:CKb VSS) capacitor c=2.92506e-17
C38 (\7\:CKb VSS) capacitor c=9.21771e-17
C39 (\2\:CKbb VSS) capacitor c=1.52748e-16
C40 (\3\:D VSS) capacitor c=7.29689e-17
C41 (\8\:SN VSS) capacitor c=1.32242e-16
C42 (\6\:qbint VSS) capacitor c=4.25184e-17
C43 (\11\:qbint VSS) capacitor c=8.06262e-17
C44 (\3\:RNb VSS) capacitor c=6.80787e-17
C45 (\11\:CKb VSS) capacitor c=2.22469e-16
C46 (\8\:RT VSS) capacitor c=1.20185e-16
C47 (\2\:RT VSS) capacitor c=6.21972e-17
C48 (\5\:qbint VSS) capacitor c=3.87746e-17
C49 (\5\:n35g VSS) capacitor c=2.76477e-17
C50 (\2\:RTb VSS) capacitor c=4.66333e-17
C51 (\4\:CKbb VSS) capacitor c=3.24964e-17
C52 (\1\:RN VSS) capacitor c=3.44907e-17
C53 (\6\:n20 VSS) capacitor c=6.12355e-17
C54 (\6\:SN VSS) capacitor c=4.5982e-17
C55 (\1\:CK VSS) capacitor c=2.82836e-17
C56 (\8\:CKb VSS) capacitor c=2.53139e-17
C57 (\3\:mout VSS) capacitor c=4.58092e-17
C58 (\9\:CKbb VSS) capacitor c=4.97927e-17
C59 (\4\:CKb VSS) capacitor c=8.43185e-17
C60 (\1\:D VSS) capacitor c=4.88945e-17
C61 (\9\:qbint VSS) capacitor c=9.41986e-17
C62 (\11\:CKbb VSS) capacitor c=7.94667e-17
C63 (\3\:SN VSS) capacitor c=3.75485e-16
C64 (\9\:SN VSS) capacitor c=9.14336e-17
C65 (\7\:RT VSS) capacitor c=1.56081e-16
C66 (\8\:CKbb VSS) capacitor c=1.67449e-16
C67 (\3\:RT VSS) capacitor c=5.78493e-17
C68 (\1\:RT VSS) capacitor c=5.2908e-17
C69 (\3\:RTb VSS) capacitor c=7.5773e-17
C70 (\3\:qbint VSS) capacitor c=4.39848e-17
C71 (\2\:n35 VSS) capacitor c=2.52873e-16
C72 (\4\:n35g VSS) capacitor c=7.14465e-17
C73 (\10\:CKb VSS) capacitor c=5.38192e-17
C74 (\12\:CKb VSS) capacitor c=2.1752e-16
C75 (\3\:n35 VSS) capacitor c=1.16128e-16
C76 (\2\:RNb VSS) capacitor c=3.31472e-17
C77 (\9\:RNb VSS) capacitor c=1.06902e-17
C78 (\8\:RNb VSS) capacitor c=8.71934e-17
C79 (\7\:n20 VSS) capacitor c=5.31263e-17
C80 (\3\:RN VSS) capacitor c=4.65564e-17
C81 (\4\:n20 VSS) capacitor c=9.37723e-17
C82 (\3\:CK VSS) capacitor c=2.36445e-17
C83 (\2\:SN VSS) capacitor c=4.18672e-17
C84 (\5\:SN VSS) capacitor c=2.03416e-17
C85 (\2\:mout VSS) capacitor c=4.69245e-17
C86 (\4\:mout VSS) capacitor c=3.1078e-17
C87 (\5\:n20 VSS) capacitor c=7.69595e-17
C88 (\2\:n20 VSS) capacitor c=7.16254e-17
C89 (\3\:CKbb VSS) capacitor c=8.26856e-17
C90 (\7\:CKbb VSS) capacitor c=3.16279e-17
C91 (\2\:D VSS) capacitor c=5.2132e-17
C92 (\1\:VDD VSS) capacitor c=3.00657e-17
C93 (\14\:VDD VSS) capacitor c=4.73736e-17
C94 (\3\:Q VSS) capacitor c=5.30919e-17
C95 (\16\:VDD VSS) capacitor c=4.92132e-17
C96 (\3\:n41 VSS) capacitor c=9.87152e-17
C97 (\14\:n35 VSS) capacitor c=5.37018e-17
C98 (\15\:n35g VSS) capacitor c=5.69979e-17
C99 (\6\:RTb VSS) capacitor c=7.23425e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.78576e-16
C101 (\9\:n35 VSS) capacitor c=6.17077e-17
C102 (\14\:qbint VSS) capacitor c=6.60601e-17
C103 (\6\:n35g VSS) capacitor c=9.10033e-17
C104 (\4\:n35 VSS) capacitor c=6.8905e-17
C105 (\5\:mout VSS) capacitor c=1.28058e-16
C106 (\13\:RNb VSS) capacitor c=2.66872e-17
C107 (\18\:VDD VSS) capacitor c=4.33723e-17
C108 (\20\:VDD VSS) capacitor c=5.21164e-17
C109 (\19\:mout VSS) capacitor c=3.67577e-17
C110 (\17\:CKb VSS) capacitor c=4.52625e-17
C111 (\16\:mout VSS) capacitor c=4.35833e-17
C112 (\22\:VDD VSS) capacitor c=6.0232e-17
C113 (\24\:VDD VSS) capacitor c=4.98798e-17
C114 (\18\:CKbb VSS) capacitor c=4.02072e-17
C115 (\8\:n20 VSS) capacitor c=4.10734e-17
C116 (\16\:n20 VSS) capacitor c=5.59145e-17
C117 (\26\:VDD VSS) capacitor c=3.57195e-17
C118 (\1\:Q VSS) capacitor c=3.74881e-17
C119 (\3\:n42 VSS) capacitor c=8.1219e-17
C120 (\3\:n40 VSS) capacitor c=8.16243e-17
C121 (\17\:n35 VSS) capacitor c=4.84026e-17
C122 (\11\:n35g VSS) capacitor c=2.63056e-17
C123 (\10\:RTb VSS) capacitor c=5.83059e-17
C124 (\12\:n35 VSS) capacitor c=6.36671e-17
C125 (\16\:qbint VSS) capacitor c=2.27954e-17
C126 (\9\:n35g VSS) capacitor c=8.03366e-17
C127 (\7\:n35 VSS) capacitor c=4.91029e-17
C128 (\11\:mout VSS) capacitor c=3.73001e-17
C129 (\10\:RNb VSS) capacitor c=4.40227e-17
C130 (\13\:mout VSS) capacitor c=3.83866e-17
C131 (\3\:net426 VSS) capacitor c=1.00475e-16
C132 (\13\:CKb VSS) capacitor c=6.40048e-17
C133 (\14\:CKbb VSS) capacitor c=5.14005e-17
C134 (\12\:n20 VSS) capacitor c=6.64112e-17
C135 (\14\:n20 VSS) capacitor c=7.04559e-17
C136 (\2\:CK VSS) capacitor c=3.40667e-17
C137 (\2\:CKb VSS) capacitor c=2.77704e-17
C138 (\3\:CKb VSS) capacitor c=5.55381e-17
C139 (\6\:CKb VSS) capacitor c=1.10229e-16
C140 (\2\:n35g VSS) capacitor c=3.34308e-17
C141 (ExtVDD VSS) capacitor c=3.93674e-17
C142 (\4\:RT VSS) capacitor c=7.44104e-17
C143 (\2\:qbint VSS) capacitor c=4.11428e-17
C144 (\5\:CKbb VSS) capacitor c=1.36991e-16
C145 (\6\:CKbb VSS) capacitor c=7.71037e-17
C146 (\4\:SN VSS) capacitor c=3.37826e-16
C147 (\5\:RNb VSS) capacitor c=5.20565e-16
C148 (\6\:RNb VSS) capacitor c=1.20397e-16
C149 (\12\:CKbb VSS) capacitor c=6.37884e-17
C150 (\13\:CKbb VSS) capacitor c=7.44131e-17
C151 (\8\:qbint VSS) capacitor c=1.06688e-16
C152 (\10\:n20 VSS) capacitor c=2.90055e-17
C153 (\11\:n20 VSS) capacitor c=6.97291e-17
C154 (\18\:n20 VSS) capacitor c=3.09122e-17
C155 (\17\:CKbb VSS) capacitor c=7.3919e-17
C156 (\10\:SN VSS) capacitor c=4.03939e-17
C157 (\11\:SN VSS) capacitor c=4.60272e-17
C158 (\5\:CK VSS) capacitor c=4.79538e-17
C159 (\6\:CK VSS) capacitor c=3.77231e-17
C160 (\15\:CKb VSS) capacitor c=7.15848e-17
C161 (\16\:CKb VSS) capacitor c=5.06653e-17
C162 (\19\:n20 VSS) capacitor c=8.13077e-17
C163 (\20\:n20 VSS) capacitor c=8.10401e-17
C164 (\12\:RNb VSS) capacitor c=5.88315e-17
C165 (\15\:RNb VSS) capacitor c=7.18462e-17
C166 (\16\:RNb VSS) capacitor c=8.34723e-17
C167 (\7\:mout VSS) capacitor c=1.56815e-16
C168 (\8\:mout VSS) capacitor c=5.3069e-17
C169 (\9\:mout VSS) capacitor c=1.06011e-16
C170 (\10\:mout VSS) capacitor c=8.55468e-17
C171 (\15\:mout VSS) capacitor c=6.20018e-17
C172 (\18\:mout VSS) capacitor c=7.39983e-17
C173 (\6\:n35 VSS) capacitor c=1.07161e-16
C174 (\19\:CKb VSS) capacitor c=3.8856e-17
C175 (\20\:CKb VSS) capacitor c=4.15834e-17
C176 (\8\:n35g VSS) capacitor c=3.19653e-17
C177 (\11\:n35 VSS) capacitor c=7.57391e-17
C178 (\12\:qbint VSS) capacitor c=8.82391e-17
C179 (\13\:qbint VSS) capacitor c=1.08749e-16
C180 (\13\:n35g VSS) capacitor c=9.96775e-17
C181 (\14\:n35g VSS) capacitor c=1.16145e-16
C182 (\5\:RTb VSS) capacitor c=4.94027e-17
C183 (\8\:RTb VSS) capacitor c=1.00867e-16
C184 (\9\:RTb VSS) capacitor c=9.21104e-17
C185 (\9\:RT VSS) capacitor c=1.10852e-16
C186 (\10\:RT VSS) capacitor c=1.18364e-16
C187 (\11\:RT VSS) capacitor c=3.85833e-17
C188 (\12\:SN VSS) capacitor c=8.28873e-17
C189 (\13\:SN VSS) capacitor c=8.06e-17
C190 (\20\:CKbb VSS) capacitor c=1.31776e-16
C191 (\21\:CKbb VSS) capacitor c=1.34217e-16
C192 (\18\:qbint VSS) capacitor c=1.95455e-17
C193 (\19\:qbint VSS) capacitor c=3.01215e-17
C194 (\16\:n35 VSS) capacitor c=5.0763e-17
C195 (\3\:VDD VSS) capacitor c=3.24499e-17
C196 (\4\:VDD VSS) capacitor c=2.62949e-17
C197 (\6\:VDD VSS) capacitor c=2.22593e-16
C198 (\7\:VDD VSS) capacitor c=1.92685e-16
C199 (\8\:VDD VSS) capacitor c=2.35077e-17
C200 (\10\:VDD VSS) capacitor c=2.59166e-17
C201 (\11\:VDD VSS) capacitor c=1.78868e-17
C202 (\12\:VDD VSS) capacitor c=2.60631e-17
C203 (\13\:VDD VSS) capacitor c=2.74726e-17
Rk19 (\5\:RN RN) resistor r=0.04968 c=0
Rk57 (RT \9\:RT) resistor r=0.182 c=0
Rk58 (\9\:RT \10\:RT) resistor r=0.6461 c=0
Rk59 (RT \11\:RT) resistor r=0.0166 c=0
Rk11 (SN \10\:SN) resistor r=0.01265 c=0
Rk12 (\10\:SN \11\:SN) resistor r=0.3244 c=0
Rk60 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk2 (\4\:D D) resistor r=0.006097 c=0
Rk80 (\2\:VDD \3\:VDD) resistor r=0.3366 c=0
Rk81 (\3\:VDD \4\:VDD) resistor r=0.2178 c=0
Rk82 (\4\:VDD \6\:VDD) resistor r=0.06676 c=0
Rk83 (\6\:VDD \7\:VDD) resistor r=1.6934 c=0
Rk84 (\7\:VDD \8\:VDD) resistor r=0.08888 c=0
Rk85 (\8\:VDD \10\:VDD) resistor r=0.1312 c=0
Rk86 (\10\:VDD \11\:VDD) resistor r=0.08907 c=0
Rk88 (\12\:VDD VDD) resistor r=0.1955 c=0
Rk87 (\11\:VDD \12\:VDD) resistor r=0.08144 c=0
Rk89 (VDD \13\:VDD) resistor r=0.1464 c=0
Rk90 (\13\:VDD VDD) resistor r=0.08883 c=0
Rk91 (\3\:VDD \15\:VDD) resistor r=0.3564 c=0
Rk92 (\4\:VDD \17\:VDD) resistor r=0.2927 c=0
Rk93 (\7\:VDD \19\:VDD) resistor r=0.2015 c=0
Rk94 (\8\:VDD \21\:VDD) resistor r=0.359 c=0
Rk95 (\11\:VDD \23\:VDD) resistor r=0.3797 c=0
Rk96 (\12\:VDD \25\:VDD) resistor r=0.2069 c=0
Rk97 (\13\:VDD \27\:VDD) resistor r=0.3585 c=0
Rk66 (\2\:Q Q) resistor r=0.1703 c=0
Rk67 (Q \4\:Q) resistor r=0.2987 c=0
Rk44 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk42 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk45 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk46 (ExtVDD \6\:ExtVDD) resistor r=0.1056 c=0
Rk13 (CK \5\:CK) resistor r=0.004352 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01406 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.004534 c=0
Rk70 (\2\:VSS \3\:VSS) resistor r=0.03204 c=0
Rk71 (\3\:VSS \4\:VSS) resistor r=0.5131 c=0
Rk72 (\4\:VSS \5\:VSS) resistor r=0.5159 c=0
Rk74 (\6\:VSS VSS) resistor r=0.04935 c=0
Rk73 (\5\:VSS \6\:VSS) resistor r=0.3271 c=0
Rk76 (\7\:VSS VSS) resistor r=0.1213 c=0
Rk75 (VSS \7\:VSS) resistor r=0.8929 c=0
Rk77 (\3\:VSS \9\:VSS) resistor r=0.2485 c=0
Rk78 (\5\:VSS \11\:VSS) resistor r=0.2434 c=0
Rk79 (VSS \13\:VSS) resistor r=0.3081 c=0
Rk98 (\15\:VSS \17\:VSS) resistor r=0.3613 c=0
Rk99 (\17\:VSS \18\:VSS) resistor r=0.8431 c=0
Rk100 (\18\:VSS \19\:VSS) resistor r=0.06676 c=0
Rk102 (\20\:VSS VSS) resistor r=0.1211 c=0
Rk101 (\19\:VSS \20\:VSS) resistor r=0.2079 c=0
Rk103 (VSS \21\:VSS) resistor r=0.7291 c=0
Rk105 (\22\:VSS VSS) resistor r=0.1188 c=0
Rk104 (\21\:VSS \22\:VSS) resistor r=0.06428 c=0
Rk106 (VSS \23\:VSS) resistor r=0.03725 c=0
Rk107 (\23\:VSS \24\:VSS) resistor r=0.4236 c=0
Rk108 (\24\:VSS \25\:VSS) resistor r=0.06428 c=0
Rk109 (\19\:VSS \27\:VSS) resistor r=0.1891 c=0
Rk110 (\20\:VSS \29\:VSS) resistor r=0.1942 c=0
Rk111 (\21\:VSS \31\:VSS) resistor r=0.2359 c=0
Rk112 (\23\:VSS \33\:VSS) resistor r=0.2364 c=0
Rk113 (\24\:VSS \35\:VSS) resistor r=0.2282 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6841 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3494 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01514 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2035 c=0
Rk61 (\20\:CKbb \21\:CKbb) resistor r=0.8245 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.7619 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.3523 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.1709 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.3404 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1231 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.09956 c=0
Rk31 (\9\:mout \15\:mout) resistor r=0.5241 c=0
Rk32 (\15\:mout \17\:mout) resistor r=0.04481 c=0
Rk33 (\10\:mout \18\:mout) resistor r=0.425 c=0
Rk34 (\15\:mout \20\:mout) resistor r=0.03462 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.2067 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2104 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.4456 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4887 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1577 c=0
Rk20 (\19\:n20 \20\:n20) resistor r=0.4615 c=0
Rk22 (\11\:RNb \12\:RNb) resistor r=0.3432 c=0
Rk23 (\12\:RNb \14\:RNb) resistor r=0.1482 c=0
Rk24 (\15\:RNb \16\:RNb) resistor r=0.3465 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3583 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1632 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.2066 c=0
Rk37 (\19\:CKb \20\:CKb) resistor r=0.3681 c=0
Rk38 (\7\:n35g \8\:n35g) resistor r=0.2407 c=0
Rk39 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk50 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk51 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk52 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk47 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk48 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk49 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk62 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk53 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk54 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk55 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk56 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4289 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.3027 c=0
Rk40 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk41 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk63 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk64 (\16\:n35 \18\:n35) resistor r=0.2874 c=0
Rk68 (\2\:n41 \4\:n41) resistor r=0.7136 c=0
Rk69 (\2\:n42 \4\:n42) resistor r=0.5301 c=0
Rk65 (\2\:n40 \4\:n40) resistor r=0.6255 c=0
Rk21 (\2\:net426 \4\:net426) resistor r=0.5521 c=0
Rl16 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl14 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl15 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl47 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl34 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl37 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl36 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl35 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl66 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl67 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl8 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl50 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl48 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl49 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl2 (\2\:D \3\:D) resistor r=108.118 c=0
Rl1 (\1\:D \2\:D) resistor r=70.6183 c=0
Rl11 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl9 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl10 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl4 (CKbb \2\:CKbb) resistor r=167.403 c=0
Rl53 (\10\:CKbb \11\:CKbb) resistor r=166.412 c=0
Rl5 (\2\:CKbb \3\:CKbb) resistor r=349.426 c=0
Rl42 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl45 (\5\:CKbb \8\:CKbb) resistor r=762.322 c=0
Rl46 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl44 (\6\:CKbb \7\:CKbb) resistor r=132.647 c=0
Rl43 (\5\:CKbb \6\:CKbb) resistor r=465.929 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl17 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl55 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl18 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl56 (\4\:RNb \5\:RNb) resistor r=1125.6 c=0
Rl59 (\5\:RNb \8\:RNb) resistor r=775.703 c=0
Rl58 (\6\:RNb \7\:RNb) resistor r=142.538 c=0
Rl60 (\6\:RNb \9\:RNb) resistor r=2.7666 c=0
Rl57 (\5\:RNb \6\:RNb) resistor r=283.029 c=0
Rl27 (\9\:CKb \10\:CKb) resistor r=163.736 c=0
Rl54 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl19 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl22 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl25 (\3\:CKb \8\:CKb) resistor r=67.2828 c=0
Rl21 (\3\:CKb \4\:CKb) resistor r=234.553 c=0
Rl20 (\2\:CKb \3\:CKb) resistor r=77.7008 c=0
Rl26 (\6\:CKb \9\:CKb) resistor r=506.359 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=86.9066 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=234.725 c=0
Rl30 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl28 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl29 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl31 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl61 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl65 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl41 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl38 (qbint \2\:qbint) resistor r=112.732 c=0
Rl40 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl39 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl62 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl64 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl63 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl32 (RTb \2\:RTb) resistor r=112.412 c=0
Rl33 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl51 (n35 \2\:n35) resistor r=508.667 c=0
Rl52 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz23 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz24 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz25 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz28 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz29 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz31 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz32 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz33 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz7 (\10\:RNb \11\:RNb) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz21 (n42 \2\:n42) resistor r=75 c=0
Rz22 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (n40 \2\:n40) resistor r=75 c=0
Rz19 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz5 (net426 \2\:net426) resistor r=75 c=0
Rz6 (\3\:net426 \4\:net426) resistor r=75 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry27 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
Ry28 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry29 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry31 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry32 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry33 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry19 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry12 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry25 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry34 (\16\:VSS \17\:VSS) resistor r=12.4 c=0
Ry35 (\16\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry36 (\16\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry37 (\16\:VSS \25\:VSS) resistor r=62 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\16\:mout \17\:mout) resistor r=62 c=0
Ry8 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry5 (\13\:RNb \14\:RNb) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry10 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry16 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry15 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry17 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry9 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry11 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx12 (\3\:RN \5\:RN) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\5\:SN \10\:SN) resistor r=45 c=0
Rx9 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx34 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx18 (\4\:mout \10\:mout) resistor r=45 c=0
Rx19 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx15 (\8\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\9\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx11 (CKb \16\:CKb) resistor r=45 c=0
Rx21 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx22 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx36 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx37 (qbint \19\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn20 (\13\:CKb \1\:CK \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \6\:SN \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\10\:RNb \1\:RN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\7\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\16\:qbint \5\:n35g \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n40 \3\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \8\:SN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\16\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\18\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\19\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp22 (\13\:RNb \4\:RN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.1952 \
        scb=0.00791337 scc=0.000154249 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n43 \4\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n41 \10\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends RDFFSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:52:18 2012 )
// Library name: gsclib045
// Cell name: RDFFSRX1
// View name: extracted

simulator lang=spectre

subckt RDFFSRX1 CK D ExtVDD Q QN RN RT SN VDD VSS
mp22 (\11\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.4481 \
        scb=0.0196885 scc=0.000695801 m=(1)
C1 (Q VSS) capacitor c=4.97632e-17
C2 (ExtVDD VSS) capacitor c=3.41735e-16
C3 (CK VSS) capacitor c=3.80732e-17
C4 (RN VSS) capacitor c=8.79545e-17
C5 (RT VSS) capacitor c=7.61948e-17
C6 (QN VSS) capacitor c=1.98965e-17
C7 (VDD VSS) capacitor c=7.42854e-16
C8 (SN VSS) capacitor c=3.73045e-17
C9 (D VSS) capacitor c=2.76271e-17
C10 (n20 VSS) capacitor c=5.58767e-17
C11 (CKbb VSS) capacitor c=6.53867e-17
C12 (mout VSS) capacitor c=4.81917e-17
C13 (RNb VSS) capacitor c=3.83103e-17
C14 (RTb VSS) capacitor c=5.50626e-17
C15 (CKb VSS) capacitor c=6.30399e-17
C16 (n35g VSS) capacitor c=1.61508e-17
C17 (qbint VSS) capacitor c=4.41826e-17
C18 (n35 VSS) capacitor c=4.77117e-17
C19 (qint VSS) capacitor c=2.23971e-17
C20 (n41 VSS) capacitor c=8.42008e-17
C21 (net426 VSS) capacitor c=8.68145e-17
C22 (n40 VSS) capacitor c=8.44192e-17
C23 (n42 VSS) capacitor c=7.9367e-17
C24 (\9\:SN VSS) capacitor c=7.05332e-17
C25 (\7\:qbint VSS) capacitor c=3.28494e-17
C26 (\11\:qbint VSS) capacitor c=1.40691e-16
C27 (\9\:RNb VSS) capacitor c=1.3033e-16
C28 (\13\:qbint VSS) capacitor c=4.52853e-17
C29 (\3\:qint VSS) capacitor c=6.11474e-17
C30 (\10\:CKbb VSS) capacitor c=5.86944e-17
C31 (\4\:RTb VSS) capacitor c=1.20506e-16
C32 (\6\:RT VSS) capacitor c=5.10042e-17
C33 (\4\:qbint VSS) capacitor c=6.71074e-17
C34 (\3\:n35g VSS) capacitor c=9.19416e-17
C35 (\3\:RT VSS) capacitor c=9.7108e-17
C36 (\8\:CKb VSS) capacitor c=4.02998e-17
C37 (\7\:RNb VSS) capacitor c=5.58168e-17
C38 (\3\:n20 VSS) capacitor c=4.79458e-17
C39 (\4\:CK VSS) capacitor c=6.28877e-17
C40 (\1\:SN VSS) capacitor c=2.60411e-17
C41 (\4\:CKb VSS) capacitor c=2.93581e-17
C42 (\9\:CKb VSS) capacitor c=1.16108e-16
C43 (\2\:CKbb VSS) capacitor c=1.51528e-16
C44 (\4\:D VSS) capacitor c=8.80674e-17
C45 (\1\:RN VSS) capacitor c=4.24263e-17
C46 (\10\:SN VSS) capacitor c=1.32177e-16
C47 (\6\:qbint VSS) capacitor c=3.71675e-17
C48 (\12\:qbint VSS) capacitor c=8.05994e-17
C49 (\8\:RNb VSS) capacitor c=6.59234e-17
C50 (\14\:qbint VSS) capacitor c=4.68281e-17
C51 (\4\:qint VSS) capacitor c=3.79512e-17
C52 (\12\:CKb VSS) capacitor c=5.20225e-17
C53 (\4\:RT VSS) capacitor c=1.54884e-16
C54 (\5\:RT VSS) capacitor c=6.62977e-17
C55 (\5\:qbint VSS) capacitor c=3.89239e-17
C56 (\4\:n35g VSS) capacitor c=2.69017e-17
C57 (\4\:CKbb VSS) capacitor c=3.37068e-17
C58 (\6\:n20 VSS) capacitor c=6.14389e-17
C59 (\1\:CK VSS) capacitor c=2.95118e-17
C60 (\3\:SN VSS) capacitor c=4.67477e-17
C61 (\11\:CKb VSS) capacitor c=2.57631e-17
C62 (\3\:mout VSS) capacitor c=4.57969e-17
C63 (\9\:CKbb VSS) capacitor c=4.92242e-17
C64 (\7\:CKb VSS) capacitor c=8.73787e-17
C65 (\1\:D VSS) capacitor c=5.17816e-17
C66 (\4\:RN VSS) capacitor c=3.69343e-17
C67 (\10\:RNb VSS) capacitor c=5.66128e-17
C68 (\13\:CKb VSS) capacitor c=4.25347e-17
C69 (\3\:n35 VSS) capacitor c=8.33805e-17
C70 (\10\:qbint VSS) capacitor c=8.39378e-17
C71 (\8\:SN VSS) capacitor c=6.27505e-17
C72 (\11\:SN VSS) capacitor c=9.51363e-17
C73 (\11\:CKbb VSS) capacitor c=6.01641e-17
C74 (\1\:RT VSS) capacitor c=1.78573e-16
C75 (\8\:CKbb VSS) capacitor c=1.40379e-16
C76 (\3\:RTb VSS) capacitor c=9.90162e-17
C77 (\7\:SN VSS) capacitor c=5.86024e-17
C78 (\4\:n35 VSS) capacitor c=6.90242e-17
C79 (\3\:qbint VSS) capacitor c=4.77478e-17
C80 (\6\:SN VSS) capacitor c=1.6739e-16
C81 (\1\:ExtVDD VSS) capacitor c=7.98494e-17
C82 (\2\:ExtVDD VSS) capacitor c=8.02791e-17
C83 (\2\:RTb VSS) capacitor c=5.41432e-17
C84 (\5\:n35g VSS) capacitor c=1.02007e-16
C85 (\2\:n35 VSS) capacitor c=5.56521e-17
C86 (\3\:RNb VSS) capacitor c=4.02966e-17
C87 (\2\:RNb VSS) capacitor c=4.32741e-17
C88 (\4\:RNb VSS) capacitor c=4.85635e-17
C89 (\7\:n20 VSS) capacitor c=5.32732e-17
C90 (\4\:n20 VSS) capacitor c=1.25118e-16
C91 (\3\:CK VSS) capacitor c=2.58563e-17
C92 (\10\:CKb VSS) capacitor c=2.16688e-17
C93 (\2\:SN VSS) capacitor c=4.94256e-17
C94 (\5\:SN VSS) capacitor c=2.63449e-17
C95 (\2\:mout VSS) capacitor c=4.31228e-17
C96 (\4\:mout VSS) capacitor c=3.16656e-17
C97 (\5\:n20 VSS) capacitor c=1.11516e-16
C98 (\3\:CKbb VSS) capacitor c=7.57749e-17
C99 (\7\:CKbb VSS) capacitor c=2.68879e-17
C100 (\3\:D VSS) capacitor c=1.52134e-17
C101 (\6\:RNb VSS) capacitor c=1.36482e-16
C102 (\2\:n20 VSS) capacitor c=6.96147e-17
C103 (\3\:RN VSS) capacitor c=4.67795e-17
C104 (\1\:VDD VSS) capacitor c=3.0029e-17
C105 (\11\:VDD VSS) capacitor c=4.49493e-17
C106 (\3\:Q VSS) capacitor c=8.425e-17
C107 (\13\:VDD VSS) capacitor c=5.0336e-17
C108 (\9\:qint VSS) capacitor c=5.46386e-17
C109 (\15\:VDD VSS) capacitor c=7.86472e-17
C110 (\3\:n41 VSS) capacitor c=9.77578e-17
C111 (\4\:QN VSS) capacitor c=6.24323e-17
C112 (\17\:n35 VSS) capacitor c=1.07272e-16
C113 (\15\:n35g VSS) capacitor c=5.66689e-17
C114 (\9\:RTb VSS) capacitor c=3.94824e-17
C115 (\11\:ExtVDD VSS) capacitor c=3.21729e-17
C116 (\3\:ExtVDD VSS) capacitor c=1.00913e-16
C117 (\7\:n35g VSS) capacitor c=6.85037e-17
C118 (\17\:qbint VSS) capacitor c=6.54125e-17
C119 (\5\:n35 VSS) capacitor c=5.94996e-17
C120 (\13\:n35 VSS) capacitor c=1.03593e-16
C121 (\5\:mout VSS) capacitor c=1.31817e-16
C122 (\17\:VDD VSS) capacitor c=4.42334e-17
C123 (\16\:CKb VSS) capacitor c=4.51257e-17
C124 (\15\:mout VSS) capacitor c=1.11308e-16
C125 (\22\:VDD VSS) capacitor c=5.74215e-17
C126 (\20\:VDD VSS) capacitor c=6.65173e-17
C127 (\18\:CKbb VSS) capacitor c=4.95554e-17
C128 (\18\:n20 VSS) capacitor c=3.23402e-17
C129 (\8\:n20 VSS) capacitor c=6.26379e-17
C130 (\29\:VDD VSS) capacitor c=3.6783e-17
C131 (\11\:RNb VSS) capacitor c=5.05803e-17
C132 (\27\:VDD VSS) capacitor c=4.68941e-17
C133 (\1\:Q VSS) capacitor c=5.44448e-17
C134 (\5\:qint VSS) capacitor c=4.69424e-17
C135 (\3\:n42 VSS) capacitor c=8.07711e-17
C136 (\3\:n40 VSS) capacitor c=8.13656e-17
C137 (\1\:QN VSS) capacitor c=4.7192e-17
C138 (\19\:n35 VSS) capacitor c=9.33561e-17
C139 (\11\:n35g VSS) capacitor c=2.94181e-17
C140 (\6\:RTb VSS) capacitor c=1.62462e-16
C141 (\9\:n35g VSS) capacitor c=8.13154e-17
C142 (\19\:qbint VSS) capacitor c=2.27182e-17
C143 (\11\:n35 VSS) capacitor c=2.56314e-17
C144 (\9\:n35 VSS) capacitor c=2.61597e-17
C145 (\11\:mout VSS) capacitor c=3.71471e-17
C146 (\13\:mout VSS) capacitor c=3.82409e-17
C147 (\18\:CKb VSS) capacitor c=5.81728e-17
C148 (\3\:net426 VSS) capacitor c=1.00173e-16
C149 (\14\:CKbb VSS) capacitor c=4.93952e-17
C150 (\14\:n20 VSS) capacitor c=5.7206e-17
C151 (\12\:n20 VSS) capacitor c=8.58402e-17
C152 (\14\:RNb VSS) capacitor c=7.34902e-17
C153 (VDD VSS) capacitor c=5.24716e-17
C154 (\2\:D VSS) capacitor c=5.34492e-17
C155 (\2\:CK VSS) capacitor c=4.12928e-17
C156 (\5\:RNb VSS) capacitor c=1.78447e-16
C157 (\2\:CKb VSS) capacitor c=8.58536e-17
C158 (\3\:CKb VSS) capacitor c=6.90482e-17
C159 (\5\:CKb VSS) capacitor c=3.29392e-17
C160 (\6\:CKb VSS) capacitor c=6.1961e-17
C161 (\2\:n35g VSS) capacitor c=3.44751e-17
C162 (\4\:SN VSS) capacitor c=2.11916e-16
C163 (\2\:qbint VSS) capacitor c=4.30878e-17
C164 (\5\:CKbb VSS) capacitor c=1.28817e-16
C165 (\6\:CKbb VSS) capacitor c=7.32144e-17
C166 (\2\:RT VSS) capacitor c=1.21201e-16
C167 (\2\:qint VSS) capacitor c=1.59387e-17
C168 (\13\:RNb VSS) capacitor c=1.20166e-16
C169 (\7\:D VSS) capacitor c=3.82395e-17
C170 (\12\:CKbb VSS) capacitor c=1.55623e-16
C171 (\13\:CKbb VSS) capacitor c=1.37959e-16
C172 (\8\:qbint VSS) capacitor c=5.09791e-17
C173 (\9\:qbint VSS) capacitor c=7.80552e-17
C174 (\10\:n20 VSS) capacitor c=7.77649e-17
C175 (\11\:n20 VSS) capacitor c=9.26184e-17
C176 (\16\:n20 VSS) capacitor c=6.53716e-17
C177 (\17\:n20 VSS) capacitor c=4.09224e-17
C178 (\17\:CKbb VSS) capacitor c=7.78565e-17
C179 (\12\:SN VSS) capacitor c=3.46687e-17
C180 (\13\:SN VSS) capacitor c=4.70007e-17
C181 (\7\:CK VSS) capacitor c=4.21288e-17
C182 (\14\:CKb VSS) capacitor c=4.61834e-17
C183 (\15\:CKb VSS) capacitor c=4.18548e-17
C184 (\20\:n20 VSS) capacitor c=7.68941e-17
C185 (\21\:n20 VSS) capacitor c=7.95904e-17
C186 (\16\:RNb VSS) capacitor c=7.12857e-17
C187 (\17\:RNb VSS) capacitor c=8.15912e-17
C188 (\7\:mout VSS) capacitor c=1.55721e-16
C189 (\8\:mout VSS) capacitor c=5.32172e-17
C190 (\9\:mout VSS) capacitor c=9.99444e-17
C191 (\10\:mout VSS) capacitor c=8.63714e-17
C192 (\17\:mout VSS) capacitor c=6.966e-17
C193 (\7\:n35 VSS) capacitor c=7.79277e-17
C194 (\8\:n35 VSS) capacitor c=1.20587e-16
C195 (\6\:n35g VSS) capacitor c=3.78131e-17
C196 (\13\:ExtVDD VSS) capacitor c=4.09478e-17
C197 (\15\:qbint VSS) capacitor c=9.02634e-17
C198 (\16\:qbint VSS) capacitor c=1.09415e-16
C199 (\13\:n35g VSS) capacitor c=1.04812e-16
C200 (\14\:n35g VSS) capacitor c=1.17203e-16
C201 (\14\:SN VSS) capacitor c=3.62102e-17
C202 (\15\:SN VSS) capacitor c=5.31263e-17
C203 (\15\:n35 VSS) capacitor c=5.86461e-17
C204 (\16\:n35 VSS) capacitor c=8.453e-17
C205 (\5\:RTb VSS) capacitor c=7.44742e-17
C206 (\8\:RTb VSS) capacitor c=1.06383e-16
C207 (\16\:SN VSS) capacitor c=8.83138e-17
C208 (\17\:SN VSS) capacitor c=8.45231e-17
C209 (\20\:CKbb VSS) capacitor c=1.27389e-16
C210 (\21\:CKbb VSS) capacitor c=1.17669e-16
C211 (\21\:qbint VSS) capacitor c=2.36714e-17
C212 (\22\:qbint VSS) capacitor c=2.97137e-17
C213 (\7\:RT VSS) capacitor c=8.0908e-17
C214 (\20\:CKb VSS) capacitor c=3.40814e-16
C215 (\21\:CKb VSS) capacitor c=4.07365e-16
C216 (\18\:RNb VSS) capacitor c=3.79856e-16
C217 (\19\:RNb VSS) capacitor c=3.25706e-16
C218 (\3\:QN VSS) capacitor c=3.15395e-17
C219 (\21\:n35 VSS) capacitor c=4.37774e-17
C220 (\7\:qint VSS) capacitor c=5.3604e-17
C221 (\8\:qint VSS) capacitor c=3.60733e-17
C222 (\3\:VDD VSS) capacitor c=3.02064e-17
C223 (\4\:VDD VSS) capacitor c=3.26173e-17
C224 (\6\:VDD VSS) capacitor c=1.00014e-17
C225 (\7\:VDD VSS) capacitor c=2.89735e-16
C226 (\8\:VDD VSS) capacitor c=2.3899e-16
C227 (\10\:VDD VSS) capacitor c=4.1172e-17
C228 (\19\:VDD VSS) capacitor c=1.22057e-17
C229 (\24\:VDD VSS) capacitor c=2.31419e-17
C230 (\26\:VDD VSS) capacitor c=3.30385e-17
Rk76 (\2\:Q Q) resistor r=0.1675 c=0
Rk77 (Q \4\:Q) resistor r=0.336 c=0
Rk46 (ExtVDD ExtVDD) resistor r=0.002123 c=0
Rk43 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.02229 c=0
Rk44 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.02229 c=0
Rk47 (\8\:ExtVDD ExtVDD) resistor r=0.01337 c=0
Rk45 (\5\:ExtVDD \8\:ExtVDD) resistor r=0.02006 c=0
Rk49 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.08224 c=0
Rk19 (\5\:CK CK) resistor r=0.004354 c=0
Rk21 (\5\:CK \7\:CK) resistor r=0.01392 c=0
Rk20 (\6\:CK \7\:CK) resistor r=0.004187 c=0
Rk1 (\5\:RN RN) resistor r=0.007658 c=0
Rk64 (\7\:RT RT) resistor r=0.01288 c=0
Rk68 (\3\:QN QN) resistor r=0.04336 c=0
Rk67 (\2\:QN \3\:QN) resistor r=0.3244 c=0
Rk69 (\3\:QN \5\:QN) resistor r=0.2331 c=0
Rk92 (\2\:VDD \3\:VDD) resistor r=0.3391 c=0
Rk93 (\3\:VDD \4\:VDD) resistor r=0.2189 c=0
Rk94 (\4\:VDD \6\:VDD) resistor r=0.06709 c=0
Rk95 (\6\:VDD \7\:VDD) resistor r=0.05214 c=0
Rk96 (\7\:VDD \8\:VDD) resistor r=1.6493 c=0
Rk97 (\8\:VDD \10\:VDD) resistor r=0.2216 c=0
Rk98 (\3\:VDD \12\:VDD) resistor r=0.3594 c=0
Rk99 (\4\:VDD \14\:VDD) resistor r=0.2953 c=0
Rk100 (\7\:VDD \16\:VDD) resistor r=0.3642 c=0
Rk101 (\8\:VDD \18\:VDD) resistor r=0.2033 c=0
Rk102 (\10\:VDD \19\:VDD) resistor r=0.09511 c=0
Rk103 (\19\:VDD \21\:VDD) resistor r=0.2308 c=0
Rk104 (\10\:VDD \23\:VDD) resistor r=0.3458 c=0
Rk107 (\24\:VDD VDD) resistor r=0.1964 c=0
Rk105 (\19\:VDD \24\:VDD) resistor r=0.07686 c=0
Rk106 (\24\:VDD \25\:VDD) resistor r=0.2207 c=0
Rk108 (VDD \26\:VDD) resistor r=0.06983 c=0
Rk109 (\26\:VDD VDD) resistor r=0.1671 c=0
Rk110 (VDD \28\:VDD) resistor r=0.3808 c=0
Rk111 (\26\:VDD \30\:VDD) resistor r=0.2828 c=0
Rk17 (\12\:SN SN) resistor r=0.03613 c=0
Rk18 (SN \13\:SN) resistor r=0.2361 c=0
Rk56 (\14\:SN \15\:SN) resistor r=0.2157 c=0
Rk61 (\16\:SN \17\:SN) resistor r=0.4639 c=0
Rk4 (\5\:D D) resistor r=0.00603 c=0
Rk6 (\5\:D \7\:D) resistor r=0.03636 c=0
Rk5 (\6\:D \7\:D) resistor r=0.00603 c=0
Rk85 (VSS VSS) resistor r=0.8423 c=0
Rk80 (\2\:VSS \3\:VSS) resistor r=0.02971 c=0
Rk81 (\3\:VSS \4\:VSS) resistor r=0.2689 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.7852 c=0
Rk84 (\6\:VSS VSS) resistor r=0.2988 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.06211 c=0
Rk86 (VSS \7\:VSS) resistor r=0.05507 c=0
Rk87 (\7\:VSS \8\:VSS) resistor r=0.1369 c=0
Rk88 (\8\:VSS \10\:VSS) resistor r=0.6667 c=0
Rk89 (\3\:VSS \12\:VSS) resistor r=0.2507 c=0
Rk90 (\5\:VSS \14\:VSS) resistor r=0.1674 c=0
Rk91 (\8\:VSS \16\:VSS) resistor r=0.2532 c=0
Rk112 (\18\:VSS \20\:VSS) resistor r=0.3664 c=0
Rk113 (\20\:VSS \21\:VSS) resistor r=0.2365 c=0
Rk114 (\21\:VSS \22\:VSS) resistor r=0.3611 c=0
Rk115 (\22\:VSS \23\:VSS) resistor r=0.3138 c=0
Rk117 (\24\:VSS VSS) resistor r=0.1242 c=0
Rk116 (\23\:VSS \24\:VSS) resistor r=0.2089 c=0
Rk119 (\25\:VSS VSS) resistor r=0.543 c=0
Rk118 (VSS \25\:VSS) resistor r=0.2993 c=0
Rk120 (VSS \26\:VSS) resistor r=0.03743 c=0
Rk121 (\26\:VSS \27\:VSS) resistor r=0.2166 c=0
Rk122 (\27\:VSS \28\:VSS) resistor r=0.2042 c=0
Rk123 (\28\:VSS \29\:VSS) resistor r=0.0945 c=0
Rk124 (\21\:VSS \31\:VSS) resistor r=0.2657 c=0
Rk125 (\23\:VSS \33\:VSS) resistor r=0.1908 c=0
Rk126 (\24\:VSS \35\:VSS) resistor r=0.1959 c=0
Rk127 (\26\:VSS \37\:VSS) resistor r=0.2425 c=0
Rk128 (\28\:VSS \39\:VSS) resistor r=0.2302 c=0
Rk8 (\9\:n20 \10\:n20) resistor r=0.3483 c=0
Rk9 (\9\:n20 \11\:n20) resistor r=0.2313 c=0
Rk10 (\11\:n20 \13\:n20) resistor r=0.5005 c=0
Rk11 (\15\:n20 \16\:n20) resistor r=0.4311 c=0
Rk12 (\16\:n20 \17\:n20) resistor r=0.314 c=0
Rk13 (\16\:n20 \19\:n20) resistor r=0.1617 c=0
Rk25 (\20\:n20 \21\:n20) resistor r=0.4665 c=0
Rk7 (\12\:CKbb \13\:CKbb) resistor r=0.8559 c=0
Rk14 (\15\:CKbb \16\:CKbb) resistor r=0.3312 c=0
Rk15 (\16\:CKbb \17\:CKbb) resistor r=0.01521 c=0
Rk16 (\16\:CKbb \19\:CKbb) resistor r=0.3111 c=0
Rk62 (\20\:CKbb \21\:CKbb) resistor r=0.7149 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.7682 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3554 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1724 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.3428 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.124 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.1005 c=0
Rk34 (\9\:mout \16\:mout) resistor r=0.5127 c=0
Rk35 (\10\:mout \17\:mout) resistor r=0.4285 c=0
Rk2 (\12\:RNb \13\:RNb) resistor r=0.1647 c=0
Rk3 (\13\:RNb \15\:RNb) resistor r=0.3836 c=0
Rk27 (\16\:RNb \17\:RNb) resistor r=0.3493 c=0
Rk66 (\18\:RNb \19\:RNb) resistor r=2.3522 c=0
Rk58 (\5\:RTb \7\:RTb) resistor r=0.5298 c=0
Rk59 (\7\:RTb \8\:RTb) resistor r=0.7289 c=0
Rk60 (\8\:RTb \10\:RTb) resistor r=0.1191 c=0
Rk22 (\14\:CKb \15\:CKb) resistor r=0.1998 c=0
Rk23 (\15\:CKb \17\:CKb) resistor r=0.2314 c=0
Rk24 (\15\:CKb \19\:CKb) resistor r=0.3608 c=0
Rk65 (\20\:CKb \21\:CKb) resistor r=2.3652 c=0
Rk41 (\6\:n35g \8\:n35g) resistor r=0.1274 c=0
Rk42 (\8\:n35g \10\:n35g) resistor r=0.5913 c=0
Rk53 (\12\:n35g \13\:n35g) resistor r=0.245 c=0
Rk54 (\13\:n35g \14\:n35g) resistor r=0.5703 c=0
Rk55 (\13\:n35g \16\:n35g) resistor r=0.4355 c=0
Rk50 (\15\:qbint \16\:qbint) resistor r=0.4987 c=0
Rk51 (\16\:qbint \18\:qbint) resistor r=0.5718 c=0
Rk52 (\16\:qbint \20\:qbint) resistor r=0.1475 c=0
Rk63 (\21\:qbint \22\:qbint) resistor r=0.2135 c=0
Rk36 (\6\:n35 \7\:n35) resistor r=0.4146 c=0
Rk37 (\7\:n35 \8\:n35) resistor r=0.5509 c=0
Rk38 (\8\:n35 \10\:n35) resistor r=0.1724 c=0
Rk39 (\7\:n35 \12\:n35) resistor r=0.1502 c=0
Rk40 (\8\:n35 \14\:n35) resistor r=0.5954 c=0
Rk57 (\15\:n35 \16\:n35) resistor r=0.4149 c=0
Rk70 (\18\:n35 \20\:n35) resistor r=0.6643 c=0
Rk71 (\20\:n35 \21\:n35) resistor r=0.1231 c=0
Rk72 (\6\:qint \7\:qint) resistor r=0.2558 c=0
Rk73 (\7\:qint \8\:qint) resistor r=0.1622 c=0
Rk74 (\7\:qint \10\:qint) resistor r=0.2863 c=0
Rk78 (\2\:n41 \4\:n41) resistor r=0.7195 c=0
Rk26 (\2\:net426 \4\:net426) resistor r=0.5568 c=0
Rk75 (\2\:n40 \4\:n40) resistor r=0.6308 c=0
Rk79 (\2\:n42 \4\:n42) resistor r=0.5345 c=0
Rl40 (\1\:ExtVDD \2\:ExtVDD) resistor r=149.73 c=0
Rl15 (\2\:CK \4\:CK) resistor r=193.945 c=0
Rl13 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl14 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\1\:RT \4\:RT) resistor r=752.514 c=0
Rl58 (\2\:RT \6\:RT) resistor r=35.9829 c=0
Rl55 (\2\:RT \3\:RT) resistor r=273.346 c=0
Rl57 (\2\:RT \5\:RT) resistor r=195.631 c=0
Rl54 (\1\:RT \2\:RT) resistor r=176.551 c=0
Rl76 (\9\:SN \10\:SN) resistor r=237.735 c=0
Rl77 (\10\:SN \11\:SN) resistor r=491.014 c=0
Rl59 (\7\:SN \8\:SN) resistor r=131.297 c=0
Rl12 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl41 (\3\:SN \4\:SN) resistor r=95.229 c=0
Rl43 (\4\:SN \6\:SN) resistor r=842.68 c=0
Rl42 (\4\:SN \5\:SN) resistor r=12.5751 c=0
Rl7 (\2\:D \4\:D) resistor r=161.253 c=0
Rl5 (\1\:D \2\:D) resistor r=95.868 c=0
Rl6 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=30.6172 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=279.747 c=0
Rl4 (n20 \2\:n20) resistor r=283.74 c=0
Rl10 (CKbb \2\:CKbb) resistor r=216.835 c=0
Rl61 (\10\:CKbb \11\:CKbb) resistor r=195.656 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=306.38 c=0
Rl49 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl52 (\5\:CKbb \8\:CKbb) resistor r=762.322 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=60.7265 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=81.3209 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl66 (\8\:RNb \9\:RNb) resistor r=234.8 c=0
Rl67 (\9\:RNb \10\:RNb) resistor r=259.682 c=0
Rl19 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl20 (\3\:RNb \4\:RNb) resistor r=180.578 c=0
Rl23 (\5\:RNb \7\:RNb) resistor r=63.8867 c=0
Rl21 (\4\:RNb \5\:RNb) resistor r=55.666 c=0
Rl22 (\5\:RNb \6\:RNb) resistor r=470.821 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=343.967 c=0
Rl38 (RTb \2\:RTb) resistor r=115.333 c=0
Rl62 (\12\:CKb \13\:CKb) resistor r=134.339 c=0
Rl24 (CKb \2\:CKb) resistor r=337.866 c=0
Rl30 (\2\:CKb \8\:CKb) resistor r=127.816 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=63.043 c=0
Rl31 (\3\:CKb \9\:CKb) resistor r=268.816 c=0
Rl25 (\2\:CKb \3\:CKb) resistor r=310.443 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=93.1104 c=0
Rl32 (\5\:CKb \10\:CKb) resistor r=1.2301 c=0
Rl33 (\6\:CKb \11\:CKb) resistor r=73.052 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=236.258 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=85.3931 c=0
Rl37 (\3\:n35g \5\:n35g) resistor r=332.357 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \4\:n35g) resistor r=92.0109 c=0
Rl68 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl73 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl75 (\13\:qbint \14\:qbint) resistor r=199.018 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl69 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl72 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl74 (\9\:qbint \13\:qbint) resistor r=89.4853 c=0
Rl71 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl70 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl60 (\3\:n35 \4\:n35) resistor r=238.77 c=0
Rl39 (n35 \2\:n35) resistor r=149.925 c=0
Rl63 (qint \2\:qint) resistor r=3.1216 c=0
Rl64 (\2\:qint \3\:qint) resistor r=66.0494 c=0
Rl65 (\2\:qint \4\:qint) resistor r=75.4463 c=0
Rz22 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz25 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz26 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz27 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz28 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz31 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz32 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz33 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz34 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz35 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz36 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz2 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz3 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz4 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\14\:RNb \15\:RNb) resistor r=75 c=0
Rz16 (\6\:RTb \7\:RTb) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz10 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (\11\:n35 \12\:n35) resistor r=75 c=0
Rz18 (\19\:n35 \20\:n35) resistor r=75 c=0
Rz19 (\5\:qint \6\:qint) resistor r=75 c=0
Rz6 (net426 \2\:net426) resistor r=75 c=0
Rz7 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz20 (n40 \2\:n40) resistor r=75 c=0
Rz21 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz23 (n42 \2\:n42) resistor r=75 c=0
Rz24 (\3\:n42 \4\:n42) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry11 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry12 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry28 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry29 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry30 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry31 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry35 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry36 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry24 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry25 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=8.8571 c=0
Ry39 (\19\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \27\:VSS) resistor r=15.5 c=0
Ry41 (\19\:VSS \29\:VSS) resistor r=31 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry3 (\18\:n20 \19\:n20) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\15\:mout \16\:mout) resistor r=31 c=0
Ry1 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry16 (\9\:RTb \10\:RTb) resistor r=62 c=0
Ry5 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry10 (\7\:n35g \8\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry8 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry9 (\13\:n35 \14\:n35) resistor r=62 c=0
Ry18 (\17\:n35 \18\:n35) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry21 (n41 \2\:n41) resistor r=62 c=0
Ry22 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx22 (\2\:ExtVDD \8\:ExtVDD) resistor r=15 c=0
Rx23 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx12 (\3\:CK \6\:CK) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx38 (\1\:RT \7\:RT) resistor r=45 c=0
Rx10 (\5\:SN \12\:SN) resistor r=45 c=0
Rx11 (\2\:SN \13\:SN) resistor r=45 c=0
Rx26 (\6\:SN \14\:SN) resistor r=45 c=0
Rx27 (\7\:SN \15\:SN) resistor r=45 c=0
Rx32 (\8\:SN \16\:SN) resistor r=45 c=0
Rx33 (\11\:SN \17\:SN) resistor r=45 c=0
Rx3 (\3\:D \6\:D) resistor r=45 c=0
Rx6 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx8 (n20 \17\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx15 (\7\:n20 \21\:n20) resistor r=45 c=0
Rx4 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx5 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (CKbb \17\:CKbb) resistor r=45 c=0
Rx34 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx18 (\4\:mout \10\:mout) resistor r=45 c=0
Rx19 (\2\:mout \17\:mout) resistor r=45 c=0
Rx2 (\6\:RNb \13\:RNb) resistor r=45 c=0
Rx16 (\4\:RNb \16\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \17\:RNb) resistor r=45 c=0
Rx41 (\10\:RNb \18\:RNb) resistor r=45 c=0
Rx42 (\3\:RNb \19\:RNb) resistor r=45 c=0
Rx30 (\2\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (\3\:RTb \8\:RTb) resistor r=45 c=0
Rx13 (\10\:CKb \14\:CKb) resistor r=45 c=0
Rx39 (CKb \20\:CKb) resistor r=45 c=0
Rx40 (\13\:CKb \21\:CKb) resistor r=45 c=0
Rx21 (\5\:n35g \6\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx20 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx28 (n35 \15\:n35) resistor r=45 c=0
Rx29 (\4\:n35 \16\:n35) resistor r=45 c=0
Rx43 (\3\:n35 \21\:n35) resistor r=45 c=0
Rx44 (qint \8\:qint) resistor r=45 c=0
mn22 (\14\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (n21 \1\:D \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \7\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \11\:CKb \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \3\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\18\:CKb \1\:CK \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\9\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g RTb \11\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \4\:n35g \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\6\:RTb \5\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.81e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \4\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\19\:n35 \12\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn51 (n40 \8\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \10\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (n22 \4\:D \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=8.07243 \
        scb=0.00427526 scc=2.63824e-05 m=(1)
mp26 (\18\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.39501 \
        scb=0.00357259 scc=2.44217e-05 m=(1)
mp36 (\8\:n20 \9\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=5.57121 \
        scb=0.00131629 scc=2.54339e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.3e-07 sd=160n sca=5.28562 \
        scb=0.00121296 scc=2.51356e-06 m=(1)
mp21 (\18\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.48645 \
        scb=0.00312433 scc=2.40957e-05 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=6.02e-14 ps=1.06e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=5.7e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\16\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.65589 \
        scb=0.00316356 scc=2.41007e-05 m=(1)
mp32 (\15\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.02e-14 ps=5.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp40 (\13\:n35 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\7\:n35g \3\:RT \5\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.1589 \
        scb=0.0273077 scc=0.0026732 m=(1)
PM1 (\17\:qbint \3\:n35g \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\9\:RTb \6\:RT \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.4484 \
        scb=0.0260103 scc=0.00229228 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\17\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5823 \
        scb=0.0110312 scc=0.000167593 m=(1)
mp51 (n43 \9\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.47524 \
        scb=0.00528697 scc=3.19779e-05 m=(1)
mp52 (n41 \11\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=10.003 \
        scb=0.00635741 scc=4.31501e-05 m=(1)
mp55 (\3\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.9109 \
        scb=0.0151829 scc=0.000449446 m=(1)
mp50 (n41 \9\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=15.4344 \
        scb=0.0162184 scc=0.000550454 m=(1)
ends RDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:53:08 2012 )
// Library name: gsclib045
// Cell name: RDFFSX1
// View name: extracted

simulator lang=spectre

subckt RDFFSX1 CK D ExtVDD Q QN RT SN VDD VSS
mp25 (n22 \3\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=4.65747e-17
C2 (QN VSS) capacitor c=1.96672e-17
C3 (VDD VSS) capacitor c=6.01519e-16
C4 (ExtVDD VSS) capacitor c=1.98008e-16
C5 (SN VSS) capacitor c=3.45894e-17
C6 (D VSS) capacitor c=4.59943e-17
C7 (RT VSS) capacitor c=4.03153e-17
C8 (CKbb VSS) capacitor c=5.61608e-17
C9 (mout VSS) capacitor c=5.78803e-17
C10 (n20 VSS) capacitor c=9.49518e-17
C11 (CKb VSS) capacitor c=2.30701e-17
C12 (n35g VSS) capacitor c=1.77631e-17
C13 (qbint VSS) capacitor c=4.57835e-17
C14 (RTb VSS) capacitor c=5.17974e-17
C15 (qint VSS) capacitor c=2.23822e-17
C16 (n35 VSS) capacitor c=1.71459e-16
C17 (n41 VSS) capacitor c=8.43054e-17
C18 (net095 VSS) capacitor c=3.64524e-17
C19 (\7\:qbint VSS) capacitor c=4.57272e-17
C20 (\7\:SN VSS) capacitor c=6.7652e-17
C21 (\11\:qbint VSS) capacitor c=7.51396e-17
C22 (\13\:qbint VSS) capacitor c=4.73126e-17
C23 (\3\:qint VSS) capacitor c=5.98274e-17
C24 (\10\:CKbb VSS) capacitor c=4.51951e-17
C25 (\4\:RTb VSS) capacitor c=9.93379e-17
C26 (\6\:RT VSS) capacitor c=2.22322e-17
C27 (\4\:qbint VSS) capacitor c=5.36719e-17
C28 (\3\:n35g VSS) capacitor c=5.78469e-17
C29 (\5\:RT VSS) capacitor c=6.34884e-17
C30 (\9\:CKb VSS) capacitor c=1.07528e-16
C31 (\3\:n20 VSS) capacitor c=3.33207e-17
C32 (\4\:CK VSS) capacitor c=5.08947e-17
C33 (\5\:CKb VSS) capacitor c=5.01249e-17
C34 (\1\:SN VSS) capacitor c=3.80174e-17
C35 (\7\:CKb VSS) capacitor c=7.5352e-17
C36 (\2\:CKbb VSS) capacitor c=1.69781e-16
C37 (\3\:D VSS) capacitor c=7.32178e-17
C38 (\6\:qbint VSS) capacitor c=3.73527e-17
C39 (\8\:SN VSS) capacitor c=1.32068e-16
C40 (\12\:qbint VSS) capacitor c=1.03084e-16
C41 (\14\:qbint VSS) capacitor c=4.409e-17
C42 (\4\:qint VSS) capacitor c=3.97103e-17
C43 (\11\:CKb VSS) capacitor c=2.23087e-16
C44 (\8\:RT VSS) capacitor c=1.21584e-16
C45 (\2\:RT VSS) capacitor c=6.21796e-17
C46 (\5\:qbint VSS) capacitor c=3.89434e-17
C47 (\5\:n35g VSS) capacitor c=2.77014e-17
C48 (\2\:RTb VSS) capacitor c=4.64723e-17
C49 (\4\:CKbb VSS) capacitor c=2.68763e-17
C50 (\1\:CK VSS) capacitor c=2.9896e-17
C51 (\6\:n20 VSS) capacitor c=6.25701e-17
C52 (\6\:SN VSS) capacitor c=6.49368e-17
C53 (\8\:CKb VSS) capacitor c=2.55841e-17
C54 (\3\:mout VSS) capacitor c=4.54723e-17
C55 (\9\:CKbb VSS) capacitor c=5.02123e-17
C56 (\4\:CKb VSS) capacitor c=8.54588e-17
C57 (\1\:D VSS) capacitor c=4.8936e-17
C58 (\10\:qbint VSS) capacitor c=8.46667e-17
C59 (\11\:CKbb VSS) capacitor c=5.21898e-17
C60 (\3\:SN VSS) capacitor c=2.91746e-16
C61 (\9\:SN VSS) capacitor c=8.5775e-17
C62 (\7\:RT VSS) capacitor c=1.44822e-16
C63 (\8\:CKbb VSS) capacitor c=1.77344e-16
C64 (\3\:RT VSS) capacitor c=3.93687e-17
C65 (\1\:RT VSS) capacitor c=5.27398e-17
C66 (\3\:RTb VSS) capacitor c=7.62516e-17
C67 (\3\:qbint VSS) capacitor c=4.43966e-17
C68 (\2\:n35 VSS) capacitor c=2.61705e-16
C69 (\4\:n35g VSS) capacitor c=4.92289e-17
C70 (\10\:CKb VSS) capacitor c=5.81809e-17
C71 (\12\:CKb VSS) capacitor c=2.18386e-16
C72 (\3\:n35 VSS) capacitor c=1.21659e-16
C73 (\4\:n20 VSS) capacitor c=1.00822e-16
C74 (\7\:n20 VSS) capacitor c=5.45979e-17
C75 (\3\:CK VSS) capacitor c=2.3752e-17
C76 (\2\:SN VSS) capacitor c=4.32409e-17
C77 (\5\:SN VSS) capacitor c=2.7214e-17
C78 (\2\:mout VSS) capacitor c=4.87271e-17
C79 (\4\:mout VSS) capacitor c=3.16028e-17
C80 (\5\:n20 VSS) capacitor c=8.48635e-17
C81 (\2\:n20 VSS) capacitor c=6.50432e-17
C82 (\2\:D VSS) capacitor c=5.3898e-17
C83 (\3\:CKbb VSS) capacitor c=7.92929e-17
C84 (\7\:CKbb VSS) capacitor c=3.11267e-17
C85 (\1\:VDD VSS) capacitor c=4.34306e-17
C86 (\7\:VDD VSS) capacitor c=2.91304e-17
C87 (\3\:Q VSS) capacitor c=8.19964e-17
C88 (\9\:VDD VSS) capacitor c=5.32936e-17
C89 (\9\:qint VSS) capacitor c=5.21032e-17
C90 (\16\:VDD VSS) capacitor c=8.00185e-17
C91 (\3\:n41 VSS) capacitor c=8.40625e-17
C92 (\4\:QN VSS) capacitor c=6.13352e-17
C93 (\14\:n35 VSS) capacitor c=5.51304e-17
C94 (\15\:n35g VSS) capacitor c=5.61339e-17
C95 (\6\:RTb VSS) capacitor c=7.28405e-17
C96 (\1\:ExtVDD VSS) capacitor c=2.76866e-16
C97 (\9\:n35 VSS) capacitor c=6.2545e-17
C98 (\17\:qbint VSS) capacitor c=6.63155e-17
C99 (\6\:n35g VSS) capacitor c=8.96816e-17
C100 (\4\:n35 VSS) capacitor c=4.98817e-17
C101 (\5\:mout VSS) capacitor c=7.97773e-17
C102 (\14\:VDD VSS) capacitor c=4.70573e-17
C103 (\17\:CKb VSS) capacitor c=2.944e-17
C104 (\19\:mout VSS) capacitor c=4.30544e-17
C105 (\22\:VDD VSS) capacitor c=6.18264e-17
C106 (\16\:mout VSS) capacitor c=4.68513e-17
C107 (\18\:CKbb VSS) capacitor c=4.0758e-17
C108 (\20\:VDD VSS) capacitor c=5.39817e-17
C109 (\16\:n20 VSS) capacitor c=5.46513e-17
C110 (\8\:n20 VSS) capacitor c=2.50886e-17
C111 (\25\:VDD VSS) capacitor c=3.3432e-17
C112 (\1\:Q VSS) capacitor c=5.48952e-17
C113 (\5\:qint VSS) capacitor c=5.02519e-17
C114 (\3\:net095 VSS) capacitor c=4.63057e-17
C115 (\1\:QN VSS) capacitor c=4.97003e-17
C116 (\17\:n35 VSS) capacitor c=4.64399e-17
C117 (\11\:n35g VSS) capacitor c=2.98389e-17
C118 (\10\:RTb VSS) capacitor c=5.8314e-17
C119 (\12\:n35 VSS) capacitor c=6.36732e-17
C120 (\19\:qbint VSS) capacitor c=2.27954e-17
C121 (\9\:n35g VSS) capacitor c=8.03039e-17
C122 (\7\:n35 VSS) capacitor c=4.06032e-17
C123 (\11\:VDD VSS) capacitor c=2.02231e-16
C124 (\11\:mout VSS) capacitor c=2.1882e-17
C125 (\13\:CKb VSS) capacitor c=4.66382e-17
C126 (\13\:mout VSS) capacitor c=1.72205e-17
C127 (\14\:CKbb VSS) capacitor c=5.06922e-17
C128 (\14\:n20 VSS) capacitor c=7.12151e-17
C129 (\12\:n20 VSS) capacitor c=5.94694e-17
C130 (VDD VSS) capacitor c=6.81515e-18
C131 (\2\:CK VSS) capacitor c=3.3905e-17
C132 (\2\:CKb VSS) capacitor c=2.78157e-17
C133 (\3\:CKb VSS) capacitor c=5.65252e-17
C134 (\6\:CKb VSS) capacitor c=1.28996e-16
C135 (\2\:n35g VSS) capacitor c=3.38232e-17
C136 (ExtVDD VSS) capacitor c=3.93674e-17
C137 (\4\:RT VSS) capacitor c=4.60848e-17
C138 (\2\:qbint VSS) capacitor c=4.12181e-17
C139 (\5\:CKbb VSS) capacitor c=1.15856e-16
C140 (\6\:CKbb VSS) capacitor c=8.13517e-17
C141 (\4\:SN VSS) capacitor c=3.13305e-16
C142 (\2\:qint VSS) capacitor c=1.74642e-17
C143 (\12\:CKbb VSS) capacitor c=5.3132e-17
C144 (\13\:CKbb VSS) capacitor c=6.96089e-17
C145 (\8\:qbint VSS) capacitor c=3.96385e-17
C146 (\9\:qbint VSS) capacitor c=6.40376e-17
C147 (\10\:n20 VSS) capacitor c=4.04322e-17
C148 (\11\:n20 VSS) capacitor c=6.26569e-17
C149 (\18\:n20 VSS) capacitor c=3.51348e-17
C150 (\17\:CKbb VSS) capacitor c=7.2514e-17
C151 (\10\:SN VSS) capacitor c=2.92929e-17
C152 (\11\:SN VSS) capacitor c=4.45444e-17
C153 (\5\:CK VSS) capacitor c=4.57027e-17
C154 (\6\:CK VSS) capacitor c=3.44482e-17
C155 (\15\:CKb VSS) capacitor c=4.82739e-17
C156 (\16\:CKb VSS) capacitor c=4.97003e-17
C157 (\19\:n20 VSS) capacitor c=5.19461e-17
C158 (\20\:n20 VSS) capacitor c=6.01353e-17
C159 (\7\:mout VSS) capacitor c=7.2852e-17
C160 (\8\:mout VSS) capacitor c=3.59356e-17
C161 (\9\:mout VSS) capacitor c=7.07298e-17
C162 (\10\:mout VSS) capacitor c=7.54819e-17
C163 (\15\:mout VSS) capacitor c=6.90564e-17
C164 (\18\:mout VSS) capacitor c=6.69458e-17
C165 (\6\:n35 VSS) capacitor c=6.55097e-17
C166 (\19\:CKb VSS) capacitor c=2.96864e-17
C167 (\20\:CKb VSS) capacitor c=3.2633e-17
C168 (\8\:n35g VSS) capacitor c=2.94004e-17
C169 (\11\:n35 VSS) capacitor c=7.53835e-17
C170 (\15\:qbint VSS) capacitor c=8.81276e-17
C171 (\16\:qbint VSS) capacitor c=1.09674e-16
C172 (\13\:n35g VSS) capacitor c=1.02088e-16
C173 (\14\:n35g VSS) capacitor c=1.16145e-16
C174 (\5\:RTb VSS) capacitor c=4.97134e-17
C175 (\8\:RTb VSS) capacitor c=9.95416e-17
C176 (\9\:RTb VSS) capacitor c=9.15552e-17
C177 (\12\:SN VSS) capacitor c=8.3139e-17
C178 (\13\:SN VSS) capacitor c=7.95586e-17
C179 (\20\:CKbb VSS) capacitor c=1.32993e-16
C180 (\21\:CKbb VSS) capacitor c=1.3649e-16
C181 (\21\:qbint VSS) capacitor c=2.38824e-17
C182 (\22\:qbint VSS) capacitor c=3.00681e-17
C183 (\9\:RT VSS) capacitor c=1.10054e-16
C184 (\10\:RT VSS) capacitor c=1.18375e-16
C185 (\11\:RT VSS) capacitor c=5.90308e-17
C186 (\3\:QN VSS) capacitor c=3.1398e-17
C187 (\16\:n35 VSS) capacitor c=4.37128e-17
C188 (\7\:qint VSS) capacitor c=4.81071e-17
C189 (\8\:qint VSS) capacitor c=3.73536e-17
C190 (\3\:VDD VSS) capacitor c=2.37673e-17
C191 (\4\:VDD VSS) capacitor c=2.95816e-17
C192 (\6\:VDD VSS) capacitor c=2.38089e-16
C193 (\13\:VDD VSS) capacitor c=1.71403e-17
C194 (\19\:VDD VSS) capacitor c=3.58549e-17
C195 (\24\:VDD VSS) capacitor c=3.48674e-17
Rk68 (\2\:Q Q) resistor r=0.1661 c=0
Rk69 (Q \4\:Q) resistor r=0.3331 c=0
Rk59 (\3\:QN QN) resistor r=0.04076 c=0
Rk58 (\2\:QN \3\:QN) resistor r=0.3192 c=0
Rk60 (\3\:QN \5\:QN) resistor r=0.231 c=0
Rk86 (\2\:VDD \3\:VDD) resistor r=0.3801 c=0
Rk87 (\3\:VDD \4\:VDD) resistor r=0.1956 c=0
Rk88 (\4\:VDD \6\:VDD) resistor r=0.1088 c=0
Rk89 (\3\:VDD \8\:VDD) resistor r=0.3184 c=0
Rk90 (\4\:VDD \10\:VDD) resistor r=0.301 c=0
Rk91 (\6\:VDD \12\:VDD) resistor r=1.6233 c=0
Rk92 (\12\:VDD \13\:VDD) resistor r=0.07661 c=0
Rk93 (\13\:VDD \15\:VDD) resistor r=0.2736 c=0
Rk94 (\6\:VDD \17\:VDD) resistor r=0.4059 c=0
Rk95 (\13\:VDD \18\:VDD) resistor r=0.1612 c=0
Rk99 (\19\:VDD VDD) resistor r=0.1011 c=0
Rk96 (\18\:VDD \19\:VDD) resistor r=0.176 c=0
Rk97 (\19\:VDD \21\:VDD) resistor r=0.275 c=0
Rk98 (\18\:VDD \23\:VDD) resistor r=0.4248 c=0
Rk100 (VDD \24\:VDD) resistor r=0.1462 c=0
Rk101 (\24\:VDD VDD) resistor r=0.08875 c=0
Rk102 (\24\:VDD \26\:VDD) resistor r=0.3582 c=0
Rk39 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk37 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk40 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk41 (ExtVDD \6\:ExtVDD) resistor r=0.1017 c=0
Rk11 (\10\:SN SN) resistor r=0.02815 c=0
Rk12 (SN \11\:SN) resistor r=0.04821 c=0
Rk52 (\12\:SN \13\:SN) resistor r=0.5353 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.361 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.2377 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.5548 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.1163 c=0
Rk75 (\8\:VSS VSS) resistor r=0.07141 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.2077 c=0
Rk77 (\9\:VSS VSS) resistor r=0.1187 c=0
Rk76 (VSS \9\:VSS) resistor r=0.7435 c=0
Rk78 (VSS \10\:VSS) resistor r=0.03722 c=0
Rk79 (\10\:VSS \11\:VSS) resistor r=0.4233 c=0
Rk80 (\11\:VSS \12\:VSS) resistor r=0.06422 c=0
Rk81 (\5\:VSS \14\:VSS) resistor r=0.2634 c=0
Rk82 (\7\:VSS \16\:VSS) resistor r=0.189 c=0
Rk83 (\8\:VSS \18\:VSS) resistor r=0.194 c=0
Rk84 (\10\:VSS \20\:VSS) resistor r=0.2362 c=0
Rk85 (\11\:VSS \22\:VSS) resistor r=0.228 c=0
Rk103 (\24\:VSS \26\:VSS) resistor r=0.6173 c=0
Rk104 (\26\:VSS \27\:VSS) resistor r=0.5651 c=0
Rk106 (\28\:VSS VSS) resistor r=0.0493 c=0
Rk105 (\27\:VSS \28\:VSS) resistor r=0.2773 c=0
Rk108 (\29\:VSS VSS) resistor r=0.1212 c=0
Rk107 (VSS \29\:VSS) resistor r=0.8426 c=0
Rk109 (VSS \31\:VSS) resistor r=0.3938 c=0
Rk110 (\27\:VSS \33\:VSS) resistor r=0.2432 c=0
Rk13 (CK \5\:CK) resistor r=0.004349 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01544 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.004531 c=0
Rk2 (\4\:D D) resistor r=0.006851 c=0
Rk55 (RT \9\:RT) resistor r=0.1921 c=0
Rk56 (\9\:RT \10\:RT) resistor r=0.6456 c=0
Rk57 (RT \11\:RT) resistor r=0.007548 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6152 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3458 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01512 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2066 c=0
Rk53 (\20\:CKbb \21\:CKbb) resistor r=0.8256 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.5286 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.296 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.3332 c=0
Rk24 (\7\:mout \12\:mout) resistor r=0.1277 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.09184 c=0
Rk26 (\9\:mout \15\:mout) resistor r=0.4802 c=0
Rk27 (\15\:mout \17\:mout) resistor r=0.04478 c=0
Rk28 (\10\:mout \18\:mout) resistor r=0.3474 c=0
Rk29 (\15\:mout \20\:mout) resistor r=0.0346 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.192 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2102 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.3758 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4882 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.144 c=0
Rk19 (\19\:n20 \20\:n20) resistor r=0.2684 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.336 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1631 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.2008 c=0
Rk32 (\19\:CKb \20\:CKb) resistor r=0.2995 c=0
Rk33 (\7\:n35g \8\:n35g) resistor r=0.2405 c=0
Rk34 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk45 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk46 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk47 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk42 (\15\:qbint \16\:qbint) resistor r=0.494 c=0
Rk43 (\16\:qbint \18\:qbint) resistor r=0.5666 c=0
Rk44 (\16\:qbint \20\:qbint) resistor r=0.1462 c=0
Rk54 (\21\:qbint \22\:qbint) resistor r=0.2116 c=0
Rk48 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk49 (\7\:RTb \8\:RTb) resistor r=0.4161 c=0
Rk50 (\8\:RTb \9\:RTb) resistor r=0.6878 c=0
Rk51 (\8\:RTb \11\:RTb) resistor r=0.3063 c=0
Rk63 (\6\:qint \7\:qint) resistor r=0.2809 c=0
Rk64 (\7\:qint \8\:qint) resistor r=0.1613 c=0
Rk65 (\7\:qint \10\:qint) resistor r=0.2563 c=0
Rk30 (\5\:n35 \6\:n35) resistor r=0.3334 c=0
Rk31 (\6\:n35 \8\:n35) resistor r=0.29 c=0
Rk35 (\10\:n35 \11\:n35) resistor r=0.4005 c=0
Rk36 (\11\:n35 \13\:n35) resistor r=0.3296 c=0
Rk61 (\15\:n35 \16\:n35) resistor r=0.3034 c=0
Rk62 (\16\:n35 \18\:n35) resistor r=0.2745 c=0
Rk67 (\2\:n41 \4\:n41) resistor r=0.6522 c=0
Rk66 (\2\:net095 \4\:net095) resistor r=0.2045 c=0
Rl54 (\7\:SN \8\:SN) resistor r=234.813 c=0
Rl55 (\8\:SN \9\:SN) resistor r=434.764 c=0
Rl8 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl46 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl44 (\3\:SN \4\:SN) resistor r=1126.2 c=0
Rl45 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl11 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl9 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl10 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl2 (\2\:D \3\:D) resistor r=108.118 c=0
Rl1 (\1\:D \2\:D) resistor r=70.6183 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl6 (CKbb \2\:CKbb) resistor r=169.108 c=0
Rl49 (\10\:CKbb \11\:CKbb) resistor r=166.412 c=0
Rl7 (\2\:CKbb \3\:CKbb) resistor r=446.586 c=0
Rl38 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl41 (\5\:CKbb \8\:CKbb) resistor r=794.708 c=0
Rl42 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl40 (\6\:CKbb \7\:CKbb) resistor r=129.238 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=430.133 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl14 (\6\:n20 \7\:n20) resistor r=105.531 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=236.609 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=196.122 c=0
Rl50 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl15 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl18 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl21 (\3\:CKb \8\:CKb) resistor r=69.2058 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=236.258 c=0
Rl16 (\2\:CKb \3\:CKb) resistor r=75.7777 c=0
Rl22 (\6\:CKb \9\:CKb) resistor r=422.225 c=0
Rl19 (\5\:CKb \6\:CKb) resistor r=292.264 c=0
Rl20 (\6\:CKb \7\:CKb) resistor r=113.702 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl56 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl61 (\11\:qbint \12\:qbint) resistor r=252.671 c=0
Rl63 (\13\:qbint \14\:qbint) resistor r=199.892 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl57 (\7\:qbint \8\:qbint) resistor r=135.6 c=0
Rl60 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl62 (\9\:qbint \13\:qbint) resistor r=90.3157 c=0
Rl59 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl58 (\8\:qbint \9\:qbint) resistor r=68.3971 c=0
Rl28 (RTb \2\:RTb) resistor r=112.412 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl51 (qint \2\:qint) resistor r=3.1216 c=0
Rl52 (\2\:qint \3\:qint) resistor r=56.4891 c=0
Rl53 (\2\:qint \4\:qint) resistor r=85.455 c=0
Rl47 (n35 \2\:n35) resistor r=508.667 c=0
Rl48 (\2\:n35 \3\:n35) resistor r=367.189 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz14 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz27 (\11\:VDD \12\:VDD) resistor r=25 c=0
Rz28 (\11\:VDD \18\:VDD) resistor r=15 c=0
Rz20 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz21 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz29 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz8 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz12 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz11 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz13 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz16 (\5\:qint \6\:qint) resistor r=75 c=0
Rz7 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz9 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (net095 \2\:net095) resistor r=75 c=0
Rz18 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry22 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry28 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry29 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry30 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry31 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=5.6364 c=0
Ry25 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry26 (\3\:VSS \12\:VSS) resistor r=62 c=0
Ry35 (\25\:VSS \26\:VSS) resistor r=5.6364 c=0
Ry36 (\25\:VSS \28\:VSS) resistor r=10.3333 c=0
Ry37 (\25\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\16\:mout \17\:mout) resistor r=62 c=0
Ry7 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\5\:SN \10\:SN) resistor r=45 c=0
Rx9 (\2\:SN \11\:SN) resistor r=45 c=0
Rx25 (\3\:SN \12\:SN) resistor r=45 c=0
Rx26 (\9\:SN \13\:SN) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx31 (\3\:RT \9\:RT) resistor r=45 c=0
Rx32 (\1\:RT \10\:RT) resistor r=45 c=0
Rx33 (\7\:RT \11\:RT) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx27 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx28 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \20\:n20) resistor r=45 c=0
Rx11 (CKb \16\:CKb) resistor r=45 c=0
Rx17 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx18 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx19 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx22 (n35g \14\:n35g) resistor r=45 c=0
Rx21 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx29 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx30 (qbint \22\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (RTb \9\:RTb) resistor r=45 c=0
Rx35 (qint \8\:qint) resistor r=45 c=0
Rx16 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx20 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx34 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net426 \6\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn52 (net095 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n42 \8\:SN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\16\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.20139 \
        scb=0.00436827 scc=2.20651e-05 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.36777 \
        scb=0.00335337 scc=1.75985e-05 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=6.506 scb=0.00275822 \
        scc=1.68594e-05 m=(1)
mp21 (\18\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\19\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.97126 \
        scb=0.00301321 scc=1.70301e-05 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5253 \
        scb=0.0111823 scc=0.000178214 m=(1)
mp52 (n41 \11\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n41 \7\:SN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends RDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:53:58 2012 )
// Library name: gsclib045
// Cell name: RDFFX1
// View name: extracted

simulator lang=spectre

subckt RDFFX1 CK D ExtVDD Q QN RT VDD VSS
mp25 (n22 \4\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.9347 \
        scb=0.0157363 scc=0.000368461 m=(1)
C1 (Q VSS) capacitor c=4.96911e-17
C2 (ExtVDD VSS) capacitor c=1.25718e-16
C3 (RT VSS) capacitor c=3.12155e-17
C4 (D VSS) capacitor c=2.91654e-17
C5 (QN VSS) capacitor c=3.03652e-17
C6 (VDD VSS) capacitor c=4.84701e-16
C7 (CKbb VSS) capacitor c=5.07473e-17
C8 (n20 VSS) capacitor c=4.5364e-17
C9 (mout VSS) capacitor c=5.65999e-17
C10 (n35 VSS) capacitor c=1.4616e-16
C11 (CKb VSS) capacitor c=3.42309e-16
C12 (n35g VSS) capacitor c=1.77389e-17
C13 (qbint VSS) capacitor c=4.82587e-17
C14 (RTb VSS) capacitor c=3.93753e-17
C15 (qint VSS) capacitor c=2.24871e-17
C16 (\7\:qbint VSS) capacitor c=4.98703e-17
C17 (\11\:qbint VSS) capacitor c=4.52676e-17
C18 (\13\:qbint VSS) capacitor c=1.41168e-16
C19 (\3\:qint VSS) capacitor c=5.93993e-17
C20 (\10\:CKbb VSS) capacitor c=8.72864e-17
C21 (\4\:RTb VSS) capacitor c=9.84044e-17
C22 (\8\:RT VSS) capacitor c=2.17453e-17
C23 (\4\:qbint VSS) capacitor c=6.83431e-17
C24 (\3\:n35g VSS) capacitor c=4.82887e-17
C25 (\6\:RT VSS) capacitor c=7.62267e-17
C26 (\7\:CKb VSS) capacitor c=2.84412e-17
C27 (\4\:CK VSS) capacitor c=3.38256e-17
C28 (\3\:n20 VSS) capacitor c=5.75688e-17
C29 (\3\:CKb VSS) capacitor c=5.98797e-17
C30 (\10\:CKb VSS) capacitor c=9.54034e-17
C31 (\2\:CKbb VSS) capacitor c=1.22497e-16
C32 (\4\:D VSS) capacitor c=6.42091e-17
C33 (\6\:qbint VSS) capacitor c=3.82813e-17
C34 (\12\:qbint VSS) capacitor c=4.59284e-17
C35 (\14\:qbint VSS) capacitor c=9.13732e-17
C36 (\4\:qint VSS) capacitor c=3.78602e-17
C37 (\7\:RT VSS) capacitor c=1.66265e-16
C38 (\1\:RT VSS) capacitor c=4.42713e-17
C39 (\5\:qbint VSS) capacitor c=3.90657e-17
C40 (\5\:n35g VSS) capacitor c=2.84697e-17
C41 (\8\:CKbb VSS) capacitor c=2.92085e-17
C42 (\1\:CK VSS) capacitor c=3.80188e-17
C43 (\6\:n20 VSS) capacitor c=5.10978e-17
C44 (\8\:CKb VSS) capacitor c=2.41108e-17
C45 (\3\:mout VSS) capacitor c=4.90535e-17
C46 (\9\:CKbb VSS) capacitor c=5.01972e-17
C47 (\5\:CKb VSS) capacitor c=8.54646e-17
C48 (\1\:D VSS) capacitor c=5.16777e-17
C49 (\11\:CKbb VSS) capacitor c=5.64291e-17
C50 (\4\:CKbb VSS) capacitor c=1.27447e-16
C51 (\10\:qbint VSS) capacitor c=5.79977e-17
C52 (\3\:RT VSS) capacitor c=1.67472e-16
C53 (\3\:RTb VSS) capacitor c=7.34091e-17
C54 (\4\:RT VSS) capacitor c=4.32411e-17
C55 (\2\:RT VSS) capacitor c=3.89058e-17
C56 (\3\:qbint VSS) capacitor c=3.52588e-17
C57 (\2\:RTb VSS) capacitor c=4.00519e-17
C58 (\2\:n35 VSS) capacitor c=1.65829e-16
C59 (\4\:n35g VSS) capacitor c=6.81327e-17
C60 (\3\:n35 VSS) capacitor c=4.35542e-17
C61 (\3\:CK VSS) capacitor c=2.6485e-17
C62 (\9\:CKb VSS) capacitor c=8.7458e-17
C63 (\2\:mout VSS) capacitor c=3.86154e-17
C64 (\4\:mout VSS) capacitor c=4.0206e-17
C65 (\5\:n20 VSS) capacitor c=4.33766e-17
C66 (\2\:n20 VSS) capacitor c=4.08892e-17
C67 (\3\:CKbb VSS) capacitor c=6.09962e-17
C68 (\7\:CKbb VSS) capacitor c=3.01016e-17
C69 (\3\:D VSS) capacitor c=1.34087e-17
C70 (\1\:VDD VSS) capacitor c=4.83252e-17
C71 (\3\:Q VSS) capacitor c=8.43461e-17
C72 (\9\:qint VSS) capacitor c=5.46365e-17
C73 (\11\:VDD VSS) capacitor c=2.50873e-17
C74 (\13\:VDD VSS) capacitor c=7.93185e-17
C75 (\4\:QN VSS) capacitor c=5.47187e-17
C76 (\15\:n35 VSS) capacitor c=4.34926e-17
C77 (\15\:n35g VSS) capacitor c=4.65303e-17
C78 (\6\:RTb VSS) capacitor c=5.77496e-17
C79 (\1\:ExtVDD VSS) capacitor c=2.902e-16
C80 (\10\:n35 VSS) capacitor c=5.11249e-17
C81 (\17\:qbint VSS) capacitor c=6.81348e-17
C82 (\6\:n35g VSS) capacitor c=8.75619e-17
C83 (\4\:n35 VSS) capacitor c=4.00017e-17
C84 (\13\:CKb VSS) capacitor c=6.0322e-17
C85 (\5\:mout VSS) capacitor c=5.94436e-17
C86 (\15\:VDD VSS) capacitor c=7.07754e-17
C87 (\17\:VDD VSS) capacitor c=5.98691e-17
C88 (\18\:CKbb VSS) capacitor c=4.70578e-17
C89 (\13\:n20 VSS) capacitor c=4.6032e-17
C90 (\9\:n20 VSS) capacitor c=8.87024e-17
C91 (\20\:VDD VSS) capacitor c=3.50156e-17
C92 (\3\:VDD VSS) capacitor c=2.53057e-16
C93 (\1\:Q VSS) capacitor c=5.493e-17
C94 (\5\:qint VSS) capacitor c=4.69544e-17
C95 (\1\:QN VSS) capacitor c=4.71067e-17
C96 (\18\:n35 VSS) capacitor c=6.04504e-17
C97 (\11\:n35g VSS) capacitor c=2.94918e-17
C98 (\10\:RTb VSS) capacitor c=5.97655e-17
C99 (\13\:n35 VSS) capacitor c=5.58349e-17
C100 (\19\:qbint VSS) capacitor c=2.37261e-17
C101 (\9\:n35g VSS) capacitor c=7.65622e-17
C102 (\7\:n35 VSS) capacitor c=4.4942e-17
C103 (\15\:CKb VSS) capacitor c=3.64522e-17
C104 (\10\:mout VSS) capacitor c=5.24732e-17
C105 (\14\:CKbb VSS) capacitor c=4.85295e-17
C106 (\16\:n20 VSS) capacitor c=4.3754e-17
C107 (\7\:n20 VSS) capacitor c=7.43575e-17
C108 (\2\:D VSS) capacitor c=4.34399e-17
C109 (\4\:n20 VSS) capacitor c=4.72351e-17
C110 (\2\:CK VSS) capacitor c=3.29059e-17
C111 (\2\:n35g VSS) capacitor c=3.01491e-17
C112 (ExtVDD VSS) capacitor c=3.95231e-17
C113 (\2\:qbint VSS) capacitor c=4.00745e-17
C114 (\5\:RT VSS) capacitor c=5.09193e-17
C115 (\5\:CKbb VSS) capacitor c=1.09059e-16
C116 (\6\:CKbb VSS) capacitor c=4.17719e-17
C117 (\2\:CKb VSS) capacitor c=2.5808e-16
C118 (\6\:CKb VSS) capacitor c=4.07593e-17
C119 (\2\:qint VSS) capacitor c=1.77293e-17
C120 (\8\:qbint VSS) capacitor c=5.52645e-17
C121 (\9\:qbint VSS) capacitor c=1.32569e-16
C122 (\12\:CKbb VSS) capacitor c=9.75358e-17
C123 (\13\:CKbb VSS) capacitor c=8.61806e-17
C124 (\6\:D VSS) capacitor c=2.54436e-17
C125 (\11\:n20 VSS) capacitor c=3.77514e-17
C126 (\12\:n20 VSS) capacitor c=5.21768e-17
C127 (\15\:n20 VSS) capacitor c=5.25701e-17
C128 (\17\:CKbb VSS) capacitor c=7.85137e-17
C129 (\7\:mout VSS) capacitor c=4.29254e-17
C130 (\8\:mout VSS) capacitor c=2.73299e-17
C131 (\9\:mout VSS) capacitor c=2.48939e-17
C132 (\12\:mout VSS) capacitor c=2.48691e-17
C133 (\5\:CK VSS) capacitor c=3.73727e-17
C134 (\7\:CK VSS) capacitor c=3.74671e-18
C135 (\8\:CK VSS) capacitor c=4.30026e-17
C136 (\11\:CKb VSS) capacitor c=5.13192e-17
C137 (\12\:CKb VSS) capacitor c=4.42148e-17
C138 (\6\:n35 VSS) capacitor c=6.84178e-17
C139 (\9\:n35 VSS) capacitor c=6.21697e-17
C140 (\8\:n35g VSS) capacitor c=3.19866e-17
C141 (\12\:n35 VSS) capacitor c=6.04519e-17
C142 (\15\:qbint VSS) capacitor c=8.88704e-17
C143 (\16\:qbint VSS) capacitor c=1.10799e-16
C144 (\13\:n35g VSS) capacitor c=1.13129e-16
C145 (\14\:n35g VSS) capacitor c=1.16555e-16
C146 (\9\:RT VSS) capacitor c=6.28792e-17
C147 (\10\:RT VSS) capacitor c=6.14517e-17
C148 (\5\:RTb VSS) capacitor c=3.67772e-17
C149 (\8\:RTb VSS) capacitor c=1.11714e-16
C150 (\9\:RTb VSS) capacitor c=6.96605e-17
C151 (\11\:RT VSS) capacitor c=4.13191e-17
C152 (\21\:qbint VSS) capacitor c=2.90362e-17
C153 (\22\:qbint VSS) capacitor c=3.10729e-17
C154 (\20\:CKbb VSS) capacitor c=1.30164e-16
C155 (\21\:CKbb VSS) capacitor c=9.80016e-17
C156 (\3\:QN VSS) capacitor c=3.33376e-17
C157 (\17\:n35 VSS) capacitor c=6.15631e-17
C158 (\7\:qint VSS) capacitor c=5.19529e-17
C159 (\8\:qint VSS) capacitor c=3.63154e-17
C160 (\5\:VDD VSS) capacitor c=1.5381e-17
C161 (\6\:VDD VSS) capacitor c=9.63787e-18
C162 (\8\:VDD VSS) capacitor c=1.87126e-16
C163 (\10\:VDD VSS) capacitor c=2.9491e-17
C164 (\19\:VDD VSS) capacitor c=3.81401e-17
Rk61 (\2\:Q Q) resistor r=0.1682 c=0
Rk62 (Q \4\:Q) resistor r=0.3377 c=0
Rk35 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk33 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk36 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk37 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk38 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02871 c=0
Rk45 (\9\:RT \10\:RT) resistor r=0.4442 c=0
Rk50 (RT \11\:RT) resistor r=0.01696 c=0
Rk2 (\5\:D \6\:D) resistor r=0.009156 c=0
Rk3 (\7\:D D) resistor r=0.009156 c=0
Rk4 (\6\:D \7\:D) resistor r=0.01888 c=0
Rk54 (\3\:QN QN) resistor r=0.0431 c=0
Rk53 (\2\:QN \3\:QN) resistor r=0.3177 c=0
Rk55 (\3\:QN \5\:QN) resistor r=0.2274 c=0
Rk80 (\2\:VDD \4\:VDD) resistor r=0.4883 c=0
Rk81 (\4\:VDD \5\:VDD) resistor r=0.1507 c=0
Rk82 (\5\:VDD \6\:VDD) resistor r=0.05156 c=0
Rk83 (\6\:VDD \7\:VDD) resistor r=0.03444 c=0
Rk84 (\7\:VDD \8\:VDD) resistor r=1.5581 c=0
Rk90 (\10\:VDD VDD) resistor r=0.1806 c=0
Rk85 (\8\:VDD \10\:VDD) resistor r=0.05483 c=0
Rk86 (\5\:VDD \12\:VDD) resistor r=0.2895 c=0
Rk87 (\6\:VDD \14\:VDD) resistor r=0.3633 c=0
Rk88 (\8\:VDD \16\:VDD) resistor r=0.3788 c=0
Rk89 (\10\:VDD \18\:VDD) resistor r=0.3557 c=0
Rk91 (VDD \19\:VDD) resistor r=0.1509 c=0
Rk92 (\19\:VDD VDD) resistor r=0.08366 c=0
Rk93 (\19\:VDD \21\:VDD) resistor r=0.3577 c=0
Rk18 (\5\:CK \6\:CK) resistor r=0.005021 c=0
Rk19 (CK \7\:CK) resistor r=0.00251 c=0
Rk20 (\5\:CK \7\:CK) resistor r=0.01225 c=0
Rk21 (CK \8\:CK) resistor r=0.005021 c=0
Rk22 (\7\:CK \8\:CK) resistor r=0.01004 c=0
Rk63 (\2\:VSS \4\:VSS) resistor r=0.3605 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.2348 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.2101 c=0
Rk67 (\7\:VSS VSS) resistor r=0.1331 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.4599 c=0
Rk68 (VSS \8\:VSS) resistor r=0.07426 c=0
Rk69 (\8\:VSS \9\:VSS) resistor r=0.1235 c=0
Rk71 (\10\:VSS VSS) resistor r=0.02182 c=0
Rk70 (\9\:VSS \10\:VSS) resistor r=0.591 c=0
Rk72 (VSS \11\:VSS) resistor r=0.1783 c=0
Rk73 (\11\:VSS \12\:VSS) resistor r=0.1853 c=0
Rk74 (\12\:VSS \13\:VSS) resistor r=0.06165 c=0
Rk75 (\5\:VSS \15\:VSS) resistor r=0.2663 c=0
Rk76 (\7\:VSS \17\:VSS) resistor r=0.1887 c=0
Rk77 (\8\:VSS \19\:VSS) resistor r=0.1938 c=0
Rk78 (\10\:VSS \21\:VSS) resistor r=0.2399 c=0
Rk79 (\12\:VSS \23\:VSS) resistor r=0.2277 c=0
Rk94 (\25\:VSS \27\:VSS) resistor r=0.3504 c=0
Rk95 (\27\:VSS \28\:VSS) resistor r=0.5613 c=0
Rk97 (\29\:VSS VSS) resistor r=0.04922 c=0
Rk96 (\28\:VSS \29\:VSS) resistor r=0.1309 c=0
Rk99 (\30\:VSS VSS) resistor r=0.1185 c=0
Rk98 (VSS \30\:VSS) resistor r=0.6928 c=0
Rk100 (VSS \32\:VSS) resistor r=0.3451 c=0
Rk101 (\28\:VSS \34\:VSS) resistor r=0.3469 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.8336 c=0
Rk10 (\15\:CKbb \16\:CKbb) resistor r=0.3218 c=0
Rk11 (\16\:CKbb \17\:CKbb) resistor r=0.02343 c=0
Rk12 (\16\:CKbb \19\:CKbb) resistor r=0.2142 c=0
Rk52 (\20\:CKbb \21\:CKbb) resistor r=0.8679 c=0
Rk5 (\8\:n20 \10\:n20) resistor r=0.4919 c=0
Rk6 (\10\:n20 \11\:n20) resistor r=0.3007 c=0
Rk7 (\12\:n20 \14\:n20) resistor r=0.2757 c=0
Rk8 (\14\:n20 \15\:n20) resistor r=0.2392 c=0
Rk9 (\12\:n20 \17\:n20) resistor r=0.2333 c=0
Rk13 (\6\:mout \7\:mout) resistor r=0.3049 c=0
Rk14 (\7\:mout \8\:mout) resistor r=0.1492 c=0
Rk15 (\8\:mout \9\:mout) resistor r=0.1241 c=0
Rk16 (\7\:mout \11\:mout) resistor r=0.2733 c=0
Rk17 (\8\:mout \12\:mout) resistor r=0.1307 c=0
Rk26 (\5\:n35 \6\:n35) resistor r=0.2864 c=0
Rk27 (\6\:n35 \8\:n35) resistor r=0.272 c=0
Rk28 (\6\:n35 \9\:n35) resistor r=0.567 c=0
Rk31 (\11\:n35 \12\:n35) resistor r=0.2719 c=0
Rk32 (\12\:n35 \14\:n35) resistor r=0.3269 c=0
Rk56 (\16\:n35 \17\:n35) resistor r=0.17 c=0
Rk57 (\17\:n35 \19\:n35) resistor r=0.4264 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2067 c=0
Rk24 (\12\:CKb \14\:CKb) resistor r=0.3154 c=0
Rk25 (\12\:CKb \16\:CKb) resistor r=0.1956 c=0
Rk29 (\7\:n35g \8\:n35g) resistor r=0.2289 c=0
Rk30 (\7\:n35g \10\:n35g) resistor r=0.6049 c=0
Rk42 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk43 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk44 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk39 (\15\:qbint \16\:qbint) resistor r=0.4933 c=0
Rk40 (\16\:qbint \18\:qbint) resistor r=0.5658 c=0
Rk41 (\16\:qbint \20\:qbint) resistor r=0.1459 c=0
Rk51 (\21\:qbint \22\:qbint) resistor r=0.2113 c=0
Rk46 (\5\:RTb \7\:RTb) resistor r=0.226 c=0
Rk47 (\7\:RTb \8\:RTb) resistor r=0.2727 c=0
Rk48 (\8\:RTb \9\:RTb) resistor r=0.669 c=0
Rk49 (\8\:RTb \11\:RTb) resistor r=0.3325 c=0
Rk58 (\6\:qint \7\:qint) resistor r=0.2591 c=0
Rk59 (\7\:qint \8\:qint) resistor r=0.1618 c=0
Rk60 (\7\:qint \10\:qint) resistor r=0.2767 c=0
Rl29 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl26 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl20 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl30 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl28 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl27 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl3 (\2\:D \4\:D) resistor r=111.253 c=0
Rl1 (\1\:D \2\:D) resistor r=99.7141 c=0
Rl2 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl12 (\1\:CK \2\:CK) resistor r=140.099 c=0
Rl13 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl5 (CKbb \2\:CKbb) resistor r=151.246 c=0
Rl38 (\10\:CKbb \11\:CKbb) resistor r=115.79 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=246.721 c=0
Rl34 (\5\:CKbb \8\:CKbb) resistor r=64.1356 c=0
Rl31 (\4\:CKbb \5\:CKbb) resistor r=862.964 c=0
Rl35 (\6\:CKbb \9\:CKbb) resistor r=64.1356 c=0
Rl33 (\6\:CKbb \7\:CKbb) resistor r=113.909 c=0
Rl32 (\5\:CKbb \6\:CKbb) resistor r=172.374 c=0
Rl4 (n20 \2\:n20) resistor r=112.885 c=0
Rl9 (\3\:n20 \4\:n20) resistor r=103.572 c=0
Rl11 (\4\:n20 \6\:n20) resistor r=96.5354 c=0
Rl10 (\4\:n20 \5\:n20) resistor r=121.254 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl36 (n35 \2\:n35) resistor r=499.328 c=0
Rl37 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl39 (CKb \2\:CKb) resistor r=1441.22 c=0
Rl40 (\2\:CKb \3\:CKb) resistor r=213.178 c=0
Rl41 (\3\:CKb \4\:CKb) resistor r=134.462 c=0
Rl45 (\4\:CKb \8\:CKb) resistor r=72.9234 c=0
Rl42 (\4\:CKb \5\:CKb) resistor r=222.576 c=0
Rl46 (\4\:CKb \9\:CKb) resistor r=3.6978 c=0
Rl44 (\6\:CKb \7\:CKb) resistor r=66.684 c=0
Rl47 (\6\:CKb \10\:CKb) resistor r=229.379 c=0
Rl43 (\2\:CKb \6\:CKb) resistor r=112.483 c=0
Rl17 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl15 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl16 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl18 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl51 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl56 (\11\:qbint \12\:qbint) resistor r=195.609 c=0
Rl58 (\13\:qbint \14\:qbint) resistor r=235.906 c=0
Rl25 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl22 (qbint \2\:qbint) resistor r=112.732 c=0
Rl24 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl23 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl52 (\7\:qbint \8\:qbint) resistor r=203.519 c=0
Rl55 (\8\:qbint \11\:qbint) resistor r=92.0202 c=0
Rl57 (\9\:qbint \13\:qbint) resistor r=355.65 c=0
Rl54 (\9\:qbint \10\:qbint) resistor r=244.214 c=0
Rl53 (\8\:qbint \9\:qbint) resistor r=221.574 c=0
Rl21 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl19 (RTb \2\:RTb) resistor r=124.312 c=0
Rl48 (qint \2\:qint) resistor r=3.1216 c=0
Rl49 (\2\:qint \3\:qint) resistor r=64.1263 c=0
Rl50 (\2\:qint \4\:qint) resistor r=73.7417 c=0
Rz16 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz13 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz23 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz24 (\3\:VDD \7\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz26 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz27 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz28 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz6 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz8 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz14 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz7 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz11 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz10 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz12 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz15 (\5\:qint \6\:qint) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry9 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry10 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry27 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry28 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry29 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry22 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry23 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \11\:VSS) resistor r=15.5 c=0
Ry25 (\3\:VSS \13\:VSS) resistor r=62 c=0
Ry32 (\26\:VSS \27\:VSS) resistor r=5.6364 c=0
Ry33 (\26\:VSS \29\:VSS) resistor r=20.6667 c=0
Ry34 (\26\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry8 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry18 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry5 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry7 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Rx17 (\4\:RT \9\:RT) resistor r=45 c=0
Rx18 (\2\:RT \10\:RT) resistor r=45 c=0
Rx21 (\3\:RT \11\:RT) resistor r=45 c=0
Rx3 (\3\:D \5\:D) resistor r=45 c=0
Rx10 (\3\:CK \6\:CK) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx24 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx25 (\4\:CKbb \21\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \11\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \12\:n20) resistor r=45 c=0
Rx6 (n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:mout \9\:mout) resistor r=45 c=0
Rx9 (\2\:mout \12\:mout) resistor r=45 c=0
Rx12 (\3\:n35 \9\:n35) resistor r=45 c=0
Rx14 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx26 (n35 \17\:n35) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx13 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx16 (n35g \14\:n35g) resistor r=45 c=0
Rx15 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx22 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx23 (qbint \22\:qbint) resistor r=45 c=0
Rx19 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx20 (\2\:RTb \9\:RTb) resistor r=45 c=0
Rx27 (qint \8\:qint) resistor r=45 c=0
mn25 (n21 \1\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\7\:n20 \5\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n30 \3\:mout \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\14\:CKbb \8\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\10\:mout \6\:n20 \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\15\:CKb \1\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \8\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM1 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \1\:RT \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 CKb net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 scb=0.0162972 \
        scc=0.00139495 m=(1)
mn52 (net095 \14\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:qint \12\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\9\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3839 \
        scb=0.011256 scc=0.000224024 m=(1)
mp36 (\13\:n20 \10\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=8.43833 \
        scb=0.00456328 scc=4.14083e-05 m=(1)
mp35 (n31 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=8.66197 \
        scb=0.00491317 scc=4.24157e-05 m=(1)
mp21 (\18\:CKbb \3\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.3786 \
        scb=0.00949038 scc=0.000203066 m=(1)
mp32 (\5\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=10.9141 \
        scb=0.00882323 scc=9.56076e-05 m=(1)
mp20 (\13\:CKb \4\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.4857 \
        scb=0.0166783 scc=0.00041931 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=22.4791 \
        scb=0.0247612 scc=0.0018296 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
mp45 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \10\:CKbb net084 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.893 \
        scb=0.031948 scc=0.00297886 m=(1)
mp52 (net084 \13\:qbint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=15.0501 \
        scb=0.0157632 scc=0.000508204 m=(1)
mp56 (\9\:qint \11\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.6819 \
        scb=0.0114274 scc=0.000189805 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2615 \
        scb=0.0122477 scc=0.000351335 m=(1)
ends RDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:54:47 2012 )
// Library name: gsclib045
// Cell name: RTLATRX1
// View name: extracted

simulator lang=spectre

subckt RTLATRX1 D ExtVDD G Q QN RN RT VDD VSS
mp2 (\8\:Gbb \4\:Gb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (D VSS) capacitor c=5.29575e-17
C2 (QN VSS) capacitor c=3.84791e-17
C3 (RT VSS) capacitor c=2.55171e-17
C4 (Q VSS) capacitor c=2.73236e-17
C5 (ExtVDD VSS) capacitor c=2.80598e-16
C6 (VDD VSS) capacitor c=3.96254e-16
C7 (RN VSS) capacitor c=3.96667e-17
C8 (G VSS) capacitor c=5.55172e-17
C9 (Gb VSS) capacitor c=7.99722e-17
C10 (Gbb VSS) capacitor c=1.281e-16
C11 (n5 VSS) capacitor c=6.89593e-17
C12 (Qbint VSS) capacitor c=3.01658e-17
C13 (Qint VSS) capacitor c=9.93019e-17
C14 (n5g VSS) capacitor c=4.74304e-17
C15 (RTb VSS) capacitor c=5.20732e-17
C16 (net103 VSS) capacitor c=9.00674e-17
C17 (net171 VSS) capacitor c=3.84734e-17
C18 (\1\:RN VSS) capacitor c=6.53712e-17
C19 (\4\:Qbint VSS) capacitor c=3.65829e-17
C20 (\2\:Qint VSS) capacitor c=9.20791e-17
C21 (\3\:Qint VSS) capacitor c=6.40417e-17
C22 (\4\:Gbb VSS) capacitor c=4.03499e-17
C23 (\10\:Qint VSS) capacitor c=2.34343e-17
C24 (\3\:RTb VSS) capacitor c=9.00987e-17
C25 (\12\:Qint VSS) capacitor c=6.62604e-17
C26 (\5\:RT VSS) capacitor c=5.32068e-17
C27 (\4\:n5g VSS) capacitor c=8.98249e-17
C28 (\7\:RT VSS) capacitor c=3.38591e-17
C29 (\1\:G VSS) capacitor c=4.19344e-17
C30 (\3\:D VSS) capacitor c=7.25947e-17
C31 (\5\:RN VSS) capacitor c=5.18488e-17
C32 (\4\:Gb VSS) capacitor c=5.74345e-17
C33 (\2\:RN VSS) capacitor c=2.56308e-16
C34 (\9\:Qint VSS) capacitor c=2.61589e-17
C35 (\8\:Gb VSS) capacitor c=7.29602e-17
C36 (\11\:Qint VSS) capacitor c=2.49084e-17
C37 (\13\:Qint VSS) capacitor c=5.74219e-17
C38 (\9\:RT VSS) capacitor c=9.24642e-17
C39 (\1\:RT VSS) capacitor c=5.93096e-17
C40 (\3\:n5g VSS) capacitor c=2.34422e-17
C41 (\2\:RTb VSS) capacitor c=5.48848e-17
C42 (\3\:Gbb VSS) capacitor c=4.2823e-17
C43 (\1\:D VSS) capacitor c=7.05368e-17
C44 (\3\:G VSS) capacitor c=7.80587e-17
C45 (\3\:RN VSS) capacitor c=2.16895e-16
C46 (\5\:Gb VSS) capacitor c=6.09497e-17
C47 (\3\:Qbint VSS) capacitor c=2.74714e-17
C48 (\5\:Gbb VSS) capacitor c=3.2757e-17
C49 (\9\:Gb VSS) capacitor c=6.51927e-17
C50 (\8\:RT VSS) capacitor c=6.08119e-17
C51 (\4\:RTb VSS) capacitor c=6.84677e-17
C52 (\5\:RTb VSS) capacitor c=4.82564e-17
C53 (\6\:RT VSS) capacitor c=5.62697e-17
C54 (\3\:n5 VSS) capacitor c=7.61574e-17
C55 (\2\:ExtVDD VSS) capacitor c=5.35292e-17
C56 (\1\:ExtVDD VSS) capacitor c=4.86404e-17
C57 (\5\:n5g VSS) capacitor c=1.01925e-16
C58 (\6\:Gb VSS) capacitor c=1.43017e-16
C59 (\8\:Qint VSS) capacitor c=7.74338e-17
C60 (\4\:n5 VSS) capacitor c=8.06615e-17
C61 (\4\:RT VSS) capacitor c=3.68672e-17
C62 (\2\:n5 VSS) capacitor c=6.31645e-17
C63 (\7\:Gb VSS) capacitor c=7.1473e-17
C64 (\2\:Gbb VSS) capacitor c=1.0203e-16
C65 (\2\:D VSS) capacitor c=5.66229e-17
C66 (\2\:G VSS) capacitor c=6.75501e-17
C67 (\4\:RN VSS) capacitor c=7.68224e-17
C68 (\3\:Gb VSS) capacitor c=3.68271e-17
C69 (\1\:VDD VSS) capacitor c=3.0581e-17
C70 (\3\:Q VSS) capacitor c=6.55238e-17
C71 (\12\:VDD VSS) capacitor c=7.41353e-17
C72 (\14\:VDD VSS) capacitor c=5.31909e-17
C73 (\7\:Qbint VSS) capacitor c=8.17484e-17
C74 (\16\:VDD VSS) capacitor c=8.7373e-17
C75 (\3\:net103 VSS) capacitor c=8.36451e-17
C76 (\21\:n5 VSS) capacitor c=3.68614e-17
C77 (\1\:QN VSS) capacitor c=6.49109e-17
C78 (\11\:n5g VSS) capacitor c=1.18767e-16
C79 (\6\:ExtVDD VSS) capacitor c=5.9034e-17
C80 (\7\:RTb VSS) capacitor c=4.6913e-17
C81 (\3\:ExtVDD VSS) capacitor c=4.33359e-17
C82 (\10\:ExtVDD VSS) capacitor c=6.26925e-17
C83 (\17\:Qint VSS) capacitor c=4.69338e-17
C84 (\7\:n5g VSS) capacitor c=7.97367e-17
C85 (\11\:n5 VSS) capacitor c=8.81159e-17
C86 (\7\:n5 VSS) capacitor c=2.59726e-17
C87 (\18\:Gb VSS) capacitor c=4.52077e-17
C88 (\18\:VDD VSS) capacitor c=6.67623e-17
C89 (\20\:VDD VSS) capacitor c=5.36997e-17
C90 (\13\:Gb VSS) capacitor c=4.71806e-17
C91 (\8\:Gbb VSS) capacitor c=5.2868e-17
C92 (\1\:Q VSS) capacitor c=4.435e-17
C93 (\9\:Qbint VSS) capacitor c=5.57442e-17
C94 (\3\:net171 VSS) capacitor c=4.44412e-17
C95 (\17\:n5 VSS) capacitor c=3.6584e-17
C96 (\3\:QN VSS) capacitor c=4.6588e-17
C97 (\12\:RTb VSS) capacitor c=2.5119e-17
C98 (\15\:n5g VSS) capacitor c=1.89334e-17
C99 (\14\:Qint VSS) capacitor c=3.89791e-17
C100 (\9\:n5g VSS) capacitor c=9.10257e-17
C101 (\15\:n5 VSS) capacitor c=4.11655e-17
C102 (\9\:n5 VSS) capacitor c=6.85463e-17
C103 (\8\:VDD VSS) capacitor c=2.81074e-16
C104 (\16\:Gb VSS) capacitor c=3.7525e-17
C105 (\10\:Gbb VSS) capacitor c=2.54426e-17
C106 (VDD VSS) capacitor c=1.54265e-17
C107 (\2\:Gb VSS) capacitor c=4.8761e-17
C108 (ExtVDD VSS) capacitor c=4.58411e-17
C109 (\2\:n5g VSS) capacitor c=4.73624e-17
C110 (\2\:RT VSS) capacitor c=8.36574e-17
C111 (\3\:RT VSS) capacitor c=7.45754e-17
C112 (\4\:Qint VSS) capacitor c=2.50393e-17
C113 (\5\:Qint VSS) capacitor c=4.58572e-17
C114 (\6\:Qint VSS) capacitor c=6.35249e-17
C115 (\7\:Qint VSS) capacitor c=4.02186e-17
C116 (\2\:Qbint VSS) capacitor c=2.01749e-17
C117 (\6\:Gbb VSS) capacitor c=5.6443e-17
C118 (\7\:Gbb VSS) capacitor c=5.65131e-17
C119 (\10\:Gb VSS) capacitor c=7.75756e-18
C120 (\11\:Gb VSS) capacitor c=4.30943e-17
C121 (\12\:Gb VSS) capacitor c=6.71059e-17
C122 (\15\:Gb VSS) capacitor c=4.96407e-17
C123 (\5\:n5 VSS) capacitor c=1.84247e-17
C124 (\6\:n5 VSS) capacitor c=5.34492e-17
C125 (\12\:RT VSS) capacitor c=2.30256e-17
C126 (\13\:n5 VSS) capacitor c=5.96576e-17
C127 (\14\:n5 VSS) capacitor c=4.91355e-17
C128 (\16\:Qint VSS) capacitor c=6.03261e-17
C129 (\6\:n5g VSS) capacitor c=2.49801e-17
C130 (\5\:ExtVDD VSS) capacitor c=5.58415e-17
C131 (\12\:ExtVDD VSS) capacitor c=3.17137e-17
C132 (\6\:RTb VSS) capacitor c=2.79626e-17
C133 (\9\:RTb VSS) capacitor c=3.78922e-17
C134 (\10\:RTb VSS) capacitor c=5.89529e-17
C135 (\11\:RTb VSS) capacitor c=6.2111e-17
C136 (\13\:n5g VSS) capacitor c=9.79609e-17
C137 (\14\:n5g VSS) capacitor c=2.88664e-17
C138 (\13\:RT VSS) capacitor c=1.29483e-16
C139 (\14\:RT VSS) capacitor c=1.31812e-16
C140 (\20\:Gb VSS) capacitor c=1.38534e-16
C141 (\21\:Gb VSS) capacitor c=1.58298e-16
C142 (\12\:Gbb VSS) capacitor c=1.89977e-16
C143 (\13\:Gbb VSS) capacitor c=2.42047e-16
C144 (\19\:n5 VSS) capacitor c=1.07836e-16
C145 (\20\:n5 VSS) capacitor c=1.81088e-16
C146 (\5\:Qbint VSS) capacitor c=2.79747e-17
C147 (\3\:VDD VSS) capacitor c=3.17796e-17
C148 (\4\:VDD VSS) capacitor c=2.0481e-17
C149 (\6\:VDD VSS) capacitor c=1.19444e-17
C150 (\7\:VDD VSS) capacitor c=2.94468e-16
Rk2 (D \4\:D) resistor r=0.003156 c=0
Rk44 (QN \4\:QN) resistor r=0.0916 c=0
Rk43 (\2\:QN \4\:QN) resistor r=0.5731 c=0
Rk19 (RT \12\:RT) resistor r=0.02095 c=0
Rk18 (\11\:RT \12\:RT) resistor r=0.004258 c=0
Rk40 (\13\:RT \14\:RT) resistor r=1.0387 c=0
Rk53 (Q \2\:Q) resistor r=0.1292 c=0
Rk54 (Q \4\:Q) resistor r=0.2929 c=0
Rk30 (ExtVDD ExtVDD) resistor r=0.003782 c=0
Rk27 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2263 c=0
Rk28 (\7\:ExtVDD ExtVDD) resistor r=0.1403 c=0
Rk31 (ExtVDD \11\:ExtVDD) resistor r=0.1482 c=0
Rk32 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.2302 c=0
Rk63 (VDD VDD) resistor r=0.131 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.3854 c=0
Rk56 (\3\:VDD \4\:VDD) resistor r=0.09847 c=0
Rk57 (\4\:VDD \6\:VDD) resistor r=0.09125 c=0
Rk58 (\6\:VDD \7\:VDD) resistor r=0.03935 c=0
Rk59 (\7\:VDD \9\:VDD) resistor r=1.7784 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.05322 c=0
Rk62 (\11\:VDD VDD) resistor r=0.04671 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.03169 c=0
Rk64 (\3\:VDD \13\:VDD) resistor r=0.3553 c=0
Rk65 (\4\:VDD \15\:VDD) resistor r=0.2806 c=0
Rk66 (\7\:VDD \17\:VDD) resistor r=0.3729 c=0
Rk67 (\10\:VDD \19\:VDD) resistor r=0.2851 c=0
Rk68 (\11\:VDD \21\:VDD) resistor r=0.3284 c=0
Rk69 (\2\:VSS \4\:VSS) resistor r=0.2896 c=0
Rk71 (\5\:VSS VSS) resistor r=0.5439 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.6426 c=0
Rk73 (\6\:VSS VSS) resistor r=0.1851 c=0
Rk72 (VSS \6\:VSS) resistor r=0.643 c=0
Rk74 (VSS \8\:VSS) resistor r=0.5483 c=0
Rk75 (VSS \10\:VSS) resistor r=0.3042 c=0
Rk76 (\12\:VSS \13\:VSS) resistor r=0.08137 c=0
Rk77 (\13\:VSS \14\:VSS) resistor r=0.116 c=0
Rk78 (\14\:VSS \15\:VSS) resistor r=0.1135 c=0
Rk79 (\15\:VSS \16\:VSS) resistor r=0.331 c=0
Rk81 (\17\:VSS VSS) resistor r=0.2096 c=0
Rk80 (\16\:VSS \17\:VSS) resistor r=0.284 c=0
Rk82 (VSS \18\:VSS) resistor r=0.2719 c=0
Rk84 (\19\:VSS VSS) resistor r=0.5786 c=0
Rk83 (\18\:VSS \19\:VSS) resistor r=0.1728 c=0
Rk85 (VSS \20\:VSS) resistor r=0.114 c=0
Rk86 (\13\:VSS \22\:VSS) resistor r=0.2467 c=0
Rk87 (\15\:VSS \24\:VSS) resistor r=0.2584 c=0
Rk88 (\17\:VSS \26\:VSS) resistor r=0.2763 c=0
Rk89 (\18\:VSS \28\:VSS) resistor r=0.2423 c=0
Rk90 (VSS \30\:VSS) resistor r=0.3039 c=0
Rk3 (G \4\:G) resistor r=0.01004 c=0
Rk7 (\10\:Gb \11\:Gb) resistor r=0.04289 c=0
Rk8 (\11\:Gb \12\:Gb) resistor r=0.2419 c=0
Rk9 (\12\:Gb \14\:Gb) resistor r=0.4577 c=0
Rk10 (\14\:Gb \15\:Gb) resistor r=0.2367 c=0
Rk11 (\11\:Gb \17\:Gb) resistor r=0.3133 c=0
Rk12 (\12\:Gb \19\:Gb) resistor r=0.1902 c=0
Rk41 (\20\:Gb \21\:Gb) resistor r=0.8009 c=0
Rk4 (\6\:Gbb \7\:Gbb) resistor r=0.286 c=0
Rk5 (\7\:Gbb \9\:Gbb) resistor r=0.4403 c=0
Rk6 (\7\:Gbb \11\:Gbb) resistor r=0.1686 c=0
Rk42 (\12\:Gbb \13\:Gbb) resistor r=1.6105 c=0
Rk13 (\5\:n5 \6\:n5) resistor r=0.2054 c=0
Rk14 (\6\:n5 \8\:n5) resistor r=0.1993 c=0
Rk15 (\6\:n5 \10\:n5) resistor r=0.4682 c=0
Rk20 (\12\:n5 \13\:n5) resistor r=0.5935 c=0
Rk21 (\12\:n5 \14\:n5) resistor r=0.2472 c=0
Rk22 (\14\:n5 \16\:n5) resistor r=0.3212 c=0
Rk45 (\18\:n5 \19\:n5) resistor r=0.3432 c=0
Rk46 (\19\:n5 \20\:n5) resistor r=1.0792 c=0
Rk47 (\19\:n5 \22\:n5) resistor r=0.2537 c=0
Rk48 (\5\:Qbint \6\:Qbint) resistor r=0.0234 c=0
Rk49 (\6\:Qbint \8\:Qbint) resistor r=0.3093 c=0
Rk50 (\6\:Qbint \10\:Qbint) resistor r=0.2054 c=0
Rk23 (\15\:Qint \16\:Qint) resistor r=0.2107 c=0
Rk24 (\16\:Qint \18\:Qint) resistor r=0.4302 c=0
Rk25 (\6\:n5g \8\:n5g) resistor r=0.1082 c=0
Rk26 (\8\:n5g \10\:n5g) resistor r=0.5652 c=0
Rk37 (\12\:n5g \13\:n5g) resistor r=0.7341 c=0
Rk38 (\13\:n5g \14\:n5g) resistor r=0.1077 c=0
Rk39 (\13\:n5g \16\:n5g) resistor r=0.08846 c=0
Rk33 (\6\:RTb \8\:RTb) resistor r=0.1321 c=0
Rk34 (\9\:RTb \10\:RTb) resistor r=0.1671 c=0
Rk35 (\10\:RTb \11\:RTb) resistor r=0.3282 c=0
Rk36 (\10\:RTb \13\:RTb) resistor r=0.09342 c=0
Rk52 (\2\:net103 \4\:net103) resistor r=0.6377 c=0
Rk51 (\2\:net171 \4\:net171) resistor r=0.3526 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl28 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl24 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl23 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl20 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl25 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl22 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl21 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl46 (\1\:RN \2\:RN) resistor r=215.452 c=0
Rl47 (\2\:RN \3\:RN) resistor r=1636.76 c=0
Rl49 (\4\:RN \5\:RN) resistor r=164.425 c=0
Rl48 (\3\:RN \4\:RN) resistor r=46.604 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl8 (\4\:Gb \5\:Gb) resistor r=249.542 c=0
Rl30 (\8\:Gb \9\:Gb) resistor r=361.066 c=0
Rl12 (\6\:Gb \7\:Gb) resistor r=452.417 c=0
Rl5 (Gb \2\:Gb) resistor r=168.204 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=143.548 c=0
Rl29 (\4\:Gbb \5\:Gbb) resistor r=178.565 c=0
Rl10 (Gbb \2\:Gbb) resistor r=696.861 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl19 (\3\:n5 \4\:n5) resistor r=172.871 c=0
Rl9 (n5 \2\:n5) resistor r=331.394 c=0
Rl43 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl45 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl44 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl31 (Qint \2\:Qint) resistor r=232.216 c=0
Rl32 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl33 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl38 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl39 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl40 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl34 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl41 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl35 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl42 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl37 (\7\:Qint \8\:Qint) resistor r=192.03 c=0
Rl36 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl18 (\4\:n5g \5\:n5g) resistor r=317.727 c=0
Rl15 (n5g \2\:n5g) resistor r=109.66 c=0
Rl17 (\2\:n5g \4\:n5g) resistor r=191.281 c=0
Rl16 (\2\:n5g \3\:n5g) resistor r=38.4366 c=0
Rl13 (RTb \2\:RTb) resistor r=124.916 c=0
Rl26 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl27 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\8\:VDD \9\:VDD) resistor r=37.5 c=0
Rz18 (\8\:VDD \11\:VDD) resistor r=75 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz21 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \22\:VSS) resistor r=37.5 c=0
Rz23 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz24 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz25 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz2 (\16\:Gb \17\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz3 (\9\:n5 \10\:n5) resistor r=75 c=0
Rz4 (\15\:n5 \16\:n5) resistor r=75 c=0
Rz11 (\17\:n5 \18\:n5) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz5 (\14\:Qint \15\:Qint) resistor r=75 c=0
Rz6 (\9\:n5g \10\:n5g) resistor r=75 c=0
Rz9 (\15\:n5g \16\:n5g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz13 (net171 \2\:net171) resistor r=75 c=0
Rz14 (\3\:net171 \4\:net171) resistor r=75 c=0
Ry13 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry18 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry8 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry9 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry10 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry21 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry26 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry28 (\11\:VSS \12\:VSS) resistor r=31 c=0
Ry29 (\11\:VSS \14\:VSS) resistor r=31 c=0
Ry30 (\11\:VSS \16\:VSS) resistor r=8.8571 c=0
Ry31 (\11\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry32 (\11\:VSS \20\:VSS) resistor r=31 c=0
Ry2 (\13\:Gb \14\:Gb) resistor r=62 c=0
Ry3 (\18\:Gb \19\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry4 (\7\:n5 \8\:n5) resistor r=62 c=0
Ry5 (\11\:n5 \12\:n5) resistor r=62 c=0
Ry14 (\21\:n5 \22\:n5) resistor r=62 c=0
Ry15 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry6 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry7 (\7\:n5g \8\:n5g) resistor r=62 c=0
Ry12 (\11\:n5g \12\:n5g) resistor r=62 c=0
Ry11 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry16 (net103 \2\:net103) resistor r=62 c=0
Ry17 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx8 (\4\:RT \11\:RT) resistor r=45 c=0
Rx19 (\8\:RT \13\:RT) resistor r=45 c=0
Rx20 (\6\:RT \14\:RT) resistor r=45 c=0
Rx13 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx14 (\1\:ExtVDD \12\:ExtVDD) resistor r=45 c=0
Rx1 (\4\:RN RN) resistor r=45 c=0
Rx3 (\2\:G \4\:G) resistor r=45 c=0
Rx5 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx6 (\3\:Gb \15\:Gb) resistor r=45 c=0
Rx21 (\9\:Gb \20\:Gb) resistor r=45 c=0
Rx22 (\6\:Gb \21\:Gb) resistor r=45 c=0
Rx4 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx23 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx24 (Gbb \13\:Gbb) resistor r=45 c=0
Rx7 (n5 \5\:n5) resistor r=45 c=0
Rx9 (\2\:n5 \13\:n5) resistor r=45 c=0
Rx10 (\4\:n5 \14\:n5) resistor r=45 c=0
Rx25 (\3\:n5 \20\:n5) resistor r=45 c=0
Rx26 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx11 (\8\:Qint \16\:Qint) resistor r=45 c=0
Rx12 (\5\:n5g \6\:n5g) resistor r=45 c=0
Rx18 (n5g \14\:n5g) resistor r=45 c=0
Rx15 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx16 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx17 (RTb \11\:RTb) resistor r=45 c=0
mn2 (\10\:Gbb \5\:Gb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (net159 \3\:RN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\16\:Gb \3\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net191 \1\:D \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\9\:n5 \3\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n5g \2\:RTb \15\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\14\:Qint \3\:n5g \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n5g \9\:RT net094 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net094 \13\:Qint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn17 (\17\:n5 \8\:Gb \3\:net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\9\:Qbint \9\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (net171 Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\1\:Q Qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mn15 (net167 \2\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp0 (\13\:Gb \5\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.9195 \
        scb=0.0189757 scc=0.000406591 m=(1)
mp5 (net142 \3\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp1 (\18\:Gb \1\:G \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\7\:n5 Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n5g \7\:RT \11\:n5 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp11 (\17\:Qint \4\:n5g \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1365 \
        scb=0.0108856 scc=0.000154611 m=(1)
mp45 (\7\:RTb \5\:RT \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net94 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n5g \3\:RTb net94 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp17 (\21\:n5 \4\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.7175 \
        scb=0.0182062 scc=0.00060472 m=(1)
mp20 (\7\:Qbint \3\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net103 \2\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\3\:Q \4\:Qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
mp15 (net103 \1\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.1035 \
        scb=0.0249499 scc=0.00160735 m=(1)
ends RTLATRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:55:36 2012 )
// Library name: gsclib045
// Cell name: RTLATSRX1
// View name: extracted

simulator lang=spectre

subckt RTLATSRX1 D ExtVDD G Q QN RN RT SN VDD VSS
mp2 (\8\:Gbb \4\:Gb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (D VSS) capacitor c=6.06336e-17
C2 (RT VSS) capacitor c=2.75905e-17
C3 (ExtVDD VSS) capacitor c=2.91122e-16
C4 (QN VSS) capacitor c=3.834e-17
C5 (RN VSS) capacitor c=4.46512e-17
C6 (Q VSS) capacitor c=2.24983e-17
C7 (G VSS) capacitor c=6.90666e-17
C8 (VDD VSS) capacitor c=3.90897e-16
C9 (Gb VSS) capacitor c=8.17772e-17
C10 (Gbb VSS) capacitor c=1.29013e-16
C11 (n5 VSS) capacitor c=6.946e-17
C12 (Qbint VSS) capacitor c=2.99278e-17
C13 (Qint VSS) capacitor c=9.93019e-17
C14 (n5g VSS) capacitor c=4.78625e-17
C15 (RTb VSS) capacitor c=5.20732e-17
C16 (net103 VSS) capacitor c=9.00674e-17
C17 (net171 VSS) capacitor c=3.84734e-17
C18 (\1\:RN VSS) capacitor c=6.53712e-17
C19 (\4\:Qbint VSS) capacitor c=3.62557e-17
C20 (\2\:Qint VSS) capacitor c=9.20791e-17
C21 (\3\:Qint VSS) capacitor c=6.39908e-17
C22 (\4\:Gbb VSS) capacitor c=4.03495e-17
C23 (\10\:Qint VSS) capacitor c=2.34012e-17
C24 (\3\:RTb VSS) capacitor c=8.97947e-17
C25 (\12\:Qint VSS) capacitor c=6.57794e-17
C26 (\5\:RT VSS) capacitor c=5.32068e-17
C27 (\4\:n5g VSS) capacitor c=1.0874e-16
C28 (\4\:SN VSS) capacitor c=5.52974e-17
C29 (\7\:RT VSS) capacitor c=3.19382e-17
C30 (\1\:G VSS) capacitor c=4.17482e-17
C31 (\3\:D VSS) capacitor c=7.27055e-17
C32 (\6\:RN VSS) capacitor c=5.21474e-17
C33 (\4\:Gb VSS) capacitor c=5.75313e-17
C34 (\2\:RN VSS) capacitor c=2.56308e-16
C35 (\9\:Qint VSS) capacitor c=2.60833e-17
C36 (\8\:Gb VSS) capacitor c=7.29602e-17
C37 (\11\:Qint VSS) capacitor c=2.49079e-17
C38 (\13\:Qint VSS) capacitor c=5.71866e-17
C39 (\9\:RT VSS) capacitor c=9.38305e-17
C40 (\1\:RT VSS) capacitor c=5.93098e-17
C41 (\3\:n5g VSS) capacitor c=3.95098e-17
C42 (\1\:SN VSS) capacitor c=3.91996e-17
C43 (\2\:RTb VSS) capacitor c=5.45794e-17
C44 (\3\:Gbb VSS) capacitor c=3.99005e-17
C45 (\1\:D VSS) capacitor c=7.06097e-17
C46 (\3\:G VSS) capacitor c=7.77994e-17
C47 (\3\:RN VSS) capacitor c=2.14606e-16
C48 (\5\:Gb VSS) capacitor c=6.09852e-17
C49 (\3\:Qbint VSS) capacitor c=2.74714e-17
C50 (\5\:Gbb VSS) capacitor c=3.27568e-17
C51 (\9\:Gb VSS) capacitor c=6.51927e-17
C52 (\8\:RT VSS) capacitor c=6.07721e-17
C53 (\4\:RTb VSS) capacitor c=6.84677e-17
C54 (\5\:RTb VSS) capacitor c=4.82564e-17
C55 (\6\:RT VSS) capacitor c=5.61807e-17
C56 (\3\:n5 VSS) capacitor c=7.61574e-17
C57 (\2\:ExtVDD VSS) capacitor c=5.33843e-17
C58 (\1\:ExtVDD VSS) capacitor c=4.85138e-17
C59 (\5\:n5g VSS) capacitor c=1.02118e-16
C60 (\8\:Qint VSS) capacitor c=7.43543e-17
C61 (\6\:Gb VSS) capacitor c=1.38815e-16
C62 (\3\:SN VSS) capacitor c=6.30637e-17
C63 (\4\:n5 VSS) capacitor c=8.0763e-17
C64 (\4\:RT VSS) capacitor c=3.68861e-17
C65 (\2\:n5 VSS) capacitor c=6.35584e-17
C66 (\7\:Gb VSS) capacitor c=7.2093e-17
C67 (\2\:Gbb VSS) capacitor c=1.05925e-16
C68 (\2\:D VSS) capacitor c=5.66906e-17
C69 (\2\:G VSS) capacitor c=6.71337e-17
C70 (\5\:RN VSS) capacitor c=7.68894e-17
C71 (\3\:Gb VSS) capacitor c=3.68271e-17
C72 (\1\:VDD VSS) capacitor c=3.0581e-17
C73 (\2\:Q VSS) capacitor c=4.84547e-17
C74 (\12\:VDD VSS) capacitor c=7.41353e-17
C75 (\14\:VDD VSS) capacitor c=5.31909e-17
C76 (\7\:Qbint VSS) capacitor c=8.17189e-17
C77 (\16\:VDD VSS) capacitor c=8.7373e-17
C78 (\3\:net103 VSS) capacitor c=8.36451e-17
C79 (\21\:n5 VSS) capacitor c=3.68614e-17
C80 (\1\:QN VSS) capacitor c=6.49088e-17
C81 (\11\:n5g VSS) capacitor c=1.1939e-16
C82 (\6\:ExtVDD VSS) capacitor c=6.44446e-17
C83 (\7\:RTb VSS) capacitor c=4.6913e-17
C84 (\3\:ExtVDD VSS) capacitor c=4.33237e-17
C85 (\10\:ExtVDD VSS) capacitor c=7.57832e-17
C86 (\18\:Qint VSS) capacitor c=8.03274e-17
C87 (\7\:n5g VSS) capacitor c=7.97367e-17
C88 (\13\:ExtVDD VSS) capacitor c=5.46988e-17
C89 (\11\:n5 VSS) capacitor c=8.80991e-17
C90 (\7\:n5 VSS) capacitor c=2.66033e-17
C91 (\18\:Gb VSS) capacitor c=3.8191e-17
C92 (\18\:VDD VSS) capacitor c=6.71755e-17
C93 (\20\:VDD VSS) capacitor c=5.41404e-17
C94 (\13\:Gb VSS) capacitor c=4.4018e-17
C95 (\8\:Gbb VSS) capacitor c=5.2868e-17
C96 (\4\:Q VSS) capacitor c=3.48755e-17
C97 (\9\:Qbint VSS) capacitor c=5.57262e-17
C98 (\3\:net171 VSS) capacitor c=4.44412e-17
C99 (\17\:n5 VSS) capacitor c=3.6584e-17
C100 (\3\:QN VSS) capacitor c=4.6734e-17
C101 (\12\:RTb VSS) capacitor c=2.5119e-17
C102 (\15\:n5g VSS) capacitor c=1.98547e-17
C103 (\16\:Qint VSS) capacitor c=3.79946e-17
C104 (\9\:n5g VSS) capacitor c=9.10183e-17
C105 (\15\:n5 VSS) capacitor c=4.10533e-17
C106 (\9\:n5 VSS) capacitor c=6.75234e-17
C107 (\8\:VDD VSS) capacitor c=2.93324e-16
C108 (\16\:Gb VSS) capacitor c=4.13463e-17
C109 (\10\:Gbb VSS) capacitor c=2.54426e-17
C110 (VDD VSS) capacitor c=1.54265e-17
C111 (\2\:Gb VSS) capacitor c=4.87889e-17
C112 (ExtVDD VSS) capacitor c=3.82923e-17
C113 (\2\:n5g VSS) capacitor c=7.11964e-17
C114 (\2\:RT VSS) capacitor c=8.36392e-17
C115 (\3\:RT VSS) capacitor c=7.46195e-17
C116 (\4\:Qint VSS) capacitor c=2.48672e-17
C117 (\5\:Qint VSS) capacitor c=4.5845e-17
C118 (\6\:Qint VSS) capacitor c=6.35672e-17
C119 (\7\:Qint VSS) capacitor c=3.999e-17
C120 (\2\:Qbint VSS) capacitor c=1.95501e-17
C121 (\6\:Gbb VSS) capacitor c=5.63382e-17
C122 (\7\:Gbb VSS) capacitor c=5.84832e-17
C123 (\10\:Gb VSS) capacitor c=9.6479e-18
C124 (\11\:Gb VSS) capacitor c=5.03085e-17
C125 (\12\:Gb VSS) capacitor c=7.28718e-17
C126 (\15\:Gb VSS) capacitor c=4.96406e-17
C127 (\5\:n5 VSS) capacitor c=1.9319e-17
C128 (\6\:n5 VSS) capacitor c=5.39319e-17
C129 (\13\:RT VSS) capacitor c=2.35311e-17
C130 (\13\:n5 VSS) capacitor c=6.07697e-17
C131 (\14\:n5 VSS) capacitor c=4.98936e-17
C132 (\5\:SN VSS) capacitor c=1.70746e-17
C133 (\6\:SN VSS) capacitor c=1.33468e-17
C134 (\7\:SN VSS) capacitor c=3.40392e-17
C135 (\14\:Qint VSS) capacitor c=2.1198e-17
C136 (\15\:Qint VSS) capacitor c=5.52527e-17
C137 (\6\:n5g VSS) capacitor c=2.49801e-17
C138 (\5\:ExtVDD VSS) capacitor c=5.58395e-17
C139 (\12\:ExtVDD VSS) capacitor c=4.53017e-17
C140 (\15\:ExtVDD VSS) capacitor c=1.69896e-17
C141 (\6\:RTb VSS) capacitor c=2.79626e-17
C142 (\9\:RTb VSS) capacitor c=3.78922e-17
C143 (\10\:RTb VSS) capacitor c=5.89529e-17
C144 (\11\:RTb VSS) capacitor c=6.2111e-17
C145 (\13\:n5g VSS) capacitor c=9.80116e-17
C146 (\14\:n5g VSS) capacitor c=2.74754e-17
C147 (\14\:RT VSS) capacitor c=1.29474e-16
C148 (\15\:RT VSS) capacitor c=1.3129e-16
C149 (\20\:Gb VSS) capacitor c=1.38534e-16
C150 (\21\:Gb VSS) capacitor c=1.58298e-16
C151 (\12\:Gbb VSS) capacitor c=1.89977e-16
C152 (\13\:Gbb VSS) capacitor c=2.41215e-16
C153 (\19\:n5 VSS) capacitor c=1.07836e-16
C154 (\20\:n5 VSS) capacitor c=1.81088e-16
C155 (\5\:Qbint VSS) capacitor c=2.8e-17
C156 (\1\:Q VSS) capacitor c=2.52192e-17
C157 (\3\:VDD VSS) capacitor c=3.20792e-17
C158 (\4\:VDD VSS) capacitor c=2.0481e-17
C159 (\6\:VDD VSS) capacitor c=1.19444e-17
C160 (\7\:VDD VSS) capacitor c=2.94475e-16
Rk3 (\4\:D D) resistor r=0.003195 c=0
Rk79 (\2\:VSS \4\:VSS) resistor r=0.2898 c=0
Rk81 (\5\:VSS VSS) resistor r=0.5443 c=0
Rk80 (\4\:VSS \5\:VSS) resistor r=0.6431 c=0
Rk83 (\6\:VSS VSS) resistor r=0.1853 c=0
Rk82 (VSS \6\:VSS) resistor r=0.6436 c=0
Rk84 (VSS \8\:VSS) resistor r=0.5487 c=0
Rk85 (VSS \10\:VSS) resistor r=0.3045 c=0
Rk86 (\12\:VSS \13\:VSS) resistor r=0.08143 c=0
Rk87 (\13\:VSS \14\:VSS) resistor r=0.1161 c=0
Rk88 (\14\:VSS \15\:VSS) resistor r=0.1136 c=0
Rk89 (\15\:VSS \16\:VSS) resistor r=0.3313 c=0
Rk91 (\17\:VSS VSS) resistor r=0.2098 c=0
Rk90 (\16\:VSS \17\:VSS) resistor r=0.2843 c=0
Rk92 (VSS \18\:VSS) resistor r=0.3241 c=0
Rk94 (\19\:VSS VSS) resistor r=0.5791 c=0
Rk93 (\18\:VSS \19\:VSS) resistor r=0.121 c=0
Rk95 (VSS \20\:VSS) resistor r=0.1141 c=0
Rk96 (\13\:VSS \22\:VSS) resistor r=0.2468 c=0
Rk97 (\15\:VSS \24\:VSS) resistor r=0.2586 c=0
Rk98 (\17\:VSS \26\:VSS) resistor r=0.2765 c=0
Rk99 (\18\:VSS \28\:VSS) resistor r=0.2375 c=0
Rk100 (VSS \30\:VSS) resistor r=0.3041 c=0
Rk16 (\10\:RT RT) resistor r=0.003262 c=0
Rk17 (\11\:RT RT) resistor r=0.001957 c=0
Rk18 (\10\:RT \11\:RT) resistor r=0.01271 c=0
Rk20 (\11\:RT \13\:RT) resistor r=0.0252 c=0
Rk19 (\12\:RT \13\:RT) resistor r=0.003262 c=0
Rk49 (\14\:RT \15\:RT) resistor r=1.0394 c=0
Rk24 (SN \5\:SN) resistor r=0.004303 c=0
Rk25 (SN \6\:SN) resistor r=0.003346 c=0
Rk26 (\5\:SN \6\:SN) resistor r=0.04235 c=0
Rk28 (\6\:SN \7\:SN) resistor r=0.03579 c=0
Rk27 (\7\:SN \8\:SN) resistor r=0.004303 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.003843 c=0
Rk34 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2265 c=0
Rk35 (\7\:ExtVDD ExtVDD) resistor r=0.1378 c=0
Rk38 (ExtVDD \11\:ExtVDD) resistor r=0.154 c=0
Rk39 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.1776 c=0
Rk40 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.4993 c=0
Rk41 (\12\:ExtVDD \15\:ExtVDD) resistor r=0.0553 c=0
Rk53 (QN \4\:QN) resistor r=0.09339 c=0
Rk52 (\2\:QN \4\:QN) resistor r=0.5735 c=0
Rk62 (Q \1\:Q) resistor r=0.005928 c=0
Rk63 (\1\:Q \3\:Q) resistor r=0.3105 c=0
Rk64 (\1\:Q \5\:Q) resistor r=0.2975 c=0
Rk2 (G \4\:G) resistor r=0.009292 c=0
Rk73 (VDD VDD) resistor r=0.1311 c=0
Rk65 (\2\:VDD \3\:VDD) resistor r=0.3857 c=0
Rk66 (\3\:VDD \4\:VDD) resistor r=0.09855 c=0
Rk67 (\4\:VDD \6\:VDD) resistor r=0.09133 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.03938 c=0
Rk69 (\7\:VDD \9\:VDD) resistor r=1.7798 c=0
Rk70 (\9\:VDD \10\:VDD) resistor r=0.05326 c=0
Rk72 (\11\:VDD VDD) resistor r=0.04675 c=0
Rk71 (\10\:VDD \11\:VDD) resistor r=0.03171 c=0
Rk74 (\3\:VDD \13\:VDD) resistor r=0.3556 c=0
Rk75 (\4\:VDD \15\:VDD) resistor r=0.2808 c=0
Rk76 (\7\:VDD \17\:VDD) resistor r=0.3732 c=0
Rk77 (\10\:VDD \19\:VDD) resistor r=0.2853 c=0
Rk78 (\11\:VDD \21\:VDD) resistor r=0.3287 c=0
Rk7 (\10\:Gb \11\:Gb) resistor r=0.1047 c=0
Rk8 (\11\:Gb \12\:Gb) resistor r=0.2421 c=0
Rk9 (\12\:Gb \14\:Gb) resistor r=0.4247 c=0
Rk10 (\14\:Gb \15\:Gb) resistor r=0.2369 c=0
Rk11 (\11\:Gb \17\:Gb) resistor r=0.2508 c=0
Rk12 (\12\:Gb \19\:Gb) resistor r=0.1542 c=0
Rk50 (\20\:Gb \21\:Gb) resistor r=0.8015 c=0
Rk4 (\6\:Gbb \7\:Gbb) resistor r=0.2892 c=0
Rk5 (\7\:Gbb \9\:Gbb) resistor r=0.4421 c=0
Rk6 (\7\:Gbb \11\:Gbb) resistor r=0.1687 c=0
Rk51 (\12\:Gbb \13\:Gbb) resistor r=1.6116 c=0
Rk13 (\5\:n5 \6\:n5) resistor r=0.2055 c=0
Rk14 (\6\:n5 \8\:n5) resistor r=0.1994 c=0
Rk15 (\6\:n5 \10\:n5) resistor r=0.4735 c=0
Rk21 (\12\:n5 \13\:n5) resistor r=0.5951 c=0
Rk22 (\12\:n5 \14\:n5) resistor r=0.2474 c=0
Rk23 (\14\:n5 \16\:n5) resistor r=0.3214 c=0
Rk54 (\18\:n5 \19\:n5) resistor r=0.3435 c=0
Rk55 (\19\:n5 \20\:n5) resistor r=1.0799 c=0
Rk56 (\19\:n5 \22\:n5) resistor r=0.2538 c=0
Rk57 (\5\:Qbint \6\:Qbint) resistor r=0.02343 c=0
Rk58 (\6\:Qbint \8\:Qbint) resistor r=0.3096 c=0
Rk59 (\6\:Qbint \10\:Qbint) resistor r=0.2055 c=0
Rk29 (\14\:Qint \15\:Qint) resistor r=0.05628 c=0
Rk30 (\15\:Qint \17\:Qint) resistor r=0.2215 c=0
Rk31 (\15\:Qint \19\:Qint) resistor r=0.3712 c=0
Rk32 (\6\:n5g \8\:n5g) resistor r=0.1083 c=0
Rk33 (\8\:n5g \10\:n5g) resistor r=0.5656 c=0
Rk46 (\12\:n5g \13\:n5g) resistor r=0.7354 c=0
Rk47 (\13\:n5g \14\:n5g) resistor r=0.1062 c=0
Rk48 (\13\:n5g \16\:n5g) resistor r=0.08852 c=0
Rk42 (\6\:RTb \8\:RTb) resistor r=0.1322 c=0
Rk43 (\9\:RTb \10\:RTb) resistor r=0.1673 c=0
Rk44 (\10\:RTb \11\:RTb) resistor r=0.3284 c=0
Rk45 (\10\:RTb \13\:RTb) resistor r=0.09349 c=0
Rk61 (\2\:net103 \4\:net103) resistor r=0.6382 c=0
Rk60 (\2\:net171 \4\:net171) resistor r=0.3528 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl31 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl27 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl26 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl23 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl28 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl25 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl24 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\2\:SN \4\:SN) resistor r=159.702 c=0
Rl12 (\1\:SN \2\:SN) resistor r=53.5603 c=0
Rl13 (\2\:SN \3\:SN) resistor r=2.0644 c=0
Rl17 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl49 (\1\:RN \2\:RN) resistor r=215.452 c=0
Rl50 (\2\:RN \3\:RN) resistor r=1636.76 c=0
Rl53 (\4\:RN \6\:RN) resistor r=178.055 c=0
Rl51 (\3\:RN \4\:RN) resistor r=56.5719 c=0
Rl52 (\4\:RN \5\:RN) resistor r=0.6051 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl8 (\4\:Gb \5\:Gb) resistor r=249.542 c=0
Rl33 (\8\:Gb \9\:Gb) resistor r=361.066 c=0
Rl15 (\6\:Gb \7\:Gb) resistor r=435.371 c=0
Rl5 (Gb \2\:Gb) resistor r=168.204 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=143.548 c=0
Rl32 (\4\:Gbb \5\:Gbb) resistor r=178.565 c=0
Rl10 (Gbb \2\:Gbb) resistor r=696.861 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl22 (\3\:n5 \4\:n5) resistor r=172.871 c=0
Rl9 (n5 \2\:n5) resistor r=331.394 c=0
Rl46 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl48 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl47 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl34 (Qint \2\:Qint) resistor r=232.216 c=0
Rl35 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl36 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl41 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl42 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl43 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl37 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl44 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl38 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl45 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl40 (\7\:Qint \8\:Qint) resistor r=186.916 c=0
Rl39 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl21 (\4\:n5g \5\:n5g) resistor r=317.727 c=0
Rl18 (n5g \2\:n5g) resistor r=109.66 c=0
Rl20 (\2\:n5g \4\:n5g) resistor r=191.281 c=0
Rl19 (\2\:n5g \3\:n5g) resistor r=38.4366 c=0
Rl16 (RTb \2\:RTb) resistor r=124.916 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl30 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz21 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \22\:VSS) resistor r=37.5 c=0
Rz23 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz24 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz25 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz17 (\8\:VDD \9\:VDD) resistor r=37.5 c=0
Rz18 (\8\:VDD \11\:VDD) resistor r=75 c=0
Rz2 (\16\:Gb \17\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz3 (\9\:n5 \10\:n5) resistor r=75 c=0
Rz4 (\15\:n5 \16\:n5) resistor r=75 c=0
Rz11 (\17\:n5 \18\:n5) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz5 (\16\:Qint \17\:Qint) resistor r=75 c=0
Rz6 (\9\:n5g \10\:n5g) resistor r=75 c=0
Rz9 (\15\:n5g \16\:n5g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz13 (net171 \2\:net171) resistor r=75 c=0
Rz14 (\3\:net171 \4\:net171) resistor r=75 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry29 (\11\:VSS \12\:VSS) resistor r=31 c=0
Ry30 (\11\:VSS \14\:VSS) resistor r=31 c=0
Ry31 (\11\:VSS \16\:VSS) resistor r=8.8571 c=0
Ry32 (\11\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry33 (\11\:VSS \20\:VSS) resistor r=31 c=0
Ry8 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry9 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry10 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry11 (\13\:ExtVDD \14\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry19 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry20 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry21 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry22 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry23 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry2 (\13\:Gb \14\:Gb) resistor r=62 c=0
Ry3 (\18\:Gb \19\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry4 (\7\:n5 \8\:n5) resistor r=62 c=0
Ry5 (\11\:n5 \12\:n5) resistor r=62 c=0
Ry15 (\21\:n5 \22\:n5) resistor r=62 c=0
Ry16 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry6 (\18\:Qint \19\:Qint) resistor r=62 c=0
Ry7 (\7\:n5g \8\:n5g) resistor r=62 c=0
Ry13 (\11\:n5g \12\:n5g) resistor r=62 c=0
Ry12 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry17 (net103 \2\:net103) resistor r=62 c=0
Ry18 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx8 (\4\:RT \12\:RT) resistor r=45 c=0
Rx20 (\8\:RT \14\:RT) resistor r=45 c=0
Rx21 (\6\:RT \15\:RT) resistor r=45 c=0
Rx11 (\3\:SN \8\:SN) resistor r=45 c=0
Rx14 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx15 (\1\:ExtVDD \15\:ExtVDD) resistor r=45 c=0
Rx1 (\5\:RN RN) resistor r=45 c=0
Rx2 (\2\:G \4\:G) resistor r=45 c=0
Rx5 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx6 (\3\:Gb \15\:Gb) resistor r=45 c=0
Rx22 (\9\:Gb \20\:Gb) resistor r=45 c=0
Rx23 (\6\:Gb \21\:Gb) resistor r=45 c=0
Rx4 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx24 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx25 (Gbb \13\:Gbb) resistor r=45 c=0
Rx7 (n5 \5\:n5) resistor r=45 c=0
Rx9 (\2\:n5 \13\:n5) resistor r=45 c=0
Rx10 (\4\:n5 \14\:n5) resistor r=45 c=0
Rx26 (\3\:n5 \20\:n5) resistor r=45 c=0
Rx27 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx12 (\8\:Qint \14\:Qint) resistor r=45 c=0
Rx13 (\5\:n5g \6\:n5g) resistor r=45 c=0
Rx19 (n5g \14\:n5g) resistor r=45 c=0
Rx16 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx17 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx18 (RTb \11\:RTb) resistor r=45 c=0
mn2 (\10\:Gbb \5\:Gb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (net159 \3\:RN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\16\:Gb \3\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net191 \1\:D \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\9\:n5 \3\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n5g \2\:RTb \15\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (net183 \1\:SN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn11 (\16\:Qint \3\:n5g net183 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n5g \9\:RT net094 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net094 \13\:Qint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn17 (\17\:n5 \8\:Gb \3\:net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\9\:Qbint \9\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (net171 Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\4\:Q Qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mn15 (net167 \2\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp0 (\13\:Gb \6\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.9195 \
        scb=0.0189757 scc=0.000406591 m=(1)
mp5 (net142 \3\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp1 (\18\:Gb \1\:G \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\7\:n5 Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n5g \7\:RT \11\:n5 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp10 (\18\:Qint \4\:SN \13\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp11 (\18\:Qint \4\:n5g \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.1365 \
        scb=0.0108856 scc=0.000154611 m=(1)
mp45 (\7\:RTb \5\:RT \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net94 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n5g \3\:RTb net94 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp17 (\21\:n5 \4\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.7175 \
        scb=0.0182062 scc=0.00060472 m=(1)
mp20 (\7\:Qbint \3\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net103 \2\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\2\:Q \4\:Qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
mp15 (net103 \1\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.1035 \
        scb=0.0249499 scc=0.00160735 m=(1)
ends RTLATSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:56:25 2012 )
// Library name: gsclib045
// Cell name: RTLATX1
// View name: extracted

simulator lang=spectre

subckt RTLATX1 D ExtVDD G Q QN RT VDD VSS
mp1 (\8\:Gbb \3\:Gb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (QN VSS) capacitor c=3.7262e-17
C2 (VDD VSS) capacitor c=3.10746e-16
C3 (RT VSS) capacitor c=2.61402e-17
C4 (ExtVDD VSS) capacitor c=2.60613e-16
C5 (Q VSS) capacitor c=2.23222e-17
C6 (D VSS) capacitor c=5.58381e-17
C7 (Gb VSS) capacitor c=5.266e-17
C8 (Gbb VSS) capacitor c=1.20531e-16
C9 (Qbint VSS) capacitor c=2.99278e-17
C10 (n0 VSS) capacitor c=6.47334e-17
C11 (Qint VSS) capacitor c=8.13439e-17
C12 (n0g VSS) capacitor c=4.74086e-17
C13 (RTb VSS) capacitor c=4.20307e-17
C14 (net095 VSS) capacitor c=4.39292e-17
C15 (\4\:Qbint VSS) capacitor c=3.88878e-17
C16 (\2\:Qint VSS) capacitor c=1.16018e-16
C17 (\4\:Gbb VSS) capacitor c=1.15221e-16
C18 (\3\:Qint VSS) capacitor c=6.26148e-17
C19 (\10\:Qint VSS) capacitor c=2.21642e-17
C20 (\3\:RTb VSS) capacitor c=8.98845e-17
C21 (\12\:Qint VSS) capacitor c=6.54344e-17
C22 (\5\:RT VSS) capacitor c=5.28764e-17
C23 (\4\:n0g VSS) capacitor c=9.10741e-17
C24 (\7\:RT VSS) capacitor c=3.42877e-17
C25 (\4\:Gb VSS) capacitor c=5.88761e-17
C26 (\1\:G VSS) capacitor c=3.78432e-17
C27 (\3\:D VSS) capacitor c=7.29864e-17
C28 (\3\:Gb VSS) capacitor c=7.63078e-17
C29 (\8\:Gb VSS) capacitor c=1.12378e-16
C30 (\9\:Qint VSS) capacitor c=2.60833e-17
C31 (\11\:Qint VSS) capacitor c=2.49079e-17
C32 (\13\:Qint VSS) capacitor c=5.74163e-17
C33 (\9\:RT VSS) capacitor c=9.2617e-17
C34 (\1\:RT VSS) capacitor c=4.97783e-17
C35 (\3\:n0g VSS) capacitor c=2.34422e-17
C36 (\2\:RTb VSS) capacitor c=4.49876e-17
C37 (\3\:Gbb VSS) capacitor c=4.2823e-17
C38 (\1\:D VSS) capacitor c=7.05281e-17
C39 (\3\:G VSS) capacitor c=4.23814e-17
C40 (\5\:Gb VSS) capacitor c=6.09748e-17
C41 (\3\:Qbint VSS) capacitor c=2.75606e-17
C42 (\5\:Gbb VSS) capacitor c=7.06913e-17
C43 (\9\:Gb VSS) capacitor c=5.88198e-17
C44 (\8\:RT VSS) capacitor c=6.08119e-17
C45 (\4\:RTb VSS) capacitor c=7.7037e-17
C46 (\5\:RTb VSS) capacitor c=4.49791e-17
C47 (\6\:RT VSS) capacitor c=5.62346e-17
C48 (\2\:ExtVDD VSS) capacitor c=5.37023e-17
C49 (\1\:ExtVDD VSS) capacitor c=4.86404e-17
C50 (\5\:n0g VSS) capacitor c=1.01336e-16
C51 (\6\:Gb VSS) capacitor c=1.03458e-16
C52 (\8\:Qint VSS) capacitor c=7.77282e-17
C53 (\4\:RT VSS) capacitor c=3.40204e-17
C54 (\2\:n0 VSS) capacitor c=8.02412e-17
C55 (\7\:Gb VSS) capacitor c=4.72225e-17
C56 (\2\:Gbb VSS) capacitor c=1.0611e-16
C57 (\2\:D VSS) capacitor c=5.64234e-17
C58 (\2\:G VSS) capacitor c=4.64539e-17
C59 (\2\:Q VSS) capacitor c=4.83735e-17
C60 (\11\:VDD VSS) capacitor c=7.21782e-17
C61 (\1\:VDD VSS) capacitor c=2.27369e-17
C62 (\7\:Qbint VSS) capacitor c=8.17094e-17
C63 (\13\:VDD VSS) capacitor c=8.75208e-17
C64 (\1\:QN VSS) capacitor c=6.44283e-17
C65 (\11\:n0g VSS) capacitor c=1.19601e-16
C66 (\6\:ExtVDD VSS) capacitor c=6.4648e-17
C67 (\7\:RTb VSS) capacitor c=3.89729e-17
C68 (\3\:ExtVDD VSS) capacitor c=4.00327e-17
C69 (\10\:ExtVDD VSS) capacitor c=6.29562e-17
C70 (\17\:Qint VSS) capacitor c=4.86609e-17
C71 (\7\:n0g VSS) capacitor c=7.36607e-17
C72 (\9\:n0 VSS) capacitor c=1.08279e-16
C73 (\5\:n0 VSS) capacitor c=2.63234e-17
C74 (\15\:Gb VSS) capacitor c=3.46136e-17
C75 (\15\:VDD VSS) capacitor c=3.62136e-17
C76 (\17\:VDD VSS) capacitor c=5.42139e-17
C77 (\8\:Gbb VSS) capacitor c=5.09686e-17
C78 (\4\:Q VSS) capacitor c=3.49476e-17
C79 (\9\:Qbint VSS) capacitor c=5.58557e-17
C80 (\3\:net095 VSS) capacitor c=4.42255e-17
C81 (\3\:QN VSS) capacitor c=4.68238e-17
C82 (\12\:RTb VSS) capacitor c=2.26472e-17
C83 (\15\:n0g VSS) capacitor c=1.89851e-17
C84 (\14\:Qint VSS) capacitor c=3.90606e-17
C85 (\9\:n0g VSS) capacitor c=8.89139e-17
C86 (\12\:n0 VSS) capacitor c=6.09083e-17
C87 (\7\:n0 VSS) capacitor c=6.87804e-17
C88 (\7\:VDD VSS) capacitor c=2.71581e-16
C89 (\13\:Gb VSS) capacitor c=4.48926e-17
C90 (\10\:Gbb VSS) capacitor c=2.54969e-17
C91 (\2\:Gb VSS) capacitor c=7.93506e-17
C92 (ExtVDD VSS) capacitor c=3.85231e-17
C93 (\2\:n0g VSS) capacitor c=4.75933e-17
C94 (\2\:RT VSS) capacitor c=5.96165e-17
C95 (\3\:RT VSS) capacitor c=5.47053e-17
C96 (\4\:Qint VSS) capacitor c=2.47361e-17
C97 (\5\:Qint VSS) capacitor c=4.82551e-17
C98 (\6\:Qint VSS) capacitor c=6.32965e-17
C99 (\7\:Qint VSS) capacitor c=4.07601e-17
C100 (\2\:Qbint VSS) capacitor c=2.01924e-17
C101 (\4\:G VSS) capacitor c=3.46724e-17
C102 (\5\:G VSS) capacitor c=3.63295e-18
C103 (\6\:G VSS) capacitor c=2.93068e-17
C104 (\6\:Gbb VSS) capacitor c=5.37738e-17
C105 (\7\:Gbb VSS) capacitor c=5.85837e-17
C106 (\10\:Gb VSS) capacitor c=1.31957e-17
C107 (\11\:Gb VSS) capacitor c=3.36675e-17
C108 (\12\:Gb VSS) capacitor c=4.2165e-17
C109 (\17\:Gb VSS) capacitor c=6.40786e-18
C110 (\3\:n0 VSS) capacitor c=2.52068e-17
C111 (\4\:n0 VSS) capacitor c=5.67143e-17
C112 (\13\:RT VSS) capacitor c=2.31119e-17
C113 (\11\:n0 VSS) capacitor c=5.3389e-17
C114 (\16\:Qint VSS) capacitor c=5.85375e-17
C115 (\6\:n0g VSS) capacitor c=2.47889e-17
C116 (\5\:ExtVDD VSS) capacitor c=5.42887e-17
C117 (\12\:ExtVDD VSS) capacitor c=3.18539e-17
C118 (\6\:RTb VSS) capacitor c=2.20655e-17
C119 (\9\:RTb VSS) capacitor c=3.91535e-17
C120 (\10\:RTb VSS) capacitor c=6.0629e-17
C121 (\11\:RTb VSS) capacitor c=6.25043e-17
C122 (\13\:n0g VSS) capacitor c=9.86135e-17
C123 (\14\:n0g VSS) capacitor c=2.8793e-17
C124 (\14\:RT VSS) capacitor c=1.29706e-16
C125 (\15\:RT VSS) capacitor c=1.31871e-16
C126 (\18\:Gb VSS) capacitor c=7.87472e-17
C127 (\19\:Gb VSS) capacitor c=1.2152e-16
C128 (\12\:Gbb VSS) capacitor c=1.83878e-16
C129 (\13\:Gbb VSS) capacitor c=2.44377e-16
C130 (\5\:Qbint VSS) capacitor c=2.81148e-17
C131 (\1\:Q VSS) capacitor c=2.48116e-17
C132 (\3\:VDD VSS) capacitor c=3.8827e-17
C133 (\5\:VDD VSS) capacitor c=2.17314e-17
C134 (\6\:VDD VSS) capacitor c=2.82635e-16
Rk46 (QN \4\:QN) resistor r=0.09302 c=0
Rk45 (\2\:QN \4\:QN) resistor r=0.5711 c=0
Rk61 (VDD VDD) resistor r=0.1305 c=0
Rk54 (\2\:VDD \3\:VDD) resistor r=0.2736 c=0
Rk55 (\3\:VDD \5\:VDD) resistor r=0.1877 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.03919 c=0
Rk57 (\6\:VDD \8\:VDD) resistor r=1.7711 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.05305 c=0
Rk60 (\10\:VDD VDD) resistor r=0.04653 c=0
Rk59 (\9\:VDD \10\:VDD) resistor r=0.03158 c=0
Rk62 (\3\:VDD \12\:VDD) resistor r=0.4167 c=0
Rk63 (\6\:VDD \14\:VDD) resistor r=0.3716 c=0
Rk64 (\9\:VDD \16\:VDD) resistor r=0.2631 c=0
Rk65 (\10\:VDD \18\:VDD) resistor r=0.3272 c=0
Rk18 (\10\:RT RT) resistor r=0.003536 c=0
Rk19 (\11\:RT RT) resistor r=0.002122 c=0
Rk20 (\10\:RT \11\:RT) resistor r=0.01898 c=0
Rk22 (\11\:RT \13\:RT) resistor r=0.02088 c=0
Rk21 (\12\:RT \13\:RT) resistor r=0.003536 c=0
Rk42 (\14\:RT \15\:RT) resistor r=1.0351 c=0
Rk31 (ExtVDD ExtVDD) resistor r=0.001963 c=0
Rk29 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2255 c=0
Rk30 (\7\:ExtVDD ExtVDD) resistor r=0.1352 c=0
Rk33 (ExtVDD \11\:ExtVDD) resistor r=0.1516 c=0
Rk34 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.2295 c=0
Rk66 (\2\:VSS \3\:VSS) resistor r=0.07857 c=0
Rk68 (\4\:VSS VSS) resistor r=0.4924 c=0
Rk67 (\3\:VSS \4\:VSS) resistor r=0.561 c=0
Rk70 (\5\:VSS VSS) resistor r=0.1844 c=0
Rk69 (VSS \5\:VSS) resistor r=0.6404 c=0
Rk71 (VSS \7\:VSS) resistor r=0.5061 c=0
Rk72 (\3\:VSS \9\:VSS) resistor r=0.2882 c=0
Rk73 (VSS \11\:VSS) resistor r=0.3032 c=0
Rk74 (\13\:VSS \14\:VSS) resistor r=0.08103 c=0
Rk75 (\14\:VSS \15\:VSS) resistor r=0.1155 c=0
Rk76 (\15\:VSS \16\:VSS) resistor r=0.113 c=0
Rk77 (\16\:VSS \17\:VSS) resistor r=0.3296 c=0
Rk79 (\18\:VSS VSS) resistor r=0.2088 c=0
Rk78 (\17\:VSS \18\:VSS) resistor r=0.2829 c=0
Rk80 (VSS \19\:VSS) resistor r=0.2708 c=0
Rk82 (\20\:VSS VSS) resistor r=0.5762 c=0
Rk81 (\19\:VSS \20\:VSS) resistor r=0.1721 c=0
Rk83 (VSS \21\:VSS) resistor r=0.1136 c=0
Rk84 (\14\:VSS \23\:VSS) resistor r=0.2458 c=0
Rk85 (\16\:VSS \25\:VSS) resistor r=0.2575 c=0
Rk86 (\18\:VSS \27\:VSS) resistor r=0.2753 c=0
Rk87 (\19\:VSS \29\:VSS) resistor r=0.2415 c=0
Rk88 (VSS \31\:VSS) resistor r=0.3028 c=0
Rk1 (\4\:G G) resistor r=0.007228 c=0
Rk2 (G \5\:G) resistor r=0.007038 c=0
Rk3 (\4\:G \5\:G) resistor r=0.004546 c=0
Rk5 (\5\:G \6\:G) resistor r=0.007576 c=0
Rk4 (\6\:G \7\:G) resistor r=0.005136 c=0
Rk51 (Q \1\:Q) resistor r=0.005993 c=0
Rk52 (\1\:Q \3\:Q) resistor r=0.3099 c=0
Rk53 (\1\:Q \5\:Q) resistor r=0.2937 c=0
Rk10 (\10\:Gb \11\:Gb) resistor r=0.156 c=0
Rk11 (\11\:Gb \12\:Gb) resistor r=0.2411 c=0
Rk12 (\12\:Gb \14\:Gb) resistor r=0.2401 c=0
Rk13 (\11\:Gb \16\:Gb) resistor r=0.1464 c=0
Rk14 (\12\:Gb \17\:Gb) resistor r=0.1139 c=0
Rk43 (\18\:Gb \19\:Gb) resistor r=0.7236 c=0
Rk7 (\6\:Gbb \7\:Gbb) resistor r=0.2873 c=0
Rk8 (\7\:Gbb \9\:Gbb) resistor r=0.4402 c=0
Rk9 (\7\:Gbb \11\:Gbb) resistor r=0.168 c=0
Rk44 (\12\:Gbb \13\:Gbb) resistor r=1.605 c=0
Rk48 (\5\:Qbint \6\:Qbint) resistor r=0.02326 c=0
Rk49 (\6\:Qbint \8\:Qbint) resistor r=0.3083 c=0
Rk50 (\6\:Qbint \10\:Qbint) resistor r=0.2047 c=0
Rk15 (\3\:n0 \4\:n0) resistor r=0.3083 c=0
Rk16 (\4\:n0 \6\:n0) resistor r=0.1986 c=0
Rk17 (\4\:n0 \8\:n0) resistor r=0.4678 c=0
Rk23 (\10\:n0 \11\:n0) resistor r=0.4878 c=0
Rk24 (\10\:n0 \13\:n0) resistor r=0.5665 c=0
Rk25 (\15\:Qint \16\:Qint) resistor r=0.2099 c=0
Rk26 (\16\:Qint \18\:Qint) resistor r=0.4287 c=0
Rk27 (\6\:n0g \8\:n0g) resistor r=0.1078 c=0
Rk28 (\8\:n0g \10\:n0g) resistor r=0.5632 c=0
Rk39 (\12\:n0g \13\:n0g) resistor r=0.7323 c=0
Rk40 (\13\:n0g \14\:n0g) resistor r=0.1057 c=0
Rk41 (\13\:n0g \16\:n0g) resistor r=0.08816 c=0
Rk35 (\6\:RTb \8\:RTb) resistor r=0.1317 c=0
Rk36 (\9\:RTb \10\:RTb) resistor r=0.1666 c=0
Rk37 (\10\:RTb \11\:RTb) resistor r=0.327 c=0
Rk38 (\10\:RTb \13\:RTb) resistor r=0.09304 c=0
Rk47 (\2\:net095 \4\:net095) resistor r=0.5082 c=0
Rl27 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl23 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl22 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl19 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl24 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl21 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl20 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl8 (\3\:Gb \5\:Gb) resistor r=249.542 c=0
Rl29 (\8\:Gb \9\:Gb) resistor r=447.998 c=0
Rl12 (\6\:Gb \7\:Gb) resistor r=435.371 c=0
Rl5 (Gb \2\:Gb) resistor r=353.207 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=168.248 c=0
Rl28 (\4\:Gbb \5\:Gbb) resistor r=455.381 c=0
Rl10 (Gbb \2\:Gbb) resistor r=706.37 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl42 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl44 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl43 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl9 (n0 \2\:n0) resistor r=331.394 c=0
Rl30 (Qint \2\:Qint) resistor r=215.233 c=0
Rl31 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl32 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl37 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl38 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl39 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl33 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl40 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl34 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl41 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl36 (\7\:Qint \8\:Qint) resistor r=192.03 c=0
Rl35 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl18 (\4\:n0g \5\:n0g) resistor r=317.727 c=0
Rl15 (n0g \2\:n0g) resistor r=109.66 c=0
Rl17 (\2\:n0g \4\:n0g) resistor r=191.281 c=0
Rl16 (\2\:n0g \3\:n0g) resistor r=38.4366 c=0
Rl13 (RTb \2\:RTb) resistor r=124.916 c=0
Rl25 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl26 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\7\:VDD \8\:VDD) resistor r=37.5 c=0
Rz16 (\7\:VDD \10\:VDD) resistor r=75 c=0
Rz17 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz18 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz19 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz20 (\22\:VSS \23\:VSS) resistor r=37.5 c=0
Rz21 (\24\:VSS \25\:VSS) resistor r=37.5 c=0
Rz22 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz23 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz24 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz13 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz2 (\13\:Gb \14\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz4 (\12\:n0 \13\:n0) resistor r=75 c=0
Rz5 (\14\:Qint \15\:Qint) resistor r=75 c=0
Rz6 (\9\:n0g \10\:n0g) resistor r=75 c=0
Rz9 (\15\:n0g \16\:n0g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz11 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry12 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry16 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry17 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry18 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry19 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry7 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry8 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry9 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry21 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry23 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry24 (\12\:VSS \13\:VSS) resistor r=31 c=0
Ry25 (\12\:VSS \15\:VSS) resistor r=31 c=0
Ry26 (\12\:VSS \17\:VSS) resistor r=8.8571 c=0
Ry27 (\12\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry28 (\12\:VSS \21\:VSS) resistor r=31 c=0
Ry15 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry2 (\15\:Gb \16\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry14 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry5 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\7\:n0g \8\:n0g) resistor r=62 c=0
Ry11 (\11\:n0g \12\:n0g) resistor r=62 c=0
Ry10 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry13 (net095 \2\:net095) resistor r=62 c=0
Rx7 (\4\:RT \12\:RT) resistor r=45 c=0
Rx17 (\8\:RT \14\:RT) resistor r=45 c=0
Rx18 (\6\:RT \15\:RT) resistor r=45 c=0
Rx11 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx12 (\1\:ExtVDD \12\:ExtVDD) resistor r=45 c=0
Rx1 (\2\:G \7\:G) resistor r=45 c=0
Rx2 (\2\:D D) resistor r=45 c=0
Rx4 (Gb \10\:Gb) resistor r=45 c=0
Rx5 (\7\:Gb \17\:Gb) resistor r=45 c=0
Rx19 (\9\:Gb \18\:Gb) resistor r=45 c=0
Rx20 (\6\:Gb \19\:Gb) resistor r=45 c=0
Rx3 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx21 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx22 (Gbb \13\:Gbb) resistor r=45 c=0
Rx23 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx6 (n0 \3\:n0) resistor r=45 c=0
Rx8 (\2\:n0 \11\:n0) resistor r=45 c=0
Rx9 (\8\:Qint \16\:Qint) resistor r=45 c=0
Rx10 (\5\:n0g \6\:n0g) resistor r=45 c=0
Rx16 (n0g \14\:n0g) resistor r=45 c=0
Rx13 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx14 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx15 (RTb \11\:RTb) resistor r=45 c=0
mn1 (\10\:Gbb \5\:Gb \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\13\:Gb \3\:G \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net257 \1\:D \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\7\:n0 \3\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n0g \2\:RTb \12\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\14\:Qint \3\:n0g \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n0g \9\:RT net093 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net093 \13\:Qint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn20 (\9\:Qbint \9\:Qint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (\3\:net095 \8\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn15 (net245 Qint \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\4\:Q Qbint \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mp5 (net220 \3\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp0 (\15\:Gb \1\:G \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\5\:n0 \4\:Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n0g \7\:RT \9\:n0 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp11 (\17\:Qint \4\:n0g \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1365 \
        scb=0.0108856 scc=0.000154611 m=(1)
mp45 (\7\:RTb \5\:RT \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net145 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n0g \3\:RTb net145 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp20 (\7\:Qbint \3\:Qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net095 \4\:Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.1709 \
        scb=0.00798825 scc=9.08326e-05 m=(1)
mp15 (net212 \2\:Qint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\2\:Q \4\:Qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
ends RTLATX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:23:05 2012 )
// Library name: gsclib045
// Cell name: SDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFHQX1 CK D Q SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.98462e-07 sd=160n sca=19.586 \
        scb=0.0215989 scc=0.000684683 m=(1)
C1 (D VSS) capacitor c=4.35084e-17
C2 (Q VSS) capacitor c=1.52714e-17
C3 (CK VSS) capacitor c=1.13847e-16
C4 (SE VSS) capacitor c=4.41301e-17
C5 (VDD VSS) capacitor c=2.85211e-16
C6 (SI VSS) capacitor c=6.08059e-17
C7 (qbint VSS) capacitor c=1.77947e-17
C8 (CKb VSS) capacitor c=2.14623e-17
C9 (n30 VSS) capacitor c=3.13465e-17
C10 (net391 VSS) capacitor c=5.82309e-18
C11 (mout VSS) capacitor c=5.57271e-17
C12 (CKbb VSS) capacitor c=3.3655e-17
C13 (n20 VSS) capacitor c=3.67409e-17
C14 (net378 VSS) capacitor c=9.11373e-19
C15 (Db VSS) capacitor c=8.98579e-17
C16 (net399 VSS) capacitor c=8.55872e-18
C17 (SEb VSS) capacitor c=3.81113e-17
C18 (net334 VSS) capacitor c=6.50403e-18
C19 (net319 VSS) capacitor c=5.33809e-18
C20 (net342 VSS) capacitor c=2.75167e-18
C21 (net350 VSS) capacitor c=6.08103e-18
C22 (\7\:SE VSS) capacitor c=4.04378e-17
C23 (\3\:SI VSS) capacitor c=4.8669e-17
C24 (\2\:SE VSS) capacitor c=6.57718e-17
C25 (\1\:D VSS) capacitor c=8.96482e-17
C26 (\5\:CKb VSS) capacitor c=4.6278e-17
C27 (\7\:CKbb VSS) capacitor c=3.89853e-17
C28 (\8\:CKb VSS) capacitor c=4.13827e-17
C29 (\5\:qbint VSS) capacitor c=4.5929e-17
C30 (\3\:n30 VSS) capacitor c=3.9376e-17
C31 (\3\:CK VSS) capacitor c=4.49303e-17
C32 (\4\:qbint VSS) capacitor c=6.26211e-17
C33 (\5\:SE VSS) capacitor c=2.40379e-17
C34 (\1\:SI VSS) capacitor c=7.51328e-17
C35 (\3\:SE VSS) capacitor c=6.94746e-17
C36 (\3\:SEb VSS) capacitor c=5.97054e-17
C37 (\4\:D VSS) capacitor c=3.74139e-17
C38 (\10\:CKb VSS) capacitor c=3.34568e-17
C39 (\11\:CKb VSS) capacitor c=2.40778e-17
C40 (\5\:CKbb VSS) capacitor c=5.89019e-17
C41 (\4\:mout VSS) capacitor c=6.61139e-17
C42 (\3\:n20 VSS) capacitor c=3.76564e-17
C43 (\3\:CKbb VSS) capacitor c=3.08296e-17
C44 (\3\:CKb VSS) capacitor c=6.7033e-17
C45 (\8\:qbint VSS) capacitor c=3.68112e-17
C46 (\1\:CK VSS) capacitor c=4.93966e-17
C47 (\3\:qbint VSS) capacitor c=2.95076e-17
C48 (\6\:SE VSS) capacitor c=3.03284e-17
C49 (\2\:SI VSS) capacitor c=4.75795e-17
C50 (\4\:SE VSS) capacitor c=4.42107e-17
C51 (\2\:SEb VSS) capacitor c=5.49608e-17
C52 (\1\:SE VSS) capacitor c=5.17208e-17
C53 (\3\:D VSS) capacitor c=2.64492e-17
C54 (\8\:CKbb VSS) capacitor c=4.15456e-17
C55 (\9\:CKb VSS) capacitor c=2.7875e-17
C56 (\6\:CKbb VSS) capacitor c=4.03023e-17
C57 (\3\:mout VSS) capacitor c=2.5529e-17
C58 (\2\:n20 VSS) capacitor c=4.34279e-17
C59 (\4\:CKb VSS) capacitor c=1.62168e-17
C60 (\4\:CKbb VSS) capacitor c=4.13288e-17
C61 (\2\:CKbb VSS) capacitor c=4.16128e-17
C62 (\7\:qbint VSS) capacitor c=2.49986e-17
C63 (\2\:n30 VSS) capacitor c=4.26709e-17
C64 (\2\:CK VSS) capacitor c=4.54577e-17
C65 (\6\:SEb VSS) capacitor c=1.03415e-16
C66 (\5\:VDD VSS) capacitor c=3.14666e-17
C67 (\7\:Db VSS) capacitor c=6.7784e-17
C68 (\7\:VDD VSS) capacitor c=5.23037e-17
C69 (\9\:CKbb VSS) capacitor c=1.02258e-16
C70 (\5\:Db VSS) capacitor c=1.04772e-16
C71 (\4\:n20 VSS) capacitor c=3.4328e-17
C72 (\10\:VDD VSS) capacitor c=3.47137e-17
C73 (\9\:mout VSS) capacitor c=7.43026e-17
C74 (\8\:n30 VSS) capacitor c=5.19174e-17
C75 (\14\:VDD VSS) capacitor c=4.188e-17
C76 (\14\:qbint VSS) capacitor c=7.14121e-17
C77 (\18\:CKb VSS) capacitor c=2.53523e-17
C78 (\17\:VDD VSS) capacitor c=2.69069e-17
C79 (\1\:Q VSS) capacitor c=5.47054e-17
C80 (\1\:VDD VSS) capacitor c=8.51025e-17
C81 (\4\:SEb VSS) capacitor c=5.50775e-17
C82 (\15\:CKbb VSS) capacitor c=4.24914e-17
C83 (\9\:Db VSS) capacitor c=6.89013e-17
C84 (\8\:n20 VSS) capacitor c=8.29575e-17
C85 (\7\:mout VSS) capacitor c=5.47759e-17
C86 (\4\:n30 VSS) capacitor c=7.27734e-17
C87 (\11\:qbint VSS) capacitor c=8.05222e-17
C88 (\15\:CKb VSS) capacitor c=9.33902e-17
C89 (\3\:Q VSS) capacitor c=5.61639e-17
C90 (\2\:qbint VSS) capacitor c=2.1853e-17
C91 (\6\:qbint VSS) capacitor c=2.38326e-17
C92 (\2\:CKb VSS) capacitor c=4.46223e-17
C93 (\2\:mout VSS) capacitor c=2.85626e-17
C94 (\6\:CKb VSS) capacitor c=5.72862e-17
C95 (\7\:CKb VSS) capacitor c=6.75539e-17
C96 (\2\:D VSS) capacitor c=2.86216e-17
C97 (\9\:qbint VSS) capacitor c=7.16079e-17
C98 (\10\:qbint VSS) capacitor c=6.70756e-17
C99 (\13\:qbint VSS) capacitor c=1.10592e-16
C100 (\6\:n30 VSS) capacitor c=1.03114e-16
C101 (\7\:n30 VSS) capacitor c=7.07733e-17
C102 (\5\:mout VSS) capacitor c=6.47005e-17
C103 (\6\:mout VSS) capacitor c=5.89137e-17
C104 (\12\:CKb VSS) capacitor c=6.14877e-17
C105 (\13\:CKb VSS) capacitor c=1.48887e-16
C106 (\14\:CKb VSS) capacitor c=1.65924e-16
C107 (\17\:CKb VSS) capacitor c=8.14787e-17
C108 (\6\:n20 VSS) capacitor c=7.88714e-17
C109 (\7\:n20 VSS) capacitor c=8.5285e-17
C110 (\11\:CKbb VSS) capacitor c=1.16991e-16
C111 (\12\:CKbb VSS) capacitor c=7.61505e-17
C112 (\13\:CKbb VSS) capacitor c=1.02156e-16
C113 (\14\:CKbb VSS) capacitor c=1.36742e-16
C114 (\17\:CKbb VSS) capacitor c=6.14671e-17
C115 (\18\:CKbb VSS) capacitor c=5.30923e-17
C116 (\5\:D VSS) capacitor c=6.56193e-17
C117 (\3\:Db VSS) capacitor c=1.3372e-16
C118 (\4\:SI VSS) capacitor c=7.60628e-17
C119 (\8\:SE VSS) capacitor c=7.45004e-17
C120 (\9\:SE VSS) capacitor c=7.39991e-17
C121 (\10\:SE VSS) capacitor c=2.61193e-17
C122 (\8\:SEb VSS) capacitor c=9.69349e-17
C123 (\3\:VDD VSS) capacitor c=2.03193e-17
C124 (\9\:VDD VSS) capacitor c=4.32212e-17
C125 (\13\:VDD VSS) capacitor c=1.33131e-17
C126 (\16\:VDD VSS) capacitor c=1.75695e-17
Rk29 (\5\:D D) resistor r=0.08856 c=0
Rk2 (\4\:Q Q) resistor r=0.02908 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.4952 c=0
Rk37 (\9\:SE SE) resistor r=0.3377 c=0
Rk36 (\8\:SE \9\:SE) resistor r=0.3554 c=0
Rk38 (SE \10\:SE) resistor r=0.02105 c=0
Rk56 (\2\:VDD \3\:VDD) resistor r=0.223 c=0
Rk57 (\3\:VDD \4\:VDD) resistor r=0.4292 c=0
Rk58 (\3\:VDD \6\:VDD) resistor r=0.2039 c=0
Rk59 (\4\:VDD \8\:VDD) resistor r=0.2986 c=0
Rk60 (\4\:VDD \9\:VDD) resistor r=0.6041 c=0
Rk61 (\9\:VDD \11\:VDD) resistor r=0.1859 c=0
Rk62 (\9\:VDD \12\:VDD) resistor r=0.4988 c=0
Rk63 (\12\:VDD \13\:VDD) resistor r=0.1302 c=0
Rk64 (\13\:VDD \15\:VDD) resistor r=0.236 c=0
Rk65 (\13\:VDD \16\:VDD) resistor r=0.3832 c=0
Rk66 (\16\:VDD \18\:VDD) resistor r=0.1817 c=0
Rk68 (\19\:VDD VDD) resistor r=0.0499 c=0
Rk67 (\16\:VDD \19\:VDD) resistor r=0.08756 c=0
Rk35 (\4\:SI SI) resistor r=0.03273 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1452 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4334 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.07252 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.5539 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.2982 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3032 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.1979 c=0
Rk48 (\9\:VSS \10\:VSS) resistor r=0.2129 c=0
Rk50 (\11\:VSS VSS) resistor r=0.0499 c=0
Rk49 (\10\:VSS \11\:VSS) resistor r=0.08756 c=0
Rk51 (\3\:VSS \13\:VSS) resistor r=0.2907 c=0
Rk52 (\4\:VSS \15\:VSS) resistor r=0.2194 c=0
Rk53 (\6\:VSS \17\:VSS) resistor r=0.1225 c=0
Rk54 (\8\:VSS \19\:VSS) resistor r=0.271 c=0
Rk55 (\10\:VSS \21\:VSS) resistor r=0.2933 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.3153 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06062 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6904 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.3182 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2788 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9711 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4234 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.5459 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.1224 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.4975 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.3813 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1685 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3192 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.145 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.3096 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.6368 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3322 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3239 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.5248 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.235 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2608 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.08271 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.4677 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.3854 c=0
Rk30 (\2\:Db \3\:Db) resistor r=0.6465 c=0
Rk31 (\3\:Db \4\:Db) resistor r=0.417 c=0
Rk32 (\4\:Db \6\:Db) resistor r=0.04616 c=0
Rk33 (\3\:Db \8\:Db) resistor r=0.2642 c=0
Rk34 (\4\:Db \10\:Db) resistor r=0.3646 c=0
Rk39 (\5\:SEb \7\:SEb) resistor r=0.5139 c=0
Rk40 (\7\:SEb \8\:SEb) resistor r=0.6394 c=0
Rl29 (\1\:D \2\:D) resistor r=123.88 c=0
Rl31 (\2\:D \4\:D) resistor r=54.6488 c=0
Rl30 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl5 (\2\:CK \3\:CK) resistor r=96.3431 c=0
Rl4 (\1\:CK \2\:CK) resistor r=109.615 c=0
Rl39 (\6\:SE \7\:SE) resistor r=126.099 c=0
Rl38 (\5\:SE \6\:SE) resistor r=40.3846 c=0
Rl35 (\3\:SE \4\:SE) resistor r=48.6653 c=0
Rl32 (\1\:SE \2\:SE) resistor r=55.6561 c=0
Rl37 (\2\:SI \3\:SI) resistor r=64.5604 c=0
Rl36 (\1\:SI \2\:SI) resistor r=100 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=120.868 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=42.0218 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=38.143 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=174.543 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=36.87 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=139.618 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=89.6181 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=32.3738 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=31.8681 c=0
Rl18 (mout \2\:mout) resistor r=48.8796 c=0
Rl20 (\2\:mout \4\:mout) resistor r=75.8027 c=0
Rl19 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=24.2328 c=0
Rl11 (CKbb \2\:CKbb) resistor r=30.0021 c=0
Rl16 (n20 \2\:n20) resistor r=29.5379 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=79.5379 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.771 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz18 (\1\:VDD \12\:VDD) resistor r=7.5 c=0
Rz19 (\1\:VDD \19\:VDD) resistor r=37.5 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\9\:Db \10\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry17 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry18 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry19 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry20 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry12 (\1\:VSS \5\:VSS) resistor r=5.6364 c=0
Ry13 (\1\:VSS \7\:VSS) resistor r=10.3333 c=0
Ry14 (\1\:VSS \9\:VSS) resistor r=15.5 c=0
Ry15 (\1\:VSS \11\:VSS) resistor r=31 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry5 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\5\:Db \6\:Db) resistor r=62 c=0
Ry9 (\7\:Db \8\:Db) resistor r=20.6667 c=0
Ry10 (\6\:SEb \7\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK CK) resistor r=45 c=0
Rx15 (\1\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\6\:SE \10\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\15\:CKb \1\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.972e-14 ps=9.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\11\:qbint n30 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(1)
mn50 (net391 \8\:qbint \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.383e-14 ad=4.408e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.945e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (\4\:n30 \3\:CKb net391 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.535e-14 ps=8.4e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.685e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.535e-14 ad=7.585e-14 ps=9.5e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.37e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=7.585e-14 ps=1.27e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=9.55e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (net378 \4\:mout \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=6.9e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn25 (\8\:n20 \11\:CKb \9\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=3.15e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.613e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=5.85e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09879e-06 sd=160n sca=7.79977 \
        scb=0.00524357 scc=6.87485e-05 m=(1)
mn11 (net399 \4\:D \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=7.93e-14 ps=9e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=9.99808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.03365e-07 sb=6.49808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.08365e-07 sb=4.44808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn13 (net411 \1\:SI \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=1.56e-14 ps=1.15e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13365e-07 sb=3.39808e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn10 (\4\:SEb \5\:SE \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.718e-14 ad=2.465e-14 ps=1.15e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18638e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\18\:CKb \3\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.483e-14 ps=1.1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=12.8361 \
        scb=0.0101573 scc=0.000104788 m=(1)
mp45 (\14\:qbint \3\:n30 \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.56e-14 ad=4.315e-14 ps=1.35e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39194e-07 sb=2e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp50 (net334 \5\:qbint \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.56e-14 ad=5.27e-14 ps=1.35e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04194e-07 sb=1.915e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\8\:n30 CKbb net334 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.145e-14 ps=9.6e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19194e-07 sb=1.7e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.209e-13 ad=9.145e-14 ps=1.4e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.59194e-07 sb=1.36e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\5\:Db \7\:CKbb \4\:n20 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=7.285e-14 ps=9.8e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=26.7199 scb=0.0211429 \
        scc=0.00304348 m=(1)
mp30 (\9\:mout n20 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=1.209e-13 ps=1.5e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39419e-06 sb=9.25e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (net319 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.46e-14 ad=4.805e-14 ps=1.5e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65919e-06 sb=6.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85919e-06 sb=4.6e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp21 (\9\:CKbb \5\:CKb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34e-06 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp11 (net342 \1\:D \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.12e-14 ps=1.16e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.43462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp12 (\7\:Db \2\:SE net342 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=7.02e-14 ps=9.4e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.94551e-07 sb=8.18462e-07 sd=160n sca=12.3656 \
        scb=0.0108222 scc=0.000412413 m=(1)
mp14 (\7\:Db SEb net350 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.02e-14 ps=1.2e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.19551e-07 sb=5.93462e-07 sd=160n sca=12.4887 \
        scb=0.0108489 scc=0.000412416 m=(1)
mp13 (net350 \3\:SI \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=8.19e-14 ps=1.41e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.74551e-07 sb=3.38462e-07 sd=160n sca=13.4085 \
        scb=0.011387 scc=0.000412933 m=(1)
mp10 (\6\:SEb \7\:SE \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=1.4e-07 sd=160n sca=21.6088 \
        scb=0.0245661 scc=0.00103605 m=(1)
ends SDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:23:43 2012 )
// Library name: gsclib045
// Cell name: SDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFHQX2 CK D Q SE SI VDD VSS
mp55_1__rcx (\1\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=30.9465 \
        scb=0.0329575 scc=0.002778 m=(2)
C1 (D VSS) capacitor c=5.85955e-17
C2 (Q VSS) capacitor c=3.45491e-17
C3 (CK VSS) capacitor c=5.84087e-17
C4 (VDD VSS) capacitor c=3.16794e-16
C5 (SI VSS) capacitor c=1.10962e-16
C6 (qbint VSS) capacitor c=1.39124e-16
C7 (CKb VSS) capacitor c=1.71024e-17
C8 (n30 VSS) capacitor c=3.48248e-17
C9 (mout VSS) capacitor c=5.9794e-17
C10 (CKbb VSS) capacitor c=3.42642e-17
C11 (n20 VSS) capacitor c=3.95258e-17
C12 (net378 VSS) capacitor c=1.65965e-18
C13 (Db VSS) capacitor c=1.0724e-16
C14 (net399 VSS) capacitor c=1.17545e-17
C15 (SEb VSS) capacitor c=4.52363e-17
C16 (net411 VSS) capacitor c=1.47994e-18
C17 (net334 VSS) capacitor c=9.04161e-18
C18 (net319 VSS) capacitor c=6.19945e-18
C19 (net342 VSS) capacitor c=5.59536e-18
C20 (net350 VSS) capacitor c=3.91527e-18
C21 (\7\:SE VSS) capacitor c=3.09855e-17
C22 (\3\:SI VSS) capacitor c=5.10005e-17
C23 (\1\:SE VSS) capacitor c=4.90247e-17
C24 (\1\:D VSS) capacitor c=6.50136e-17
C25 (\10\:CKb VSS) capacitor c=4.79797e-17
C26 (\7\:CKbb VSS) capacitor c=3.99169e-17
C27 (\8\:CKb VSS) capacitor c=4.35806e-17
C28 (\4\:CKb VSS) capacitor c=2.12298e-17
C29 (\8\:qbint VSS) capacitor c=4.67457e-17
C30 (\3\:n30 VSS) capacitor c=4.23954e-17
C31 (\3\:CK VSS) capacitor c=3.7808e-17
C32 (\5\:SE VSS) capacitor c=2.94341e-17
C33 (\1\:SI VSS) capacitor c=7.44934e-17
C34 (\3\:SE VSS) capacitor c=6.56106e-17
C35 (\3\:SEb VSS) capacitor c=5.86906e-17
C36 (\4\:D VSS) capacitor c=4.22846e-17
C37 (\5\:CKb VSS) capacitor c=3.17219e-17
C38 (\11\:CKb VSS) capacitor c=2.44902e-17
C39 (\5\:CKbb VSS) capacitor c=5.22482e-17
C40 (\4\:mout VSS) capacitor c=5.45502e-17
C41 (\3\:n20 VSS) capacitor c=4.24488e-17
C42 (\3\:CKbb VSS) capacitor c=3.01112e-17
C43 (\3\:CKb VSS) capacitor c=6.76524e-17
C44 (\11\:qbint VSS) capacitor c=3.53238e-17
C45 (\1\:CK VSS) capacitor c=4.09456e-17
C46 (\6\:SE VSS) capacitor c=2.65585e-17
C47 (\2\:SI VSS) capacitor c=5.01425e-17
C48 (\4\:SE VSS) capacitor c=4.74003e-17
C49 (\2\:SEb VSS) capacitor c=6.65582e-17
C50 (\2\:SE VSS) capacitor c=3.85634e-17
C51 (\3\:D VSS) capacitor c=2.76772e-17
C52 (\8\:CKbb VSS) capacitor c=3.97049e-17
C53 (\9\:CKb VSS) capacitor c=2.41653e-17
C54 (\6\:CKbb VSS) capacitor c=4.74902e-17
C55 (\3\:mout VSS) capacitor c=1.84103e-17
C56 (\2\:n20 VSS) capacitor c=3.53071e-17
C57 (\4\:CKbb VSS) capacitor c=3.88618e-17
C58 (\2\:CKbb VSS) capacitor c=4.35829e-17
C59 (\10\:qbint VSS) capacitor c=2.49612e-17
C60 (\2\:n30 VSS) capacitor c=4.33813e-17
C61 (\2\:CK VSS) capacitor c=3.6198e-17
C62 (\6\:qbint VSS) capacitor c=2.44162e-17
C63 (\5\:SEb VSS) capacitor c=1.06304e-16
C64 (\1\:VDD VSS) capacitor c=3.83653e-17
C65 (\6\:Db VSS) capacitor c=6.56961e-17
C66 (\7\:VDD VSS) capacitor c=5.47932e-17
C67 (\9\:CKbb VSS) capacitor c=7.42978e-17
C68 (\4\:Db VSS) capacitor c=9.12862e-17
C69 (\4\:n20 VSS) capacitor c=6.13157e-17
C70 (\9\:VDD VSS) capacitor c=3.52365e-17
C71 (\9\:mout VSS) capacitor c=6.69154e-17
C72 (\6\:n30 VSS) capacitor c=5.91297e-17
C73 (\12\:VDD VSS) capacitor c=2.87066e-17
C74 (\14\:qbint VSS) capacitor c=7.55677e-17
C75 (\15\:CKb VSS) capacitor c=3.65383e-17
C76 (\1\:Q VSS) capacitor c=8.11633e-17
C77 (\3\:VDD VSS) capacitor c=9.85218e-17
C78 (\7\:SEb VSS) capacitor c=6.87153e-17
C79 (\15\:CKbb VSS) capacitor c=5.92902e-17
C80 (\8\:Db VSS) capacitor c=7.23922e-17
C81 (\8\:n20 VSS) capacitor c=6.66301e-17
C82 (\7\:mout VSS) capacitor c=5.96049e-17
C83 (\8\:n30 VSS) capacitor c=8.92952e-17
C84 (\16\:qbint VSS) capacitor c=7.57636e-17
C85 (\18\:CKb VSS) capacitor c=8.97571e-17
C86 (\3\:Q VSS) capacitor c=1.5202e-17
C87 (\9\:qbint VSS) capacitor c=2.45183e-17
C88 (\2\:CKb VSS) capacitor c=4.31786e-17
C89 (\2\:mout VSS) capacitor c=3.33344e-17
C90 (\6\:CKb VSS) capacitor c=7.5044e-17
C91 (\7\:CKb VSS) capacitor c=6.9748e-17
C92 (\2\:D VSS) capacitor c=2.49828e-17
C93 (\4\:CK VSS) capacitor c=7.24612e-17
C94 (\12\:qbint VSS) capacitor c=6.77187e-17
C95 (\13\:qbint VSS) capacitor c=6.07745e-17
C96 (\18\:qbint VSS) capacitor c=9.50368e-17
C97 (\4\:n30 VSS) capacitor c=7.30885e-17
C98 (\5\:n30 VSS) capacitor c=9.07728e-17
C99 (\5\:mout VSS) capacitor c=5.13199e-17
C100 (\6\:mout VSS) capacitor c=4.82668e-17
C101 (\12\:CKb VSS) capacitor c=5.43264e-17
C102 (\13\:CKb VSS) capacitor c=1.43553e-16
C103 (\14\:CKb VSS) capacitor c=1.42582e-16
C104 (\17\:CKb VSS) capacitor c=8.11055e-17
C105 (\6\:n20 VSS) capacitor c=7.25046e-17
C106 (\7\:n20 VSS) capacitor c=6.65653e-17
C107 (\11\:CKbb VSS) capacitor c=1.29191e-16
C108 (\12\:CKbb VSS) capacitor c=7.69544e-17
C109 (\13\:CKbb VSS) capacitor c=1.27966e-16
C110 (\14\:CKbb VSS) capacitor c=1.33147e-16
C111 (\17\:CKbb VSS) capacitor c=4.68611e-17
C112 (\18\:CKbb VSS) capacitor c=6.10134e-17
C113 (\5\:D VSS) capacitor c=5.46774e-17
C114 (\3\:Db VSS) capacitor c=1.48264e-16
C115 (\8\:SE VSS) capacitor c=1.44649e-17
C116 (\9\:SE VSS) capacitor c=1.20918e-16
C117 (\10\:SE VSS) capacitor c=5.65479e-17
C118 (\11\:SE VSS) capacitor c=9.86258e-17
C119 (\4\:SEb VSS) capacitor c=9.19403e-17
C120 (\5\:VDD VSS) capacitor c=3.39158e-17
C121 (\11\:VDD VSS) capacitor c=2.85755e-17
Rk29 (\5\:D D) resistor r=0.1122 c=0
Rk1 (\2\:Q Q) resistor r=0.2051 c=0
Rk2 (Q \4\:Q) resistor r=0.166 c=0
Rk3 (\4\:CK CK) resistor r=0.1297 c=0
Rk35 (\8\:SE \9\:SE) resistor r=0.04037 c=0
Rk36 (\9\:SE \10\:SE) resistor r=0.4299 c=0
Rk38 (\11\:SE SE) resistor r=0.004282 c=0
Rk37 (\9\:SE \11\:SE) resistor r=0.6809 c=0
Rk56 (\2\:VDD \4\:VDD) resistor r=0.3008 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.3482 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.6546 c=0
Rk59 (\5\:VDD \8\:VDD) resistor r=0.3102 c=0
Rk60 (\6\:VDD \10\:VDD) resistor r=0.2882 c=0
Rk61 (\6\:VDD \11\:VDD) resistor r=0.6164 c=0
Rk62 (\11\:VDD \13\:VDD) resistor r=0.2266 c=0
Rk64 (\14\:VDD VDD) resistor r=0.08252 c=0
Rk63 (\11\:VDD \14\:VDD) resistor r=0.3357 c=0
Rk34 (\4\:SI SI) resistor r=0.003482 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1677 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.4307 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.05244 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.5487 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.3031 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3532 c=0
Rk48 (\9\:VSS VSS) resistor r=0.08252 c=0
Rk47 (\8\:VSS \9\:VSS) resistor r=0.3482 c=0
Rk51 (\3\:VSS \14\:VSS) resistor r=0.2067 c=0
Rk52 (\4\:VSS \16\:VSS) resistor r=0.2111 c=0
Rk53 (\6\:VSS \18\:VSS) resistor r=0.1222 c=0
Rk54 (\8\:VSS \20\:VSS) resistor r=0.237 c=0
Rk4 (\12\:qbint \13\:qbint) resistor r=0.3074 c=0
Rk5 (\13\:qbint \15\:qbint) resistor r=0.3138 c=0
Rk6 (\13\:qbint \17\:qbint) resistor r=0.05799 c=0
Rk7 (\17\:qbint \18\:qbint) resistor r=0.7082 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.2506 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.9254 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.1459 c=0
Rk17 (\13\:CKb \17\:CKb) resistor r=0.6495 c=0
Rk18 (\14\:CKb \19\:CKb) resistor r=0.4111 c=0
Rk8 (\4\:n30 \5\:n30) resistor r=0.3724 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.1741 c=0
Rk10 (\5\:n30 \9\:n30) resistor r=0.5381 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.241 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1153 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2348 c=0
Rk22 (\10\:CKbb \11\:CKbb) resistor r=0.5667 c=0
Rk23 (\11\:CKbb \12\:CKbb) resistor r=0.3076 c=0
Rk24 (\12\:CKbb \13\:CKbb) resistor r=0.3291 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.858 c=0
Rk26 (\12\:CKbb \16\:CKbb) resistor r=0.2753 c=0
Rk27 (\13\:CKbb \17\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \18\:CKbb) resistor r=0.2539 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1934 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3963 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2531 c=0
Rk30 (\2\:Db \3\:Db) resistor r=0.6822 c=0
Rk31 (\3\:Db \5\:Db) resistor r=0.3925 c=0
Rk32 (\3\:Db \7\:Db) resistor r=0.3379 c=0
Rk33 (\5\:Db \9\:Db) resistor r=0.3871 c=0
Rk39 (\4\:SEb \6\:SEb) resistor r=0.649 c=0
Rk40 (\6\:SEb \8\:SEb) resistor r=0.5281 c=0
Rl32 (\1\:D \2\:D) resistor r=101.637 c=0
Rl34 (\2\:D \4\:D) resistor r=59.3295 c=0
Rl33 (\2\:D \3\:D) resistor r=8.3038 c=0
Rl8 (\2\:CK \3\:CK) resistor r=52.6149 c=0
Rl7 (\1\:CK \2\:CK) resistor r=96.1338 c=0
Rl42 (\6\:SE \7\:SE) resistor r=39.5604 c=0
Rl41 (\5\:SE \6\:SE) resistor r=105.769 c=0
Rl38 (\3\:SE \4\:SE) resistor r=29.4849 c=0
Rl35 (\1\:SE \2\:SE) resistor r=48.7687 c=0
Rl40 (\2\:SI \3\:SI) resistor r=48.0541 c=0
Rl39 (\1\:SI \2\:SI) resistor r=99.7951 c=0
Rl5 (qbint \6\:qbint) resistor r=9.5287 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=49.7141 c=0
Rl13 (\9\:qbint \11\:qbint) resistor r=84.3295 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl16 (CKb \2\:CKb) resistor r=37.675 c=0
Rl18 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl17 (\2\:CKb \3\:CKb) resistor r=178.39 c=0
Rl30 (\6\:CKb \10\:CKb) resistor r=199.259 c=0
Rl26 (\5\:CKb \6\:CKb) resistor r=76.0085 c=0
Rl28 (\7\:CKb \8\:CKb) resistor r=143.774 c=0
Rl31 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl27 (\6\:CKb \7\:CKb) resistor r=198.915 c=0
Rl9 (n30 \2\:n30) resistor r=84.6154 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=33.7912 c=0
Rl21 (mout \2\:mout) resistor r=99.7141 c=0
Rl23 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl22 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=39.6174 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl15 (\3\:CKbb \4\:CKbb) resistor r=33.8482 c=0
Rl14 (CKbb \2\:CKbb) resistor r=37.6944 c=0
Rl19 (n20 \2\:n20) resistor r=29.5379 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=87.2302 c=0
Rl36 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=131.73 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz18 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz19 (\14\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz12 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\17\:qbint \16\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \7\:VDD) resistor r=31 c=0
Ry17 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry18 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\5\:VSS \1\:VSS) resistor r=6.2 c=0
Ry13 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry14 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry2 (\15\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\6\:n30 \7\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=20.6667 c=0
Ry10 (\5\:SEb \6\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\4\:SE \8\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\6\:SE \11\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx3 (\18\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn55 (\3\:Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.73654e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\18\:CKb \1\:CK VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.567e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\16\:qbint n30 \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.382e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=8.61e-14 ps=1.18e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=9.95e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn50 (net391 \11\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.382e-14 ad=5.432e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\8\:n30 \3\:CKb net391 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=4.51e-14 ps=9.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=1.725e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=8.61e-14 ps=8.5e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.46e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (net378 \4\:mout \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=1.435e-14 ps=1.18e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=7.3e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=6.15e-07 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn25 (\8\:n20 \11\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=5.228e-14 ps=1.04e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn21 (\15\:CKbb \5\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10552e-06 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn11 (net399 \4\:D \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=7.67e-14 ps=8.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=1.07942e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=7.39423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.69e-14 ad=4.16e-14 ps=6.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.81635e-07 sb=5.34423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn13 (net411 \1\:SI \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=1.69e-14 ps=1.33e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91635e-07 sb=4.24423e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(1)
mn10 (\7\:SEb \5\:SE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.482e-14 ad=2.9e-14 ps=1.33e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25569e-06 sb=2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mp20 (\15\:CKb \3\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.3324 \
        scb=0.00994664 scc=0.000204208 m=(1)
mp45 (\14\:qbint \3\:n30 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.1e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp50 (net334 \8\:qbint \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.1e-14 ad=5.27e-14 ps=1.44e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.92871e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\6\:n30 CKbb net334 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.765e-14 ps=9.6e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.71597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\6\:n30 \4\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.302e-13 ad=9.765e-14 ps=1.46e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.35597e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\9\:mout n20 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.302e-13 ps=1.38e-06 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=8.90968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net319 mout \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.045e-14 ps=1.38e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=6.25968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.58e-14 ps=1.01e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=3.85968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:Db \7\:CKbb \4\:n20 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.99e-14 ps=9.8e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.60968e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\9\:CKbb \10\:CKb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.05465e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp11 (net342 \1\:D \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.85833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (\6\:Db \1\:SE net342 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.59551e-07 sb=7.95833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp14 (\6\:Db SEb net350 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.84551e-07 sb=5.70833e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (net350 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=5.265e-14 ps=1.6e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.64551e-07 sb=3.90833e-07 sd=160n sca=16.239 \
        scb=0.0143727 scc=0.00110279 m=(1)
mp10 (\5\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1265e-13 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23372e-06 sb=1.4e-07 sd=160n sca=25.6683 \
        scb=0.0269847 scc=0.00206824 m=(1)
ends SDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:24:21 2012 )
// Library name: gsclib045
// Cell name: SDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFHQX4 CK D Q SE SI VDD VSS
mp20 (\14\:CKb \4\:CK \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.8563 scb=0.0365862 \
        scc=0.0028968 m=(1)
C1 (D VSS) capacitor c=5.34416e-17
C2 (CK VSS) capacitor c=6.7592e-17
C3 (Q VSS) capacitor c=1.89106e-16
C4 (SE VSS) capacitor c=6.31725e-17
C5 (VDD VSS) capacitor c=3.30425e-16
C6 (SI VSS) capacitor c=1.01637e-16
C7 (CKb VSS) capacitor c=2.26939e-17
C8 (qbint VSS) capacitor c=3.01232e-16
C9 (n30 VSS) capacitor c=1.82769e-16
C10 (net391 VSS) capacitor c=5.33374e-18
C11 (mout VSS) capacitor c=6.81624e-17
C12 (CKbb VSS) capacitor c=4.78294e-17
C13 (n20 VSS) capacitor c=3.85698e-17
C14 (net378 VSS) capacitor c=1.08109e-18
C15 (Db VSS) capacitor c=8.38159e-17
C16 (net399 VSS) capacitor c=6.57884e-18
C17 (SEb VSS) capacitor c=4.29579e-17
C18 (net334 VSS) capacitor c=5.48591e-18
C19 (net319 VSS) capacitor c=2.64832e-18
C20 (net342 VSS) capacitor c=1.75166e-18
C21 (net350 VSS) capacitor c=4.24869e-18
C22 (\5\:SE VSS) capacitor c=4.42466e-17
C23 (\3\:SI VSS) capacitor c=5.39846e-17
C24 (\2\:SE VSS) capacitor c=7.17313e-17
C25 (\1\:D VSS) capacitor c=8.84837e-17
C26 (\5\:CKb VSS) capacitor c=6.48657e-17
C27 (\7\:CKbb VSS) capacitor c=3.96514e-17
C28 (\8\:CKb VSS) capacitor c=5.76856e-17
C29 (\4\:CKb VSS) capacitor c=2.71594e-17
C30 (\14\:qbint VSS) capacitor c=6.36695e-17
C31 (\4\:CK VSS) capacitor c=3.71103e-17
C32 (\7\:SE VSS) capacitor c=3.22595e-17
C33 (\1\:SI VSS) capacitor c=8.49824e-17
C34 (\3\:SE VSS) capacitor c=7.00365e-17
C35 (\3\:SEb VSS) capacitor c=5.91962e-17
C36 (\4\:D VSS) capacitor c=4.16112e-17
C37 (\10\:CKb VSS) capacitor c=2.52801e-17
C38 (\11\:CKb VSS) capacitor c=2.46091e-17
C39 (\5\:CKbb VSS) capacitor c=4.379e-17
C40 (\4\:mout VSS) capacitor c=4.38761e-17
C41 (\3\:n20 VSS) capacitor c=4.5498e-17
C42 (\3\:CKbb VSS) capacitor c=3.02372e-17
C43 (\3\:CKb VSS) capacitor c=5.11864e-17
C44 (\17\:qbint VSS) capacitor c=2.94429e-17
C45 (\3\:CK VSS) capacitor c=2.96838e-17
C46 (\6\:SE VSS) capacitor c=3.56635e-17
C47 (\2\:SI VSS) capacitor c=5.76235e-17
C48 (\4\:SE VSS) capacitor c=4.31807e-17
C49 (\1\:SE VSS) capacitor c=4.75129e-17
C50 (\3\:D VSS) capacitor c=3.16702e-17
C51 (\8\:CKbb VSS) capacitor c=3.79749e-17
C52 (\9\:CKb VSS) capacitor c=2.90483e-17
C53 (\6\:CKbb VSS) capacitor c=3.87894e-17
C54 (\3\:mout VSS) capacitor c=1.618e-17
C55 (\2\:n20 VSS) capacitor c=3.8782e-17
C56 (\4\:CKbb VSS) capacitor c=3.63133e-17
C57 (\2\:CKbb VSS) capacitor c=4.59307e-17
C58 (\16\:qbint VSS) capacitor c=2.97465e-17
C59 (\1\:CK VSS) capacitor c=2.61002e-17
C60 (\7\:SEb VSS) capacitor c=9.30488e-17
C61 (\1\:VDD VSS) capacitor c=3.2305e-17
C62 (\4\:Db VSS) capacitor c=6.67079e-17
C63 (\15\:VDD VSS) capacitor c=3.38837e-17
C64 (\9\:CKbb VSS) capacitor c=8.41114e-17
C65 (\6\:Db VSS) capacitor c=1.25699e-16
C66 (\4\:n20 VSS) capacitor c=5.868e-17
C67 (\17\:VDD VSS) capacitor c=3.29441e-17
C68 (\9\:mout VSS) capacitor c=6.30943e-17
C69 (\11\:n30 VSS) capacitor c=5.63104e-17
C70 (\18\:qbint VSS) capacitor c=4.8374e-17
C71 (\14\:CKb VSS) capacitor c=2.25251e-16
C72 (\3\:VDD VSS) capacitor c=1.20946e-16
C73 (\5\:SEb VSS) capacitor c=4.88925e-17
C74 (\15\:CKbb VSS) capacitor c=5.67017e-17
C75 (\8\:Db VSS) capacitor c=7.30232e-17
C76 (\8\:n20 VSS) capacitor c=6.62503e-17
C77 (\7\:mout VSS) capacitor c=4.87607e-17
C78 (\7\:n30 VSS) capacitor c=6.00855e-17
C79 (\23\:qbint VSS) capacitor c=2.429e-17
C80 (\16\:CKb VSS) capacitor c=4.30312e-17
C81 (\2\:CK VSS) capacitor c=1.82014e-17
C82 (\15\:qbint VSS) capacitor c=2.50108e-17
C83 (\2\:CKb VSS) capacitor c=5.55847e-17
C84 (\2\:mout VSS) capacitor c=3.64582e-17
C85 (\6\:CKb VSS) capacitor c=5.15939e-17
C86 (\7\:CKb VSS) capacitor c=5.3565e-17
C87 (\2\:D VSS) capacitor c=3.57038e-17
C88 (\2\:SEb VSS) capacitor c=5.68036e-17
C89 (\5\:CK VSS) capacitor c=5.77103e-17
C90 (\20\:qbint VSS) capacitor c=2.42396e-17
C91 (\21\:qbint VSS) capacitor c=4.09929e-17
C92 (\22\:qbint VSS) capacitor c=1.42324e-17
C93 (\25\:qbint VSS) capacitor c=4.78171e-17
C94 (\9\:n30 VSS) capacitor c=8.14931e-17
C95 (\10\:n30 VSS) capacitor c=5.0766e-17
C96 (\5\:mout VSS) capacitor c=4.98762e-17
C97 (\6\:mout VSS) capacitor c=5.61253e-17
C98 (\12\:CKb VSS) capacitor c=5.15258e-17
C99 (\13\:CKb VSS) capacitor c=2.3528e-16
C100 (\18\:CKb VSS) capacitor c=7.76845e-17
C101 (\6\:n20 VSS) capacitor c=6.57831e-17
C102 (\7\:n20 VSS) capacitor c=6.57543e-17
C103 (\11\:CKbb VSS) capacitor c=1.41121e-16
C104 (\12\:CKbb VSS) capacitor c=7.68733e-17
C105 (\13\:CKbb VSS) capacitor c=1.1084e-16
C106 (\14\:CKbb VSS) capacitor c=1.02102e-16
C107 (\17\:CKbb VSS) capacitor c=5.45126e-17
C108 (\18\:CKbb VSS) capacitor c=6.09275e-17
C109 (\5\:D VSS) capacitor c=6.14338e-17
C110 (\3\:Db VSS) capacitor c=1.26934e-16
C111 (\9\:SE VSS) capacitor c=5.42778e-17
C112 (\10\:SE VSS) capacitor c=7.82043e-17
C113 (\9\:SEb VSS) capacitor c=8.8464e-17
C114 (\5\:VDD VSS) capacitor c=1.00818e-17
C115 (\7\:VDD VSS) capacitor c=2.86579e-17
C116 (\9\:VDD VSS) capacitor c=1.63872e-16
Rk31 (\5\:D D) resistor r=0.1545 c=0
Rk1 (CK \5\:CK) resistor r=0.1707 c=0
Rk38 (SE \8\:SE) resistor r=0.003095 c=0
Rk39 (\8\:SE \9\:SE) resistor r=0.2335 c=0
Rk40 (\9\:SE \10\:SE) resistor r=0.3245 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.3134 c=0
Rk60 (\4\:VDD \5\:VDD) resistor r=0.2905 c=0
Rk61 (\5\:VDD \6\:VDD) resistor r=0.1602 c=0
Rk62 (\6\:VDD \7\:VDD) resistor r=0.5111 c=0
Rk63 (\7\:VDD \8\:VDD) resistor r=0.2404 c=0
Rk69 (\9\:VDD VDD) resistor r=0.1003 c=0
Rk64 (\8\:VDD \9\:VDD) resistor r=0.3607 c=0
Rk71 (\5\:VDD \16\:VDD) resistor r=0.2396 c=0
Rk72 (\7\:VDD \18\:VDD) resistor r=0.1619 c=0
Rk37 (\4\:SI SI) resistor r=0.007054 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.09003 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.4616 c=0
Rk45 (\3\:VSS \6\:VSS) resistor r=0.2894 c=0
Rk46 (\4\:VSS \7\:VSS) resistor r=0.5812 c=0
Rk47 (\7\:VSS \8\:VSS) resistor r=0.471 c=0
Rk52 (\9\:VSS VSS) resistor r=0.1507 c=0
Rk48 (\8\:VSS \9\:VSS) resistor r=0.1602 c=0
Rk53 (\4\:VSS \14\:VSS) resistor r=0.3621 c=0
Rk54 (\7\:VSS \16\:VSS) resistor r=0.1253 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2989 c=0
Rk18 (\13\:CKb \15\:CKb) resistor r=1.7741 c=0
Rk19 (\15\:CKb \17\:CKb) resistor r=0.392 c=0
Rk20 (\13\:CKb \18\:CKb) resistor r=0.5387 c=0
Rk6 (\19\:qbint \20\:qbint) resistor r=0.3027 c=0
Rk7 (\20\:qbint \21\:qbint) resistor r=0.2096 c=0
Rk8 (\20\:qbint \22\:qbint) resistor r=0.07797 c=0
Rk9 (\22\:qbint \24\:qbint) resistor r=0.07084 c=0
Rk10 (\22\:qbint \25\:qbint) resistor r=0.1852 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.4493 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.2117 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.3038 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.2333 c=0
Rk15 (\6\:mout \8\:mout) resistor r=0.1994 c=0
Rk16 (\6\:mout \10\:mout) resistor r=0.2599 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.6608 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.3715 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.2829 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.8171 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.3533 c=0
Rk29 (\13\:CKbb \17\:CKbb) resistor r=0.2213 c=0
Rk30 (\14\:CKbb \18\:CKbb) resistor r=0.2549 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.171 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3369 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.286 c=0
Rk32 (\2\:Db \3\:Db) resistor r=0.6566 c=0
Rk33 (\3\:Db \5\:Db) resistor r=0.1478 c=0
Rk34 (\3\:Db \7\:Db) resistor r=0.5202 c=0
Rk35 (\7\:Db \9\:Db) resistor r=0.3715 c=0
Rk36 (\5\:Db \10\:Db) resistor r=0.1569 c=0
Rk41 (\6\:SEb \8\:SEb) resistor r=0.4631 c=0
Rk42 (\8\:SEb \9\:SEb) resistor r=0.533 c=0
Rl42 (\1\:D \2\:D) resistor r=50.8027 c=0
Rl44 (\2\:D \4\:D) resistor r=98.8796 c=0
Rl43 (\2\:D \3\:D) resistor r=12.2499 c=0
Rl3 (\2\:CK \4\:CK) resistor r=82.4064 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.3295 c=0
Rl1 (\1\:CK \2\:CK) resistor r=3.5213 c=0
Rl52 (\5\:SE \6\:SE) resistor r=104.538 c=0
Rl53 (\6\:SE \7\:SE) resistor r=39.1533 c=0
Rl49 (\3\:SE \4\:SE) resistor r=28.079 c=0
Rl45 (\1\:SE \2\:SE) resistor r=37.7189 c=0
Rl51 (\2\:SI \3\:SI) resistor r=43.6813 c=0
Rl50 (\1\:SI \2\:SI) resistor r=92.3077 c=0
Rl39 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl26 (CKb \2\:CKb) resistor r=84.5407 c=0
Rl28 (\2\:CKb \4\:CKb) resistor r=30.4507 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=145.697 c=0
Rl36 (\5\:CKb \6\:CKb) resistor r=185.338 c=0
Rl40 (\6\:CKb \10\:CKb) resistor r=47.3105 c=0
Rl38 (\7\:CKb \8\:CKb) resistor r=170.697 c=0
Rl41 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl37 (\6\:CKb \7\:CKb) resistor r=214.3 c=0
Rl21 (\15\:qbint \14\:qbint) resistor r=103.56 c=0
Rl23 (\15\:qbint \17\:qbint) resistor r=34.3295 c=0
Rl22 (\15\:qbint \16\:qbint) resistor r=11.4953 c=0
Rl31 (mout \2\:mout) resistor r=98.8796 c=0
Rl33 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl32 (\2\:mout \3\:mout) resistor r=1.2301 c=0
Rl35 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl25 (\3\:CKbb \4\:CKbb) resistor r=33.3841 c=0
Rl24 (CKbb \2\:CKbb) resistor r=41.0764 c=0
Rl29 (n20 \2\:n20) resistor r=26.098 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl46 (SEb \2\:SEb) resistor r=67.4757 c=0
Rl47 (\2\:SEb \3\:SEb) resistor r=147.664 c=0
Rl48 (\2\:SEb \4\:SEb) resistor r=1.2666 c=0
Rz24 (VDD \3\:VDD) resistor r=75 c=0
Rz19 (\4\:VDD \3\:VDD) resistor r=12.5 c=0
Rz20 (\6\:VDD \3\:VDD) resistor r=25 c=0
Rz21 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz23 (\9\:VDD \3\:VDD) resistor r=15 c=0
Rz12 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz6 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz3 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\4\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry15 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\19\:qbint \18\:qbint) resistor r=62 c=0
Ry4 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:Db \5\:Db) resistor r=62 c=0
Ry10 (\6\:Db \7\:Db) resistor r=62 c=0
Ry11 (\4\:Db \10\:Db) resistor r=62 c=0
Ry12 (\7\:SEb \8\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx15 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\1\:SE \10\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx6 (CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \18\:CKb) resistor r=45 c=0
Rx2 (\21\:qbint qbint) resistor r=45 c=0
Rx3 (\25\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx9 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx8 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \9\:SEb) resistor r=45 c=0
mn20 (\16\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.7e-14 ad=4.81e-14 ps=9e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.74721e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mn45_1__rcx (\23\:qbint n30 \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.273e-14 ad=3.28e-14 ps=8.55e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16317e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn50 (net391 \17\:qbint \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.51e-14 ad=3.28e-14 ps=8.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63317e-06 sb=1.94e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\7\:n30 \3\:CKb net391 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=4.92e-14 ps=7.3e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83817e-06 sb=1.735e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:mout \3\:CKbb \7\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=8.2e-14 ps=8.9e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.45e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=8.2e-14 ps=1.32e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net378 \4\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=2.358e-14 ps=1.32e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.4e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=4.51e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.8e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:n20 \11\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.51e-14 ps=1.04e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn21 (\15\:CKbb \10\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.485e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net399 \4\:D \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=9.8e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75673e-07 sb=8.70673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.60673e-07 sb=5.85673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65673e-07 sb=3.80673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net411 \1\:SI \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70673e-07 sb=2.75673e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\5\:SEb \7\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.045e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16069e-06 sb=2.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp55_1__rcx (Q qbint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=6.24e-14 ps=1.605e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.40577e-07 sb=1.76308e-06 sd=160n sca=18.6093 \
        scb=0.0174808 scc=0.00104939 m=(4)
mp45_1__rcx (\18\:qbint n30 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.96e-14 ad=4.96e-14 ps=1.55e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21685e-06 sb=2e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(2)
mp50 (net334 \14\:qbint \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.76e-14 ad=3.875e-14 ps=1.55e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68685e-06 sb=1.78685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp51 (\11\:n30 CKbb net334 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85685e-06 sb=1.61685e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp40 (\11\:n30 \4\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.5965e-13 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.41185e-06 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp30 (\9\:mout n20 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=1.5965e-13 ps=1.45e-06 pd=1.65e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.51855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp35 (net319 mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.16e-14 ad=4.495e-14 ps=1.45e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.86855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=5.58e-14 ps=9.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.96855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp25 (\6\:Db \7\:CKbb \4\:n20 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=5.328e-14 ps=9.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.71855e-07 sd=160n sca=16.8851 \
        scb=0.0157945 scc=0.0012748 m=(1)
mp21 (\9\:CKbb \5\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.17093e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp11 (net342 \1\:D \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.14359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp12 (\4\:Db \2\:SE net342 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.09359e-07 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(1)
mp14 (\4\:Db SEb net350 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=7.02e-14 ps=1.07e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.84359e-07 sd=160n sca=15.6414 \
        scb=0.0138242 scc=0.000948215 m=(1)
mp13 (net350 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=5.655e-14 ps=1.25e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.55064e-07 sb=2.94359e-07 sd=160n sca=16.7327 \
        scb=0.0148635 scc=0.000950884 m=(1)
mp10 (\7\:SEb \5\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.503e-14 ad=3.01e-14 ps=1.25e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45581e-07 sb=1.4e-07 sd=160n sca=26.9589 \
        scb=0.0303196 scc=0.00206685 m=(1)
ends SDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:24:59 2012 )
// Library name: gsclib045
// Cell name: SDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFHQX8 CK D Q SE SI VDD VSS
mp55_1__rcx (Q qbint \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.271e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.92213e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D VSS) capacitor c=6.44793e-17
C2 (CK VSS) capacitor c=7.56189e-17
C3 (SE VSS) capacitor c=4.48235e-17
C4 (VDD VSS) capacitor c=2.96924e-16
C5 (Q VSS) capacitor c=4.96309e-16
C6 (SI VSS) capacitor c=5.28077e-17
C7 (qbint VSS) capacitor c=3.63125e-16
C8 (n30 VSS) capacitor c=2.0137e-16
C9 (CKb VSS) capacitor c=4.68954e-17
C10 (net391 VSS) capacitor c=2.75049e-18
C11 (mout VSS) capacitor c=6.58911e-17
C12 (CKbb VSS) capacitor c=2.503e-17
C13 (n20 VSS) capacitor c=3.87573e-17
C14 (net378 VSS) capacitor c=1.12961e-18
C15 (Db VSS) capacitor c=9.71031e-17
C16 (net399 VSS) capacitor c=5.74422e-18
C17 (SEb VSS) capacitor c=3.45398e-17
C18 (net334 VSS) capacitor c=3.48222e-18
C19 (net319 VSS) capacitor c=3.30937e-18
C20 (net342 VSS) capacitor c=1.73603e-18
C21 (net350 VSS) capacitor c=7.01633e-18
C22 (\8\:SE VSS) capacitor c=4.83304e-17
C23 (\1\:SI VSS) capacitor c=5.11311e-17
C24 (\2\:SE VSS) capacitor c=7.17901e-17
C25 (\4\:D VSS) capacitor c=9.24691e-17
C26 (\10\:CKb VSS) capacitor c=6.15941e-17
C27 (\7\:CKbb VSS) capacitor c=3.78504e-17
C28 (\8\:CKb VSS) capacitor c=3.96787e-17
C29 (\3\:CKb VSS) capacitor c=2.40718e-17
C30 (\3\:CKbb VSS) capacitor c=6.54663e-17
C31 (\22\:qbint VSS) capacitor c=4.87132e-17
C32 (\1\:CK VSS) capacitor c=3.2684e-17
C33 (\7\:SE VSS) capacitor c=3.1088e-17
C34 (\3\:SI VSS) capacitor c=7.97902e-17
C35 (\3\:SE VSS) capacitor c=7.00577e-17
C36 (\3\:SEb VSS) capacitor c=6.75249e-17
C37 (\1\:D VSS) capacitor c=4.68776e-17
C38 (\5\:CKb VSS) capacitor c=2.57088e-17
C39 (\11\:CKb VSS) capacitor c=2.5299e-17
C40 (\5\:CKbb VSS) capacitor c=6.02422e-17
C41 (\4\:mout VSS) capacitor c=5.83414e-17
C42 (\3\:n20 VSS) capacitor c=4.54417e-17
C43 (\24\:qbint VSS) capacitor c=5.82509e-17
C44 (\3\:CK VSS) capacitor c=3.64996e-17
C45 (\5\:SE VSS) capacitor c=1.69852e-17
C46 (\2\:SI VSS) capacitor c=4.72656e-17
C47 (\4\:SE VSS) capacitor c=4.39177e-17
C48 (\2\:SEb VSS) capacitor c=5.17593e-17
C49 (\1\:SE VSS) capacitor c=5.5647e-17
C50 (\3\:D VSS) capacitor c=2.93562e-17
C51 (\8\:CKbb VSS) capacitor c=4.1696e-17
C52 (\9\:CKb VSS) capacitor c=2.73525e-17
C53 (\6\:CKbb VSS) capacitor c=3.98525e-17
C54 (\3\:mout VSS) capacitor c=1.73126e-17
C55 (\2\:n20 VSS) capacitor c=3.51673e-17
C56 (\4\:CKbb VSS) capacitor c=2.5985e-17
C57 (\4\:CKb VSS) capacitor c=3.7326e-17
C58 (\2\:CKb VSS) capacitor c=3.89957e-17
C59 (\23\:qbint VSS) capacitor c=4.73342e-17
C60 (\2\:CK VSS) capacitor c=3.19215e-17
C61 (\6\:SEb VSS) capacitor c=1.11895e-16
C62 (\1\:VDD VSS) capacitor c=2.78983e-17
C63 (\8\:Db VSS) capacitor c=5.02858e-17
C64 (\16\:VDD VSS) capacitor c=4.1642e-17
C65 (\15\:CKbb VSS) capacitor c=8.05496e-17
C66 (\4\:Db VSS) capacitor c=1.12748e-16
C67 (\4\:n20 VSS) capacitor c=6.06092e-17
C68 (\18\:VDD VSS) capacitor c=3.50566e-17
C69 (\9\:mout VSS) capacitor c=5.79449e-17
C70 (\14\:n30 VSS) capacitor c=1.09135e-16
C71 (\20\:VDD VSS) capacitor c=1.03068e-17
C72 (\18\:CKb VSS) capacitor c=1.03494e-16
C73 (\26\:qbint VSS) capacitor c=3.76922e-16
C74 (\3\:VDD VSS) capacitor c=1.29631e-16
C75 (\4\:SEb VSS) capacitor c=8.99442e-17
C76 (\9\:CKbb VSS) capacitor c=6.43183e-17
C77 (\6\:Db VSS) capacitor c=7.68061e-17
C78 (\8\:n20 VSS) capacitor c=7.05413e-17
C79 (\7\:mout VSS) capacitor c=5.25977e-17
C80 (\12\:n30 VSS) capacitor c=2.09147e-16
C81 (\15\:CKb VSS) capacitor c=1.54372e-16
C82 (\2\:CKbb VSS) capacitor c=4.83315e-17
C83 (\2\:mout VSS) capacitor c=3.63156e-17
C84 (\6\:CKb VSS) capacitor c=6.35927e-17
C85 (\7\:CKb VSS) capacitor c=6.53101e-17
C86 (\2\:D VSS) capacitor c=4.58936e-17
C87 (\6\:SE VSS) capacitor c=2.50977e-17
C88 (\4\:CK VSS) capacitor c=3.80823e-17
C89 (\25\:qbint VSS) capacitor c=1.19277e-16
C90 (\31\:qbint VSS) capacitor c=3.49523e-17
C91 (\11\:n30 VSS) capacitor c=1.5533e-16
C92 (\5\:mout VSS) capacitor c=5.39584e-17
C93 (\6\:mout VSS) capacitor c=5.5928e-17
C94 (\12\:CKb VSS) capacitor c=5.31803e-17
C95 (\13\:CKb VSS) capacitor c=1.31025e-16
C96 (\14\:CKb VSS) capacitor c=1.59367e-16
C97 (\17\:CKb VSS) capacitor c=1.01634e-16
C98 (\6\:n20 VSS) capacitor c=7.46218e-17
C99 (\7\:n20 VSS) capacitor c=7.58195e-17
C100 (\11\:CKbb VSS) capacitor c=9.04386e-17
C101 (\12\:CKbb VSS) capacitor c=1.12123e-16
C102 (\13\:CKbb VSS) capacitor c=1.19223e-16
C103 (\14\:CKbb VSS) capacitor c=1.31347e-16
C104 (\17\:CKbb VSS) capacitor c=6.76507e-17
C105 (\5\:D VSS) capacitor c=4.66694e-17
C106 (\3\:Db VSS) capacitor c=1.17544e-16
C107 (\4\:SI VSS) capacitor c=7.88508e-17
C108 (\9\:SE VSS) capacitor c=6.48937e-17
C109 (\10\:SE VSS) capacitor c=8.25297e-17
C110 (\11\:SE VSS) capacitor c=3.03312e-17
C111 (\8\:SEb VSS) capacitor c=8.57522e-17
C112 (\5\:VDD VSS) capacitor c=4.39476e-17
C113 (\7\:VDD VSS) capacitor c=1.73011e-17
C114 (\10\:VDD VSS) capacitor c=4.96581e-16
Rk42 (\5\:D D) resistor r=0.05403 c=0
Rk74 (\2\:VSS \4\:VSS) resistor r=0.4882 c=0
Rk75 (\4\:VSS \5\:VSS) resistor r=0.1829 c=0
Rk76 (\5\:VSS \6\:VSS) resistor r=0.6107 c=0
Rk77 (\6\:VSS \7\:VSS) resistor r=0.2572 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.3726 c=0
Rk85 (\9\:VSS VSS) resistor r=0.1024 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.4552 c=0
Rk86 (\5\:VSS \16\:VSS) resistor r=0.2341 c=0
Rk87 (\6\:VSS \18\:VSS) resistor r=0.04332 c=0
Rk88 (\8\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk14 (\4\:CK CK) resistor r=0.1318 c=0
Rk49 (\10\:SE SE) resistor r=0.3407 c=0
Rk48 (\9\:SE \10\:SE) resistor r=0.3756 c=0
Rk50 (SE \11\:SE) resistor r=0.03909 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.2684 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.3685 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5341 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.05749 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.564 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.2306 c=0
Rk65 (\10\:VDD VDD) resistor r=0.1024 c=0
Rk59 (\9\:VDD \10\:VDD) resistor r=0.2632 c=0
Rk66 (\5\:VDD \17\:VDD) resistor r=0.2268 c=0
Rk67 (\7\:VDD \19\:VDD) resistor r=0.2199 c=0
Rk68 (\8\:VDD \21\:VDD) resistor r=0.07405 c=0
Rk47 (\4\:SI SI) resistor r=0.0251 c=0
Rk15 (\25\:qbint \26\:qbint) resistor r=0.8718 c=0
Rk19 (\26\:qbint \31\:qbint) resistor r=0.1663 c=0
Rk23 (\11\:n30 \13\:n30) resistor r=1.2398 c=0
Rk24 (\13\:n30 \15\:n30) resistor r=0.4642 c=0
Rk28 (\12\:CKb \13\:CKb) resistor r=0.2504 c=0
Rk29 (\13\:CKb \14\:CKb) resistor r=0.687 c=0
Rk30 (\14\:CKb \16\:CKb) resistor r=0.637 c=0
Rk31 (\13\:CKb \17\:CKb) resistor r=0.7147 c=0
Rk32 (\16\:CKb \19\:CKb) resistor r=0.5734 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2281 c=0
Rk26 (\6\:mout \8\:mout) resistor r=0.193 c=0
Rk27 (\6\:mout \10\:mout) resistor r=0.2421 c=0
Rk36 (\10\:CKbb \11\:CKbb) resistor r=0.3958 c=0
Rk37 (\11\:CKbb \12\:CKbb) resistor r=0.2849 c=0
Rk38 (\12\:CKbb \13\:CKbb) resistor r=0.8474 c=0
Rk39 (\11\:CKbb \14\:CKbb) resistor r=0.3429 c=0
Rk40 (\14\:CKbb \16\:CKbb) resistor r=0.6275 c=0
Rk41 (\12\:CKbb \17\:CKbb) resistor r=0.2249 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.1647 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3859 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.3046 c=0
Rk43 (\2\:Db \3\:Db) resistor r=0.6476 c=0
Rk44 (\3\:Db \5\:Db) resistor r=0.4237 c=0
Rk45 (\5\:Db \7\:Db) resistor r=0.4045 c=0
Rk46 (\3\:Db \9\:Db) resistor r=0.2015 c=0
Rk51 (\5\:SEb \7\:SEb) resistor r=0.7143 c=0
Rk52 (\7\:SEb \8\:SEb) resistor r=0.5705 c=0
Rl54 (\2\:D \4\:D) resistor r=58.495 c=0
Rl52 (\1\:D \2\:D) resistor r=109.984 c=0
Rl53 (\2\:D \3\:D) resistor r=9.6183 c=0
Rl30 (\1\:CK \2\:CK) resistor r=96.1538 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl58 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl55 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl63 (\6\:SE \8\:SE) resistor r=121.957 c=0
Rl62 (\6\:SE \7\:SE) resistor r=46.9565 c=0
Rl61 (\5\:SE \6\:SE) resistor r=13.569 c=0
Rl59 (\1\:SI \2\:SI) resistor r=55.0021 c=0
Rl60 (\2\:SI \3\:SI) resistor r=85.7713 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=65.3618 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=80.5643 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=193.478 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=61.5164 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=41.9892 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=185.006 c=0
Rl41 (mout \2\:mout) resistor r=102.726 c=0
Rl43 (\2\:mout \4\:mout) resistor r=37.3411 c=0
Rl42 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=30.0021 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=37.2302 c=0
Rl36 (CKbb \2\:CKbb) resistor r=32.3738 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=138.005 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=92.233 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=94.9225 c=0
Rl56 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl57 (\2\:SEb \3\:SEb) resistor r=121.943 c=0
Rz19 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=12.5 c=0
Rz16 (\6\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=15 c=0
Rz18 (\10\:VDD \3\:VDD) resistor r=7.5 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\7\:mout \8\:mout) resistor r=75 c=0
Rz11 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\6\:Db \7\:Db) resistor r=75 c=0
Rz14 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry25 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\9\:mout \10\:mout) resistor r=62 c=0
Ry11 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=31 c=0
Ry14 (\6\:SEb \7\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\1\:SE \9\:SE) resistor r=45 c=0
Rx16 (\4\:SE \10\:SE) resistor r=45 c=0
Rx17 (\5\:SE \11\:SE) resistor r=45 c=0
Rx14 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\31\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\26\:qbint n30 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn50 (net391 \24\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.95e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\12\:n30 CKb net391 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=3.895e-14 ps=6.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.79e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\7\:mout CKbb \12\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.895e-14 ad=1.1377e-13 ps=7.9e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3378e-07 sb=1.555e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\7\:mout \3\:n20 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.63e-14 ad=1.1377e-13 ps=1.37e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43378e-06 sb=9.55e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (net378 \4\:mout \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.23e-14 ps=1.37e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69878e-06 sb=6.9e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\8\:n20 \11\:CKb \6\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94293e-06 sb=3.15e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (\8\:n20 \5\:CKbb net378 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.612e-14 ps=5.3e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80378e-06 sb=5.85e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn21 (\9\:CKbb \5\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.10759e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net399 \1\:D \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.94e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=7.98365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net399 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.06058e-07 sb=5.63365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net411 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.11058e-07 sb=3.58365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net411 \3\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.16058e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11448e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45_1__rcx (\26\:qbint n30 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.887e-14 ad=5.98e-14 ps=1.15667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.204e-13 ad=3.01e-14 ps=1.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.99814e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (net334 \22\:qbint \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.204e-13 ad=3.1e-14 ps=1.93e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67661e-07 sb=1.75185e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp51 (\14\:n30 \3\:CKbb net334 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.12661e-07 sb=1.60685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp40 (\14\:n30 \3\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.82661e-07 sb=1.33685e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp30 (\9\:mout n20 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25766e-06 sb=8.61855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp35 (net319 mout \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=4.805e-14 ps=1.38e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52266e-06 sb=5.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp36 (\4\:n20 \8\:CKb net319 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=5.58e-14 ps=9.3e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72266e-06 sb=3.96855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\4\:Db \7\:CKbb \4\:n20 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=5.328e-14 ps=9.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92339e-06 sb=1.71855e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp21 (\15\:CKbb \10\:CKb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp11 (net342 \4\:D \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\8\:Db \2\:SE net342 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\8\:Db SEb net350 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=13.6902 \
        scb=0.0122097 scc=0.000647516 m=(1)
mp13 (net350 \1\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=14.7912 \
        scb=0.012924 scc=0.00064842 m=(1)
mp10 (\6\:SEb \8\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=20.6301 \
        scb=0.0216347 scc=0.00118997 m=(1)
ends SDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:25:38 2012 )
// Library name: gsclib045
// Cell name: SDFFNSRX1
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX1 CKN D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:qint \32\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
C1 (Q VSS) capacitor c=6.66489e-17
C2 (SE VSS) capacitor c=4.19921e-17
C3 (SN VSS) capacitor c=2.94383e-16
C4 (SI VSS) capacitor c=7.38351e-17
C5 (QN VSS) capacitor c=2.29651e-17
C6 (VDD VSS) capacitor c=5.13562e-16
C7 (D VSS) capacitor c=1.41921e-16
C8 (RN VSS) capacitor c=9.1203e-17
C9 (qint VSS) capacitor c=2.10533e-17
C10 (qbint VSS) capacitor c=2.86599e-17
C11 (RNb VSS) capacitor c=7.31103e-17
C12 (n35 VSS) capacitor c=3.99133e-17
C13 (net498 VSS) capacitor c=9.19349e-17
C14 (net0363 VSS) capacitor c=7.31237e-17
C15 (CKNbb VSS) capacitor c=4.66426e-17
C16 (mout VSS) capacitor c=6.59707e-17
C17 (CKNb VSS) capacitor c=2.50352e-17
C18 (net521 VSS) capacitor c=7.88834e-17
C19 (n20 VSS) capacitor c=5.43304e-17
C20 (Db VSS) capacitor c=1.19409e-16
C21 (SEb VSS) capacitor c=6.07762e-17
C22 (net566 VSS) capacitor c=1.15288e-16
C23 (net414 VSS) capacitor c=1.07971e-18
C24 (net478 VSS) capacitor c=3.56466e-18
C25 (net486 VSS) capacitor c=6.62353e-19
C26 (net461 VSS) capacitor c=1.96861e-18
C27 (net453 VSS) capacitor c=1.92664e-18
C28 (\4\:SE VSS) capacitor c=5.83956e-17
C29 (\3\:SI VSS) capacitor c=7.81684e-17
C30 (\3\:SEb VSS) capacitor c=6.04665e-17
C31 (\3\:SE VSS) capacitor c=7.24255e-17
C32 (\1\:D VSS) capacitor c=3.53005e-17
C33 (\1\:CKN VSS) capacitor c=5.37338e-17
C34 (\8\:CKNb VSS) capacitor c=1.31531e-17
C35 (\9\:CKNb VSS) capacitor c=2.53729e-17
C36 (\6\:CKNbb VSS) capacitor c=6.00178e-17
C37 (\4\:SN VSS) capacitor c=5.75509e-17
C38 (\4\:RNb VSS) capacitor c=6.2749e-17
C39 (\4\:CKNbb VSS) capacitor c=3.41517e-17
C40 (\7\:CKNb VSS) capacitor c=5.96432e-17
C41 (\2\:RNb VSS) capacitor c=7.6789e-17
C42 (\7\:qbint VSS) capacitor c=9.5932e-17
C43 (\1\:SN VSS) capacitor c=3.38709e-17
C44 (\1\:RN VSS) capacitor c=4.02427e-17
C45 (\5\:qbint VSS) capacitor c=4.87568e-17
C46 (\6\:qbint VSS) capacitor c=2.83128e-17
C47 (\4\:qint VSS) capacitor c=4.44192e-17
C48 (\6\:SE VSS) capacitor c=3.31139e-17
C49 (\1\:SI VSS) capacitor c=6.35825e-17
C50 (\1\:SE VSS) capacitor c=3.65356e-17
C51 (\3\:D VSS) capacitor c=9.06224e-17
C52 (\3\:CKN VSS) capacitor c=3.8639e-17
C53 (\8\:CKNbb VSS) capacitor c=5.03837e-17
C54 (\5\:CKNb VSS) capacitor c=1.67589e-16
C55 (\4\:mout VSS) capacitor c=5.26497e-17
C56 (\6\:SN VSS) capacitor c=6.14735e-17
C57 (\3\:n20 VSS) capacitor c=3.81559e-17
C58 (\6\:RNb VSS) capacitor c=5.13695e-17
C59 (\6\:CKNb VSS) capacitor c=1.22153e-16
C60 (\8\:qbint VSS) capacitor c=5.64931e-17
C61 (\3\:SN VSS) capacitor c=5.9332e-17
C62 (\3\:n35 VSS) capacitor c=2.76437e-17
C63 (\3\:RN VSS) capacitor c=4.67047e-17
C64 (\4\:qbint VSS) capacitor c=2.67667e-17
C65 (\3\:qint VSS) capacitor c=3.44254e-17
C66 (\5\:SE VSS) capacitor c=5.97088e-17
C67 (\2\:SI VSS) capacitor c=7.06675e-17
C68 (\2\:SE VSS) capacitor c=7.569e-17
C69 (\4\:SEb VSS) capacitor c=4.48104e-17
C70 (\2\:SEb VSS) capacitor c=4.72038e-17
C71 (\2\:D VSS) capacitor c=6.13131e-17
C72 (\2\:CKN VSS) capacitor c=4.14662e-17
C73 (\9\:CKNbb VSS) capacitor c=3.42418e-17
C74 (\7\:CKNbb VSS) capacitor c=4.15704e-17
C75 (\3\:mout VSS) capacitor c=2.43506e-17
C76 (\5\:SN VSS) capacitor c=3.55747e-17
C77 (\2\:n20 VSS) capacitor c=3.66122e-17
C78 (\5\:CKNbb VSS) capacitor c=3.18881e-17
C79 (\5\:RNb VSS) capacitor c=1.91617e-17
C80 (\3\:CKNbb VSS) capacitor c=3.42027e-17
C81 (\2\:CKNbb VSS) capacitor c=3.1668e-17
C82 (\3\:RNb VSS) capacitor c=2.68216e-17
C83 (\9\:qbint VSS) capacitor c=2.68232e-17
C84 (\2\:SN VSS) capacitor c=4.26006e-17
C85 (\2\:n35 VSS) capacitor c=2.92258e-17
C86 (\2\:RN VSS) capacitor c=3.80476e-17
C87 (\2\:qbint VSS) capacitor c=3.60956e-17
C88 (\5\:SEb VSS) capacitor c=6.61474e-18
C89 (\9\:VDD VSS) capacitor c=3.54751e-17
C90 (\11\:VDD VSS) capacitor c=4.80515e-17
C91 (\10\:CKNb VSS) capacitor c=7.43198e-17
C92 (\13\:VDD VSS) capacitor c=7.08351e-17
C93 (\17\:CKNbb VSS) capacitor c=8.79125e-17
C94 (\8\:Db VSS) capacitor c=1.00912e-16
C95 (\4\:n20 VSS) capacitor c=7.84919e-17
C96 (\15\:VDD VSS) capacitor c=1.57919e-17
C97 (\11\:mout VSS) capacitor c=3.89677e-17
C98 (\17\:VDD VSS) capacitor c=2.40034e-17
C99 (\9\:mout VSS) capacitor c=8.12014e-17
C100 (\8\:n35 VSS) capacitor c=4.33685e-17
C101 (\20\:VDD VSS) capacitor c=3.85535e-17
C102 (\3\:net566 VSS) capacitor c=1.16206e-16
C103 (\24\:VDD VSS) capacitor c=6.81425e-17
C104 (\14\:qbint VSS) capacitor c=8.17921e-17
C105 (\9\:RNb VSS) capacitor c=1.94337e-16
C106 (\28\:VDD VSS) capacitor c=3.68344e-17
C107 (\1\:Q VSS) capacitor c=4.47534e-17
C108 (\5\:qint VSS) capacitor c=3.56946e-17
C109 (\32\:VDD VSS) capacitor c=5.95458e-17
C110 (\1\:QN VSS) capacitor c=4.79775e-17
C111 (\1\:VDD VSS) capacitor c=1.56848e-16
C112 (\10\:SEb VSS) capacitor c=7.50509e-17
C113 (\6\:Db VSS) capacitor c=2.01342e-17
C114 (\14\:CKNb VSS) capacitor c=4.68593e-17
C115 (\19\:CKNbb VSS) capacitor c=5.71836e-17
C116 (\4\:Db VSS) capacitor c=1.72223e-16
C117 (\7\:n20 VSS) capacitor c=3.6684e-17
C118 (\13\:mout VSS) capacitor c=3.58906e-17
C119 (\3\:net521 VSS) capacitor c=7.17276e-17
C120 (\15\:mout VSS) capacitor c=3.08328e-17
C121 (\4\:n35 VSS) capacitor c=4.08112e-17
C122 (\3\:net498 VSS) capacitor c=8.09926e-17
C123 (\3\:net0363 VSS) capacitor c=9.1464e-17
C124 (\11\:qbint VSS) capacitor c=1.52666e-16
C125 (\11\:RNb VSS) capacitor c=9.27392e-17
C126 (\3\:Q VSS) capacitor c=6.86877e-17
C127 (\9\:qint VSS) capacitor c=3.27489e-17
C128 (\3\:QN VSS) capacitor c=3.64453e-17
C129 (\2\:qint VSS) capacitor c=8.29322e-18
C130 (\3\:qbint VSS) capacitor c=3.10025e-17
C131 (\2\:mout VSS) capacitor c=3.76855e-17
C132 (\7\:qint VSS) capacitor c=2.83093e-17
C133 (\8\:qint VSS) capacitor c=2.98125e-17
C134 (\3\:CKNb VSS) capacitor c=2.55817e-17
C135 (\4\:CKNb VSS) capacitor c=6.27058e-17
C136 (\4\:RN VSS) capacitor c=3.87862e-17
C137 (\10\:qbint VSS) capacitor c=7.41815e-17
C138 (\13\:qbint VSS) capacitor c=1.20753e-16
C139 (\6\:n35 VSS) capacitor c=1.70146e-16
C140 (\7\:n35 VSS) capacitor c=1.58899e-16
C141 (\10\:CKNbb VSS) capacitor c=6.87043e-17
C142 (\11\:CKNbb VSS) capacitor c=1.17012e-16
C143 (\7\:RNb VSS) capacitor c=1.37229e-16
C144 (\8\:RNb VSS) capacitor c=3.08845e-16
C145 (\7\:SN VSS) capacitor c=2.62989e-16
C146 (\8\:SN VSS) capacitor c=3.74329e-17
C147 (\5\:mout VSS) capacitor c=4.95071e-17
C148 (\6\:mout VSS) capacitor c=6.20908e-17
C149 (\7\:mout VSS) capacitor c=5.10013e-17
C150 (\8\:mout VSS) capacitor c=5.87888e-17
C151 (\6\:n20 VSS) capacitor c=8.93326e-17
C152 (\9\:n20 VSS) capacitor c=1.00961e-16
C153 (\12\:CKNbb VSS) capacitor c=5.11947e-17
C154 (\13\:CKNbb VSS) capacitor c=1.25471e-16
C155 (\14\:CKNbb VSS) capacitor c=1.49173e-16
C156 (\15\:CKNbb VSS) capacitor c=9.74953e-17
C157 (\16\:CKNbb VSS) capacitor c=9.37856e-17
C158 (\12\:CKNb VSS) capacitor c=6.12771e-17
C159 (\13\:CKNb VSS) capacitor c=3.36643e-17
C160 (\4\:CKN VSS) capacitor c=3.88274e-17
C161 (\6\:CKN VSS) capacitor c=7.85154e-17
C162 (\3\:Db VSS) capacitor c=2.16215e-16
C163 (\7\:SE VSS) capacitor c=3.50153e-17
C164 (\8\:SE VSS) capacitor c=2.70064e-17
C165 (\5\:SI VSS) capacitor c=7.19681e-17
C166 (\7\:SEb VSS) capacitor c=1.08751e-16
C167 (\8\:SEb VSS) capacitor c=1.20963e-16
C168 (\9\:SEb VSS) capacitor c=1.48142e-16
C169 (\12\:SEb VSS) capacitor c=4.12165e-17
C170 (\3\:VDD VSS) capacitor c=2.30489e-17
C171 (\4\:VDD VSS) capacitor c=3.18825e-17
C172 (\6\:VDD VSS) capacitor c=3.08617e-17
C173 (\7\:VDD VSS) capacitor c=4.93917e-17
C174 (\19\:VDD VSS) capacitor c=1.82162e-17
C175 (\23\:VDD VSS) capacitor c=3.27267e-18
C176 (\27\:VDD VSS) capacitor c=1.54665e-17
C177 (\31\:VDD VSS) capacitor c=1.30978e-17
Rk6 (\2\:Q Q) resistor r=0.1666 c=0
Rk7 (Q \4\:Q) resistor r=0.3594 c=0
Rk62 (\2\:VSS \4\:VSS) resistor r=0.3048 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.3486 c=0
Rk64 (\5\:VSS \6\:VSS) resistor r=0.3951 c=0
Rk65 (\6\:VSS \7\:VSS) resistor r=0.1067 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.4289 c=0
Rk67 (\8\:VSS \9\:VSS) resistor r=0.7249 c=0
Rk68 (\9\:VSS \10\:VSS) resistor r=0.6095 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.193 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.2131 c=0
Rk71 (\12\:VSS \13\:VSS) resistor r=0.2883 c=0
Rk73 (\14\:VSS VSS) resistor r=0.2003 c=0
Rk72 (\13\:VSS \14\:VSS) resistor r=0.04999 c=0
Rk74 (\5\:VSS \16\:VSS) resistor r=0.2336 c=0
Rk75 (\6\:VSS \18\:VSS) resistor r=0.04334 c=0
Rk76 (\8\:VSS \20\:VSS) resistor r=0.3181 c=0
Rk77 (\10\:VSS \22\:VSS) resistor r=0.07428 c=0
Rk78 (\12\:VSS \24\:VSS) resistor r=0.3878 c=0
Rk79 (\14\:VSS \26\:VSS) resistor r=0.3721 c=0
Rk44 (\4\:CKN \5\:CKN) resistor r=0.002026 c=0
Rk45 (CKN \6\:CKN) resistor r=0.001959 c=0
Rk46 (\4\:CKN \6\:CKN) resistor r=0.0678 c=0
Rk52 (\7\:SE SE) resistor r=0.09481 c=0
Rk53 (SE \8\:SE) resistor r=0.1194 c=0
Rk23 (\7\:SN SN) resistor r=2.0205 c=0
Rk24 (SN \8\:SN) resistor r=0.07777 c=0
Rk54 (\4\:SI \5\:SI) resistor r=0.004909 c=0
Rk55 (\6\:SI SI) resistor r=0.005032 c=0
Rk56 (\5\:SI \6\:SI) resistor r=0.03605 c=0
Rk2 (\4\:QN QN) resistor r=0.09293 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3065 c=0
Rk80 (\2\:VDD \3\:VDD) resistor r=0.09264 c=0
Rk81 (\3\:VDD \4\:VDD) resistor r=0.4236 c=0
Rk82 (\4\:VDD \5\:VDD) resistor r=0.2357 c=0
Rk83 (\5\:VDD \6\:VDD) resistor r=0.07257 c=0
Rk84 (\6\:VDD \7\:VDD) resistor r=0.6068 c=0
Rk85 (\7\:VDD \8\:VDD) resistor r=0.4238 c=0
Rk86 (\3\:VDD \10\:VDD) resistor r=0.2004 c=0
Rk87 (\4\:VDD \12\:VDD) resistor r=0.2615 c=0
Rk88 (\6\:VDD \14\:VDD) resistor r=0.4646 c=0
Rk89 (\7\:VDD \16\:VDD) resistor r=0.1031 c=0
Rk90 (\8\:VDD \18\:VDD) resistor r=0.07151 c=0
Rk91 (\8\:VDD \19\:VDD) resistor r=0.5179 c=0
Rk92 (\19\:VDD \21\:VDD) resistor r=0.1467 c=0
Rk93 (\19\:VDD \22\:VDD) resistor r=0.1855 c=0
Rk94 (\22\:VDD \23\:VDD) resistor r=0.193 c=0
Rk95 (\23\:VDD \25\:VDD) resistor r=0.3354 c=0
Rk96 (\23\:VDD \26\:VDD) resistor r=0.2081 c=0
Rk97 (\26\:VDD \27\:VDD) resistor r=0.2156 c=0
Rk98 (\27\:VDD \29\:VDD) resistor r=0.2163 c=0
Rk99 (\27\:VDD \30\:VDD) resistor r=0.2858 c=0
Rk102 (\31\:VDD VDD) resistor r=0.2003 c=0
Rk100 (\30\:VDD \31\:VDD) resistor r=0.04999 c=0
Rk101 (\31\:VDD \33\:VDD) resistor r=0.4374 c=0
Rk47 (\4\:D D) resistor r=0.003698 c=0
Rk8 (\4\:RN RN) resistor r=0.06442 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.115 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1197 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.109 c=0
Rk9 (\10\:qbint \12\:qbint) resistor r=0.5127 c=0
Rk10 (\12\:qbint \13\:qbint) resistor r=0.8441 c=0
Rk11 (\12\:qbint \15\:qbint) resistor r=0.521 c=0
Rk19 (\7\:RNb \8\:RNb) resistor r=1.0744 c=0
Rk20 (\8\:RNb \10\:RNb) resistor r=1.1727 c=0
Rk21 (\10\:RNb \12\:RNb) resistor r=0.4929 c=0
Rk15 (\5\:n35 \6\:n35) resistor r=0.1601 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=1.1429 c=0
Rk17 (\6\:n35 \9\:n35) resistor r=0.1633 c=0
Rk12 (\2\:net498 \4\:net498) resistor r=0.566 c=0
Rk14 (\2\:net0363 \4\:net0363) resistor r=0.362 c=0
Rk18 (\10\:CKNbb \11\:CKNbb) resistor r=0.6298 c=0
Rk35 (\12\:CKNbb \13\:CKNbb) resistor r=0.2124 c=0
Rk36 (\13\:CKNbb \14\:CKNbb) resistor r=0.9087 c=0
Rk37 (\13\:CKNbb \15\:CKNbb) resistor r=0.3464 c=0
Rk38 (\15\:CKNbb \16\:CKNbb) resistor r=0.4627 c=0
Rk39 (\15\:CKNbb \18\:CKNbb) resistor r=0.5214 c=0
Rk40 (\18\:CKNbb \20\:CKNbb) resistor r=0.2704 c=0
Rk25 (\5\:mout \6\:mout) resistor r=0.2305 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.3334 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3185 c=0
Rk28 (\8\:mout \10\:mout) resistor r=0.3831 c=0
Rk29 (\6\:mout \12\:mout) resistor r=0.09453 c=0
Rk30 (\7\:mout \14\:mout) resistor r=0.1023 c=0
Rk31 (\8\:mout \16\:mout) resistor r=0.05885 c=0
Rk41 (\11\:CKNb \12\:CKNb) resistor r=0.5232 c=0
Rk42 (\12\:CKNb \13\:CKNb) resistor r=0.1508 c=0
Rk43 (\12\:CKNb \15\:CKNb) resistor r=0.1836 c=0
Rk22 (\2\:net521 \4\:net521) resistor r=0.4977 c=0
Rk32 (\5\:n20 \6\:n20) resistor r=0.3353 c=0
Rk33 (\6\:n20 \8\:n20) resistor r=0.1457 c=0
Rk34 (\6\:n20 \9\:n20) resistor r=0.5442 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.52 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.3689 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.07507 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.6202 c=0
Rk57 (\6\:SEb \7\:SEb) resistor r=0.02809 c=0
Rk58 (\7\:SEb \8\:SEb) resistor r=0.3525 c=0
Rk59 (\8\:SEb \9\:SEb) resistor r=0.8647 c=0
Rk60 (\7\:SEb \11\:SEb) resistor r=0.6988 c=0
Rk61 (\8\:SEb \12\:SEb) resistor r=0.1307 c=0
Rk13 (\2\:net566 \4\:net566) resistor r=0.3956 c=0
Rl41 (\1\:CKN \2\:CKN) resistor r=151.923 c=0
Rl42 (\2\:CKN \3\:CKN) resistor r=53.2967 c=0
Rl51 (\4\:SE \5\:SE) resistor r=193.812 c=0
Rl52 (\5\:SE \6\:SE) resistor r=67.9995 c=0
Rl48 (\2\:SE \3\:SE) resistor r=254.568 c=0
Rl47 (\1\:SE \2\:SE) resistor r=74.2328 c=0
Rl27 (\4\:SN \6\:SN) resistor r=157.692 c=0
Rl26 (\4\:SN \5\:SN) resistor r=59.5926 c=0
Rl13 (\1\:SN \2\:SN) resistor r=62.2302 c=0
Rl14 (\2\:SN \3\:SN) resistor r=112.23 c=0
Rl50 (\2\:SI \3\:SI) resistor r=99.2818 c=0
Rl49 (\1\:SI \2\:SI) resistor r=141.668 c=0
Rl43 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl44 (\2\:D \3\:D) resistor r=212.694 c=0
Rl9 (\1\:RN \2\:RN) resistor r=96.8456 c=0
Rl10 (\2\:RN \3\:RN) resistor r=89.1533 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl15 (\7\:qbint \8\:qbint) resistor r=200 c=0
Rl16 (\8\:qbint \9\:qbint) resistor r=46.2406 c=0
Rl4 (qbint \2\:qbint) resistor r=26.1559 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=89.9037 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=39.6181 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=49.2335 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=161.953 c=0
Rl17 (RNb \2\:RNb) resistor r=264.95 c=0
Rl23 (\4\:RNb \6\:RNb) resistor r=157.692 c=0
Rl22 (\4\:RNb \5\:RNb) resistor r=99.5131 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl11 (n35 \2\:n35) resistor r=119.922 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=39.1533 c=0
Rl32 (\8\:CKNbb \9\:CKNbb) resistor r=49.5519 c=0
Rl31 (\6\:CKNbb \7\:CKNbb) resistor r=24.2328 c=0
Rl20 (\3\:CKNbb \4\:CKNbb) resistor r=53.3592 c=0
Rl21 (\3\:CKNbb \5\:CKNbb) resistor r=97.5374 c=0
Rl19 (CKNbb \2\:CKNbb) resistor r=93.4636 c=0
Rl28 (mout \2\:mout) resistor r=60.4181 c=0
Rl30 (\2\:mout \4\:mout) resistor r=110.418 c=0
Rl29 (\2\:mout \3\:mout) resistor r=7.6446 c=0
Rl38 (\6\:CKNb \7\:CKNb) resistor r=147.208 c=0
Rl37 (\5\:CKNb \6\:CKNb) resistor r=747.643 c=0
Rl33 (CKNb \2\:CKNb) resistor r=30.5643 c=0
Rl39 (\3\:CKNb \8\:CKNb) resistor r=26.0821 c=0
Rl34 (\2\:CKNb \3\:CKNb) resistor r=9.6894 c=0
Rl40 (\4\:CKNb \9\:CKNb) resistor r=57.3738 c=0
Rl36 (\4\:CKNb \5\:CKNb) resistor r=221.132 c=0
Rl35 (\3\:CKNb \4\:CKNb) resistor r=157.767 c=0
Rl24 (n20 \2\:n20) resistor r=102.615 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl46 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl45 (SEb \2\:SEb) resistor r=78.079 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz28 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz29 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz30 (\1\:VDD \8\:VDD) resistor r=7.5 c=0
Rz31 (\1\:VDD \22\:VDD) resistor r=18.75 c=0
Rz32 (\1\:VDD \26\:VDD) resistor r=18.75 c=0
Rz33 (\1\:VDD \30\:VDD) resistor r=12.5 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (net498 \2\:net498) resistor r=75 c=0
Rz6 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz7 (net0363 \2\:net0363) resistor r=75 c=0
Rz8 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz16 (\19\:CKNbb \20\:CKNbb) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz14 (\15\:mout \16\:mout) resistor r=75 c=0
Rz17 (\14\:CKNb \15\:CKNb) resistor r=75 c=0
Rz11 (net521 \2\:net521) resistor r=75 c=0
Rz12 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz15 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz18 (\4\:Db \5\:Db) resistor r=75 c=0
Rz19 (\6\:Db \7\:Db) resistor r=75 c=0
Rz20 (\10\:SEb \11\:SEb) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry17 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry18 (\3\:VSS \7\:VSS) resistor r=5.6364 c=0
Ry19 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry20 (\3\:VSS \11\:VSS) resistor r=15.5 c=0
Ry21 (\3\:VSS \13\:VSS) resistor r=10.3333 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry22 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry23 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry24 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry25 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry28 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry29 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry30 (\32\:VDD \33\:VDD) resistor r=62 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\17\:CKNbb \18\:CKNbb) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\11\:mout \12\:mout) resistor r=62 c=0
Ry13 (\10\:CKNb \11\:CKNb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry14 (Db \2\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net566 \2\:net566) resistor r=62 c=0
Ry6 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx18 (\2\:CKN \5\:CKN) resistor r=45 c=0
Rx20 (\5\:SE \7\:SE) resistor r=45 c=0
Rx21 (\2\:SE \8\:SE) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx22 (\2\:SI \4\:SI) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \10\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \13\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\3\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx14 (\7\:CKNbb \12\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx17 (\2\:CKNb \13\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx24 (\4\:SEb \12\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.833e-14 ad=3.64e-14 ps=8.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.833e-14 ad=2.03e-14 ps=8.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.267e-14 ad=3.64e-14 ps=9.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.00769e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn22 (\11\:RNb \3\:RN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.267e-14 ad=2.9e-14 ps=9.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\11\:qbint \3\:n35 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.548e-14 ad=2.03e-14 ps=1.55e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.44483e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn50 (net498 \3\:SN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.548e-14 ad=3.335e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.22414e-07 sb=7.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn52 (\3\:net0363 \8\:qbint net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.335e-14 ad=3.988e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.97414e-07 sb=4.65e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn51 (\3\:net0363 RNb \3\:net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.103e-14 ad=3.988e-14 ps=5.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.17414e-07 sb=1.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn53 (\4\:n35 CKNbb net0363 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\15\:mout \6\:CKNb \4\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.698e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn31 (\13\:mout \6\:RNb \3\:net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn36 (\7\:n20 \5\:CKNb net582 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=3.45e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn32 (\13\:mout \3\:n20 net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.755e-14 ps=6.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=9.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn30 (net521 \6\:SN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.537e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=7.65e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn25 (\4\:Db \8\:CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn35 (net582 \4\:mout \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.595e-14 ps=7.3e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=5e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn21 (\19\:CKNbb CKNb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.025e-14 ad=2.03e-14 ps=1.76e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\14\:CKNb \3\:CKN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=3.407e-14 ps=9.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.06897e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (net546 \3\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71034e-07 sb=9.95e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn12 (\6\:Db SEb net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.857e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.76034e-07 sb=8.9e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn10 (\10\:SEb \6\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12603e-06 sb=1.4e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn14 (\6\:Db \1\:SE net538 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=4.857e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.56034e-07 sb=5.1e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn13 (net538 \1\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.21034e-07 sb=3.45e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mp56 (\5\:qint \6\:qbint \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\1\:Q \5\:qbint \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=5.46e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.01218e-07 sd=160n sca=12.7076 \
        scb=0.0112318 scc=0.000478212 m=(1)
mp22 (\9\:RNb \1\:RN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=4.3e-14 ps=1.22e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-07 sd=160n sca=10.1345 \
        scb=0.00732736 scc=7.25592e-05 m=(1)
mp45 (\14\:qbint n35 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=5.483e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=9.25e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (\3\:net566 \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.407e-14 ad=4.945e-14 ps=8.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=6.75e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp52 (\3\:net566 \7\:qbint net414 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=4.945e-14 ps=5.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=4e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp51 (net414 \2\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.223e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2.95e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp53 (\8\:n35 \7\:CKNb net566 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.762e-14 ps=1.06e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.6e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\8\:n35 \4\:CKNbb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.762e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp31 (net478 \4\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.928e-14 ad=4.085e-14 ps=2.06e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.25e-07 sb=1.13919e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp32 (\11\:mout n20 net478 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.762e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=9.04186e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\11\:mout \4\:SN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.762e-14 ps=1.71e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=6.84186e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp35 (net486 mout \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.00814e-07 sb=5.22442e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp36 (\4\:n20 \6\:CKNbb net486 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.85e-14 ps=5.5e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.05814e-07 sb=4.17442e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp25 (\4\:n20 \9\:CKNb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=6.85e-14 ps=7.1e-07 pd=1.3e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12209e-06 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp21 (\17\:CKNbb \8\:CKNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\10\:CKNb \1\:CKN \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13686e-06 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp11 (net461 \1\:D \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.333e-14 ps=7.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=9.2686e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp12 (Db \3\:SE net461 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=6.128e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.2686e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp14 (Db \3\:SEb net453 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=3.9686e-07 sd=160n sca=11.3725 \
        scb=0.00850478 scc=0.000119858 m=(1)
mp13 (net453 \3\:SI \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.41e-14 ad=1.29e-14 ps=9.4e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.9186e-07 sd=160n sca=11.993 \
        scb=0.00910029 scc=0.000121216 m=(1)
mp10 (\5\:SEb \4\:SE \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.41e-14 ad=3.01e-14 ps=9.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.93488e-07 sb=1.4e-07 sd=160n sca=15.0667 \
        scb=0.0139761 scc=0.000182543 m=(1)
ends SDFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:26:17 2012 )
// Library name: gsclib045
// Cell name: SDFFNSRX2
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX2 CKN D Q QN RN SE SI SN VDD VSS
mp10 (\7\:SEb \1\:SE \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.227e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.62558e-07 sd=160n sca=26.8497 \
        scb=0.0316789 scc=0.0018946 m=(1)
C1 (D VSS) capacitor c=5.98605e-17
C2 (Q VSS) capacitor c=3.01578e-17
C3 (RN VSS) capacitor c=6.61053e-17
C4 (SN VSS) capacitor c=5.38005e-17
C5 (QN VSS) capacitor c=3.79008e-17
C6 (SE VSS) capacitor c=3.09075e-17
C7 (VDD VSS) capacitor c=5.88636e-16
C8 (SI VSS) capacitor c=4.04234e-17
C9 (CKN VSS) capacitor c=4.12928e-17
C10 (SEb VSS) capacitor c=6.00151e-17
C11 (Db VSS) capacitor c=8.01204e-17
C12 (CKNb VSS) capacitor c=6.96385e-17
C13 (CKNbb VSS) capacitor c=3.93478e-17
C14 (n20 VSS) capacitor c=3.9334e-17
C15 (mout VSS) capacitor c=5.76441e-17
C16 (net521 VSS) capacitor c=6.29967e-17
C17 (RNb VSS) capacitor c=5.15347e-17
C18 (n35 VSS) capacitor c=4.8435e-17
C19 (net0363 VSS) capacitor c=8.09605e-17
C20 (net498 VSS) capacitor c=8.58424e-17
C21 (qbint VSS) capacitor c=6.39235e-17
C22 (qint VSS) capacitor c=1.59034e-16
C23 (net453 VSS) capacitor c=3.39026e-19
C24 (net461 VSS) capacitor c=4.24823e-18
C25 (net486 VSS) capacitor c=4.25379e-19
C26 (net478 VSS) capacitor c=2.5288e-18
C27 (net566 VSS) capacitor c=1.37961e-16
C28 (net414 VSS) capacitor c=4.13799e-18
C29 (\11\:qbint VSS) capacitor c=3.21707e-17
C30 (\4\:qbint VSS) capacitor c=4.96883e-16
C31 (\1\:RN VSS) capacitor c=5.60181e-17
C32 (\6\:SN VSS) capacitor c=7.78532e-17
C33 (\2\:RNb VSS) capacitor c=3.71287e-17
C34 (\5\:CKNbb VSS) capacitor c=3.70288e-17
C35 (\4\:RNb VSS) capacitor c=1.31313e-16
C36 (\3\:n20 VSS) capacitor c=4.72429e-17
C37 (\4\:SN VSS) capacitor c=3.37564e-17
C38 (\3\:CKNbb VSS) capacitor c=7.23658e-17
C39 (\8\:CKNb VSS) capacitor c=1.90358e-17
C40 (\9\:CKNb VSS) capacitor c=1.32654e-17
C41 (\3\:CKN VSS) capacitor c=3.56332e-17
C42 (\3\:D VSS) capacitor c=3.4427e-17
C43 (\4\:SE VSS) capacitor c=8.14021e-17
C44 (\1\:SI VSS) capacitor c=8.00875e-17
C45 (\1\:SE VSS) capacitor c=6.21499e-17
C46 (\13\:qbint VSS) capacitor c=5.45612e-17
C47 (\3\:RN VSS) capacitor c=3.83075e-17
C48 (\4\:n35 VSS) capacitor c=3.94436e-17
C49 (\8\:SN VSS) capacitor c=5.84683e-17
C50 (\3\:qbint VSS) capacitor c=3.4443e-17
C51 (\7\:CKNbb VSS) capacitor c=4.08508e-17
C52 (\2\:CKNb VSS) capacitor c=1.35299e-16
C53 (\5\:RNb VSS) capacitor c=4.75352e-17
C54 (\1\:SN VSS) capacitor c=5.66408e-17
C55 (\3\:mout VSS) capacitor c=7.24832e-17
C56 (\3\:CKNb VSS) capacitor c=2.08915e-16
C57 (\10\:CKNb VSS) capacitor c=2.61064e-17
C58 (\1\:CKN VSS) capacitor c=2.53762e-17
C59 (\1\:D VSS) capacitor c=5.52438e-17
C60 (\3\:SEb VSS) capacitor c=4.27703e-17
C61 (\6\:SE VSS) capacitor c=3.3366e-17
C62 (\3\:SI VSS) capacitor c=7.11068e-17
C63 (\3\:SE VSS) capacitor c=2.82429e-17
C64 (\12\:qbint VSS) capacitor c=4.42054e-17
C65 (\6\:qint VSS) capacitor c=2.0814e-17
C66 (\2\:RN VSS) capacitor c=5.05735e-17
C67 (\3\:n35 VSS) capacitor c=2.21728e-17
C68 (\7\:SN VSS) capacitor c=3.30553e-17
C69 (\2\:qbint VSS) capacitor c=4.2044e-17
C70 (\3\:RNb VSS) capacitor c=1.18553e-16
C71 (\8\:CKNbb VSS) capacitor c=3.22062e-17
C72 (\6\:CKNbb VSS) capacitor c=3.02729e-17
C73 (\2\:n20 VSS) capacitor c=4.9619e-17
C74 (\5\:SN VSS) capacitor c=2.20878e-17
C75 (\3\:SN VSS) capacitor c=4.05713e-17
C76 (\2\:mout VSS) capacitor c=5.2214e-17
C77 (\4\:CKNbb VSS) capacitor c=2.75503e-17
C78 (\2\:CKNbb VSS) capacitor c=4.28194e-17
C79 (\7\:CKNb VSS) capacitor c=8.93044e-18
C80 (\2\:CKN VSS) capacitor c=3.24323e-17
C81 (\2\:D VSS) capacitor c=5.46093e-17
C82 (\4\:SEb VSS) capacitor c=3.98107e-17
C83 (\5\:SE VSS) capacitor c=6.15037e-17
C84 (\2\:SEb VSS) capacitor c=4.2539e-17
C85 (\2\:SI VSS) capacitor c=6.3475e-17
C86 (\2\:SE VSS) capacitor c=4.32875e-17
C87 (\8\:qint VSS) capacitor c=3.92853e-17
C88 (\1\:QN VSS) capacitor c=5.26122e-17
C89 (\1\:Q VSS) capacitor c=4.96093e-17
C90 (\10\:RNb VSS) capacitor c=2.06812e-17
C91 (\20\:qbint VSS) capacitor c=5.74468e-17
C92 (\28\:VDD VSS) capacitor c=1.54459e-17
C93 (\30\:VDD VSS) capacitor c=3.03307e-17
C94 (\3\:net566 VSS) capacitor c=1.32664e-16
C95 (\7\:n35 VSS) capacitor c=2.21867e-17
C96 (\10\:mout VSS) capacitor c=3.57542e-17
C97 (\32\:VDD VSS) capacitor c=3.0282e-17
C98 (\14\:mout VSS) capacitor c=3.3163e-17
C99 (\34\:VDD VSS) capacitor c=3.42998e-17
C100 (\7\:n20 VSS) capacitor c=7.50814e-17
C101 (\13\:CKNbb VSS) capacitor c=7.27113e-17
C102 (\37\:VDD VSS) capacitor c=4.31446e-17
C103 (\13\:CKNb VSS) capacitor c=5.21449e-17
C104 (\39\:VDD VSS) capacitor c=3.14146e-17
C105 (\8\:Db VSS) capacitor c=1.25469e-16
C106 (\41\:VDD VSS) capacitor c=9.33681e-18
C107 (\7\:SEb VSS) capacitor c=6.69464e-17
C108 (\1\:VDD VSS) capacitor c=2.94672e-16
C109 (\12\:qint VSS) capacitor c=2.08934e-17
C110 (\3\:QN VSS) capacitor c=3.0434e-17
C111 (\4\:Q VSS) capacitor c=7.93738e-17
C112 (\6\:RNb VSS) capacitor c=1.15714e-16
C113 (\17\:qbint VSS) capacitor c=6.56096e-17
C114 (\3\:net0363 VSS) capacitor c=1.14329e-16
C115 (\3\:net498 VSS) capacitor c=6.82981e-17
C116 (\9\:n35 VSS) capacitor c=6.33489e-17
C117 (\4\:mout VSS) capacitor c=4.23858e-17
C118 (\12\:mout VSS) capacitor c=4.3084e-17
C119 (\3\:net521 VSS) capacitor c=7.72486e-17
C120 (\5\:n20 VSS) capacitor c=1.92377e-16
C121 (\3\:Db VSS) capacitor c=1.91441e-16
C122 (\17\:CKNbb VSS) capacitor c=5.08554e-17
C123 (\15\:CKNb VSS) capacitor c=4.68027e-17
C124 (\6\:Db VSS) capacitor c=1.95888e-17
C125 (\9\:SEb VSS) capacitor c=7.45634e-17
C126 (\2\:SN VSS) capacitor c=3.1632e-17
C127 (\4\:SI VSS) capacitor c=6.43867e-17
C128 (\7\:SE VSS) capacitor c=4.89435e-17
C129 (\8\:SE VSS) capacitor c=3.27522e-17
C130 (\4\:CKNb VSS) capacitor c=5.65492e-17
C131 (\5\:CKNb VSS) capacitor c=1.97665e-17
C132 (\5\:SEb VSS) capacitor c=1.78123e-16
C133 (\6\:SEb VSS) capacitor c=1.36822e-16
C134 (\11\:SEb VSS) capacitor c=4.09735e-17
C135 (\4\:D VSS) capacitor c=4.58912e-17
C136 (\4\:CKN VSS) capacitor c=5.68803e-17
C137 (\2\:n35 VSS) capacitor c=1.49831e-17
C138 (\11\:CKNb VSS) capacitor c=4.84509e-17
C139 (\12\:CKNb VSS) capacitor c=5.98318e-17
C140 (\5\:Db VSS) capacitor c=2.3728e-16
C141 (\9\:SN VSS) capacitor c=6.23225e-17
C142 (\4\:n20 VSS) capacitor c=1.73934e-16
C143 (\6\:mout VSS) capacitor c=5.50681e-17
C144 (\7\:mout VSS) capacitor c=8.31161e-17
C145 (\8\:mout VSS) capacitor c=7.43846e-17
C146 (\9\:mout VSS) capacitor c=5.84745e-17
C147 (\9\:CKNbb VSS) capacitor c=8.1836e-17
C148 (\10\:CKNbb VSS) capacitor c=3.20871e-16
C149 (\11\:CKNbb VSS) capacitor c=2.09946e-16
C150 (\12\:CKNbb VSS) capacitor c=6.68798e-17
C151 (\15\:CKNbb VSS) capacitor c=1.73578e-17
C152 (\16\:CKNbb VSS) capacitor c=6.36633e-17
C153 (\10\:SN VSS) capacitor c=2.70973e-16
C154 (\11\:SN VSS) capacitor c=2.77105e-16
C155 (\5\:n35 VSS) capacitor c=1.75013e-16
C156 (\6\:n35 VSS) capacitor c=1.50438e-16
C157 (\8\:RNb VSS) capacitor c=1.34399e-16
C158 (\9\:RNb VSS) capacitor c=1.14241e-16
C159 (\4\:RN VSS) capacitor c=6.14709e-17
C160 (\3\:Q VSS) capacitor c=5.2621e-17
C161 (\14\:qbint VSS) capacitor c=1.10487e-16
C162 (\19\:qbint VSS) capacitor c=6.39611e-17
C163 (\23\:qbint VSS) capacitor c=7.27287e-17
C164 (\10\:qint VSS) capacitor c=3.88988e-17
C165 (\11\:qint VSS) capacitor c=3.27441e-17
C166 (\3\:VDD VSS) capacitor c=1.13424e-16
C167 (\9\:VDD VSS) capacitor c=8.61171e-19
C168 (\11\:VDD VSS) capacitor c=3.52161e-17
C169 (\13\:VDD VSS) capacitor c=2.60785e-17
C170 (\14\:VDD VSS) capacitor c=1.71266e-17
C171 (\16\:VDD VSS) capacitor c=1.42316e-18
C172 (\18\:VDD VSS) capacitor c=2.7732e-18
C173 (\20\:VDD VSS) capacitor c=6.85448e-19
Rk10 (\4\:D D) resistor r=0.015 c=0
Rk49 (\3\:Q Q) resistor r=0.05081 c=0
Rk48 (\2\:Q \3\:Q) resistor r=0.1385 c=0
Rk50 (\3\:Q \5\:Q) resistor r=0.4019 c=0
Rk94 (\2\:VSS \3\:VSS) resistor r=0.1177 c=0
Rk98 (\3\:VSS \8\:VSS) resistor r=0.3296 c=0
Rk99 (\8\:VSS \9\:VSS) resistor r=0.2706 c=0
Rk100 (\9\:VSS \10\:VSS) resistor r=1.1256 c=0
Rk101 (\10\:VSS \11\:VSS) resistor r=0.07753 c=0
Rk102 (\11\:VSS \12\:VSS) resistor r=0.7335 c=0
Rk103 (\12\:VSS \13\:VSS) resistor r=0.4124 c=0
Rk104 (\13\:VSS \14\:VSS) resistor r=0.05497 c=0
Rk106 (\15\:VSS VSS) resistor r=0.1149 c=0
Rk105 (\14\:VSS \15\:VSS) resistor r=0.4361 c=0
Rk109 (\8\:VSS \21\:VSS) resistor r=0.3564 c=0
Rk110 (\10\:VSS \23\:VSS) resistor r=0.338 c=0
Rk111 (\12\:VSS \25\:VSS) resistor r=0.0433 c=0
Rk112 (\13\:VSS \27\:VSS) resistor r=0.1726 c=0
Rk113 (\15\:VSS \29\:VSS) resistor r=0.1817 c=0
Rk47 (RN \4\:RN) resistor r=0.177 c=0
Rk19 (\9\:SN SN) resistor r=0.1631 c=0
Rk40 (\10\:SN \11\:SN) resistor r=2.1227 c=0
Rk51 (\2\:QN QN) resistor r=0.1716 c=0
Rk52 (QN \4\:QN) resistor r=0.05987 c=0
Rk2 (\7\:SE SE) resistor r=0.1426 c=0
Rk3 (SE \8\:SE) resistor r=0.05367 c=0
Rk63 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk68 (\3\:VDD \8\:VDD) resistor r=0.1653 c=0
Rk69 (\8\:VDD \9\:VDD) resistor r=0.1603 c=0
Rk70 (\9\:VDD \10\:VDD) resistor r=0.1904 c=0
Rk71 (\10\:VDD \11\:VDD) resistor r=0.2305 c=0
Rk72 (\11\:VDD \12\:VDD) resistor r=0.5715 c=0
Rk73 (\12\:VDD \13\:VDD) resistor r=0.1678 c=0
Rk74 (\13\:VDD \14\:VDD) resistor r=0.4309 c=0
Rk75 (\14\:VDD \15\:VDD) resistor r=0.3032 c=0
Rk76 (\15\:VDD \16\:VDD) resistor r=0.2806 c=0
Rk77 (\16\:VDD \17\:VDD) resistor r=0.2706 c=0
Rk78 (\17\:VDD \18\:VDD) resistor r=0.2681 c=0
Rk79 (\18\:VDD \19\:VDD) resistor r=0.1828 c=0
Rk80 (\19\:VDD \20\:VDD) resistor r=0.243 c=0
Rk82 (\21\:VDD VDD) resistor r=0.0499 c=0
Rk81 (\20\:VDD \21\:VDD) resistor r=0.05747 c=0
Rk86 (\9\:VDD \29\:VDD) resistor r=0.07381 c=0
Rk87 (\11\:VDD \31\:VDD) resistor r=0.1572 c=0
Rk88 (\13\:VDD \33\:VDD) resistor r=0.1526 c=0
Rk89 (\14\:VDD \35\:VDD) resistor r=0.07381 c=0
Rk90 (\35\:VDD \36\:VDD) resistor r=0.1501 c=0
Rk91 (\16\:VDD \38\:VDD) resistor r=0.4058 c=0
Rk92 (\18\:VDD \40\:VDD) resistor r=0.254 c=0
Rk93 (\20\:VDD \42\:VDD) resistor r=0.07381 c=0
Rk1 (SI \4\:SI) resistor r=0.02867 c=0
Rk11 (CKN \4\:CKN) resistor r=0.1124 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=1.1937 c=0
Rk5 (\6\:SEb \8\:SEb) resistor r=0.2534 c=0
Rk6 (\8\:SEb \10\:SEb) resistor r=0.6366 c=0
Rk7 (\6\:SEb \11\:SEb) resistor r=0.1561 c=0
Rk15 (\2\:Db \4\:Db) resistor r=0.4096 c=0
Rk16 (\4\:Db \5\:Db) resistor r=1.532 c=0
Rk17 (\5\:Db \7\:Db) resistor r=0.1012 c=0
Rk18 (\5\:Db \9\:Db) resistor r=0.7111 c=0
Rk12 (\11\:CKNb \12\:CKNb) resistor r=0.3582 c=0
Rk13 (\12\:CKNb \14\:CKNb) resistor r=0.4916 c=0
Rk14 (\12\:CKNb \16\:CKNb) resistor r=0.178 c=0
Rk30 (\9\:CKNbb \10\:CKNbb) resistor r=0.6269 c=0
Rk31 (\10\:CKNbb \11\:CKNbb) resistor r=1.6418 c=0
Rk32 (\11\:CKNbb \12\:CKNbb) resistor r=0.2063 c=0
Rk33 (\12\:CKNbb \14\:CKNbb) resistor r=0.4036 c=0
Rk34 (\11\:CKNbb \15\:CKNbb) resistor r=0.05041 c=0
Rk35 (\12\:CKNbb \16\:CKNbb) resistor r=0.3465 c=0
Rk36 (\14\:CKNbb \18\:CKNbb) resistor r=0.2847 c=0
Rk20 (\4\:n20 \6\:n20) resistor r=1.2023 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.3838 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.2236 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.4568 c=0
Rk25 (\7\:mout \8\:mout) resistor r=0.3521 c=0
Rk26 (\8\:mout \9\:mout) resistor r=0.3157 c=0
Rk27 (\6\:mout \11\:mout) resistor r=0.1203 c=0
Rk28 (\7\:mout \13\:mout) resistor r=0.215 c=0
Rk29 (\8\:mout \15\:mout) resistor r=0.1168 c=0
Rk22 (\2\:net521 \4\:net521) resistor r=0.5226 c=0
Rk44 (\7\:RNb \8\:RNb) resistor r=0.6011 c=0
Rk45 (\8\:RNb \9\:RNb) resistor r=0.7204 c=0
Rk46 (\8\:RNb \11\:RNb) resistor r=0.0503 c=0
Rk41 (\5\:n35 \6\:n35) resistor r=1.125 c=0
Rk42 (\6\:n35 \8\:n35) resistor r=0.05676 c=0
Rk43 (\6\:n35 \10\:n35) resistor r=0.2943 c=0
Rk37 (\2\:net0363 \4\:net0363) resistor r=0.7252 c=0
Rk38 (\2\:net498 \4\:net498) resistor r=0.3862 c=0
Rk53 (\14\:qbint \4\:qbint) resistor r=0.8478 c=0
Rk55 (\4\:qbint \18\:qbint) resistor r=0.5105 c=0
Rk56 (\18\:qbint \19\:qbint) resistor r=0.1593 c=0
Rk57 (\19\:qbint \21\:qbint) resistor r=0.2594 c=0
Rk59 (\19\:qbint \23\:qbint) resistor r=0.3557 c=0
Rk60 (\9\:qint \10\:qint) resistor r=0.3681 c=0
Rk61 (\10\:qint \11\:qint) resistor r=0.1802 c=0
Rk62 (\10\:qint \13\:qint) resistor r=0.1138 c=0
Rk39 (\2\:net566 \4\:net566) resistor r=0.7765 c=0
Rl10 (\2\:D \3\:D) resistor r=112.637 c=0
Rl9 (\1\:D \2\:D) resistor r=161.538 c=0
Rl45 (\1\:RN \2\:RN) resistor r=156.925 c=0
Rl46 (\2\:RN \3\:RN) resistor r=37.6944 c=0
Rl41 (\6\:SN \8\:SN) resistor r=140.385 c=0
Rl40 (\6\:SN \7\:SN) resistor r=70.3288 c=0
Rl20 (\4\:SN \5\:SN) resistor r=50.6918 c=0
Rl19 (\2\:SN \4\:SN) resistor r=99.6815 c=0
Rl17 (\1\:SN \2\:SN) resistor r=105.747 c=0
Rl18 (\2\:SN \3\:SN) resistor r=78.0596 c=0
Rl6 (\4\:SE \5\:SE) resistor r=276.489 c=0
Rl7 (\5\:SE \6\:SE) resistor r=26.3736 c=0
Rl1 (\1\:SE \2\:SE) resistor r=193 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl3 (\1\:SI \2\:SI) resistor r=104.538 c=0
Rl4 (\2\:SI \3\:SI) resistor r=168 c=0
Rl12 (\2\:CKN \3\:CKN) resistor r=135.714 c=0
Rl11 (\1\:CKN \2\:CKN) resistor r=30.7692 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=93.4636 c=0
Rl5 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl24 (CKNb \2\:CKNb) resistor r=158.747 c=0
Rl25 (\2\:CKNb \3\:CKNb) resistor r=905.335 c=0
Rl30 (\4\:CKNb \8\:CKNb) resistor r=30.4507 c=0
Rl26 (\3\:CKNb \4\:CKNb) resistor r=224.543 c=0
Rl31 (\5\:CKNb \9\:CKNb) resistor r=28.0797 c=0
Rl27 (\4\:CKNb \5\:CKNb) resistor r=149.196 c=0
Rl32 (\6\:CKNb \10\:CKNb) resistor r=46.9565 c=0
Rl29 (\6\:CKNb \7\:CKNb) resistor r=3.7301 c=0
Rl28 (\5\:CKNb \6\:CKNb) resistor r=25.0362 c=0
Rl33 (\7\:CKNbb \8\:CKNbb) resistor r=81.9251 c=0
Rl23 (\5\:CKNbb \6\:CKNbb) resistor r=24.2328 c=0
Rl14 (\3\:CKNbb \4\:CKNbb) resistor r=37.6944 c=0
Rl13 (CKNbb \2\:CKNbb) resistor r=39.1533 c=0
Rl21 (n20 \2\:n20) resistor r=33.4411 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=89.5604 c=0
Rl15 (mout \2\:mout) resistor r=24.2328 c=0
Rl16 (\2\:mout \3\:mout) resistor r=91.5405 c=0
Rl34 (RNb \2\:RNb) resistor r=132.325 c=0
Rl37 (\4\:RNb \5\:RNb) resistor r=172.643 c=0
Rl35 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl36 (\3\:RNb \4\:RNb) resistor r=987.26 c=0
Rl42 (n35 \2\:n35) resistor r=34.3295 c=0
Rl44 (\2\:n35 \4\:n35) resistor r=74.7141 c=0
Rl43 (\2\:n35 \3\:n35) resistor r=2.0166 c=0
Rl58 (\12\:qbint \11\:qbint) resistor r=26.098 c=0
Rl59 (\12\:qbint \13\:qbint) resistor r=137.637 c=0
Rl38 (\2\:qbint qbint) resistor r=60.7713 c=0
Rl39 (\2\:qbint \3\:qbint) resistor r=37.6944 c=0
Rl56 (qint \6\:qint) resistor r=4.9938 c=0
Rz17 (\5\:Q \4\:Q) resistor r=75 c=0
Rz34 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz35 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz36 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz37 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz38 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz18 (\4\:QN \3\:QN) resistor r=75 c=0
Rz21 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz23 (\3\:VDD \1\:VDD) resistor r=15 c=0
Rz24 (\8\:VDD \1\:VDD) resistor r=25 c=0
Rz25 (\10\:VDD \1\:VDD) resistor r=18.75 c=0
Rz26 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz27 (\15\:VDD \1\:VDD) resistor r=12.5 c=0
Rz28 (\17\:VDD \1\:VDD) resistor r=15 c=0
Rz29 (\19\:VDD \1\:VDD) resistor r=18.75 c=0
Rz30 (\21\:VDD \1\:VDD) resistor r=37.5 c=0
Rz1 (\9\:SEb \10\:SEb) resistor r=75 c=0
Rz3 (\3\:Db \4\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\15\:CKNb \16\:CKNb) resistor r=75 c=0
Rz10 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz5 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\12\:mout \13\:mout) resistor r=75 c=0
Rz6 (net521 \2\:net521) resistor r=75 c=0
Rz7 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz16 (\6\:RNb \7\:RNb) resistor r=75 c=0
Rz15 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (net0363 \2\:net0363) resistor r=75 c=0
Rz12 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz13 (net498 \2\:net498) resistor r=75 c=0
Rz14 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz19 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz20 (\13\:qint \12\:qint) resistor r=75 c=0
Ry13 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry28 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry29 (\3\:VSS \1\:VSS) resistor r=12.4 c=0
Ry30 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry31 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry32 (\14\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\2\:QN \1\:QN) resistor r=62 c=0
Ry20 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry21 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry22 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry23 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry24 (\36\:VDD \34\:VDD) resistor r=62 c=0
Ry25 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry26 (\40\:VDD \39\:VDD) resistor r=62 c=0
Ry27 (\42\:VDD \41\:VDD) resistor r=62 c=0
Ry1 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry3 (Db \2\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\13\:CKNb \14\:CKNb) resistor r=62 c=0
Ry8 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry5 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (\10\:mout \11\:mout) resistor r=62 c=0
Ry7 (\14\:mout \15\:mout) resistor r=62 c=0
Ry12 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry11 (\7\:n35 \8\:n35) resistor r=62 c=0
Ry15 (\21\:qbint \20\:qbint) resistor r=62 c=0
Ry16 (\9\:qint \8\:qint) resistor r=62 c=0
Ry9 (net566 \2\:net566) resistor r=62 c=0
Ry10 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx20 (\2\:RN \4\:RN) resistor r=45 c=0
Rx9 (\3\:SN \9\:SN) resistor r=45 c=0
Rx16 (\7\:SN \10\:SN) resistor r=45 c=0
Rx17 (\5\:SN \11\:SN) resistor r=45 c=0
Rx2 (\2\:SE \7\:SE) resistor r=45 c=0
Rx3 (\5\:SE \8\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \11\:SEb) resistor r=45 c=0
Rx8 (\7\:CKNb \11\:CKNb) resistor r=45 c=0
Rx12 (\8\:CKNbb \9\:CKNbb) resistor r=45 c=0
Rx13 (\6\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx14 (\4\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx15 (\2\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx10 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx11 (\2\:mout \9\:mout) resistor r=45 c=0
Rx19 (\3\:RNb \9\:RNb) resistor r=45 c=0
Rx18 (\3\:n35 \5\:n35) resistor r=45 c=0
Rx21 (\14\:qbint \12\:qbint) resistor r=45 c=0
Rx24 (\23\:qbint \2\:qbint) resistor r=45 c=0
Rx25 (\11\:qint \6\:qint) resistor r=45 c=0
mn10 (\9\:SEb \3\:SE \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.103e-14 ps=6.4e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.09e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn13 (net538 \3\:SI \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=1.16e-14 ps=6.4e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=8.7e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn14 (\6\:Db \6\:SE net538 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=5.075e-14 ps=4.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=7.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn12 (\6\:Db \3\:SEb net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=5.075e-14 ps=5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.5e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn11 (net546 \1\:D \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.025e-14 ad=1.522e-14 ps=1.35e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=2e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn20 (\15\:CKNb \1\:CKN \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.025e-14 ad=4.132e-14 ps=1.35e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2.85e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\17\:CKNbb \10\:CKNb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=2.61e-14 ps=1.66e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60345e-07 sb=1.8e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn25 (\3\:Db CKNbb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.53e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn36 (\5\:n20 \3\:CKNb net582 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.265e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (net582 \3\:mout \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.975e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.16e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn30 (\3\:net521 \1\:SN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.975e-14 ad=2.32e-14 ps=1.39e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=5.65e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\12\:mout n20 \3\:net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=3.6e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\12\:mout \5\:RNb net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\4\:mout \2\:CKNb \9\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.132e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn53 (\9\:n35 \7\:CKNbb net0363 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn51 (\3\:net0363 RNb \3\:net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn52 (\3\:net0363 \3\:qbint net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn50 (net498 \8\:SN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn45 (\17\:qbint \4\:n35 \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.63293e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn22 (\6\:RNb \3\:RN \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.685e-14 ad=2.03e-14 ps=1.53e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.027e-14 ad=4.94e-14 ps=1.27e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=9.66635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(2)
mn57 (\3\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=4.16e-14 ps=9.25e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.61635e-07 sb=4.41635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(2)
mn56 (\12\:qint \13\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp13 (net453 \1\:SI \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.227e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.02791e-07 sb=1.05e-06 sd=160n sca=13.4953 \
        scb=0.011285 scc=0.000140006 m=(1)
mp14 (\8\:Db SEb net453 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.655e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07791e-07 sb=9.45e-07 sd=160n sca=12.2741 \
        scb=0.0094438 scc=0.000122647 m=(1)
mp12 (\8\:Db \4\:SE net461 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.655e-14 ps=9.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.22791e-07 sb=7.3e-07 sd=160n sca=11.0664 \
        scb=0.00830854 scc=0.000119688 m=(1)
mp11 (net461 \3\:D \39\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=5.375e-14 ps=9.3e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.17791e-07 sb=4.35e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp20 (\13\:CKNb \3\:CKN \39\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.375e-14 ad=3.01e-14 ps=9.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11279e-06 sb=1.4e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp21 (\13\:CKNbb \9\:CKNb \37\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp25 (\7\:n20 \8\:CKNb Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=7.203e-14 ps=7.1e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.485e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\14\:mout \4\:SN \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.3178e-13 ad=5.697e-14 ps=2.08e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=6.1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\7\:n20 \3\:CKNbb net486 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.203e-14 ps=5.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.105e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (net486 mout \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3178e-13 ad=1.29e-14 ps=2.08e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp32 (\14\:mout \3\:n20 net478 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=5.697e-14 ps=7.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=3e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp31 (net478 \4\:RNb \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.765e-14 ad=3.332e-14 ps=1.48e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n35 \5\:CKNbb \10\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=5.482e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=4.4e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp53 (\7\:n35 CKNb \3\:net566 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.483e-14 ps=7.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=31.508 scb=0.0252524 \
        scc=0.00399199 m=(1)
mp51 (net414 \2\:RNb \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.69e-14 ad=2.902e-14 ps=1.85e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6.6093e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp52 (net566 qbint net414 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.58e-14 ps=7e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=4.8093e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp50 (net566 \6\:SN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.005e-14 ad=3.58e-14 ps=1.79e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.22326e-07 sb=3.5e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp45 (\20\:qbint n35 \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.005e-14 ad=4.495e-14 ps=1.79e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65726e-07 sb=1.45e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp22 (\10\:RNb \1\:RN \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.22442e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.342e-14 ad=7.41e-14 ps=1.305e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.25385e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(2)
mp57 (\1\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.914e-14 ad=6.24e-14 ps=1.4e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.23141e-07 sb=4.40385e-07 sd=160n sca=31.0979 \
        scb=0.0204275 scc=0.00336106 m=(2)
mp56 (\8\:qint \11\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.333e-14 ad=3.655e-14 ps=1.29e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.69651e-07 sb=1.7e-07 sd=160n sca=18.4729 \
        scb=0.019884 scc=0.000529148 m=(1)
ends SDFFNSRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:26:55 2012 )
// Library name: gsclib045
// Cell name: SDFFNSRX4
// View name: extracted

simulator lang=spectre

subckt SDFFNSRX4 CKN D Q QN RN SE SI SN VDD VSS
mp10 (\8\:SEb \1\:SE \43\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.80233e-07 sd=160n sca=12.896 \
        scb=0.0102095 scc=9.31837e-05 m=(1)
C1 (D VSS) capacitor c=6.42567e-17
C2 (Q VSS) capacitor c=1.72764e-17
C3 (RN VSS) capacitor c=6.42906e-17
C4 (SN VSS) capacitor c=5.2328e-17
C5 (QN VSS) capacitor c=1.70282e-17
C6 (SE VSS) capacitor c=9.69327e-17
C7 (VDD VSS) capacitor c=6.11819e-16
C8 (SI VSS) capacitor c=6.15106e-17
C9 (CKN VSS) capacitor c=7.65708e-17
C10 (SEb VSS) capacitor c=7.24038e-17
C11 (net538 VSS) capacitor c=7.30944e-19
C12 (Db VSS) capacitor c=9.46359e-17
C13 (net546 VSS) capacitor c=1.37725e-18
C14 (CKNb VSS) capacitor c=3.36182e-17
C15 (n20 VSS) capacitor c=8.31386e-17
C16 (CKNbb VSS) capacitor c=3.31064e-17
C17 (net582 VSS) capacitor c=1.44418e-19
C18 (mout VSS) capacitor c=7.14607e-17
C19 (RNb VSS) capacitor c=7.5262e-17
C20 (net521 VSS) capacitor c=9.11345e-17
C21 (n35 VSS) capacitor c=1.88131e-16
C22 (net0363 VSS) capacitor c=7.94011e-17
C23 (net498 VSS) capacitor c=8.79882e-17
C24 (qbint VSS) capacitor c=8.62997e-17
C25 (qint VSS) capacitor c=2.60826e-16
C26 (net461 VSS) capacitor c=4.43802e-18
C27 (net486 VSS) capacitor c=1.28745e-20
C28 (net478 VSS) capacitor c=2.70109e-19
C29 (net566 VSS) capacitor c=1.04721e-16
C30 (net414 VSS) capacitor c=3.22857e-18
C31 (\19\:qbint VSS) capacitor c=5.03102e-17
C32 (\1\:SN VSS) capacitor c=6.77214e-17
C33 (\4\:RNb VSS) capacitor c=7.54919e-17
C34 (\14\:CKNb VSS) capacitor c=5.52462e-17
C35 (\5\:CKNbb VSS) capacitor c=6.39988e-17
C36 (\3\:RN VSS) capacitor c=2.86854e-17
C37 (\5\:SN VSS) capacitor c=3.55722e-17
C38 (\9\:CKNb VSS) capacitor c=3.69162e-17
C39 (\1\:CKN VSS) capacitor c=4.23419e-17
C40 (\1\:D VSS) capacitor c=7.21185e-17
C41 (\6\:SE VSS) capacitor c=4.30895e-17
C42 (\3\:SEb VSS) capacitor c=4.74268e-17
C43 (\1\:SI VSS) capacitor c=8.33925e-17
C44 (\1\:SE VSS) capacitor c=5.83772e-17
C45 (\17\:qbint VSS) capacitor c=2.21712e-17
C46 (\4\:qbint VSS) capacitor c=2.55093e-16
C47 (\2\:SN VSS) capacitor c=1.64253e-16
C48 (\3\:qbint VSS) capacitor c=3.92617e-17
C49 (\6\:RNb VSS) capacitor c=4.05003e-17
C50 (\4\:CKNbb VSS) capacitor c=5.66576e-17
C51 (\11\:CKNb VSS) capacitor c=5.1792e-17
C52 (\1\:RN VSS) capacitor c=3.7742e-17
C53 (\3\:SN VSS) capacitor c=1.40868e-16
C54 (\3\:n20 VSS) capacitor c=6.08299e-17
C55 (\2\:RNb VSS) capacitor c=6.8016e-17
C56 (\5\:CKNb VSS) capacitor c=2.80523e-17
C57 (\2\:mout VSS) capacitor c=6.0791e-17
C58 (\3\:CKNb VSS) capacitor c=4.80839e-17
C59 (\3\:CKNbb VSS) capacitor c=5.98954e-17
C60 (\3\:CKN VSS) capacitor c=2.76455e-17
C61 (\3\:D VSS) capacitor c=3.33568e-17
C62 (\4\:SE VSS) capacitor c=5.55533e-17
C63 (\3\:SI VSS) capacitor c=6.05052e-17
C64 (\3\:SE VSS) capacitor c=2.3579e-17
C65 (\18\:qbint VSS) capacitor c=3.75706e-17
C66 (\2\:qbint VSS) capacitor c=5.83344e-17
C67 (\5\:RNb VSS) capacitor c=5.67286e-17
C68 (\13\:CKNb VSS) capacitor c=2.15564e-17
C69 (\6\:CKNbb VSS) capacitor c=2.06487e-17
C70 (\12\:CKNb VSS) capacitor c=3.47246e-17
C71 (\2\:RN VSS) capacitor c=3.01434e-17
C72 (\3\:RNb VSS) capacitor c=4.31997e-17
C73 (\4\:SN VSS) capacitor c=4.94617e-17
C74 (\2\:n20 VSS) capacitor c=2.8977e-17
C75 (\10\:CKNb VSS) capacitor c=2.67168e-17
C76 (\7\:CKNb VSS) capacitor c=1.80065e-17
C77 (\3\:mout VSS) capacitor c=2.69688e-17
C78 (\4\:CKNb VSS) capacitor c=4.74118e-17
C79 (\2\:CKNbb VSS) capacitor c=5.99295e-17
C80 (\2\:CKNb VSS) capacitor c=3.16095e-17
C81 (\2\:CKN VSS) capacitor c=4.06077e-17
C82 (\2\:D VSS) capacitor c=6.15012e-17
C83 (\7\:SE VSS) capacitor c=5.22459e-17
C84 (\2\:SEb VSS) capacitor c=7.95596e-17
C85 (\5\:SE VSS) capacitor c=4.26455e-17
C86 (\2\:SI VSS) capacitor c=6.21177e-17
C87 (\2\:SE VSS) capacitor c=5.76876e-17
C88 (\20\:qint VSS) capacitor c=4.14222e-17
C89 (\25\:qbint VSS) capacitor c=6.52839e-17
C90 (\24\:VDD VSS) capacitor c=4.41177e-17
C91 (\3\:net566 VSS) capacitor c=1.01016e-16
C92 (\12\:n35 VSS) capacitor c=4.0174e-17
C93 (\6\:mout VSS) capacitor c=1.73805e-16
C94 (\11\:RNb VSS) capacitor c=5.61626e-17
C95 (\28\:VDD VSS) capacitor c=3.90547e-17
C96 (\8\:mout VSS) capacitor c=1.62739e-16
C97 (\32\:VDD VSS) capacitor c=2.21048e-17
C98 (\8\:CKNbb VSS) capacitor c=2.55511e-16
C99 (\35\:VDD VSS) capacitor c=2.72892e-17
C100 (\5\:n20 VSS) capacitor c=1.7659e-16
C101 (\3\:Db VSS) capacitor c=1.38827e-16
C102 (\21\:CKNb VSS) capacitor c=9.50404e-17
C103 (\39\:VDD VSS) capacitor c=1.72891e-17
C104 (\5\:Db VSS) capacitor c=1.42681e-16
C105 (\43\:VDD VSS) capacitor c=3.08078e-17
C106 (\8\:SEb VSS) capacitor c=1.45291e-17
C107 (\1\:VDD VSS) capacitor c=2.55142e-16
C108 (\16\:qint VSS) capacitor c=3.09026e-17
C109 (\1\:QN VSS) capacitor c=1.2403e-16
C110 (\1\:Q VSS) capacitor c=1.20739e-16
C111 (\27\:qbint VSS) capacitor c=2.05674e-17
C112 (\3\:net0363 VSS) capacitor c=1.04188e-16
C113 (\3\:net498 VSS) capacitor c=8.57494e-17
C114 (\10\:n35 VSS) capacitor c=5.9424e-17
C115 (\4\:mout VSS) capacitor c=8.95096e-17
C116 (\8\:RNb VSS) capacitor c=2.2151e-16
C117 (\3\:net521 VSS) capacitor c=9.78736e-17
C118 (\11\:mout VSS) capacitor c=6.42495e-17
C119 (\12\:CKNbb VSS) capacitor c=4.65282e-17
C120 (\7\:n20 VSS) capacitor c=9.86698e-17
C121 (\18\:CKNb VSS) capacitor c=1.02999e-16
C122 (\7\:Db VSS) capacitor c=1.16518e-16
C123 (\6\:SEb VSS) capacitor c=6.89497e-17
C124 (\6\:CKNb VSS) capacitor c=1.09179e-17
C125 (\8\:CKNb VSS) capacitor c=1.73575e-17
C126 (\4\:SI VSS) capacitor c=4.00008e-17
C127 (\4\:SEb VSS) capacitor c=5.57053e-17
C128 (\5\:SEb VSS) capacitor c=7.74025e-17
C129 (\8\:SE VSS) capacitor c=1.35916e-16
C130 (\9\:SE VSS) capacitor c=4.69111e-17
C131 (\10\:SE VSS) capacitor c=4.94304e-17
C132 (\11\:SE VSS) capacitor c=3.70989e-17
C133 (\4\:D VSS) capacitor c=6.98789e-17
C134 (\4\:CKN VSS) capacitor c=5.92615e-17
C135 (\15\:CKNb VSS) capacitor c=4.78466e-17
C136 (\16\:CKNb VSS) capacitor c=8.35092e-17
C137 (\17\:CKNb VSS) capacitor c=1.15992e-16
C138 (\20\:CKNb VSS) capacitor c=7.97916e-17
C139 (\4\:n20 VSS) capacitor c=1.86176e-16
C140 (\6\:SN VSS) capacitor c=6.7101e-17
C141 (\4\:RN VSS) capacitor c=5.86491e-17
C142 (\10\:mout VSS) capacitor c=1.41776e-16
C143 (\13\:mout VSS) capacitor c=1.00972e-16
C144 (\7\:CKNbb VSS) capacitor c=2.66014e-16
C145 (\10\:CKNbb VSS) capacitor c=6.74695e-17
C146 (\11\:CKNbb VSS) capacitor c=6.9345e-17
C147 (\23\:CKNb VSS) capacitor c=8.28245e-17
C148 (\24\:CKNb VSS) capacitor c=3.21074e-16
C149 (\25\:CKNb VSS) capacitor c=2.54526e-16
C150 (\26\:CKNb VSS) capacitor c=6.08443e-17
C151 (\7\:RNb VSS) capacitor c=1.98942e-16
C152 (\10\:RNb VSS) capacitor c=8.10214e-17
C153 (\8\:n35 VSS) capacitor c=1.42928e-16
C154 (\9\:n35 VSS) capacitor c=1.71681e-16
C155 (\6\:Q VSS) capacitor c=1.68867e-16
C156 (\5\:QN VSS) capacitor c=1.50725e-16
C157 (\20\:qbint VSS) capacitor c=2.64556e-16
C158 (\21\:qbint VSS) capacitor c=1.99775e-16
C159 (\22\:qbint VSS) capacitor c=3.7642e-17
C160 (\23\:qbint VSS) capacitor c=5.87653e-17
C161 (\24\:qbint VSS) capacitor c=2.29194e-17
C162 (\29\:qbint VSS) capacitor c=1.74305e-17
C163 (\18\:qint VSS) capacitor c=5.41024e-17
C164 (\19\:qint VSS) capacitor c=3.4401e-17
C165 (\3\:VDD VSS) capacitor c=4.29721e-16
C166 (\23\:VDD VSS) capacitor c=2.13303e-17
C167 (\27\:VDD VSS) capacitor c=5.67437e-17
C168 (\31\:VDD VSS) capacitor c=9.04428e-18
C169 (\34\:VDD VSS) capacitor c=8.58717e-18
C170 (\42\:VDD VSS) capacitor c=3.08988e-18
Rk9 (D \4\:D) resistor r=0.2014 c=0
Rk47 (\1\:Q Q) resistor r=0.218 c=0
Rk48 (Q \6\:Q) resistor r=0.03303 c=0
Rk23 (\4\:RN RN) resistor r=0.2629 c=0
Rk22 (SN \6\:SN) resistor r=0.1163 c=0
Rk52 (\1\:QN QN) resistor r=0.2356 c=0
Rk53 (QN \5\:QN) resistor r=0.0584 c=0
Rk5 (\8\:SE SE) resistor r=0.8605 c=0
Rk6 (SE \9\:SE) resistor r=0.03995 c=0
Rk7 (\9\:SE \10\:SE) resistor r=0.2597 c=0
Rk8 (\9\:SE \11\:SE) resistor r=0.1343 c=0
Rk93 (\2\:VDD \3\:VDD) resistor r=0.193 c=0
Rk107 (\3\:VDD \23\:VDD) resistor r=0.2731 c=0
Rk108 (\23\:VDD \25\:VDD) resistor r=0.2872 c=0
Rk109 (\23\:VDD \26\:VDD) resistor r=0.3485 c=0
Rk110 (\26\:VDD \27\:VDD) resistor r=0.622 c=0
Rk111 (\27\:VDD \29\:VDD) resistor r=0.1029 c=0
Rk112 (\27\:VDD \30\:VDD) resistor r=0.3309 c=0
Rk113 (\30\:VDD \31\:VDD) resistor r=0.1218 c=0
Rk114 (\31\:VDD \33\:VDD) resistor r=0.04333 c=0
Rk115 (\31\:VDD \34\:VDD) resistor r=0.2144 c=0
Rk116 (\34\:VDD \36\:VDD) resistor r=0.1029 c=0
Rk117 (\34\:VDD \37\:VDD) resistor r=0.3134 c=0
Rk118 (\37\:VDD \38\:VDD) resistor r=0.3034 c=0
Rk119 (\38\:VDD \40\:VDD) resistor r=0.07416 c=0
Rk120 (\38\:VDD \41\:VDD) resistor r=0.198 c=0
Rk121 (\41\:VDD \42\:VDD) resistor r=0.2181 c=0
Rk122 (\42\:VDD \44\:VDD) resistor r=0.1914 c=0
Rk124 (\45\:VDD VDD) resistor r=0.1001 c=0
Rk123 (\42\:VDD \45\:VDD) resistor r=0.1328 c=0
Rk1 (\4\:SI SI) resistor r=0.04057 c=0
Rk66 (\2\:VSS \3\:VSS) resistor r=0.1202 c=0
Rk74 (\3\:VSS \11\:VSS) resistor r=0.3711 c=0
Rk75 (\11\:VSS \12\:VSS) resistor r=0.5944 c=0
Rk76 (\12\:VSS \13\:VSS) resistor r=0.3585 c=0
Rk77 (\13\:VSS \14\:VSS) resistor r=0.5407 c=0
Rk78 (\14\:VSS \15\:VSS) resistor r=0.611 c=0
Rk79 (\15\:VSS \16\:VSS) resistor r=0.0851 c=0
Rk80 (\16\:VSS \17\:VSS) resistor r=0.4637 c=0
Rk82 (\18\:VSS VSS) resistor r=0.04992 c=0
Rk81 (\17\:VSS \18\:VSS) resistor r=0.1027 c=0
Rk89 (\12\:VSS \32\:VSS) resistor r=0.228 c=0
Rk90 (\14\:VSS \34\:VSS) resistor r=0.04333 c=0
Rk91 (\16\:VSS \36\:VSS) resistor r=0.3246 c=0
Rk92 (\17\:VSS \38\:VSS) resistor r=0.2463 c=0
Rk10 (CKN \4\:CKN) resistor r=0.1714 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.3683 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.6748 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04813 c=0
Rk11 (\2\:Db \4\:Db) resistor r=0.488 c=0
Rk12 (\4\:Db \6\:Db) resistor r=0.7845 c=0
Rk13 (\6\:Db \8\:Db) resistor r=0.5667 c=0
Rk14 (\15\:CKNb \16\:CKNb) resistor r=0.2499 c=0
Rk15 (\16\:CKNb \17\:CKNb) resistor r=0.481 c=0
Rk16 (\17\:CKNb \19\:CKNb) resistor r=0.3538 c=0
Rk17 (\17\:CKNb \20\:CKNb) resistor r=0.3732 c=0
Rk18 (\19\:CKNb \22\:CKNb) resistor r=0.5788 c=0
Rk33 (\23\:CKNb \24\:CKNb) resistor r=0.3685 c=0
Rk34 (\24\:CKNb \25\:CKNb) resistor r=1.7794 c=0
Rk35 (\24\:CKNb \26\:CKNb) resistor r=0.422 c=0
Rk19 (\4\:n20 \6\:n20) resistor r=1.3129 c=0
Rk20 (\6\:n20 \8\:n20) resistor r=0.4705 c=0
Rk29 (\7\:CKNbb \9\:CKNbb) resistor r=1.9431 c=0
Rk30 (\9\:CKNbb \10\:CKNbb) resistor r=0.1391 c=0
Rk31 (\10\:CKNbb \11\:CKNbb) resistor r=0.3859 c=0
Rk32 (\10\:CKNbb \13\:CKNbb) resistor r=0.2541 c=0
Rk24 (\5\:mout \7\:mout) resistor r=0.4434 c=0
Rk25 (\7\:mout \9\:mout) resistor r=0.8606 c=0
Rk26 (\9\:mout \10\:mout) resistor r=0.4776 c=0
Rk27 (\10\:mout \12\:mout) resistor r=0.2253 c=0
Rk28 (\10\:mout \13\:mout) resistor r=0.8518 c=0
Rk36 (\7\:RNb \9\:RNb) resistor r=1.2189 c=0
Rk37 (\9\:RNb \10\:RNb) resistor r=0.7067 c=0
Rk38 (\9\:RNb \12\:RNb) resistor r=0.3508 c=0
Rk21 (\2\:net521 \4\:net521) resistor r=0.4636 c=0
Rk42 (\8\:n35 \9\:n35) resistor r=1.0156 c=0
Rk43 (\9\:n35 \11\:n35) resistor r=0.25 c=0
Rk44 (\9\:n35 \13\:n35) resistor r=0.1305 c=0
Rk39 (\2\:net0363 \4\:net0363) resistor r=0.3236 c=0
Rk40 (\2\:net498 \4\:net498) resistor r=0.4095 c=0
Rk56 (\20\:qbint \21\:qbint) resistor r=2.0416 c=0
Rk57 (\21\:qbint \22\:qbint) resistor r=0.08306 c=0
Rk58 (\22\:qbint \23\:qbint) resistor r=0.3426 c=0
Rk59 (\21\:qbint \24\:qbint) resistor r=0.09617 c=0
Rk60 (\24\:qbint \26\:qbint) resistor r=0.2737 c=0
Rk61 (\22\:qbint \28\:qbint) resistor r=0.05853 c=0
Rk62 (\24\:qbint \29\:qbint) resistor r=0.2041 c=0
Rk63 (\17\:qint \18\:qint) resistor r=0.3995 c=0
Rk64 (\18\:qint \19\:qint) resistor r=0.2082 c=0
Rk65 (\18\:qint \21\:qint) resistor r=0.1833 c=0
Rk41 (\2\:net566 \4\:net566) resistor r=0.679 c=0
Rl9 (\1\:D \2\:D) resistor r=186.333 c=0
Rl10 (\2\:D \3\:D) resistor r=43.7671 c=0
Rl29 (\2\:RN \3\:RN) resistor r=60.7713 c=0
Rl28 (\1\:RN \2\:RN) resistor r=45.708 c=0
Rl38 (\1\:SN \2\:SN) resistor r=223.077 c=0
Rl39 (\2\:SN \3\:SN) resistor r=928.412 c=0
Rl41 (\4\:SN \5\:SN) resistor r=60.7713 c=0
Rl40 (\3\:SN \4\:SN) resistor r=189.939 c=0
Rl8 (\6\:SE \7\:SE) resistor r=79.5379 c=0
Rl5 (\4\:SE \5\:SE) resistor r=47.3097 c=0
Rl1 (\1\:SE \2\:SE) resistor r=251.489 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl3 (\1\:SI \2\:SI) resistor r=144.923 c=0
Rl4 (\2\:SI \3\:SI) resistor r=85.3072 c=0
Rl11 (\1\:CKN \2\:CKN) resistor r=109.615 c=0
Rl12 (\2\:CKN \3\:CKN) resistor r=59.0659 c=0
Rl6 (SEb \2\:SEb) resistor r=263.567 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl33 (\13\:CKNb \14\:CKNb) resistor r=120.667 c=0
Rl30 (\11\:CKNb \12\:CKNb) resistor r=37.6944 c=0
Rl16 (\3\:CKNb \4\:CKNb) resistor r=29.5379 c=0
Rl13 (CKNb \2\:CKNb) resistor r=64.1533 c=0
Rl19 (\5\:CKNb \6\:CKNb) resistor r=49.7141 c=0
Rl20 (\6\:CKNb \7\:CKNb) resistor r=1.2666 c=0
Rl22 (\8\:CKNb \9\:CKNb) resistor r=35.7866 c=0
Rl23 (\8\:CKNb \10\:CKNb) resistor r=92.8494 c=0
Rl21 (\6\:CKNb \8\:CKNb) resistor r=44.8859 c=0
Rl25 (n20 \3\:n20) resistor r=123.077 c=0
Rl24 (n20 \2\:n20) resistor r=139.617 c=0
Rl31 (\4\:CKNbb \5\:CKNbb) resistor r=176.054 c=0
Rl32 (\5\:CKNbb \6\:CKNbb) resistor r=64.1533 c=0
Rl14 (CKNbb \2\:CKNbb) resistor r=24.7951 c=0
Rl15 (\2\:CKNbb \3\:CKNbb) resistor r=172.62 c=0
Rl17 (mout \2\:mout) resistor r=169.231 c=0
Rl18 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl26 (RNb \2\:RNb) resistor r=143.796 c=0
Rl34 (\4\:RNb \5\:RNb) resistor r=138.439 c=0
Rl35 (\5\:RNb \6\:RNb) resistor r=80.5643 c=0
Rl27 (\2\:RNb \3\:RNb) resistor r=249.513 c=0
Rl75 (\18\:qbint \19\:qbint) resistor r=110.555 c=0
Rl74 (\18\:qbint \17\:qbint) resistor r=34.6284 c=0
Rl36 (\2\:qbint qbint) resistor r=164.153 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=33.3841 c=0
Rz33 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz34 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz36 (\26\:VDD \1\:VDD) resistor r=6.25 c=0
Rz37 (\30\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz38 (\37\:VDD \1\:VDD) resistor r=12.5 c=0
Rz39 (\41\:VDD \1\:VDD) resistor r=18.75 c=0
Rz40 (\45\:VDD \1\:VDD) resistor r=25 c=0
Rz29 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz30 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz4 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz5 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (\12\:CKNbb \13\:CKNbb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz6 (net521 \2\:net521) resistor r=75 c=0
Rz7 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz16 (\11\:n35 \10\:n35) resistor r=75 c=0
Rz12 (net0363 \2\:net0363) resistor r=75 c=0
Rz13 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz14 (net498 \2\:net498) resistor r=75 c=0
Rz15 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz21 (\28\:qbint \27\:qbint) resistor r=75 c=0
Rz22 (\17\:qint \16\:qint) resistor r=75 c=0
Ry33 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry34 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry35 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry36 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry37 (\40\:VDD \39\:VDD) resistor r=62 c=0
Ry38 (\44\:VDD \43\:VDD) resistor r=62 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry20 (\3\:VSS \1\:VSS) resistor r=4.7692 c=0
Ry22 (\11\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry23 (\13\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry24 (\15\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry25 (\18\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\5\:Db \6\:Db) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry8 (\8\:CKNbb \9\:CKNbb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry12 (\13\:n35 \12\:n35) resistor r=62 c=0
Ry17 (\26\:qbint \25\:qbint) resistor r=31 c=0
Ry18 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Ry10 (net566 \2\:net566) resistor r=62 c=0
Ry11 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx13 (\2\:RN \4\:RN) resistor r=45 c=0
Rx12 (\4\:SN \6\:SN) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\7\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\4\:CKNb \16\:CKNb) resistor r=45 c=0
Rx10 (\2\:CKNb \20\:CKNb) resistor r=45 c=0
Rx17 (\12\:CKNb \23\:CKNb) resistor r=45 c=0
Rx18 (\10\:CKNb \25\:CKNb) resistor r=45 c=0
Rx19 (\13\:CKNb \26\:CKNb) resistor r=45 c=0
Rx11 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx15 (\6\:CKNbb \7\:CKNbb) resistor r=45 c=0
Rx16 (\2\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx14 (\3\:mout \13\:mout) resistor r=45 c=0
Rx20 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx21 (\3\:RNb \10\:RNb) resistor r=45 c=0
Rx22 (\8\:n35 n35) resistor r=45 c=0
Rx23 (\20\:qbint \18\:qbint) resistor r=45 c=0
Rx24 (\23\:qbint \2\:qbint) resistor r=45 c=0
Rx25 (\29\:qbint \4\:qbint) resistor r=45 c=0
Rx26 (\19\:qint qint) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.88e-14 ad=2.465e-14 ps=1.12e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.43448e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn13 (net538 \3\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.88e-14 ad=8.7e-15 ps=1.12e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=9.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn14 (\7\:Db \4\:SE net538 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=8.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn12 (\7\:Db SEb net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=3.698e-14 ps=5.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net546 \3\:D \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=1.595e-14 ps=6.9e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=3.85e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn20 (\18\:CKNb \3\:CKN \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (Db \3\:CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.698e-14 ps=7.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=8.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKNb net582 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=3.045e-14 ps=5.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net582 \2\:mout \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.877e-14 ad=1.667e-14 ps=1.85e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=4.1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\12\:CKNbb \5\:CKNb \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.877e-14 ad=2.03e-14 ps=1.85e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn31 (\11\:mout \2\:RNb net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.32e-14 ps=7.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=1.24e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn32 (\11\:mout \3\:n20 \3\:net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.482e-14 ad=2.32e-14 ps=1.46e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.035e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\3\:net521 \3\:SN \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.75e-14 ad=8.482e-14 ps=9.9e-07 pd=1.46e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=4.05e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn22 (\8\:RNb \1\:RN \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\4\:mout \11\:CKNb \10\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn53 (\10\:n35 \4\:CKNbb net0363 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\3\:net0363 \6\:RNb \3\:net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.9e-14 ad=2.392e-14 ps=6.9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn52 (\3\:net0363 \3\:qbint net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn50 (net498 \2\:SN \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2e-06 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn45_1__rcx (\27\:qbint n35 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.861e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.09268e-07 sb=2e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(2)
mn55_1__rcx (\1\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.061e-14 ad=4.16e-14 ps=1.3475e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.39135e-07 sb=2e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
mn57_1__rcx (\1\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.342e-14 ad=4.16e-14 ps=1.3475e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70346e-06 sb=1.165e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(4)
mn56 (\16\:qint \17\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mp13 (net453 \1\:SI \43\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75233e-07 sd=160n sca=11.1175 \
        scb=0.00789061 scc=7.80015e-05 m=(1)
mp14 (\5\:Db \3\:SEb net453 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.70233e-07 sd=160n sca=10.6702 \
        scb=0.0075867 scc=7.76926e-05 m=(1)
mp12 (\5\:Db \6\:SE net461 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=6.128e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=3.40233e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp11 (net461 \1\:D \39\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.215e-14 ad=2.473e-14 ps=1.73e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.80233e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp20 (\21\:CKNb \1\:CKN \39\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.215e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.61628e-07 sb=1.6e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp25 (\5\:n20 CKNb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.73e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.73488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp36 (\5\:n20 CKNbb net486 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.73e-14 ps=7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.08488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp35 (net486 mout \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.86e-14 ad=2.903e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.28488e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp21 (\8\:CKNbb \9\:CKNb \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.86e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05814e-07 sb=1.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp31 (net478 RNb \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.205e-14 ad=1.29e-14 ps=2.66e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83721e-07 sb=1.11e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp32 (\8\:mout n20 net478 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.88721e-07 sb=1.005e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout \5\:SN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6557e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.93721e-07 sb=8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\11\:RNb \3\:RN \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6557e-13 ad=3.44e-14 ps=2.79e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13372e-06 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\12\:n35 \5\:CKNbb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=3.45e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp53 (\12\:n35 \14\:CKNb \3\:net566 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=15.6338 scb=0.015455 \
        scc=0.000959319 m=(1)
mp51 (net414 \4\:RNb \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp52 (net566 qbint net414 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (net566 \1\:SN \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.863e-14 ad=3.44e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp45_1__rcx (\25\:qbint n35 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.776e-14 ad=4.96e-14 ps=1.165e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.64677e-07 sb=2e-06 sd=160n sca=15.9771 \
        scb=0.0149994 scc=0.00109313 m=(2)
mp57_1__rcx (\5\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64724e-06 sb=9.85e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(4)
mp55_1__rcx (\6\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.352e-14 ad=7.312e-14 ps=1.115e-06 pd=1.155e-06 \
        nrd=1.16667 nrs=1.16667 sa=8.19103e-07 sb=1.86e-06 sd=160n \
        sca=25.6993 scb=0.0190507 scc=0.00277827 m=(4)
mp56 (\20\:qint \19\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96308e-06 sb=1.4e-07 sd=160n sca=27.1678 \
        scb=0.0200607 scc=0.00278 m=(1)
ends SDFFNSRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:27:33 2012 )
// Library name: gsclib045
// Cell name: SDFFNSRXL
// View name: extracted

simulator lang=spectre

subckt SDFFNSRXL CKN D Q QN RN SE SI SN VDD VSS
mp57 (\1\:QN \4\:qint \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
C1 (QN VSS) capacitor c=2.29659e-17
C2 (CKN VSS) capacitor c=5.73794e-17
C3 (SN VSS) capacitor c=2.70228e-16
C4 (SI VSS) capacitor c=7.71159e-17
C5 (VDD VSS) capacitor c=4.9362e-16
C6 (D VSS) capacitor c=6.5895e-17
C7 (Q VSS) capacitor c=2.68356e-17
C8 (RN VSS) capacitor c=9.92959e-17
C9 (qint VSS) capacitor c=2.2096e-17
C10 (qbint VSS) capacitor c=4.02273e-17
C11 (RNb VSS) capacitor c=6.14778e-17
C12 (n35 VSS) capacitor c=4.22218e-17
C13 (net498 VSS) capacitor c=7.65242e-17
C14 (net0363 VSS) capacitor c=1.09596e-16
C15 (CKNbb VSS) capacitor c=2.66696e-17
C16 (mout VSS) capacitor c=5.62335e-17
C17 (CKNb VSS) capacitor c=3.84346e-17
C18 (net521 VSS) capacitor c=7.2809e-17
C19 (n20 VSS) capacitor c=5.33448e-17
C20 (Db VSS) capacitor c=4.30653e-17
C21 (net546 VSS) capacitor c=5.48097e-18
C22 (SEb VSS) capacitor c=2.75349e-17
C23 (net566 VSS) capacitor c=1.03685e-16
C24 (net414 VSS) capacitor c=4.37718e-18
C25 (net478 VSS) capacitor c=3.50425e-18
C26 (net486 VSS) capacitor c=1.12332e-18
C27 (net453 VSS) capacitor c=4.7683e-18
C28 (\5\:SE VSS) capacitor c=5.01218e-17
C29 (\1\:SI VSS) capacitor c=4.70173e-17
C30 (\2\:SE VSS) capacitor c=5.12513e-17
C31 (\1\:D VSS) capacitor c=4.68427e-17
C32 (\1\:CKN VSS) capacitor c=5.11274e-17
C33 (\3\:CKNb VSS) capacitor c=1.62697e-17
C34 (\11\:CKNb VSS) capacitor c=3.25249e-17
C35 (\8\:CKNbb VSS) capacitor c=5.43656e-17
C36 (\5\:SN VSS) capacitor c=5.60439e-17
C37 (\4\:RNb VSS) capacitor c=5.66909e-17
C38 (\2\:CKNb VSS) capacitor c=4.75485e-17
C39 (\2\:RNb VSS) capacitor c=4.56172e-17
C40 (\8\:qbint VSS) capacitor c=6.08994e-17
C41 (\1\:SN VSS) capacitor c=3.34276e-17
C42 (\1\:RN VSS) capacitor c=3.76211e-17
C43 (\7\:qbint VSS) capacitor c=2.61784e-17
C44 (\4\:qint VSS) capacitor c=2.91458e-17
C45 (\7\:SE VSS) capacitor c=2.43647e-17
C46 (\3\:SI VSS) capacitor c=7.42621e-17
C47 (\3\:SE VSS) capacitor c=6.61976e-17
C48 (\3\:SEb VSS) capacitor c=5.14709e-17
C49 (\3\:D VSS) capacitor c=2.44104e-17
C50 (\3\:CKN VSS) capacitor c=3.04987e-17
C51 (\10\:CKNb VSS) capacitor c=2.7688e-17
C52 (\5\:CKNbb VSS) capacitor c=4.35624e-17
C53 (\6\:CKNb VSS) capacitor c=1.53009e-16
C54 (\3\:mout VSS) capacitor c=6.95458e-17
C55 (\7\:SN VSS) capacitor c=6.4813e-17
C56 (\3\:n20 VSS) capacitor c=3.68917e-17
C57 (\6\:RNb VSS) capacitor c=5.18963e-17
C58 (\8\:CKNb VSS) capacitor c=2.635e-17
C59 (\3\:CKNbb VSS) capacitor c=4.78946e-17
C60 (\9\:qbint VSS) capacitor c=5.68608e-17
C61 (\4\:SN VSS) capacitor c=4.9358e-17
C62 (\3\:n35 VSS) capacitor c=3.614e-17
C63 (\3\:RN VSS) capacitor c=4.26881e-17
C64 (\6\:qbint VSS) capacitor c=2.35479e-17
C65 (\4\:qbint VSS) capacitor c=1.97568e-17
C66 (\3\:qint VSS) capacitor c=2.53189e-17
C67 (\6\:SE VSS) capacitor c=4.07481e-17
C68 (\2\:SI VSS) capacitor c=4.38971e-17
C69 (\2\:SEb VSS) capacitor c=7.94702e-17
C70 (\4\:SE VSS) capacitor c=5.00935e-17
C71 (\1\:SE VSS) capacitor c=4.19994e-17
C72 (\2\:D VSS) capacitor c=3.82302e-17
C73 (\2\:CKN VSS) capacitor c=3.72112e-17
C74 (\9\:CKNb VSS) capacitor c=1.13738e-17
C75 (\7\:CKNbb VSS) capacitor c=4.35687e-17
C76 (\6\:CKNbb VSS) capacitor c=3.3054e-17
C77 (\2\:mout VSS) capacitor c=5.60648e-17
C78 (\6\:SN VSS) capacitor c=3.59118e-17
C79 (\2\:n20 VSS) capacitor c=3.51452e-17
C80 (\4\:CKNbb VSS) capacitor c=4.47728e-17
C81 (\5\:RNb VSS) capacitor c=2.95491e-17
C82 (\7\:CKNb VSS) capacitor c=7.08235e-17
C83 (\3\:RNb VSS) capacitor c=2.2359e-17
C84 (\10\:qbint VSS) capacitor c=2.7037e-17
C85 (\3\:SN VSS) capacitor c=2.62424e-17
C86 (\2\:n35 VSS) capacitor c=3.55459e-17
C87 (\2\:RN VSS) capacitor c=4.06389e-17
C88 (\5\:qbint VSS) capacitor c=1.75407e-17
C89 (\6\:SEb VSS) capacitor c=1.07763e-16
C90 (\8\:VDD VSS) capacitor c=2.37149e-17
C91 (\6\:Db VSS) capacitor c=7.05783e-17
C92 (\10\:VDD VSS) capacitor c=3.96607e-17
C93 (\14\:CKNb VSS) capacitor c=9.04486e-17
C94 (\12\:VDD VSS) capacitor c=1.00283e-17
C95 (\11\:CKNbb VSS) capacitor c=1.11021e-16
C96 (\8\:Db VSS) capacitor c=1.12941e-16
C97 (\4\:n20 VSS) capacitor c=6.59448e-17
C98 (\16\:VDD VSS) capacitor c=1.26933e-17
C99 (\10\:mout VSS) capacitor c=3.59404e-17
C100 (\20\:VDD VSS) capacitor c=2.15075e-17
C101 (\8\:mout VSS) capacitor c=6.64039e-17
C102 (\8\:n35 VSS) capacitor c=4.62413e-17
C103 (\23\:VDD VSS) capacitor c=3.18362e-17
C104 (\3\:net566 VSS) capacitor c=1.03266e-16
C105 (\27\:VDD VSS) capacitor c=2.76137e-17
C106 (\16\:qbint VSS) capacitor c=6.87872e-17
C107 (\9\:RNb VSS) capacitor c=1.50898e-16
C108 (\30\:VDD VSS) capacitor c=3.8921e-17
C109 (\5\:qint VSS) capacitor c=2.5433e-17
C110 (\34\:VDD VSS) capacitor c=4.06277e-17
C111 (\1\:QN VSS) capacitor c=1.977e-17
C112 (\1\:VDD VSS) capacitor c=1.91494e-16
C113 (\4\:SEb VSS) capacitor c=7.86084e-17
C114 (\18\:CKNb VSS) capacitor c=5.03148e-17
C115 (\9\:CKNbb VSS) capacitor c=7.47761e-17
C116 (\4\:Db VSS) capacitor c=1.96785e-16
C117 (\7\:n20 VSS) capacitor c=3.47496e-17
C118 (\12\:mout VSS) capacitor c=2.82332e-17
C119 (\3\:net521 VSS) capacitor c=8.28038e-17
C120 (\14\:mout VSS) capacitor c=4.14543e-17
C121 (\4\:n35 VSS) capacitor c=9.11368e-17
C122 (\3\:net0363 VSS) capacitor c=1.16061e-16
C123 (\3\:net498 VSS) capacitor c=6.73736e-17
C124 (\14\:qbint VSS) capacitor c=4.50015e-17
C125 (\11\:RNb VSS) capacitor c=1.09888e-16
C126 (\4\:Q VSS) capacitor c=8.2822e-17
C127 (\9\:qint VSS) capacitor c=2.94544e-17
C128 (\3\:QN VSS) capacitor c=4.27533e-17
C129 (\2\:qint VSS) capacitor c=1.32808e-17
C130 (\2\:qbint VSS) capacitor c=3.45466e-17
C131 (\3\:qbint VSS) capacitor c=4.41112e-17
C132 (\2\:SN VSS) capacitor c=2.40098e-17
C133 (\2\:CKNbb VSS) capacitor c=4.40101e-17
C134 (\7\:qint VSS) capacitor c=2.24744e-17
C135 (\8\:qint VSS) capacitor c=3.63241e-17
C136 (\3\:Q VSS) capacitor c=6.37913e-17
C137 (\4\:CKNb VSS) capacitor c=1.8658e-17
C138 (\5\:CKNb VSS) capacitor c=6.92051e-17
C139 (\11\:qbint VSS) capacitor c=5.09383e-17
C140 (\12\:qbint VSS) capacitor c=1.19307e-16
C141 (\13\:qbint VSS) capacitor c=1.17814e-16
C142 (\6\:n35 VSS) capacitor c=1.92103e-16
C143 (\7\:n35 VSS) capacitor c=1.34815e-16
C144 (\12\:CKNb VSS) capacitor c=9.71193e-17
C145 (\13\:CKNb VSS) capacitor c=1.11776e-16
C146 (\7\:RNb VSS) capacitor c=1.55163e-16
C147 (\8\:RNb VSS) capacitor c=2.31169e-16
C148 (\8\:SN VSS) capacitor c=2.66802e-16
C149 (\9\:SN VSS) capacitor c=3.56952e-17
C150 (\4\:mout VSS) capacitor c=5.11714e-17
C151 (\5\:mout VSS) capacitor c=5.49111e-17
C152 (\6\:mout VSS) capacitor c=6.00586e-17
C153 (\7\:mout VSS) capacitor c=6.83481e-17
C154 (\6\:n20 VSS) capacitor c=8.81245e-17
C155 (\9\:n20 VSS) capacitor c=8.0084e-17
C156 (\13\:CKNbb VSS) capacitor c=1.48248e-16
C157 (\14\:CKNbb VSS) capacitor c=6.45564e-17
C158 (\15\:CKNbb VSS) capacitor c=5.45437e-17
C159 (\16\:CKNbb VSS) capacitor c=1.69554e-16
C160 (\4\:CKN VSS) capacitor c=4.17577e-17
C161 (\16\:CKNb VSS) capacitor c=9.7308e-17
C162 (\17\:CKNb VSS) capacitor c=2.59437e-17
C163 (\4\:D VSS) capacitor c=3.82078e-17
C164 (\3\:Db VSS) capacitor c=2.19207e-16
C165 (\8\:SE VSS) capacitor c=5.78505e-17
C166 (\9\:SE VSS) capacitor c=7.7421e-17
C167 (\10\:SE VSS) capacitor c=7.85596e-17
C168 (\4\:SI VSS) capacitor c=4.51555e-17
C169 (\8\:SEb VSS) capacitor c=7.69133e-17
C170 (\15\:VDD VSS) capacitor c=2.67498e-17
C171 (\19\:VDD VSS) capacitor c=2.67739e-17
C172 (\22\:VDD VSS) capacitor c=2.56216e-17
C173 (\26\:VDD VSS) capacitor c=2.58736e-17
C174 (\29\:VDD VSS) capacitor c=2.34609e-17
C175 (\33\:VDD VSS) capacitor c=1.134e-17
Rk2 (\4\:QN QN) resistor r=0.09288 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk42 (\4\:CKN CKN) resistor r=0.1665 c=0
Rk51 (\8\:SE \9\:SE) resistor r=0.2657 c=0
Rk53 (\10\:SE SE) resistor r=0.01279 c=0
Rk52 (\9\:SE \10\:SE) resistor r=0.2765 c=0
Rk25 (\8\:SN SN) resistor r=2.0735 c=0
Rk26 (SN \9\:SN) resistor r=0.1035 c=0
Rk54 (SI \4\:SI) resistor r=0.1871 c=0
Rk57 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk58 (\3\:VDD \4\:VDD) resistor r=0.2406 c=0
Rk59 (\4\:VDD \5\:VDD) resistor r=0.2305 c=0
Rk60 (\5\:VDD \6\:VDD) resistor r=0.1202 c=0
Rk61 (\6\:VDD \7\:VDD) resistor r=0.1505 c=0
Rk62 (\3\:VDD \9\:VDD) resistor r=0.1842 c=0
Rk63 (\5\:VDD \11\:VDD) resistor r=0.2911 c=0
Rk64 (\7\:VDD \13\:VDD) resistor r=0.1203 c=0
Rk65 (\7\:VDD \14\:VDD) resistor r=0.2012 c=0
Rk66 (\14\:VDD \15\:VDD) resistor r=0.3976 c=0
Rk67 (\15\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk68 (\15\:VDD \18\:VDD) resistor r=0.3525 c=0
Rk69 (\18\:VDD \19\:VDD) resistor r=0.08914 c=0
Rk70 (\19\:VDD \21\:VDD) resistor r=0.04331 c=0
Rk71 (\19\:VDD \22\:VDD) resistor r=0.5093 c=0
Rk72 (\22\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk73 (\22\:VDD \25\:VDD) resistor r=0.1493 c=0
Rk74 (\25\:VDD \26\:VDD) resistor r=0.2095 c=0
Rk75 (\26\:VDD \28\:VDD) resistor r=0.04331 c=0
Rk76 (\26\:VDD \29\:VDD) resistor r=0.4651 c=0
Rk77 (\29\:VDD \31\:VDD) resistor r=0.2815 c=0
Rk78 (\29\:VDD \32\:VDD) resistor r=0.07504 c=0
Rk81 (\33\:VDD VDD) resistor r=0.2127 c=0
Rk79 (\32\:VDD \33\:VDD) resistor r=0.3384 c=0
Rk80 (\33\:VDD \35\:VDD) resistor r=0.4181 c=0
Rk46 (\4\:D D) resistor r=0.08852 c=0
Rk7 (\3\:Q Q) resistor r=0.07888 c=0
Rk6 (\2\:Q \3\:Q) resistor r=0.03859 c=0
Rk8 (\3\:Q \5\:Q) resistor r=0.502 c=0
Rk82 (\2\:VSS \4\:VSS) resistor r=0.4273 c=0
Rk83 (\4\:VSS \5\:VSS) resistor r=0.3308 c=0
Rk84 (\5\:VSS \6\:VSS) resistor r=0.2745 c=0
Rk85 (\6\:VSS \7\:VSS) resistor r=0.1945 c=0
Rk86 (\7\:VSS \8\:VSS) resistor r=0.3835 c=0
Rk87 (\8\:VSS \9\:VSS) resistor r=0.6694 c=0
Rk88 (\9\:VSS \10\:VSS) resistor r=0.691 c=0
Rk89 (\10\:VSS \11\:VSS) resistor r=0.435 c=0
Rk90 (\11\:VSS \12\:VSS) resistor r=0.07504 c=0
Rk92 (\13\:VSS VSS) resistor r=0.2127 c=0
Rk91 (\12\:VSS \13\:VSS) resistor r=0.3384 c=0
Rk93 (\5\:VSS \15\:VSS) resistor r=0.3234 c=0
Rk94 (\6\:VSS \17\:VSS) resistor r=0.04331 c=0
Rk95 (\8\:VSS \19\:VSS) resistor r=0.3223 c=0
Rk96 (\10\:VSS \21\:VSS) resistor r=0.04331 c=0
Rk97 (\11\:VSS \23\:VSS) resistor r=0.2878 c=0
Rk98 (\13\:VSS \25\:VSS) resistor r=0.3692 c=0
Rk9 (\4\:RN RN) resistor r=0.004839 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1148 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1194 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1088 c=0
Rk10 (\11\:qbint \12\:qbint) resistor r=0.3772 c=0
Rk11 (\12\:qbint \13\:qbint) resistor r=0.8163 c=0
Rk12 (\12\:qbint \15\:qbint) resistor r=0.1081 c=0
Rk13 (\15\:qbint \17\:qbint) resistor r=0.4093 c=0
Rk21 (\7\:RNb \8\:RNb) resistor r=1.0765 c=0
Rk22 (\8\:RNb \10\:RNb) resistor r=0.9729 c=0
Rk23 (\10\:RNb \12\:RNb) resistor r=0.6681 c=0
Rk17 (\5\:n35 \6\:n35) resistor r=0.4954 c=0
Rk18 (\6\:n35 \7\:n35) resistor r=1.0387 c=0
Rk19 (\6\:n35 \9\:n35) resistor r=0.1739 c=0
Rk14 (\2\:net498 \4\:net498) resistor r=0.4348 c=0
Rk16 (\2\:net0363 \4\:net0363) resistor r=0.7318 c=0
Rk37 (\10\:CKNbb \12\:CKNbb) resistor r=0.3745 c=0
Rk38 (\12\:CKNbb \13\:CKNbb) resistor r=0.531 c=0
Rk39 (\13\:CKNbb \14\:CKNbb) resistor r=0.2842 c=0
Rk40 (\14\:CKNbb \15\:CKNbb) resistor r=0.1332 c=0
Rk41 (\13\:CKNbb \16\:CKNbb) resistor r=1.1535 c=0
Rk27 (\4\:mout \5\:mout) resistor r=0.2406 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.3342 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.2689 c=0
Rk30 (\7\:mout \9\:mout) resistor r=0.395 c=0
Rk31 (\5\:mout \11\:mout) resistor r=0.09337 c=0
Rk32 (\6\:mout \13\:mout) resistor r=0.1022 c=0
Rk33 (\7\:mout \15\:mout) resistor r=0.1469 c=0
Rk20 (\12\:CKNb \13\:CKNb) resistor r=0.5141 c=0
Rk43 (\15\:CKNb \16\:CKNb) resistor r=0.6458 c=0
Rk44 (\16\:CKNb \17\:CKNb) resistor r=0.04241 c=0
Rk45 (\16\:CKNb \19\:CKNb) resistor r=0.288 c=0
Rk24 (\2\:net521 \4\:net521) resistor r=0.5131 c=0
Rk34 (\5\:n20 \6\:n20) resistor r=0.3746 c=0
Rk35 (\6\:n20 \8\:n20) resistor r=0.1396 c=0
Rk36 (\6\:n20 \9\:n20) resistor r=0.398 c=0
Rk47 (\2\:Db \3\:Db) resistor r=0.3037 c=0
Rk48 (\3\:Db \5\:Db) resistor r=1.3668 c=0
Rk49 (\3\:Db \7\:Db) resistor r=0.4492 c=0
Rk50 (\5\:Db \9\:Db) resistor r=0.5648 c=0
Rk55 (\5\:SEb \7\:SEb) resistor r=0.633 c=0
Rk56 (\7\:SEb \8\:SEb) resistor r=0.5733 c=0
Rk15 (\2\:net566 \4\:net566) resistor r=0.3873 c=0
Rl43 (\1\:CKN \2\:CKN) resistor r=114.183 c=0
Rl44 (\2\:CKN \3\:CKN) resistor r=91.5405 c=0
Rl53 (\5\:SE \6\:SE) resistor r=144.231 c=0
Rl54 (\6\:SE \7\:SE) resistor r=28.2967 c=0
Rl50 (\3\:SE \4\:SE) resistor r=41.5405 c=0
Rl47 (\1\:SE \2\:SE) resistor r=63.2246 c=0
Rl30 (\5\:SN \7\:SN) resistor r=146.154 c=0
Rl29 (\5\:SN \6\:SN) resistor r=59.5926 c=0
Rl14 (\1\:SN \2\:SN) resistor r=36.5533 c=0
Rl16 (\2\:SN \4\:SN) resistor r=89.5925 c=0
Rl15 (\2\:SN \3\:SN) resistor r=5.4946 c=0
Rl51 (\1\:SI \2\:SI) resistor r=66.0764 c=0
Rl52 (\2\:SI \3\:SI) resistor r=109.94 c=0
Rl45 (\1\:D \2\:D) resistor r=80.0021 c=0
Rl46 (\2\:D \3\:D) resistor r=87.6944 c=0
Rl10 (\1\:RN \2\:RN) resistor r=119.922 c=0
Rl11 (\2\:RN \3\:RN) resistor r=89.1533 c=0
Rl1 (qint \2\:qint) resistor r=2.0213 c=0
Rl3 (\2\:qint \4\:qint) resistor r=47.791 c=0
Rl2 (\2\:qint \3\:qint) resistor r=36.2526 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=153.412 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=111.052 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=29.5379 c=0
Rl4 (qbint \2\:qbint) resistor r=147.31 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=28.7715 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=224.363 c=0
Rl19 (RNb \2\:RNb) resistor r=163.027 c=0
Rl26 (\4\:RNb \6\:RNb) resistor r=146.154 c=0
Rl25 (\4\:RNb \5\:RNb) resistor r=109.128 c=0
Rl20 (\2\:RNb \3\:RNb) resistor r=78.079 c=0
Rl12 (n35 \2\:n35) resistor r=88.4615 c=0
Rl13 (\2\:n35 \3\:n35) resistor r=29.9451 c=0
Rl34 (\7\:CKNbb \8\:CKNbb) resistor r=63.2246 c=0
Rl33 (\5\:CKNbb \6\:CKNbb) resistor r=26.1559 c=0
Rl22 (CKNbb \2\:CKNbb) resistor r=28.0797 c=0
Rl23 (\2\:CKNbb \3\:CKNbb) resistor r=137.261 c=0
Rl24 (\2\:CKNbb \4\:CKNbb) resistor r=179.219 c=0
Rl31 (mout \2\:mout) resistor r=60.7134 c=0
Rl32 (\2\:mout \3\:mout) resistor r=87.6365 c=0
Rl21 (CKNb \2\:CKNb) resistor r=55.1375 c=0
Rl41 (\9\:CKNb \10\:CKNb) resistor r=39.1533 c=0
Rl38 (\6\:CKNb \7\:CKNb) resistor r=505.975 c=0
Rl39 (\7\:CKNb \8\:CKNb) resistor r=32.0175 c=0
Rl35 (\3\:CKNb \4\:CKNb) resistor r=38.0255 c=0
Rl40 (\4\:CKNb \9\:CKNb) resistor r=11.3405 c=0
Rl42 (\5\:CKNb \11\:CKNb) resistor r=82.3738 c=0
Rl37 (\5\:CKNb \6\:CKNb) resistor r=228.824 c=0
Rl36 (\4\:CKNb \5\:CKNb) resistor r=159.512 c=0
Rl27 (n20 \2\:n20) resistor r=91.0764 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl48 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl49 (\2\:SEb \3\:SEb) resistor r=179.104 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz21 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz22 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz23 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz24 (\1\:VDD \7\:VDD) resistor r=75 c=0
Rz25 (\1\:VDD \14\:VDD) resistor r=25 c=0
Rz26 (\1\:VDD \18\:VDD) resistor r=6.25 c=0
Rz27 (\1\:VDD \25\:VDD) resistor r=25 c=0
Rz28 (\1\:VDD \32\:VDD) resistor r=6.25 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz29 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz30 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz31 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz32 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz33 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz34 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz35 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (net498 \2\:net498) resistor r=75 c=0
Rz6 (\3\:net498 \4\:net498) resistor r=75 c=0
Rz7 (net0363 \2\:net0363) resistor r=75 c=0
Rz8 (\3\:net0363 \4\:net0363) resistor r=75 c=0
Rz16 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz13 (\12\:mout \13\:mout) resistor r=75 c=0
Rz14 (\14\:mout \15\:mout) resistor r=75 c=0
Rz17 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz11 (net521 \2\:net521) resistor r=75 c=0
Rz12 (\3\:net521 \4\:net521) resistor r=75 c=0
Rz15 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz18 (Db \2\:Db) resistor r=75 c=0
Rz19 (\4\:Db \5\:Db) resistor r=75 c=0
Rz20 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry17 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry18 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry19 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry23 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry24 (\30\:VDD \31\:VDD) resistor r=62 c=0
Ry25 (\34\:VDD \35\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry27 (\3\:VSS \7\:VSS) resistor r=6.8889 c=0
Ry28 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\11\:CKNbb \12\:CKNbb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\10\:mout \11\:mout) resistor r=62 c=0
Ry13 (\14\:CKNb \15\:CKNb) resistor r=62 c=0
Ry11 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry15 (\8\:Db \9\:Db) resistor r=62 c=0
Ry16 (\6\:SEb \7\:SEb) resistor r=62 c=0
Ry5 (net566 \2\:net566) resistor r=62 c=0
Ry6 (\3\:net566 \4\:net566) resistor r=62 c=0
Rx17 (\2\:CKN \4\:CKN) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\6\:SE \10\:SE) resistor r=45 c=0
Rx10 (\6\:SN \8\:SN) resistor r=45 c=0
Rx11 (\3\:SN \9\:SN) resistor r=45 c=0
Rx23 (\2\:SI \4\:SI) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\5\:qbint \13\:qbint) resistor r=45 c=0
Rx8 (\5\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx14 (\7\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx15 (\6\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx16 (\4\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx12 (\2\:mout \4\:mout) resistor r=45 c=0
Rx6 (\7\:CKNb \12\:CKNb) resistor r=45 c=0
Rx7 (CKNb \13\:CKNb) resistor r=45 c=0
Rx18 (\9\:CKNb \17\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx24 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\4\:Q \6\:qbint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn22 (\11\:RNb \3\:RN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=3.48e-14 ps=6.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=2.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn45 (\14\:qbint \3\:n35 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.87e-14 ad=2.392e-14 ps=1.51e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=1e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn50 (\3\:net498 \4\:SN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.87e-14 ad=5.002e-14 ps=1.51e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=7.35e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn52 (\3\:net0363 \9\:qbint \3\:net498 VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=5.002e-14 ad=2.32e-14 ps=9.8e-07 pd=6.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=8.2e-07 sb=3.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn51 (\3\:net0363 RNb net498 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn53 (\4\:n35 \3\:CKNbb net0363 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.277e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn40 (\14\:mout \8\:CKNb \4\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.277e-14 ad=2.03e-14 ps=8.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn31 (\12\:mout \6\:RNb \3\:net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.125e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn32 (\12\:mout \3\:n20 net521 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.972e-14 ps=6.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=8.75e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn30 (net521 \7\:SN \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn35 (net582 \3\:mout \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=4.5e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn36 (\7\:n20 \6\:CKNb net582 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (\4\:Db \5\:CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\9\:CKNbb \10\:CKNb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.725e-14 ad=3.335e-14 ps=1.34e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.3e-07 sb=1.7e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn20 (\18\:CKNb \3\:CKN \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn11 (net546 \3\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=4.713e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.035e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn12 (Db \3\:SEb net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.713e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=6.65e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn14 (Db \3\:SE net538 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=4.6e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn13 (net538 \3\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=3.55e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp56 (\5\:qint \7\:qbint \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp22 (\9\:RNb \1\:RN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp45 (\16\:qbint n35 \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.89e-14 ad=3.01e-14 ps=1.73e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp50 (\3\:net566 \1\:SN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.89e-14 ad=4.515e-14 ps=1.73e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=6.25e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp52 (\3\:net566 \8\:qbint net414 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.902e-14 ad=4.515e-14 ps=7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.7e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp51 (net414 \2\:RNb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=2.902e-14 ps=1.67e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.9e-07 sd=160n sca=19.7413 scb=0.019281 \
        scc=0.00179464 m=(1)
mp53 (\8\:n35 \2\:CKNb net566 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=5.375e-14 ps=9e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=4.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\8\:n35 CKNbb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.375e-14 ps=7.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp31 (net478 \4\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.805e-14 ad=4.408e-14 ps=2.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.01767e-06 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp32 (\10\:mout n20 net478 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.763e-14 ps=8.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.67674e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp30 (\10\:mout \5\:SN \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.763e-14 ps=1.81e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=5.47674e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp35 (net486 mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.49e-14 ad=2.15e-14 ps=1.81e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.14535e-07 sb=6.65e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp36 (\4\:n20 \8\:CKNbb net486 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=6.45e-14 ps=6.3e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.59535e-07 sb=5.2e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp25 (\4\:n20 \11\:CKNb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=6.45e-14 ps=7.8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10453e-06 sb=1.75e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp21 (\11\:CKNbb \3\:CKNb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp20 (\14\:CKNb \1\:CKN \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.395e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp12 (\6\:Db \2\:SE net461 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.688e-14 ad=6.45e-14 ps=6.8e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.02e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp11 (net461 \1\:D \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.688e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.19e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp14 (\6\:Db SEb net453 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=6.45e-14 ps=7.2e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=6.75e-07 sd=160n sca=12.7214 \
        scb=0.0110237 scc=0.000332196 m=(1)
mp13 (net453 \1\:SI \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=3.118e-14 ps=1.19e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=4.85e-07 sd=160n sca=13.8366 \
        scb=0.012107 scc=0.000335122 m=(1)
mp10 (\6\:SEb \5\:SE \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=4.73e-14 ps=1.19e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=2.2e-07 sd=160n sca=19.4835 \
        scb=0.0215572 scc=0.000673289 m=(1)
ends SDFFNSRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:28:10 2012 )
// Library name: gsclib045
// Cell name: SDFFQX1
// View name: extracted

simulator lang=spectre

subckt SDFFQX1 CK D Q SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=31.6283 \
        scb=0.0342226 scc=0.00291148 m=(1)
C1 (D VSS) capacitor c=4.34164e-17
C2 (CK VSS) capacitor c=5.91381e-17
C3 (SE VSS) capacitor c=3.08262e-17
C4 (VDD VSS) capacitor c=3.20649e-16
C5 (SI VSS) capacitor c=1.32897e-16
C6 (qbint VSS) capacitor c=2.22679e-17
C7 (CKb VSS) capacitor c=4.20208e-17
C8 (n30 VSS) capacitor c=5.24372e-17
C9 (mout VSS) capacitor c=7.97168e-17
C10 (CKbb VSS) capacitor c=1.97809e-17
C11 (n20 VSS) capacitor c=4.28122e-17
C12 (Db VSS) capacitor c=9.49867e-17
C13 (n1 VSS) capacitor c=5.34612e-18
C14 (SEb VSS) capacitor c=7.09584e-17
C15 (n8 VSS) capacitor c=4.67726e-18
C16 (n6 VSS) capacitor c=7.53388e-20
C17 (n2 VSS) capacitor c=5.98588e-18
C18 (\5\:SE VSS) capacitor c=5.1842e-17
C19 (\1\:SI VSS) capacitor c=7.57864e-17
C20 (\1\:SE VSS) capacitor c=3.96081e-17
C21 (\1\:D VSS) capacitor c=6.79563e-17
C22 (\5\:CKb VSS) capacitor c=5.37006e-17
C23 (\6\:CKbb VSS) capacitor c=4.39999e-17
C24 (\8\:CKb VSS) capacitor c=7.1048e-17
C25 (\3\:n20 VSS) capacitor c=4.08655e-17
C26 (\3\:CKb VSS) capacitor c=5.88712e-17
C27 (\3\:CKbb VSS) capacitor c=4.83652e-17
C28 (\5\:qbint VSS) capacitor c=4.95392e-17
C29 (\1\:CK VSS) capacitor c=3.03336e-17
C30 (\4\:qbint VSS) capacitor c=4.65374e-17
C31 (\7\:SE VSS) capacitor c=2.79499e-17
C32 (\3\:SI VSS) capacitor c=7.16934e-17
C33 (\3\:SE VSS) capacitor c=6.62061e-17
C34 (\3\:SEb VSS) capacitor c=5.50407e-17
C35 (\3\:D VSS) capacitor c=4.0496e-17
C36 (\9\:CKb VSS) capacitor c=4.17877e-17
C37 (\10\:CKb VSS) capacitor c=2.61717e-17
C38 (\4\:CKbb VSS) capacitor c=8.43119e-17
