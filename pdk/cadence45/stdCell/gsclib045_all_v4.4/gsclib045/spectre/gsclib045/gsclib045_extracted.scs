Rl17 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl8 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl6 (\1\:CK \2\:CK) resistor r=140.099 c=0
Rl7 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl21 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl23 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl20 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl22 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl19 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl38 (\1\:ExtVDD \2\:ExtVDD) resistor r=149.73 c=0
Rl14 (\2\:D \4\:D) resistor r=115.099 c=0
Rl12 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl13 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl51 (\1\:RT \4\:RT) resistor r=752.514 c=0
Rl53 (\2\:RT \6\:RT) resistor r=35.9829 c=0
Rl50 (\2\:RT \3\:RT) resistor r=273.346 c=0
Rl52 (\2\:RT \5\:RT) resistor r=195.631 c=0
Rl49 (\1\:RT \2\:RT) resistor r=176.551 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl9 (\3\:n20 \4\:n20) resistor r=83.1175 c=0
Rl11 (\4\:n20 \6\:n20) resistor r=197.322 c=0
Rl10 (\4\:n20 \5\:n20) resistor r=244.414 c=0
Rl2 (CKbb \2\:CKbb) resistor r=200.882 c=0
Rl55 (\10\:CKbb \11\:CKbb) resistor r=195.656 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=330.626 c=0
Rl44 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl47 (\5\:CKbb \8\:CKbb) resistor r=762.322 c=0
Rl48 (\6\:CKbb \9\:CKbb) resistor r=60.7265 c=0
Rl46 (\6\:CKbb \7\:CKbb) resistor r=81.3209 c=0
Rl45 (\5\:CKbb \6\:CKbb) resistor r=462.851 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=210.875 c=0
Rl56 (\10\:CKb \11\:CKb) resistor r=134.339 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=127.615 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=66.0764 c=0
Rl24 (CKb \2\:CKb) resistor r=354.912 c=0
Rl30 (\2\:CKb \8\:CKb) resistor r=127.816 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl31 (\3\:CKb \9\:CKb) resistor r=147.793 c=0
Rl25 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl15 (SEb \2\:SEb) resistor r=101.718 c=0
Rl16 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl35 (\3\:n35g \5\:n35g) resistor r=332.357 c=0
Rl32 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl33 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl34 (\2\:n35g \4\:n35g) resistor r=94.1963 c=0
Rl57 (\6\:qbint \7\:qbint) resistor r=235.906 c=0
Rl43 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl40 (qbint \2\:qbint) resistor r=112.732 c=0
Rl42 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl41 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl58 (\7\:qbint \8\:qbint) resistor r=540.591 c=0
Rl60 (\8\:qbint \10\:qbint) resistor r=67.086 c=0
Rl61 (\8\:qbint \11\:qbint) resistor r=76.4828 c=0
Rl59 (\8\:qbint \9\:qbint) resistor r=219.718 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=338.853 c=0
Rl36 (RTb \2\:RTb) resistor r=115.333 c=0
Rl54 (\3\:n35 \4\:n35) resistor r=234.929 c=0
Rl37 (n35 \2\:n35) resistor r=149.925 c=0
Rz23 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz24 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz25 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz26 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz27 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz28 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz29 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz18 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\17\:CKbb \18\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\6\:RTb \7\:RTb) resistor r=75 c=0
Rz10 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (\11\:n35 \12\:n35) resistor r=75 c=0
Rz17 (\19\:n35 \20\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Rz19 (net0118 \2\:net0118) resistor r=75 c=0
Rz20 (\3\:net0118 \4\:net0118) resistor r=75 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry24 (\10\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry25 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry26 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry28 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry29 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry31 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry33 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry34 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry35 (\19\:VSS \34\:VSS) resistor r=5.1667 c=0
Ry20 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry13 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry14 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry15 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry3 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\15\:mout \16\:mout) resistor r=62 c=0
Ry4 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\7\:n35g \8\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry18 (\9\:RTb \10\:RTb) resistor r=62 c=0
Ry10 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry11 (\13\:n35 \14\:n35) resistor r=62 c=0
Ry19 (\17\:n35 \18\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry21 (net0110 \2\:net0110) resistor r=62 c=0
Ry22 (\3\:net0110 \4\:net0110) resistor r=62 c=0
Rx12 (\2\:SI SI) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx13 (\1\:SE SE) resistor r=45 c=0
Rx17 (\2\:ExtVDD \8\:ExtVDD) resistor r=15 c=0
Rx18 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx9 (\3\:D D) resistor r=45 c=0
Rx25 (\1\:RT \7\:RT) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx6 (CKbb \16\:CKbb) resistor r=45 c=0
Rx26 (\11\:CKbb \19\:CKbb) resistor r=45 c=0
Rx27 (\8\:CKbb \20\:CKbb) resistor r=45 c=0
Rx10 (\4\:mout \10\:mout) resistor r=45 c=0
Rx11 (\2\:mout \17\:mout) resistor r=45 c=0
Rx8 (\5\:CKb \15\:CKb) resistor r=45 c=0
Rx30 (CKb \18\:CKb) resistor r=45 c=0
Rx31 (\11\:CKb \19\:CKb) resistor r=45 c=0
Rx14 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx16 (\5\:n35g \6\:n35g) resistor r=45 c=0
Rx20 (n35g \14\:n35g) resistor r=45 c=0
Rx19 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx28 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx29 (qbint \19\:qbint) resistor r=45 c=0
Rx23 (\2\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (\3\:RTb \8\:RTb) resistor r=45 c=0
Rx15 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx21 (\4\:n35 \15\:n35) resistor r=45 c=0
Rx22 (n35 \16\:n35) resistor r=45 c=0
Rx32 (\3\:n35 \21\:n35) resistor r=45 c=0
mn25 (\7\:Db \7\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \9\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\17\:CKbb \6\:CKb \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=8.7e-15 ps=7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.05e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\12\:CKb \1\:CK \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\13\:mout \6\:n20 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\9\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn10 (\4\:SEb \5\:SE \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g RTb \11\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \4\:n35g \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\6\:RTb \5\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.81e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \4\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\19\:n35 \10\:CKb \3\:net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\3\:Q \11\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn52 (net0118 \6\:qbint \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp36 (\12\:n20 \9\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.81232 \
        scb=0.00143001 scc=2.43069e-06 m=(1)
mp21 (\14\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.44154 \
        scb=0.00123191 scc=2.30905e-06 m=(1)
mp20 (\16\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\15\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.41289 \
        scb=0.00122082 scc=2.30567e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\13\:n35 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.5649 \
        scb=0.0251664 scc=0.00264914 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\7\:n35g \3\:RT \5\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.1589 \
        scb=0.0273077 scc=0.0026732 m=(1)
mp45 (\14\:qbint \3\:n35g \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\9\:RTb \6\:RT \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.4484 \
        scb=0.0260103 scc=0.00229228 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\17\:n35 \10\:CKbb \3\:net0110 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.2721 \
        scb=0.0274454 scc=0.00267566 m=(1)
mp55 (\1\:Q \10\:qbint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.8779 \
        scb=0.0123722 scc=0.000341425 m=(1)
mp52 (net0110 \7\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.0849 \
        scb=0.0117187 scc=0.000200072 m=(1)
ends SRDFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:03:01 2012 )
// Library name: gsclib045
// Cell name: SRDFFRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFRQX1 CK D ExtVDD Q RN RT SE SI VDD VSS
mp22 (\10\:RNb \1\:RN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (SI VSS) capacitor c=8.71917e-17
C2 (RN VSS) capacitor c=8.17943e-17
C3 (RT VSS) capacitor c=3.75399e-17
C4 (Q VSS) capacitor c=2.16972e-17
C5 (VDD VSS) capacitor c=6.60999e-16
C6 (SE VSS) capacitor c=3.95426e-17
C7 (ExtVDD VSS) capacitor c=2.34537e-16
C8 (D VSS) capacitor c=4.57153e-17
C9 (n20 VSS) capacitor c=3.92762e-17
C10 (CKbb VSS) capacitor c=3.00292e-17
C11 (mout VSS) capacitor c=4.95495e-17
C12 (CKb VSS) capacitor c=5.52799e-17
C13 (RNb VSS) capacitor c=2.7463e-16
C14 (SEb VSS) capacitor c=7.75211e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.57473e-17
C17 (RTb VSS) capacitor c=5.17873e-17
C18 (n35 VSS) capacitor c=1.3462e-16
C19 (Db VSS) capacitor c=1.04956e-16
C20 (n10 VSS) capacitor c=6.36691e-17
C21 (n1 VSS) capacitor c=1.02126e-18
C22 (\7\:RNb VSS) capacitor c=1.00899e-16
C23 (\9\:qbint VSS) capacitor c=2.81783e-17
C24 (\10\:qbint VSS) capacitor c=2.20934e-16
C25 (\11\:CKbb VSS) capacitor c=9.86081e-17
C26 (\4\:RTb VSS) capacitor c=9.87178e-17
C27 (\6\:RT VSS) capacitor c=2.21451e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.21168e-17
C30 (\5\:RT VSS) capacitor c=8.4067e-17
C31 (\3\:SE VSS) capacitor c=7.72547e-17
C32 (\7\:CKb VSS) capacitor c=3.23122e-17
C33 (\3\:SI VSS) capacitor c=9.47876e-17
C34 (\4\:SE VSS) capacitor c=1.2264e-16
C35 (\4\:D VSS) capacitor c=7.01011e-17
C36 (\5\:RNb VSS) capacitor c=6.66155e-17
C37 (\5\:n20 VSS) capacitor c=1.21055e-16
C38 (\4\:CK VSS) capacitor c=6.01774e-17
C39 (\4\:CKb VSS) capacitor c=4.53192e-17
C40 (\8\:CKb VSS) capacitor c=8.35802e-17
C41 (\3\:CKbb VSS) capacitor c=2.89617e-17
C42 (\1\:RN VSS) capacitor c=4.2139e-17
C43 (\8\:RNb VSS) capacitor c=8.56207e-17
C44 (\6\:qbint VSS) capacitor c=3.17649e-17
C45 (\11\:qbint VSS) capacitor c=8.89948e-17
C46 (\11\:CKb VSS) capacitor c=2.13298e-16
C47 (\8\:RT VSS) capacitor c=1.28278e-16
C48 (\2\:RT VSS) capacitor c=6.21538e-17
C49 (\5\:qbint VSS) capacitor c=3.87694e-17
C50 (\5\:n35g VSS) capacitor c=3.28917e-17
C51 (\2\:RTb VSS) capacitor c=4.79204e-17
C52 (\5\:SE VSS) capacitor c=5.7887e-17
C53 (\9\:CKbb VSS) capacitor c=2.52869e-17
C54 (\1\:SI VSS) capacitor c=4.91308e-17
C55 (\6\:SE VSS) capacitor c=8.61913e-17
C56 (\3\:SEb VSS) capacitor c=6.60462e-17
C57 (\1\:D VSS) capacitor c=4.94494e-17
C58 (\6\:RNb VSS) capacitor c=5.09058e-17
C59 (\3\:n20 VSS) capacitor c=8.28417e-17
C60 (\1\:CK VSS) capacitor c=2.87619e-17
C61 (\3\:mout VSS) capacitor c=5.00666e-17
C62 (\9\:CKb VSS) capacitor c=3.90899e-17
C63 (\10\:CKbb VSS) capacitor c=4.89185e-17
C64 (\6\:CKb VSS) capacitor c=5.34296e-17
C65 (\4\:RN VSS) capacitor c=3.6922e-17
C66 (\8\:qbint VSS) capacitor c=1.04092e-16
C67 (\12\:CKbb VSS) capacitor c=6.71982e-17
C68 (\9\:RNb VSS) capacitor c=6.11895e-17
C69 (\7\:RT VSS) capacitor c=1.51736e-16
C70 (\5\:CKbb VSS) capacitor c=1.64527e-16
C71 (\3\:RT VSS) capacitor c=5.4998e-17
C72 (\1\:RT VSS) capacitor c=5.27439e-17
C73 (\3\:RTb VSS) capacitor c=7.6147e-17
C74 (\3\:qbint VSS) capacitor c=4.43509e-17
C75 (\2\:n35 VSS) capacitor c=1.90399e-16
C76 (\4\:n35g VSS) capacitor c=6.72291e-17
C77 (\12\:CKb VSS) capacitor c=2.07004e-16
C78 (\3\:n35 VSS) capacitor c=9.08061e-17
C79 (\1\:SE VSS) capacitor c=2.48251e-17
C80 (\2\:SI VSS) capacitor c=7.76389e-17
C81 (\2\:SEb VSS) capacitor c=7.74415e-17
C82 (\3\:D VSS) capacitor c=1.46469e-17
C83 (\3\:CK VSS) capacitor c=2.33567e-17
C84 (\2\:mout VSS) capacitor c=3.79422e-17
C85 (\4\:mout VSS) capacitor c=4.33186e-17
C86 (\10\:CKb VSS) capacitor c=2.11774e-17
C87 (\6\:n20 VSS) capacitor c=1.05145e-16
C88 (\4\:n20 VSS) capacitor c=6.91974e-17
C89 (\4\:CKbb VSS) capacitor c=7.10829e-17
C90 (\8\:CKbb VSS) capacitor c=2.74016e-17
C91 (\4\:RNb VSS) capacitor c=9.81903e-17
C92 (\2\:n20 VSS) capacitor c=4.55207e-17
C93 (\3\:RN VSS) capacitor c=4.82646e-17
C94 (\1\:VDD VSS) capacitor c=2.43855e-17
C95 (\10\:VDD VSS) capacitor c=4.39786e-17
C96 (\4\:Q VSS) capacitor c=6.38054e-17
C97 (\14\:n35 VSS) capacitor c=5.68374e-17
C98 (\15\:n35g VSS) capacitor c=5.76971e-17
C99 (\6\:RTb VSS) capacitor c=7.20391e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.77981e-16
C101 (\9\:n35 VSS) capacitor c=6.15721e-17
C102 (\14\:qbint VSS) capacitor c=6.81232e-17
C103 (\6\:n35g VSS) capacitor c=9.40514e-17
C104 (\8\:SEb VSS) capacitor c=5.05319e-17
C105 (\4\:n35 VSS) capacitor c=6.36368e-17
C106 (\12\:VDD VSS) capacitor c=6.07503e-17
C107 (\5\:mout VSS) capacitor c=7.31091e-17
C108 (\3\:Db VSS) capacitor c=1.88508e-16
C109 (\14\:VDD VSS) capacitor c=2.98062e-17
C110 (\19\:VDD VSS) capacitor c=3.4302e-17
C111 (\13\:mout VSS) capacitor c=5.17159e-17
C112 (\17\:CKb VSS) capacitor c=2.91338e-17
C113 (\17\:VDD VSS) capacitor c=4.24614e-17
C114 (\17\:CKbb VSS) capacitor c=6.74654e-17
C115 (\12\:n20 VSS) capacitor c=6.1008e-17
C116 (\5\:Db VSS) capacitor c=2.23494e-16
C117 (\10\:RNb VSS) capacitor c=5.0493e-17
C118 (\9\:n20 VSS) capacitor c=6.35945e-17
C119 (\21\:VDD VSS) capacitor c=4.24098e-17
C120 (\3\:VDD VSS) capacitor c=2.36204e-16
C121 (\1\:Q VSS) capacitor c=3.47098e-17
C122 (\3\:n10 VSS) capacitor c=7.9996e-17
C123 (\17\:n35 VSS) capacitor c=7.30793e-17
C124 (\11\:n35g VSS) capacitor c=2.72594e-17
C125 (\10\:RTb VSS) capacitor c=5.79526e-17
C126 (\12\:n35 VSS) capacitor c=6.3485e-17
C127 (\16\:qbint VSS) capacitor c=2.43025e-17
C128 (\9\:n35g VSS) capacitor c=8.05092e-17
C129 (\4\:SEb VSS) capacitor c=3.82428e-17
C130 (\7\:n35 VSS) capacitor c=4.10685e-17
C131 (\11\:mout VSS) capacitor c=2.63954e-17
C132 (\15\:mout VSS) capacitor c=4.00685e-17
C133 (\13\:CKb VSS) capacitor c=6.69783e-17
C134 (\15\:CKbb VSS) capacitor c=8.30493e-17
C135 (\17\:n20 VSS) capacitor c=5.27563e-17
C136 (\7\:Db VSS) capacitor c=7.75866e-17
C137 (\13\:RNb VSS) capacitor c=7.34786e-17
C138 (\7\:n20 VSS) capacitor c=5.89089e-17
C139 (VDD VSS) capacitor c=6.92418e-17
C140 (\2\:CKbb VSS) capacitor c=6.11803e-17
C141 (\2\:CK VSS) capacitor c=3.41706e-17
C142 (\2\:D VSS) capacitor c=3.5271e-17
C143 (\2\:SE VSS) capacitor c=2.51114e-17
C144 (\2\:CKb VSS) capacitor c=1.45267e-16
C145 (\3\:CKb VSS) capacitor c=8.91815e-17
C146 (\5\:CKb VSS) capacitor c=5.62737e-17
C147 (\2\:n35g VSS) capacitor c=2.90794e-17
C148 (\4\:RT VSS) capacitor c=7.44104e-17
C149 (\2\:qbint VSS) capacitor c=4.14972e-17
C150 (\6\:CKbb VSS) capacitor c=1.22521e-16
C151 (\7\:CKbb VSS) capacitor c=8.12993e-17
C152 (\2\:RNb VSS) capacitor c=1.77688e-16
C153 (\3\:RNb VSS) capacitor c=1.03929e-16
C154 (\11\:n20 VSS) capacitor c=4.44679e-17
C155 (\7\:qbint VSS) capacitor c=3.84393e-17
C156 (\12\:RNb VSS) capacitor c=1.19795e-16
C157 (\13\:CKbb VSS) capacitor c=1.55474e-16
C158 (\14\:CKbb VSS) capacitor c=1.38098e-16
C159 (\14\:n20 VSS) capacitor c=7.52999e-17
C160 (\15\:n20 VSS) capacitor c=6.1545e-17
C161 (\16\:n20 VSS) capacitor c=5.98052e-17
C162 (\19\:CKbb VSS) capacitor c=5.61218e-17
C163 (\7\:CK VSS) capacitor c=8.4105e-17
C164 (\15\:CKb VSS) capacitor c=6.28153e-17
C165 (\16\:CKb VSS) capacitor c=4.09685e-17
C166 (\6\:D VSS) capacitor c=4.80153e-17
C167 (\7\:mout VSS) capacitor c=8.26205e-17
C168 (\9\:mout VSS) capacitor c=6.4648e-17
C169 (\10\:mout VSS) capacitor c=5.26265e-17
C170 (\17\:mout VSS) capacitor c=4.55409e-17
C171 (\7\:SE VSS) capacitor c=5.24686e-17
C172 (\6\:SEb VSS) capacitor c=8.17114e-17
C173 (\7\:SEb VSS) capacitor c=6.71871e-17
C174 (\6\:n35 VSS) capacitor c=7.90922e-17
C175 (\19\:CKb VSS) capacitor c=3.96414e-17
C176 (\20\:CKb VSS) capacitor c=4.2063e-17
C177 (\8\:n35g VSS) capacitor c=3.48863e-17
C178 (\11\:n35 VSS) capacitor c=7.50013e-17
C179 (\12\:qbint VSS) capacitor c=8.77437e-17
C180 (\13\:qbint VSS) capacitor c=1.12023e-16
C181 (\13\:n35g VSS) capacitor c=1.03947e-16
C182 (\14\:n35g VSS) capacitor c=1.15912e-16
C183 (\5\:RTb VSS) capacitor c=4.92957e-17
C184 (\8\:RTb VSS) capacitor c=1.00061e-16
C185 (\9\:RTb VSS) capacitor c=9.13858e-17
C186 (\9\:RT VSS) capacitor c=1.19039e-16
C187 (\10\:RT VSS) capacitor c=1.18186e-16
C188 (\11\:RT VSS) capacitor c=3.80585e-17
C189 (\15\:RNb VSS) capacitor c=1.13564e-16
C190 (\16\:RNb VSS) capacitor c=1.13929e-16
C191 (\20\:CKbb VSS) capacitor c=1.5381e-16
C192 (\21\:CKbb VSS) capacitor c=1.43916e-16
C193 (\18\:qbint VSS) capacitor c=2.25365e-17
C194 (\19\:qbint VSS) capacitor c=3.20899e-17
C195 (\16\:n35 VSS) capacitor c=8.97661e-17
C196 (\3\:Q VSS) capacitor c=1.78346e-17
C197 (\6\:VDD VSS) capacitor c=1.99067e-16
C198 (\7\:VDD VSS) capacitor c=2.17233e-17
C199 (\9\:VDD VSS) capacitor c=2.94541e-17
C200 (\16\:VDD VSS) capacitor c=5.08481e-17
Rk33 (SI \4\:SI) resistor r=0.001854 c=0
Rk34 (\4\:SI \5\:SI) resistor r=0.001854 c=0
Rk35 (\6\:SI SI) resistor r=0.001854 c=0
Rk36 (\4\:SI \6\:SI) resistor r=0.01025 c=0
Rk1 (\5\:RN RN) resistor r=0.006385 c=0
Rk63 (RT \9\:RT) resistor r=0.1847 c=0
Rk64 (\9\:RT \10\:RT) resistor r=0.6593 c=0
Rk65 (RT \11\:RT) resistor r=0.01483 c=0
Rk72 (\3\:Q Q) resistor r=0.02782 c=0
Rk71 (\2\:Q \3\:Q) resistor r=0.1934 c=0
Rk73 (\3\:Q \5\:Q) resistor r=0.3685 c=0
Rk13 (CK \5\:CK) resistor r=0.003455 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01476 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.003637 c=0
Rk87 (VDD VDD) resistor r=0.2369 c=0
Rk75 (\2\:VDD \4\:VDD) resistor r=0.2907 c=0
Rk76 (\4\:VDD \5\:VDD) resistor r=0.1196 c=0
Rk77 (\5\:VDD \6\:VDD) resistor r=1.5124 c=0
Rk78 (\6\:VDD \7\:VDD) resistor r=0.2384 c=0
Rk79 (\7\:VDD \9\:VDD) resistor r=0.1024 c=0
Rk80 (\4\:VDD \11\:VDD) resistor r=0.3603 c=0
Rk81 (\6\:VDD \13\:VDD) resistor r=0.3682 c=0
Rk82 (\7\:VDD \15\:VDD) resistor r=0.2001 c=0
Rk86 (\16\:VDD VDD) resistor r=0.1961 c=0
Rk83 (\9\:VDD \16\:VDD) resistor r=0.1715 c=0
Rk84 (\16\:VDD \18\:VDD) resistor r=0.2027 c=0
Rk85 (\9\:VDD \20\:VDD) resistor r=0.2388 c=0
Rk88 (VDD \22\:VDD) resistor r=0.3797 c=0
Rk37 (SE \7\:SE) resistor r=0.04331 c=0
Rk50 (ExtVDD ExtVDD) resistor r=0.002067 c=0
Rk48 (\2\:ExtVDD ExtVDD) resistor r=0.02221 c=0
Rk51 (ExtVDD \5\:ExtVDD) resistor r=0.02019 c=0
Rk52 (ExtVDD \6\:ExtVDD) resistor r=0.15 c=0
Rk19 (\5\:D D) resistor r=0.007222 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01656 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007222 c=0
Rk89 (\2\:VSS \3\:VSS) resistor r=0.0421 c=0
Rk90 (\3\:VSS \4\:VSS) resistor r=0.1068 c=0
Rk91 (\4\:VSS \5\:VSS) resistor r=0.6641 c=0
Rk92 (\5\:VSS \6\:VSS) resistor r=0.03215 c=0
Rk94 (\7\:VSS VSS) resistor r=0.2707 c=0
Rk93 (\6\:VSS \7\:VSS) resistor r=0.1764 c=0
Rk95 (VSS \8\:VSS) resistor r=0.3732 c=0
Rk96 (\8\:VSS \9\:VSS) resistor r=0.3081 c=0
Rk98 (\10\:VSS VSS) resistor r=0.1217 c=0
Rk97 (\9\:VSS \10\:VSS) resistor r=0.06449 c=0
Rk99 (VSS \12\:VSS) resistor r=0.3134 c=0
Rk100 (\3\:VSS \14\:VSS) resistor r=0.262 c=0
Rk101 (\5\:VSS \16\:VSS) resistor r=0.1902 c=0
Rk102 (\7\:VSS \18\:VSS) resistor r=0.1953 c=0
Rk103 (\8\:VSS \20\:VSS) resistor r=0.2547 c=0
Rk104 (\9\:VSS \22\:VSS) resistor r=0.2503 c=0
Rk105 (\24\:VSS \25\:VSS) resistor r=0.08688 c=0
Rk106 (\25\:VSS \26\:VSS) resistor r=0.311 c=0
Rk107 (\26\:VSS \27\:VSS) resistor r=0.3185 c=0
Rk109 (\28\:VSS VSS) resistor r=0.1988 c=0
Rk108 (\27\:VSS \28\:VSS) resistor r=0.3282 c=0
Rk110 (VSS \29\:VSS) resistor r=0.6817 c=0
Rk112 (\30\:VSS VSS) resistor r=0.1217 c=0
Rk111 (\29\:VSS \30\:VSS) resistor r=0.06449 c=0
Rk113 (VSS \31\:VSS) resistor r=0.01747 c=0
Rk114 (\31\:VSS \33\:VSS) resistor r=0.6655 c=0
Rk115 (\25\:VSS \35\:VSS) resistor r=0.2482 c=0
Rk116 (\27\:VSS \37\:VSS) resistor r=0.2448 c=0
Rk117 (\29\:VSS \39\:VSS) resistor r=0.2412 c=0
Rk118 (\31\:VSS \41\:VSS) resistor r=0.2412 c=0
Rk2 (\8\:n20 \10\:n20) resistor r=0.546 c=0
Rk3 (\10\:n20 \11\:n20) resistor r=0.2555 c=0
Rk7 (\13\:n20 \14\:n20) resistor r=0.3473 c=0
Rk8 (\13\:n20 \15\:n20) resistor r=0.2307 c=0
Rk9 (\15\:n20 \16\:n20) resistor r=0.2517 c=0
Rk10 (\16\:n20 \18\:n20) resistor r=0.2474 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8535 c=0
Rk11 (\16\:CKbb \18\:CKbb) resistor r=0.5348 c=0
Rk12 (\18\:CKbb \19\:CKbb) resistor r=0.2047 c=0
Rk67 (\20\:CKbb \21\:CKbb) resistor r=0.9488 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.6054 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.5102 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.04826 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.198 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1285 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.5423 c=0
Rk31 (\9\:mout \16\:mout) resistor r=0.1048 c=0
Rk32 (\10\:mout \17\:mout) resistor r=0.3958 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3527 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1588 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.1646 c=0
Rk43 (\19\:CKb \20\:CKb) resistor r=0.3735 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1643 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3826 c=0
Rk66 (\15\:RNb \16\:RNb) resistor r=0.6792 c=0
Rk38 (\5\:SEb \6\:SEb) resistor r=0.2181 c=0
Rk39 (\6\:SEb \7\:SEb) resistor r=0.3488 c=0
Rk40 (\6\:SEb \9\:SEb) resistor r=0.3114 c=0
Rk44 (\7\:n35g \8\:n35g) resistor r=0.2748 c=0
Rk45 (\7\:n35g \10\:n35g) resistor r=0.6952 c=0
Rk56 (\12\:n35g \13\:n35g) resistor r=0.2443 c=0
Rk57 (\13\:n35g \14\:n35g) resistor r=0.5686 c=0
Rk58 (\13\:n35g \16\:n35g) resistor r=0.4343 c=0
Rk53 (\12\:qbint \13\:qbint) resistor r=0.4973 c=0
Rk54 (\13\:qbint \15\:qbint) resistor r=0.5702 c=0
Rk55 (\13\:qbint \17\:qbint) resistor r=0.1471 c=0
Rk68 (\18\:qbint \19\:qbint) resistor r=0.2424 c=0
Rk59 (\5\:RTb \7\:RTb) resistor r=0.2174 c=0
Rk60 (\7\:RTb \8\:RTb) resistor r=0.4188 c=0
Rk61 (\8\:RTb \9\:RTb) resistor r=0.6924 c=0
Rk62 (\8\:RTb \11\:RTb) resistor r=0.3083 c=0
Rk41 (\5\:n35 \6\:n35) resistor r=0.412 c=0
Rk42 (\6\:n35 \8\:n35) resistor r=0.2919 c=0
Rk46 (\10\:n35 \11\:n35) resistor r=0.4031 c=0
Rk47 (\11\:n35 \13\:n35) resistor r=0.3317 c=0
Rk69 (\15\:n35 \16\:n35) resistor r=0.4129 c=0
Rk70 (\16\:n35 \18\:n35) resistor r=0.3473 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6398 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.4053 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5681 c=0
Rk74 (\2\:n10 \4\:n10) resistor r=0.5717 c=0
Rl21 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl20 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl55 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl42 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl45 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl44 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl43 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl24 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl26 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl23 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl25 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl22 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl17 (\2\:D \4\:D) resistor r=115.099 c=0
Rl15 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl16 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\5\:n20 \6\:n20) resistor r=285.406 c=0
Rl13 (\3\:n20 \4\:n20) resistor r=208.269 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=213.245 c=0
Rl5 (CKbb \2\:CKbb) resistor r=38.8525 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=66.575 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=264.436 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=65.3159 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=753.137 c=0
Rl54 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=455.369 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl63 (\11\:CKb \12\:CKb) resistor r=804.248 c=0
Rl27 (CKb \2\:CKb) resistor r=349.798 c=0
Rl32 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl29 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl33 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl28 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl30 (\4\:CKb \5\:CKb) resistor r=61.3849 c=0
Rl34 (\5\:CKb \9\:CKb) resistor r=146 c=0
Rl31 (\5\:CKb \6\:CKb) resistor r=271.541 c=0
Rl35 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl70 (\7\:RNb \8\:RNb) resistor r=233.721 c=0
Rl71 (\8\:RNb \9\:RNb) resistor r=267.896 c=0
Rl56 (RNb \2\:RNb) resistor r=1075.02 c=0
Rl59 (\2\:RNb \5\:RNb) resistor r=114.179 c=0
Rl60 (\3\:RNb \6\:RNb) resistor r=153.384 c=0
Rl58 (\3\:RNb \4\:RNb) resistor r=293.646 c=0
Rl57 (\2\:RNb \3\:RNb) resistor r=46.238 c=0
Rl18 (SEb \2\:SEb) resistor r=101.718 c=0
Rl19 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl38 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl36 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl37 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl39 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl69 (\10\:qbint \11\:qbint) resistor r=260.089 c=0
Rl68 (\8\:qbint \10\:qbint) resistor r=512.697 c=0
Rl49 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl46 (qbint \2\:qbint) resistor r=112.732 c=0
Rl48 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl47 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl67 (\7\:qbint \9\:qbint) resistor r=70.3116 c=0
Rl65 (\6\:qbint \7\:qbint) resistor r=76.2993 c=0
Rl66 (\7\:qbint \8\:qbint) resistor r=254.112 c=0
Rl40 (RTb \2\:RTb) resistor r=112.412 c=0
Rl41 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl61 (n35 \2\:n35) resistor r=442.189 c=0
Rl62 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz22 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz23 (\3\:VDD \5\:VDD) resistor r=25 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz27 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz28 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz11 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz20 (n10 \2\:n10) resistor r=75 c=0
Rz21 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry21 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\10\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry24 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry25 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry31 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry33 (\23\:VSS \24\:VSS) resistor r=31 c=0
Ry34 (\23\:VSS \26\:VSS) resistor r=10.3333 c=0
Ry35 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry36 (\23\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry3 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Rx15 (\2\:SI \5\:SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx27 (\3\:RT \9\:RT) resistor r=45 c=0
Rx28 (\1\:RT \10\:RT) resistor r=45 c=0
Rx29 (\7\:RT \11\:RT) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx16 (\1\:SE \7\:SE) resistor r=45 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \11\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx7 (\6\:n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:n20 \16\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx9 (CKbb \19\:CKbb) resistor r=45 c=0
Rx32 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx33 (\5\:CKbb \21\:CKbb) resistor r=45 c=0
Rx13 (\4\:mout \10\:mout) resistor r=45 c=0
Rx14 (\2\:mout \17\:mout) resistor r=45 c=0
Rx11 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx19 (CKb \19\:CKb) resistor r=45 c=0
Rx20 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx3 (\4\:RNb \12\:RNb) resistor r=45 c=0
Rx30 (RNb \15\:RNb) resistor r=45 c=0
Rx31 (\9\:RNb \16\:RNb) resistor r=45 c=0
Rx17 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx21 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx24 (n35g \14\:n35g) resistor r=45 c=0
Rx23 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx34 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx35 (qbint \19\:qbint) resistor r=45 c=0
Rx25 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx26 (RTb \9\:RTb) resistor r=45 c=0
Rx18 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx22 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx36 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\15\:mout \6\:RNb \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \9\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \11\:qbint \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n10 \8\:RNb \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\9\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\12\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.17022 \
        scb=0.00118687 scc=2.51048e-06 m=(1)
mp31 (n5 \5\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.5373 \
        scb=0.0297678 scc=0.00268647 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=19.3315 \
        scb=0.0212584 scc=0.000579348 m=(1)
mp55 (\4\:Q \9\:qbint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.4029 \
        scb=0.0248226 scc=0.000748112 m=(1)
mp51 (n9 \7\:RNb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=19.1728 \
        scb=0.0210507 scc=0.000546994 m=(1)
ends SRDFFRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:03:52 2012 )
// Library name: gsclib045
// Cell name: SRDFFRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFRX1 CK D ExtVDD Q QN RN RT SE SI VDD VSS
mp22 (\8\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (Q VSS) capacitor c=6.77488e-17
C2 (ExtVDD VSS) capacitor c=2.30193e-16
C3 (SI VSS) capacitor c=9.04304e-17
C4 (RN VSS) capacitor c=8.36082e-17
C5 (RT VSS) capacitor c=6.00722e-17
C6 (QN VSS) capacitor c=2.76152e-17
C7 (VDD VSS) capacitor c=7.54776e-16
C8 (SE VSS) capacitor c=9.23296e-17
C9 (D VSS) capacitor c=3.83522e-17
C10 (n20 VSS) capacitor c=3.92699e-17
C11 (CKbb VSS) capacitor c=2.88856e-17
C12 (mout VSS) capacitor c=4.80664e-17
C13 (CKb VSS) capacitor c=5.97859e-17
C14 (RNb VSS) capacitor c=5.78139e-17
C15 (SEb VSS) capacitor c=7.75136e-17
C16 (n35g VSS) capacitor c=1.77753e-17
C17 (qbint VSS) capacitor c=4.54407e-17
C18 (RTb VSS) capacitor c=5.18061e-17
C19 (net573 VSS) capacitor c=2.25772e-17
C20 (n35 VSS) capacitor c=1.5135e-16
C21 (Db VSS) capacitor c=1.058e-16
C22 (n11 VSS) capacitor c=6.29546e-17
C23 (n10 VSS) capacitor c=7.48782e-17
C24 (n1 VSS) capacitor c=1.02126e-18
C25 (\7\:qbint VSS) capacitor c=3.36523e-17
C26 (\11\:qbint VSS) capacitor c=1.20328e-16
C27 (\2\:RNb VSS) capacitor c=3.69147e-16
C28 (\13\:qbint VSS) capacitor c=4.40915e-17
C29 (\3\:net573 VSS) capacitor c=5.86778e-17
C30 (\11\:CKbb VSS) capacitor c=5.65953e-17
C31 (\4\:RTb VSS) capacitor c=9.88373e-17
C32 (\6\:RT VSS) capacitor c=2.20693e-17
C33 (\4\:qbint VSS) capacitor c=5.36612e-17
C34 (\3\:n35g VSS) capacitor c=5.19979e-17
C35 (\5\:RT VSS) capacitor c=6.97914e-17
C36 (\3\:SE VSS) capacitor c=7.6545e-17
C37 (\7\:CKb VSS) capacitor c=3.4512e-17
C38 (\3\:SI VSS) capacitor c=9.47782e-17
C39 (\4\:SE VSS) capacitor c=1.23145e-16
C40 (\7\:RNb VSS) capacitor c=5.99721e-17
C41 (\4\:D VSS) capacitor c=7.03535e-17
C42 (\5\:n20 VSS) capacitor c=9.42183e-17
C43 (\4\:CK VSS) capacitor c=5.9719e-17
C44 (\4\:CKb VSS) capacitor c=4.61759e-17
C45 (\8\:CKb VSS) capacitor c=8.21133e-17
C46 (\3\:CKbb VSS) capacitor c=2.54163e-17
C47 (\1\:RN VSS) capacitor c=4.14282e-17
C48 (\6\:qbint VSS) capacitor c=3.74891e-17
C49 (\12\:qbint VSS) capacitor c=5.80945e-17
C50 (\14\:qbint VSS) capacitor c=4.60218e-17
C51 (\4\:net573 VSS) capacitor c=3.68027e-17
C52 (\11\:CKb VSS) capacitor c=2.02821e-16
C53 (\8\:RT VSS) capacitor c=1.22101e-16
C54 (\2\:RT VSS) capacitor c=6.23027e-17
C55 (\5\:qbint VSS) capacitor c=3.89021e-17
C56 (\5\:n35g VSS) capacitor c=3.28666e-17
C57 (\2\:RTb VSS) capacitor c=4.86582e-17
C58 (\5\:SE VSS) capacitor c=5.77695e-17
C59 (\5\:CKbb VSS) capacitor c=3.48485e-17
C60 (\1\:SI VSS) capacitor c=4.91308e-17
C61 (\6\:SE VSS) capacitor c=8.62193e-17
C62 (\6\:RNb VSS) capacitor c=5.26448e-17
C63 (\3\:SEb VSS) capacitor c=6.59873e-17
C64 (\1\:D VSS) capacitor c=4.94494e-17
C65 (\3\:n20 VSS) capacitor c=4.38664e-17
C66 (\1\:CK VSS) capacitor c=2.87619e-17
C67 (\3\:mout VSS) capacitor c=5.01444e-17
C68 (\9\:CKb VSS) capacitor c=3.86211e-17
C69 (\10\:CKbb VSS) capacitor c=4.92772e-17
C70 (\6\:CKb VSS) capacitor c=4.9159e-17
C71 (\4\:RN VSS) capacitor c=3.68513e-17
C72 (\12\:CKbb VSS) capacitor c=5.16127e-17
C73 (\10\:qbint VSS) capacitor c=8.53651e-17
C74 (\7\:RT VSS) capacitor c=1.52948e-16
C75 (\9\:CKbb VSS) capacitor c=1.67521e-16
C76 (\3\:RT VSS) capacitor c=5.08277e-17
C77 (\1\:RT VSS) capacitor c=5.22705e-17
C78 (\3\:RTb VSS) capacitor c=7.5942e-17
C79 (\3\:qbint VSS) capacitor c=4.42891e-17
C80 (\2\:n35 VSS) capacitor c=2.32651e-16
C81 (\4\:n35g VSS) capacitor c=6.68719e-17
C82 (\12\:CKb VSS) capacitor c=2.17818e-16
C83 (\3\:n35 VSS) capacitor c=1.06034e-16
C84 (\1\:SE VSS) capacitor c=2.48216e-17
C85 (\2\:SI VSS) capacitor c=7.769e-17
C86 (\2\:SEb VSS) capacitor c=7.74591e-17
C87 (\3\:D VSS) capacitor c=1.47465e-17
C88 (\6\:n20 VSS) capacitor c=8.05878e-17
C89 (\4\:n20 VSS) capacitor c=3.85621e-17
C90 (\3\:CK VSS) capacitor c=2.32859e-17
C91 (\2\:mout VSS) capacitor c=3.17302e-17
C92 (\4\:mout VSS) capacitor c=3.92547e-17
C93 (\7\:n20 VSS) capacitor c=5.4197e-17
C94 (\4\:CKbb VSS) capacitor c=7.10193e-17
C95 (\8\:CKbb VSS) capacitor c=2.70288e-17
C96 (\5\:RNb VSS) capacitor c=1.19217e-16
C97 (\2\:n20 VSS) capacitor c=4.55346e-17
C98 (\3\:RN VSS) capacitor c=4.75117e-17
C99 (\1\:VDD VSS) capacitor c=4.93951e-17
C100 (\3\:Q VSS) capacitor c=7.29834e-17
C101 (\11\:VDD VSS) capacitor c=4.90276e-17
C102 (\9\:net573 VSS) capacitor c=5.58518e-17
C103 (\13\:VDD VSS) capacitor c=7.96787e-17
C104 (\3\:n11 VSS) capacitor c=9.94421e-17
C105 (\4\:QN VSS) capacitor c=5.9451e-17
C106 (\14\:n35 VSS) capacitor c=5.24739e-17
C107 (\15\:n35g VSS) capacitor c=5.5909e-17
C108 (\6\:RTb VSS) capacitor c=7.24208e-17
C109 (\1\:ExtVDD VSS) capacitor c=2.78533e-16
C110 (\9\:n35 VSS) capacitor c=6.19273e-17
C111 (\17\:qbint VSS) capacitor c=6.81986e-17
C112 (\6\:n35g VSS) capacitor c=9.60383e-17
C113 (\8\:SEb VSS) capacitor c=5.06071e-17
C114 (\4\:n35 VSS) capacitor c=6.12731e-17
C115 (\15\:VDD VSS) capacitor c=6.10012e-17
C116 (\5\:mout VSS) capacitor c=7.76403e-17
C117 (\3\:Db VSS) capacitor c=1.90964e-16
C118 (\17\:VDD VSS) capacitor c=3.85232e-17
C119 (\22\:VDD VSS) capacitor c=3.52556e-17
C120 (\13\:mout VSS) capacitor c=5.83998e-17
C121 (\17\:CKb VSS) capacitor c=2.91722e-17
C122 (\20\:VDD VSS) capacitor c=4.12536e-17
C123 (\17\:CKbb VSS) capacitor c=6.76195e-17
C124 (\13\:n20 VSS) capacitor c=6.3032e-17
C125 (\5\:Db VSS) capacitor c=2.18772e-16
C126 (\8\:RNb VSS) capacitor c=5.40837e-17
C127 (\10\:n20 VSS) capacitor c=6.3646e-17
C128 (\24\:VDD VSS) capacitor c=4.25619e-17
C129 (\1\:Q VSS) capacitor c=5.32881e-17
C130 (\5\:net573 VSS) capacitor c=4.31427e-17
C131 (\3\:n10 VSS) capacitor c=7.9152e-17
C132 (\1\:QN VSS) capacitor c=3.75793e-17
C133 (\17\:n35 VSS) capacitor c=4.13331e-17
C134 (\11\:n35g VSS) capacitor c=2.96827e-17
C135 (\10\:RTb VSS) capacitor c=5.81982e-17
C136 (\12\:n35 VSS) capacitor c=6.35168e-17
C137 (\19\:qbint VSS) capacitor c=2.43447e-17
C138 (\9\:n35g VSS) capacitor c=7.72521e-17
C139 (\4\:SEb VSS) capacitor c=3.862e-17
C140 (\7\:n35 VSS) capacitor c=3.77874e-17
C141 (\11\:mout VSS) capacitor c=3.75653e-17
C142 (\15\:mout VSS) capacitor c=2.97046e-17
C143 (\13\:CKb VSS) capacitor c=6.50014e-17
C144 (\15\:CKbb VSS) capacitor c=8.31141e-17
C145 (\17\:n20 VSS) capacitor c=8.30467e-17
C146 (\7\:Db VSS) capacitor c=7.74174e-17
C147 (\11\:RNb VSS) capacitor c=7.08116e-17
C148 (\8\:n20 VSS) capacitor c=5.88674e-17
C149 (VDD VSS) capacitor c=6.97221e-17
C150 (\2\:CKbb VSS) capacitor c=6.16702e-17
C151 (\2\:CK VSS) capacitor c=3.36601e-17
C152 (\2\:D VSS) capacitor c=3.55457e-17
C153 (\2\:SE VSS) capacitor c=2.57292e-17
C154 (\2\:CKb VSS) capacitor c=1.43171e-16
C155 (\3\:CKb VSS) capacitor c=7.50789e-17
C156 (\5\:CKb VSS) capacitor c=7.54648e-17
C157 (\2\:n35g VSS) capacitor c=2.91124e-17
C158 (\4\:RT VSS) capacitor c=5.2386e-17
C159 (\2\:qbint VSS) capacitor c=4.11016e-17
C160 (\6\:CKbb VSS) capacitor c=1.28162e-16
C161 (\7\:CKbb VSS) capacitor c=6.52723e-17
C162 (\2\:net573 VSS) capacitor c=1.5367e-17
C163 (\12\:n20 VSS) capacitor c=4.40692e-17
C164 (\3\:RNb VSS) capacitor c=2.91833e-16
C165 (\4\:RNb VSS) capacitor c=1.1855e-16
C166 (\10\:RNb VSS) capacitor c=1.20246e-16
C167 (\13\:CKbb VSS) capacitor c=1.55458e-16
C168 (\14\:CKbb VSS) capacitor c=1.38277e-16
C169 (\15\:n20 VSS) capacitor c=7.5196e-17
C170 (\16\:n20 VSS) capacitor c=9.28307e-17
C171 (\8\:qbint VSS) capacitor c=5.11452e-17
C172 (\9\:qbint VSS) capacitor c=7.72727e-17
C173 (\19\:CKbb VSS) capacitor c=5.16846e-17
C174 (\5\:CK VSS) capacitor c=4.77117e-17
C175 (\6\:CK VSS) capacitor c=3.67433e-17
C176 (\19\:n20 VSS) capacitor c=4.89495e-17
C177 (\20\:n20 VSS) capacitor c=4.84792e-17
C178 (\15\:CKb VSS) capacitor c=6.11815e-17
C179 (\16\:CKb VSS) capacitor c=4.13179e-17
C180 (\7\:D VSS) capacitor c=4.85056e-17
C181 (\7\:mout VSS) capacitor c=8.35937e-17
C182 (\8\:mout VSS) capacitor c=5.28295e-17
C183 (\9\:mout VSS) capacitor c=1.90246e-17
C184 (\10\:mout VSS) capacitor c=7.5834e-17
C185 (\17\:mout VSS) capacitor c=7.40516e-17
C186 (\6\:n35 VSS) capacitor c=7.11534e-17
C187 (\6\:SEb VSS) capacitor c=8.35365e-17
C188 (\7\:SEb VSS) capacitor c=6.80475e-17
C189 (\19\:CKb VSS) capacitor c=3.49327e-17
C190 (\20\:CKb VSS) capacitor c=3.64971e-17
C191 (\8\:n35g VSS) capacitor c=3.39835e-17
C192 (\11\:n35 VSS) capacitor c=7.49055e-17
C193 (\15\:qbint VSS) capacitor c=8.78471e-17
C194 (\16\:qbint VSS) capacitor c=1.11964e-16
C195 (\13\:n35g VSS) capacitor c=1.02815e-16
C196 (\14\:n35g VSS) capacitor c=1.1611e-16
C197 (\5\:RTb VSS) capacitor c=4.9153e-17
C198 (\8\:RTb VSS) capacitor c=9.96219e-17
C199 (\9\:RTb VSS) capacitor c=9.1018e-17
C200 (\10\:RT VSS) capacitor c=1.04967e-16
C201 (\11\:RT VSS) capacitor c=1.18336e-16
C202 (\21\:qbint VSS) capacitor c=2.43468e-17
C203 (\22\:qbint VSS) capacitor c=3.00163e-17
C204 (\20\:CKbb VSS) capacitor c=9.70534e-17
C205 (\21\:CKbb VSS) capacitor c=1.00377e-16
C206 (\3\:QN VSS) capacitor c=3.73666e-17
C207 (\16\:n35 VSS) capacitor c=4.45599e-17
C208 (\7\:net573 VSS) capacitor c=5.35006e-17
C209 (\8\:net573 VSS) capacitor c=3.44553e-17
C210 (\3\:VDD VSS) capacitor c=5.03511e-17
C211 (\5\:VDD VSS) capacitor c=9.96254e-18
C212 (\6\:VDD VSS) capacitor c=2.20714e-16
C213 (\7\:VDD VSS) capacitor c=2.06079e-16
C214 (\8\:VDD VSS) capacitor c=2.3561e-17
C215 (\10\:VDD VSS) capacitor c=3.18808e-17
C216 (\19\:VDD VSS) capacitor c=5.20684e-17
Rk74 (\2\:Q Q) resistor r=0.1701 c=0
Rk75 (Q \4\:Q) resistor r=0.2885 c=0
Rk47 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk45 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk48 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk49 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk1 (\5\:RN RN) resistor r=0.006381 c=0
Rk61 (RT \10\:RT) resistor r=0.1993 c=0
Rk62 (\10\:RT \11\:RT) resistor r=0.6434 c=0
Rk12 (CK \5\:CK) resistor r=0.004361 c=0
Rk14 (\5\:CK \6\:CK) resistor r=0.01475 c=0
Rk13 (\6\:CK \7\:CK) resistor r=0.004543 c=0
Rk66 (\3\:QN QN) resistor r=0.01499 c=0
Rk65 (\2\:QN \3\:QN) resistor r=0.2917 c=0
Rk67 (\3\:QN \5\:QN) resistor r=0.3259 c=0
Rk108 (VDD VDD) resistor r=0.2367 c=0
Rk94 (\2\:VDD \3\:VDD) resistor r=0.578 c=0
Rk95 (\3\:VDD \5\:VDD) resistor r=0.06692 c=0
Rk96 (\5\:VDD \6\:VDD) resistor r=0.05201 c=0
Rk97 (\6\:VDD \7\:VDD) resistor r=1.5259 c=0
Rk98 (\7\:VDD \8\:VDD) resistor r=0.186 c=0
Rk99 (\8\:VDD \10\:VDD) resistor r=0.1545 c=0
Rk100 (\3\:VDD \12\:VDD) resistor r=0.294 c=0
Rk101 (\6\:VDD \14\:VDD) resistor r=0.3757 c=0
Rk102 (\7\:VDD \16\:VDD) resistor r=0.3677 c=0
Rk103 (\8\:VDD \18\:VDD) resistor r=0.2024 c=0
Rk107 (\19\:VDD VDD) resistor r=0.1959 c=0
Rk104 (\10\:VDD \19\:VDD) resistor r=0.1713 c=0
Rk105 (\19\:VDD \21\:VDD) resistor r=0.1998 c=0
Rk106 (\10\:VDD \23\:VDD) resistor r=0.2381 c=0
Rk109 (VDD \25\:VDD) resistor r=0.3792 c=0
Rk19 (\5\:D D) resistor r=0.006794 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01719 c=0
Rk20 (\6\:D \7\:D) resistor r=0.006794 c=0
Rk77 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk78 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk79 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk80 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk81 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk83 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk82 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk84 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk85 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk87 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk86 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk88 (VSS \14\:VSS) resistor r=0.313 c=0
Rk89 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk90 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk91 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk92 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk93 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk110 (\26\:VSS \27\:VSS) resistor r=0.08432 c=0
Rk111 (\27\:VSS \28\:VSS) resistor r=0.1142 c=0
Rk112 (\28\:VSS \29\:VSS) resistor r=0.0893 c=0
Rk113 (\29\:VSS \30\:VSS) resistor r=0.3578 c=0
Rk115 (\31\:VSS VSS) resistor r=0.3774 c=0
Rk114 (\30\:VSS \31\:VSS) resistor r=0.3679 c=0
Rk116 (VSS \32\:VSS) resistor r=0.1494 c=0
Rk118 (\33\:VSS VSS) resistor r=0.3252 c=0
Rk117 (\32\:VSS \33\:VSS) resistor r=0.5417 c=0
Rk119 (VSS \34\:VSS) resistor r=0.01745 c=0
Rk120 (\34\:VSS \35\:VSS) resistor r=0.05947 c=0
Rk121 (\35\:VSS \37\:VSS) resistor r=0.6053 c=0
Rk122 (\27\:VSS \39\:VSS) resistor r=0.2409 c=0
Rk123 (\29\:VSS \41\:VSS) resistor r=0.2472 c=0
Rk124 (\31\:VSS \43\:VSS) resistor r=0.2445 c=0
Rk125 (\33\:VSS \45\:VSS) resistor r=0.2409 c=0
Rk126 (\34\:VSS \47\:VSS) resistor r=0.2409 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3469 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2525 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4762 c=0
Rk15 (\19\:n20 \20\:n20) resistor r=0.2144 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8523 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.5355 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.194 c=0
Rk64 (\20\:CKbb \21\:CKbb) resistor r=0.7635 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.6076 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.3647 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.1128 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.2021 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1352 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.525 c=0
Rk31 (\9\:mout \16\:mout) resistor r=0.09784 c=0
Rk32 (\10\:mout \17\:mout) resistor r=0.426 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3503 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1622 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.1643 c=0
Rk40 (\19\:CKb \20\:CKb) resistor r=0.3729 c=0
Rk4 (\9\:RNb \10\:RNb) resistor r=0.193 c=0
Rk5 (\10\:RNb \12\:RNb) resistor r=0.3636 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3502 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk41 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk42 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk53 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk54 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk55 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk50 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk51 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk52 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk63 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk56 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk57 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk58 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk59 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk70 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk71 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk72 (\7\:net573 \10\:net573) resistor r=0.2923 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk43 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk44 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.3075 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.2886 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.3936 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5673 c=0
Rk76 (\2\:n11 \4\:n11) resistor r=0.71 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.6281 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl43 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl46 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl45 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl44 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\2\:D \4\:D) resistor r=115.099 c=0
Rl16 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl17 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\5\:n20 \6\:n20) resistor r=190.564 c=0
Rl13 (\3\:n20 \4\:n20) resistor r=90.3645 c=0
Rl15 (\6\:n20 \7\:n20) resistor r=117.486 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl59 (\11\:CKbb \12\:CKbb) resistor r=137.716 c=0
Rl5 (CKbb \2\:CKbb) resistor r=39.6682 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl51 (\5\:CKbb \6\:CKbb) resistor r=65.0422 c=0
Rl54 (\6\:CKbb \9\:CKbb) resistor r=808.345 c=0
Rl55 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl53 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl52 (\6\:CKbb \7\:CKbb) resistor r=416.829 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl60 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl28 (CKb \2\:CKb) resistor r=395.821 c=0
Rl33 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl30 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl34 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl29 (\2\:CKb \3\:CKb) resistor r=385.443 c=0
Rl31 (\4\:CKb \5\:CKb) resistor r=58.0449 c=0
Rl35 (\5\:CKb \9\:CKb) resistor r=133.091 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=268.582 c=0
Rl36 (\5\:CKb \10\:CKb) resistor r=4.0748 c=0
Rl64 (RNb \2\:RNb) resistor r=234.8 c=0
Rl65 (\2\:RNb \3\:RNb) resistor r=1469.68 c=0
Rl68 (\3\:RNb \6\:RNb) resistor r=180.888 c=0
Rl69 (\4\:RNb \7\:RNb) resistor r=75.8186 c=0
Rl67 (\4\:RNb \5\:RNb) resistor r=424.798 c=0
Rl66 (\3\:RNb \4\:RNb) resistor r=83.4088 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl39 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl37 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl38 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl40 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl70 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl75 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl77 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl50 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl47 (qbint \2\:qbint) resistor r=112.732 c=0
Rl49 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl48 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl71 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl74 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl76 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl73 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl72 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl41 (RTb \2\:RTb) resistor r=112.412 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl61 (net573 \2\:net573) resistor r=3.1216 c=0
Rl62 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl63 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl57 (n35 \2\:n35) resistor r=508.667 c=0
Rl58 (\2\:n35 \3\:n35) resistor r=380.826 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz18 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz24 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz25 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz26 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz27 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz28 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz30 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz36 (\42\:VSS \43\:VSS) resistor r=75 c=0
Rz37 (\44\:VSS \45\:VSS) resistor r=75 c=0
Rz38 (\46\:VSS \47\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz2 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz11 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz20 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz19 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry23 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry32 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry33 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry34 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry37 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=31 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=31 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \32\:VSS) resistor r=5.6364 c=0
Ry42 (\25\:VSS \35\:VSS) resistor r=7.75 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry2 (\8\:RNb \9\:RNb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry24 (n11 \2\:n11) resistor r=62 c=0
Ry25 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\3\:CK \7\:CK) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\7\:n20 \16\:n20) resistor r=45 c=0
Rx10 (\6\:n20 \19\:n20) resistor r=45 c=0
Rx11 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx12 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (CKb \19\:CKb) resistor r=45 c=0
Rx21 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx3 (\5\:RNb \10\:RNb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx31 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx32 (qbint \22\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx36 (net573 \8\:net573) resistor r=45 c=0
Rx18 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx35 (n35 \16\:n35) resistor r=45 c=0
mn22 (\11\:RNb \4\:RN \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb \44\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \42\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 RNb \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp31 (n5 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.74828 \
        scb=0.00141025 scc=2.59727e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0497 \
        scb=0.0111987 scc=0.000289961 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \2\:RNb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:04:47 2012 )
// Library name: gsclib045
// Cell name: SRDFFSQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSQX1 CK D ExtVDD Q RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=1.95048e-17
C2 (D VSS) capacitor c=7.90325e-17
C3 (ExtVDD VSS) capacitor c=2.25481e-16
C4 (CK VSS) capacitor c=6.15029e-17
C5 (SI VSS) capacitor c=8.75259e-17
C6 (RT VSS) capacitor c=6.46434e-17
C7 (SN VSS) capacitor c=4.79525e-17
C8 (VDD VSS) capacitor c=7.18071e-16
C9 (SE VSS) capacitor c=9.26878e-17
C10 (n20 VSS) capacitor c=3.84704e-17
C11 (CKbb VSS) capacitor c=3.2382e-17
C12 (mout VSS) capacitor c=4.84697e-17
C13 (CKb VSS) capacitor c=5.0436e-17
C14 (SEb VSS) capacitor c=7.76244e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.60369e-17
C17 (RTb VSS) capacitor c=5.17974e-17
C18 (n35 VSS) capacitor c=1.72427e-16
C19 (Db VSS) capacitor c=1.02921e-16
C20 (n11 VSS) capacitor c=8.1482e-17
C21 (n1 VSS) capacitor c=8.87983e-19
C22 (\7\:SN VSS) capacitor c=8.82435e-17
C23 (\7\:qbint VSS) capacitor c=3.7351e-17
C24 (\10\:qbint VSS) capacitor c=1.01692e-16
C25 (\11\:CKbb VSS) capacitor c=4.77402e-17
C26 (\4\:RTb VSS) capacitor c=9.76746e-17
C27 (\6\:RT VSS) capacitor c=2.23208e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.19228e-17
C30 (\5\:RT VSS) capacitor c=6.48326e-17
C31 (\3\:SE VSS) capacitor c=7.71436e-17
C32 (\8\:CKb VSS) capacitor c=2.96146e-17
C33 (\3\:SI VSS) capacitor c=9.43059e-17
C34 (\4\:SE VSS) capacitor c=1.25071e-16
C35 (\4\:D VSS) capacitor c=6.94903e-17
C36 (\3\:n20 VSS) capacitor c=3.30664e-17
C37 (\1\:SN VSS) capacitor c=3.07428e-17
C38 (\4\:CK VSS) capacitor c=6.33781e-17
C39 (\4\:CKb VSS) capacitor c=4.34245e-17
C40 (\9\:CKb VSS) capacitor c=8.38868e-17
C41 (\3\:CKbb VSS) capacitor c=2.64181e-17
C42 (\6\:qbint VSS) capacitor c=4.17716e-17
C43 (\8\:SN VSS) capacitor c=1.46965e-16
C44 (\11\:qbint VSS) capacitor c=1.49802e-16
C45 (\12\:CKb VSS) capacitor c=2.55236e-16
C46 (\8\:RT VSS) capacitor c=1.20655e-16
C47 (\2\:RT VSS) capacitor c=6.21869e-17
C48 (\5\:qbint VSS) capacitor c=3.87334e-17
C49 (\5\:n35g VSS) capacitor c=3.28693e-17
C50 (\2\:RTb VSS) capacitor c=4.65075e-17
C51 (\5\:SE VSS) capacitor c=5.7365e-17
C52 (\5\:CKbb VSS) capacitor c=2.73311e-17
C53 (\1\:SI VSS) capacitor c=4.90982e-17
C54 (\6\:SE VSS) capacitor c=8.63749e-17
C55 (\3\:SEb VSS) capacitor c=6.59314e-17
C56 (\1\:D VSS) capacitor c=4.94601e-17
C57 (\7\:n20 VSS) capacitor c=6.12287e-17
C58 (\6\:SN VSS) capacitor c=6.63573e-17
C59 (\1\:CK VSS) capacitor c=2.87786e-17
C60 (\3\:mout VSS) capacitor c=4.54948e-17
C61 (\11\:CKb VSS) capacitor c=3.86863e-17
C62 (\10\:CKbb VSS) capacitor c=4.83019e-17
C63 (\7\:CKb VSS) capacitor c=5.09176e-17
C64 (\9\:qbint VSS) capacitor c=8.50195e-17
C65 (\12\:CKbb VSS) capacitor c=5.13348e-17
C66 (\3\:SN VSS) capacitor c=2.94979e-16
C67 (\9\:SN VSS) capacitor c=6.35258e-17
C68 (\7\:RT VSS) capacitor c=1.46821e-16
C69 (\9\:CKbb VSS) capacitor c=1.67836e-16
C70 (\3\:RT VSS) capacitor c=3.94588e-17
C71 (\1\:RT VSS) capacitor c=5.29002e-17
C72 (\3\:RTb VSS) capacitor c=7.57746e-17
C73 (\3\:qbint VSS) capacitor c=4.37709e-17
C74 (\2\:n35 VSS) capacitor c=2.52896e-16
C75 (\4\:n35g VSS) capacitor c=6.63869e-17
C76 (\13\:CKb VSS) capacitor c=2.17891e-16
C77 (\3\:n35 VSS) capacitor c=1.15146e-16
C78 (\1\:SE VSS) capacitor c=2.47752e-17
C79 (\2\:SI VSS) capacitor c=7.74104e-17
C80 (\2\:SEb VSS) capacitor c=7.79882e-17
C81 (\4\:n20 VSS) capacitor c=9.8643e-17
C82 (\6\:n20 VSS) capacitor c=5.87967e-17
C83 (\3\:D VSS) capacitor c=1.47417e-17
C84 (\2\:SN VSS) capacitor c=4.72396e-17
C85 (\5\:SN VSS) capacitor c=1.95507e-17
C86 (\3\:CK VSS) capacitor c=2.22345e-17
C87 (\2\:mout VSS) capacitor c=4.32831e-17
C88 (\4\:mout VSS) capacitor c=3.05301e-17
C89 (\10\:CKb VSS) capacitor c=2.18385e-17
C90 (\5\:n20 VSS) capacitor c=6.33008e-17
C91 (\4\:CKbb VSS) capacitor c=6.32907e-17
C92 (\8\:CKbb VSS) capacitor c=2.46391e-17
C93 (\2\:n20 VSS) capacitor c=3.94849e-17
C94 (\1\:VDD VSS) capacitor c=2.80666e-17
C95 (\11\:VDD VSS) capacitor c=5.0035e-17
C96 (\4\:Q VSS) capacitor c=5.45787e-17
C97 (\13\:VDD VSS) capacitor c=5.29634e-17
C98 (\3\:n11 VSS) capacitor c=8.3971e-17
C99 (\14\:n35 VSS) capacitor c=5.13832e-17
C100 (\15\:n35g VSS) capacitor c=5.69979e-17
C101 (\6\:RTb VSS) capacitor c=7.28217e-17
C102 (\1\:ExtVDD VSS) capacitor c=2.78211e-16
C103 (\9\:n35 VSS) capacitor c=6.21565e-17
C104 (\14\:qbint VSS) capacitor c=6.82755e-17
C105 (\6\:n35g VSS) capacitor c=9.41385e-17
C106 (\8\:SEb VSS) capacitor c=5.06833e-17
C107 (\4\:n35 VSS) capacitor c=6.39896e-17
C108 (\15\:VDD VSS) capacitor c=6.13069e-17
C109 (\5\:mout VSS) capacitor c=7.57577e-17
C110 (\3\:Db VSS) capacitor c=1.90673e-16
C111 (\17\:VDD VSS) capacitor c=3.6346e-17
C112 (\22\:VDD VSS) capacitor c=3.78681e-17
C113 (\15\:mout VSS) capacitor c=1.02067e-16
C114 (\20\:VDD VSS) capacitor c=6.72915e-17
C115 (\18\:CKb VSS) capacitor c=2.48584e-17
C116 (\17\:CKbb VSS) capacitor c=7.93677e-17
C117 (\13\:n20 VSS) capacitor c=6.11956e-17
C118 (\5\:Db VSS) capacitor c=2.33931e-16
C119 (\10\:n20 VSS) capacitor c=6.36453e-17
C120 (\1\:Q VSS) capacitor c=3.73986e-17
C121 (\17\:n35 VSS) capacitor c=3.93544e-17
C122 (\11\:n35g VSS) capacitor c=2.63056e-17
C123 (\10\:RTb VSS) capacitor c=5.83059e-17
C124 (\12\:n35 VSS) capacitor c=6.37112e-17
C125 (\16\:qbint VSS) capacitor c=2.43869e-17
C126 (\9\:n35g VSS) capacitor c=8.056e-17
C127 (\4\:SEb VSS) capacitor c=3.95357e-17
C128 (\7\:n35 VSS) capacitor c=4.10332e-17
C129 (\11\:mout VSS) capacitor c=2.23063e-17
C130 (\13\:mout VSS) capacitor c=1.74521e-17
C131 (\14\:CKb VSS) capacitor c=6.8952e-17
C132 (\15\:CKbb VSS) capacitor c=9.22274e-17
C133 (\17\:n20 VSS) capacitor c=8.70381e-17
C134 (\7\:Db VSS) capacitor c=7.79427e-17
C135 (\8\:n20 VSS) capacitor c=5.89516e-17
C136 (VDD VSS) capacitor c=4.2649e-17
C137 (\2\:CKbb VSS) capacitor c=6.28793e-17
C138 (\2\:CK VSS) capacitor c=3.17677e-17
C139 (\2\:D VSS) capacitor c=3.57107e-17
C140 (\2\:SE VSS) capacitor c=2.50121e-17
C141 (\2\:CKb VSS) capacitor c=1.46221e-16
C142 (\3\:CKb VSS) capacitor c=8.7622e-17
C143 (\5\:CKb VSS) capacitor c=5.84869e-17
C144 (\2\:n35g VSS) capacitor c=2.91068e-17
C145 (\4\:RT VSS) capacitor c=4.60846e-17
C146 (\2\:qbint VSS) capacitor c=4.11428e-17
C147 (\6\:CKbb VSS) capacitor c=1.23198e-16
C148 (\7\:CKbb VSS) capacitor c=7.82294e-17
C149 (\4\:SN VSS) capacitor c=2.43808e-16
C150 (\12\:n20 VSS) capacitor c=4.40883e-17
C151 (\8\:qbint VSS) capacitor c=8.88011e-17
C152 (\13\:CKbb VSS) capacitor c=9.93286e-17
C153 (\14\:CKbb VSS) capacitor c=9.7321e-17
C154 (\15\:n20 VSS) capacitor c=5.21932e-17
C155 (\16\:n20 VSS) capacitor c=9.23421e-17
C156 (\19\:CKbb VSS) capacitor c=4.82477e-17
C157 (\6\:CK VSS) capacitor c=4.1533e-17
C158 (\16\:CKb VSS) capacitor c=5.95117e-17
C159 (\17\:CKb VSS) capacitor c=4.43352e-17
C160 (\10\:SN VSS) capacitor c=3.71238e-17
C161 (\11\:SN VSS) capacitor c=4.54966e-17
C162 (\19\:n20 VSS) capacitor c=5.04696e-17
C163 (\20\:n20 VSS) capacitor c=5.63541e-17
C164 (\7\:mout VSS) capacitor c=7.80368e-17
C165 (\8\:mout VSS) capacitor c=3.68573e-17
C166 (\9\:mout VSS) capacitor c=1.17266e-16
C167 (\10\:mout VSS) capacitor c=8.75638e-17
C168 (\17\:mout VSS) capacitor c=7.17464e-17
C169 (\6\:SEb VSS) capacitor c=8.38168e-17
C170 (\7\:SEb VSS) capacitor c=6.95868e-17
C171 (\6\:n35 VSS) capacitor c=7.82284e-17
C172 (\20\:CKb VSS) capacitor c=3.92018e-17
C173 (\21\:CKb VSS) capacitor c=4.23649e-17
C174 (\8\:n35g VSS) capacitor c=3.46579e-17
C175 (\11\:n35 VSS) capacitor c=7.51701e-17
C176 (\12\:qbint VSS) capacitor c=8.80722e-17
C177 (\13\:qbint VSS) capacitor c=1.12231e-16
C178 (\13\:n35g VSS) capacitor c=9.95615e-17
C179 (\14\:n35g VSS) capacitor c=1.16309e-16
C180 (\5\:RTb VSS) capacitor c=4.95471e-17
C181 (\8\:RTb VSS) capacitor c=9.95035e-17
C182 (\9\:RTb VSS) capacitor c=9.15287e-17
C183 (\10\:RT VSS) capacitor c=1.09721e-16
C184 (\11\:RT VSS) capacitor c=1.18363e-16
C185 (\12\:SN VSS) capacitor c=8.31748e-17
C186 (\13\:SN VSS) capacitor c=7.95664e-17
C187 (\20\:CKbb VSS) capacitor c=1.31062e-16
C188 (\21\:CKbb VSS) capacitor c=1.34586e-16
C189 (\18\:qbint VSS) capacitor c=1.95257e-17
C190 (\19\:qbint VSS) capacitor c=3.00557e-17
C191 (\16\:n35 VSS) capacitor c=4.52132e-17
C192 (\3\:Q VSS) capacitor c=1.70107e-17
C193 (\3\:VDD VSS) capacitor c=2.57292e-17
C194 (\4\:VDD VSS) capacitor c=2.86246e-17
C195 (\6\:VDD VSS) capacitor c=2.03314e-16
C196 (\7\:VDD VSS) capacitor c=2.09015e-16
C197 (\8\:VDD VSS) capacitor c=2.40069e-17
C198 (\10\:VDD VSS) capacitor c=2.27281e-17
C199 (\19\:VDD VSS) capacitor c=2.05808e-17
C200 (\24\:VDD VSS) capacitor c=4.46418e-17
Rk65 (\3\:Q Q) resistor r=0.01117 c=0
Rk64 (\2\:Q \3\:Q) resistor r=0.2899 c=0
Rk66 (\3\:Q \5\:Q) resistor r=0.3337 c=0
Rk85 (\2\:VSS \3\:VSS) resistor r=0.1015 c=0
Rk86 (\3\:VSS \4\:VSS) resistor r=0.1957 c=0
Rk87 (\4\:VSS \5\:VSS) resistor r=0.7611 c=0
Rk88 (\5\:VSS \6\:VSS) resistor r=0.03204 c=0
Rk90 (\7\:VSS VSS) resistor r=0.1211 c=0
Rk89 (\6\:VSS \7\:VSS) resistor r=0.1759 c=0
Rk91 (VSS \8\:VSS) resistor r=0.5208 c=0
Rk92 (\8\:VSS \9\:VSS) resistor r=0.3071 c=0
Rk94 (\10\:VSS VSS) resistor r=0.1213 c=0
Rk93 (\9\:VSS \10\:VSS) resistor r=0.06428 c=0
Rk95 (VSS \12\:VSS) resistor r=0.3119 c=0
Rk96 (\3\:VSS \14\:VSS) resistor r=0.2605 c=0
Rk97 (\5\:VSS \16\:VSS) resistor r=0.1891 c=0
Rk98 (\7\:VSS \18\:VSS) resistor r=0.1942 c=0
Rk99 (\8\:VSS \20\:VSS) resistor r=0.2532 c=0
Rk100 (\9\:VSS \22\:VSS) resistor r=0.2488 c=0
Rk101 (\24\:VSS \25\:VSS) resistor r=0.1808 c=0
Rk102 (\25\:VSS \26\:VSS) resistor r=0.3643 c=0
Rk103 (\26\:VSS \27\:VSS) resistor r=0.3671 c=0
Rk105 (\28\:VSS VSS) resistor r=0.04935 c=0
Rk104 (\27\:VSS \28\:VSS) resistor r=0.3271 c=0
Rk107 (\29\:VSS VSS) resistor r=0.1213 c=0
Rk106 (VSS \29\:VSS) resistor r=0.8929 c=0
Rk108 (\25\:VSS \31\:VSS) resistor r=0.2347 c=0
Rk109 (\27\:VSS \33\:VSS) resistor r=0.2434 c=0
Rk110 (VSS \35\:VSS) resistor r=0.3081 c=0
Rk43 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk41 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk44 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk45 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk10 (CK \6\:CK) resistor r=0.01219 c=0
Rk9 (\5\:CK \6\:CK) resistor r=0.003336 c=0
Rk57 (RT \10\:RT) resistor r=0.1986 c=0
Rk58 (\10\:RT \11\:RT) resistor r=0.6461 c=0
Rk14 (\10\:SN SN) resistor r=0.02012 c=0
Rk15 (SN \11\:SN) resistor r=0.221 c=0
Rk59 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk84 (VDD VDD) resistor r=0.2356 c=0
Rk68 (\2\:VDD \3\:VDD) resistor r=0.3368 c=0
Rk69 (\3\:VDD \4\:VDD) resistor r=0.1658 c=0
Rk70 (\4\:VDD \6\:VDD) resistor r=0.1164 c=0
Rk71 (\6\:VDD \7\:VDD) resistor r=1.5248 c=0
Rk72 (\7\:VDD \8\:VDD) resistor r=0.2302 c=0
Rk73 (\8\:VDD \10\:VDD) resistor r=0.1095 c=0
Rk74 (\3\:VDD \12\:VDD) resistor r=0.3564 c=0
Rk75 (\4\:VDD \14\:VDD) resistor r=0.3013 c=0
Rk76 (\7\:VDD \16\:VDD) resistor r=0.3661 c=0
Rk77 (\8\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk78 (\10\:VDD \19\:VDD) resistor r=0.09403 c=0
Rk79 (\19\:VDD \21\:VDD) resistor r=0.2288 c=0
Rk80 (\10\:VDD \23\:VDD) resistor r=0.2389 c=0
Rk83 (\24\:VDD VDD) resistor r=0.1955 c=0
Rk81 (\19\:VDD \24\:VDD) resistor r=0.07648 c=0
Rk82 (\24\:VDD \25\:VDD) resistor r=0.2188 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.543 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2541 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3402 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2294 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4963 c=0
Rk17 (\19\:n20 \20\:n20) resistor r=0.2606 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7511 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.5421 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.2243 c=0
Rk60 (\20\:CKbb \21\:CKbb) resistor r=0.8245 c=0
Rk21 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk22 (\7\:mout \8\:mout) resistor r=0.3504 c=0
Rk23 (\8\:mout \9\:mout) resistor r=0.1025 c=0
Rk24 (\9\:mout \10\:mout) resistor r=0.3414 c=0
Rk25 (\7\:mout \12\:mout) resistor r=0.1278 c=0
Rk26 (\8\:mout \14\:mout) resistor r=0.09193 c=0
Rk27 (\9\:mout \16\:mout) resistor r=0.6357 c=0
Rk28 (\10\:mout \17\:mout) resistor r=0.425 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.3782 c=0
Rk12 (\16\:CKb \17\:CKb) resistor r=0.1578 c=0
Rk13 (\16\:CKb \19\:CKb) resistor r=0.1343 c=0
Rk36 (\20\:CKb \21\:CKb) resistor r=0.3714 c=0
Rk31 (\5\:SEb \6\:SEb) resistor r=0.2161 c=0
Rk32 (\6\:SEb \7\:SEb) resistor r=0.3544 c=0
Rk33 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk37 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk38 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk49 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk50 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk51 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk46 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk47 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk48 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk61 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk52 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk53 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk54 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk55 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk34 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk35 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk39 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk40 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk62 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk63 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk18 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk19 (\4\:Db \6\:Db) resistor r=1.384 c=0
Rk20 (\6\:Db \8\:Db) resistor r=0.5649 c=0
Rk67 (\2\:n11 \4\:n11) resistor r=0.6527 c=0
Rl13 (\2\:D \4\:D) resistor r=115.099 c=0
Rl11 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl12 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl20 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl19 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl55 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl42 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl45 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl44 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl43 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl68 (\7\:SN \8\:SN) resistor r=366.394 c=0
Rl69 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl10 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl58 (\4\:SN \6\:SN) resistor r=106.74 c=0
Rl56 (\3\:SN \4\:SN) resistor r=1145.23 c=0
Rl57 (\4\:SN \5\:SN) resistor r=8.9604 c=0
Rl23 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl25 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl22 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl24 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl21 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=56.7001 c=0
Rl16 (\6\:n20 \7\:n20) resistor r=98.0144 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=249.192 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl2 (CKbb \2\:CKbb) resistor r=43.9661 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.6212 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl54 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl52 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\12\:CKb \13\:CKb) resistor r=870.726 c=0
Rl26 (CKb \2\:CKb) resistor r=349.798 c=0
Rl32 (\2\:CKb \8\:CKb) resistor r=127.816 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl33 (\3\:CKb \9\:CKb) resistor r=147.793 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=45.0334 c=0
Rl34 (\5\:CKb \10\:CKb) resistor r=1.2301 c=0
Rl35 (\6\:CKb \11\:CKb) resistor r=135.772 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=263.829 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=25.0362 c=0
Rl17 (SEb \2\:SEb) resistor r=101.718 c=0
Rl18 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl38 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl36 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl37 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl39 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl63 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl67 (\10\:qbint \11\:qbint) resistor r=343.229 c=0
Rl49 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl46 (qbint \2\:qbint) resistor r=112.732 c=0
Rl48 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl47 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl64 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl66 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl65 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl40 (RTb \2\:RTb) resistor r=112.412 c=0
Rl41 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (n35 \2\:n35) resistor r=508.667 c=0
Rl60 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz18 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz28 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz29 (\34\:VSS \35\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry20 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry31 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry32 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry33 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry34 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry35 (\23\:VSS \24\:VSS) resistor r=15.5 c=0
Ry36 (\23\:VSS \26\:VSS) resistor r=8.8571 c=0
Ry37 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry38 (\23\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry24 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry25 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry26 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry28 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry29 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\15\:mout \16\:mout) resistor r=62 c=0
Ry4 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry19 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry21 (n11 \2\:n11) resistor r=62 c=0
Ry22 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx11 (\3\:D D) resistor r=45 c=0
Rx7 (\3\:CK \5\:CK) resistor r=45 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx31 (\3\:SN \12\:SN) resistor r=45 c=0
Rx32 (\9\:SN \13\:SN) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\6\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \17\:CKb) resistor r=45 c=0
Rx20 (CKb \20\:CKb) resistor r=45 c=0
Rx21 (\13\:CKb \21\:CKb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx35 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx36 (qbint \19\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \7\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \11\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\14\:CKb \1\:CK \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0119 \6\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \7\:n20 net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \12\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net0118 \11\:qbint net0116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0116 \8\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \9\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.05e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\18\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=3.45e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp32 (\15\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=5.45048 \
        scb=0.00126552 scc=2.52508e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp52 (n11 \10\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\4\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0167 \
        scb=0.00981108 scc=0.000312648 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
ends SRDFFSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:05:36 2012 )
// Library name: gsclib045
// Cell name: SRDFFSRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSRQX1 CK D ExtVDD Q RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (ExtVDD VSS) capacitor c=2.41014e-16
C2 (D VSS) capacitor c=4.29321e-17
C3 (VDD VSS) capacitor c=7.82202e-16
C4 (SE VSS) capacitor c=9.36226e-17
C5 (Q VSS) capacitor c=3.75183e-17
C6 (CK VSS) capacitor c=6.00247e-17
C7 (SN VSS) capacitor c=3.63977e-17
C8 (SI VSS) capacitor c=8.72108e-17
C9 (RN VSS) capacitor c=8.90831e-17
C10 (RT VSS) capacitor c=6.2503e-17
C11 (n20 VSS) capacitor c=3.92699e-17
C12 (CKbb VSS) capacitor c=2.9956e-17
C13 (mout VSS) capacitor c=5.42535e-17
C14 (RNb VSS) capacitor c=3.91539e-17
C15 (CKb VSS) capacitor c=5.53018e-17
C16 (SEb VSS) capacitor c=7.75745e-17
C17 (n35g VSS) capacitor c=1.7772e-17
C18 (qbint VSS) capacitor c=4.57429e-17
C19 (RTb VSS) capacitor c=5.17974e-17
C20 (n35 VSS) capacitor c=1.71934e-16
C21 (Db VSS) capacitor c=1.05441e-16
C22 (n11 VSS) capacitor c=8.44886e-17
C23 (n8 VSS) capacitor c=7.938e-17
C24 (n10 VSS) capacitor c=8.44144e-17
C25 (n4 VSS) capacitor c=8.7069e-17
C26 (n1 VSS) capacitor c=1.02126e-18
C27 (\7\:SN VSS) capacitor c=7.05736e-17
C28 (\7\:qbint VSS) capacitor c=3.83819e-17
C29 (\10\:qbint VSS) capacitor c=1.41633e-16
C30 (\4\:RNb VSS) capacitor c=4.00602e-16
C31 (\11\:CKbb VSS) capacitor c=5.76934e-17
C32 (\4\:RTb VSS) capacitor c=9.76746e-17
C33 (\6\:RT VSS) capacitor c=2.20615e-17
C34 (\4\:qbint VSS) capacitor c=5.35397e-17
C35 (\3\:n35g VSS) capacitor c=5.2053e-17
C36 (\5\:RT VSS) capacitor c=8.2554e-17
C37 (\3\:SE VSS) capacitor c=7.72314e-17
C38 (\7\:CKb VSS) capacitor c=3.84202e-17
C39 (\3\:SI VSS) capacitor c=9.59651e-17
C40 (\9\:RNb VSS) capacitor c=6.01657e-17
C41 (\4\:SE VSS) capacitor c=1.22448e-16
C42 (\3\:n20 VSS) capacitor c=4.73671e-17
C43 (\4\:D VSS) capacitor c=7.00534e-17
C44 (\1\:SN VSS) capacitor c=3.03399e-17
C45 (\4\:CK VSS) capacitor c=6.08222e-17
C46 (\4\:CKb VSS) capacitor c=4.72846e-17
C47 (\8\:CKb VSS) capacitor c=8.3205e-17
C48 (\3\:CKbb VSS) capacitor c=2.56782e-17
C49 (\1\:RN VSS) capacitor c=4.24515e-17
C50 (\8\:SN VSS) capacitor c=1.32242e-16
C51 (\6\:qbint VSS) capacitor c=4.25639e-17
C52 (\11\:qbint VSS) capacitor c=8.06262e-17
C53 (\3\:RNb VSS) capacitor c=6.80787e-17
C54 (\11\:CKb VSS) capacitor c=2.22469e-16
C55 (\8\:RT VSS) capacitor c=1.20208e-16
C56 (\2\:RT VSS) capacitor c=6.21971e-17
C57 (\5\:qbint VSS) capacitor c=3.87528e-17
C58 (\5\:n35g VSS) capacitor c=3.28693e-17
C59 (\2\:RTb VSS) capacitor c=4.66333e-17
C60 (\5\:SE VSS) capacitor c=5.7365e-17
C61 (\5\:CKbb VSS) capacitor c=3.24964e-17
C62 (\1\:SI VSS) capacitor c=4.90982e-17
C63 (\6\:SE VSS) capacitor c=8.63749e-17
C64 (\3\:SEb VSS) capacitor c=6.60023e-17
C65 (\1\:D VSS) capacitor c=4.94877e-17
C66 (\6\:n20 VSS) capacitor c=6.12355e-17
C67 (\6\:SN VSS) capacitor c=4.59773e-17
C68 (\1\:CK VSS) capacitor c=2.87585e-17
C69 (\3\:mout VSS) capacitor c=4.57969e-17
C70 (\9\:CKb VSS) capacitor c=3.92875e-17
C71 (\10\:CKbb VSS) capacitor c=4.92133e-17
C72 (\6\:CKb VSS) capacitor c=4.97881e-17
C73 (\4\:RN VSS) capacitor c=3.69343e-17
C74 (\9\:qbint VSS) capacitor c=9.41633e-17
C75 (\12\:CKbb VSS) capacitor c=7.94667e-17
C76 (\3\:SN VSS) capacitor c=3.75362e-16
C77 (\9\:SN VSS) capacitor c=9.14336e-17
C78 (\7\:RT VSS) capacitor c=1.55207e-16
C79 (\9\:CKbb VSS) capacitor c=1.67449e-16
C80 (\3\:RT VSS) capacitor c=5.78494e-17
C81 (\1\:RT VSS) capacitor c=5.2908e-17
C82 (\3\:RTb VSS) capacitor c=7.57746e-17
C83 (\3\:qbint VSS) capacitor c=4.37709e-17
C84 (\2\:n35 VSS) capacitor c=2.52896e-16
C85 (\4\:n35g VSS) capacitor c=6.71687e-17
C86 (\12\:CKb VSS) capacitor c=2.1752e-16
C87 (\3\:n35 VSS) capacitor c=1.16125e-16
C88 (\1\:SE VSS) capacitor c=2.47732e-17
C89 (\2\:SI VSS) capacitor c=7.74104e-17
C90 (\2\:RNb VSS) capacitor c=3.31472e-17
C91 (\8\:RNb VSS) capacitor c=1.24868e-17
C92 (\2\:SEb VSS) capacitor c=7.84485e-17
C93 (\7\:n20 VSS) capacitor c=5.31155e-17
C94 (\4\:n20 VSS) capacitor c=1.14939e-16
C95 (\3\:D VSS) capacitor c=1.47127e-17
C96 (\2\:SN VSS) capacitor c=4.19842e-17
C97 (\5\:SN VSS) capacitor c=2.63859e-17
C98 (\3\:CK VSS) capacitor c=2.59385e-17
C99 (\2\:mout VSS) capacitor c=4.64695e-17
C100 (\4\:mout VSS) capacitor c=3.16539e-17
C101 (\10\:CKb VSS) capacitor c=2.16773e-17
C102 (\5\:n20 VSS) capacitor c=1.14457e-16
C103 (\4\:CKbb VSS) capacitor c=7.14888e-17
C104 (\8\:CKbb VSS) capacitor c=2.69454e-17
C105 (\7\:RNb VSS) capacitor c=1.31525e-16
C106 (\2\:n20 VSS) capacitor c=4.55398e-17
C107 (\3\:RN VSS) capacitor c=4.64202e-17
C108 (\1\:VDD VSS) capacitor c=2.99681e-17
C109 (\11\:VDD VSS) capacitor c=4.72134e-17
C110 (\3\:Q VSS) capacitor c=5.29163e-17
C111 (\13\:VDD VSS) capacitor c=4.90394e-17
C112 (\3\:n11 VSS) capacitor c=9.83748e-17
C113 (\14\:n35 VSS) capacitor c=5.35185e-17
C114 (\15\:n35g VSS) capacitor c=5.68608e-17
C115 (\6\:RTb VSS) capacitor c=7.21465e-17
C116 (\1\:ExtVDD VSS) capacitor c=2.78454e-16
C117 (\9\:n35 VSS) capacitor c=6.17256e-17
C118 (\14\:qbint VSS) capacitor c=6.81232e-17
C119 (\6\:n35g VSS) capacitor c=9.40263e-17
C120 (\8\:SEb VSS) capacitor c=5.05319e-17
C121 (\4\:n35 VSS) capacitor c=7.23682e-17
C122 (\15\:VDD VSS) capacitor c=6.09072e-17
C123 (\5\:mout VSS) capacitor c=1.33866e-16
C124 (\17\:VDD VSS) capacitor c=4.33457e-17
C125 (\3\:Db VSS) capacitor c=1.90445e-16
C126 (\19\:mout VSS) capacitor c=3.68829e-17
C127 (\22\:VDD VSS) capacitor c=3.51828e-17
C128 (\16\:mout VSS) capacitor c=4.35597e-17
C129 (\17\:CKb VSS) capacitor c=2.91358e-17
C130 (\20\:VDD VSS) capacitor c=4.82871e-17
C131 (\17\:CKbb VSS) capacitor c=6.64212e-17
C132 (\13\:n20 VSS) capacitor c=6.09021e-17
C133 (\5\:Db VSS) capacitor c=2.1604e-16
C134 (\10\:RNb VSS) capacitor c=5.04168e-17
C135 (\10\:n20 VSS) capacitor c=6.34584e-17
C136 (\24\:VDD VSS) capacitor c=4.7501e-17
C137 (\1\:Q VSS) capacitor c=3.65642e-17
C138 (\3\:n8 VSS) capacitor c=8.0956e-17
C139 (\3\:n10 VSS) capacitor c=8.13502e-17
C140 (\17\:n35 VSS) capacitor c=4.82161e-17
C141 (\11\:n35g VSS) capacitor c=2.62261e-17
C142 (\10\:RTb VSS) capacitor c=5.80906e-17
C143 (\12\:n35 VSS) capacitor c=6.34409e-17
C144 (\16\:qbint VSS) capacitor c=2.43025e-17
C145 (\9\:n35g VSS) capacitor c=8.00873e-17
C146 (\4\:SEb VSS) capacitor c=3.94072e-17
C147 (\7\:n35 VSS) capacitor c=4.89445e-17
C148 (\11\:mout VSS) capacitor c=3.71624e-17
C149 (\13\:mout VSS) capacitor c=3.82409e-17
C150 (\3\:n4 VSS) capacitor c=1.00173e-16
C151 (\13\:CKb VSS) capacitor c=6.60839e-17
C152 (\15\:CKbb VSS) capacitor c=9.62315e-17
C153 (\17\:n20 VSS) capacitor c=8.58437e-17
C154 (\7\:Db VSS) capacitor c=7.72667e-17
C155 (\13\:RNb VSS) capacitor c=7.34902e-17
C156 (\8\:n20 VSS) capacitor c=5.87832e-17
C157 (VDD VSS) capacitor c=6.96261e-17
C158 (\2\:CKbb VSS) capacitor c=6.21539e-17
C159 (\2\:CK VSS) capacitor c=3.37747e-17
C160 (\2\:D VSS) capacitor c=3.54972e-17
C161 (\2\:SE VSS) capacitor c=2.50121e-17
C162 (\2\:CKb VSS) capacitor c=1.511e-16
C163 (\3\:CKb VSS) capacitor c=8.58211e-17
C164 (\5\:CKb VSS) capacitor c=5.69698e-17
C165 (\2\:n35g VSS) capacitor c=2.91068e-17
C166 (\4\:RT VSS) capacitor c=7.42812e-17
C167 (\2\:qbint VSS) capacitor c=4.11428e-17
C168 (\6\:CKbb VSS) capacitor c=1.37045e-16
C169 (\7\:CKbb VSS) capacitor c=7.33353e-17
C170 (\4\:SN VSS) capacitor c=3.61113e-16
C171 (\12\:n20 VSS) capacitor c=4.40558e-17
C172 (\5\:RNb VSS) capacitor c=3.89507e-16
C173 (\6\:RNb VSS) capacitor c=1.80962e-16
C174 (\12\:RNb VSS) capacitor c=1.19782e-16
C175 (\13\:CKbb VSS) capacitor c=1.55652e-16
C176 (\14\:CKbb VSS) capacitor c=1.37959e-16
C177 (\8\:qbint VSS) capacitor c=1.0665e-16
C178 (\15\:n20 VSS) capacitor c=7.55281e-17
C179 (\16\:n20 VSS) capacitor c=9.2527e-17
C180 (\19\:CKbb VSS) capacitor c=4.95421e-17
C181 (\6\:CK VSS) capacitor c=4.64788e-17
C182 (\15\:CKb VSS) capacitor c=6.20893e-17
C183 (\16\:CKb VSS) capacitor c=4.46235e-17
C184 (\10\:SN VSS) capacitor c=4.36376e-17
C185 (\11\:SN VSS) capacitor c=4.60909e-17
C186 (\7\:D VSS) capacitor c=4.7322e-17
C187 (\19\:n20 VSS) capacitor c=8.03059e-17
C188 (\20\:n20 VSS) capacitor c=8.11054e-17
C189 (\15\:RNb VSS) capacitor c=7.08611e-17
C190 (\16\:RNb VSS) capacitor c=8.31202e-17
C191 (\7\:mout VSS) capacitor c=1.56129e-16
C192 (\8\:mout VSS) capacitor c=5.29694e-17
C193 (\9\:mout VSS) capacitor c=1.00196e-16
C194 (\10\:mout VSS) capacitor c=8.87294e-17
C195 (\15\:mout VSS) capacitor c=6.05008e-17
C196 (\18\:mout VSS) capacitor c=7.26103e-17
C197 (\6\:SEb VSS) capacitor c=8.35718e-17
C198 (\7\:SEb VSS) capacitor c=6.93987e-17
C199 (\6\:n35 VSS) capacitor c=1.06844e-16
C200 (\19\:CKb VSS) capacitor c=3.86723e-17
C201 (\20\:CKb VSS) capacitor c=4.17163e-17
C202 (\8\:n35g VSS) capacitor c=3.50808e-17
C203 (\11\:n35 VSS) capacitor c=7.54758e-17
C204 (\12\:qbint VSS) capacitor c=8.77654e-17
C205 (\13\:qbint VSS) capacitor c=1.11932e-16
C206 (\13\:n35g VSS) capacitor c=9.94617e-17
C207 (\14\:n35g VSS) capacitor c=1.15912e-16
C208 (\5\:RTb VSS) capacitor c=4.92668e-17
C209 (\8\:RTb VSS) capacitor c=1.00536e-16
C210 (\9\:RTb VSS) capacitor c=9.1424e-17
C211 (\10\:RT VSS) capacitor c=1.10449e-16
C212 (\11\:RT VSS) capacitor c=1.17918e-16
C213 (\12\:SN VSS) capacitor c=8.25765e-17
C214 (\13\:SN VSS) capacitor c=8.03267e-17
C215 (\20\:CKbb VSS) capacitor c=1.3168e-16
C216 (\21\:CKbb VSS) capacitor c=1.33733e-16
C217 (\18\:qbint VSS) capacitor c=1.9502e-17
C218 (\19\:qbint VSS) capacitor c=3.00427e-17
C219 (\16\:n35 VSS) capacitor c=5.06065e-17
C220 (\3\:VDD VSS) capacitor c=3.242e-17
C221 (\4\:VDD VSS) capacitor c=2.63582e-17
C222 (\6\:VDD VSS) capacitor c=2.01956e-16
C223 (\7\:VDD VSS) capacitor c=2.1195e-16
C224 (\8\:VDD VSS) capacitor c=2.90348e-17
C225 (\10\:VDD VSS) capacitor c=5.22206e-17
C226 (\19\:VDD VSS) capacitor c=5.45052e-17
Rk52 (ExtVDD ExtVDD) resistor r=0.002069 c=0
Rk50 (\2\:ExtVDD ExtVDD) resistor r=0.02222 c=0
Rk53 (ExtVDD \5\:ExtVDD) resistor r=0.02021 c=0
Rk54 (ExtVDD \6\:ExtVDD) resistor r=0.1501 c=0
Rk19 (\5\:D D) resistor r=0.007226 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01721 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007226 c=0
Rk104 (VDD VDD) resistor r=0.2371 c=0
Rk90 (\2\:VDD \3\:VDD) resistor r=0.3387 c=0
Rk91 (\3\:VDD \4\:VDD) resistor r=0.2187 c=0
Rk92 (\4\:VDD \6\:VDD) resistor r=0.06703 c=0
Rk93 (\6\:VDD \7\:VDD) resistor r=1.5809 c=0
Rk94 (\7\:VDD \8\:VDD) resistor r=0.1191 c=0
Rk95 (\8\:VDD \10\:VDD) resistor r=0.222 c=0
Rk96 (\3\:VDD \12\:VDD) resistor r=0.3589 c=0
Rk97 (\4\:VDD \14\:VDD) resistor r=0.2948 c=0
Rk98 (\7\:VDD \16\:VDD) resistor r=0.3688 c=0
Rk99 (\8\:VDD \18\:VDD) resistor r=0.203 c=0
Rk103 (\19\:VDD VDD) resistor r=0.1963 c=0
Rk100 (\10\:VDD \19\:VDD) resistor r=0.1716 c=0
Rk101 (\19\:VDD \21\:VDD) resistor r=0.2084 c=0
Rk102 (\10\:VDD \23\:VDD) resistor r=0.2388 c=0
Rk105 (VDD \25\:VDD) resistor r=0.3802 c=0
Rk74 (\2\:Q Q) resistor r=0.1691 c=0
Rk75 (Q \4\:Q) resistor r=0.2939 c=0
Rk13 (CK \6\:CK) resistor r=0.01224 c=0
Rk12 (\5\:CK \6\:CK) resistor r=0.003439 c=0
Rk78 (\2\:VSS \3\:VSS) resistor r=0.03217 c=0
Rk79 (\3\:VSS \4\:VSS) resistor r=0.5152 c=0
Rk80 (\4\:VSS \5\:VSS) resistor r=0.5181 c=0
Rk82 (\6\:VSS VSS) resistor r=0.04955 c=0
Rk81 (\5\:VSS \6\:VSS) resistor r=0.3285 c=0
Rk84 (\7\:VSS VSS) resistor r=0.1218 c=0
Rk83 (VSS \7\:VSS) resistor r=0.8966 c=0
Rk85 (VSS \8\:VSS) resistor r=0.01748 c=0
Rk86 (\8\:VSS \10\:VSS) resistor r=0.6662 c=0
Rk87 (\3\:VSS \12\:VSS) resistor r=0.2503 c=0
Rk88 (\5\:VSS \14\:VSS) resistor r=0.2452 c=0
Rk89 (\8\:VSS \16\:VSS) resistor r=0.2528 c=0
Rk106 (\18\:VSS \20\:VSS) resistor r=0.4133 c=0
Rk107 (\20\:VSS \21\:VSS) resistor r=0.8638 c=0
Rk108 (\21\:VSS \22\:VSS) resistor r=0.03217 c=0
Rk110 (\23\:VSS VSS) resistor r=0.1216 c=0
Rk109 (\22\:VSS \23\:VSS) resistor r=0.1766 c=0
Rk111 (VSS \24\:VSS) resistor r=0.5229 c=0
Rk112 (\24\:VSS \25\:VSS) resistor r=0.3084 c=0
Rk114 (\26\:VSS VSS) resistor r=0.1218 c=0
Rk113 (\25\:VSS \26\:VSS) resistor r=0.06454 c=0
Rk115 (VSS \28\:VSS) resistor r=0.3138 c=0
Rk116 (\21\:VSS \30\:VSS) resistor r=0.1905 c=0
Rk117 (\23\:VSS \32\:VSS) resistor r=0.1956 c=0
Rk118 (\24\:VSS \34\:VSS) resistor r=0.255 c=0
Rk119 (\25\:VSS \36\:VSS) resistor r=0.2506 c=0
Rk17 (SN \10\:SN) resistor r=0.008773 c=0
Rk18 (SN \11\:SN) resistor r=0.2654 c=0
Rk68 (\12\:SN \13\:SN) resistor r=0.5395 c=0
Rk1 (\5\:RN RN) resistor r=0.006372 c=0
Rk66 (RT \10\:RT) resistor r=0.1997 c=0
Rk67 (\10\:RT \11\:RT) resistor r=0.6506 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5468 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2558 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3478 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.231 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4998 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4645 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8547 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.544 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.1872 c=0
Rk69 (\20\:CKbb \21\:CKbb) resistor r=0.8302 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.7671 c=0
Rk31 (\7\:mout \8\:mout) resistor r=0.3549 c=0
Rk32 (\8\:mout \9\:mout) resistor r=0.1721 c=0
Rk33 (\9\:mout \10\:mout) resistor r=0.3451 c=0
Rk34 (\7\:mout \12\:mout) resistor r=0.1239 c=0
Rk35 (\8\:mout \14\:mout) resistor r=0.1004 c=0
Rk36 (\9\:mout \15\:mout) resistor r=0.5279 c=0
Rk37 (\15\:mout \17\:mout) resistor r=0.04496 c=0
Rk38 (\10\:mout \18\:mout) resistor r=0.4279 c=0
Rk39 (\15\:mout \20\:mout) resistor r=0.03474 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1645 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3831 c=0
Rk27 (\15\:RNb \16\:RNb) resistor r=0.3488 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3522 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.159 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.1648 c=0
Rk45 (\19\:CKb \20\:CKb) resistor r=0.374 c=0
Rk40 (\5\:SEb \6\:SEb) resistor r=0.2176 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.357 c=0
Rk42 (\6\:SEb \9\:SEb) resistor r=0.3118 c=0
Rk46 (\7\:n35g \8\:n35g) resistor r=0.2752 c=0
Rk47 (\7\:n35g \10\:n35g) resistor r=0.6962 c=0
Rk58 (\12\:n35g \13\:n35g) resistor r=0.2446 c=0
Rk59 (\13\:n35g \14\:n35g) resistor r=0.5695 c=0
Rk60 (\13\:n35g \16\:n35g) resistor r=0.4349 c=0
Rk55 (\12\:qbint \13\:qbint) resistor r=0.498 c=0
Rk56 (\13\:qbint \15\:qbint) resistor r=0.571 c=0
Rk57 (\13\:qbint \17\:qbint) resistor r=0.1473 c=0
Rk70 (\18\:qbint \19\:qbint) resistor r=0.2132 c=0
Rk61 (\5\:RTb \7\:RTb) resistor r=0.2177 c=0
Rk62 (\7\:RTb \8\:RTb) resistor r=0.4194 c=0
Rk63 (\8\:RTb \9\:RTb) resistor r=0.6934 c=0
Rk64 (\8\:RTb \11\:RTb) resistor r=0.3087 c=0
Rk43 (\5\:n35 \6\:n35) resistor r=0.4319 c=0
Rk44 (\6\:n35 \8\:n35) resistor r=0.3048 c=0
Rk48 (\10\:n35 \11\:n35) resistor r=0.4037 c=0
Rk49 (\11\:n35 \13\:n35) resistor r=0.3322 c=0
Rk71 (\15\:n35 \16\:n35) resistor r=0.3058 c=0
Rk72 (\16\:n35 \18\:n35) resistor r=0.2894 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6407 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.395 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5689 c=0
Rk76 (\2\:n11 \4\:n11) resistor r=0.7185 c=0
Rk77 (\2\:n8 \4\:n8) resistor r=0.5338 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.6299 c=0
Rk26 (\2\:n4 \4\:n4) resistor r=0.556 c=0
Rl16 (\2\:D \4\:D) resistor r=115.099 c=0
Rl14 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl15 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl77 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl78 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl13 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl61 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl59 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl60 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl58 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl45 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl48 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl47 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl46 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl19 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl17 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl5 (CKbb \2\:CKbb) resistor r=43.0773 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl56 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl57 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl55 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl66 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl67 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl70 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl71 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl69 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl68 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl65 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl30 (CKb \2\:CKb) resistor r=349.798 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=104.389 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=58.0449 c=0
Rl37 (\5\:CKb \9\:CKb) resistor r=133.091 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=267.802 c=0
Rl38 (\5\:CKb \10\:CKb) resistor r=4.6486 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl41 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl39 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl40 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl42 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl72 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl76 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl52 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl49 (qbint \2\:qbint) resistor r=112.732 c=0
Rl51 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl50 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl73 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl75 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl74 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl43 (RTb \2\:RTb) resistor r=112.412 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl62 (n35 \2\:n35) resistor r=508.667 c=0
Rl63 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz26 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz27 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz28 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz29 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz32 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz33 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz34 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz35 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz36 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz37 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz20 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz24 (n8 \2\:n8) resistor r=75 c=0
Rz25 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry30 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry31 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry32 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry35 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry36 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry22 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry26 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry27 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry28 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=10.3333 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry39 (\19\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx19 (\1\:SE SE) resistor r=45 c=0
Rx9 (\3\:CK \5\:CK) resistor r=45 c=0
Rx11 (\5\:SN \10\:SN) resistor r=45 c=0
Rx12 (\2\:SN \11\:SN) resistor r=45 c=0
Rx35 (\3\:SN \12\:SN) resistor r=45 c=0
Rx36 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx32 (\7\:RT RT) resistor r=45 c=0
Rx33 (\3\:RT \10\:RT) resistor r=45 c=0
Rx34 (\1\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx37 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx38 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx20 (\4\:mout \10\:mout) resistor r=45 c=0
Rx21 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx10 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx24 (CKb \19\:CKb) resistor r=45 c=0
Rx25 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx26 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx29 (n35g \14\:n35g) resistor r=45 c=0
Rx28 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx39 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx40 (qbint \19\:qbint) resistor r=45 c=0
Rx30 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (RTb \9\:RTb) resistor r=45 c=0
Rx23 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx27 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx41 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \11\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n9 \4\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:06:27 2012 )
// Library name: gsclib045
// Cell name: SRDFFSRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSRX1 CK D ExtVDD Q QN RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (Q VSS) capacitor c=5.1606e-17
C2 (D VSS) capacitor c=4.28787e-17
C3 (QN VSS) capacitor c=2.21785e-17
C4 (VDD VSS) capacitor c=7.9263e-16
C5 (SE VSS) capacitor c=9.34843e-17
C6 (ExtVDD VSS) capacitor c=2.42324e-16
C7 (CK VSS) capacitor c=4.5608e-17
C8 (SN VSS) capacitor c=4.12743e-17
C9 (SI VSS) capacitor c=8.70533e-17
C10 (RN VSS) capacitor c=6.78794e-17
C11 (RT VSS) capacitor c=4.08272e-17
C12 (n20 VSS) capacitor c=3.86301e-17
C13 (CKbb VSS) capacitor c=3.31954e-17
C14 (mout VSS) capacitor c=5.42548e-17
C15 (RNb VSS) capacitor c=3.91539e-17
C16 (CKb VSS) capacitor c=5.53018e-17
C17 (SEb VSS) capacitor c=7.75904e-17
C18 (n35g VSS) capacitor c=1.77753e-17
C19 (qbint VSS) capacitor c=4.54322e-17
C20 (RTb VSS) capacitor c=5.17974e-17
C21 (net573 VSS) capacitor c=2.25772e-17
C22 (n35 VSS) capacitor c=1.71705e-16
C23 (Db VSS) capacitor c=1.05264e-16
C24 (n11 VSS) capacitor c=8.44491e-17
C25 (n8 VSS) capacitor c=7.92568e-17
C26 (n10 VSS) capacitor c=8.42863e-17
C27 (n4 VSS) capacitor c=8.69277e-17
C28 (n1 VSS) capacitor c=1.02126e-18
C29 (\7\:SN VSS) capacitor c=7.05736e-17
C30 (\7\:qbint VSS) capacitor c=3.31318e-17
C31 (\11\:qbint VSS) capacitor c=1.41624e-16
C32 (\4\:RNb VSS) capacitor c=4.06878e-16
C33 (\13\:qbint VSS) capacitor c=4.39115e-17
C34 (\3\:net573 VSS) capacitor c=5.86653e-17
C35 (\11\:CKbb VSS) capacitor c=5.94746e-17
C36 (\4\:RTb VSS) capacitor c=9.88373e-17
C37 (\6\:RT VSS) capacitor c=2.19082e-17
C38 (\4\:qbint VSS) capacitor c=5.36612e-17
C39 (\3\:n35g VSS) capacitor c=5.2053e-17
C40 (\5\:RT VSS) capacitor c=8.2554e-17
C41 (\3\:SE VSS) capacitor c=7.72314e-17
C42 (\7\:CKb VSS) capacitor c=3.84202e-17
C43 (\3\:SI VSS) capacitor c=9.59651e-17
C44 (\9\:RNb VSS) capacitor c=6.01657e-17
C45 (\4\:SE VSS) capacitor c=1.22612e-16
C46 (\3\:n20 VSS) capacitor c=4.73671e-17
C47 (\4\:D VSS) capacitor c=7.012e-17
C48 (\1\:SN VSS) capacitor c=3.03656e-17
C49 (\4\:CK VSS) capacitor c=5.83505e-17
C50 (\4\:CKb VSS) capacitor c=4.94815e-17
C51 (\8\:CKb VSS) capacitor c=8.3205e-17
C52 (\3\:CKbb VSS) capacitor c=2.59536e-17
C53 (\1\:RN VSS) capacitor c=4.24621e-17
C54 (\8\:SN VSS) capacitor c=1.32242e-16
C55 (\6\:qbint VSS) capacitor c=3.77911e-17
C56 (\12\:qbint VSS) capacitor c=8.06262e-17
C57 (\3\:RNb VSS) capacitor c=6.80787e-17
C58 (\14\:qbint VSS) capacitor c=4.60843e-17
C59 (\4\:net573 VSS) capacitor c=3.68535e-17
C60 (\11\:CKb VSS) capacitor c=2.22561e-16
C61 (\8\:RT VSS) capacitor c=1.21595e-16
C62 (\2\:RT VSS) capacitor c=6.21972e-17
C63 (\5\:qbint VSS) capacitor c=3.89021e-17
C64 (\5\:n35g VSS) capacitor c=3.28693e-17
C65 (\2\:RTb VSS) capacitor c=4.66333e-17
C66 (\5\:SE VSS) capacitor c=5.7365e-17
C67 (\5\:CKbb VSS) capacitor c=3.24964e-17
C68 (\1\:SI VSS) capacitor c=4.90982e-17
C69 (\6\:SE VSS) capacitor c=8.63749e-17
C70 (\3\:SEb VSS) capacitor c=6.60023e-17
C71 (\1\:D VSS) capacitor c=4.94494e-17
C72 (\6\:n20 VSS) capacitor c=6.12355e-17
C73 (\6\:SN VSS) capacitor c=4.59773e-17
C74 (\1\:CK VSS) capacitor c=2.87544e-17
C75 (\3\:mout VSS) capacitor c=4.57969e-17
C76 (\9\:CKb VSS) capacitor c=3.74186e-17
C77 (\10\:CKbb VSS) capacitor c=4.92133e-17
C78 (\6\:CKb VSS) capacitor c=4.97881e-17
C79 (\4\:RN VSS) capacitor c=3.69395e-17
C80 (\10\:qbint VSS) capacitor c=8.46484e-17
C81 (\12\:CKbb VSS) capacitor c=8.24974e-17
C82 (\3\:SN VSS) capacitor c=3.75168e-16
C83 (\9\:SN VSS) capacitor c=9.15257e-17
C84 (\7\:RT VSS) capacitor c=1.51246e-16
C85 (\9\:CKbb VSS) capacitor c=1.67463e-16
C86 (\3\:RT VSS) capacitor c=5.77115e-17
C87 (\1\:RT VSS) capacitor c=5.2908e-17
C88 (\3\:RTb VSS) capacitor c=7.61041e-17
C89 (\3\:qbint VSS) capacitor c=4.43778e-17
C90 (\2\:n35 VSS) capacitor c=2.52896e-16
C91 (\4\:n35g VSS) capacitor c=6.71687e-17
C92 (\12\:CKb VSS) capacitor c=2.1752e-16
C93 (\3\:n35 VSS) capacitor c=1.16129e-16
C94 (\1\:SE VSS) capacitor c=2.47732e-17
C95 (\2\:SI VSS) capacitor c=7.74104e-17
C96 (\2\:RNb VSS) capacitor c=3.31472e-17
C97 (\8\:RNb VSS) capacitor c=1.24868e-17
C98 (\2\:SEb VSS) capacitor c=7.84493e-17
C99 (\7\:n20 VSS) capacitor c=5.31281e-17
C100 (\4\:n20 VSS) capacitor c=1.14993e-16
C101 (\3\:D VSS) capacitor c=1.47669e-17
C102 (\2\:SN VSS) capacitor c=4.20268e-17
C103 (\5\:SN VSS) capacitor c=2.77004e-17
C104 (\3\:CK VSS) capacitor c=2.33906e-17
C105 (\2\:mout VSS) capacitor c=4.64603e-17
C106 (\4\:mout VSS) capacitor c=3.16539e-17
C107 (\10\:CKb VSS) capacitor c=7.51537e-17
C108 (\5\:n20 VSS) capacitor c=1.14861e-16
C109 (\4\:CKbb VSS) capacitor c=7.14894e-17
C110 (\8\:CKbb VSS) capacitor c=2.69454e-17
C111 (\7\:RNb VSS) capacitor c=1.31852e-16
C112 (\2\:n20 VSS) capacitor c=4.55367e-17
C113 (\3\:RN VSS) capacitor c=4.53768e-17
C114 (\1\:VDD VSS) capacitor c=2.99202e-17
C115 (\12\:VDD VSS) capacitor c=4.47866e-17
C116 (\3\:Q VSS) capacitor c=8.26827e-17
C117 (\14\:VDD VSS) capacitor c=4.92886e-17
C118 (\9\:net573 VSS) capacitor c=5.55923e-17
C119 (\16\:VDD VSS) capacitor c=7.94605e-17
C120 (\3\:n11 VSS) capacitor c=9.90547e-17
C121 (\4\:QN VSS) capacitor c=6.79898e-17
C122 (\14\:n35 VSS) capacitor c=5.58386e-17
C123 (\15\:n35g VSS) capacitor c=5.57509e-17
C124 (\6\:RTb VSS) capacitor c=7.20782e-17
C125 (\1\:ExtVDD VSS) capacitor c=2.77989e-16
C126 (\9\:n35 VSS) capacitor c=6.16225e-17
C127 (\17\:qbint VSS) capacitor c=6.80388e-17
C128 (\6\:n35g VSS) capacitor c=9.38837e-17
C129 (\8\:SEb VSS) capacitor c=5.04498e-17
C130 (\4\:n35 VSS) capacitor c=7.2232e-17
C131 (\18\:VDD VSS) capacitor c=6.08131e-17
C132 (\5\:mout VSS) capacitor c=1.33608e-16
C133 (\20\:VDD VSS) capacitor c=4.3269e-17
C134 (\3\:Db VSS) capacitor c=1.94165e-16
C135 (\19\:mout VSS) capacitor c=3.68281e-17
C136 (\25\:VDD VSS) capacitor c=3.44737e-17
C137 (\16\:mout VSS) capacitor c=4.36959e-17
C138 (\17\:CKb VSS) capacitor c=2.98973e-17
C139 (\23\:VDD VSS) capacitor c=4.82067e-17
C140 (\17\:CKbb VSS) capacitor c=6.70114e-17
C141 (\13\:n20 VSS) capacitor c=6.10909e-17
C142 (\5\:Db VSS) capacitor c=2.21397e-16
C143 (\10\:RNb VSS) capacitor c=5.0321e-17
C144 (\10\:n20 VSS) capacitor c=6.33513e-17
C145 (\27\:VDD VSS) capacitor c=3.89039e-17
C146 (\1\:Q VSS) capacitor c=5.41875e-17
C147 (\5\:net573 VSS) capacitor c=4.29547e-17
C148 (\3\:n8 VSS) capacitor c=8.08245e-17
C149 (\3\:n10 VSS) capacitor c=8.12131e-17
C150 (\1\:QN VSS) capacitor c=3.68722e-17
C151 (\17\:n35 VSS) capacitor c=4.81229e-17
C152 (\11\:n35g VSS) capacitor c=2.95879e-17
C153 (\10\:RTb VSS) capacitor c=5.7983e-17
C154 (\12\:n35 VSS) capacitor c=6.33278e-17
C155 (\19\:qbint VSS) capacitor c=2.42602e-17
C156 (\9\:n35g VSS) capacitor c=7.99627e-17
C157 (\4\:SEb VSS) capacitor c=3.93429e-17
C158 (\7\:n35 VSS) capacitor c=4.88653e-17
C159 (\11\:mout VSS) capacitor c=3.70935e-17
C160 (\13\:mout VSS) capacitor c=3.8164e-17
C161 (\3\:n4 VSS) capacitor c=1.00022e-16
C162 (\13\:CKb VSS) capacitor c=6.24114e-17
C163 (\15\:CKbb VSS) capacitor c=8.91749e-17
C164 (\17\:n20 VSS) capacitor c=8.56888e-17
C165 (\7\:Db VSS) capacitor c=7.7131e-17
C166 (\13\:RNb VSS) capacitor c=7.3362e-17
C167 (\8\:n20 VSS) capacitor c=5.86991e-17
C168 (VDD VSS) capacitor c=6.94204e-17
C169 (\2\:CKbb VSS) capacitor c=6.16866e-17
C170 (\2\:CK VSS) capacitor c=3.38152e-17
C171 (\2\:D VSS) capacitor c=3.55168e-17
C172 (\2\:SE VSS) capacitor c=2.5012e-17
C173 (\2\:CKb VSS) capacitor c=1.511e-16
C174 (\3\:CKb VSS) capacitor c=8.78376e-17
C175 (\2\:n35g VSS) capacitor c=2.91123e-17
C176 (\4\:RT VSS) capacitor c=7.42727e-17
C177 (\2\:qbint VSS) capacitor c=4.13305e-17
C178 (\6\:CKbb VSS) capacitor c=1.37045e-16
C179 (\7\:CKbb VSS) capacitor c=7.33584e-17
C180 (\4\:SN VSS) capacitor c=3.6098e-16
C181 (\2\:net573 VSS) capacitor c=1.5308e-17
C182 (\12\:n20 VSS) capacitor c=4.40581e-17
C183 (\5\:RNb VSS) capacitor c=3.89503e-16
C184 (\6\:RNb VSS) capacitor c=1.81254e-16
C185 (\12\:RNb VSS) capacitor c=1.12461e-16
C186 (\13\:CKbb VSS) capacitor c=1.5538e-16
C187 (\14\:CKbb VSS) capacitor c=1.3771e-16
C188 (\8\:qbint VSS) capacitor c=5.09063e-17
C189 (\9\:qbint VSS) capacitor c=7.54296e-17
C190 (\15\:n20 VSS) capacitor c=7.51695e-17
C191 (\16\:n20 VSS) capacitor c=9.23447e-17
C192 (\19\:CKbb VSS) capacitor c=4.27767e-17
C193 (\6\:CK VSS) capacitor c=4.1089e-17
C194 (\15\:CKb VSS) capacitor c=6.18223e-17
C195 (\16\:CKb VSS) capacitor c=4.2145e-17
C196 (\10\:SN VSS) capacitor c=4.01325e-17
C197 (\11\:SN VSS) capacitor c=4.61727e-17
C198 (\7\:D VSS) capacitor c=4.72535e-17
C199 (\19\:n20 VSS) capacitor c=8.0144e-17
C200 (\20\:n20 VSS) capacitor c=8.09807e-17
C201 (\15\:RNb VSS) capacitor c=7.07284e-17
C202 (\16\:RNb VSS) capacitor c=8.29616e-17
C203 (\7\:mout VSS) capacitor c=1.55818e-16
C204 (\8\:mout VSS) capacitor c=5.28652e-17
C205 (\9\:mout VSS) capacitor c=1.04266e-16
C206 (\10\:mout VSS) capacitor c=8.64662e-17
C207 (\15\:mout VSS) capacitor c=6.04063e-17
C208 (\18\:mout VSS) capacitor c=7.19626e-17
C209 (\6\:SEb VSS) capacitor c=8.34493e-17
C210 (\7\:SEb VSS) capacitor c=6.92775e-17
C211 (\6\:n35 VSS) capacitor c=1.06598e-16
C212 (\19\:CKb VSS) capacitor c=3.86002e-17
C213 (\20\:CKb VSS) capacitor c=4.1645e-17
C214 (\8\:n35g VSS) capacitor c=3.50411e-17
C215 (\11\:n35 VSS) capacitor c=7.53442e-17
C216 (\15\:qbint VSS) capacitor c=8.75403e-17
C217 (\16\:qbint VSS) capacitor c=1.11665e-16
C218 (\13\:n35g VSS) capacitor c=1.02467e-16
C219 (\14\:n35g VSS) capacitor c=1.15714e-16
C220 (\5\:RTb VSS) capacitor c=4.93559e-17
C221 (\8\:RTb VSS) capacitor c=1.00362e-16
C222 (\9\:RTb VSS) capacitor c=9.12712e-17
C223 (\12\:SN VSS) capacitor c=8.24211e-17
C224 (\13\:SN VSS) capacitor c=8.01901e-17
C225 (\20\:CKbb VSS) capacitor c=1.33803e-16
C226 (\21\:CKbb VSS) capacitor c=1.33492e-16
C227 (\21\:qbint VSS) capacitor c=2.40592e-17
C228 (\22\:qbint VSS) capacitor c=2.9991e-17
C229 (\9\:RT VSS) capacitor c=1.10679e-16
C230 (\10\:RT VSS) capacitor c=1.17695e-16
C231 (\11\:RT VSS) capacitor c=5.56594e-17
C232 (\3\:QN VSS) capacitor c=3.33685e-17
C233 (\16\:n35 VSS) capacitor c=5.05282e-17
C234 (\7\:net573 VSS) capacitor c=5.04197e-17
C235 (\8\:net573 VSS) capacitor c=3.48307e-17
C236 (\3\:VDD VSS) capacitor c=3.01355e-17
C237 (\4\:VDD VSS) capacitor c=3.07325e-17
C238 (\6\:VDD VSS) capacitor c=9.78486e-18
C239 (\7\:VDD VSS) capacitor c=2.27379e-16
C240 (\8\:VDD VSS) capacitor c=2.02744e-16
C241 (\9\:VDD VSS) capacitor c=2.90114e-17
C242 (\11\:VDD VSS) capacitor c=5.32489e-17
C243 (\22\:VDD VSS) capacitor c=6.10398e-17
Rk80 (\2\:Q Q) resistor r=0.1725 c=0
Rk81 (Q \4\:Q) resistor r=0.3385 c=0
Rk19 (\5\:D D) resistor r=0.007241 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01725 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007241 c=0
Rk72 (\3\:QN QN) resistor r=0.02836 c=0
Rk71 (\2\:QN \3\:QN) resistor r=0.1971 c=0
Rk73 (\3\:QN \5\:QN) resistor r=0.3615 c=0
Rk112 (VDD VDD) resistor r=0.2377 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.34 c=0
Rk97 (\3\:VDD \4\:VDD) resistor r=0.2193 c=0
Rk98 (\4\:VDD \6\:VDD) resistor r=0.0672 c=0
Rk99 (\6\:VDD \7\:VDD) resistor r=0.05222 c=0
Rk100 (\7\:VDD \8\:VDD) resistor r=1.5323 c=0
Rk101 (\8\:VDD \9\:VDD) resistor r=0.1194 c=0
Rk102 (\9\:VDD \11\:VDD) resistor r=0.2226 c=0
Rk103 (\3\:VDD \13\:VDD) resistor r=0.3605 c=0
Rk104 (\4\:VDD \15\:VDD) resistor r=0.2961 c=0
Rk105 (\7\:VDD \17\:VDD) resistor r=0.3784 c=0
Rk106 (\8\:VDD \19\:VDD) resistor r=0.3704 c=0
Rk107 (\9\:VDD \21\:VDD) resistor r=0.2039 c=0
Rk111 (\22\:VDD VDD) resistor r=0.1968 c=0
Rk108 (\11\:VDD \22\:VDD) resistor r=0.172 c=0
Rk109 (\22\:VDD \24\:VDD) resistor r=0.2093 c=0
Rk110 (\11\:VDD \26\:VDD) resistor r=0.2416 c=0
Rk113 (VDD \28\:VDD) resistor r=0.3818 c=0
Rk52 (ExtVDD ExtVDD) resistor r=0.002073 c=0
Rk50 (\2\:ExtVDD ExtVDD) resistor r=0.02227 c=0
Rk53 (ExtVDD \5\:ExtVDD) resistor r=0.02025 c=0
Rk54 (ExtVDD \6\:ExtVDD) resistor r=0.1504 c=0
Rk13 (CK \6\:CK) resistor r=0.01226 c=0
Rk12 (\5\:CK \6\:CK) resistor r=0.004824 c=0
Rk84 (\2\:VSS \3\:VSS) resistor r=0.03225 c=0
Rk85 (\3\:VSS \4\:VSS) resistor r=0.5165 c=0
Rk86 (\4\:VSS \5\:VSS) resistor r=0.5194 c=0
Rk88 (\6\:VSS VSS) resistor r=0.04967 c=0
Rk87 (\5\:VSS \6\:VSS) resistor r=0.3293 c=0
Rk90 (\7\:VSS VSS) resistor r=0.1221 c=0
Rk89 (VSS \7\:VSS) resistor r=0.8989 c=0
Rk91 (VSS \8\:VSS) resistor r=0.01753 c=0
Rk92 (\8\:VSS \10\:VSS) resistor r=0.6682 c=0
Rk93 (\3\:VSS \12\:VSS) resistor r=0.2514 c=0
Rk94 (\5\:VSS \14\:VSS) resistor r=0.2463 c=0
Rk95 (\8\:VSS \16\:VSS) resistor r=0.2539 c=0
Rk114 (\18\:VSS \20\:VSS) resistor r=0.3648 c=0
Rk115 (\20\:VSS \21\:VSS) resistor r=0.2394 c=0
Rk116 (\21\:VSS \22\:VSS) resistor r=0.05971 c=0
Rk117 (\22\:VSS \23\:VSS) resistor r=0.6164 c=0
Rk118 (\23\:VSS \24\:VSS) resistor r=0.03225 c=0
Rk120 (\25\:VSS VSS) resistor r=0.1219 c=0
Rk119 (\24\:VSS \25\:VSS) resistor r=0.177 c=0
Rk121 (VSS \26\:VSS) resistor r=0.5242 c=0
Rk122 (\26\:VSS \27\:VSS) resistor r=0.3091 c=0
Rk124 (\28\:VSS VSS) resistor r=0.1221 c=0
Rk123 (\27\:VSS \28\:VSS) resistor r=0.0647 c=0
Rk125 (VSS \30\:VSS) resistor r=0.3149 c=0
Rk126 (\21\:VSS \32\:VSS) resistor r=0.2698 c=0
Rk127 (\23\:VSS \34\:VSS) resistor r=0.1914 c=0
Rk128 (\25\:VSS \36\:VSS) resistor r=0.1965 c=0
Rk129 (\26\:VSS \38\:VSS) resistor r=0.2562 c=0
Rk130 (\27\:VSS \40\:VSS) resistor r=0.2517 c=0
Rk17 (SN \10\:SN) resistor r=0.01165 c=0
Rk18 (\10\:SN \11\:SN) resistor r=0.3167 c=0
Rk65 (\12\:SN \13\:SN) resistor r=0.5417 c=0
Rk1 (\5\:RN RN) resistor r=0.008217 c=0
Rk68 (RT \9\:RT) resistor r=0.1927 c=0
Rk69 (\9\:RT \10\:RT) resistor r=0.6534 c=0
Rk70 (RT \11\:RT) resistor r=0.008064 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5491 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2569 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3492 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.232 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.5019 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4664 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8583 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.5434 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.1435 c=0
Rk66 (\20\:CKbb \21\:CKbb) resistor r=0.8355 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.7703 c=0
Rk31 (\7\:mout \8\:mout) resistor r=0.3564 c=0
Rk32 (\8\:mout \9\:mout) resistor r=0.1729 c=0
Rk33 (\9\:mout \10\:mout) resistor r=0.3451 c=0
Rk34 (\7\:mout \12\:mout) resistor r=0.1244 c=0
Rk35 (\8\:mout \14\:mout) resistor r=0.1009 c=0
Rk36 (\9\:mout \15\:mout) resistor r=0.5302 c=0
Rk37 (\15\:mout \17\:mout) resistor r=0.04505 c=0
Rk38 (\10\:mout \18\:mout) resistor r=0.4297 c=0
Rk39 (\15\:mout \20\:mout) resistor r=0.03481 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1652 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3847 c=0
Rk27 (\15\:RNb \16\:RNb) resistor r=0.3502 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3366 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.1634 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.1787 c=0
Rk45 (\19\:CKb \20\:CKb) resistor r=0.3756 c=0
Rk40 (\5\:SEb \6\:SEb) resistor r=0.2186 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.3586 c=0
Rk42 (\6\:SEb \9\:SEb) resistor r=0.3131 c=0
Rk46 (\7\:n35g \8\:n35g) resistor r=0.2763 c=0
Rk47 (\7\:n35g \10\:n35g) resistor r=0.6991 c=0
Rk58 (\12\:n35g \13\:n35g) resistor r=0.2457 c=0
Rk59 (\13\:n35g \14\:n35g) resistor r=0.5719 c=0
Rk60 (\13\:n35g \16\:n35g) resistor r=0.4367 c=0
Rk55 (\15\:qbint \16\:qbint) resistor r=0.5002 c=0
Rk56 (\16\:qbint \18\:qbint) resistor r=0.5734 c=0
Rk57 (\16\:qbint \20\:qbint) resistor r=0.1479 c=0
Rk67 (\21\:qbint \22\:qbint) resistor r=0.2141 c=0
Rk61 (\5\:RTb \7\:RTb) resistor r=0.2186 c=0
Rk62 (\7\:RTb \8\:RTb) resistor r=0.4212 c=0
Rk63 (\8\:RTb \9\:RTb) resistor r=0.6964 c=0
Rk64 (\8\:RTb \11\:RTb) resistor r=0.31 c=0
Rk76 (\6\:net573 \7\:net573) resistor r=0.2387 c=0
Rk77 (\7\:net573 \8\:net573) resistor r=0.1669 c=0
Rk78 (\7\:net573 \10\:net573) resistor r=0.2869 c=0
Rk43 (\5\:n35 \6\:n35) resistor r=0.4337 c=0
Rk44 (\6\:n35 \8\:n35) resistor r=0.306 c=0
Rk48 (\10\:n35 \11\:n35) resistor r=0.4054 c=0
Rk49 (\11\:n35 \13\:n35) resistor r=0.3336 c=0
Rk74 (\15\:n35 \16\:n35) resistor r=0.3071 c=0
Rk75 (\16\:n35 \18\:n35) resistor r=0.2906 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6434 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.436 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5713 c=0
Rk82 (\2\:n11 \4\:n11) resistor r=0.7216 c=0
Rk83 (\2\:n8 \4\:n8) resistor r=0.536 c=0
Rk79 (\2\:n10 \4\:n10) resistor r=0.6325 c=0
Rk26 (\2\:n4 \4\:n4) resistor r=0.5583 c=0
Rl16 (\2\:D \4\:D) resistor r=115.099 c=0
Rl14 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl15 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl83 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl84 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl13 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl61 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl59 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl60 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl58 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl45 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl48 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl47 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl46 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl19 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl17 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl5 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl56 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl57 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl55 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl69 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl70 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl73 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl74 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl72 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl71 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl65 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl30 (CKb \2\:CKb) resistor r=349.798 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=63.8165 c=0
Rl37 (\5\:CKb \9\:CKb) resistor r=126.273 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=264.86 c=0
Rl38 (\5\:CKb \10\:CKb) resistor r=4.0236 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl41 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl39 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl40 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl42 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl75 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl80 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl82 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl52 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl49 (qbint \2\:qbint) resistor r=112.732 c=0
Rl51 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl50 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl76 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl79 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl81 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl78 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl77 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl43 (RTb \2\:RTb) resistor r=112.412 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl66 (net573 \2\:net573) resistor r=3.1216 c=0
Rl67 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl68 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl62 (n35 \2\:n35) resistor r=508.667 c=0
Rl63 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz25 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz20 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz28 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz29 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz30 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz31 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz34 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz35 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz36 (\31\:VSS \32\:VSS) resistor r=37.5 c=0
Rz37 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz38 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz39 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz40 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz22 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz21 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz26 (n8 \2\:n8) resistor r=75 c=0
Rz27 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz23 (n10 \2\:n10) resistor r=75 c=0
Rz24 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry21 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry31 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry32 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry33 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry34 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry35 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry36 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry37 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry38 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry39 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry27 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry28 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry30 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry41 (\19\:VSS \22\:VSS) resistor r=62 c=0
Ry42 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry43 (\19\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry23 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry22 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry25 (n11 \2\:n11) resistor r=62 c=0
Ry26 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx19 (\1\:SE SE) resistor r=45 c=0
Rx9 (\3\:CK \5\:CK) resistor r=45 c=0
Rx11 (\5\:SN \10\:SN) resistor r=45 c=0
Rx12 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx38 (\3\:RT \9\:RT) resistor r=45 c=0
Rx39 (\1\:RT \10\:RT) resistor r=45 c=0
Rx40 (\7\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx34 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx20 (\4\:mout \10\:mout) resistor r=45 c=0
Rx21 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx10 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx24 (CKb \19\:CKb) resistor r=45 c=0
Rx25 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx26 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx29 (n35g \14\:n35g) resistor r=45 c=0
Rx28 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx30 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (RTb \9\:RTb) resistor r=45 c=0
Rx42 (net573 \8\:net573) resistor r=45 c=0
Rx23 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx27 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx41 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \4\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:07:19 2012 )
// Library name: gsclib045
// Cell name: SRDFFSX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSX1 CK D ExtVDD Q QN RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=5.88779e-17
C2 (D VSS) capacitor c=7.95582e-17
C3 (QN VSS) capacitor c=1.89066e-17
C4 (CK VSS) capacitor c=7.48802e-17
C5 (SI VSS) capacitor c=8.73684e-17
C6 (RT VSS) capacitor c=6.46039e-17
C7 (ExtVDD VSS) capacitor c=2.26793e-16
C8 (SN VSS) capacitor c=5.16294e-17
C9 (VDD VSS) capacitor c=7.47013e-16
C10 (SE VSS) capacitor c=9.25495e-17
C11 (n20 VSS) capacitor c=3.84704e-17
C12 (CKbb VSS) capacitor c=2.98958e-17
C13 (mout VSS) capacitor c=5.41849e-17
C14 (CKb VSS) capacitor c=5.04575e-17
C15 (SEb VSS) capacitor c=7.75157e-17
C16 (n35g VSS) capacitor c=1.7772e-17
C17 (qbint VSS) capacitor c=4.57835e-17
C18 (RTb VSS) capacitor c=5.17974e-17
C19 (net573 VSS) capacitor c=2.25505e-17
C20 (n35 VSS) capacitor c=1.72515e-16
C21 (Db VSS) capacitor c=1.02659e-16
C22 (n11 VSS) capacitor c=7.99274e-17
C23 (n1 VSS) capacitor c=1.02126e-18
C24 (\7\:qbint VSS) capacitor c=3.28246e-17
C25 (\7\:SN VSS) capacitor c=8.60102e-17
C26 (\11\:qbint VSS) capacitor c=1.07191e-16
C27 (\13\:qbint VSS) capacitor c=4.38863e-17
C28 (\3\:net573 VSS) capacitor c=5.86658e-17
C29 (\11\:CKbb VSS) capacitor c=4.51636e-17
C30 (\4\:RTb VSS) capacitor c=9.88373e-17
C31 (\6\:RT VSS) capacitor c=2.23208e-17
C32 (\4\:qbint VSS) capacitor c=5.36612e-17
C33 (\3\:n35g VSS) capacitor c=5.1929e-17
C34 (\5\:RT VSS) capacitor c=6.48597e-17
C35 (\3\:SE VSS) capacitor c=7.72628e-17
C36 (\7\:CKb VSS) capacitor c=3.10427e-17
C37 (\3\:SI VSS) capacitor c=9.47876e-17
C38 (\4\:SE VSS) capacitor c=1.22542e-16
C39 (\3\:n20 VSS) capacitor c=2.47551e-17
C40 (\4\:D VSS) capacitor c=7.11031e-17
C41 (\1\:SN VSS) capacitor c=3.03251e-17
C42 (\4\:CK VSS) capacitor c=5.78548e-17
C43 (\4\:CKb VSS) capacitor c=4.5846e-17
C44 (\8\:CKb VSS) capacitor c=8.3611e-17
C45 (\3\:CKbb VSS) capacitor c=2.57688e-17
C46 (\6\:qbint VSS) capacitor c=3.83344e-17
C47 (\14\:qbint VSS) capacitor c=4.62185e-17
C48 (\8\:SN VSS) capacitor c=1.45704e-16
C49 (\12\:qbint VSS) capacitor c=1.48984e-16
C50 (\4\:net573 VSS) capacitor c=3.67878e-17
C51 (\11\:CKb VSS) capacitor c=2.53721e-16
C52 (\8\:RT VSS) capacitor c=1.21316e-16
C53 (\2\:RT VSS) capacitor c=6.21869e-17
C54 (\5\:qbint VSS) capacitor c=3.89021e-17
C55 (\5\:n35g VSS) capacitor c=3.28693e-17
C56 (\2\:RTb VSS) capacitor c=4.64921e-17
C57 (\5\:SE VSS) capacitor c=5.7365e-17
C58 (\5\:CKbb VSS) capacitor c=2.72722e-17
C59 (\1\:SI VSS) capacitor c=4.90982e-17
C60 (\6\:SE VSS) capacitor c=8.63749e-17
C61 (\3\:SEb VSS) capacitor c=6.59302e-17
C62 (\1\:D VSS) capacitor c=4.94494e-17
C63 (\6\:n20 VSS) capacitor c=8.23106e-17
C64 (\6\:SN VSS) capacitor c=7.01056e-17
C65 (\1\:CK VSS) capacitor c=2.87489e-17
C66 (\3\:mout VSS) capacitor c=4.47479e-17
C67 (\9\:CKb VSS) capacitor c=3.64392e-17
C68 (\10\:CKbb VSS) capacitor c=4.84288e-17
C69 (\6\:CKb VSS) capacitor c=4.93311e-17
C70 (\10\:qbint VSS) capacitor c=8.42187e-17
C71 (\12\:CKbb VSS) capacitor c=5.14498e-17
C72 (\3\:SN VSS) capacitor c=2.84633e-16
C73 (\9\:SN VSS) capacitor c=6.35258e-17
C74 (\7\:RT VSS) capacitor c=1.445e-16
C75 (\9\:CKbb VSS) capacitor c=1.67836e-16
C76 (\3\:RT VSS) capacitor c=3.94588e-17
C77 (\1\:RT VSS) capacitor c=5.29002e-17
C78 (\3\:RTb VSS) capacitor c=7.5942e-17
C79 (\3\:qbint VSS) capacitor c=4.44019e-17
C80 (\2\:n35 VSS) capacitor c=2.52896e-16
C81 (\4\:n35g VSS) capacitor c=6.67426e-17
C82 (\12\:CKb VSS) capacitor c=2.18493e-16
C83 (\3\:n35 VSS) capacitor c=1.16031e-16
C84 (\1\:SE VSS) capacitor c=2.47752e-17
C85 (\2\:SI VSS) capacitor c=7.74104e-17
C86 (\2\:SEb VSS) capacitor c=7.84364e-17
C87 (\7\:n20 VSS) capacitor c=4.70827e-17
C88 (\4\:n20 VSS) capacitor c=7.28737e-17
C89 (\3\:D VSS) capacitor c=1.51045e-17
C90 (\2\:SN VSS) capacitor c=4.20762e-17
C91 (\5\:SN VSS) capacitor c=2.65613e-17
C92 (\3\:CK VSS) capacitor c=2.31437e-17
C93 (\2\:mout VSS) capacitor c=4.66573e-17
C94 (\4\:mout VSS) capacitor c=2.82052e-17
C95 (\10\:CKb VSS) capacitor c=2.21463e-17
C96 (\5\:n20 VSS) capacitor c=7.87098e-17
C97 (\4\:CKbb VSS) capacitor c=6.32587e-17
C98 (\8\:CKbb VSS) capacitor c=2.44292e-17
C99 (\2\:n20 VSS) capacitor c=3.95634e-17
C100 (\1\:VDD VSS) capacitor c=4.33505e-17
C101 (\12\:VDD VSS) capacitor c=2.78404e-17
C102 (\3\:Q VSS) capacitor c=7.97765e-17
C103 (\14\:VDD VSS) capacitor c=5.29599e-17
C104 (\9\:net573 VSS) capacitor c=5.55504e-17
C105 (\16\:VDD VSS) capacitor c=7.97455e-17
C106 (\3\:n11 VSS) capacitor c=8.48924e-17
C107 (\4\:QN VSS) capacitor c=6.86594e-17
C108 (\14\:n35 VSS) capacitor c=5.21976e-17
C109 (\15\:n35g VSS) capacitor c=5.5909e-17
C110 (\6\:RTb VSS) capacitor c=7.27087e-17
C111 (\1\:ExtVDD VSS) capacitor c=2.77768e-16
C112 (\9\:n35 VSS) capacitor c=6.20489e-17
C113 (\17\:qbint VSS) capacitor c=6.81911e-17
C114 (\6\:n35g VSS) capacitor c=9.39178e-17
C115 (\8\:SEb VSS) capacitor c=5.06012e-17
C116 (\4\:n35 VSS) capacitor c=6.29062e-17
C117 (\18\:VDD VSS) capacitor c=6.10013e-17
C118 (\5\:mout VSS) capacitor c=8.78996e-17
C119 (\3\:Db VSS) capacitor c=1.94197e-16
C120 (\20\:VDD VSS) capacitor c=5.06609e-17
C121 (\19\:mout VSS) capacitor c=3.95742e-17
C122 (\25\:VDD VSS) capacitor c=3.45959e-17
C123 (\16\:mout VSS) capacitor c=4.39997e-17
C124 (\17\:CKb VSS) capacitor c=2.98518e-17
C125 (\23\:VDD VSS) capacitor c=4.83128e-17
C126 (\17\:CKbb VSS) capacitor c=6.82922e-17
C127 (\13\:n20 VSS) capacitor c=6.05939e-17
C128 (\5\:Db VSS) capacitor c=2.29715e-16
C129 (\10\:n20 VSS) capacitor c=6.36434e-17
C130 (\1\:Q VSS) capacitor c=5.32881e-17
C131 (\5\:net573 VSS) capacitor c=4.31107e-17
C132 (\1\:QN VSS) capacitor c=3.95495e-17
C133 (\17\:n35 VSS) capacitor c=3.9291e-17
C134 (\11\:n35g VSS) capacitor c=2.96827e-17
C135 (\10\:RTb VSS) capacitor c=5.81982e-17
C136 (\12\:n35 VSS) capacitor c=6.35981e-17
C137 (\19\:qbint VSS) capacitor c=2.43447e-17
C138 (\9\:n35g VSS) capacitor c=8.04088e-17
C139 (\4\:SEb VSS) capacitor c=3.94714e-17
C140 (\7\:n35 VSS) capacitor c=4.09459e-17
C141 (\11\:mout VSS) capacitor c=2.19228e-17
C142 (\13\:mout VSS) capacitor c=1.77684e-17
C143 (\13\:CKb VSS) capacitor c=5.69102e-17
C144 (\15\:CKbb VSS) capacitor c=8.68125e-17
C145 (\17\:n20 VSS) capacitor c=8.69141e-17
C146 (\7\:Db VSS) capacitor c=7.83291e-17
C147 (\8\:n20 VSS) capacitor c=5.88588e-17
C148 (VDD VSS) capacitor c=4.23916e-17
C149 (\2\:CKbb VSS) capacitor c=6.33399e-17
C150 (\2\:CK VSS) capacitor c=3.70344e-17
C151 (\2\:D VSS) capacitor c=3.58843e-17
C152 (\2\:SE VSS) capacitor c=2.5012e-17
C153 (\2\:CKb VSS) capacitor c=1.47509e-16
C154 (\3\:CKb VSS) capacitor c=8.67096e-17
C155 (\5\:CKb VSS) capacitor c=5.70483e-17
C156 (\2\:n35g VSS) capacitor c=2.91068e-17
C157 (\4\:RT VSS) capacitor c=4.60748e-17
C158 (\2\:qbint VSS) capacitor c=4.13305e-17
C159 (\6\:CKbb VSS) capacitor c=1.2768e-16
C160 (\7\:CKbb VSS) capacitor c=7.19841e-17
C161 (\4\:SN VSS) capacitor c=2.47908e-16
C162 (\2\:net573 VSS) capacitor c=1.5265e-17
C163 (\12\:n20 VSS) capacitor c=4.44175e-17
C164 (\13\:CKbb VSS) capacitor c=9.9031e-17
C165 (\14\:CKbb VSS) capacitor c=9.72819e-17
C166 (\15\:n20 VSS) capacitor c=5.20721e-17
C167 (\16\:n20 VSS) capacitor c=9.21474e-17
C168 (\8\:qbint VSS) capacitor c=4.48796e-17
C169 (\9\:qbint VSS) capacitor c=6.56685e-17
C170 (\19\:CKbb VSS) capacitor c=5.18124e-17
C171 (\15\:CKb VSS) capacitor c=6.00279e-17
C172 (\16\:CKb VSS) capacitor c=3.92201e-17
C173 (\10\:SN VSS) capacitor c=3.93965e-17
C174 (\11\:SN VSS) capacitor c=4.44027e-17
C175 (\19\:n20 VSS) capacitor c=6.57619e-17
C176 (\20\:n20 VSS) capacitor c=7.69525e-17
C177 (\7\:mout VSS) capacitor c=8.21686e-17
C178 (\8\:mout VSS) capacitor c=4.27767e-17
C179 (\9\:mout VSS) capacitor c=9.97875e-17
C180 (\10\:mout VSS) capacitor c=8.77644e-17
C181 (\15\:mout VSS) capacitor c=6.71878e-17
C182 (\18\:mout VSS) capacitor c=7.29698e-17
C183 (\6\:SEb VSS) capacitor c=8.36943e-17
C184 (\7\:SEb VSS) capacitor c=6.95574e-17
C185 (\6\:n35 VSS) capacitor c=7.82109e-17
C186 (\19\:CKb VSS) capacitor c=3.91478e-17
C187 (\20\:CKb VSS) capacitor c=4.23519e-17
C188 (\8\:n35g VSS) capacitor c=3.45284e-17
C189 (\11\:n35 VSS) capacitor c=7.50221e-17
C190 (\15\:qbint VSS) capacitor c=8.78471e-17
C191 (\16\:qbint VSS) capacitor c=1.11964e-16
C192 (\13\:n35g VSS) capacitor c=1.02391e-16
C193 (\14\:n35g VSS) capacitor c=1.1611e-16
C194 (\5\:RTb VSS) capacitor c=4.94791e-17
C195 (\8\:RTb VSS) capacitor c=9.93242e-17
C196 (\9\:RTb VSS) capacitor c=9.14752e-17
C197 (\10\:RT VSS) capacitor c=1.09503e-16
C198 (\11\:RT VSS) capacitor c=1.1814e-16
C199 (\12\:SN VSS) capacitor c=8.30194e-17
C200 (\13\:SN VSS) capacitor c=7.94276e-17
C201 (\20\:CKbb VSS) capacitor c=1.30835e-16
C202 (\21\:CKbb VSS) capacitor c=1.34343e-16
C203 (\21\:qbint VSS) capacitor c=2.41935e-17
C204 (\22\:qbint VSS) capacitor c=3.00163e-17
C205 (\3\:QN VSS) capacitor c=3.12928e-17
C206 (\16\:n35 VSS) capacitor c=4.52226e-17
C207 (\7\:net573 VSS) capacitor c=5.43172e-17
C208 (\8\:net573 VSS) capacitor c=3.52344e-17
C209 (\3\:VDD VSS) capacitor c=2.70942e-17
C210 (\4\:VDD VSS) capacitor c=2.45956e-17
C211 (\6\:VDD VSS) capacitor c=9.10299e-18
C212 (\7\:VDD VSS) capacitor c=2.13361e-16
C213 (\8\:VDD VSS) capacitor c=2.06955e-16
C214 (\9\:VDD VSS) capacitor c=2.63757e-17
C215 (\11\:VDD VSS) capacitor c=4.71375e-17
C216 (\22\:VDD VSS) capacitor c=6.14773e-17
Rk72 (\2\:Q Q) resistor r=0.1675 c=0
Rk73 (Q \4\:Q) resistor r=0.332 c=0
Rk64 (\3\:QN QN) resistor r=0.03624 c=0
Rk63 (\2\:QN \3\:QN) resistor r=0.1939 c=0
Rk65 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk74 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk75 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk76 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk77 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk80 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk81 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk82 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk84 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk83 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk85 (VSS \14\:VSS) resistor r=0.313 c=0
Rk86 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk87 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk88 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk89 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk90 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk108 (\26\:VSS \27\:VSS) resistor r=0.1813 c=0
Rk109 (\27\:VSS \28\:VSS) resistor r=0.3652 c=0
Rk110 (\28\:VSS \29\:VSS) resistor r=0.3681 c=0
Rk112 (\30\:VSS VSS) resistor r=0.04947 c=0
Rk111 (\29\:VSS \30\:VSS) resistor r=0.3279 c=0
Rk114 (\31\:VSS VSS) resistor r=0.1216 c=0
Rk113 (VSS \31\:VSS) resistor r=0.8951 c=0
Rk115 (VSS \33\:VSS) resistor r=0.3043 c=0
Rk116 (\27\:VSS \35\:VSS) resistor r=0.2357 c=0
Rk117 (\29\:VSS \37\:VSS) resistor r=0.2445 c=0
Rk118 (\33\:VSS \38\:VSS) resistor r=0.1028 c=0
Rk58 (RT \10\:RT) resistor r=0.1993 c=0
Rk59 (\10\:RT \11\:RT) resistor r=0.6488 c=0
Rk44 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk42 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk45 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk46 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk13 (SN \10\:SN) resistor r=0.0106 c=0
Rk14 (\10\:SN \11\:SN) resistor r=0.3153 c=0
Rk60 (\12\:SN \13\:SN) resistor r=0.538 c=0
Rk107 (VDD VDD) resistor r=0.2362 c=0
Rk91 (\2\:VDD \3\:VDD) resistor r=0.3819 c=0
Rk92 (\3\:VDD \4\:VDD) resistor r=0.1963 c=0
Rk93 (\4\:VDD \6\:VDD) resistor r=0.06692 c=0
Rk94 (\6\:VDD \7\:VDD) resistor r=0.05201 c=0
Rk95 (\7\:VDD \8\:VDD) resistor r=1.5259 c=0
Rk96 (\8\:VDD \9\:VDD) resistor r=0.1711 c=0
Rk97 (\9\:VDD \11\:VDD) resistor r=0.1695 c=0
Rk98 (\3\:VDD \13\:VDD) resistor r=0.32 c=0
Rk99 (\4\:VDD \15\:VDD) resistor r=0.3026 c=0
Rk100 (\7\:VDD \17\:VDD) resistor r=0.3757 c=0
Rk101 (\8\:VDD \19\:VDD) resistor r=0.3677 c=0
Rk102 (\9\:VDD \21\:VDD) resistor r=0.2078 c=0
Rk106 (\22\:VDD VDD) resistor r=0.1959 c=0
Rk103 (\11\:VDD \22\:VDD) resistor r=0.1713 c=0
Rk104 (\22\:VDD \24\:VDD) resistor r=0.2078 c=0
Rk105 (\11\:VDD \26\:VDD) resistor r=0.2399 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3416 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2303 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4984 c=0
Rk19 (\19\:n20 \20\:n20) resistor r=0.4375 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7542 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.532 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.2044 c=0
Rk61 (\20\:CKbb \21\:CKbb) resistor r=0.8279 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.6045 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.3058 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1684 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.3479 c=0
Rk24 (\7\:mout \12\:mout) resistor r=0.1284 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.09239 c=0
Rk26 (\9\:mout \15\:mout) resistor r=0.5264 c=0
Rk27 (\15\:mout \17\:mout) resistor r=0.0449 c=0
Rk28 (\10\:mout \18\:mout) resistor r=0.4268 c=0
Rk29 (\15\:mout \20\:mout) resistor r=0.03469 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.318 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1585 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1872 c=0
Rk37 (\19\:CKb \20\:CKb) resistor r=0.3729 c=0
Rk32 (\5\:SEb \6\:SEb) resistor r=0.217 c=0
Rk33 (\6\:SEb \7\:SEb) resistor r=0.3559 c=0
Rk34 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk38 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk39 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk50 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk51 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk52 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk47 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk48 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk49 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk62 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk53 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk54 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk55 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk56 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk68 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk69 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk70 (\7\:net573 \10\:net573) resistor r=0.2849 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk40 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk41 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk66 (\15\:n35 \16\:n35) resistor r=0.305 c=0
Rk67 (\16\:n35 \18\:n35) resistor r=0.2683 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk17 (\4\:Db \6\:Db) resistor r=1.4324 c=0
Rk18 (\6\:Db \8\:Db) resistor r=0.5673 c=0
Rk71 (\2\:n11 \4\:n11) resistor r=0.6555 c=0
Rl13 (\2\:D \4\:D) resistor r=115.099 c=0
Rl11 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl12 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl20 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl19 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl54 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl41 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl44 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl43 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl42 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl65 (\7\:SN \8\:SN) resistor r=367.487 c=0
Rl66 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl10 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl57 (\4\:SN \6\:SN) resistor r=115.884 c=0
Rl55 (\3\:SN \4\:SN) resistor r=1092.88 c=0
Rl56 (\4\:SN \5\:SN) resistor r=66.1252 c=0
Rl23 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl25 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl22 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl24 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl21 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl16 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl60 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl2 (CKbb \2\:CKbb) resistor r=38.8525 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl49 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl52 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl53 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl51 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl50 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl26 (CKb \2\:CKb) resistor r=349.798 c=0
Rl31 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl32 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl33 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=266.282 c=0
Rl34 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl17 (SEb \2\:SEb) resistor r=101.718 c=0
Rl18 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl37 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl35 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl36 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl38 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl67 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl74 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl72 (\11\:qbint \12\:qbint) resistor r=343.448 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl68 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl71 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl73 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl70 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl69 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl39 (RTb \2\:RTb) resistor r=112.412 c=0
Rl40 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl62 (net573 \2\:net573) resistor r=3.1216 c=0
Rl63 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl64 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl58 (n35 \2\:n35) resistor r=508.667 c=0
Rl59 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz33 (\32\:VSS \38\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry25 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=15.5 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry37 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry9 (\19\:mout \20\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx11 (\3\:D D) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx31 (\3\:SN \12\:SN) resistor r=45 c=0
Rx32 (\9\:SN \13\:SN) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx12 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (CKb \19\:CKb) resistor r=45 c=0
Rx21 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx35 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx36 (qbint \22\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx38 (net573 \8\:net573) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.307e-14 ad=8.7e-15 ps=1.16e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0119 \6\:SN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn52 (net0118 \12\:qbint net0116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0116 \8\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (n11 \11\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n11 \7\:SN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:08:11 2012 )
// Library name: gsclib045
// Cell name: SRDFFX1
// View name: extracted

simulator lang=spectre

subckt SRDFFX1 CK D ExtVDD Q QN RT SE SI VDD VSS
mp25 (\9\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (QN VSS) capacitor c=1.96753e-17
C2 (SI VSS) capacitor c=8.75259e-17
C3 (RT VSS) capacitor c=3.67638e-17
C4 (ExtVDD VSS) capacitor c=2.18919e-16
C5 (CK VSS) capacitor c=7.98675e-17
C6 (VDD VSS) capacitor c=7.1504e-16
C7 (SE VSS) capacitor c=3.96872e-17
C8 (Q VSS) capacitor c=6.17444e-17
C9 (D VSS) capacitor c=7.97214e-17
C10 (n20 VSS) capacitor c=3.84704e-17
C11 (CKbb VSS) capacitor c=3.32985e-17
C12 (mout VSS) capacitor c=5.37744e-17
C13 (CKb VSS) capacitor c=4.82614e-17
C14 (SEb VSS) capacitor c=7.75108e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.57835e-17
C17 (RTb VSS) capacitor c=5.18061e-17
C18 (net573 VSS) capacitor c=2.25505e-17
C19 (n35 VSS) capacitor c=1.45528e-16
C20 (Db VSS) capacitor c=1.02833e-16
C21 (net0110 VSS) capacitor c=6.33869e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:qbint VSS) capacitor c=3.39026e-17
C24 (\11\:qbint VSS) capacitor c=8.31359e-17
C25 (\13\:qbint VSS) capacitor c=4.3763e-17
C26 (\3\:net573 VSS) capacitor c=5.86679e-17
C27 (\11\:CKbb VSS) capacitor c=4.93916e-17
C28 (\4\:RTb VSS) capacitor c=9.88373e-17
C29 (\6\:RT VSS) capacitor c=2.22306e-17
C30 (\4\:qbint VSS) capacitor c=5.36612e-17
C31 (\3\:n35g VSS) capacitor c=5.22105e-17
C32 (\5\:RT VSS) capacitor c=5.86041e-17
C33 (\3\:SE VSS) capacitor c=7.73577e-17
C34 (\7\:CKb VSS) capacitor c=2.48722e-17
C35 (\3\:SI VSS) capacitor c=9.47876e-17
C36 (\4\:SE VSS) capacitor c=1.22829e-16
C37 (\4\:D VSS) capacitor c=7.17432e-17
C38 (\3\:n20 VSS) capacitor c=4.49327e-17
C39 (\4\:CK VSS) capacitor c=5.80043e-17
C40 (\4\:CKb VSS) capacitor c=4.923e-17
C41 (\8\:CKb VSS) capacitor c=8.26279e-17
C42 (\3\:CKbb VSS) capacitor c=2.60323e-17
C43 (\6\:qbint VSS) capacitor c=3.71807e-17
C44 (\14\:qbint VSS) capacitor c=4.56859e-17
C45 (\12\:qbint VSS) capacitor c=8.5727e-17
C46 (\4\:net573 VSS) capacitor c=3.6802e-17
C47 (\11\:CKb VSS) capacitor c=2.33773e-16
C48 (\8\:RT VSS) capacitor c=1.21363e-16
C49 (\2\:RT VSS) capacitor c=6.22925e-17
C50 (\5\:qbint VSS) capacitor c=3.89021e-17
C51 (\5\:n35g VSS) capacitor c=3.28693e-17
C52 (\2\:RTb VSS) capacitor c=4.65527e-17
C53 (\5\:SE VSS) capacitor c=5.7365e-17
C54 (\5\:CKbb VSS) capacitor c=2.45241e-17
C55 (\1\:SI VSS) capacitor c=4.90982e-17
C56 (\6\:SE VSS) capacitor c=8.63749e-17
C57 (\3\:SEb VSS) capacitor c=6.59302e-17
C58 (\1\:D VSS) capacitor c=4.94494e-17
C59 (\6\:n20 VSS) capacitor c=6.51408e-17
C60 (\1\:CK VSS) capacitor c=2.87489e-17
C61 (\3\:mout VSS) capacitor c=5.00546e-17
C62 (\9\:CKb VSS) capacitor c=3.64731e-17
C63 (\10\:CKbb VSS) capacitor c=4.86151e-17
C64 (\6\:CKb VSS) capacitor c=5.11913e-17
C65 (\10\:qbint VSS) capacitor c=8.4112e-17
C66 (\12\:CKbb VSS) capacitor c=3.97735e-17
C67 (\7\:RT VSS) capacitor c=1.4413e-16
C68 (\9\:CKbb VSS) capacitor c=1.55969e-16
C69 (\3\:RT VSS) capacitor c=3.3013e-17
C70 (\1\:RT VSS) capacitor c=5.2467e-17
C71 (\3\:RTb VSS) capacitor c=7.61997e-17
C72 (\3\:qbint VSS) capacitor c=4.44155e-17
C73 (\2\:n35 VSS) capacitor c=1.89205e-16
C74 (\4\:n35g VSS) capacitor c=6.64048e-17
C75 (\12\:CKb VSS) capacitor c=2.21201e-16
C76 (\3\:n35 VSS) capacitor c=7.66801e-17
C77 (\1\:SE VSS) capacitor c=2.47752e-17
C78 (\2\:SI VSS) capacitor c=7.74068e-17
C79 (\2\:SEb VSS) capacitor c=7.8411e-17
C80 (\3\:D VSS) capacitor c=1.51143e-17
C81 (\3\:CK VSS) capacitor c=2.31437e-17
C82 (\2\:mout VSS) capacitor c=3.80143e-17
C83 (\4\:mout VSS) capacitor c=3.80927e-17
C84 (\10\:CKb VSS) capacitor c=2.21463e-17
C85 (\5\:n20 VSS) capacitor c=3.73048e-17
C86 (\4\:CKbb VSS) capacitor c=6.31669e-17
C87 (\8\:CKbb VSS) capacitor c=2.45777e-17
C88 (\2\:n20 VSS) capacitor c=3.95838e-17
C89 (\1\:VDD VSS) capacitor c=4.94752e-17
C90 (\3\:Q VSS) capacitor c=7.27761e-17
C91 (\10\:VDD VSS) capacitor c=5.42941e-17
C92 (\9\:net573 VSS) capacitor c=5.56972e-17
C93 (\12\:VDD VSS) capacitor c=7.99107e-17
C94 (\3\:net0110 VSS) capacitor c=8.53421e-17
C95 (\4\:QN VSS) capacitor c=6.81951e-17
C96 (\14\:n35 VSS) capacitor c=5.41413e-17
C97 (\15\:n35g VSS) capacitor c=5.5988e-17
C98 (\6\:RTb VSS) capacitor c=7.31995e-17
C99 (\1\:ExtVDD VSS) capacitor c=2.78276e-16
C100 (\9\:n35 VSS) capacitor c=6.22363e-17
C101 (\17\:qbint VSS) capacitor c=6.84723e-17
C102 (\6\:n35g VSS) capacitor c=9.31897e-17
C103 (\8\:SEb VSS) capacitor c=5.08032e-17
C104 (\4\:n35 VSS) capacitor c=6.41853e-17
C105 (\14\:VDD VSS) capacitor c=6.09381e-17
C106 (\5\:mout VSS) capacitor c=6.55783e-17
C107 (\3\:Db VSS) capacitor c=1.93889e-16
C108 (\19\:VDD VSS) capacitor c=3.46338e-17
C109 (\14\:mout VSS) capacitor c=4.55773e-17
C110 (\17\:CKb VSS) capacitor c=2.99062e-17
C111 (\17\:VDD VSS) capacitor c=4.83231e-17
C112 (\17\:CKbb VSS) capacitor c=7.28685e-17
C113 (\12\:n20 VSS) capacitor c=6.7629e-17
C114 (\5\:Db VSS) capacitor c=2.22367e-16
C115 (\9\:n20 VSS) capacitor c=6.36354e-17
C116 (\1\:Q VSS) capacitor c=6.54344e-17
C117 (\5\:net573 VSS) capacitor c=4.31609e-17
C118 (\1\:QN VSS) capacitor c=3.92499e-17
C119 (\17\:n35 VSS) capacitor c=3.68796e-17
C120 (\11\:n35g VSS) capacitor c=2.97301e-17
C121 (\10\:RTb VSS) capacitor c=5.83059e-17
C122 (\12\:n35 VSS) capacitor c=6.37635e-17
C123 (\19\:qbint VSS) capacitor c=2.43869e-17
C124 (\9\:n35g VSS) capacitor c=8.1299e-17
C125 (\4\:SEb VSS) capacitor c=3.95357e-17
C126 (\7\:n35 VSS) capacitor c=4.17234e-17
C127 (\10\:mout VSS) capacitor c=2.32392e-17
C128 (\12\:mout VSS) capacitor c=2.62247e-17
C129 (\13\:CKb VSS) capacitor c=5.70233e-17
C130 (\15\:CKbb VSS) capacitor c=9.11333e-17
C131 (\16\:n20 VSS) capacitor c=8.2119e-17
C132 (\7\:Db VSS) capacitor c=7.8489e-17
C133 (\7\:n20 VSS) capacitor c=5.89516e-17
C134 (VDD VSS) capacitor c=4.24372e-17
C135 (\2\:CKbb VSS) capacitor c=6.47353e-17
C136 (\2\:CK VSS) capacitor c=3.70344e-17
C137 (\4\:n20 VSS) capacitor c=5.43891e-17
C138 (\2\:D VSS) capacitor c=3.58484e-17
C139 (\2\:SE VSS) capacitor c=2.50121e-17
C140 (\2\:CKb VSS) capacitor c=1.5308e-16
C141 (\3\:CKb VSS) capacitor c=8.93576e-17
C142 (\5\:CKb VSS) capacitor c=5.76797e-17
C143 (\2\:n35g VSS) capacitor c=2.90883e-17
C144 (\4\:RT VSS) capacitor c=3.78115e-17
C145 (\2\:qbint VSS) capacitor c=4.13305e-17
C146 (\6\:CKbb VSS) capacitor c=1.29582e-16
C147 (\7\:CKbb VSS) capacitor c=7.26353e-17
C148 (\2\:net573 VSS) capacitor c=1.52866e-17
C149 (\11\:n20 VSS) capacitor c=4.46389e-17
C150 (\13\:CKbb VSS) capacitor c=9.84345e-17
C151 (\14\:CKbb VSS) capacitor c=9.76079e-17
C152 (\8\:qbint VSS) capacitor c=4.58346e-17
C153 (\9\:qbint VSS) capacitor c=6.60997e-17
C154 (\14\:n20 VSS) capacitor c=5.19649e-17
C155 (\15\:n20 VSS) capacitor c=8.82111e-17
C156 (\19\:CKbb VSS) capacitor c=4.38948e-17
C157 (\15\:CKb VSS) capacitor c=6.01146e-17
C158 (\16\:CKb VSS) capacitor c=4.45341e-17
C159 (\7\:mout VSS) capacitor c=8.2704e-17
C160 (\8\:mout VSS) capacitor c=5.71549e-17
C161 (\9\:mout VSS) capacitor c=5.30418e-17
C162 (\16\:mout VSS) capacitor c=4.527e-17
C163 (\7\:SE VSS) capacitor c=5.26435e-17
C164 (\6\:SEb VSS) capacitor c=8.36785e-17
C165 (\7\:SEb VSS) capacitor c=6.96329e-17
C166 (\6\:n35 VSS) capacitor c=7.67648e-17
C167 (\19\:CKb VSS) capacitor c=3.8227e-17
C168 (\20\:CKb VSS) capacitor c=4.1869e-17
C169 (\8\:n35g VSS) capacitor c=3.40218e-17
C170 (\11\:n35 VSS) capacitor c=7.40109e-17
C171 (\15\:qbint VSS) capacitor c=8.80005e-17
C172 (\16\:qbint VSS) capacitor c=1.12149e-16
C173 (\13\:n35g VSS) capacitor c=1.02685e-16
C174 (\14\:n35g VSS) capacitor c=1.16309e-16
C175 (\5\:RTb VSS) capacitor c=4.94973e-17
C176 (\8\:RTb VSS) capacitor c=1.01992e-16
C177 (\9\:RTb VSS) capacitor c=9.17318e-17
C178 (\20\:CKbb VSS) capacitor c=9.48784e-17
C179 (\21\:CKbb VSS) capacitor c=1.00848e-16
C180 (\21\:qbint VSS) capacitor c=2.39372e-17
C181 (\22\:qbint VSS) capacitor c=3.00557e-17
C182 (\9\:RT VSS) capacitor c=1.04346e-16
C183 (\10\:RT VSS) capacitor c=1.18785e-16
C184 (\11\:RT VSS) capacitor c=5.89968e-17
C185 (\3\:QN VSS) capacitor c=3.18227e-17
C186 (\16\:n35 VSS) capacitor c=3.71648e-17
C187 (\7\:net573 VSS) capacitor c=5.7709e-17
C188 (\8\:net573 VSS) capacitor c=3.51646e-17
C189 (\3\:VDD VSS) capacitor c=4.42231e-17
C190 (\5\:VDD VSS) capacitor c=9.3079e-18
C191 (\6\:VDD VSS) capacitor c=2.25179e-16
C192 (\7\:VDD VSS) capacitor c=2.13236e-16
C193 (\9\:VDD VSS) capacitor c=3.80928e-17
C194 (\16\:VDD VSS) capacitor c=5.94309e-17
Rk57 (\3\:QN QN) resistor r=0.02948 c=0
Rk56 (\2\:QN \3\:QN) resistor r=0.1988 c=0
Rk58 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk53 (RT \9\:RT) resistor r=0.1932 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6407 c=0
Rk55 (RT \11\:RT) resistor r=0.006609 c=0
Rk38 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk96 (VDD VDD) resistor r=0.2356 c=0
Rk84 (\2\:VDD \3\:VDD) resistor r=0.5761 c=0
Rk85 (\3\:VDD \5\:VDD) resistor r=0.06676 c=0
Rk86 (\5\:VDD \6\:VDD) resistor r=0.05188 c=0
Rk87 (\6\:VDD \7\:VDD) resistor r=1.5221 c=0
Rk88 (\7\:VDD \9\:VDD) resistor r=0.3401 c=0
Rk89 (\3\:VDD \11\:VDD) resistor r=0.3013 c=0
Rk90 (\6\:VDD \13\:VDD) resistor r=0.3741 c=0
Rk91 (\7\:VDD \15\:VDD) resistor r=0.3661 c=0
Rk95 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk92 (\9\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk93 (\16\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk94 (\9\:VDD \20\:VDD) resistor r=0.2389 c=0
Rk25 (SE \7\:SE) resistor r=0.0432 c=0
Rk65 (\2\:Q Q) resistor r=0.2973 c=0
Rk66 (Q \4\:Q) resistor r=0.2044 c=0
Rk67 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk68 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk69 (\5\:VSS \6\:VSS) resistor r=0.05932 c=0
Rk70 (\6\:VSS \7\:VSS) resistor r=0.6123 c=0
Rk71 (\7\:VSS \8\:VSS) resistor r=0.03204 c=0
Rk73 (\9\:VSS VSS) resistor r=0.1211 c=0
Rk72 (\8\:VSS \9\:VSS) resistor r=0.1759 c=0
Rk74 (VSS \10\:VSS) resistor r=0.5208 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk77 (\12\:VSS VSS) resistor r=0.1213 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk78 (VSS \14\:VSS) resistor r=0.3119 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.2667 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.1891 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.1942 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.2532 c=0
Rk83 (\11\:VSS \24\:VSS) resistor r=0.2488 c=0
Rk97 (\26\:VSS \28\:VSS) resistor r=0.3487 c=0
Rk98 (\28\:VSS \29\:VSS) resistor r=0.5654 c=0
Rk100 (\30\:VSS VSS) resistor r=0.04935 c=0
Rk99 (\29\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk102 (\31\:VSS VSS) resistor r=0.1213 c=0
Rk101 (VSS \31\:VSS) resistor r=0.8929 c=0
Rk103 (VSS \33\:VSS) resistor r=0.2968 c=0
Rk104 (\29\:VSS \35\:VSS) resistor r=0.2434 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2662 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4595 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7511 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.5321 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.142 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.7115 c=0
Rk17 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk18 (\7\:mout \8\:mout) resistor r=0.5259 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.1904 c=0
Rk20 (\7\:mout \11\:mout) resistor r=0.1278 c=0
Rk21 (\8\:mout \13\:mout) resistor r=0.1169 c=0
Rk22 (\8\:mout \15\:mout) resistor r=0.5475 c=0
Rk23 (\9\:mout \16\:mout) resistor r=0.3936 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.3167 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1578 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1865 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.3714 c=0
Rk26 (\5\:SEb \6\:SEb) resistor r=0.2161 c=0
Rk27 (\6\:SEb \7\:SEb) resistor r=0.3544 c=0
Rk28 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk42 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk43 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk52 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk61 (\6\:net573 \7\:net573) resistor r=0.2307 c=0
Rk62 (\7\:net573 \8\:net573) resistor r=0.1648 c=0
Rk63 (\7\:net573 \10\:net573) resistor r=0.2901 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk59 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk60 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.42 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.5649 c=0
Rk64 (\2\:net0110 \4\:net0110) resistor r=0.6451 c=0
Rl19 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl18 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl53 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl40 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl43 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl42 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl41 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl22 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl24 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl21 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl23 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl20 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl10 (\3\:n20 \4\:n20) resistor r=100.163 c=0
Rl12 (\4\:n20 \6\:n20) resistor r=179.184 c=0
Rl11 (\4\:n20 \5\:n20) resistor r=123.391 c=0
Rl56 (\11\:CKbb \12\:CKbb) resistor r=163.284 c=0
Rl2 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl48 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl51 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl52 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl50 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl49 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl57 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl25 (CKb \2\:CKb) resistor r=349.798 c=0
Rl30 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl27 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl31 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl26 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl32 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=266.239 c=0
Rl33 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl16 (SEb \2\:SEb) resistor r=101.718 c=0
Rl17 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl36 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl37 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl61 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl68 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl66 (\11\:qbint \12\:qbint) resistor r=337.984 c=0
Rl47 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl44 (qbint \2\:qbint) resistor r=112.732 c=0
Rl46 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl45 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl62 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl65 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl67 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl64 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl63 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl38 (RTb \2\:RTb) resistor r=112.412 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl58 (net573 \2\:net573) resistor r=3.1216 c=0
Rl59 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl60 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl54 (n35 \2\:n35) resistor r=508.667 c=0
Rl55 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\12\:mout \13\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry19 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry30 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry35 (\27\:VSS \28\:VSS) resistor r=5.6364 c=0
Ry36 (\27\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry37 (\27\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry21 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry22 (net0110 \2\:net0110) resistor r=62 c=0
Ry23 (\3\:net0110 \4\:net0110) resistor r=62 c=0
Rx12 (\2\:SI SI) resistor r=45 c=0
Rx28 (\3\:RT \9\:RT) resistor r=45 c=0
Rx29 (\1\:RT \10\:RT) resistor r=45 c=0
Rx30 (\7\:RT \11\:RT) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx13 (\1\:SE \7\:SE) resistor r=45 c=0
Rx9 (\3\:D D) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx24 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx25 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx10 (\4\:mout \9\:mout) resistor r=45 c=0
Rx11 (\2\:mout \16\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (CKb \19\:CKb) resistor r=45 c=0
Rx17 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx26 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx27 (qbint \22\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx32 (net573 \8\:net573) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\12\:mout \6\:n20 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn52 (net0118 \12\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\14\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:net0110 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (net0110 \11\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:12:03 2012 )
// Library name: gsclib045
// Cell name: TBUFX1
// View name: extracted

simulator lang=spectre

subckt TBUFX1 A OE VDD VSS Y
mp4 (\4\:pon \3\:OE \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=6.1e-07 sd=160n sca=20.0544 \
        scb=0.0221539 scc=0.000755314 m=(1)
C1 (OE VSS) capacitor c=3.16522e-17
C2 (Y VSS) capacitor c=2.91421e-17
C3 (VDD VSS) capacitor c=1.53536e-16
C4 (A VSS) capacitor c=1.80982e-16
C5 (pon VSS) capacitor c=3.18162e-17
C6 (OEb VSS) capacitor c=6.10506e-17
C7 (non VSS) capacitor c=4.03159e-17
C8 (\4\:A VSS) capacitor c=7.82255e-17
C9 (\4\:OE VSS) capacitor c=4.59365e-17
C10 (\1\:A VSS) capacitor c=3.8246e-17
C11 (\3\:OE VSS) capacitor c=3.59605e-17
C12 (\5\:A VSS) capacitor c=5.45442e-17
C13 (\3\:OEb VSS) capacitor c=2.8243e-17
C14 (\7\:OE VSS) capacitor c=4.00383e-17
C15 (\3\:A VSS) capacitor c=5.92184e-17
C16 (\1\:OE VSS) capacitor c=3.94766e-17
C17 (\2\:pon VSS) capacitor c=2.32212e-17
C18 (\2\:non VSS) capacitor c=3.76886e-17
C19 (\6\:A VSS) capacitor c=2.5351e-17
C20 (\2\:OEb VSS) capacitor c=3.84973e-17
C21 (\6\:OE VSS) capacitor c=1.65255e-17
C22 (\2\:A VSS) capacitor c=5.55562e-17
C23 (\2\:OE VSS) capacitor c=4.04734e-17
C24 (\3\:Y VSS) capacitor c=8.1794e-17
C25 (\1\:VDD VSS) capacitor c=9.80823e-17
C26 (\5\:non VSS) capacitor c=5.17393e-17
C27 (\6\:OEb VSS) capacitor c=8.12213e-17
C28 (\8\:VDD VSS) capacitor c=1.94774e-17
C29 (\4\:pon VSS) capacitor c=2.25537e-16
C30 (\10\:VDD VSS) capacitor c=3.40986e-17
C31 (\3\:VDD VSS) capacitor c=6.0185e-17
C32 (\1\:Y VSS) capacitor c=2.53254e-17
C33 (\7\:non VSS) capacitor c=3.71804e-17
C34 (\8\:OEb VSS) capacitor c=3.73818e-17
C35 (\6\:pon VSS) capacitor c=6.03124e-17
C36 (\5\:OE VSS) capacitor c=2.34629e-17
C37 (\8\:OE VSS) capacitor c=3.31516e-17
C38 (\9\:OE VSS) capacitor c=3.59536e-17
C39 (\10\:OE VSS) capacitor c=3.39327e-17
C40 (\4\:OEb VSS) capacitor c=2.95279e-17
C41 (\5\:OEb VSS) capacitor c=7.4483e-17
C42 (\7\:A VSS) capacitor c=3.58242e-17
C43 (\8\:A VSS) capacitor c=1.33447e-16
C44 (\3\:non VSS) capacitor c=3.19474e-17
C45 (\4\:non VSS) capacitor c=4.03208e-17
C46 (\3\:pon VSS) capacitor c=1.8872e-16
C47 (\5\:VDD VSS) capacitor c=1.98939e-17
C48 (\7\:VDD VSS) capacitor c=3.07045e-19
Rk3 (\9\:OE OE) resistor r=0.09855 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.09991 c=0
Rk2 (\9\:OE \10\:OE) resistor r=0.1315 c=0
Rk14 (Y \2\:Y) resistor r=0.06799 c=0
Rk15 (Y \4\:Y) resistor r=0.4085 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.5944 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.3551 c=0
Rk18 (\5\:VDD \6\:VDD) resistor r=0.1444 c=0
Rk20 (\7\:VDD VDD) resistor r=0.01962 c=0
Rk19 (\6\:VDD \7\:VDD) resistor r=0.08008 c=0
Rk21 (\5\:VDD \9\:VDD) resistor r=0.04333 c=0
Rk22 (\7\:VDD \11\:VDD) resistor r=0.2629 c=0
Rk7 (\7\:A A) resistor r=0.1512 c=0
Rk8 (A \8\:A) resistor r=1.1058 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.1202 c=0
Rk24 (\3\:VSS \4\:VSS) resistor r=0.2309 c=0
Rk25 (\4\:VSS \5\:VSS) resistor r=0.2566 c=0
Rk27 (\6\:VSS VSS) resistor r=0.1001 c=0
Rk26 (\5\:VSS \6\:VSS) resistor r=0.1453 c=0
Rk28 (\3\:VSS \8\:VSS) resistor r=0.2261 c=0
Rk29 (\4\:VSS \10\:VSS) resistor r=0.0715 c=0
Rk30 (\5\:VSS \12\:VSS) resistor r=0.2849 c=0
Rk12 (\3\:pon \5\:pon) resistor r=1.4482 c=0
Rk13 (\5\:pon \7\:pon) resistor r=0.6071 c=0
Rk4 (\4\:OEb \5\:OEb) resistor r=0.09504 c=0
Rk5 (\5\:OEb \7\:OEb) resistor r=0.5608 c=0
Rk6 (\5\:OEb \9\:OEb) resistor r=0.1516 c=0
Rk9 (\3\:non \4\:non) resistor r=0.1125 c=0
Rk10 (\4\:non \6\:non) resistor r=0.2942 c=0
Rk11 (\4\:non \8\:non) resistor r=0.1776 c=0
Rl2 (\2\:OE \3\:OE) resistor r=87.6374 c=0
Rl1 (\1\:OE \2\:OE) resistor r=90.3846 c=0
Rl5 (\4\:OE \5\:OE) resistor r=107.406 c=0
Rl7 (\5\:OE \7\:OE) resistor r=86.2526 c=0
Rl6 (\5\:OE \6\:OE) resistor r=2.0166 c=0
Rl10 (\4\:A \5\:A) resistor r=134.615 c=0
Rl11 (\5\:A \6\:A) resistor r=24.2328 c=0
Rl3 (\1\:A \2\:A) resistor r=26.098 c=0
Rl4 (\2\:A \3\:A) resistor r=143.406 c=0
Rl13 (pon \2\:pon) resistor r=26.098 c=0
Rl8 (OEb \2\:OEb) resistor r=103.823 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=24.7951 c=0
Rl12 (non \2\:non) resistor r=59.1284 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz6 (\3\:VDD \6\:VDD) resistor r=25 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz3 (\6\:pon \7\:pon) resistor r=75 c=0
Rz1 (\8\:OEb \9\:OEb) resistor r=75 c=0
Rz2 (\7\:non \8\:non) resistor r=75 c=0
Ry4 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry7 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry8 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry9 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry10 (\1\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry3 (\4\:pon \5\:pon) resistor r=62 c=0
Ry1 (\6\:OEb \7\:OEb) resistor r=62 c=0
Ry2 (\5\:non \6\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \10\:OE) resistor r=45 c=0
Rx4 (\2\:A \7\:A) resistor r=45 c=0
Rx5 (\6\:A \8\:A) resistor r=45 c=0
Rx7 (\2\:pon \3\:pon) resistor r=45 c=0
Rx3 (\2\:OEb \4\:OEb) resistor r=45 c=0
Rx6 (\2\:non \3\:non) resistor r=45 c=0
mn4 (\6\:pon \1\:OE net144 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.03e-14 ps=5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn3 (net144 \3\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.33e-14 ad=1.522e-14 ps=9.2e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=5.2e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn0 (\8\:OEb \7\:OE \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.33e-14 ad=3.698e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.55e-07 sd=160n sca=17.28 \
        scb=0.0183577 scc=0.00144167 m=(1)
mn2 (\7\:non \3\:OEb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.965e-14 ad=2.32e-14 ps=1.3e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6e-07 sd=160n sca=12.2839 scb=0.0124725 \
        scc=0.000542081 m=(1)
mn1 (\7\:non \5\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.95e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn5 (\1\:Y non \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.655e-14 ad=3.64e-14 ps=9.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.74231e-07 sb=1.4e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mp3 (\4\:pon \1\:A \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=4.05e-07 sd=160n sca=13.5021 \
        scb=0.0113243 scc=0.000155139 m=(1)
mp0 (\6\:OEb \4\:OE \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.4e-07 sd=160n sca=11.3955 \
        scb=0.00869667 scc=0.000138257 m=(1)
mp2 (\5\:non OEb net127 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=40.6729 \
        scb=0.0277136 scc=0.00519699 m=(1)
mp1 (net127 \4\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.652e-14 ad=1.29e-14 ps=1.45e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.3e-07 sd=160n sca=41.2802 \
        scb=0.0282849 scc=0.00519823 m=(1)
mp5 (\3\:Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.652e-14 ad=5.85e-14 ps=1.45e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.07372e-07 sb=1.5e-07 sd=160n sca=39.7153 \
        scb=0.0373018 scc=0.00416002 m=(1)
ends TBUFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:12:42 2012 )
// Library name: gsclib045
// Cell name: TBUFX12
// View name: extracted

simulator lang=spectre

subckt TBUFX12 A OE VDD VSS Y
mp0 (\14\:OEb \1\:OE \26\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.945e-14 ad=6.63e-14 ps=1.36e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.50135e-06 sd=160n sca=24.3916 \
        scb=0.0229031 scc=0.00193544 m=(1)
C1 (OE VSS) capacitor c=3.26285e-17
C2 (Y VSS) capacitor c=8.73676e-16
C3 (VDD VSS) capacitor c=3.57937e-16
C4 (A VSS) capacitor c=1.48162e-15
C5 (OEb VSS) capacitor c=6.80479e-17
C6 (pon VSS) capacitor c=4.19267e-16
C7 (14 VSS) capacitor c=1.84769e-18
C8 (15 VSS) capacitor c=5.60508e-20
C9 (16 VSS) capacitor c=1.82655e-18
C10 (non VSS) capacitor c=3.45018e-16
C11 (6 VSS) capacitor c=4.28957e-18
C12 (7 VSS) capacitor c=2.85578e-18
C13 (8 VSS) capacitor c=2.83609e-18
C14 (9 VSS) capacitor c=2.12885e-18
C15 (\23\:A VSS) capacitor c=7.95092e-17
C16 (\8\:OEb VSS) capacitor c=8.60842e-17
C17 (\13\:OEb VSS) capacitor c=6.61636e-17
C18 (\16\:A VSS) capacitor c=6.15335e-17
C19 (\21\:A VSS) capacitor c=5.32364e-17
C20 (\5\:OEb VSS) capacitor c=2.24603e-17
C21 (\10\:A VSS) capacitor c=4.03256e-17
C22 (\1\:OE VSS) capacitor c=5.21116e-17
C23 (\15\:A VSS) capacitor c=3.3048e-17
C24 (\16\:OE VSS) capacitor c=3.05468e-17
C25 (\18\:OE VSS) capacitor c=5.03333e-17
C26 (\7\:A VSS) capacitor c=3.78673e-17
C27 (\8\:A VSS) capacitor c=2.24123e-17
C28 (\4\:OE VSS) capacitor c=3.70021e-17
C29 (\11\:OE VSS) capacitor c=2.16457e-17
C30 (\3\:A VSS) capacitor c=5.2842e-17
C31 (\3\:OE VSS) capacitor c=3.39203e-17
C32 (\13\:non VSS) capacitor c=3.80327e-17
C33 (\6\:OEb VSS) capacitor c=1.71462e-17
C34 (\2\:OEb VSS) capacitor c=4.67008e-16
C35 (\5\:OE VSS) capacitor c=4.16006e-16
C36 (\8\:OE VSS) capacitor c=2.516e-17
C37 (\2\:OE VSS) capacitor c=2.52488e-17
C38 (\1\:VDD VSS) capacitor c=6.02999e-16
C39 (\40\:non VSS) capacitor c=4.49515e-17
C40 (\24\:VDD VSS) capacitor c=4.95588e-17
C41 (\34\:non VSS) capacitor c=1.23558e-16
C42 (\4\:VDD VSS) capacitor c=1.04702e-16
C43 (\25\:non VSS) capacitor c=3.24397e-16
C44 (\24\:pon VSS) capacitor c=7.89306e-17
C45 (\34\:pon VSS) capacitor c=8.21509e-17
C46 (\16\:OEb VSS) capacitor c=4.95935e-17
C47 (\7\:OE VSS) capacitor c=1.02122e-17
C48 (\19\:OE VSS) capacitor c=5.05601e-17
C49 (\20\:OE VSS) capacitor c=3.70636e-17
C50 (\15\:OEb VSS) capacitor c=2.07591e-16
C51 (\18\:OEb VSS) capacitor c=2.32676e-16
C52 (\32\:non VSS) capacitor c=7.64937e-17
C53 (\33\:non VSS) capacitor c=1.45593e-16
C54 (\26\:pon VSS) capacitor c=5.29329e-16
C55 (\36\:pon VSS) capacitor c=2.63738e-16
C56 (\23\:VDD VSS) capacitor c=2.18127e-17
C57 (\26\:VDD VSS) capacitor c=1.39851e-16
Rk1 (\19\:OE OE) resistor r=0.1575 c=0
Rk2 (OE \20\:OE) resistor r=0.06326 c=0
Rk95 (\1\:VSS \23\:VSS) resistor r=0.3934 c=0
Rk96 (\23\:VSS \24\:VSS) resistor r=0.1653 c=0
Rk98 (\25\:VSS VSS) resistor r=0.1827 c=0
Rk97 (\24\:VSS \25\:VSS) resistor r=0.3685 c=0
Rk107 (\23\:VSS \43\:VSS) resistor r=0.2646 c=0
Rk108 (\25\:VSS \45\:VSS) resistor r=0.2547 c=0
Rk61 (\1\:VDD \22\:VDD) resistor r=0.1679 c=0
Rk62 (\22\:VDD \23\:VDD) resistor r=0.223 c=0
Rk63 (\23\:VDD \25\:VDD) resistor r=0.24 c=0
Rk77 (\26\:VDD VDD) resistor r=0.201 c=0
Rk64 (\23\:VDD \26\:VDD) resistor r=0.3809 c=0
Rk4 (\15\:OEb \17\:OEb) resistor r=0.4064 c=0
Rk5 (\15\:OEb \18\:OEb) resistor r=1.8402 c=0
Rk22 (\25\:pon \26\:pon) resistor r=0.3642 c=0
Rk27 (\26\:pon \35\:pon) resistor r=0.3926 c=0
Rk28 (\26\:pon \36\:pon) resistor r=1.9434 c=0
Rk16 (\25\:non \32\:non) resistor r=0.2383 c=0
Rk17 (\32\:non \33\:non) resistor r=0.4675 c=0
Rk18 (\33\:non \35\:non) resistor r=0.6406 c=0
Rk21 (\33\:non \41\:non) resistor r=0.1133 c=0
Rl20 (\5\:OE \16\:OE) resistor r=84.2969 c=0
Rl22 (\5\:OE \18\:OE) resistor r=89.8352 c=0
Rl5 (\5\:OE \4\:OE) resistor r=97.3098 c=0
Rl1 (\2\:OE \1\:OE) resistor r=73.7687 c=0
Rl2 (\2\:OE \3\:OE) resistor r=29.5379 c=0
Rl11 (\7\:OE \11\:OE) resistor r=34.3295 c=0
Rl7 (\7\:OE \5\:OE) resistor r=56.64 c=0
Rl8 (\7\:OE \8\:OE) resistor r=2.0166 c=0
Rl45 (A \23\:A) resistor r=114.264 c=0
Rl34 (A \16\:A) resistor r=84.5933 c=0
Rl38 (A \21\:A) resistor r=24.2328 c=0
Rl23 (A \10\:A) resistor r=78.3307 c=0
Rl27 (A \15\:A) resistor r=84.3341 c=0
Rl14 (A \7\:A) resistor r=28.0797 c=0
Rl15 (A \8\:A) resistor r=30.2861 c=0
Rl4 (A \3\:A) resistor r=98.7687 c=0
Rl32 (\6\:OEb \5\:OEb) resistor r=29.5379 c=0
Rl28 (\2\:OEb OEb) resistor r=133.437 c=0
Rl40 (\2\:OEb \8\:OEb) resistor r=210.338 c=0
Rl44 (\2\:OEb \13\:OEb) resistor r=94.0258 c=0
Rl31 (\2\:OEb \5\:OEb) resistor r=86.8321 c=0
Rl59 (non \13\:non) resistor r=9.5799 c=0
Rz31 (\43\:VSS \42\:VSS) resistor r=75 c=0
Rz32 (\45\:VSS \44\:VSS) resistor r=75 c=0
Rz14 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz15 (\22\:VDD \4\:VDD) resistor r=6.25 c=0
Rz16 (\26\:VDD \4\:VDD) resistor r=6.25 c=0
Rz1 (\17\:OEb \16\:OEb) resistor r=75 c=0
Rz6 (\25\:pon \24\:pon) resistor r=75 c=0
Rz7 (\35\:pon \34\:pon) resistor r=75 c=0
Ry32 (\24\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry1 (\15\:OEb \14\:OEb) resistor r=20.6667 c=0
Ry2 (\35\:non \34\:non) resistor r=62 c=0
Ry3 (\41\:non \40\:non) resistor r=62 c=0
Rx1 (\19\:OE \8\:OE) resistor r=45 c=0
Rx2 (\20\:OE \2\:OE) resistor r=45 c=0
Rx5 (\18\:OEb \6\:OEb) resistor r=45 c=0
Rx14 (\36\:pon pon) resistor r=45 c=0
Rx13 (\32\:non \13\:non) resistor r=45 c=0
mn0 (\16\:OEb \3\:OE \44\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.42e-14 ps=9.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.50837e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn3_1__rcx (13 \3\:A \44\:VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.12e-14 ps=9.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.92077e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn4_1__rcx (\34\:pon \11\:OE 13 VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=6.728e-14 ps=7.1e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.84192e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn4 (\34\:pon \4\:OE 14 VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=2.535e-14 ad=6.728e-14 ps=6.5e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.68885e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn3 (14 \8\:A \42\:VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=2.535e-14 ps=7.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.61705e-06 sd=160n sca=10.4876 \
        scb=0.00973116 scc=0.000329538 m=(1)
mn3_2__rcx (15 \7\:A \42\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=1.14e-14 ps=7.1e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.57605e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn4_2__rcx (\24\:pon \18\:OE 15 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=1.14e-14 ad=4.37e-14 ps=5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1.53461e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn4_3__rcx (\24\:pon \16\:OE 16 VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=2.945e-14 ad=4.37e-14 ps=6.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.42605e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn3_3__rcx (16 \15\:A \1\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=2.945e-14 ps=7.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99e-06 sb=1.34711e-06 sd=160n sca=10.353 \
        scb=0.00952974 scc=0.000309813 m=(1)
mn1_1__rcx (\25\:non A \1\:VSS VSS) g45n1svt w=(1.95e-07) l=4.5e-08 nf=1 \
        as=3.09e-14 ad=3.26e-14 ps=7.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95128e-06 sb=1.285e-06 sd=160n sca=10.2695 \
        scb=0.00939499 scc=0.000302823 m=(2)
mn2_1__rcx (\25\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(1.95e-07) \
        l=4.5e-08 nf=1 as=3.12e-14 ad=3.26e-14 ps=7.1e-07 pd=7.8e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.27449e-06 sb=1.96179e-06 sd=160n \
        sca=7.99316 scb=0.0056435 scc=9.07136e-05 m=(2)
mn1_3__rcx (\25\:non A \1\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.415e-14 ad=3.04e-14 ps=7.75e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49816e-06 sb=2e-06 sd=160n sca=7.92284 \
        scb=0.00551663 scc=8.5052e-05 m=(2)
mn2 (\25\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(1.9e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=3.04e-14 ps=7e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.57908e-06 sb=2e-06 sd=160n sca=7.92284 scb=0.00551663 \
        scc=8.5052e-05 m=(2)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.082e-14 ad=4.16e-14 ps=8.3667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35827e-06 sb=2e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(12)
mp3_1__rcx (\26\:pon A \26\:VDD VDD) g45p1svt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=8.093e-14 ad=4.74e-14 ps=1.595e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.91661e-06 sd=160n sca=24.0377 \
        scb=0.0205536 scc=0.00241838 m=(2)
mp4_1__rcx (\26\:pon \5\:OE \26\:VDD VDD) g45p1svt w=(2.95e-07) \
        l=4.5e-08 nf=1 as=1.2427e-13 ad=4.74e-14 ps=2.18e-06 pd=9.2e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.21695e-07 sb=1.97754e-06 sd=160n \
        sca=25.2842 scb=0.0209131 scc=0.00278313 m=(2)
mp3 (\26\:pon A \26\:VDD VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=5.438e-14 ps=1.83e-06 pd=9.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39138e-06 sb=1.93759e-06 sd=160n sca=25.2314 \
        scb=0.0210442 scc=0.00282901 m=(2)
mp4 (\26\:pon \5\:OE \26\:VDD VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.124e-13 ad=5.437e-14 ps=1.83e-06 pd=9.55e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59638e-06 sb=1.81034e-06 sd=160n sca=25.2314 \
        scb=0.0210442 scc=0.00282901 m=(2)
mp1_1__rcx (6 \10\:A \26\:VDD VDD) g45p1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=5.015e-14 ps=1.83e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96085e-06 sb=1.37424e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp2_1__rcx (\34\:non \5\:OEb 6 VDD) g45p1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=4.72e-14 ps=9.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97144e-06 sb=1.24305e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp2_2__rcx (\34\:non OEb 7 VDD) g45p1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97492e-06 sb=1.11797e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp1_2__rcx (7 \21\:A \24\:VDD VDD) g45p1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=1.77e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97669e-06 sb=1.0539e-06 sd=160n sca=24.985 \
        scb=0.0208309 scc=0.00278311 m=(1)
mp1 (8 \16\:A \24\:VDD VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=1.74e-14 ps=1.32e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94931e-06 sb=9.47759e-07 sd=160n sca=23.09 \
        scb=0.0200797 scc=0.00245753 m=(1)
mp2 (\40\:non \13\:OEb 8 VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=6.4e-14 ps=7e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95293e-06 sb=8.86207e-07 sd=160n sca=23.09 \
        scb=0.0200797 scc=0.00245753 m=(1)
mp2_3__rcx (\40\:non \8\:OEb 9 VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=6.4e-14 ps=7e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4931e-07 sb=2e-06 sd=160n sca=10.9993 \
        scb=0.00888516 scc=0.000178627 m=(1)
mp1_3__rcx (9 \23\:A \1\:VDD VDD) g45p1svt w=(2.9e-07) l=4.5e-08 nf=1 \
        as=8.975e-14 ad=1.74e-14 ps=1.33e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.14483e-07 sb=2e-06 sd=160n sca=10.9993 \
        scb=0.00888516 scc=0.000178627 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.403e-14 ad=6.24e-14 ps=1.11583e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.53333e-07 sb=2e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(12)
ends TBUFX12
// End of subcircuit definition.

// Generated for: spectre (May  9 18:13:22 2012 )
// Library name: gsclib045
// Cell name: TBUFX16
// View name: extracted

simulator lang=spectre

subckt TBUFX16 A OE VDD VSS Y
mp4_1__rcx (\34\:pon \1\:OE \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.836e-14 ad=5.834e-14 ps=9.32e-07 pd=1.026e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.99726e-06 sd=160n \
        sca=16.3045 scb=0.0159017 scc=0.000427021 m=(5)
C1 (A VSS) capacitor c=2.02944e-17
C2 (OE VSS) capacitor c=3.44572e-17
C3 (VDD VSS) capacitor c=4.70965e-16
C4 (Y VSS) capacitor c=1.01579e-15
C5 (pon VSS) capacitor c=5.26627e-16
C6 (16 VSS) capacitor c=1.86268e-18
C7 (17 VSS) capacitor c=1.38687e-18
C8 (18 VSS) capacitor c=2.31144e-18
C9 (OEb VSS) capacitor c=5.10987e-17
C10 (non VSS) capacitor c=4.863e-16
C11 (6 VSS) capacitor c=3.46041e-18
C12 (7 VSS) capacitor c=3.35142e-18
C13 (8 VSS) capacitor c=1.93954e-18
C14 (9 VSS) capacitor c=1.92628e-18
C15 (10 VSS) capacitor c=1.87512e-18
C16 (\31\:A VSS) capacitor c=8.39819e-17
C17 (\13\:OEb VSS) capacitor c=5.90708e-17
C18 (\12\:OEb VSS) capacitor c=5.85542e-17
C19 (\23\:A VSS) capacitor c=6.9934e-17
C20 (\28\:A VSS) capacitor c=7.07144e-17
C21 (\4\:OEb VSS) capacitor c=6.54506e-17
C22 (\6\:OEb VSS) capacitor c=4.2431e-17
C23 (\16\:A VSS) capacitor c=5.62948e-17
C24 (\21\:A VSS) capacitor c=3.7666e-17
C25 (\14\:OE VSS) capacitor c=7.54005e-17
C26 (\1\:A VSS) capacitor c=1.29889e-15
C27 (\1\:OE VSS) capacitor c=6.84239e-16
C28 (\20\:OE VSS) capacitor c=3.86263e-17
C29 (\15\:A VSS) capacitor c=2.73089e-17
C30 (\22\:OE VSS) capacitor c=2.7298e-17
C31 (\19\:OE VSS) capacitor c=4.44707e-17
C32 (\10\:A VSS) capacitor c=4.0997e-17
C33 (\12\:A VSS) capacitor c=2.51437e-17
C34 (\11\:OE VSS) capacitor c=3.08648e-17
C35 (\13\:OE VSS) capacitor c=2.23837e-17
C36 (\6\:A VSS) capacitor c=2.971e-17
C37 (\3\:A VSS) capacitor c=3.18663e-17
C38 (\3\:OE VSS) capacitor c=3.24925e-17
C39 (\17\:non VSS) capacitor c=2.45771e-17
C40 (\18\:A VSS) capacitor c=6.27984e-16
C41 (\2\:OEb VSS) capacitor c=8.03165e-16
C42 (\1\:VDD VSS) capacitor c=1.01619e-15
C43 (\52\:non VSS) capacitor c=3.57123e-17
C44 (\30\:VDD VSS) capacitor c=4.62993e-17
C45 (\54\:non VSS) capacitor c=3.46743e-17
C46 (\33\:VDD VSS) capacitor c=4.84751e-17
C47 (\44\:non VSS) capacitor c=1.12308e-16
C48 (\21\:OEb VSS) capacitor c=2.96871e-17
C49 (\33\:non VSS) capacitor c=4.35034e-16
C50 (\19\:OEb VSS) capacitor c=6.92999e-17
C51 (\32\:pon VSS) capacitor c=8.2413e-17
C52 (\42\:pon VSS) capacitor c=8.33553e-17
C53 (\49\:pon VSS) capacitor c=8.35907e-17
C54 (\17\:A VSS) capacitor c=3.09041e-17
C55 (\18\:OEb VSS) capacitor c=4.99553e-17
C56 (\41\:non VSS) capacitor c=1.05428e-16
C57 (\42\:non VSS) capacitor c=1.25096e-16
C58 (\43\:non VSS) capacitor c=1.5496e-16
C59 (\34\:pon VSS) capacitor c=7.34732e-16
C60 (\37\:pon VSS) capacitor c=3.94523e-16
C61 (\32\:VDD VSS) capacitor c=1.43616e-17
Rk18 (\1\:A A) resistor r=0.003673 c=0
Rk14 (\1\:A \18\:A) resistor r=1.3948 c=0
Rk132 (\1\:VSS \25\:VSS) resistor r=0.2027 c=0
Rk133 (\25\:VSS \26\:VSS) resistor r=0.1828 c=0
Rk134 (\26\:VSS \27\:VSS) resistor r=0.2179 c=0
Rk135 (\27\:VSS \28\:VSS) resistor r=0.1928 c=0
Rk136 (\28\:VSS \29\:VSS) resistor r=0.4084 c=0
Rk138 (\30\:VSS VSS) resistor r=0.2753 c=0
Rk137 (\29\:VSS \30\:VSS) resistor r=0.07501 c=0
Rk153 (\26\:VSS \60\:VSS) resistor r=0.3411 c=0
Rk154 (\28\:VSS \62\:VSS) resistor r=0.3314 c=0
Rk155 (\30\:VSS \64\:VSS) resistor r=0.3236 c=0
Rk1 (OE \1\:OE) resistor r=0.03115 c=0
Rk109 (\1\:VDD VDD) resistor r=0.08981 c=0
Rk89 (\1\:VDD \29\:VDD) resistor r=0.3373 c=0
Rk90 (\29\:VDD \31\:VDD) resistor r=0.3085 c=0
Rk93 (\32\:VDD \1\:VDD) resistor r=0.2981 c=0
Rk91 (\29\:VDD \32\:VDD) resistor r=0.3536 c=0
Rk92 (\32\:VDD \34\:VDD) resistor r=0.2623 c=0
Rk33 (\33\:pon \34\:pon) resistor r=0.4161 c=0
Rk35 (\34\:pon \37\:pon) resistor r=3.0493 c=0
Rk39 (\34\:pon \43\:pon) resistor r=0.362 c=0
Rk43 (\34\:pon \50\:pon) resistor r=0.7273 c=0
Rk6 (\2\:OEb \18\:OEb) resistor r=0.4155 c=0
Rk7 (\18\:OEb \20\:OEb) resistor r=0.2001 c=0
Rk8 (\18\:OEb \22\:OEb) resistor r=0.08288 c=0
Rk24 (\33\:non \41\:non) resistor r=0.2767 c=0
Rk25 (\41\:non \42\:non) resistor r=0.5185 c=0
Rk26 (\42\:non \43\:non) resistor r=0.5743 c=0
Rk27 (\43\:non \45\:non) resistor r=0.6502 c=0
Rk31 (\42\:non \53\:non) resistor r=0.07109 c=0
Rk32 (\43\:non \55\:non) resistor r=0.07109 c=0
Rl22 (\1\:A \15\:A) resistor r=35.989 c=0
Rl18 (\1\:A \10\:A) resistor r=55.0028 c=0
Rl20 (\1\:A \12\:A) resistor r=35.3463 c=0
Rl6 (\1\:A \6\:A) resistor r=86.3335 c=0
Rl4 (\1\:A \3\:A) resistor r=76.098 c=0
Rl54 (\18\:A \31\:A) resistor r=128.297 c=0
Rl43 (\18\:A \23\:A) resistor r=148.385 c=0
Rl47 (\18\:A \28\:A) resistor r=135.771 c=0
Rl33 (\17\:A \16\:A) resistor r=100.426 c=0
Rl37 (\17\:A \21\:A) resistor r=35.772 c=0
Rl34 (\17\:A \18\:A) resistor r=98.0022 c=0
Rl23 (\1\:OE \14\:OE) resistor r=263.027 c=0
Rl28 (\20\:OE \14\:OE) resistor r=92.3077 c=0
Rl30 (\1\:OE \22\:OE) resistor r=72.9851 c=0
Rl27 (\1\:OE \19\:OE) resistor r=53.079 c=0
Rl13 (\1\:OE \11\:OE) resistor r=30.0028 c=0
Rl15 (\1\:OE \13\:OE) resistor r=24.6815 c=0
Rl2 (\1\:OE \3\:OE) resistor r=29.5379 c=0
Rl31 (\2\:OEb OEb) resistor r=70.9489 c=0
Rl51 (\2\:OEb \13\:OEb) resistor r=72.3105 c=0
Rl50 (\2\:OEb \12\:OEb) resistor r=71.8867 c=0
Rl39 (\2\:OEb \4\:OEb) resistor r=121.898 c=0
Rl40 (\2\:OEb \6\:OEb) resistor r=75.5053 c=0
Rl70 (non \17\:non) resistor r=24.2107 c=0
Rz40 (\60\:VSS \59\:VSS) resistor r=75 c=0
Rz41 (\62\:VSS \61\:VSS) resistor r=75 c=0
Rz42 (\64\:VSS \63\:VSS) resistor r=75 c=0
Rz7 (\33\:pon \32\:pon) resistor r=75 c=0
Rz8 (\43\:pon \42\:pon) resistor r=75 c=0
Rz9 (\50\:pon \49\:pon) resistor r=75 c=0
Rz1 (\20\:OEb \19\:OEb) resistor r=75 c=0
Ry46 (\27\:VSS \1\:VSS) resistor r=15.5 c=0
Ry47 (\29\:VSS \1\:VSS) resistor r=7.75 c=0
Ry28 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry29 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry1 (\22\:OEb \21\:OEb) resistor r=62 c=0
Ry2 (\45\:non \44\:non) resistor r=62 c=0
Ry3 (\53\:non \52\:non) resistor r=62 c=0
Ry4 (\55\:non \54\:non) resistor r=62 c=0
Rx16 (\37\:pon pon) resistor r=45 c=0
Rx15 (\41\:non \17\:non) resistor r=45 c=0
mn4_1__rcx (\49\:pon \3\:OE 14 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.46e-14 ad=2.87e-14 ps=6.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3_1__rcx (14 \3\:A \63\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=2.46e-14 ps=7.5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn3 (15 \6\:A \63\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=4.92e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn4_3__rcx (\32\:pon \19\:OE 17 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.998e-14 ps=5.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=9.35e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4 (\42\:pon \13\:OE 15 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=6.15e-14 ps=8.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.775e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4_2__rcx (\42\:pon \11\:OE 16 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.153e-14 ad=6.15e-14 ps=6.2e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.43e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3_2__rcx (16 \12\:A \61\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.998e-14 ad=2.153e-14 ps=8e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.28e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3_3__rcx (17 \10\:A \61\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.998e-14 ad=1.23e-14 ps=8e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.04e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn4_4__rcx (\32\:pon \22\:OE 18 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.998e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.885e-06 sb=6.95e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn3_4__rcx (18 \15\:A \59\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=3.28e-14 ps=1.13e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn0 (\19\:OEb \20\:OE \59\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2_1__rcx (\33\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(2.05e-07) \
        l=4.5e-08 nf=1 as=3.198e-14 ad=3.444e-14 ps=7.22e-07 pd=7.46e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.14613 \
        scb=0.0042077 scc=4.68757e-05 m=(5)
mn1_1__rcx (\33\:non \18\:A \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.492e-14 ad=3.444e-14 ps=7.62e-07 pd=7.46e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.14613 scb=0.0042077 \
        scc=4.68757e-05 m=(5)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.139e-14 ad=4.16e-14 ps=8.4062e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=2e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(16)
mp3_1__rcx (\34\:pon \1\:A \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.056e-14 ad=5.834e-14 ps=1.476e-06 pd=1.026e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.94105e-06 sd=160n \
        sca=13.5722 scb=0.0115826 scc=0.000363488 m=(5)
mp0 (\21\:OEb \14\:OE \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=1.2285e-13 ps=1.1e-06 pd=1.41e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24083e-06 sb=3.15e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp2_1__rcx (\44\:non OEb 6 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.34e-14 ps=8.2e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_1__rcx (6 \21\:A \33\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=3.1e-14 ps=9.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_2__rcx (7 \16\:A \33\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=3.1e-14 ps=9.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2_2__rcx (\54\:non \6\:OEb 7 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.96e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2_3__rcx (\54\:non \4\:OEb 8 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_3__rcx (8 \28\:A \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=1.86e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1 (9 \23\:A \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.2e-14 ad=1.86e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp2 (\52\:non \12\:OEb 9 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.2e-14 ps=7.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.295e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp2_4__rcx (\52\:non \13\:OEb 10 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.2e-14 ps=7.4e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=13.6224 scb=0.0125368 \
        scc=0.000630866 m=(1)
mp1_4__rcx (10 \31\:A \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2115e-13 ad=1.86e-14 ps=1.51e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=6.484e-14 ps=1.12313e-06 pd=1.1125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.61026e-06 sb=2e-06 sd=160n sca=12.8992 \
        scb=0.0114532 scc=0.000515529 m=(16)
ends TBUFX16
// End of subcircuit definition.

// Generated for: spectre (May  9 18:14:02 2012 )
// Library name: gsclib045
// Cell name: TBUFX2
// View name: extracted

simulator lang=spectre

subckt TBUFX2 A OE VDD VSS Y
mp4 (\6\:pon \3\:OE \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.837e-14 ps=7.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=33.0431 \
        scb=0.0334326 scc=0.00333002 m=(1)
C1 (Y VSS) capacitor c=1.99734e-17
C2 (VDD VSS) capacitor c=1.33737e-16
C3 (A VSS) capacitor c=1.26529e-16
C4 (pon VSS) capacitor c=9.61993e-17
C5 (OEb VSS) capacitor c=6.07848e-17
C6 (non VSS) capacitor c=7.83406e-17
C7 (net127 VSS) capacitor c=1.93634e-18
C8 (\5\:A VSS) capacitor c=5.28552e-17
C9 (\4\:OE VSS) capacitor c=5.74835e-17
C10 (\1\:A VSS) capacitor c=3.58029e-17
C11 (\3\:OE VSS) capacitor c=2.84532e-17
C12 (\7\:A VSS) capacitor c=4.43409e-17
C13 (\4\:OEb VSS) capacitor c=2.97682e-17
C14 (\7\:OE VSS) capacitor c=2.11951e-17
C15 (\3\:A VSS) capacitor c=4.79645e-17
C16 (\1\:OE VSS) capacitor c=2.7101e-17
C17 (\3\:non VSS) capacitor c=2.67185e-17
C18 (\6\:A VSS) capacitor c=5.45103e-17
C19 (\3\:OEb VSS) capacitor c=1.66398e-17
C20 (\6\:OE VSS) capacitor c=4.23539e-17
C21 (\2\:OE VSS) capacitor c=3.07394e-17
C22 (\1\:VDD VSS) capacitor c=1.15321e-16
C23 (\3\:Y VSS) capacitor c=7.29831e-17
C24 (\8\:non VSS) capacitor c=7.20813e-17
C25 (\9\:OEb VSS) capacitor c=5.70853e-17
C26 (\11\:VDD VSS) capacitor c=2.31883e-17
C27 (\6\:pon VSS) capacitor c=2.04502e-16
C28 (\13\:VDD VSS) capacitor c=4.42286e-17
C29 (\4\:VDD VSS) capacitor c=3.16059e-17
C30 (\1\:Y VSS) capacitor c=4.41295e-17
C31 (\5\:non VSS) capacitor c=3.60722e-17
C32 (\7\:OEb VSS) capacitor c=2.17353e-17
C33 (\4\:pon VSS) capacitor c=6.56833e-17
C34 (\2\:A VSS) capacitor c=5.03e-17
C35 (\2\:OEb VSS) capacitor c=3.53466e-17
C36 (\8\:OE VSS) capacitor c=6.05238e-17
C37 (\9\:OE VSS) capacitor c=5.281e-17
C38 (\5\:OEb VSS) capacitor c=1.60497e-17
C39 (\6\:OEb VSS) capacitor c=3.78854e-17
C40 (\8\:A VSS) capacitor c=1.31802e-16
C41 (\9\:A VSS) capacitor c=2.87373e-17
C42 (\7\:non VSS) capacitor c=5.94712e-17
C43 (\10\:non VSS) capacitor c=3.73571e-17
C44 (\8\:pon VSS) capacitor c=1.53861e-16
C45 (\6\:VDD VSS) capacitor c=2.21705e-17
C46 (\7\:VDD VSS) capacitor c=1.15706e-17
Rk2 (\9\:OE OE) resistor r=0.009977 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.2301 c=0
Rk13 (Y \2\:Y) resistor r=0.2524 c=0
Rk14 (Y \4\:Y) resistor r=0.1409 c=0
Rk26 (\1\:VSS \6\:VSS) resistor r=0.08504 c=0
Rk27 (\6\:VSS \7\:VSS) resistor r=0.1051 c=0
Rk31 (\8\:VSS VSS) resistor r=0.2504 c=0
Rk28 (\7\:VSS \8\:VSS) resistor r=0.2962 c=0
Rk30 (\7\:VSS \12\:VSS) resistor r=0.2295 c=0
Rk32 (\8\:VSS \14\:VSS) resistor r=0.3374 c=0
Rk16 (\1\:VDD \5\:VDD) resistor r=0.2295 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.2872 c=0
Rk19 (\7\:VDD VDD) resistor r=0.04468 c=0
Rk18 (\6\:VDD \7\:VDD) resistor r=0.2168 c=0
Rk22 (\6\:VDD \12\:VDD) resistor r=0.04329 c=0
Rk23 (\7\:VDD \14\:VDD) resistor r=0.4084 c=0
Rk6 (\8\:A A) resistor r=1.0464 c=0
Rk7 (A \9\:A) resistor r=0.051 c=0
Rk11 (\5\:pon \7\:pon) resistor r=0.6441 c=0
Rk12 (\7\:pon \8\:pon) resistor r=1.3156 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.1077 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.1174 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.246 c=0
Rk8 (\6\:non \7\:non) resistor r=0.09746 c=0
Rk9 (\7\:non \9\:non) resistor r=0.4111 c=0
Rk10 (\7\:non \10\:non) resistor r=0.189 c=0
Rl2 (\2\:OE \3\:OE) resistor r=89.5604 c=0
Rl1 (\1\:OE \2\:OE) resistor r=40.3846 c=0
Rl6 (\4\:OE \5\:OE) resistor r=109.329 c=0
Rl8 (\5\:OE \7\:OE) resistor r=36.2526 c=0
Rl7 (\5\:OE \6\:OE) resistor r=0.5166 c=0
Rl12 (\5\:A \6\:A) resistor r=74.2328 c=0
Rl13 (\6\:A \7\:A) resistor r=87.6944 c=0
Rl3 (\1\:A \2\:A) resistor r=41.4601 c=0
Rl4 (\2\:A \3\:A) resistor r=106.845 c=0
Rl5 (\2\:A \4\:A) resistor r=4.959 c=0
Rl9 (OEb \2\:OEb) resistor r=112.741 c=0
Rl11 (\2\:OEb \4\:OEb) resistor r=70.868 c=0
Rl10 (\2\:OEb \3\:OEb) resistor r=25.857 c=0
Rl15 (non \3\:non) resistor r=18.7325 c=0
Rz4 (\2\:Y \1\:Y) resistor r=75 c=0
Rz9 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz6 (VDD \4\:VDD) resistor r=75 c=0
Rz5 (\5\:VDD \4\:VDD) resistor r=7.5 c=0
Rz3 (\5\:pon \4\:pon) resistor r=75 c=0
Rz1 (\7\:OEb \8\:OEb) resistor r=75 c=0
Rz2 (\6\:non \5\:non) resistor r=75 c=0
Ry4 (\4\:Y \3\:Y) resistor r=20.6667 c=0
Ry9 (\1\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry10 (\6\:VSS \3\:VSS) resistor r=31 c=0
Ry11 (\8\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry7 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry8 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry3 (\7\:pon \6\:pon) resistor r=62 c=0
Ry1 (\9\:OEb \10\:OEb) resistor r=62 c=0
Ry2 (\9\:non \8\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\6\:A \8\:A) resistor r=45 c=0
Rx5 (\4\:A \9\:A) resistor r=45 c=0
Rx7 (\8\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\10\:non \3\:non) resistor r=45 c=0
mn4 (\4\:pon \1\:OE net144 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (net144 \3\:A \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.8e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\7\:OEb \7\:OE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\5\:non \4\:OEb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (\5\:non \7\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn5 (\1\:Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.99e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84423e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp3 (\6\:pon \1\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=4.838e-14 ps=1.8e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=4e-07 sd=160n sca=27.5463 scb=0.0242522 \
        scc=0.00301933 m=(1)
mp0 (\9\:OEb \4\:OE \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=4.408e-14 ps=1.8e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=2.05e-07 sd=160n sca=26.4598 \
        scb=0.0232447 scc=0.00301689 m=(1)
mp2 (\8\:non OEb net127 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.01e-14 ps=6.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=26.1509 \
        scb=0.0231087 scc=0.00301684 m=(1)
mp1 (net127 \5\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.208e-13 ad=2.365e-14 ps=1.96e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=6.4e-07 sd=160n sca=26.6838 \
        scb=0.0233875 scc=0.00301701 m=(1)
mp5 (\3\:Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.77e-14 ad=6.24e-14 ps=1.51e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.92564e-07 sb=3.45e-07 sd=160n sca=34.13 \
        scb=0.0245441 scc=0.00340271 m=(2)
ends TBUFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:14:41 2012 )
// Library name: gsclib045
// Cell name: TBUFX20
// View name: extracted

simulator lang=spectre

subckt TBUFX20 A OE VDD VSS Y
mp3_1__rcx (\40\:pon \2\:A VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=7.425e-14 ad=5.2e-14 ps=1.76667e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=49.4087 scb=0.0429485 \
        scc=0.0056687 m=(6)
C1 (Y VSS) capacitor c=1.22088e-15
C2 (A VSS) capacitor c=2.35345e-17
C3 (VDD VSS) capacitor c=1.59134e-15
C4 (OE VSS) capacitor c=7.19368e-16
C5 (15 VSS) capacitor c=6.35687e-18
C6 (pon VSS) capacitor c=6.94125e-16
C7 (16 VSS) capacitor c=2.50553e-18
C8 (17 VSS) capacitor c=2.83825e-18
C9 (18 VSS) capacitor c=3.00585e-18
C10 (19 VSS) capacitor c=9.24291e-19
C11 (20 VSS) capacitor c=1.88768e-18
C12 (OEb VSS) capacitor c=5.84533e-17
C13 (non VSS) capacitor c=6.18242e-16
C14 (5 VSS) capacitor c=7.30684e-18
C15 (7 VSS) capacitor c=2.86247e-18
C16 (8 VSS) capacitor c=7.06791e-18
C17 (9 VSS) capacitor c=5.29684e-18
C18 (10 VSS) capacitor c=8.69276e-18
C19 (11 VSS) capacitor c=9.61153e-18
C20 (\34\:A VSS) capacitor c=5.50407e-17
C21 (\13\:OEb VSS) capacitor c=4.12327e-17
C22 (\19\:OEb VSS) capacitor c=3.0894e-17
C23 (\28\:A VSS) capacitor c=4.45272e-17
C24 (\31\:A VSS) capacitor c=5.49234e-17
C25 (\7\:OEb VSS) capacitor c=4.1116e-17
C26 (\12\:OEb VSS) capacitor c=4.05992e-17
C27 (\22\:A VSS) capacitor c=6.12113e-17
C28 (\27\:A VSS) capacitor c=6.77205e-17
C29 (\6\:OEb VSS) capacitor c=2.59697e-17
C30 (\19\:A VSS) capacitor c=5.44283e-17
C31 (\14\:OE VSS) capacitor c=1.89581e-16
C32 (\18\:A VSS) capacitor c=3.42186e-17
C33 (\24\:OE VSS) capacitor c=3.50987e-17
C34 (\26\:OE VSS) capacitor c=5.26879e-17
C35 (\13\:A VSS) capacitor c=3.82751e-17
C36 (\14\:A VSS) capacitor c=1.61603e-17
C37 (\11\:OE VSS) capacitor c=2.67218e-17
C38 (\12\:OE VSS) capacitor c=3.17522e-17
C39 (\9\:A VSS) capacitor c=1.90188e-17
C40 (\6\:A VSS) capacitor c=2.10651e-17
C41 (\1\:OE VSS) capacitor c=2.46728e-17
C42 (\4\:OE VSS) capacitor c=3.04449e-17
C43 (\1\:A VSS) capacitor c=3.02971e-17
C44 (\21\:non VSS) capacitor c=2.35483e-17
C45 (\20\:A VSS) capacitor c=1.0331e-15
C46 (\2\:A VSS) capacitor c=1.14006e-15
C47 (\51\:non VSS) capacitor c=1.42832e-16
C48 (\58\:VDD VSS) capacitor c=3.77092e-17
C49 (\53\:non VSS) capacitor c=1.79146e-16
C50 (\60\:VDD VSS) capacitor c=3.87531e-17
C51 (\55\:non VSS) capacitor c=1.1864e-16
C52 (\26\:OEb VSS) capacitor c=3.44184e-17
C53 (\40\:pon VSS) capacitor c=6.96775e-16
C54 (\41\:non VSS) capacitor c=4.79939e-16
C55 (\24\:OEb VSS) capacitor c=8.50821e-17
C56 (\45\:pon VSS) capacitor c=8.11488e-17
C57 (\52\:pon VSS) capacitor c=6.97942e-17
C58 (\59\:pon VSS) capacitor c=8.3928e-17
C59 (\2\:OEb VSS) capacitor c=8.12477e-16
C60 (\23\:OEb VSS) capacitor c=5.51012e-17
C61 (\50\:non VSS) capacitor c=1.20005e-16
C62 (\43\:pon VSS) capacitor c=3.99586e-16
C63 (\20\:VDD VSS) capacitor c=1.13729e-17
C64 (\22\:VDD VSS) capacitor c=1.30005e-17
Rk17 (\2\:A A) resistor r=0.07968 c=0
Rk12 (\20\:A \2\:A) resistor r=1.0099 c=0
Rk96 (VDD \20\:VDD) resistor r=0.3559 c=0
Rk97 (\20\:VDD \21\:VDD) resistor r=0.1954 c=0
Rk98 (\21\:VDD \22\:VDD) resistor r=0.1854 c=0
Rk100 (\23\:VDD VDD) resistor r=0.08439 c=0
Rk99 (\22\:VDD \23\:VDD) resistor r=0.3659 c=0
Rk125 (\20\:VDD \59\:VDD) resistor r=0.1592 c=0
Rk126 (\22\:VDD \61\:VDD) resistor r=0.2126 c=0
Rk182 (\1\:VSS \67\:VSS) resistor r=0.3533 c=0
Rk183 (\67\:VSS \68\:VSS) resistor r=0.4486 c=0
Rk185 (\69\:VSS VSS) resistor r=0.02212 c=0
Rk184 (\68\:VSS \69\:VSS) resistor r=0.3789 c=0
Rk187 (\67\:VSS \73\:VSS) resistor r=0.2598 c=0
Rk188 (\68\:VSS \75\:VSS) resistor r=0.3061 c=0
Rk189 (\69\:VSS \77\:VSS) resistor r=0.251 c=0
Rk35 (\40\:pon \43\:pon) resistor r=2.9728 c=0
Rk37 (\40\:pon \46\:pon) resistor r=0.3461 c=0
Rk41 (\40\:pon \53\:pon) resistor r=0.3509 c=0
Rk45 (\40\:pon \60\:pon) resistor r=0.3642 c=0
Rk6 (\2\:OEb \23\:OEb) resistor r=0.5161 c=0
Rk7 (\23\:OEb \25\:OEb) resistor r=0.1344 c=0
Rk8 (\23\:OEb \27\:OEb) resistor r=0.06751 c=0
Rk26 (\41\:non \50\:non) resistor r=0.261 c=0
Rk27 (\50\:non \52\:non) resistor r=0.5173 c=0
Rk28 (\52\:non \54\:non) resistor r=0.6086 c=0
Rk29 (\54\:non \56\:non) resistor r=0.5824 c=0
Rl65 (\20\:A \34\:A) resistor r=114.264 c=0
Rl54 (\20\:A \28\:A) resistor r=103.08 c=0
Rl56 (\20\:A \31\:A) resistor r=115.362 c=0
Rl44 (\20\:A \22\:A) resistor r=112.261 c=0
Rl48 (\20\:A \27\:A) resistor r=85.7713 c=0
Rl37 (\20\:A \19\:A) resistor r=88.4615 c=0
Rl24 (\2\:A \18\:A) resistor r=43.6813 c=0
Rl20 (\2\:A \13\:A) resistor r=28.0797 c=0
Rl21 (\2\:A \14\:A) resistor r=32.2092 c=0
Rl12 (\2\:A \9\:A) resistor r=26.098 c=0
Rl10 (\2\:A \6\:A) resistor r=26.098 c=0
Rl1 (\2\:A \1\:A) resistor r=36.5385 c=0
Rl28 (OE \14\:OE) resistor r=289.95 c=0
Rl34 (OE \24\:OE) resistor r=78.5277 c=0
Rl36 (OE \26\:OE) resistor r=79.9451 c=0
Rl15 (OE \11\:OE) resistor r=74.7951 c=0
Rl16 (OE \12\:OE) resistor r=81.9251 c=0
Rl3 (OE \1\:OE) resistor r=27.2353 c=0
Rl5 (OE \4\:OE) resistor r=28.0797 c=0
Rl39 (\2\:OEb OEb) resistor r=74.6625 c=0
Rl59 (\2\:OEb \13\:OEb) resistor r=151.157 c=0
Rl64 (\2\:OEb \19\:OEb) resistor r=43.4636 c=0
Rl49 (\2\:OEb \7\:OEb) resistor r=45.3874 c=0
Rl53 (\2\:OEb \12\:OEb) resistor r=43.4636 c=0
Rl43 (\2\:OEb \6\:OEb) resistor r=24.2328 c=0
Rl87 (non \21\:non) resistor r=11.3141 c=0
Rz27 (\21\:VDD VDD) resistor r=18.75 c=0
Rz54 (\73\:VSS \72\:VSS) resistor r=75 c=0
Rz55 (\75\:VSS \74\:VSS) resistor r=75 c=0
Rz56 (\77\:VSS \76\:VSS) resistor r=75 c=0
Rz8 (\46\:pon \45\:pon) resistor r=75 c=0
Rz9 (\53\:pon \52\:pon) resistor r=75 c=0
Rz10 (\60\:pon \59\:pon) resistor r=75 c=0
Rz1 (\25\:OEb \24\:OEb) resistor r=75 c=0
Ry32 (\59\:VDD \58\:VDD) resistor r=62 c=0
Ry33 (\61\:VDD \60\:VDD) resistor r=62 c=0
Ry56 (\68\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry1 (\27\:OEb \26\:OEb) resistor r=62 c=0
Ry2 (\52\:non \51\:non) resistor r=62 c=0
Ry3 (\54\:non \53\:non) resistor r=62 c=0
Ry4 (\56\:non \55\:non) resistor r=62 c=0
Rx18 (\43\:pon pon) resistor r=45 c=0
Rx17 (\50\:non \21\:non) resistor r=45 c=0
mn3_1__rcx (15 \1\:A \76\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.258e-14 ps=7.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn4_1__rcx (\59\:pon \4\:OE 15 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=3.44e-14 ps=6.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.9e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn3 (19 \13\:A \72\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4_2__rcx (\59\:pon \1\:OE 16 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_2__rcx (16 \6\:A \74\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_3__rcx (17 \9\:A \74\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.333e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn4_3__rcx (\52\:pon \12\:OE 17 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=4.515e-14 ps=7.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn1_1__rcx (\41\:non \20\:A \1\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.253e-14 ad=3.44e-14 ps=8.4167e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(6)
mn4_4__rcx (\52\:pon \11\:OE 18 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn3_4__rcx (18 \14\:A \72\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4 (\45\:pon \26\:OE 19 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(1)
mn4_5__rcx (\45\:pon \24\:OE 20 VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.3e-14 ps=6.6e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn3_5__rcx (20 \18\:A \1\:VSS VSS) g45n1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.007e-14 ad=2.472e-14 ps=1.13e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 scb=0.00953019 \
        scc=0.000328496 m=(1)
mn0_1__rcx (\24\:OEb \14\:OE \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.007e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67115e-06 sb=1.70663e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn2_1__rcx (\41\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=10.3734 \
        scb=0.00953019 scc=0.000328496 m=(6)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.163e-14 ad=4.16e-14 ps=8.42e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67115e-06 sb=2e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(20)
mp4_1__rcx (\40\:pon OE VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.877e-14 ad=5.2e-14 ps=1.97e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=38.3877 scb=0.0274361 \
        scc=0.00406713 m=(6)
mp0_1__rcx (\26\:OEb \14\:OE VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.896e-14 ad=8.775e-14 ps=1.43e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.68333e-06 sb=1.59295e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp1_1__rcx (5 \19\:A VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=1.2318e-13 ad=6.012e-14 ps=1.66e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.69262e-06 sb=1.79077e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp2_1__rcx (\55\:non \6\:OEb 5 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=6.012e-14 ad=5.2e-14 ps=1.02e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74569e-06 sb=1.75538e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp2_2__rcx (\55\:non OEb 7 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=1.95e-14 ad=5.2e-14 ps=7.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.793e-06 sb=1.72385e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp1_2__rcx (7 \27\:A \60\:VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=1.95e-14 ps=1.32e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81723e-06 sb=1.70769e-06 sd=160n sca=17.5615 \
        scb=0.01617 scc=0.00141748 m=(1)
mp1_3__rcx (8 \22\:A \60\:VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.18e-14 ad=3.25e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59685e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1_5__rcx (11 \34\:A VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=9.035e-14 ad=5.2e-14 ps=1.28e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.93e-06 sb=2e-06 sd=160n sca=13.7057 scb=0.0125682 \
        scc=0.000653447 m=(1)
mp2_3__rcx (\53\:non \12\:OEb 8 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=3.25e-14 ad=5.2e-14 ps=8.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65262e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2_4__rcx (\53\:non \7\:OEb 9 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=3.25e-14 ad=5.2e-14 ps=8.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73146e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1_4__rcx (9 \31\:A \58\:VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.89e-14 ad=3.25e-14 ps=1.38e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78123e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp1 (10 \28\:A \58\:VDD VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=8.89e-14 ad=5.2e-14 ps=1.38e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83015e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2 (\51\:non \19\:OEb 10 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=5.2e-14 ps=9.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86692e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp2_5__rcx (\51\:non \13\:OEb 11 VDD) g45p1svt w=(3.25e-07) l=4.5e-08 \
        nf=1 as=5.2e-14 ad=5.2e-14 ps=9.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89846e-06 sb=2e-06 sd=160n sca=13.7057 \
        scb=0.0125682 scc=0.000653447 m=(1)
mp5_1__rcx (Y pon VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.341e-14 ad=6.396e-14 ps=1.107e-06 pd=1.108e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66949e-06 sb=2e-06 sd=160n sca=13.1056 \
        scb=0.0116857 scc=0.000556045 m=(20)
ends TBUFX20
// End of subcircuit definition.

// Generated for: spectre (May  9 18:15:22 2012 )
// Library name: gsclib045
// Cell name: TBUFX3
// View name: extracted

simulator lang=spectre

subckt TBUFX3 A OE VDD VSS Y
mp4 (\6\:pon \3\:OE \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.04551e-07 sd=160n sca=24.3383 \
        scb=0.0260706 scc=0.00165215 m=(1)
C1 (OE VSS) capacitor c=6.19058e-17
C2 (Y VSS) capacitor c=2.44729e-17
C3 (VDD VSS) capacitor c=1.10273e-16
C4 (A VSS) capacitor c=2.51846e-17
C5 (pon VSS) capacitor c=1.42354e-16
C6 (OEb VSS) capacitor c=8.89281e-17
C7 (non VSS) capacitor c=1.11865e-16
C8 (net127 VSS) capacitor c=3.8178e-18
C9 (\4\:A VSS) capacitor c=8.80734e-17
C10 (\4\:OE VSS) capacitor c=3.57195e-17
C11 (\1\:A VSS) capacitor c=4.31802e-17
C12 (\3\:OE VSS) capacitor c=4.40243e-17
C13 (\6\:A VSS) capacitor c=2.7067e-17
C14 (\4\:OEb VSS) capacitor c=2.58785e-17
C15 (\7\:OE VSS) capacitor c=2.29633e-17
C16 (\3\:A VSS) capacitor c=6.1785e-17
C17 (\1\:OE VSS) capacitor c=4.00592e-17
C18 (\4\:non VSS) capacitor c=2.31202e-17
C19 (\5\:A VSS) capacitor c=4.93418e-17
C20 (\3\:OEb VSS) capacitor c=1.07105e-17
C21 (\6\:OE VSS) capacitor c=1.85536e-17
C22 (\2\:A VSS) capacitor c=4.09395e-17
C23 (\2\:OE VSS) capacitor c=3.675e-17
C24 (\9\:non VSS) capacitor c=3.25342e-17
C25 (\7\:OEb VSS) capacitor c=9.32362e-17
C26 (\15\:VDD VSS) capacitor c=3.50423e-17
C27 (\6\:pon VSS) capacitor c=2.17866e-16
C28 (\17\:VDD VSS) capacitor c=2.8289e-17
C29 (\1\:VDD VSS) capacitor c=7.85401e-17
C30 (\1\:Y VSS) capacitor c=7.5848e-17
C31 (\11\:non VSS) capacitor c=6.64874e-17
C32 (\9\:OEb VSS) capacitor c=3.06926e-17
C33 (\8\:pon VSS) capacitor c=7.92411e-17
C34 (\5\:OE VSS) capacitor c=1.44028e-17
C35 (\2\:OEb VSS) capacitor c=3.34066e-17
C36 (\8\:OE VSS) capacitor c=5.57575e-17
C37 (\5\:OEb VSS) capacitor c=2.40442e-17
C38 (\6\:OEb VSS) capacitor c=5.04931e-17
C39 (\7\:A VSS) capacitor c=1.6326e-16
C40 (\8\:A VSS) capacitor c=1.52485e-16
C41 (\9\:A VSS) capacitor c=5.44813e-17
C42 (\7\:non VSS) capacitor c=7.42051e-17
C43 (\8\:non VSS) capacitor c=6.01143e-17
C44 (\5\:pon VSS) capacitor c=1.98253e-16
C45 (\4\:Y VSS) capacitor c=9.94186e-17
C46 (\3\:VDD VSS) capacitor c=6.64962e-17
Rk2 (\9\:OE OE) resistor r=0.003271 c=0
Rk1 (\8\:OE \9\:OE) resistor r=0.2153 c=0
Rk15 (\1\:Y Y) resistor r=0.2199 c=0
Rk16 (Y \4\:Y) resistor r=0.04988 c=0
Rk29 (\2\:VDD \3\:VDD) resistor r=0.08252 c=0
Rk32 (\3\:VDD \6\:VDD) resistor r=0.2981 c=0
Rk33 (\6\:VDD \7\:VDD) resistor r=0.3056 c=0
Rk34 (\7\:VDD \8\:VDD) resistor r=0.09505 c=0
Rk36 (\9\:VDD VDD) resistor r=0.03966 c=0
Rk35 (\8\:VDD \9\:VDD) resistor r=0.1101 c=0
Rk40 (\7\:VDD \16\:VDD) resistor r=0.2154 c=0
Rk41 (\9\:VDD \18\:VDD) resistor r=0.2577 c=0
Rk8 (\8\:A A) resistor r=0.0262 c=0
Rk6 (\7\:A \8\:A) resistor r=1.1854 c=0
Rk7 (\8\:A \9\:A) resistor r=0.2681 c=0
Rk21 (\1\:VSS \5\:VSS) resistor r=0.1327 c=0
Rk22 (\5\:VSS \6\:VSS) resistor r=0.1593 c=0
Rk23 (\6\:VSS \7\:VSS) resistor r=0.3521 c=0
Rk25 (\8\:VSS VSS) resistor r=0.1 c=0
Rk24 (\7\:VSS \8\:VSS) resistor r=0.1377 c=0
Rk27 (\6\:VSS \12\:VSS) resistor r=0.04328 c=0
Rk28 (\7\:VSS \14\:VSS) resistor r=0.2466 c=0
Rk12 (\5\:pon \7\:pon) resistor r=1.5174 c=0
Rk13 (\7\:pon \9\:pon) resistor r=0.7166 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.1109 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.4762 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.05947 c=0
Rk9 (\7\:non \8\:non) resistor r=0.4473 c=0
Rk10 (\8\:non \10\:non) resistor r=0.1057 c=0
Rk11 (\8\:non \12\:non) resistor r=0.2549 c=0
Rl2 (\2\:OE \3\:OE) resistor r=87.6374 c=0
Rl1 (\1\:OE \2\:OE) resistor r=30.7692 c=0
Rl5 (\4\:OE \5\:OE) resistor r=99.7141 c=0
Rl7 (\5\:OE \7\:OE) resistor r=34.3295 c=0
Rl6 (\5\:OE \6\:OE) resistor r=4.3144 c=0
Rl11 (\4\:A \5\:A) resistor r=91.0764 c=0
Rl12 (\5\:A \6\:A) resistor r=29.5379 c=0
Rl3 (\1\:A \2\:A) resistor r=26.098 c=0
Rl4 (\2\:A \3\:A) resistor r=83.7903 c=0
Rl8 (OEb \2\:OEb) resistor r=150.308 c=0
Rl10 (\2\:OEb \4\:OEb) resistor r=23.7402 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=16.1277 c=0
Rl18 (non \4\:non) resistor r=3.203 c=0
Rz14 (VDD \1\:VDD) resistor r=75 c=0
Rz10 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz11 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz12 (\6\:VDD \1\:VDD) resistor r=12.5 c=0
Rz13 (\8\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz3 (\9\:pon \8\:pon) resistor r=75 c=0
Rz1 (\9\:OEb \10\:OEb) resistor r=75 c=0
Rz2 (\12\:non \11\:non) resistor r=75 c=0
Ry10 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry11 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry6 (\5\:VSS \4\:VSS) resistor r=6.2 c=0
Ry7 (\8\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry3 (\7\:pon \6\:pon) resistor r=20.6667 c=0
Ry1 (\7\:OEb \8\:OEb) resistor r=62 c=0
Ry2 (\10\:non \9\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\5\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \9\:A) resistor r=45 c=0
Rx7 (\5\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\7\:non \4\:non) resistor r=45 c=0
mn4 (\8\:pon \1\:OE net144 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=3.64e-14 ps=7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.42692e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mn3 (net144 \3\:A \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.017e-14 ad=2.34e-14 ps=9.9e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.07692e-07 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn0 (\9\:OEb \7\:OE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.017e-14 ad=4.93e-14 ps=9.9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn2 (\11\:non \4\:OEb \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.58e-14 ad=5.72e-14 ps=1.22e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.105e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn1 (\11\:non \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.37e-14 ad=5.72e-14 ps=1.01e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=8.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn5 (\1\:Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.897e-14 ad=3.987e-14 ps=8.9667e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=5.5e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(3)
mp3 (\6\:pon \1\:A \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.99551e-07 sd=160n sca=19.1183 \
        scb=0.0171898 scc=0.00129044 m=(1)
mp0 (\7\:OEb \4\:OE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.305e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=22.5405 \
        scb=0.0210689 scc=0.00225095 m=(1)
mp2 (\9\:non OEb net127 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.35e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp1 (net127 \4\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.3e-07 sd=160n sca=30.5804 \
        scb=0.0202168 scc=0.00336097 m=(1)
mp5 (\4\:Y pon \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.795e-14 ad=5.98e-14 ps=1.32333e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=6.1e-07 sd=160n sca=31.2654 \
        scb=0.0205378 scc=0.00336116 m=(3)
ends TBUFX3
// End of subcircuit definition.

// Generated for: spectre (May  9 18:16:03 2012 )
// Library name: gsclib045
// Cell name: TBUFX4
// View name: extracted

simulator lang=spectre

subckt TBUFX4 A OE VDD VSS Y
mp4 (\9\:pon \1\:OE \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.07308e-07 sd=160n sca=21.9686 \
        scb=0.0221039 scc=0.00141228 m=(1)
C1 (OE VSS) capacitor c=4.31709e-17
C2 (Y VSS) capacitor c=3.27551e-17
C3 (VDD VSS) capacitor c=1.32539e-16
C4 (A VSS) capacitor c=2.01926e-17
C5 (pon VSS) capacitor c=1.5928e-16
C6 (OEb VSS) capacitor c=8.60428e-17
C7 (non VSS) capacitor c=1.33435e-16
C8 (net127 VSS) capacitor c=3.87139e-18
C9 (\4\:A VSS) capacitor c=8.28148e-17
C10 (\4\:OE VSS) capacitor c=5.17027e-17
C11 (\1\:A VSS) capacitor c=5.3688e-17
C12 (\1\:OE VSS) capacitor c=4.61498e-17
C13 (\6\:A VSS) capacitor c=2.7039e-17
C14 (\4\:OEb VSS) capacitor c=4.02746e-17
C15 (\7\:OE VSS) capacitor c=3.19312e-17
C16 (\3\:A VSS) capacitor c=6.23756e-17
C17 (\3\:OE VSS) capacitor c=4.24472e-17
C18 (\5\:non VSS) capacitor c=2.64161e-17
C19 (\5\:A VSS) capacitor c=4.99797e-17
C20 (\3\:OEb VSS) capacitor c=1.25532e-17
C21 (\6\:OE VSS) capacitor c=2.12927e-17
C22 (\2\:A VSS) capacitor c=4.54041e-17
C23 (\2\:OE VSS) capacitor c=3.41588e-17
C24 (\1\:VDD VSS) capacitor c=1.66881e-16
C25 (\1\:Y VSS) capacitor c=1.3727e-16
C26 (\11\:non VSS) capacitor c=4.49542e-17
C27 (\7\:OEb VSS) capacitor c=6.8071e-17
C28 (\15\:VDD VSS) capacitor c=3.63451e-17
C29 (\9\:pon VSS) capacitor c=2.09283e-16
C30 (\17\:VDD VSS) capacitor c=2.81809e-17
C31 (\3\:VDD VSS) capacitor c=2.83545e-17
C32 (\13\:non VSS) capacitor c=6.361e-17
C33 (\9\:OEb VSS) capacitor c=4.69445e-17
C34 (\11\:pon VSS) capacitor c=7.49089e-17
C35 (\5\:OE VSS) capacitor c=1.88589e-17
C36 (\2\:OEb VSS) capacitor c=3.25907e-17
C37 (\8\:OE VSS) capacitor c=3.64459e-17
C38 (\9\:OE VSS) capacitor c=3.27444e-17
C39 (\5\:OEb VSS) capacitor c=1.92834e-17
C40 (\6\:OEb VSS) capacitor c=4.46625e-17
C41 (\7\:A VSS) capacitor c=1.5078e-16
C42 (\8\:A VSS) capacitor c=1.59473e-16
C43 (\9\:A VSS) capacitor c=7.27173e-17
C44 (\9\:non VSS) capacitor c=7.19988e-17
C45 (\10\:non VSS) capacitor c=6.34313e-17
C46 (\8\:pon VSS) capacitor c=1.99238e-16
C47 (\4\:Y VSS) capacitor c=7.80023e-17
C48 (\8\:VDD VSS) capacitor c=1.86378e-17
C49 (\9\:VDD VSS) capacitor c=7.5531e-18
Rk1 (\8\:OE OE) resistor r=0.09997 c=0
Rk2 (OE \9\:OE) resistor r=0.1038 c=0
Rk15 (\1\:Y Y) resistor r=0.0738 c=0
Rk16 (Y \4\:Y) resistor r=0.21 c=0
Rk23 (\1\:VDD \7\:VDD) resistor r=0.1552 c=0
Rk24 (\7\:VDD \8\:VDD) resistor r=0.3757 c=0
Rk26 (\9\:VDD VDD) resistor r=0.06973 c=0
Rk25 (\8\:VDD \9\:VDD) resistor r=0.2051 c=0
Rk30 (\8\:VDD \16\:VDD) resistor r=0.2151 c=0
Rk31 (\9\:VDD \18\:VDD) resistor r=0.2573 c=0
Rk8 (\8\:A A) resistor r=0.003669 c=0
Rk6 (\7\:A \8\:A) resistor r=1.01 c=0
Rk7 (\8\:A \9\:A) resistor r=0.4051 c=0
Rk32 (\2\:VSS \3\:VSS) resistor r=0.05494 c=0
Rk37 (\3\:VSS \8\:VSS) resistor r=0.286 c=0
Rk38 (\8\:VSS \9\:VSS) resistor r=0.3113 c=0
Rk40 (\10\:VSS VSS) resistor r=0.1 c=0
Rk39 (\9\:VSS \10\:VSS) resistor r=0.1401 c=0
Rk44 (\8\:VSS \18\:VSS) resistor r=0.07143 c=0
Rk45 (\9\:VSS \20\:VSS) resistor r=0.2329 c=0
Rk12 (\8\:pon \10\:pon) resistor r=1.3384 c=0
Rk13 (\10\:pon \12\:pon) resistor r=0.7152 c=0
Rk3 (\5\:OEb \6\:OEb) resistor r=0.05422 c=0
Rk4 (\6\:OEb \8\:OEb) resistor r=0.3249 c=0
Rk5 (\6\:OEb \10\:OEb) resistor r=0.179 c=0
Rk9 (\9\:non \10\:non) resistor r=0.3628 c=0
Rk10 (\10\:non \12\:non) resistor r=0.1488 c=0
Rk11 (\10\:non \14\:non) resistor r=0.238 c=0
Rl1 (\1\:OE \2\:OE) resistor r=87.2302 c=0
Rl2 (\2\:OE \3\:OE) resistor r=37.2302 c=0
Rl5 (\4\:OE \5\:OE) resistor r=118.464 c=0
Rl7 (\5\:OE \7\:OE) resistor r=28.0797 c=0
Rl6 (\5\:OE \6\:OE) resistor r=31.5487 c=0
Rl11 (\4\:A \5\:A) resistor r=99.1749 c=0
Rl12 (\5\:A \6\:A) resistor r=26.098 c=0
Rl3 (\1\:A \2\:A) resistor r=28.1965 c=0
Rl4 (\2\:A \3\:A) resistor r=90.1797 c=0
Rl8 (OEb \2\:OEb) resistor r=119.539 c=0
Rl10 (\2\:OEb \4\:OEb) resistor r=71.8171 c=0
Rl9 (\2\:OEb \3\:OEb) resistor r=14.532 c=0
Rl16 (non \5\:non) resistor r=24.9253 c=0
Rz8 (VDD \3\:VDD) resistor r=75 c=0
Rz6 (\1\:VDD \3\:VDD) resistor r=75 c=0
Rz7 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz13 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz3 (\12\:pon \11\:pon) resistor r=75 c=0
Rz1 (\9\:OEb \10\:OEb) resistor r=75 c=0
Rz2 (\14\:non \13\:non) resistor r=75 c=0
Ry9 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry10 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry14 (\8\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry15 (\10\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry3 (\10\:pon \9\:pon) resistor r=20.6667 c=0
Ry1 (\7\:OEb \8\:OEb) resistor r=62 c=0
Ry2 (\12\:non \11\:non) resistor r=62 c=0
Rx1 (\6\:OE \8\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\5\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \9\:A) resistor r=45 c=0
Rx7 (\8\:pon pon) resistor r=45 c=0
Rx3 (\3\:OEb \5\:OEb) resistor r=45 c=0
Rx6 (\9\:non \5\:non) resistor r=45 c=0
mn4 (\11\:pon \3\:OE net144 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=3.64e-14 ps=7e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.39904e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn3 (net144 \3\:A \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=2.34e-14 ps=1.11e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=4.04904e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn0 (\9\:OEb \7\:OE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.887e-14 ad=3.987e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2.75e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (\13\:non \4\:OEb \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.39e-14 ad=4.94e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.31e-06 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1 (\13\:non \6\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.94e-14 ps=1.07e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.075e-06 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn5 (\4\:Y non \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.777e-14 ad=4.16e-14 ps=8.875e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mp3 (\9\:pon \1\:A \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.02308e-07 sd=160n sca=18.49 \
        scb=0.0162883 scc=0.00128386 m=(1)
mp0 (\7\:OEb \4\:OE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=22.3241 \
        scb=0.0209633 scc=0.0022509 m=(1)
mp2 (\11\:non OEb net127 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp1 (net127 \4\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.014e-13 ad=2.34e-14 ps=1.3e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.13e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp5 (\1\:Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.605e-14 ps=1.14e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=8.25e-07 sd=160n sca=20.6353 \
        scb=0.0171431 scc=0.00197772 m=(4)
ends TBUFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:16:42 2012 )
// Library name: gsclib045
// Cell name: TBUFX6
// View name: extracted

simulator lang=spectre

subckt TBUFX6 A OE VDD VSS Y
mp4_1__rcx (\13\:pon OE \10\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.29e-14 ps=8.2667e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40433e-06 sd=160n sca=23.1083 \
        scb=0.0266933 scc=0.00125052 m=(3)
C1 (Y VSS) capacitor c=3.801e-16
C2 (A VSS) capacitor c=2.35189e-17
C3 (VDD VSS) capacitor c=2.15956e-16
C4 (OE VSS) capacitor c=4.10748e-16
C5 (12 VSS) capacitor c=1.62221e-18
C6 (pon VSS) capacitor c=2.77229e-16
C7 (13 VSS) capacitor c=2.34057e-18
C8 (OEb VSS) capacitor c=8.99629e-17
C9 (non VSS) capacitor c=2.1337e-16
C10 (6 VSS) capacitor c=2.23816e-18
C11 (7 VSS) capacitor c=6.89697e-18
C12 (8 VSS) capacitor c=2.90695e-18
C13 (\18\:A VSS) capacitor c=7.80652e-17
C14 (\4\:OEb VSS) capacitor c=4.86136e-17
C15 (\9\:OEb VSS) capacitor c=3.25647e-17
C16 (\13\:A VSS) capacitor c=4.55958e-17
C17 (\10\:A VSS) capacitor c=7.20938e-17
C18 (\10\:OE VSS) capacitor c=6.2751e-17
C19 (\1\:A VSS) capacitor c=4.45252e-16
C20 (\11\:A VSS) capacitor c=5.20416e-16
C21 (\13\:OE VSS) capacitor c=3.35563e-17
C22 (\9\:A VSS) capacitor c=8.45446e-17
C23 (\8\:OE VSS) capacitor c=4.03479e-17
C24 (\9\:OE VSS) capacitor c=5.03314e-17
C25 (\6\:A VSS) capacitor c=3.52756e-17
C26 (\4\:A VSS) capacitor c=6.46443e-17
C27 (\3\:OE VSS) capacitor c=6.01322e-17
C28 (\7\:non VSS) capacitor c=5.83113e-17
C29 (\2\:OEb VSS) capacitor c=3.64925e-16
C30 (\12\:OE VSS) capacitor c=4.10042e-17
C31 (\1\:VDD VSS) capacitor c=2.65012e-16
C32 (\13\:non VSS) capacitor c=4.85045e-17
C33 (\22\:VDD VSS) capacitor c=5.26848e-17
C34 (\16\:non VSS) capacitor c=1.28529e-16
C35 (\15\:OEb VSS) capacitor c=6.04566e-17
C36 (\13\:pon VSS) capacitor c=4.4511e-16
C37 (\5\:VDD VSS) capacitor c=4.74353e-17
C38 (\19\:non VSS) capacitor c=1.39451e-16
C39 (\13\:OEb VSS) capacitor c=4.28098e-17
C40 (\21\:pon VSS) capacitor c=9.11173e-17
C41 (\19\:pon VSS) capacitor c=1.08863e-16
C42 (\3\:A VSS) capacitor c=2.52922e-17
C43 (\11\:OE VSS) capacitor c=2.92735e-17
C44 (\16\:OE VSS) capacitor c=5.21705e-17
C45 (\12\:OEb VSS) capacitor c=2.82049e-17
C46 (\15\:non VSS) capacitor c=1.01452e-16
C47 (\18\:non VSS) capacitor c=8.40245e-17
C48 (\25\:non VSS) capacitor c=4.97601e-17
C49 (\12\:pon VSS) capacitor c=2.75673e-16
C50 (\8\:VDD VSS) capacitor c=2.58286e-17
C51 (\10\:VDD VSS) capacitor c=1.10865e-16
Rk8 (A \1\:A) resistor r=0.01324 c=0
Rk10 (\1\:A \11\:A) resistor r=0.8981 c=0
Rk57 (\1\:VDD \8\:VDD) resistor r=0.4234 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.3158 c=0
Rk65 (\10\:VDD VDD) resistor r=0.02463 c=0
Rk59 (\9\:VDD \10\:VDD) resistor r=0.08663 c=0
Rk69 (\8\:VDD \23\:VDD) resistor r=0.2987 c=0
Rk41 (\1\:VSS \10\:VSS) resistor r=0.2595 c=0
Rk42 (\10\:VSS \11\:VSS) resistor r=0.2807 c=0
Rk44 (\12\:VSS VSS) resistor r=0.1801 c=0
Rk43 (\11\:VSS \12\:VSS) resistor r=0.07002 c=0
Rk51 (\10\:VSS \26\:VSS) resistor r=0.3167 c=0
Rk52 (\12\:VSS \28\:VSS) resistor r=0.2196 c=0
Rk3 (OE \16\:OE) resistor r=0.1909 c=0
Rk20 (\12\:pon \13\:pon) resistor r=2.1909 c=0
Rk23 (\13\:pon \20\:pon) resistor r=0.5868 c=0
Rk24 (\20\:pon \22\:pon) resistor r=0.518 c=0
Rk5 (\2\:OEb \12\:OEb) resistor r=0.09138 c=0
Rk6 (\12\:OEb \14\:OEb) resistor r=0.2222 c=0
Rk7 (\12\:OEb \16\:OEb) resistor r=0.2842 c=0
Rk13 (\14\:non \15\:non) resistor r=0.1328 c=0
Rk14 (\15\:non \17\:non) resistor r=0.7773 c=0
Rk16 (\18\:non \19\:non) resistor r=0.0254 c=0
Rk15 (\15\:non \18\:non) resistor r=0.2504 c=0
Rk19 (\18\:non \25\:non) resistor r=0.1562 c=0
Rl30 (\11\:A \18\:A) resistor r=184.181 c=0
Rl22 (\11\:A \13\:A) resistor r=178.693 c=0
Rl20 (\11\:A \10\:A) resistor r=176.489 c=0
Rl14 (\1\:A \9\:A) resistor r=156.093 c=0
Rl4 (\3\:A \1\:A) resistor r=58.644 c=0
Rl7 (\3\:A \6\:A) resistor r=35.772 c=0
Rl5 (\3\:A \4\:A) resistor r=123.503 c=0
Rl11 (OE \8\:OE) resistor r=37.4796 c=0
Rl12 (OE \9\:OE) resistor r=83.5649 c=0
Rl2 (OE \3\:OE) resistor r=102.615 c=0
Rl15 (\11\:OE \10\:OE) resistor r=205.747 c=0
Rl17 (\11\:OE \13\:OE) resistor r=30.4507 c=0
Rl16 (\11\:OE \12\:OE) resistor r=36.87 c=0
Rl18 (\2\:OEb OEb) resistor r=132.258 c=0
Rl24 (\2\:OEb \4\:OEb) resistor r=137.695 c=0
Rl28 (\2\:OEb \9\:OEb) resistor r=107.487 c=0
Rl46 (non \7\:non) resistor r=11.1519 c=0
Rz19 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz20 (\9\:VDD \5\:VDD) resistor r=12.5 c=0
Rz22 (\10\:VDD \5\:VDD) resistor r=15 c=0
Rz17 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz18 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz5 (\20\:pon \19\:pon) resistor r=75 c=0
Rz6 (\22\:pon \21\:pon) resistor r=75 c=0
Rz1 (\14\:OEb \13\:OEb) resistor r=75 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=3.6471 c=0
Ry12 (\11\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry1 (\16\:OEb \15\:OEb) resistor r=62 c=0
Ry2 (\14\:non \13\:non) resistor r=62 c=0
Ry3 (\17\:non \16\:non) resistor r=62 c=0
Rx3 (\16\:OE \12\:OE) resistor r=45 c=0
Rx12 (\12\:pon pon) resistor r=45 c=0
Rx11 (\25\:non \7\:non) resistor r=45 c=0
mn4_1__rcx (\19\:pon \3\:OE 12 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.02e-14 ad=2.38e-14 ps=4.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26618e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_1__rcx (12 \4\:A \27\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.02e-14 ps=1.01e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.16118e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3 (13 \6\:A \27\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.36e-14 ps=1.01e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.96176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4 (\21\:pon \9\:OE 13 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.36e-14 ad=2.77e-14 ps=5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=7.71176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4_2__rcx (\21\:pon \8\:OE 14 VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=1.05e-14 ad=2.77e-14 ps=4.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18857e-07 sb=5.68143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn3_2__rcx (14 \9\:A \25\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=1.05e-14 ps=8.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.23857e-07 sb=4.63143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn0 (\13\:OEb \13\:OE \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=3.553e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20448e-06 sb=2.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn2_1__rcx (\19\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 \
        nf=1 as=5.872e-14 ad=2.933e-14 ps=1.37e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn1_1__rcx (\19\:non \11\:A \1\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 \
        nf=1 as=8.005e-14 ad=2.932e-14 ps=1.47e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn2_2__rcx (\19\:non \2\:OEb \1\:VSS VSS) g45n1svt w=(1.75e-07) \
        l=4.5e-08 nf=1 as=7.605e-14 ad=2.8e-14 ps=1.42e-06 pd=6.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.06371e-06 sb=1.59e-06 sd=160n \
        sca=12.1767 scb=0.0122352 scc=0.000549928 m=(1)
mn1_2__rcx (\19\:non \11\:A \1\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 \
        nf=1 as=3.912e-14 ad=2.8e-14 ps=8.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26871e-06 sb=1.385e-06 sd=160n sca=12.1767 \
        scb=0.0122352 scc=0.000549928 m=(1)
mn5_1__rcx (Y non \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.032e-14 ad=4.16e-14 ps=8.3833e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03471e-06 sb=1.165e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(6)
mp3_1__rcx (\13\:pon \1\:A \10\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.925e-14 ad=4.29e-14 ps=1.1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18433e-06 sd=160n sca=16.3479 \
        scb=0.0155274 scc=0.000646302 m=(3)
mp0 (\15\:OEb \10\:OE \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp2_1__rcx (\16\:non OEb 6 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_1__rcx (6 \10\:A \22\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1 (7 \13\:A \22\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=4.81e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.98e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp2 (\13\:non \9\:OEb 7 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=4.29e-14 ps=8.9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=1.75e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp2_2__rcx (\13\:non \4\:OEb 8 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.47e-14 ad=4.29e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.54e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp1_2__rcx (8 \18\:A \1\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.47e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=1.4e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=6.24e-14 ps=1.10333e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.23333e-07 sb=1.165e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(6)
ends TBUFX6
// End of subcircuit definition.

// Generated for: spectre (May  9 18:17:20 2012 )
// Library name: gsclib045
// Cell name: TBUFX8
// View name: extracted

simulator lang=spectre

subckt TBUFX8 A OE VDD VSS Y
mp4_1__rcx (\17\:pon OE \11\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.29e-14 ps=8.2667e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40433e-06 sd=160n sca=23.1083 \
        scb=0.0266933 scc=0.00125052 m=(3)
C1 (Y VSS) capacitor c=5.01369e-16
C2 (A VSS) capacitor c=2.35189e-17
C3 (VDD VSS) capacitor c=2.26748e-16
C4 (OE VSS) capacitor c=4.10807e-16
C5 (12 VSS) capacitor c=1.62221e-18
C6 (pon VSS) capacitor c=3.54656e-16
C7 (13 VSS) capacitor c=2.34057e-18
C8 (OEb VSS) capacitor c=9.14252e-17
C9 (non VSS) capacitor c=2.90668e-16
C10 (6 VSS) capacitor c=2.23816e-18
C11 (7 VSS) capacitor c=4.58974e-18
C12 (8 VSS) capacitor c=2.90695e-18
C13 (\18\:A VSS) capacitor c=7.80652e-17
C14 (\4\:OEb VSS) capacitor c=5.02808e-17
C15 (\9\:OEb VSS) capacitor c=3.89722e-17
C16 (\13\:A VSS) capacitor c=4.50776e-17
C17 (\10\:A VSS) capacitor c=7.25011e-17
C18 (\10\:OE VSS) capacitor c=6.28557e-17
C19 (\1\:A VSS) capacitor c=4.4921e-16
C20 (\11\:A VSS) capacitor c=5.28947e-16
C21 (\13\:OE VSS) capacitor c=3.3522e-17
C22 (\9\:A VSS) capacitor c=8.45576e-17
C23 (\8\:OE VSS) capacitor c=4.03325e-17
C24 (\9\:OE VSS) capacitor c=5.0322e-17
C25 (\6\:A VSS) capacitor c=3.52756e-17
C26 (\4\:A VSS) capacitor c=6.46443e-17
C27 (\3\:OE VSS) capacitor c=6.01248e-17
C28 (\9\:non VSS) capacitor c=5.96558e-17
C29 (\2\:OEb VSS) capacitor c=3.69024e-16
C30 (\12\:OE VSS) capacitor c=4.09826e-17
C31 (\17\:non VSS) capacitor c=5.01471e-17
C32 (\27\:VDD VSS) capacitor c=5.29496e-17
C33 (\20\:non VSS) capacitor c=1.27827e-16
C34 (\15\:OEb VSS) capacitor c=5.79562e-17
C35 (\17\:pon VSS) capacitor c=4.45326e-16
C36 (\1\:VDD VSS) capacitor c=3.8582e-16
C37 (\23\:non VSS) capacitor c=1.39765e-16
C38 (\13\:OEb VSS) capacitor c=4.14372e-17
C39 (\25\:pon VSS) capacitor c=9.11173e-17
C40 (\23\:pon VSS) capacitor c=1.08863e-16
C41 (\3\:A VSS) capacitor c=2.52941e-17
C42 (\11\:OE VSS) capacitor c=2.88438e-17
C43 (\16\:OE VSS) capacitor c=5.21727e-17
C44 (\12\:OEb VSS) capacitor c=3.1643e-17
C45 (\19\:non VSS) capacitor c=1.00116e-16
C46 (\22\:non VSS) capacitor c=8.4444e-17
C47 (\29\:non VSS) capacitor c=4.97875e-17
C48 (\16\:pon VSS) capacitor c=2.74296e-16
C49 (\9\:VDD VSS) capacitor c=2.56289e-17
C50 (\11\:VDD VSS) capacitor c=1.10865e-16
Rk8 (A \1\:A) resistor r=0.01324 c=0
Rk10 (\1\:A \11\:A) resistor r=0.8955 c=0
Rk66 (\1\:VDD \9\:VDD) resistor r=0.4234 c=0
Rk67 (\9\:VDD \10\:VDD) resistor r=0.3158 c=0
Rk74 (\11\:VDD VDD) resistor r=0.02463 c=0
Rk68 (\10\:VDD \11\:VDD) resistor r=0.08663 c=0
Rk80 (\9\:VDD \28\:VDD) resistor r=0.2987 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.06752 c=0
Rk48 (\3\:VSS \15\:VSS) resistor r=0.2595 c=0
Rk49 (\15\:VSS \16\:VSS) resistor r=0.2807 c=0
Rk51 (\17\:VSS VSS) resistor r=0.1801 c=0
Rk50 (\16\:VSS \17\:VSS) resistor r=0.07002 c=0
Rk58 (\15\:VSS \31\:VSS) resistor r=0.3167 c=0
Rk59 (\17\:VSS \33\:VSS) resistor r=0.2196 c=0
Rk3 (OE \16\:OE) resistor r=0.1909 c=0
Rk20 (\16\:pon \17\:pon) resistor r=2.1909 c=0
Rk23 (\17\:pon \24\:pon) resistor r=0.5868 c=0
Rk24 (\24\:pon \26\:pon) resistor r=0.518 c=0
Rk5 (\2\:OEb \12\:OEb) resistor r=0.1315 c=0
Rk6 (\12\:OEb \14\:OEb) resistor r=0.18 c=0
Rk7 (\12\:OEb \16\:OEb) resistor r=0.2708 c=0
Rk13 (\18\:non \19\:non) resistor r=0.1328 c=0
Rk14 (\19\:non \21\:non) resistor r=0.768 c=0
Rk16 (\22\:non \23\:non) resistor r=0.0254 c=0
Rk15 (\19\:non \22\:non) resistor r=0.2504 c=0
Rk19 (\22\:non \29\:non) resistor r=0.1562 c=0
Rl30 (\11\:A \18\:A) resistor r=184.181 c=0
Rl22 (\11\:A \13\:A) resistor r=178.693 c=0
Rl20 (\11\:A \10\:A) resistor r=176.489 c=0
Rl14 (\1\:A \9\:A) resistor r=156.093 c=0
Rl4 (\3\:A \1\:A) resistor r=58.644 c=0
Rl7 (\3\:A \6\:A) resistor r=35.772 c=0
Rl5 (\3\:A \4\:A) resistor r=123.503 c=0
Rl11 (OE \8\:OE) resistor r=37.4796 c=0
Rl12 (OE \9\:OE) resistor r=83.5649 c=0
Rl2 (OE \3\:OE) resistor r=102.615 c=0
Rl15 (\11\:OE \10\:OE) resistor r=205.747 c=0
Rl17 (\11\:OE \13\:OE) resistor r=30.4507 c=0
Rl16 (\11\:OE \12\:OE) resistor r=36.87 c=0
Rl18 (\2\:OEb OEb) resistor r=132.258 c=0
Rl24 (\2\:OEb \4\:OEb) resistor r=137.695 c=0
Rl28 (\2\:OEb \9\:OEb) resistor r=107.487 c=0
Rl52 (non \9\:non) resistor r=11.1519 c=0
Rz23 (\10\:VDD \1\:VDD) resistor r=12.5 c=0
Rz25 (\11\:VDD \1\:VDD) resistor r=15 c=0
Rz19 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz20 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz5 (\24\:pon \23\:pon) resistor r=75 c=0
Rz6 (\26\:pon \25\:pon) resistor r=75 c=0
Rz1 (\14\:OEb \13\:OEb) resistor r=75 c=0
Ry20 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\3\:VSS \1\:VSS) resistor r=3.4444 c=0
Ry14 (\16\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\16\:OEb \15\:OEb) resistor r=62 c=0
Ry2 (\18\:non \17\:non) resistor r=62 c=0
Ry3 (\21\:non \20\:non) resistor r=62 c=0
Rx3 (\16\:OE \12\:OE) resistor r=45 c=0
Rx12 (\16\:pon pon) resistor r=45 c=0
Rx11 (\29\:non \9\:non) resistor r=45 c=0
mn4_1__rcx (\23\:pon \3\:OE 12 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.02e-14 ad=2.38e-14 ps=4.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26618e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3_1__rcx (12 \4\:A \32\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.02e-14 ps=1.01e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.16118e-06 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn3 (13 \6\:A \32\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=5.12e-14 ad=1.36e-14 ps=1.01e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.96176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4 (\25\:pon \9\:OE 13 VSS) g45n1svt w=(1.7e-07) l=4.5e-08 nf=1 \
        as=1.36e-14 ad=2.77e-14 ps=5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=7.71176e-07 sd=160n sca=13.6381 \
        scb=0.0141729 scc=0.000783402 m=(1)
mn4_2__rcx (\25\:pon \8\:OE 14 VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=1.05e-14 ad=2.77e-14 ps=4.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18857e-07 sb=5.68143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn3_2__rcx (14 \9\:A \30\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=1.05e-14 ps=8.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.23857e-07 sb=4.63143e-07 sd=160n sca=13.8761 \
        scb=0.0144385 scc=0.000829722 m=(1)
mn0 (\13\:OEb \13\:OE \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=3.553e-14 ps=8.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20448e-06 sb=2.45e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn2_1__rcx (\23\:non \2\:OEb \3\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 \
        nf=1 as=5.872e-14 ad=2.933e-14 ps=1.37e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn1_1__rcx (\23\:non \11\:A \3\:VSS VSS) g45n1svt w=(1.7e-07) l=4.5e-08 \
        nf=1 as=8.005e-14 ad=2.932e-14 ps=1.47e-06 pd=6.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=12.2924 scb=0.0124108 \
        scc=0.000563444 m=(2)
mn2_2__rcx (\23\:non \2\:OEb \3\:VSS VSS) g45n1svt w=(1.75e-07) \
        l=4.5e-08 nf=1 as=7.605e-14 ad=2.8e-14 ps=1.42e-06 pd=6.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.06371e-06 sb=2e-06 sd=160n \
        sca=12.1767 scb=0.0122352 scc=0.000549928 m=(1)
mn1 (\23\:non \11\:A \3\:VSS VSS) g45n1svt w=(1.75e-07) l=4.5e-08 nf=1 \
        as=3.912e-14 ad=2.8e-14 ps=8.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26871e-06 sb=1.795e-06 sd=160n sca=12.1767 \
        scb=0.0122352 scc=0.000549928 m=(1)
mn5_1__rcx (Y non \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.064e-14 ad=4.16e-14 ps=8.3875e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03471e-06 sb=1.575e-06 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(8)
mp3 (\17\:pon \1\:A \11\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=4.29e-14 ps=1.1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.18433e-06 sd=160n sca=16.3479 \
        scb=0.0155274 scc=0.000646302 m=(3)
mp0 (\15\:OEb \10\:OE \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp2_1__rcx (\20\:non OEb 6 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1_1__rcx (6 \10\:A \27\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=1.56e-14 ps=9.8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp1 (7 \13\:A \27\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=3.38e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp2 (\17\:non \9\:OEb 7 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.38e-14 ad=5.72e-14 ps=7.8e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=2e-06 sd=160n sca=14.3604 scb=0.0136769 \
        scc=0.000743805 m=(1)
mp2_2__rcx (\17\:non \4\:OEb 8 VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.47e-14 ad=5.72e-14 ps=7.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.95e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp1_2__rcx (8 \18\:A \1\:VDD VDD) g45p1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.47e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=1.81e-06 sd=160n sca=14.3604 \
        scb=0.0136769 scc=0.000743805 m=(1)
mp5_1__rcx (Y pon \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.142e-14 ad=6.24e-14 ps=1.1025e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.23333e-07 sb=1.575e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(8)
ends TBUFX8
// End of subcircuit definition.

// Generated for: spectre (May  9 18:18:00 2012 )
// Library name: gsclib045
// Cell name: TBUFXL
// View name: extracted

simulator lang=spectre

subckt TBUFXL A OE VDD VSS Y
mp4 (\5\:pon \3\:OE \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.1e-07 sd=160n sca=23.8733 \
        scb=0.0264891 scc=0.00148688 m=(1)
C1 (OE VSS) capacitor c=2.21751e-17
C2 (VDD VSS) capacitor c=1.83274e-16
C3 (A VSS) capacitor c=1.83783e-17
C4 (pon VSS) capacitor c=4.81989e-17
C5 (OEb VSS) capacitor c=6.09083e-17
C6 (non VSS) capacitor c=4.51e-17
C7 (\4\:A VSS) capacitor c=8.07849e-17
C8 (\4\:OE VSS) capacitor c=4.84469e-17
C9 (\1\:A VSS) capacitor c=4.52507e-17
C10 (\3\:OE VSS) capacitor c=4.27761e-17
C11 (\5\:A VSS) capacitor c=5.73706e-17
C12 (\3\:OEb VSS) capacitor c=2.99281e-17
C13 (\6\:OE VSS) capacitor c=4.24077e-17
C14 (\3\:A VSS) capacitor c=6.49534e-17
C15 (\1\:OE VSS) capacitor c=4.81758e-17
C16 (\2\:pon VSS) capacitor c=2.10442e-17
C17 (\2\:non VSS) capacitor c=3.93632e-17
C18 (\6\:A VSS) capacitor c=2.60099e-17
C19 (\2\:OEb VSS) capacitor c=4.21184e-17
C20 (\5\:OE VSS) capacitor c=4.21223e-17
C21 (\2\:A VSS) capacitor c=6.842e-17
C22 (\2\:OE VSS) capacitor c=5.57436e-17
C23 (\1\:Y VSS) capacitor c=3.3163e-17
C24 (\4\:VDD VSS) capacitor c=1.44547e-17
C25 (\5\:non VSS) capacitor c=6.09964e-17
C26 (\6\:OEb VSS) capacitor c=8.11757e-17
C27 (\8\:VDD VSS) capacitor c=2.45544e-17
C28 (\5\:pon VSS) capacitor c=1.83303e-16
C29 (\10\:VDD VSS) capacitor c=3.12829e-17
C30 (\1\:VDD VSS) capacitor c=6.64436e-17
C31 (\3\:Y VSS) capacitor c=4.53216e-17
C32 (\7\:non VSS) capacitor c=3.91588e-17
C33 (\8\:OEb VSS) capacitor c=5.9066e-17
C34 (\3\:pon VSS) capacitor c=7.41275e-17
C35 (\7\:OE VSS) capacitor c=5.25198e-17
C36 (\9\:OE VSS) capacitor c=5.57451e-17
C37 (\4\:OEb VSS) capacitor c=3.06825e-17
C38 (\5\:OEb VSS) capacitor c=8.79497e-17
C39 (\7\:A VSS) capacitor c=1.59773e-16
C40 (\8\:A VSS) capacitor c=1.86942e-16
C41 (\3\:non VSS) capacitor c=3.16368e-17
C42 (\4\:non VSS) capacitor c=3.98131e-17
C43 (\7\:pon VSS) capacitor c=1.20834e-16
C44 (\7\:VDD VSS) capacitor c=1.09833e-17
Rk3 (\8\:OE OE) resistor r=0.05673 c=0
Rk1 (\7\:OE \8\:OE) resistor r=0.1998 c=0
Rk2 (\8\:OE \9\:OE) resistor r=0.037 c=0
Rk14 (Y \2\:Y) resistor r=0.002901 c=0
Rk15 (\2\:Y \4\:Y) resistor r=0.3392 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.1504 c=0
Rk25 (\3\:VDD \5\:VDD) resistor r=0.1198 c=0
Rk26 (\3\:VDD \6\:VDD) resistor r=0.4016 c=0
Rk29 (\7\:VDD VDD) resistor r=0.2195 c=0
Rk27 (\6\:VDD \7\:VDD) resistor r=0.07907 c=0
Rk28 (\7\:VDD \9\:VDD) resistor r=0.04328 c=0
Rk30 (VDD \11\:VDD) resistor r=0.239 c=0
Rk8 (\8\:A A) resistor r=0.02018 c=0
Rk7 (\7\:A \8\:A) resistor r=1.3617 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.1276 c=0
Rk17 (\3\:VSS \4\:VSS) resistor r=0.2493 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.1217 c=0
Rk20 (\6\:VSS VSS) resistor r=0.1976 c=0
Rk19 (\5\:VSS \6\:VSS) resistor r=0.1527 c=0
Rk21 (\3\:VSS \8\:VSS) resistor r=0.3496 c=0
Rk22 (\4\:VSS \10\:VSS) resistor r=0.04328 c=0
Rk23 (\6\:VSS \12\:VSS) resistor r=0.2832 c=0
Rk12 (\4\:pon \6\:pon) resistor r=0.671 c=0
Rk13 (\6\:pon \7\:pon) resistor r=1.0729 c=0
Rk4 (\4\:OEb \5\:OEb) resistor r=0.09647 c=0
Rk5 (\5\:OEb \7\:OEb) resistor r=0.5589 c=0
Rk6 (\5\:OEb \9\:OEb) resistor r=0.2473 c=0
Rk9 (\3\:non \4\:non) resistor r=0.1183 c=0
Rk10 (\4\:non \6\:non) resistor r=0.3397 c=0
Rk11 (\4\:non \8\:non) resistor r=0.1145 c=0
Rl5 (\4\:OE \5\:OE) resistor r=131.02 c=0
Rl6 (\5\:OE \6\:OE) resistor r=76.1559 c=0
Rl2 (\2\:OE \3\:OE) resistor r=135.714 c=0
Rl1 (\1\:OE \2\:OE) resistor r=75 c=0
Rl9 (\4\:A \5\:A) resistor r=129.43 c=0
Rl10 (\5\:A \6\:A) resistor r=35.3072 c=0
Rl3 (\1\:A \2\:A) resistor r=60.7713 c=0
Rl4 (\2\:A \3\:A) resistor r=155.323 c=0
Rl12 (pon \2\:pon) resistor r=71.8456 c=0
Rl7 (OEb \2\:OEb) resistor r=93.7849 c=0
Rl8 (\2\:OEb \3\:OEb) resistor r=24.2328 c=0
Rl11 (non \2\:non) resistor r=35.2058 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz8 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz9 (\1\:VDD \3\:VDD) resistor r=75 c=0
Rz10 (\1\:VDD \6\:VDD) resistor r=10.7143 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz3 (\3\:pon \4\:pon) resistor r=75 c=0
Rz1 (\8\:OEb \9\:OEb) resistor r=75 c=0
Rz2 (\7\:non \8\:non) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry8 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \5\:VSS) resistor r=7.75 c=0
Ry3 (\5\:pon \6\:pon) resistor r=62 c=0
Ry1 (\6\:OEb \7\:OEb) resistor r=62 c=0
Ry2 (\5\:non \6\:non) resistor r=62 c=0
Rx1 (\5\:OE \7\:OE) resistor r=45 c=0
Rx2 (\2\:OE \9\:OE) resistor r=45 c=0
Rx4 (\6\:A \7\:A) resistor r=45 c=0
Rx5 (\2\:A \8\:A) resistor r=45 c=0
Rx7 (\2\:pon \7\:pon) resistor r=45 c=0
Rx3 (\2\:OEb \4\:OEb) resistor r=45 c=0
Rx6 (\2\:non \3\:non) resistor r=45 c=0
mn4 (\3\:pon \1\:OE net144 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=6.25e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (net144 \3\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.358e-14 ad=8.7e-15 ps=9.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=5.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn0 (\8\:OEb \6\:OE \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.358e-14 ad=3.19e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn2 (\7\:non \3\:OEb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.025e-14 ad=2.32e-14 ps=1.39e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.65e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn1 (\7\:non \5\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.6e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn5 (\3\:Y non \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.4e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mp3 (\5\:pon \1\:A \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.44e-14 ps=1.32e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.05e-07 sd=160n sca=13.8395 \
        scb=0.0118164 scc=0.000122256 m=(1)
mp0 (\6\:OEb \4\:OE \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.4e-07 sd=160n sca=11.1189 \
        scb=0.00792127 scc=8.08408e-05 m=(1)
mp2 (\5\:non OEb net127 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=28.9946 \
        scb=0.0243497 scc=0.00347661 m=(1)
mp1 (net127 \4\:A \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.043e-13 ad=1.29e-14 ps=1.82e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=29.4689 \
        scb=0.0246948 scc=0.00347702 m=(1)
mp5 (\1\:Y pon \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.043e-13 ad=3.01e-14 ps=1.82e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=32.5034 \
        scb=0.0292389 scc=0.00353613 m=(1)
ends TBUFXL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:18:38 2012 )
// Library name: gsclib045
// Cell name: TIEHI
// View name: extracted

simulator lang=spectre

subckt TIEHI VDD VSS Y
mp0 (\1\:Y net25 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=8.53177e-17
C2 (VDD VSS) capacitor c=2.92602e-17
C3 (net25 VSS) capacitor c=2.83574e-17
C4 (\3\:net25 VSS) capacitor c=2.0101e-17
C5 (\2\:net25 VSS) capacitor c=1.68248e-17
C6 (\1\:VDD VSS) capacitor c=5.5492e-17
C7 (\5\:net25 VSS) capacitor c=3.20906e-17
C8 (\4\:net25 VSS) capacitor c=2.69902e-17
C9 (\4\:VDD VSS) capacitor c=1.59733e-18
Rk6 (\4\:VSS VSS) resistor r=0.09927 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.3126 c=0
Rk1 (Y \2\:Y) resistor r=0.02976 c=0
Rk4 (\4\:VDD VDD) resistor r=0.09927 c=0
Rk3 (\2\:VDD \4\:VDD) resistor r=0.4506 c=0
Rk2 (\4\:net25 \6\:net25) resistor r=0.1853 c=0
Rl1 (net25 \2\:net25) resistor r=48.7687 c=0
Rl2 (\2\:net25 \3\:net25) resistor r=29.5379 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\5\:net25 \6\:net25) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Rx1 (\2\:net25 \4\:net25) resistor r=45 c=0
mn0 (\5\:net25 \3\:net25 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
ends TIEHI
// End of subcircuit definition.

// Generated for: spectre (May  9 18:19:17 2012 )
// Library name: gsclib045
// Cell name: TIELO
// View name: extracted

simulator lang=spectre

subckt TIELO VDD VSS Y
mp0 (\4\:net25 net25 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=47.9961 \
        scb=0.0439169 scc=0.00481722 m=(1)
C1 (Y VSS) capacitor c=8.65384e-17
C2 (VDD VSS) capacitor c=2.88647e-17
C3 (net25 VSS) capacitor c=2.2686e-17
C4 (\3\:net25 VSS) capacitor c=1.97466e-17
C5 (\2\:net25 VSS) capacitor c=1.67661e-17
C6 (\1\:VDD VSS) capacitor c=5.00331e-17
C7 (\4\:net25 VSS) capacitor c=4.28686e-17
C8 (\6\:net25 VSS) capacitor c=2.8388e-17
C9 (\4\:VDD VSS) capacitor c=1.83731e-18
Rk7 (\4\:VSS VSS) resistor r=0.09943 c=0
Rk6 (\2\:VSS \4\:VSS) resistor r=0.3495 c=0
Rk1 (\2\:Y Y) resistor r=0.00298 c=0
Rk5 (\4\:VDD VDD) resistor r=0.09943 c=0
Rk3 (\2\:VDD \4\:VDD) resistor r=0.3452 c=0
Rk4 (\2\:VDD \5\:VDD) resistor r=0.1606 c=0
Rk2 (\5\:net25 \6\:net25) resistor r=0.1727 c=0
Rl1 (net25 \2\:net25) resistor r=24.2328 c=0
Rl2 (\2\:net25 \3\:net25) resistor r=39.6174 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\1\:VDD \5\:VDD) resistor r=62 c=0
Ry1 (\4\:net25 \5\:net25) resistor r=20.6667 c=0
Rx1 (\2\:net25 \6\:net25) resistor r=45 c=0
mn0 (\1\:Y \3\:net25 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
ends TIELO
// End of subcircuit definition.

// Generated for: spectre (May  9 18:19:58 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX12
// View name: extracted

simulator lang=spectre

subckt TLATNCAX12 CK E ECK VDD VSS
mp0 (\9\:CKb \1\:CK \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.262e-14 ad=3.44e-14 ps=1.68e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=57.0065 scb=0.0445545 \
        scc=0.00681945 m=(1)
C1 (CK VSS) capacitor c=5.39857e-17
C2 (ECK VSS) capacitor c=1.39531e-17
C3 (VDD VSS) capacitor c=3.1445e-16
C4 (E VSS) capacitor c=6.18482e-17
C5 (CKb VSS) capacitor c=4.03673e-17
C6 (ECKb VSS) capacitor c=4.97621e-16
C7 (CKbb VSS) capacitor c=6.71698e-17
C8 (13 VSS) capacitor c=2.21455e-18
C9 (Eint VSS) capacitor c=5.27839e-16
C10 (14 VSS) capacitor c=3.80903e-18
C11 (15 VSS) capacitor c=3.98847e-19
C12 (n0 VSS) capacitor c=5.21112e-17
C13 (net254 VSS) capacitor c=5.09891e-18
C14 (net205 VSS) capacitor c=2.74045e-18
C15 (net217 VSS) capacitor c=2.41405e-18
C16 (\1\:E VSS) capacitor c=3.8891e-17
C17 (\12\:CKbb VSS) capacitor c=4.19564e-17
C18 (\5\:CKb VSS) capacitor c=5.7952e-17
C19 (\7\:Eint VSS) capacitor c=3.74176e-17
C20 (\1\:CK VSS) capacitor c=3.6288e-17
C21 (\3\:n0 VSS) capacitor c=4.46606e-17
C22 (\3\:E VSS) capacitor c=4.16136e-17
C23 (\4\:CKb VSS) capacitor c=5.76812e-17
C24 (\10\:CKbb VSS) capacitor c=6.37675e-17
C25 (\10\:Eint VSS) capacitor c=4.28321e-17
C26 (\12\:Eint VSS) capacitor c=1.93572e-17
C27 (\8\:CKbb VSS) capacitor c=2.46262e-17
C28 (\7\:CKbb VSS) capacitor c=4.47842e-17
C29 (\5\:Eint VSS) capacitor c=3.04048e-17
C30 (\4\:Eint VSS) capacitor c=5.17835e-17
C31 (\2\:CKb VSS) capacitor c=4.89949e-17
C32 (\3\:CK VSS) capacitor c=2.37096e-17
C33 (\2\:n0 VSS) capacitor c=3.17108e-17
C34 (\2\:E VSS) capacitor c=4.14701e-17
C35 (\13\:CKbb VSS) capacitor c=3.91386e-17
C36 (\6\:CKb VSS) capacitor c=2.68664e-17
C37 (\11\:CKbb VSS) capacitor c=6.47205e-17
C38 (\2\:CKbb VSS) capacitor c=4.74376e-16
C39 (\3\:CKb VSS) capacitor c=2.97697e-17
C40 (\2\:CK VSS) capacitor c=2.31433e-17
C41 (\13\:Eint VSS) capacitor c=6.89928e-17
C42 (\1\:VDD VSS) capacitor c=4.02915e-17
C43 (\4\:n0 VSS) capacitor c=5.56049e-17
C44 (\31\:ECKb VSS) capacitor c=3.63696e-16
C45 (\19\:CKbb VSS) capacitor c=2.81608e-17
C46 (\1\:ECK VSS) capacitor c=2.5545e-16
C47 (\9\:CKb VSS) capacitor c=2.50987e-16
C48 (\3\:VDD VSS) capacitor c=3.21914e-16
C49 (\15\:Eint VSS) capacitor c=1.85693e-16
C50 (\7\:n0 VSS) capacitor c=5.81707e-17
C51 (\41\:ECKb VSS) capacitor c=8.61359e-17
C52 (\38\:ECKb VSS) capacitor c=1.37883e-16
C53 (\21\:CKbb VSS) capacitor c=7.02067e-17
C54 (\11\:CKb VSS) capacitor c=4.26522e-17
C55 (\8\:Eint VSS) capacitor c=3.67966e-17
C56 (\4\:CK VSS) capacitor c=2.77378e-17
C57 (\9\:ECK VSS) capacitor c=3.09621e-16
C58 (\37\:ECKb VSS) capacitor c=1.52368e-16
C59 (\40\:ECKb VSS) capacitor c=3.64928e-17
C60 (\7\:CKb VSS) capacitor c=1.86386e-16
C61 (\8\:CKb VSS) capacitor c=4.55765e-16
C62 (\14\:CKbb VSS) capacitor c=4.36049e-17
C63 (\15\:CKbb VSS) capacitor c=8.20966e-17
C64 (\18\:CKbb VSS) capacitor c=3.60326e-17
C65 (\4\:E VSS) capacitor c=5.27559e-17
C66 (\6\:n0 VSS) capacitor c=1.03125e-16
C67 (\9\:n0 VSS) capacitor c=5.98023e-17
C68 (\5\:VDD VSS) capacitor c=1.67458e-16
Rk1 (CK \4\:CK) resistor r=0.08922 c=0
Rk5 (\1\:ECK ECK) resistor r=0.04211 c=0
Rk6 (ECK \9\:ECK) resistor r=0.2193 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.3369 c=0
Rk65 (\5\:VDD \3\:VDD) resistor r=0.08478 c=0
Rk60 (\4\:VDD \5\:VDD) resistor r=0.3459 c=0
Rk76 (\20\:VDD VDD) resistor r=0.04991 c=0
Rk30 (\4\:E E) resistor r=0.109 c=0
Rk37 (\2\:VSS \3\:VSS) resistor r=0.05247 c=0
Rk38 (\3\:VSS \4\:VSS) resistor r=0.5212 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=0.1277 c=0
Rk40 (\5\:VSS \6\:VSS) resistor r=0.3459 c=0
Rk41 (\6\:VSS \7\:VSS) resistor r=0.4134 c=0
Rk49 (\14\:VSS VSS) resistor r=0.04991 c=0
Rk48 (\7\:VSS \14\:VSS) resistor r=0.1177 c=0
Rk50 (\3\:VSS \16\:VSS) resistor r=0.2445 c=0
Rk51 (\4\:VSS \18\:VSS) resistor r=0.2959 c=0
Rk52 (\6\:VSS \20\:VSS) resistor r=0.2831 c=0
Rk21 (\7\:CKb \8\:CKb) resistor r=1.5284 c=0
Rk22 (\8\:CKb \10\:CKb) resistor r=2.1189 c=0
Rk23 (\10\:CKb \12\:CKb) resistor r=0.3349 c=0
Rk17 (\31\:ECKb \37\:ECKb) resistor r=0.7589 c=0
Rk18 (\37\:ECKb \39\:ECKb) resistor r=0.7269 c=0
Rk19 (\37\:ECKb \40\:ECKb) resistor r=0.2317 c=0
Rk20 (\39\:ECKb \42\:ECKb) resistor r=0.5671 c=0
Rk25 (\15\:CKbb \2\:CKbb) resistor r=0.6456 c=0
Rk24 (\14\:CKbb \15\:CKbb) resistor r=0.1664 c=0
Rk27 (\2\:CKbb \18\:CKbb) resistor r=0.1521 c=0
Rk28 (\18\:CKbb \20\:CKbb) resistor r=0.06532 c=0
Rk29 (\18\:CKbb \22\:CKbb) resistor r=0.2883 c=0
Rk35 (\16\:Eint Eint) resistor r=1.3075 c=0
Rk34 (\14\:Eint \16\:Eint) resistor r=0.5017 c=0
Rk31 (\5\:n0 \6\:n0) resistor r=0.3739 c=0
Rk32 (\6\:n0 \8\:n0) resistor r=0.3835 c=0
Rk33 (\6\:n0 \9\:n0) resistor r=0.2604 c=0
Rl1 (\1\:CK \2\:CK) resistor r=74.2328 c=0
Rl2 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl55 (\1\:E \2\:E) resistor r=29.5379 c=0
Rl56 (\2\:E \3\:E) resistor r=117.999 c=0
Rl52 (\4\:CKb \5\:CKb) resistor r=172.643 c=0
Rl32 (CKb \2\:CKb) resistor r=126.923 c=0
Rl53 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl33 (CKb \3\:CKb) resistor r=61.0982 c=0
Rl54 (\13\:CKbb \12\:CKbb) resistor r=57.6695 c=0
Rl51 (\11\:CKbb \10\:CKbb) resistor r=98.7687 c=0
Rl34 (\2\:CKbb CKbb) resistor r=126.477 c=0
Rl44 (\2\:CKbb \8\:CKbb) resistor r=86.22 c=0
Rl43 (\2\:CKbb \7\:CKbb) resistor r=119.208 c=0
Rl50 (Eint \12\:Eint) resistor r=53.0285 c=0
Rl39 (Eint \5\:Eint) resistor r=28.6412 c=0
Rl38 (Eint \4\:Eint) resistor r=58.8489 c=0
Rl47 (\8\:Eint Eint) resistor r=68.9123 c=0
Rl46 (\8\:Eint \7\:Eint) resistor r=89.6181 c=0
Rl48 (\8\:Eint \10\:Eint) resistor r=80.0028 c=0
Rl57 (n0 \2\:n0) resistor r=102.615 c=0
Rl58 (\2\:n0 \3\:n0) resistor r=44.9225 c=0
Rz21 (\4\:VDD \3\:VDD) resistor r=12.5 c=0
Rz27 (\20\:VDD \3\:VDD) resistor r=0.1023 c=0
Rz12 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz14 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz8 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz6 (\39\:ECKb \38\:ECKb) resistor r=75 c=0
Rz7 (\42\:ECKb \41\:ECKb) resistor r=75 c=0
Rz9 (\22\:CKbb \21\:CKbb) resistor r=75 c=0
Rz11 (\16\:Eint \15\:Eint) resistor r=75 c=0
Rz10 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\14\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry10 (\20\:CKbb \19\:CKbb) resistor r=62 c=0
Ry12 (\14\:Eint \13\:Eint) resistor r=20.6667 c=0
Ry11 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx9 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\6\:CKb \7\:CKb) resistor r=45 c=0
Rx4 (\3\:CKb \8\:CKb) resistor r=45 c=0
Rx2 (\40\:ECKb ECKb) resistor r=45 c=0
Rx5 (\14\:CKbb \13\:CKbb) resistor r=45 c=0
Rx6 (\15\:CKbb \11\:CKbb) resistor r=45 c=0
Rx10 (\2\:n0 \9\:n0) resistor r=45 c=0
mn0 (\11\:CKb \3\:CK \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.152e-14 ad=2.392e-14 ps=1.15e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=2e-06 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn22 (\9\:ECK ECKb \7\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.96e-14 ps=9.67e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.96694e-07 sb=1.99202e-06 sd=160n sca=9.82009 \
        scb=0.00857019 scc=0.000324687 m=(10)
mn1 (\21\:CKbb \2\:CKb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.065e-14 ad=3.262e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.25e-07 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn21_1__rcx (\38\:ECKb CKbb 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.61923e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20_1__rcx (13 \4\:Eint \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.29e-14 ad=1.56e-14 ps=8.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.57279e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (14 \5\:Eint \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=2.99e-14 ps=8.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.4799e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21 (\41\:ECKb \7\:CKbb 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.35337e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21_2__rcx (\41\:ECKb \8\:CKbb 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.67e-14 ad=4.16e-14 ps=1.11e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.14837e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20_2__rcx (15 \12\:Eint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.922e-14 ad=7.67e-14 ps=1.01e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=8.08365e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn15 (net230 \10\:Eint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.922e-14 ad=8.7e-15 ps=1.01e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=1.065e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn16 (\7\:n0 \10\:CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=9.6e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn6 (\7\:n0 \4\:CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.857e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=7.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn5 (net254 \3\:E \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.857e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.75e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn10 (\15\:Eint \3\:n0 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.17731e-06 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mp22_1__rcx (\1\:ECK ECKb \3\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 \
        nf=1 as=7.755e-14 ad=7.52e-14 ps=1.348e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.81915e-07 sb=1.97016e-06 sd=160n sca=28.8268 \
        scb=0.0193852 scc=0.00280057 m=(10)
mp1 (\19\:CKbb CKb \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.125e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp21_1__rcx (\31\:ECKb \2\:CKbb \5\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.88e-14 ad=6.24e-14 ps=1.30667e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.10769e-07 sb=1.66122e-06 sd=160n \
        sca=12.2138 scb=0.0106342 scc=0.00038358 m=(3)
mp20 (\31\:ECKb Eint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.957e-14 ad=6.24e-14 ps=1.47333e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15769e-07 sb=1.56923e-06 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(3)
mp15 (net205 \7\:Eint \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.27e-14 ad=4.73e-14 ps=1.74e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=1.095e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp16 (\4\:n0 \5\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.3e-14 ps=8.7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=8.3e-07 sd=160n sca=14.0993 \
        scb=0.0134558 scc=0.000640581 m=(1)
mp6 (\4\:n0 \12\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.85e-07 sd=160n sca=14.9963 scb=0.0139879 \
        scc=0.000641097 m=(1)
mp5 (net217 \1\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.902e-14 ps=1.16e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=16.5968 scb=0.0160997 \
        scc=0.000654774 m=(1)
mp10 (\13\:Eint n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.63e-14 ps=1.16e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16538e-06 sb=1.7e-07 sd=160n sca=23.0147 \
        scb=0.0263355 scc=0.00124475 m=(1)
ends TLATNCAX12
// End of subcircuit definition.

// Generated for: spectre (May  9 18:20:37 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX16
// View name: extracted

simulator lang=spectre

subckt TLATNCAX16 CK E ECK VDD VSS
mp0 (\11\:CKb \3\:CK \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.305e-14 ad=3.01e-14 ps=1.27e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.1157 scb=0.029461 \
        scc=0.0022003 m=(1)
C1 (CK VSS) capacitor c=4.07365e-17
C2 (ECK VSS) capacitor c=6.41729e-16
C3 (VDD VSS) capacitor c=3.60539e-16
C4 (CKb VSS) capacitor c=3.64896e-17
C5 (ECKb VSS) capacitor c=6.54045e-16
C6 (Eint VSS) capacitor c=7.35744e-17
C7 (CKbb VSS) capacitor c=6.57009e-16
C8 (14 VSS) capacitor c=4.59195e-18
C9 (15 VSS) capacitor c=4.49552e-18
C10 (n0 VSS) capacitor c=1.77271e-16
C11 (net230 VSS) capacitor c=4.19908e-18
C12 (net254 VSS) capacitor c=5.22978e-18
C13 (net205 VSS) capacitor c=2.66516e-18
C14 (net217 VSS) capacitor c=6.20531e-18
C15 (\7\:CKb VSS) capacitor c=3.25207e-17
C16 (\1\:E VSS) capacitor c=3.32175e-17
C17 (\13\:CKbb VSS) capacitor c=5.21902e-17
C18 (\2\:CKb VSS) capacitor c=3.74952e-17
C19 (\13\:Eint VSS) capacitor c=5.37912e-17
C20 (\3\:CK VSS) capacitor c=3.96591e-17
C21 (\5\:CKb VSS) capacitor c=2.63942e-17
C22 (\3\:E VSS) capacitor c=3.94522e-17
C23 (\3\:CKb VSS) capacitor c=4.85666e-17
C24 (\14\:CKbb VSS) capacitor c=2.77701e-17
C25 (\15\:Eint VSS) capacitor c=3.12322e-17
C26 (\12\:Eint VSS) capacitor c=6.95611e-17
C27 (\10\:CKbb VSS) capacitor c=4.45323e-17
C28 (\11\:CKbb VSS) capacitor c=2.32918e-17
C29 (\8\:Eint VSS) capacitor c=3.58221e-17
C30 (\7\:Eint VSS) capacitor c=3.62272e-17
C31 (\5\:CKbb VSS) capacitor c=2.50682e-17
C32 (\4\:CKbb VSS) capacitor c=4.64406e-17
C33 (\1\:CK VSS) capacitor c=2.65087e-17
C34 (\6\:CKb VSS) capacitor c=3.29911e-17
C35 (\2\:E VSS) capacitor c=4.22321e-17
C36 (\4\:CKb VSS) capacitor c=2.6832e-17
C37 (\15\:CKbb VSS) capacitor c=2.07149e-17
C38 (\14\:Eint VSS) capacitor c=3.22219e-17
C39 (\2\:Eint VSS) capacitor c=7.15334e-16
C40 (\2\:CK VSS) capacitor c=3.09717e-17
C41 (\22\:CKbb VSS) capacitor c=4.52076e-17
C42 (\9\:VDD VSS) capacitor c=3.26382e-17
C43 (\12\:n0 VSS) capacitor c=6.37483e-17
C44 (\16\:Eint VSS) capacitor c=3.11799e-17
C45 (\56\:ECKb VSS) capacitor c=4.35768e-16
C46 (\11\:CKb VSS) capacitor c=6.71513e-16
C47 (\1\:VDD VSS) capacitor c=6.47797e-16
C48 (\20\:CKbb VSS) capacitor c=1.26144e-16
C49 (\8\:n0 VSS) capacitor c=7.87592e-17
C50 (\23\:Eint VSS) capacitor c=3.04795e-17
C51 (\68\:ECKb VSS) capacitor c=1.09508e-16
C52 (\65\:ECKb VSS) capacitor c=1.19104e-16
C53 (\13\:CKb VSS) capacitor c=4.04284e-17
C54 (\4\:CK VSS) capacitor c=6.83894e-17
C55 (\64\:ECKb VSS) capacitor c=6.4514e-17
C56 (\67\:ECKb VSS) capacitor c=3.45084e-17
C57 (\18\:Eint VSS) capacitor c=3.78147e-17
C58 (\22\:Eint VSS) capacitor c=3.47177e-17
C59 (\25\:Eint VSS) capacitor c=5.49422e-17
C60 (\10\:n0 VSS) capacitor c=8.72834e-17
C61 (\11\:n0 VSS) capacitor c=5.8455e-17
C62 (\4\:E VSS) capacitor c=4.49281e-17
C63 (\6\:E VSS) capacitor c=5.12448e-17
C64 (\8\:CKb VSS) capacitor c=1.00093e-16
C65 (\9\:CKb VSS) capacitor c=8.0877e-17
C66 (\10\:CKb VSS) capacitor c=5.91767e-16
C67 (\15\:CKb VSS) capacitor c=4.59814e-17
C68 (\19\:CKbb VSS) capacitor c=2.04348e-16
Rk1 (\4\:CK CK) resistor r=0.1076 c=0
Rk73 (\2\:VDD \3\:VDD) resistor r=0.1026 c=0
Rk75 (\4\:VDD \1\:VDD) resistor r=0.3007 c=0
Rk74 (\3\:VDD \4\:VDD) resistor r=0.2981 c=0
Rk79 (\3\:VDD \10\:VDD) resistor r=0.3397 c=0
Rk109 (\52\:VDD VDD) resistor r=0.04988 c=0
Rk33 (\4\:E \5\:E) resistor r=0.00188 c=0
Rk34 (E \6\:E) resistor r=0.001786 c=0
Rk35 (\4\:E \6\:E) resistor r=0.06016 c=0
Rk65 (\3\:VSS VSS) resistor r=0.1951 c=0
Rk46 (\2\:VSS \4\:VSS) resistor r=0.301 c=0
Rk47 (\4\:VSS \5\:VSS) resistor r=0.4014 c=0
Rk49 (\5\:VSS \7\:VSS) resistor r=0.08001 c=0
Rk50 (\7\:VSS \8\:VSS) resistor r=0.3407 c=0
Rk51 (\8\:VSS \9\:VSS) resistor r=0.2104 c=0
Rk56 (\8\:VSS \17\:VSS) resistor r=0.2054 c=0
Rk36 (\8\:CKb \9\:CKb) resistor r=0.6063 c=0
Rk37 (\9\:CKb \10\:CKb) resistor r=0.1379 c=0
Rk38 (\10\:CKb \12\:CKb) resistor r=4.9485 c=0
Rk39 (\12\:CKb \14\:CKb) resistor r=0.3164 c=0
Rk40 (\10\:CKb \15\:CKb) resistor r=0.2442 c=0
Rk19 (\56\:ECKb \64\:ECKb) resistor r=0.3419 c=0
Rk20 (\64\:ECKb \66\:ECKb) resistor r=0.4673 c=0
Rk21 (\64\:ECKb \67\:ECKb) resistor r=0.1264 c=0
Rk22 (\66\:ECKb \69\:ECKb) resistor r=0.7007 c=0
Rk24 (\18\:Eint \2\:Eint) resistor r=0.2342 c=0
Rk23 (\17\:Eint \18\:Eint) resistor r=0.1161 c=0
Rk27 (\18\:Eint \22\:Eint) resistor r=0.1613 c=0
Rk28 (\22\:Eint \24\:Eint) resistor r=0.09357 c=0
Rk29 (\22\:Eint \25\:Eint) resistor r=0.2657 c=0
Rk43 (CKbb \19\:CKbb) resistor r=1.4213 c=0
Rk44 (\19\:CKbb \21\:CKbb) resistor r=0.7402 c=0
Rk45 (\21\:CKbb \23\:CKbb) resistor r=0.3798 c=0
Rk30 (\9\:n0 \10\:n0) resistor r=0.5107 c=0
Rk31 (\10\:n0 \11\:n0) resistor r=0.2657 c=0
Rk32 (\10\:n0 \13\:n0) resistor r=0.2281 c=0
Rl2 (\2\:CK \3\:CK) resistor r=74.3312 c=0
Rl1 (\1\:CK \2\:CK) resistor r=24.7951 c=0
Rl88 (\1\:E \2\:E) resistor r=94.9225 c=0
Rl89 (\2\:E \3\:E) resistor r=29.5379 c=0
Rl84 (CKb \2\:CKb) resistor r=57.6695 c=0
Rl91 (\6\:CKb \7\:CKb) resistor r=80.5643 c=0
Rl90 (\5\:CKb \6\:CKb) resistor r=39.6664 c=0
Rl87 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl82 (\14\:Eint \13\:Eint) resistor r=97.3098 c=0
Rl83 (\14\:Eint \15\:Eint) resistor r=24.2328 c=0
Rl57 (\2\:Eint Eint) resistor r=74.2328 c=0
Rl75 (\2\:Eint \12\:Eint) resistor r=98.4922 c=0
Rl67 (\2\:Eint \8\:Eint) resistor r=72.3105 c=0
Rl66 (\2\:Eint \7\:Eint) resistor r=71.8867 c=0
Rl85 (\14\:CKbb \13\:CKbb) resistor r=150 c=0
Rl71 (CKbb \10\:CKbb) resistor r=28.0797 c=0
Rl72 (CKbb \11\:CKbb) resistor r=24.2328 c=0
Rl62 (CKbb \5\:CKbb) resistor r=22.5951 c=0
Rl61 (CKbb \4\:CKbb) resistor r=28.0797 c=0
Rl86 (\15\:CKbb \14\:CKbb) resistor r=26.1559 c=0
Rz26 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz35 (\52\:VDD \1\:VDD) resistor r=0.1023 c=0
Rz14 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz12 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz8 (\66\:ECKb \65\:ECKb) resistor r=75 c=0
Rz9 (\69\:ECKb \68\:ECKb) resistor r=75 c=0
Rz10 (\24\:Eint \23\:Eint) resistor r=75 c=0
Rz13 (\21\:CKbb \20\:CKbb) resistor r=75 c=0
Rz11 (\9\:n0 \8\:n0) resistor r=75 c=0
Ry22 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry16 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry17 (\5\:VSS \3\:VSS) resistor r=62 c=0
Ry18 (\7\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry19 (\9\:VSS \3\:VSS) resistor r=0.2051 c=0
Ry14 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry12 (\17\:Eint \16\:Eint) resistor r=62 c=0
Ry15 (\23\:CKbb \22\:CKbb) resistor r=62 c=0
Ry13 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:E \5\:E) resistor r=45 c=0
Rx9 (\6\:CKb \8\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \9\:CKb) resistor r=45 c=0
Rx11 (CKb \15\:CKb) resistor r=45 c=0
Rx2 (\67\:ECKb ECKb) resistor r=45 c=0
Rx6 (\25\:Eint \14\:Eint) resistor r=45 c=0
Rx14 (\19\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\11\:n0 n0) resistor r=45 c=0
mn0 (\13\:CKb \1\:CK \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.218e-14 ad=2.465e-14 ps=1.02e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22_1__rcx (ECK ECKb \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.843e-14 ad=4.825e-14 ps=9.2571e-07 pd=9.1714e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.82542e-07 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(14)
mn20_1__rcx (13 Eint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.94e-14 ad=1.56e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.90587e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_1__rcx (\65\:ECKb \4\:CKbb 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.88365e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_2__rcx (\65\:ECKb \5\:CKbb 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78721e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_2__rcx (14 \7\:Eint \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.68e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.69654e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20 (15 \8\:Eint \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.68e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.57933e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21 (\68\:ECKb \11\:CKbb 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.72e-14 ps=8.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.48865e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_3__rcx (\68\:ECKb \10\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37144e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_3__rcx (16 \12\:Eint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.408e-14 ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.325e-06 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn10 (\23\:Eint n0 \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.913e-14 ad=3.895e-14 ps=1.355e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.42902e-06 sd=160n sca=15.5643 \
        scb=0.0161016 scc=0.00117276 m=(2)
mn15 (net230 \15\:Eint \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.418e-14 ad=5.365e-14 ps=1.64e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.275e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn1 (\20\:CKbb \5\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=2.175e-14 ps=1.37e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.5e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn16 (\8\:n0 \14\:CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=3.553e-14 ps=1.03e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn6 (\8\:n0 \3\:CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=3.553e-14 ps=5.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.7e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn5 (net254 \3\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=1.595e-14 ps=1.37e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.15e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.223e-14 ad=7.12e-14 ps=1.21929e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.53539e-07 sb=2e-06 sd=160n sca=16.9974 \
        scb=0.0149208 scc=0.00098088 m=(14)
mp20_1__rcx (\56\:ECKb \2\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=8.805e-14 ad=6.24e-14 ps=1.4325e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=1.94154e-06 sd=160n \
        sca=15.8351 scb=0.0142471 scc=0.00110276 m=(4)
mp21_1__rcx (\56\:ECKb CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.24e-14 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.89365e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(4)
mp10_1__rcx (\16\:Eint n0 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.136e-14 ad=4.96e-14 ps=1.675e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.3554e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp15 (net205 \13\:Eint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.907e-14 ad=2.687e-14 ps=1.56e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.245e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp16 (\12\:n0 \2\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.3e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.075e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp6 (\12\:n0 \13\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=4.3e-14 ps=1.23e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.3e-07 sd=160n sca=16.4857 scb=0.0163525 \
        scc=0.00112485 m=(1)
mp5 (net217 \1\:E \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=8.6e-14 ps=8.3e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.85e-07 sd=160n sca=18.6197 scb=0.0182692 \
        scc=0.00113172 m=(1)
mp1 (\22\:CKbb \7\:CKb \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=25.1716 scb=0.0291739 \
        scc=0.0016465 m=(1)
ends TLATNCAX16
// End of subcircuit definition.

// Generated for: spectre (May  9 18:21:19 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX2
// View name: extracted

simulator lang=spectre

subckt TLATNCAX2 CK E ECK VDD VSS
mp0 (\9\:CKb \4\:CK \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.025e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.88023e-07 sd=160n sca=50.7282 \
        scb=0.0349898 scc=0.00599471 m=(1)
C1 (CK VSS) capacitor c=4.1274e-17
C2 (VDD VSS) capacitor c=1.9209e-16
C3 (E VSS) capacitor c=2.98714e-17
C4 (ECK VSS) capacitor c=2.75898e-17
C5 (CKb VSS) capacitor c=4.31166e-17
C6 (ECKb VSS) capacitor c=1.45284e-16
C7 (CKbb VSS) capacitor c=4.17392e-17
C8 (Eint VSS) capacitor c=4.74747e-17
C9 (n0 VSS) capacitor c=2.92147e-17
C10 (net254 VSS) capacitor c=4.88086e-18
C11 (net205 VSS) capacitor c=2.13272e-18
C12 (net217 VSS) capacitor c=2.16579e-18
C13 (\1\:E VSS) capacitor c=3.70296e-17
C14 (\6\:CKbb VSS) capacitor c=4.34966e-17
C15 (\5\:CKb VSS) capacitor c=5.63508e-17
C16 (\7\:Eint VSS) capacitor c=3.66724e-17
C17 (\4\:CK VSS) capacitor c=2.10918e-17
C18 (\3\:n0 VSS) capacitor c=2.68352e-17
C19 (\3\:E VSS) capacitor c=3.76975e-17
C20 (\4\:CKb VSS) capacitor c=7.26074e-17
C21 (\4\:CKbb VSS) capacitor c=5.72527e-17
C22 (\5\:Eint VSS) capacitor c=1.47193e-17
C23 (\4\:Eint VSS) capacitor c=4.11711e-17
C24 (\3\:CKbb VSS) capacitor c=4.96214e-17
C25 (\2\:CKb VSS) capacitor c=4.41158e-17
C26 (\3\:CK VSS) capacitor c=2.86334e-17
C27 (\2\:n0 VSS) capacitor c=2.74832e-17
C28 (\2\:E VSS) capacitor c=3.45953e-17
C29 (\7\:CKbb VSS) capacitor c=4.48922e-17
C30 (\6\:CKb VSS) capacitor c=3.02443e-17
C31 (\5\:CKbb VSS) capacitor c=4.95793e-17
C32 (\6\:Eint VSS) capacitor c=2.68281e-17
C33 (\2\:CKbb VSS) capacitor c=2.85135e-17
C34 (\3\:CKb VSS) capacitor c=2.50903e-17
C35 (\6\:ECKb VSS) capacitor c=1.6435e-17
C36 (\1\:CK VSS) capacitor c=1.99124e-17
C37 (\8\:Eint VSS) capacitor c=4.38854e-17
C38 (\1\:VDD VSS) capacitor c=3.20303e-17
C39 (\8\:n0 VSS) capacitor c=6.51911e-17
C40 (\11\:VDD VSS) capacitor c=1.23461e-17
C41 (\9\:ECKb VSS) capacitor c=1.16192e-16
C42 (\13\:VDD VSS) capacitor c=1.12389e-17
C43 (\15\:CKbb VSS) capacitor c=2.96076e-17
C44 (\3\:ECK VSS) capacitor c=5.31531e-17
C45 (\9\:CKb VSS) capacitor c=1.0259e-16
C46 (\3\:VDD VSS) capacitor c=6.14486e-17
C47 (\10\:Eint VSS) capacitor c=1.64373e-16
C48 (\6\:n0 VSS) capacitor c=4.51016e-17
C49 (\13\:ECKb VSS) capacitor c=7.20863e-17
C50 (\12\:CKbb VSS) capacitor c=4.9782e-17
C51 (\1\:ECK VSS) capacitor c=2.32546e-17
C52 (\11\:CKb VSS) capacitor c=4.67723e-17
C53 (\2\:CK VSS) capacitor c=1.37218e-17
C54 (\2\:Eint VSS) capacitor c=2.88729e-17
C55 (\3\:Eint VSS) capacitor c=3.04049e-17
C56 (\5\:CK VSS) capacitor c=8.30572e-17
C57 (\11\:ECKb VSS) capacitor c=1.59213e-16
C58 (\12\:ECKb VSS) capacitor c=2.27651e-17
C59 (\7\:CKb VSS) capacitor c=8.8633e-17
C60 (\8\:CKb VSS) capacitor c=1.79637e-16
C61 (\8\:CKbb VSS) capacitor c=1.01947e-17
C62 (\9\:CKbb VSS) capacitor c=3.92977e-17
C63 (\10\:CKbb VSS) capacitor c=4.85273e-17
C64 (\11\:CKbb VSS) capacitor c=3.68537e-17
C65 (\14\:CKbb VSS) capacitor c=4.10865e-17
C66 (\4\:E VSS) capacitor c=8.41155e-17
C67 (\4\:n0 VSS) capacitor c=8.74103e-17
C68 (\5\:n0 VSS) capacitor c=1.18057e-16
C69 (\12\:Eint VSS) capacitor c=1.10025e-16
C70 (\5\:VDD VSS) capacitor c=1.51012e-17
C71 (\7\:VDD VSS) capacitor c=6.65944e-18
C72 (\8\:VDD VSS) capacitor c=7.07711e-17
Rk1 (CK \5\:CK) resistor r=0.05279 c=0
Rk34 (\2\:VSS \3\:VSS) resistor r=0.07311 c=0
Rk39 (\5\:VSS VSS) resistor r=0.1922 c=0
Rk35 (\3\:VSS \5\:VSS) resistor r=0.4277 c=0
Rk36 (\3\:VSS \6\:VSS) resistor r=0.3727 c=0
Rk37 (\6\:VSS \8\:VSS) resistor r=0.2471 c=0
Rk22 (\2\:VDD \4\:VDD) resistor r=0.4144 c=0
Rk23 (\4\:VDD \5\:VDD) resistor r=0.3226 c=0
Rk24 (\5\:VDD \6\:VDD) resistor r=0.1274 c=0
Rk25 (\6\:VDD \7\:VDD) resistor r=0.1074 c=0
Rk29 (\8\:VDD VDD) resistor r=0.1922 c=0
Rk26 (\7\:VDD \8\:VDD) resistor r=0.2298 c=0
Rk30 (\5\:VDD \12\:VDD) resistor r=0.07311 c=0
Rk31 (\7\:VDD \14\:VDD) resistor r=0.07311 c=0
Rk16 (E \4\:E) resistor r=0.01106 c=0
Rk2 (ECK \2\:ECK) resistor r=0.05081 c=0
Rk3 (ECK \4\:ECK) resistor r=0.1755 c=0
Rk7 (\7\:CKb \8\:CKb) resistor r=0.7929 c=0
Rk8 (\8\:CKb \10\:CKb) resistor r=0.7437 c=0
Rk9 (\10\:CKb \12\:CKb) resistor r=0.3427 c=0
Rk4 (\10\:ECKb \11\:ECKb) resistor r=0.6808 c=0
Rk5 (\11\:ECKb \12\:ECKb) resistor r=0.08039 c=0
Rk6 (\11\:ECKb \14\:ECKb) resistor r=0.6701 c=0
Rk10 (\8\:CKbb \9\:CKbb) resistor r=0.03407 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.3995 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.1499 c=0
Rk13 (\11\:CKbb \13\:CKbb) resistor r=0.2318 c=0
Rk14 (\9\:CKbb \14\:CKbb) resistor r=0.1827 c=0
Rk15 (\11\:CKbb \16\:CKbb) resistor r=0.03518 c=0
Rk20 (\9\:Eint \11\:Eint) resistor r=0.4393 c=0
Rk21 (\11\:Eint \12\:Eint) resistor r=0.9619 c=0
Rk17 (\4\:n0 \5\:n0) resistor r=0.5133 c=0
Rk18 (\5\:n0 \7\:n0) resistor r=0.1353 c=0
Rk19 (\5\:n0 \9\:n0) resistor r=0.4787 c=0
Rl3 (\2\:CK \4\:CK) resistor r=57.4064 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.3295 c=0
Rl1 (\1\:CK \2\:CK) resistor r=1.2713 c=0
Rl25 (\1\:E \2\:E) resistor r=56.9251 c=0
Rl26 (\2\:E \3\:E) resistor r=70.3867 c=0
Rl22 (\4\:CKb \5\:CKb) resistor r=188.027 c=0
Rl11 (CKb \2\:CKb) resistor r=100 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl12 (CKb \3\:CKb) resistor r=50.6918 c=0
Rl8 (ECKb \6\:ECKb) resistor r=9.0449 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=57.6695 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=50.6918 c=0
Rl13 (CKbb \2\:CKbb) resistor r=50.6918 c=0
Rl14 (\2\:CKbb \3\:CKbb) resistor r=79.5379 c=0
Rl19 (\5\:Eint \6\:Eint) resistor r=35.7713 c=0
Rl15 (Eint \2\:Eint) resistor r=129.568 c=0
Rl18 (\2\:Eint \5\:Eint) resistor r=35.772 c=0
Rl20 (\3\:Eint \7\:Eint) resistor r=111.22 c=0
Rl17 (\3\:Eint \4\:Eint) resistor r=65.3625 c=0
Rl16 (\2\:Eint \3\:Eint) resistor r=62.3766 c=0
Rl27 (n0 \2\:n0) resistor r=100.692 c=0
Rl28 (\2\:n0 \3\:n0) resistor r=29.5379 c=0
Rz10 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz11 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz8 (\6\:VDD \3\:VDD) resistor r=37.5 c=0
Rz9 (\8\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz1 (\2\:ECK \1\:ECK) resistor r=75 c=0
Rz3 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz2 (\14\:ECKb \13\:ECKb) resistor r=75 c=0
Rz4 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz6 (\10\:Eint \11\:Eint) resistor r=75 c=0
Rz5 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry12 (\5\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry13 (\6\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry7 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry8 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry1 (\4\:ECK \3\:ECK) resistor r=62 c=0
Ry3 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry2 (\10\:ECKb \9\:ECKb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry6 (\8\:Eint \9\:Eint) resistor r=62 c=0
Ry5 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx8 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\6\:CKb \7\:CKb) resistor r=45 c=0
Rx4 (\3\:CKb \8\:CKb) resistor r=45 c=0
Rx2 (\12\:ECKb \6\:ECKb) resistor r=45 c=0
Rx5 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx6 (\2\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\7\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\6\:Eint \12\:Eint) resistor r=45 c=0
Rx9 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (\11\:CKb \3\:CK \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn22 (\1\:ECK ECKb \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=4.16e-14 ps=9.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=5.23462e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mn1 (\12\:CKbb \2\:CKb \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=2.393e-14 ps=1.02e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.65e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\13\:ECKb \3\:CKbb net238 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.62e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn20 (net238 \4\:Eint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.64e-14 ad=8.7e-15 ps=1.63e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.515e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn15 (net230 \5\:Eint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.64e-14 ad=1.958e-14 ps=1.63e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.23e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn16 (\6\:n0 \4\:CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.755e-14 ps=5.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.05e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn6 (\6\:n0 \4\:CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.755e-14 ps=7.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=8.15e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn5 (net254 \3\:E \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.48e-14 ps=1.51e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=5.3e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn10 (\10\:Eint \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.97e-14 ad=3.263e-14 ps=1.51e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=2.25e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mp22 (\3\:ECK ECKb \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.698e-14 ad=6.24e-14 ps=1.61e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=4.80321e-07 sd=160n sca=31.7249 \
        scb=0.0209416 scc=0.00336188 m=(2)
mp1 (\15\:CKbb CKb \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.37e-14 ad=3.29e-14 ps=1.78e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.53023e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\9\:ECKb CKbb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.765e-14 ad=3.44e-14 ps=1.48e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.535e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp20 (\9\:ECKb \7\:Eint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.99e-14 ad=3.44e-14 ps=1.58e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.33e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp15 (net205 Eint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=3.44e-14 ps=1.58e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.065e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp16 (\8\:n0 \5\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.3e-14 ps=7.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=8.6e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp6 (\8\:n0 \6\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.688e-14 ad=4.3e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=6.15e-07 sd=160n sca=13.9337 \
        scb=0.0128784 scc=0.000544065 m=(1)
mp5 (net217 \1\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.688e-14 ps=9.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=4.45e-07 sd=160n sca=14.806 \
        scb=0.0136191 scc=0.000545447 m=(1)
mp10 (\8\:Eint n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=3.01e-14 ps=9.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=1.4e-07 sd=160n sca=20.7705 \
        scb=0.0234544 scc=0.000885185 m=(1)
ends TLATNCAX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:22:01 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX20
// View name: extracted

simulator lang=spectre

subckt TLATNCAX20 CK E ECK VDD VSS
mp0 (\15\:CKb \1\:CK \60\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32756e-06 sd=160n sca=16.9134 \
        scb=0.0172871 scc=0.000377502 m=(1)
C1 (CK VSS) capacitor c=1.29386e-16
C2 (ECK VSS) capacitor c=1.7092e-15
C3 (VDD VSS) capacitor c=3.8589e-16
C4 (E VSS) capacitor c=3.30533e-17
C5 (CKb VSS) capacitor c=5.43358e-17
C6 (n0 VSS) capacitor c=1.71068e-16
