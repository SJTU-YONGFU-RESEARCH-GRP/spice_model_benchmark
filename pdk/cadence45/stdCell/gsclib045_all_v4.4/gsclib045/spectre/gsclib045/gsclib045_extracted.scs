Rl43 (\6\:CKbb \7\:CKbb) resistor r=98.7985 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=85.7713 c=0
Rl37 (n20 \2\:n20) resistor r=76.1559 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=49.131 c=0
Rz7 (\1\:Q \2\:Q) resistor r=75 c=0
Rz2 (\3\:QN \4\:QN) resistor r=75 c=0
Rz23 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz24 (\4\:VDD \8\:VDD) resistor r=7.5 c=0
Rz25 (\4\:VDD \11\:VDD) resistor r=9.375 c=0
Rz26 (\4\:VDD \13\:VDD) resistor r=12.5 c=0
Rz16 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz20 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz21 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz22 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz4 (Db \2\:Db) resistor r=75 c=0
Rz5 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:net502 \10\:net502) resistor r=75 c=0
Rz8 (\15\:net536 \16\:net536) resistor r=75 c=0
Rz6 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz12 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz13 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz9 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz15 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz10 (\7\:mout \8\:mout) resistor r=75 c=0
Rz14 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz11 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry7 (\3\:Q \4\:Q) resistor r=62 c=0
Ry2 (\1\:QN \2\:QN) resistor r=62 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry24 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry25 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry26 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry27 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry28 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry18 (\1\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry19 (\1\:VSS \10\:VSS) resistor r=12.4 c=0
Ry20 (\1\:VSS \12\:VSS) resistor r=12.4 c=0
Ry21 (\1\:VSS \14\:VSS) resistor r=31 c=0
Ry1 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry4 (\3\:Db \4\:Db) resistor r=62 c=0
Ry5 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\7\:net502 \8\:net502) resistor r=62 c=0
Ry8 (\13\:net536 \14\:net536) resistor r=62 c=0
Ry6 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry12 (Dbp \2\:Dbp) resistor r=62 c=0
Ry13 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry15 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry10 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx3 (\7\:E \8\:E) resistor r=45 c=0
Rx4 (\2\:E \10\:E) resistor r=45 c=0
Rx5 (\5\:E \11\:E) resistor r=45 c=0
Rx23 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \5\:D) resistor r=45 c=0
Rx10 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\4\:SE \8\:SE) resistor r=45 c=0
Rx2 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx6 (\2\:net502 \11\:net502) resistor r=45 c=0
Rx11 (\9\:net536 \11\:net536) resistor r=45 c=0
Rx12 (\6\:net536 \17\:net536) resistor r=45 c=0
Rx13 (\2\:net536 \18\:net536) resistor r=45 c=0
Rx8 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx9 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx14 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx22 (CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:mout \9\:mout) resistor r=45 c=0
Rx17 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx18 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx19 (CKbb \15\:CKbb) resistor r=45 c=0
Rx16 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\6\:Eb \3\:E \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.435e-14 ad=2.175e-14 ps=1.05e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.42e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn3 (net554 \3\:D \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.435e-14 ad=1.305e-14 ps=1.05e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.025e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn4 (\7\:Db \4\:E net554 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.537e-14 ps=4.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=8.9e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (\7\:Db \3\:Eb net514 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.537e-14 ps=5.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=6.7e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn1 (net514 \4\:net502 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.69e-14 ad=1.957e-14 ps=1.48e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=4.9e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn57 (\3\:QN \5\:net502 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.69e-14 ad=3.262e-14 ps=1.48e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=2.25e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn56 (\9\:net502 \3\:net536 \21\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.2e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\7\:SEb \7\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (Db SEb \7\:Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.9e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn55 (\1\:Q \5\:net536 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn13 (\7\:Dbp \1\:SE net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.537e-14 ps=6.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6.7e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn12 (net546 \3\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=2.392e-14 ps=8.4e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.6e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\15\:net536 \3\:n30 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.455e-14 ad=3.407e-14 ps=1.42e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.955e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn50 (net534 \7\:net536 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.455e-14 ad=2.972e-14 ps=1.42e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.64e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn51 (\4\:n30 \3\:CKb net534 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=2.32e-14 ps=7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.39e-06 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn25 (\3\:Dbp \8\:CKb \4\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.712e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.185e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\7\:mout n20 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=4.713e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=8.15e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (net526 mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=2.32e-14 ps=1.32e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=5.5e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn36 (\4\:n20 \7\:CKbb net526 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=3.45e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn21 (\10\:CKbb \6\:CKb \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\16\:CKb \3\:CK \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp3 (net473 \1\:D \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.665e-14 ps=7.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11e-06 sd=160n sca=13.0329 \
        scb=0.0112451 scc=0.000332435 m=(1)
mp4 (\5\:Db Eb net473 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=5.805e-14 ps=1.05e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=7.55e-07 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp2 (\5\:Db \6\:E net425 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.805e-14 ps=5.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=4.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (net425 \6\:net502 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.69e-14 ad=1.29e-14 ps=1.52e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=3.35e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp57 (\1\:QN net502 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.69e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp56 (\7\:net502 net536 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.073e-13 ad=5.375e-14 ps=1.87e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=4.05e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp10 (\10\:SEb \6\:SE \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.073e-13 ad=3.01e-14 ps=1.87e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.4e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp11 (\5\:Dbp \5\:SE \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.945e-14 ps=7.1e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp13 (\5\:Dbp \3\:SEb net465 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.945e-14 ps=5.9e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=6.3e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp12 (net465 \1\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0352e-13 ad=1.72e-14 ps=1.72e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=5.05e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp55 (\3\:Q \4\:net536 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0352e-13 ad=3.977e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.85e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp45 (\13\:net536 n30 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.955e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp51 (\8\:n30 \2\:CKbb net457 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=5.267e-14 ps=6.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.58e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp50 (net457 \10\:net536 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=2.687e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp36 (\8\:n20 \4\:CKb net437 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.595e-06 sb=5e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp40 (\8\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=5.267e-14 ps=1.18e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.29e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp30 (\4\:mout \3\:n20 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=8.062e-14 ps=1.78e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=8.7e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp35 (net437 \3\:mout \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=1.29e-14 ps=1.78e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=6.05e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp25 (\8\:n20 \5\:CKbb Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=4.085e-14 ps=9.6e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=2.65e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp21 (\8\:CKbb \9\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.79e-14 ad=3.01e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=16.6557 \
        scb=0.0159745 scc=0.000820274 m=(1)
mp20 (\10\:CKb \1\:CK \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=3.01e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=22.504 \
        scb=0.0257568 scc=0.00118856 m=(1)
ends SEDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:58:50 2012 )
// Library name: gsclib045
// Cell name: SMDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX1 CK D0 D1 Q S0 SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=5.46e-14 ps=1.23e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1641e-07 sd=160n sca=31.1408 \
        scb=0.033664 scc=0.00281778 m=(1)
C1 (CK VSS) capacitor c=5.87746e-17
C2 (SE VSS) capacitor c=7.41799e-17
C3 (S0 VSS) capacitor c=8.14694e-17
C4 (VDD VSS) capacitor c=3.48457e-16
C5 (D1 VSS) capacitor c=1.13558e-16
C6 (SI VSS) capacitor c=5.09961e-17
C7 (qbint VSS) capacitor c=2.23837e-17
C8 (CKb VSS) capacitor c=4.75555e-17
C9 (n30 VSS) capacitor c=5.95721e-17
C10 (net482 VSS) capacitor c=2.77605e-18
C11 (mout VSS) capacitor c=6.32353e-17
C12 (CKbb VSS) capacitor c=2.32095e-17
C13 (n20 VSS) capacitor c=4.00842e-17
C14 (net474 VSS) capacitor c=6.70793e-19
C15 (dbp VSS) capacitor c=8.83437e-17
C16 (db VSS) capacitor c=1.2329e-16
C17 (SEb VSS) capacitor c=5.465e-17
C18 (net498 VSS) capacitor c=6.50309e-18
C19 (S0b VSS) capacitor c=3.37641e-17
C20 (net409 VSS) capacitor c=8.55417e-18
C21 (net393 VSS) capacitor c=5.52914e-18
C22 (net417 VSS) capacitor c=1.63895e-18
C23 (net425 VSS) capacitor c=1.71352e-18
C24 (net429 VSS) capacitor c=7.45545e-18
C25 (\8\:S0 VSS) capacitor c=5.11484e-17
C26 (\1\:D1 VSS) capacitor c=5.4452e-17
C27 (\2\:S0 VSS) capacitor c=7.19524e-17
C28 (\4\:D0 VSS) capacitor c=9.91275e-17
C29 (\5\:SE VSS) capacitor c=4.69272e-17
C30 (\6\:SE VSS) capacitor c=3.10549e-17
C31 (\2\:SEb VSS) capacitor c=7.19029e-17
C32 (\4\:SI VSS) capacitor c=8.84955e-17
C33 (\10\:CKb VSS) capacitor c=6.04767e-17
C34 (\7\:CKbb VSS) capacitor c=3.8399e-17
C35 (\8\:CKb VSS) capacitor c=4.10628e-17
C36 (\3\:CKb VSS) capacitor c=2.41128e-17
C37 (\3\:CKbb VSS) capacitor c=6.30365e-17
C38 (\5\:qbint VSS) capacitor c=6.59385e-17
C39 (\1\:CK VSS) capacitor c=3.14641e-17
C40 (\4\:qbint VSS) capacitor c=4.62528e-17
C41 (\7\:S0 VSS) capacitor c=3.20994e-17
C42 (\3\:D1 VSS) capacitor c=8.61553e-17
C43 (\3\:S0 VSS) capacitor c=7.01826e-17
C44 (\3\:S0b VSS) capacitor c=5.96283e-17
C45 (\1\:D0 VSS) capacitor c=5.19141e-17
C46 (\1\:SE VSS) capacitor c=4.11301e-17
C47 (\3\:SEb VSS) capacitor c=3.63631e-17
C48 (\4\:SE VSS) capacitor c=8.60542e-17
C49 (\1\:SI VSS) capacitor c=6.92409e-17
C50 (\5\:CKb VSS) capacitor c=4.24117e-17
C51 (\11\:CKb VSS) capacitor c=2.39876e-17
C52 (\5\:CKbb VSS) capacitor c=5.47618e-17
C53 (\4\:mout VSS) capacitor c=5.37689e-17
C54 (\3\:n20 VSS) capacitor c=4.76843e-17
C55 (\7\:qbint VSS) capacitor c=5.94346e-17
C56 (\3\:n30 VSS) capacitor c=2.61592e-17
C57 (\3\:CK VSS) capacitor c=4.1959e-17
C58 (\3\:qbint VSS) capacitor c=2.88702e-17
C59 (\5\:S0 VSS) capacitor c=1.13952e-17
C60 (\2\:D1 VSS) capacitor c=5.11155e-17
C61 (\4\:S0 VSS) capacitor c=4.60586e-17
C62 (\2\:S0b VSS) capacitor c=6.73264e-17
C63 (\1\:S0 VSS) capacitor c=5.10016e-17
C64 (\3\:D0 VSS) capacitor c=2.50262e-17
C65 (\2\:SE VSS) capacitor c=7.48136e-17
C66 (\4\:SEb VSS) capacitor c=4.31889e-17
C67 (\3\:SI VSS) capacitor c=3.51743e-17
C68 (\8\:CKbb VSS) capacitor c=3.2217e-17
C69 (\9\:CKb VSS) capacitor c=2.63047e-17
C70 (\6\:CKbb VSS) capacitor c=3.75114e-17
C71 (\3\:mout VSS) capacitor c=1.80499e-17
C72 (\2\:n20 VSS) capacitor c=3.66802e-17
C73 (\4\:CKbb VSS) capacitor c=2.00831e-17
C74 (\4\:CKb VSS) capacitor c=2.82414e-17
C75 (\2\:CKb VSS) capacitor c=5.46647e-17
C76 (\6\:qbint VSS) capacitor c=5.14529e-17
C77 (\2\:n30 VSS) capacitor c=4.13809e-17
C78 (\2\:CK VSS) capacitor c=2.76284e-17
C79 (\6\:S0b VSS) capacitor c=1.06825e-16
C80 (\1\:VDD VSS) capacitor c=2.76633e-17
C81 (\7\:db VSS) capacitor c=4.92237e-17
C82 (\7\:VDD VSS) capacitor c=3.71435e-17
C83 (\10\:SEb VSS) capacitor c=1.08147e-16
C84 (\5\:db VSS) capacitor c=3.6971e-17
C85 (\8\:dbp VSS) capacitor c=6.28834e-17
C86 (\9\:VDD VSS) capacitor c=4.64307e-17
C87 (\15\:CKbb VSS) capacitor c=7.4057e-17
C88 (\4\:dbp VSS) capacitor c=1.00166e-16
C89 (\4\:n20 VSS) capacitor c=6.76997e-17
C90 (\12\:VDD VSS) capacitor c=3.8505e-17
C91 (\9\:mout VSS) capacitor c=5.97167e-17
C92 (\8\:n30 VSS) capacitor c=9.75189e-17
C93 (\15\:VDD VSS) capacitor c=3.38922e-17
C94 (\12\:qbint VSS) capacitor c=4.37976e-17
C95 (\15\:CKb VSS) capacitor c=9.04277e-17
C96 (\18\:VDD VSS) capacitor c=3.90277e-17
C97 (\1\:Q VSS) capacitor c=5.70981e-17
C98 (\3\:VDD VSS) capacitor c=1.31694e-16
C99 (\4\:S0b VSS) capacitor c=8.09533e-17
C100 (\5\:SEb VSS) capacitor c=8.68251e-17
C101 (\9\:db VSS) capacitor c=9.92922e-17
C102 (\9\:CKbb VSS) capacitor c=6.25247e-17
C103 (\6\:dbp VSS) capacitor c=8.08116e-17
C104 (\8\:n20 VSS) capacitor c=6.74373e-17
C105 (\7\:mout VSS) capacitor c=5.01514e-17
C106 (\4\:n30 VSS) capacitor c=1.82363e-17
C107 (\10\:qbint VSS) capacitor c=8.39932e-17
C108 (\17\:CKb VSS) capacitor c=5.77918e-17
C109 (\3\:Q VSS) capacitor c=5.38358e-17
C110 (\2\:qbint VSS) capacitor c=1.57723e-17
C111 (\2\:CKbb VSS) capacitor c=4.97966e-17
C112 (\2\:mout VSS) capacitor c=3.88433e-17
C113 (\6\:CKb VSS) capacitor c=5.77453e-17
C114 (\7\:CKb VSS) capacitor c=4.9735e-17
C115 (\2\:SI VSS) capacitor c=3.48786e-17
C116 (\3\:SE VSS) capacitor c=6.97749e-17
C117 (\2\:D0 VSS) capacitor c=4.17349e-17
C118 (\4\:CK VSS) capacitor c=5.68172e-17
C119 (\6\:S0 VSS) capacitor c=3.20686e-17
C120 (\8\:qbint VSS) capacitor c=4.17948e-17
C121 (\9\:qbint VSS) capacitor c=3.92349e-17
C122 (\14\:qbint VSS) capacitor c=1.41147e-16
C123 (\6\:n30 VSS) capacitor c=6.63702e-17
C124 (\7\:n30 VSS) capacitor c=7.40964e-17
C125 (\5\:mout VSS) capacitor c=4.57293e-17
C126 (\6\:mout VSS) capacitor c=5.69995e-17
C127 (\12\:CKb VSS) capacitor c=4.96415e-17
C128 (\13\:CKb VSS) capacitor c=1.00149e-16
C129 (\14\:CKb VSS) capacitor c=1.22318e-16
C130 (\19\:CKb VSS) capacitor c=1.02712e-16
C131 (\20\:CKb VSS) capacitor c=7.29268e-17
C132 (\6\:n20 VSS) capacitor c=8.12907e-17
C133 (\7\:n20 VSS) capacitor c=6.32649e-17
C134 (\11\:CKbb VSS) capacitor c=9.15746e-17
C135 (\12\:CKbb VSS) capacitor c=1.20927e-16
C136 (\13\:CKbb VSS) capacitor c=1.16405e-16
C137 (\14\:CKbb VSS) capacitor c=1.12994e-16
C138 (\17\:CKbb VSS) capacitor c=5.85194e-17
C139 (\5\:SI VSS) capacitor c=7.49351e-17
C140 (\3\:dbp VSS) capacitor c=9.86874e-17
C141 (\8\:SE VSS) capacitor c=6.41168e-17
C142 (\7\:SEb VSS) capacitor c=7.82486e-17
C143 (\8\:SEb VSS) capacitor c=9.61054e-17
C144 (\9\:SEb VSS) capacitor c=3.78388e-17
C145 (\5\:D0 VSS) capacitor c=1.31296e-16
C146 (\3\:db VSS) capacitor c=1.29071e-16
C147 (\4\:db VSS) capacitor c=1.15801e-16
C148 (\9\:S0 VSS) capacitor c=7.53431e-17
C149 (\11\:S0 VSS) capacitor c=5.38436e-17
C150 (\8\:S0b VSS) capacitor c=7.30018e-17
C151 (\5\:VDD VSS) capacitor c=5.16921e-17
C152 (\11\:VDD VSS) capacitor c=4.51469e-17
C153 (\17\:VDD VSS) capacitor c=1.4461e-17
Rk3 (\4\:CK CK) resistor r=0.1973 c=0
Rk1 (\2\:Q Q) resistor r=0.3602 c=0
Rk2 (Q \4\:Q) resistor r=0.05967 c=0
Rk41 (\5\:D0 D0) resistor r=0.003002 c=0
Rk65 (\2\:VSS \4\:VSS) resistor r=0.3522 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.3183 c=0
Rk67 (\5\:VSS \6\:VSS) resistor r=0.2832 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.2506 c=0
Rk69 (\7\:VSS \8\:VSS) resistor r=0.6531 c=0
Rk70 (\5\:VSS \10\:VSS) resistor r=0.1976 c=0
Rk71 (\7\:VSS \12\:VSS) resistor r=0.2759 c=0
Rk72 (\8\:VSS \13\:VSS) resistor r=0.6217 c=0
Rk73 (\13\:VSS \14\:VSS) resistor r=0.2807 c=0
Rk75 (\15\:VSS VSS) resistor r=0.1099 c=0
Rk74 (\14\:VSS \15\:VSS) resistor r=0.1402 c=0
Rk76 (\8\:VSS \17\:VSS) resistor r=0.07147 c=0
Rk77 (\13\:VSS \19\:VSS) resistor r=0.2263 c=0
Rk78 (\15\:VSS \21\:VSS) resistor r=0.2937 c=0
Rk36 (SE \8\:SE) resistor r=0.01201 c=0
Rk48 (\9\:S0 S0) resistor r=0.3968 c=0
Rk49 (S0 \10\:S0) resistor r=0.002702 c=0
Rk50 (\10\:S0 \11\:S0) resistor r=0.3244 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.2504 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.3359 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.5666 c=0
Rk56 (\5\:VDD \8\:VDD) resistor r=0.1786 c=0
Rk57 (\6\:VDD \10\:VDD) resistor r=0.2807 c=0
Rk58 (\6\:VDD \11\:VDD) resistor r=0.5822 c=0
Rk59 (\11\:VDD \13\:VDD) resistor r=0.2196 c=0
Rk60 (\11\:VDD \14\:VDD) resistor r=0.6224 c=0
Rk61 (\14\:VDD \16\:VDD) resistor r=0.266 c=0
Rk64 (\17\:VDD VDD) resistor r=0.1099 c=0
Rk62 (\14\:VDD \17\:VDD) resistor r=0.4412 c=0
Rk63 (\17\:VDD \19\:VDD) resistor r=0.2722 c=0
Rk47 (\4\:D1 D1) resistor r=0.01279 c=0
Rk29 (\5\:SI SI) resistor r=0.01802 c=0
Rk4 (\8\:qbint \9\:qbint) resistor r=0.2116 c=0
Rk5 (\9\:qbint \11\:qbint) resistor r=0.3019 c=0
Rk6 (\9\:qbint \13\:qbint) resistor r=0.1908 c=0
Rk7 (\11\:qbint \14\:qbint) resistor r=0.7181 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.23 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.3637 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.6823 c=0
Rk17 (\16\:CKb \18\:CKb) resistor r=0.274 c=0
Rk18 (\13\:CKb \19\:CKb) resistor r=0.7408 c=0
Rk19 (\14\:CKb \20\:CKb) resistor r=0.3578 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.06093 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.4162 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.3957 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.2421 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.179 c=0
Rk13 (\6\:mout \10\:mout) resistor r=0.2857 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3701 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2845 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.8729 c=0
Rk26 (\11\:CKbb \14\:CKbb) resistor r=0.3758 c=0
Rk27 (\14\:CKbb \16\:CKbb) resistor r=0.4989 c=0
Rk28 (\12\:CKbb \17\:CKbb) resistor r=0.2347 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2239 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.398 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.2833 c=0
Rk30 (\2\:dbp \3\:dbp) resistor r=0.5918 c=0
Rk31 (\3\:dbp \5\:dbp) resistor r=0.3814 c=0
Rk32 (\5\:dbp \7\:dbp) resistor r=0.4327 c=0
Rk33 (\3\:dbp \9\:dbp) resistor r=0.2187 c=0
Rk42 (\2\:db \3\:db) resistor r=0.8279 c=0
Rk43 (\3\:db \4\:db) resistor r=0.4113 c=0
Rk44 (\4\:db \6\:db) resistor r=0.04027 c=0
Rk45 (\3\:db \8\:db) resistor r=0.1979 c=0
Rk46 (\4\:db \10\:db) resistor r=0.4808 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.5643 c=0
Rk38 (\7\:SEb \8\:SEb) resistor r=0.1767 c=0
Rk39 (\8\:SEb \9\:SEb) resistor r=0.1437 c=0
Rk40 (\8\:SEb \11\:SEb) resistor r=0.6361 c=0
Rk51 (\5\:S0b \7\:S0b) resistor r=0.6607 c=0
Rk52 (\7\:S0b \8\:S0b) resistor r=0.5458 c=0
Rl4 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl5 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl40 (\2\:D0 \4\:D0) resistor r=76.8641 c=0
Rl38 (\1\:D0 \2\:D0) resistor r=121.734 c=0
Rl39 (\2\:D0 \3\:D0) resistor r=11.665 c=0
Rl36 (\2\:SE \5\:SE) resistor r=148.798 c=0
Rl33 (\1\:SE \2\:SE) resistor r=135.337 c=0
Rl37 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl35 (\3\:SE \4\:SE) resistor r=137.261 c=0
Rl34 (\2\:SE \3\:SE) resistor r=157.169 c=0
Rl44 (\3\:S0 \4\:S0) resistor r=43.4636 c=0
Rl41 (\1\:S0 \2\:S0) resistor r=36.4253 c=0
Rl49 (\6\:S0 \8\:S0) resistor r=143.11 c=0
Rl48 (\6\:S0 \7\:S0) resistor r=64.2642 c=0
Rl47 (\5\:S0 \6\:S0) resistor r=3.7334 c=0
Rl45 (\1\:D1 \2\:D1) resistor r=73.7687 c=0
Rl46 (\2\:D1 \3\:D1) resistor r=117.999 c=0
Rl30 (\2\:SI \4\:SI) resistor r=74.4619 c=0
Rl28 (\1\:SI \2\:SI) resistor r=59.125 c=0
Rl29 (\2\:SI \3\:SI) resistor r=15.5599 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=45.8535 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=111.334 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=68.9449 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl25 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=30.0021 c=0
Rl10 (CKb \2\:CKb) resistor r=53.079 c=0
Rl26 (\6\:CKb \10\:CKb) resistor r=207.374 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=86.5164 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=172.62 c=0
Rl27 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=163.852 c=0
Rl6 (n30 \2\:n30) resistor r=117.308 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.9451 c=0
Rl17 (mout \2\:mout) resistor r=128.56 c=0
Rl19 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl18 (\2\:mout \3\:mout) resistor r=2.7666 c=0
Rl21 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=37.6944 c=0
Rl12 (CKbb \2\:CKbb) resistor r=28.858 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=178.636 c=0
Rl14 (\2\:CKbb \4\:CKbb) resistor r=81.0483 c=0
Rl15 (n20 \2\:n20) resistor r=44.9225 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=100.692 c=0
Rl31 (SEb \2\:SEb) resistor r=34.6607 c=0
Rl32 (\3\:SEb \4\:SEb) resistor r=39.1533 c=0
Rl42 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl43 (\2\:S0b \3\:S0b) resistor r=170.02 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz18 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz19 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz20 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz21 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \6\:VDD) resistor r=6.25 c=0
Rz16 (\3\:VDD \14\:VDD) resistor r=6.25 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz5 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (dbp \2\:dbp) resistor r=75 c=0
Rz9 (\6\:dbp \7\:dbp) resistor r=75 c=0
Rz11 (db \2\:db) resistor r=75 c=0
Rz12 (\9\:db \10\:db) resistor r=75 c=0
Rz10 (\5\:SEb \6\:SEb) resistor r=75 c=0
Rz13 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry20 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry21 (\3\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry22 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry23 (\3\:VSS \14\:VSS) resistor r=10.3333 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry16 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry17 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry9 (\8\:dbp \9\:dbp) resistor r=31 c=0
Ry11 (\5\:db \6\:db) resistor r=62 c=0
Ry12 (\7\:db \8\:db) resistor r=31 c=0
Ry10 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry13 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx14 (\2\:SE \8\:SE) resistor r=45 c=0
Rx19 (\1\:S0 \9\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \10\:S0) resistor r=45 c=0
Rx21 (\5\:S0 \11\:S0) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx3 (qbint \14\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\3\:mout \5\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\4\:SEb \7\:SEb) resistor r=45 c=0
Rx16 (SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\17\:CKb \3\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\10\:qbint \3\:n30 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.485e-14 ad=3.485e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=1.1377e-13 ps=1.32e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=9.95e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn50 (net482 \7\:qbint \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.485e-14 ad=2.768e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=2e-06 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mn51 (\4\:n30 CKb net482 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.305e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.85e-06 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn40 (\7\:mout CKbb \4\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=1.1377e-13 ps=8.3e-07 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.595e-06 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn35 (net474 \4\:mout \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=1.435e-14 ps=1.32e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=7.3e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn36 (\8\:n20 \5\:CKbb net474 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=5.227e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=6.15e-07 sd=160n sca=9.34441 \
        scb=0.0079183 scc=0.000206043 m=(1)
mn25 (\6\:dbp \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=9.34441 scb=0.0079183 \
        scc=0.000206043 m=(1)
mn21 (\9\:CKbb \5\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (net490 \1\:SI \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=5.65e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41635e-07 sb=4.6e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.76635e-07 sb=2.25e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn10 (\5\:SEb \1\:SE \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (net498 \1\:D0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=8.33365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41058e-07 sb=5.63365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46058e-07 sb=3.58365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn3 (net510 \3\:D1 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51058e-07 sb=2.53365e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn0 (\4\:S0b \7\:S0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp20 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.304 scb=0.0253194 \
        scc=0.00302671 m=(1)
mp45 (\12\:qbint n30 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=19.1541 scb=0.0174883 \
        scc=0.00172295 m=(1)
mp50 (net409 \5\:qbint \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=4.34e-14 ps=1.32e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.83e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 \3\:CKbb net409 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=6.975e-14 ps=9e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.645e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:n30 \3\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=6.975e-14 ps=1.48e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.375e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\9\:mout n20 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=1.333e-13 ps=1.32e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=9e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net393 mout \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=6.045e-14 ps=1.32e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=6.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=5.89e-14 ps=1.01e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=3.95e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=19.1541 scb=0.0174883 \
        scc=0.00172295 m=(1)
mp21 (\15\:CKbb \10\:CKb \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.695e-14 ad=3.01e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.46279e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp12 (net417 \4\:SI \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.695e-14 ad=2.34e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.73654e-07 sb=5.13333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp13 (\8\:dbp \2\:SEb net417 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.78654e-07 sb=4.08333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp11 (\8\:dbp \6\:SE \5\:db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.83654e-07 sb=2.03333e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (\10\:SEb \5\:SE \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.00372e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp1 (net425 \4\:D0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=8.84551e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=7.79551e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.36e-14 ad=7.02e-14 ps=1.26e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55321e-07 sb=5.54551e-07 sd=160n sca=11.6718 \
        scb=0.0096151 scc=0.000231869 m=(1)
mp3 (net429 \1\:D1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=9.36e-14 ps=1.16e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40321e-07 sb=2.69551e-07 sd=160n sca=13.0988 \
        scb=0.0108483 scc=0.000234868 m=(1)
mp0 (\6\:S0b \8\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8814e-07 sb=1.4e-07 sd=160n sca=18.2097 \
        scb=0.0194526 scc=0.000535674 m=(1)
ends SMDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:59:29 2012 )
// Library name: gsclib045
// Cell name: SMDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX2 CK D0 D1 Q S0 SE SI VDD VSS
mp55 (\1\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.997e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.32436e-07 sd=160n sca=36.0887 \
        scb=0.0354203 scc=0.00361645 m=(2)
C1 (CK VSS) capacitor c=1.01694e-16
C2 (D0 VSS) capacitor c=6.30861e-17
C3 (Q VSS) capacitor c=3.81744e-17
C4 (SE VSS) capacitor c=7.82904e-17
C5 (S0 VSS) capacitor c=2.31154e-17
C6 (VDD VSS) capacitor c=5.07031e-16
C7 (D1 VSS) capacitor c=5.95231e-17
C8 (SI VSS) capacitor c=4.1956e-17
C9 (qbint VSS) capacitor c=1.41874e-16
C10 (CKb VSS) capacitor c=3.82923e-17
C11 (n30 VSS) capacitor c=3.54531e-17
C12 (mout VSS) capacitor c=5.80082e-17
C13 (CKbb VSS) capacitor c=1.91705e-17
C14 (n20 VSS) capacitor c=4.06078e-17
C15 (net474 VSS) capacitor c=2.84767e-19
C16 (dbp VSS) capacitor c=7.84233e-17
C17 (net490 VSS) capacitor c=3.26724e-18
C18 (db VSS) capacitor c=1.02186e-16
C19 (SEb VSS) capacitor c=3.94698e-17
C20 (net498 VSS) capacitor c=7.27148e-18
C21 (S0b VSS) capacitor c=4.12043e-17
C22 (net409 VSS) capacitor c=1.05054e-17
C23 (net393 VSS) capacitor c=5.3009e-18
C24 (net417 VSS) capacitor c=2.26823e-18
C25 (net425 VSS) capacitor c=2.11964e-18
C26 (net429 VSS) capacitor c=4.59827e-18
C27 (\7\:S0 VSS) capacitor c=5.99327e-17
C28 (\3\:D1 VSS) capacitor c=5.21668e-17
C29 (\2\:S0 VSS) capacitor c=7.10137e-17
C30 (\1\:D0 VSS) capacitor c=9.25938e-17
C31 (\1\:SE VSS) capacitor c=6.65406e-17
C32 (\6\:SE VSS) capacitor c=3.29949e-17
C33 (\2\:SEb VSS) capacitor c=8.7149e-17
C34 (\4\:SI VSS) capacitor c=8.67412e-17
C35 (\10\:CKb VSS) capacitor c=5.29328e-17
C36 (\6\:CKbb VSS) capacitor c=3.8403e-17
C37 (\8\:CKb VSS) capacitor c=4.32609e-17
C38 (\3\:mout VSS) capacitor c=5.75257e-17
C39 (\3\:CKb VSS) capacitor c=2.64413e-17
C40 (\3\:CKbb VSS) capacitor c=7.53838e-17
C41 (\8\:qbint VSS) capacitor c=4.32847e-17
C42 (\3\:n30 VSS) capacitor c=4.73835e-17
C43 (\1\:CK VSS) capacitor c=3.33541e-17
C44 (\5\:S0 VSS) capacitor c=2.29035e-17
C45 (\1\:D1 VSS) capacitor c=8.0609e-17
C46 (\3\:S0 VSS) capacitor c=6.99403e-17
C47 (\3\:S0b VSS) capacitor c=6.45831e-17
C48 (\4\:D0 VSS) capacitor c=4.57765e-17
C49 (\5\:SE VSS) capacitor c=3.81865e-17
C50 (\3\:SEb VSS) capacitor c=3.87374e-17
C51 (\4\:SE VSS) capacitor c=6.96176e-17
C52 (\1\:SI VSS) capacitor c=5.24967e-17
C53 (\5\:CKb VSS) capacitor c=2.90238e-17
C54 (\11\:CKb VSS) capacitor c=2.45159e-17
C55 (\4\:CKbb VSS) capacitor c=6.20286e-17
C56 (\3\:n20 VSS) capacitor c=4.28816e-17
C57 (\10\:qbint VSS) capacitor c=5.57184e-17
C58 (\3\:CK VSS) capacitor c=3.49373e-17
C59 (\6\:S0 VSS) capacitor c=3.90937e-17
C60 (\2\:D1 VSS) capacitor c=5.0923e-17
C61 (\4\:S0 VSS) capacitor c=4.32013e-17
C62 (\2\:S0b VSS) capacitor c=5.37273e-17
C63 (\1\:S0 VSS) capacitor c=4.60081e-17
C64 (\3\:D0 VSS) capacitor c=2.99866e-17
C65 (\2\:SE VSS) capacitor c=6.7395e-17
C66 (\4\:SEb VSS) capacitor c=4.11894e-17
C67 (\3\:SI VSS) capacitor c=2.58936e-17
C68 (\7\:CKbb VSS) capacitor c=3.44457e-17
C69 (\9\:CKb VSS) capacitor c=2.37516e-17
C70 (\5\:CKbb VSS) capacitor c=4.15257e-17
C71 (\2\:mout VSS) capacitor c=5.79472e-17
C72 (\2\:n20 VSS) capacitor c=3.32966e-17
C73 (\2\:CKbb VSS) capacitor c=4.35745e-17
C74 (\4\:CKb VSS) capacitor c=3.8661e-17
C75 (\2\:CKb VSS) capacitor c=3.78189e-17
C76 (\9\:qbint VSS) capacitor c=4.58272e-17
C77 (\2\:n30 VSS) capacitor c=2.74667e-17
C78 (\2\:CK VSS) capacitor c=2.5755e-17
C79 (\6\:S0b VSS) capacitor c=1.16339e-16
C80 (\1\:VDD VSS) capacitor c=2.92589e-17
C81 (\7\:db VSS) capacitor c=6.6103e-17
C82 (\6\:VDD VSS) capacitor c=4.55063e-17
C83 (\5\:SEb VSS) capacitor c=9.85149e-17
C84 (\5\:db VSS) capacitor c=4.45704e-17
C85 (\6\:dbp VSS) capacitor c=5.35271e-17
C86 (\10\:VDD VSS) capacitor c=4.40465e-17
C87 (\14\:CKbb VSS) capacitor c=7.65558e-17
C88 (\4\:dbp VSS) capacitor c=1.03978e-16
C89 (\4\:n20 VSS) capacitor c=6.31864e-17
C90 (\13\:VDD VSS) capacitor c=3.32071e-17
C91 (\8\:mout VSS) capacitor c=5.64266e-17
C92 (\4\:n30 VSS) capacitor c=8.74396e-17
C93 (\17\:VDD VSS) capacitor c=3.88789e-17
C94 (\12\:qbint VSS) capacitor c=7.50262e-17
C95 (\15\:CKb VSS) capacitor c=1.08722e-16
C96 (\1\:Q VSS) capacitor c=6.73073e-17
C97 (\3\:VDD VSS) capacitor c=1.80036e-16
C98 (\4\:S0b VSS) capacitor c=6.22258e-17
C99 (\10\:SEb VSS) capacitor c=7.93375e-17
C100 (\9\:db VSS) capacitor c=9.02793e-17
C101 (\8\:CKbb VSS) capacitor c=5.40425e-17
C102 (\8\:dbp VSS) capacitor c=7.496e-17
C103 (\8\:n20 VSS) capacitor c=7.09449e-17
C104 (\6\:mout VSS) capacitor c=5.09949e-17
C105 (\8\:n30 VSS) capacitor c=1.85941e-17
C106 (\14\:qbint VSS) capacitor c=8.48782e-17
C107 (\19\:CKb VSS) capacitor c=6.69654e-17
C108 (\3\:Q VSS) capacitor c=3.18342e-17
C109 (\6\:CKb VSS) capacitor c=6.42851e-17
C110 (\7\:CKb VSS) capacitor c=5.8483e-17
C111 (\2\:SI VSS) capacitor c=4.24414e-17
C112 (\3\:SE VSS) capacitor c=6.83985e-17
C113 (\2\:D0 VSS) capacitor c=3.06744e-17
C114 (\4\:CK VSS) capacitor c=3.45399e-17
C115 (\11\:qbint VSS) capacitor c=5.01503e-17
C116 (\16\:qbint VSS) capacitor c=1.27444e-16
C117 (\6\:n30 VSS) capacitor c=6.8343e-17
C118 (\7\:n30 VSS) capacitor c=8.07574e-17
C119 (\4\:mout VSS) capacitor c=6.43346e-17
C120 (\5\:mout VSS) capacitor c=5.21046e-17
C121 (\12\:CKb VSS) capacitor c=4.83274e-17
C122 (\13\:CKb VSS) capacitor c=9.98086e-17
C123 (\14\:CKb VSS) capacitor c=1.15081e-16
C124 (\17\:CKb VSS) capacitor c=1.02923e-16
C125 (\18\:CKb VSS) capacitor c=5.72123e-17
C126 (\6\:n20 VSS) capacitor c=8.06382e-17
C127 (\7\:n20 VSS) capacitor c=6.83396e-17
C128 (\10\:CKbb VSS) capacitor c=9.60947e-17
C129 (\11\:CKbb VSS) capacitor c=1.56403e-16
C130 (\12\:CKbb VSS) capacitor c=1.00254e-16
C131 (\13\:CKbb VSS) capacitor c=1.24714e-16
C132 (\16\:CKbb VSS) capacitor c=4.75257e-17
C133 (\5\:SI VSS) capacitor c=7.19247e-17
C134 (\3\:dbp VSS) capacitor c=1.02249e-16
C135 (\7\:SE VSS) capacitor c=5.33451e-17
C136 (\7\:SEb VSS) capacitor c=1.12308e-16
C137 (\8\:SEb VSS) capacitor c=2.54855e-17
C138 (\9\:SEb VSS) capacitor c=7.90605e-17
C139 (\5\:D0 VSS) capacitor c=6.75277e-17
C140 (\3\:db VSS) capacitor c=1.39876e-16
C141 (\4\:db VSS) capacitor c=9.80581e-17
C142 (\4\:D1 VSS) capacitor c=8.28198e-17
C143 (\8\:S0 VSS) capacitor c=6.82297e-17
C144 (\9\:S0 VSS) capacitor c=9.95073e-17
C145 (\10\:S0 VSS) capacitor c=3.01693e-17
C146 (\8\:S0b VSS) capacitor c=8.70015e-17
C147 (\5\:VDD VSS) capacitor c=1.85568e-17
C148 (\12\:VDD VSS) capacitor c=3.11182e-17
C149 (\16\:VDD VSS) capacitor c=7.87774e-18
Rk5 (\4\:CK CK) resistor r=0.02699 c=0
Rk40 (D0 \5\:D0) resistor r=0.1299 c=0
Rk1 (\2\:Q Q) resistor r=0.2042 c=0
Rk2 (Q \4\:Q) resistor r=0.1835 c=0
Rk35 (\7\:SE SE) resistor r=0.1256 c=0
Rk48 (\9\:S0 S0) resistor r=0.2581 c=0
Rk47 (\8\:S0 \9\:S0) resistor r=0.3297 c=0
Rk49 (S0 \10\:S0) resistor r=0.108 c=0
Rk70 (\2\:VDD \4\:VDD) resistor r=0.2961 c=0
Rk71 (\4\:VDD \5\:VDD) resistor r=0.3608 c=0
Rk72 (\5\:VDD \7\:VDD) resistor r=0.2814 c=0
Rk73 (\5\:VDD \8\:VDD) resistor r=0.03992 c=0
Rk74 (\8\:VDD \9\:VDD) resistor r=0.6524 c=0
Rk75 (\9\:VDD \11\:VDD) resistor r=0.3121 c=0
Rk76 (\9\:VDD \12\:VDD) resistor r=0.5814 c=0
Rk77 (\12\:VDD \14\:VDD) resistor r=0.159 c=0
Rk78 (\12\:VDD \15\:VDD) resistor r=0.3207 c=0
Rk79 (\15\:VDD \16\:VDD) resistor r=0.3207 c=0
Rk80 (\16\:VDD \18\:VDD) resistor r=0.2623 c=0
Rk82 (\19\:VDD VDD) resistor r=0.08504 c=0
Rk81 (\16\:VDD \19\:VDD) resistor r=0.3307 c=0
Rk46 (D1 \4\:D1) resistor r=0.01164 c=0
Rk30 (\5\:SI SI) resistor r=0.1124 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.1552 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.1953 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.2104 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.5915 c=0
Rk56 (\6\:VSS \7\:VSS) resistor r=0.03992 c=0
Rk57 (\7\:VSS \8\:VSS) resistor r=0.5787 c=0
Rk58 (\8\:VSS \9\:VSS) resistor r=0.3332 c=0
Rk59 (\9\:VSS \10\:VSS) resistor r=0.3307 c=0
Rk61 (\11\:VSS VSS) resistor r=0.1076 c=0
Rk60 (\10\:VSS \11\:VSS) resistor r=0.3708 c=0
Rk64 (\3\:VSS \16\:VSS) resistor r=0.2903 c=0
Rk65 (\5\:VSS \18\:VSS) resistor r=0.2303 c=0
Rk66 (\7\:VSS \20\:VSS) resistor r=0.3132 c=0
Rk67 (\8\:VSS \22\:VSS) resistor r=0.2823 c=0
Rk68 (\10\:VSS \24\:VSS) resistor r=0.2823 c=0
Rk6 (\11\:qbint \13\:qbint) resistor r=0.269 c=0
Rk7 (\13\:qbint \15\:qbint) resistor r=0.341 c=0
Rk8 (\15\:qbint \16\:qbint) resistor r=0.6406 c=0
Rk15 (\12\:CKb \13\:CKb) resistor r=0.2414 c=0
Rk16 (\13\:CKb \14\:CKb) resistor r=0.3417 c=0
Rk17 (\14\:CKb \16\:CKb) resistor r=0.5962 c=0
Rk18 (\13\:CKb \17\:CKb) resistor r=0.7694 c=0
Rk19 (\14\:CKb \18\:CKb) resistor r=0.2548 c=0
Rk20 (\16\:CKb \20\:CKb) resistor r=0.3125 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.3556 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.4579 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.07075 c=0
Rk12 (\4\:mout \5\:mout) resistor r=0.271 c=0
Rk13 (\5\:mout \7\:mout) resistor r=0.1609 c=0
Rk14 (\5\:mout \9\:mout) resistor r=0.2238 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.3506 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.4384 c=0
Rk26 (\11\:CKbb \12\:CKbb) resistor r=0.92 c=0
Rk27 (\10\:CKbb \13\:CKbb) resistor r=0.3918 c=0
Rk28 (\13\:CKbb \15\:CKbb) resistor r=0.526 c=0
Rk29 (\11\:CKbb \16\:CKbb) resistor r=0.1137 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.1863 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.4043 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.3034 c=0
Rk31 (\2\:dbp \3\:dbp) resistor r=0.5569 c=0
Rk32 (\3\:dbp \5\:dbp) resistor r=0.414 c=0
Rk33 (\3\:dbp \7\:dbp) resistor r=0.1803 c=0
Rk34 (\5\:dbp \9\:dbp) resistor r=0.4005 c=0
Rk41 (\2\:db \3\:db) resistor r=0.6511 c=0
Rk42 (\3\:db \4\:db) resistor r=0.4973 c=0
Rk43 (\4\:db \6\:db) resistor r=0.1165 c=0
Rk44 (\3\:db \8\:db) resistor r=0.2658 c=0
Rk45 (\4\:db \10\:db) resistor r=0.421 c=0
Rk36 (\6\:SEb \7\:SEb) resistor r=0.7613 c=0
Rk37 (\7\:SEb \8\:SEb) resistor r=0.07943 c=0
Rk38 (\7\:SEb \9\:SEb) resistor r=0.2307 c=0
Rk39 (\9\:SEb \11\:SEb) resistor r=0.5336 c=0
Rk50 (\5\:S0b \7\:S0b) resistor r=0.6332 c=0
Rk51 (\7\:S0b \8\:S0b) resistor r=0.5193 c=0
Rl7 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl8 (\2\:CK \3\:CK) resistor r=44.9225 c=0
Rl39 (\1\:D0 \2\:D0) resistor r=60.772 c=0
Rl41 (\2\:D0 \4\:D0) resistor r=105.003 c=0
Rl40 (\2\:D0 \3\:D0) resistor r=58.0656 c=0
Rl34 (\1\:SE \2\:SE) resistor r=162.26 c=0
Rl37 (\2\:SE \5\:SE) resistor r=152.645 c=0
Rl38 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl36 (\3\:SE \4\:SE) resistor r=139.184 c=0
Rl35 (\2\:SE \3\:SE) resistor r=157.169 c=0
Rl49 (\6\:S0 \7\:S0) resistor r=180.746 c=0
Rl48 (\5\:S0 \6\:S0) resistor r=34.4104 c=0
Rl45 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl42 (\1\:S0 \2\:S0) resistor r=33.3481 c=0
Rl47 (\2\:D1 \3\:D1) resistor r=26.3736 c=0
Rl46 (\1\:D1 \2\:D1) resistor r=119.231 c=0
Rl31 (\2\:SI \4\:SI) resistor r=42.0218 c=0
Rl29 (\1\:SI \2\:SI) resistor r=93.5105 c=0
Rl30 (\2\:SI \3\:SI) resistor r=2.0166 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=29.5379 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=106.461 c=0
Rl5 (qbint \6\:qbint) resistor r=8.1398 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl13 (CKb \2\:CKb) resistor r=58.8482 c=0
Rl27 (\6\:CKb \10\:CKb) resistor r=157.374 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=67.2856 c=0
Rl25 (\7\:CKb \8\:CKb) resistor r=163.005 c=0
Rl28 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=192.698 c=0
Rl9 (n30 \2\:n30) resistor r=24.7951 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=41.8301 c=0
Rl19 (mout \2\:mout) resistor r=64.6308 c=0
Rl20 (\2\:mout \3\:mout) resistor r=83.7903 c=0
Rl22 (\6\:CKbb \7\:CKbb) resistor r=35.3072 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=37.2302 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.7951 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=226.466 c=0
Rl17 (n20 \2\:n20) resistor r=24.2328 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=108.848 c=0
Rl32 (SEb \2\:SEb) resistor r=51.1187 c=0
Rl33 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl43 (S0b \2\:S0b) resistor r=25.6167 c=0
Rl44 (\2\:S0b \3\:S0b) resistor r=121.55 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz21 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz22 (\8\:VDD \3\:VDD) resistor r=75 c=0
Rz23 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\15\:VDD \3\:VDD) resistor r=12.5 c=0
Rz25 (\19\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz15 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz17 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz18 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz2 (\15\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (dbp \2\:dbp) resistor r=75 c=0
Rz9 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz11 (db \2\:db) resistor r=75 c=0
Rz12 (\9\:db \10\:db) resistor r=75 c=0
Rz10 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz13 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry19 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry20 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry21 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry22 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry23 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry15 (\4\:VSS \1\:VSS) resistor r=15.5 c=0
Ry16 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry17 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry18 (\11\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry8 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry9 (\6\:dbp \7\:dbp) resistor r=31 c=0
Ry11 (\5\:db \6\:db) resistor r=62 c=0
Ry12 (\7\:db \8\:db) resistor r=20.6667 c=0
Ry10 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry13 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx14 (\2\:SE \7\:SE) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (SEb \8\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55_1__rcx (\3\:Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.111e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.59712e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn20 (\19\:CKb \3\:CK VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.583e-14 ad=3.988e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\14\:qbint n30 \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.035e-14 ad=4.42e-14 ps=8.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.59808e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn50 (net482 \10\:qbint \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.035e-14 ad=3.178e-14 ps=8.6e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=2e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn51 (\8\:n30 CKb net482 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=8.2e-14 ps=7.2e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.83e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\6\:mout CKbb \8\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.2e-14 ad=6.662e-14 ps=1.21e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.385e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn30 (\6\:mout \3\:n20 \21\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.14e-14 ad=6.663e-14 ps=1.02e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=1.015e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net474 mout \21\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=1.23e-14 ps=1.02e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.735e-06 sb=6.8e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn36 (\8\:n20 \4\:CKbb net474 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.408e-14 ps=5.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=5.75e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=6.458e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn21 (\8\:CKbb \5\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.85e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn12 (net490 \1\:SI \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.99e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.8e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=5.72e-14 ps=7.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.96635e-07 sb=5.2e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.63e-14 ps=9.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.61635e-07 sb=2.55e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn10 (\10\:SEb \5\:SE \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=2.03e-14 ps=1.06e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22483e-06 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn1 (net498 \4\:D0 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=6.5e-14 ps=1.06e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.9875e-07 sb=9.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9875e-07 sb=4.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.5e-14 ad=4.16e-14 ps=1.02e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9375e-07 sb=6.86058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (net510 \1\:D1 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=1.56e-14 ps=1.28e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.0375e-07 sb=3.76058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:S0b \5\:S0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=2.465e-14 ps=1.28e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2769e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \1\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.268e-14 ps=1.16e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.45e-07 sd=160n sca=36.2017 \
        scb=0.0268185 scc=0.00456568 m=(1)
mp45 (\12\:qbint \3\:n30 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.905e-14 ad=5.85e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.39103e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp50 (net409 \8\:qbint \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=6.355e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.79435e-07 sb=1.92339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp51 (\4\:n30 \3\:CKbb net409 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.355e-14 ad=7.595e-14 ps=1.03e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.29435e-07 sb=1.67339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.333e-13 ad=7.595e-14 ps=1.48e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.19435e-07 sb=1.38339e-06 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=5.89e-14 ps=1.05e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91944e-06 sb=3.83387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp30 (\8\:mout n20 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.333e-13 ps=1.38e-06 pd=1.48e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39444e-06 sb=9.08387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp35 (net393 \3\:mout \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=6.665e-14 ps=1.38e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65944e-06 sb=6.43387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.6e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.99202e-06 sb=1.48387e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp21 (\14\:CKbb \10\:CKb \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.7e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp12 (net417 \4\:SI \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25321e-07 sb=5.65e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp13 (\6\:dbp \2\:SEb net417 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=9.36e-14 ps=9e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.30321e-07 sb=4.6e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp11 (\6\:dbp \6\:SE \5\:db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=9.36e-14 ps=1.13e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.15321e-07 sb=1.75e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp10 (\5\:SEb \1\:SE \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.00616e-06 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp1 (net425 \1\:D0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=7.99551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=6.94551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=7.02e-14 ps=1.09e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.69551e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (net429 \3\:D1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.045e-14 ps=1.16e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65064e-07 sb=2.69551e-07 sd=160n sca=14.0034 \
        scb=0.0123236 scc=0.000647549 m=(1)
mp0 (\6\:S0b \7\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00174e-06 sb=1.4e-07 sd=160n sca=18.1789 \
        scb=0.0176591 scc=0.00112786 m=(1)
ends SMDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:00:08 2012 )
// Library name: gsclib045
// Cell name: SMDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX4 CK D0 D1 Q S0 SE SI VDD VSS
mp20 (\15\:CKb \3\:CK \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=34.5903 scb=0.0376512 \
        scc=0.00347075 m=(1)
C1 (CK VSS) capacitor c=1.16091e-16
C2 (Q VSS) capacitor c=4.13291e-17
C3 (D0 VSS) capacitor c=8.43384e-17
C4 (SE VSS) capacitor c=2.841e-17
C5 (S0 VSS) capacitor c=3.98658e-17
C6 (VDD VSS) capacitor c=3.88906e-16
C7 (D1 VSS) capacitor c=5.07452e-17
C8 (SI VSS) capacitor c=3.91001e-17
C9 (CKb VSS) capacitor c=4.62732e-17
C10 (qbint VSS) capacitor c=2.59004e-16
C11 (n30 VSS) capacitor c=9.62853e-17
C12 (net482 VSS) capacitor c=3.02224e-18
C13 (mout VSS) capacitor c=5.95205e-17
C14 (CKbb VSS) capacitor c=1.8224e-17
C15 (n20 VSS) capacitor c=3.86265e-17
C16 (net474 VSS) capacitor c=5.97186e-19
C17 (dbp VSS) capacitor c=8.57957e-17
C18 (db VSS) capacitor c=1.00574e-16
C19 (SEb VSS) capacitor c=5.68382e-17
C20 (net498 VSS) capacitor c=1.87259e-18
C21 (S0b VSS) capacitor c=4.57595e-17
C22 (net409 VSS) capacitor c=6.03734e-18
C23 (net393 VSS) capacitor c=4.05178e-18
C24 (net417 VSS) capacitor c=1.8729e-18
C25 (net425 VSS) capacitor c=2.9009e-18
C26 (net429 VSS) capacitor c=3.79054e-18
C27 (\7\:S0 VSS) capacitor c=4.10309e-17
C28 (\3\:D1 VSS) capacitor c=6.67646e-17
C29 (\2\:S0 VSS) capacitor c=5.77595e-17
C30 (\4\:D0 VSS) capacitor c=9.00886e-17
C31 (\1\:SE VSS) capacitor c=3.57326e-17
C32 (\6\:SE VSS) capacitor c=4.08294e-17
C33 (\2\:SEb VSS) capacitor c=7.07502e-17
C34 (\4\:SI VSS) capacitor c=8.20437e-17
C35 (\10\:CKb VSS) capacitor c=5.09988e-17
C36 (\6\:CKbb VSS) capacitor c=3.84811e-17
C37 (\8\:CKb VSS) capacitor c=3.52721e-17
C38 (\3\:CKb VSS) capacitor c=2.74686e-17
C39 (\3\:CKbb VSS) capacitor c=8.64675e-17
C40 (\15\:qbint VSS) capacitor c=7.63768e-17
C41 (\3\:CK VSS) capacitor c=3.18982e-17
C42 (\5\:S0 VSS) capacitor c=2.61635e-17
C43 (\1\:D1 VSS) capacitor c=7.70141e-17
C44 (\3\:S0 VSS) capacitor c=6.51393e-17
C45 (\3\:S0b VSS) capacitor c=1.04689e-16
C46 (\1\:D0 VSS) capacitor c=7.66053e-17
C47 (\5\:SE VSS) capacitor c=3.57461e-17
C48 (\3\:SEb VSS) capacitor c=3.98542e-17
C49 (\4\:SE VSS) capacitor c=6.58674e-17
C50 (\1\:SI VSS) capacitor c=5.12019e-17
C51 (\5\:CKb VSS) capacitor c=3.35104e-17
C52 (\11\:CKb VSS) capacitor c=2.37559e-17
C53 (\4\:CKbb VSS) capacitor c=6.00291e-17
C54 (\3\:mout VSS) capacitor c=5.71974e-17
C55 (\3\:n20 VSS) capacitor c=4.1168e-17
C56 (\17\:qbint VSS) capacitor c=4.49374e-17
C57 (\1\:CK VSS) capacitor c=3.11074e-17
C58 (\6\:S0 VSS) capacitor c=3.96686e-17
C59 (\2\:D1 VSS) capacitor c=6.89004e-17
C60 (\4\:S0 VSS) capacitor c=5.58688e-17
C61 (\2\:S0b VSS) capacitor c=6.73871e-17
C62 (\1\:S0 VSS) capacitor c=5.09735e-17
C63 (\3\:D0 VSS) capacitor c=2.23533e-17
C64 (\2\:SE VSS) capacitor c=6.13992e-17
C65 (\4\:SEb VSS) capacitor c=4.04017e-17
C66 (\3\:SI VSS) capacitor c=2.95453e-17
C67 (\7\:CKbb VSS) capacitor c=4.30929e-17
C68 (\9\:CKb VSS) capacitor c=2.53906e-17
C69 (\5\:CKbb VSS) capacitor c=3.73573e-17
C70 (\2\:mout VSS) capacitor c=4.56668e-17
C71 (\2\:n20 VSS) capacitor c=3.14648e-17
C72 (\2\:CKbb VSS) capacitor c=3.88172e-17
C73 (\4\:CKb VSS) capacitor c=4.15666e-17
C74 (\2\:CKb VSS) capacitor c=4.55208e-17
C75 (\16\:qbint VSS) capacitor c=6.1323e-17
C76 (\8\:n30 VSS) capacitor c=1.73649e-17
C77 (\2\:CK VSS) capacitor c=3.02662e-17
C78 (\6\:S0b VSS) capacitor c=1.00781e-16
C79 (\15\:VDD VSS) capacitor c=3.3092e-17
C80 (\7\:db VSS) capacitor c=7.00073e-17
C81 (\17\:VDD VSS) capacitor c=5.12782e-17
C82 (\5\:SEb VSS) capacitor c=1.13871e-16
C83 (\5\:db VSS) capacitor c=4.11232e-17
C84 (\4\:dbp VSS) capacitor c=7.33025e-17
C85 (\19\:VDD VSS) capacitor c=3.53896e-17
C86 (\8\:CKbb VSS) capacitor c=7.84364e-17
C87 (\6\:dbp VSS) capacitor c=1.04011e-16
C88 (\4\:n20 VSS) capacitor c=5.51284e-17
C89 (\21\:VDD VSS) capacitor c=3.44198e-17
C90 (\4\:mout VSS) capacitor c=6.45643e-17
C91 (\12\:n30 VSS) capacitor c=9.9672e-17
C92 (\23\:qbint VSS) capacitor c=5.04974e-17
C93 (\1\:Q VSS) capacitor c=1.64573e-16
C94 (\15\:CKb VSS) capacitor c=1.64052e-16
C95 (\1\:VDD VSS) capacitor c=8.66349e-17
C96 (\4\:S0b VSS) capacitor c=5.63866e-17
C97 (\10\:SEb VSS) capacitor c=7.69313e-17
C98 (\9\:db VSS) capacitor c=7.35193e-17
C99 (\14\:CKbb VSS) capacitor c=5.19137e-17
C100 (\8\:dbp VSS) capacitor c=6.76345e-17
C101 (\8\:n20 VSS) capacitor c=6.86545e-17
C102 (\7\:mout VSS) capacitor c=4.71429e-17
C103 (\9\:n30 VSS) capacitor c=8.1545e-17
C104 (\21\:qbint VSS) capacitor c=4.64356e-17
C105 (\17\:CKb VSS) capacitor c=5.37582e-17
C106 (\3\:n30 VSS) capacitor c=8.01584e-17
C107 (\6\:CKb VSS) capacitor c=6.04443e-17
C108 (\7\:CKb VSS) capacitor c=6.45381e-17
C109 (\2\:SI VSS) capacitor c=3.54714e-17
C110 (\3\:SE VSS) capacitor c=6.83285e-17
C111 (\2\:D0 VSS) capacitor c=3.32166e-17
C112 (\18\:qbint VSS) capacitor c=6.71392e-17
C113 (\19\:qbint VSS) capacitor c=4.67429e-17
C114 (\20\:qbint VSS) capacitor c=3.25617e-17
C115 (\11\:n30 VSS) capacitor c=9.24769e-17
C116 (\6\:mout VSS) capacitor c=5.06805e-17
C117 (\9\:mout VSS) capacitor c=5.40806e-17
C118 (\12\:CKb VSS) capacitor c=5.55149e-17
C119 (\13\:CKb VSS) capacitor c=1.01191e-16
C120 (\14\:CKb VSS) capacitor c=2.11832e-16
C121 (\19\:CKb VSS) capacitor c=9.22417e-17
C122 (\20\:CKb VSS) capacitor c=8.16801e-17
C123 (\6\:n20 VSS) capacitor c=7.0306e-17
C124 (\7\:n20 VSS) capacitor c=7.88805e-17
C125 (\10\:CKbb VSS) capacitor c=1.18046e-16
C126 (\11\:CKbb VSS) capacitor c=7.28418e-17
C127 (\12\:CKbb VSS) capacitor c=1.00757e-16
C128 (\13\:CKbb VSS) capacitor c=1.04315e-16
C129 (\16\:CKbb VSS) capacitor c=6.04265e-17
C130 (\5\:SI VSS) capacitor c=7.60237e-17
C131 (\3\:dbp VSS) capacitor c=8.98827e-17
C132 (\7\:SEb VSS) capacitor c=7.99562e-17
C133 (\8\:SEb VSS) capacitor c=3.84732e-17
C134 (\9\:SEb VSS) capacitor c=8.54487e-17
C135 (\7\:SE VSS) capacitor c=8.30898e-17
C136 (\5\:D0 VSS) capacitor c=6.35209e-17
C137 (\3\:db VSS) capacitor c=1.48957e-16
C138 (\4\:db VSS) capacitor c=8.27924e-17
C139 (\4\:D1 VSS) capacitor c=7.52481e-17
C140 (\8\:S0 VSS) capacitor c=7.8767e-17
C141 (\9\:S0 VSS) capacitor c=6.03649e-17
C142 (\10\:S0 VSS) capacitor c=2.79825e-17
C143 (\8\:S0b VSS) capacitor c=9.41271e-17
C144 (\3\:VDD VSS) capacitor c=2.01199e-17
C145 (\4\:VDD VSS) capacitor c=3.8552e-17
C146 (\6\:VDD VSS) capacitor c=2.68852e-17
C147 (\7\:VDD VSS) capacitor c=3.85846e-17
C148 (\9\:VDD VSS) capacitor c=1.46846e-16
Rk1 (\4\:CK CK) resistor r=0.002997 c=0
Rk6 (\1\:Q Q) resistor r=0.02432 c=0
Rk46 (\5\:D0 D0) resistor r=0.02098 c=0
Rk58 (\2\:VSS \3\:VSS) resistor r=0.2755 c=0
Rk59 (\3\:VSS \4\:VSS) resistor r=0.3758 c=0
Rk60 (\4\:VSS \5\:VSS) resistor r=0.06498 c=0
Rk61 (\5\:VSS \6\:VSS) resistor r=0.5868 c=0
Rk62 (\3\:VSS \8\:VSS) resistor r=0.2532 c=0
Rk63 (\5\:VSS \10\:VSS) resistor r=0.1804 c=0
Rk64 (\6\:VSS \11\:VSS) resistor r=0.6029 c=0
Rk65 (\11\:VSS \12\:VSS) resistor r=0.04648 c=0
Rk66 (\12\:VSS \13\:VSS) resistor r=0.6089 c=0
Rk74 (\20\:VSS VSS) resistor r=0.04988 c=0
Rk73 (\13\:VSS \20\:VSS) resistor r=0.06247 c=0
Rk75 (\6\:VSS \22\:VSS) resistor r=0.3157 c=0
Rk76 (\11\:VSS \24\:VSS) resistor r=0.04328 c=0
Rk43 (\7\:SE SE) resistor r=0.005993 c=0
Rk54 (\9\:S0 S0) resistor r=0.2875 c=0
Rk53 (\8\:S0 \9\:S0) resistor r=0.3841 c=0
Rk55 (S0 \10\:S0) resistor r=0.03339 c=0
Rk81 (\2\:VDD \3\:VDD) resistor r=0.07751 c=0
Rk82 (\3\:VDD \4\:VDD) resistor r=0.3831 c=0
Rk83 (\4\:VDD \5\:VDD) resistor r=0.441 c=0
Rk84 (\5\:VDD \6\:VDD) resistor r=0.1778 c=0
Rk85 (\6\:VDD \7\:VDD) resistor r=0.5912 c=0
Rk86 (\7\:VDD \8\:VDD) resistor r=0.4334 c=0
Rk87 (\8\:VDD \9\:VDD) resistor r=0.1276 c=0
Rk93 (\14\:VDD VDD) resistor r=0.04988 c=0
Rk92 (\9\:VDD \14\:VDD) resistor r=0.08252 c=0
Rk94 (\3\:VDD \16\:VDD) resistor r=0.1734 c=0
Rk95 (\4\:VDD \18\:VDD) resistor r=0.2216 c=0
Rk96 (\6\:VDD \20\:VDD) resistor r=0.2532 c=0
Rk97 (\7\:VDD \22\:VDD) resistor r=0.202 c=0
Rk52 (D1 \4\:D1) resistor r=0.05461 c=0
Rk31 (SI \5\:SI) resistor r=0.07572 c=0
Rk16 (\12\:CKb \13\:CKb) resistor r=0.3022 c=0
Rk17 (\13\:CKb \14\:CKb) resistor r=0.3617 c=0
Rk18 (\14\:CKb \16\:CKb) resistor r=1.3338 c=0
Rk19 (\16\:CKb \18\:CKb) resistor r=0.37 c=0
Rk20 (\13\:CKb \19\:CKb) resistor r=0.6893 c=0
Rk21 (\14\:CKb \20\:CKb) resistor r=0.3534 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.3865 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.1927 c=0
Rk9 (\19\:qbint \22\:qbint) resistor r=0.2468 c=0
Rk10 (\19\:qbint \24\:qbint) resistor r=0.2692 c=0
Rk11 (\10\:n30 \11\:n30) resistor r=0.4714 c=0
Rk12 (\10\:n30 \13\:n30) resistor r=0.4786 c=0
Rk13 (\5\:mout \6\:mout) resistor r=0.2474 c=0
Rk14 (\6\:mout \8\:mout) resistor r=0.1649 c=0
Rk15 (\6\:mout \9\:mout) resistor r=0.2462 c=0
Rk25 (\9\:CKbb \10\:CKbb) resistor r=0.5271 c=0
Rk26 (\10\:CKbb \11\:CKbb) resistor r=0.3528 c=0
Rk27 (\11\:CKbb \12\:CKbb) resistor r=0.2851 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.846 c=0
Rk29 (\11\:CKbb \15\:CKbb) resistor r=0.2718 c=0
Rk30 (\12\:CKbb \16\:CKbb) resistor r=0.2303 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.149 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.3933 c=0
Rk24 (\6\:n20 \9\:n20) resistor r=0.303 c=0
Rk32 (\2\:dbp \3\:dbp) resistor r=0.5263 c=0
Rk33 (\3\:dbp \5\:dbp) resistor r=0.1258 c=0
Rk34 (\3\:dbp \7\:dbp) resistor r=0.4271 c=0
Rk35 (\7\:dbp \9\:dbp) resistor r=0.3601 c=0
Rk36 (\5\:dbp \10\:dbp) resistor r=0.1627 c=0
Rk47 (\2\:db \3\:db) resistor r=0.7325 c=0
Rk48 (\3\:db \4\:db) resistor r=0.4829 c=0
Rk49 (\4\:db \6\:db) resistor r=0.07934 c=0
Rk50 (\3\:db \8\:db) resistor r=0.2634 c=0
Rk51 (\4\:db \10\:db) resistor r=0.356 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.6934 c=0
Rk38 (\7\:SEb \8\:SEb) resistor r=0.12 c=0
Rk39 (\7\:SEb \9\:SEb) resistor r=0.1527 c=0
Rk40 (\9\:SEb \11\:SEb) resistor r=0.5886 c=0
Rk56 (\5\:S0b \7\:S0b) resistor r=0.6043 c=0
Rk57 (\7\:S0b \8\:S0b) resistor r=0.6029 c=0
Rl2 (\2\:CK \3\:CK) resistor r=34.9443 c=0
Rl1 (\1\:CK \2\:CK) resistor r=62.9757 c=0
Rl53 (\2\:D0 \4\:D0) resistor r=159.077 c=0
Rl51 (\1\:D0 \2\:D0) resistor r=126.433 c=0
Rl52 (\2\:D0 \3\:D0) resistor r=6.4284 c=0
Rl46 (\1\:SE \2\:SE) resistor r=80.0021 c=0
Rl49 (\2\:SE \5\:SE) resistor r=164.617 c=0
Rl50 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl48 (\3\:SE \4\:SE) resistor r=127.645 c=0
Rl47 (\2\:SE \3\:SE) resistor r=199.477 c=0
Rl61 (\6\:S0 \7\:S0) resistor r=135.714 c=0
Rl60 (\5\:S0 \6\:S0) resistor r=69.2308 c=0
Rl57 (\3\:S0 \4\:S0) resistor r=55.0021 c=0
Rl54 (\1\:S0 \2\:S0) resistor r=59.5926 c=0
Rl59 (\2\:D1 \3\:D1) resistor r=111.516 c=0
Rl58 (\1\:D1 \2\:D1) resistor r=113.257 c=0
Rl43 (\2\:SI \4\:SI) resistor r=41.1873 c=0
Rl41 (\1\:SI \2\:SI) resistor r=85.265 c=0
Rl42 (\2\:SI \3\:SI) resistor r=8.3025 c=0
Rl38 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=31.6893 c=0
Rl25 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl39 (\6\:CKb \10\:CKb) resistor r=165.066 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=88.4394 c=0
Rl37 (\7\:CKb \8\:CKb) resistor r=139.928 c=0
Rl40 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=192.698 c=0
Rl23 (\16\:qbint \15\:qbint) resistor r=123.334 c=0
Rl24 (\16\:qbint \17\:qbint) resistor r=33.3841 c=0
Rl17 (\3\:n30 n30) resistor r=44.9718 c=0
Rl22 (\3\:n30 \8\:n30) resistor r=4.6885 c=0
Rl31 (mout \2\:mout) resistor r=79.9442 c=0
Rl32 (\2\:mout \3\:mout) resistor r=26.098 c=0
Rl34 (\6\:CKbb \7\:CKbb) resistor r=33.3841 c=0
Rl33 (\4\:CKbb \5\:CKbb) resistor r=33.3841 c=0
Rl27 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl28 (\2\:CKbb \3\:CKbb) resistor r=191.862 c=0
Rl29 (n20 \2\:n20) resistor r=29.5379 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=83.3841 c=0
Rl44 (SEb \2\:SEb) resistor r=39.4 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl55 (S0b \2\:S0b) resistor r=24.2328 c=0
Rl56 (\2\:S0b \3\:S0b) resistor r=179.675 c=0
Rz15 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz16 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz23 (\2\:VDD \1\:VDD) resistor r=12.5 c=0
Rz24 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz25 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz26 (\9\:VDD \1\:VDD) resistor r=37.5 c=0
Rz27 (\14\:VDD \1\:VDD) resistor r=37.5 c=0
Rz6 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\22\:qbint \21\:qbint) resistor r=75 c=0
Rz4 (\10\:n30 \9\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (dbp \2\:dbp) resistor r=75 c=0
Rz10 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz12 (db \2\:db) resistor r=75 c=0
Rz13 (\9\:db \10\:db) resistor r=75 c=0
Rz11 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz14 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry16 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry17 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\6\:VSS \1\:VSS) resistor r=62 c=0
Ry19 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\13\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry23 (\20\:VSS \1\:VSS) resistor r=31 c=0
Ry24 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry25 (\18\:VDD \17\:VDD) resistor r=31 c=0
Ry26 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry27 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\24\:qbint \23\:qbint) resistor r=62 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry10 (\6\:dbp \7\:dbp) resistor r=62 c=0
Ry11 (\4\:dbp \10\:dbp) resistor r=62 c=0
Ry13 (\5\:db \6\:db) resistor r=62 c=0
Ry14 (\7\:db \8\:db) resistor r=20.6667 c=0
Ry12 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry15 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx16 (\2\:SE \7\:SE) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx6 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\9\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\20\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (SEb \8\:SEb) resistor r=45 c=0
Rx15 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn20 (\17\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.74e-14 ad=2.465e-14 ps=1.59e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.58655e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn55_1__rcx (\1\:Q qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.473e-14 ad=4.16e-14 ps=1.0275e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.47788e-07 sb=1.72817e-06 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
mn45 (\21\:qbint \3\:n30 \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.68e-14 ad=3.28e-14 ps=9.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03634e-06 sb=2e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(2)
mn50 (net482 \17\:qbint \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.53e-14 ad=2.358e-14 ps=1.02e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50634e-06 sb=2e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (\9\:n30 CKb net482 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=8.61e-14 ps=6.4e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66634e-06 sb=1.84e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn40 (\7\:mout CKbb \9\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.61e-14 ad=7.073e-14 ps=1.25e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.375e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn30 (\7\:mout \3\:n20 \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.29e-14 ad=7.073e-14 ps=1.48e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.85e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn35 (net474 \3\:mout \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.29e-14 ad=1.23e-14 ps=1.48e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.2e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn36 (\8\:n20 \4\:CKbb net474 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.15e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.228e-14 ad=6.458e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn21 (\14\:CKbb \5\:CKb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (net490 \1\:SI \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.51e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.4e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn13 (dbp \4\:SE net490 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.94e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.16635e-07 sb=4.6e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn11 (\9\:db \3\:SEb dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.85e-14 ps=9e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.51635e-07 sb=2.25e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn1 (net498 \1\:D0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.53e-14 ad=1.56e-14 ps=1.4e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.92788e-07 sb=7.43654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn10 (\10\:SEb \5\:SE \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.53e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.08483e-06 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.97788e-07 sb=6.38654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.02788e-07 sb=4.33654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn3 (net510 \1\:D1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.427e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.07788e-07 sb=3.28654e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn0 (\4\:S0b \5\:S0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.427e-14 ad=2.465e-14 ps=1.11e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.63621e-07 sb=1.7e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mp55_1__rcx (\1\:Q qbint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.235e-14 ad=6.24e-14 ps=1.515e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=1.76308e-06 sd=160n sca=20.0514 \
        scb=0.0177139 scc=0.00149226 m=(4)
mp45_1__rcx (\23\:qbint n30 \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.94e-14 ad=4.96e-14 ps=1.38e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25153e-06 sb=2e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(2)
mp50 (net409 \15\:qbint \9\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=3.875e-14 ps=1.38e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72153e-06 sb=1.73339e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp51 (\12\:n30 \3\:CKbb net409 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89153e-06 sb=1.56339e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp40 (\12\:n30 \3\:CKb \4\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96476e-06 sb=1.35839e-06 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp30 (\4\:mout n20 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=1.3485e-13 ps=1.38e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.78387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp35 (net393 mout \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.74e-14 ad=5.735e-14 ps=1.38e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.13387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.89e-14 ps=9.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.83387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp25 (\4\:n20 \6\:CKbb \6\:dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.6e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.48387e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp21 (\8\:CKbb \10\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.05e-14 ad=2.95e-14 ps=1.18e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37209e-07 sb=8.1e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp12 (net417 \4\:SI \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.05e-14 ad=2.34e-14 ps=1.18e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55577e-07 sb=5.65e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp13 (\4\:dbp \2\:SEb net417 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60577e-07 sb=4.6e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp11 (\4\:dbp \6\:SE \5\:db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.775e-14 ad=7.41e-14 ps=1.23e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.95577e-07 sb=2.25e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp10 (\5\:SEb \1\:SE \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (net425 \4\:D0 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.29e-14 ps=1.16e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.15e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp2 (\7\:db \2\:S0 net425 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.02e-14 ps=1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.24551e-07 sb=7.6e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp4 (\7\:db S0b net429 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.49551e-07 sb=5.35e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp3 (net429 \3\:D1 \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.868e-14 ad=5.265e-14 ps=1.47e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.29551e-07 sb=3.55e-07 sd=160n sca=11.6183 \
        scb=0.00959647 scc=0.000231864 m=(1)
mp0 (\6\:S0b \7\:S0 \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.868e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=14.7678 \
        scb=0.0134734 scc=0.000346306 m=(1)
ends SMDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:00:47 2012 )
// Library name: gsclib045
// Cell name: SMDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SMDFFHQX8 CK D0 D1 Q S0 SE SI VDD VSS
mp55_1__rcx (Q qbint \21\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90404e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (CK VSS) capacitor c=7.74175e-17
C2 (D0 VSS) capacitor c=6.32585e-17
C3 (SE VSS) capacitor c=7.19478e-17
C4 (S0 VSS) capacitor c=3.16325e-17
C5 (VDD VSS) capacitor c=3.97284e-16
C6 (D1 VSS) capacitor c=1.35671e-16
C7 (Q VSS) capacitor c=5.09152e-16
C8 (SI VSS) capacitor c=3.96208e-17
C9 (qbint VSS) capacitor c=3.60011e-16
C10 (n30 VSS) capacitor c=2.03872e-16
C11 (CKb VSS) capacitor c=4.526e-17
C12 (net482 VSS) capacitor c=2.62936e-18
C13 (mout VSS) capacitor c=5.93086e-17
C14 (CKbb VSS) capacitor c=2.36861e-17
C15 (n20 VSS) capacitor c=3.74998e-17
C16 (net474 VSS) capacitor c=1.38453e-18
C17 (dbp VSS) capacitor c=6.01794e-17
C18 (net490 VSS) capacitor c=2.07039e-18
C19 (db VSS) capacitor c=1.05446e-16
C20 (SEb VSS) capacitor c=7.21904e-17
C21 (net498 VSS) capacitor c=5.7093e-18
C22 (S0b VSS) capacitor c=3.56164e-17
C23 (net409 VSS) capacitor c=2.7333e-18
C24 (net393 VSS) capacitor c=2.33668e-18
C25 (net417 VSS) capacitor c=2.23037e-18
C26 (net425 VSS) capacitor c=2.05099e-18
C27 (net429 VSS) capacitor c=6.74141e-18
C28 (\7\:S0 VSS) capacitor c=3.78953e-17
C29 (\1\:D1 VSS) capacitor c=4.64247e-17
C30 (\2\:S0 VSS) capacitor c=7.02524e-17
C31 (\4\:D0 VSS) capacitor c=9.06227e-17
C32 (\1\:SE VSS) capacitor c=5.71518e-17
C33 (\6\:SE VSS) capacitor c=3.09081e-17
C34 (\1\:SI VSS) capacitor c=9.19536e-17
C35 (\5\:CKb VSS) capacitor c=7.336e-17
C36 (\7\:CKbb VSS) capacitor c=3.87995e-17
C37 (\8\:CKb VSS) capacitor c=4.92051e-17
C38 (\3\:CKb VSS) capacitor c=2.44198e-17
C39 (\3\:CKbb VSS) capacitor c=7.54833e-17
C40 (\22\:qbint VSS) capacitor c=4.62481e-17
C41 (\1\:CK VSS) capacitor c=3.02846e-17
C42 (\5\:S0 VSS) capacitor c=2.1959e-17
C43 (\3\:D1 VSS) capacitor c=7.20024e-17
C44 (\3\:S0 VSS) capacitor c=7.04511e-17
C45 (\3\:S0b VSS) capacitor c=6.40312e-17
C46 (\1\:D0 VSS) capacitor c=5.46486e-17
C47 (\5\:SE VSS) capacitor c=4.10656e-17
C48 (\3\:SEb VSS) capacitor c=3.43811e-17
C49 (\4\:SE VSS) capacitor c=9.58576e-17
C50 (\4\:SI VSS) capacitor c=8.19422e-17
C51 (\10\:CKb VSS) capacitor c=3.71684e-17
C52 (\11\:CKb VSS) capacitor c=2.4472e-17
C53 (\5\:CKbb VSS) capacitor c=5.92745e-17
C54 (\4\:mout VSS) capacitor c=5.5388e-17
C55 (\3\:n20 VSS) capacitor c=3.85403e-17
C56 (\24\:qbint VSS) capacitor c=5.24772e-17
C57 (\3\:CK VSS) capacitor c=3.61186e-17
C58 (\6\:S0 VSS) capacitor c=2.68925e-17
C59 (\2\:D1 VSS) capacitor c=4.08256e-17
C60 (\4\:S0 VSS) capacitor c=4.33603e-17
C61 (\2\:S0b VSS) capacitor c=5.04324e-17
C62 (\1\:S0 VSS) capacitor c=4.6944e-17
C63 (\3\:D0 VSS) capacitor c=4.1277e-17
C64 (\2\:SE VSS) capacitor c=7.48359e-17
C65 (\4\:SEb VSS) capacitor c=4.1649e-17
C66 (\2\:SEb VSS) capacitor c=5.3632e-17
C67 (\3\:SI VSS) capacitor c=3.94629e-17
C68 (\8\:CKbb VSS) capacitor c=3.72192e-17
C69 (\9\:CKb VSS) capacitor c=2.83456e-17
C70 (\6\:CKbb VSS) capacitor c=4.46809e-17
C71 (\3\:mout VSS) capacitor c=1.9672e-17
C72 (\2\:n20 VSS) capacitor c=2.94622e-17
C73 (\4\:CKbb VSS) capacitor c=2.12705e-17
C74 (\4\:CKb VSS) capacitor c=3.86969e-17
C75 (\2\:CKb VSS) capacitor c=4.19488e-17
C76 (\23\:qbint VSS) capacitor c=4.38276e-17
C77 (\2\:CK VSS) capacitor c=2.95726e-17
C78 (\6\:S0b VSS) capacitor c=9.58672e-17
C79 (\9\:VDD VSS) capacitor c=3.32204e-17
C80 (\6\:db VSS) capacitor c=5.39039e-17
C81 (\11\:VDD VSS) capacitor c=4.02672e-17
C82 (\5\:SEb VSS) capacitor c=9.20215e-17
C83 (\4\:db VSS) capacitor c=1.48933e-16
C84 (\13\:VDD VSS) capacitor c=4.43969e-17
C85 (\14\:CKbb VSS) capacitor c=9.69423e-17
C86 (\4\:dbp VSS) capacitor c=1.00862e-16
C87 (\4\:n20 VSS) capacitor c=6.27021e-17
C88 (\15\:VDD VSS) capacitor c=3.45831e-17
C89 (\5\:mout VSS) capacitor c=4.42153e-17
C90 (\14\:n30 VSS) capacitor c=1.08344e-16
C91 (\18\:VDD VSS) capacitor c=2.64852e-17
C92 (\18\:CKb VSS) capacitor c=1.11584e-16
C93 (\26\:qbint VSS) capacitor c=3.82251e-16
C94 (\1\:VDD VSS) capacitor c=1.61362e-16
C95 (\4\:S0b VSS) capacitor c=5.10633e-17
C96 (\10\:SEb VSS) capacitor c=1.16099e-16
C97 (\8\:db VSS) capacitor c=9.85603e-17
C98 (\6\:dbp VSS) capacitor c=7.19613e-17
C99 (\16\:CKbb VSS) capacitor c=5.12455e-17
C100 (\8\:dbp VSS) capacitor c=8.28421e-17
C101 (\8\:n20 VSS) capacitor c=6.4456e-17
C102 (\8\:mout VSS) capacitor c=4.88278e-17
C103 (\12\:n30 VSS) capacitor c=2.10781e-16
C104 (\15\:CKb VSS) capacitor c=1.51094e-16
C105 (\2\:CKbb VSS) capacitor c=3.80337e-17
C106 (\2\:mout VSS) capacitor c=2.98929e-17
C107 (\6\:CKb VSS) capacitor c=6.8448e-17
C108 (\7\:CKb VSS) capacitor c=5.26985e-17
C109 (\2\:SI VSS) capacitor c=3.83759e-17
C110 (\3\:SE VSS) capacitor c=7.29502e-17
C111 (\2\:D0 VSS) capacitor c=3.40863e-17
C112 (\4\:CK VSS) capacitor c=4.25455e-17
C113 (\25\:qbint VSS) capacitor c=1.27555e-16
C114 (\37\:qbint VSS) capacitor c=3.2166e-17
C115 (\11\:n30 VSS) capacitor c=1.63316e-16
C116 (\7\:mout VSS) capacitor c=6.09441e-17
C117 (\10\:mout VSS) capacitor c=7.37563e-17
C118 (\12\:CKb VSS) capacitor c=1.05423e-16
C119 (\13\:CKb VSS) capacitor c=1.22924e-16
C120 (\14\:CKb VSS) capacitor c=1.6475e-16
C121 (\17\:CKb VSS) capacitor c=6.842e-17
C122 (\6\:n20 VSS) capacitor c=7.24509e-17
C123 (\7\:n20 VSS) capacitor c=8.37571e-17
C124 (\9\:CKbb VSS) capacitor c=1.32272e-16
C125 (\10\:CKbb VSS) capacitor c=1.45695e-16
C126 (\11\:CKbb VSS) capacitor c=4.56657e-17
C127 (\12\:CKbb VSS) capacitor c=7.7279e-17
C128 (\13\:CKbb VSS) capacitor c=1.50037e-16
C129 (\5\:SI VSS) capacitor c=6.05883e-17
C130 (\3\:dbp VSS) capacitor c=1.03852e-16
C131 (\7\:SE VSS) capacitor c=6.92383e-17
C132 (\7\:SEb VSS) capacitor c=9.47786e-17
C133 (\8\:SEb VSS) capacitor c=3.59918e-17
C134 (\9\:SEb VSS) capacitor c=7.9526e-17
C135 (\5\:D0 VSS) capacitor c=6.99057e-17
C136 (\3\:db VSS) capacitor c=1.28801e-16
C137 (\8\:S0 VSS) capacitor c=7.00828e-17
C138 (\9\:S0 VSS) capacitor c=5.1718e-17
C139 (\10\:S0 VSS) capacitor c=6.46148e-17
C140 (\8\:S0b VSS) capacitor c=1.02446e-16
C141 (\3\:VDD VSS) capacitor c=9.33222e-19
C142 (\5\:VDD VSS) capacitor c=1.41233e-17
C143 (\7\:VDD VSS) capacitor c=4.33963e-17
C144 (\17\:VDD VSS) capacitor c=2.42918e-17
C145 (\21\:VDD VSS) capacitor c=5.14626e-16
Rk11 (\4\:CK CK) resistor r=0.1658 c=0
Rk85 (\2\:VSS \3\:VSS) resistor r=0.1553 c=0
Rk86 (\3\:VSS \4\:VSS) resistor r=0.1954 c=0
Rk87 (\4\:VSS \5\:VSS) resistor r=0.2029 c=0
Rk88 (\5\:VSS \6\:VSS) resistor r=0.2982 c=0
Rk89 (\6\:VSS \7\:VSS) resistor r=0.2757 c=0
Rk90 (\7\:VSS \8\:VSS) resistor r=0.5965 c=0
Rk91 (\8\:VSS \9\:VSS) resistor r=0.0299 c=0
Rk92 (\9\:VSS \10\:VSS) resistor r=0.6092 c=0
Rk93 (\10\:VSS \11\:VSS) resistor r=0.1428 c=0
Rk100 (\12\:VSS VSS) resistor r=0.1074 c=0
Rk94 (\11\:VSS \12\:VSS) resistor r=0.3735 c=0
Rk101 (\3\:VSS \19\:VSS) resistor r=0.3045 c=0
Rk102 (\5\:VSS \21\:VSS) resistor r=0.2317 c=0
Rk103 (\7\:VSS \23\:VSS) resistor r=0.2555 c=0
Rk104 (\8\:VSS \25\:VSS) resistor r=0.201 c=0
Rk105 (\10\:VSS \27\:VSS) resistor r=0.1026 c=0
Rk49 (D0 \5\:D0) resistor r=0.1475 c=0
Rk44 (SE \7\:SE) resistor r=0.1249 c=0
Rk55 (\8\:S0 S0) resistor r=0.2785 c=0
Rk56 (S0 \9\:S0) resistor r=0.02672 c=0
Rk57 (\9\:S0 \10\:S0) resistor r=0.3875 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.1553 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.1954 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.2105 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.2907 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.2757 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.6268 c=0
Rk66 (\3\:VDD \10\:VDD) resistor r=0.2243 c=0
Rk67 (\5\:VDD \12\:VDD) resistor r=0.2273 c=0
Rk68 (\7\:VDD \14\:VDD) resistor r=0.2365 c=0
Rk69 (\8\:VDD \16\:VDD) resistor r=0.2325 c=0
Rk70 (\8\:VDD \17\:VDD) resistor r=0.5973 c=0
Rk71 (\17\:VDD \19\:VDD) resistor r=0.2042 c=0
Rk72 (\17\:VDD \20\:VDD) resistor r=0.1553 c=0
Rk84 (\21\:VDD VDD) resistor r=0.1074 c=0
Rk73 (\20\:VDD \21\:VDD) resistor r=0.3735 c=0
Rk54 (\4\:D1 D1) resistor r=0.004469 c=0
Rk39 (SI \5\:SI) resistor r=0.1413 c=0
Rk12 (\25\:qbint \26\:qbint) resistor r=0.9606 c=0
Rk19 (\26\:qbint \37\:qbint) resistor r=0.166 c=0
Rk20 (\11\:n30 \13\:n30) resistor r=1.2746 c=0
Rk21 (\13\:n30 \15\:n30) resistor r=0.4567 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.7396 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.673 c=0
Rk27 (\14\:CKb \16\:CKb) resistor r=0.6287 c=0
Rk28 (\13\:CKb \17\:CKb) resistor r=0.2825 c=0
Rk29 (\16\:CKb \19\:CKb) resistor r=0.6911 c=0
Rk22 (\6\:mout \7\:mout) resistor r=0.2446 c=0
Rk23 (\7\:mout \9\:mout) resistor r=0.1294 c=0
Rk24 (\7\:mout \10\:mout) resistor r=0.3113 c=0
Rk33 (\9\:CKbb \10\:CKbb) resistor r=1.0082 c=0
Rk34 (\10\:CKbb \11\:CKbb) resistor r=0.1502 c=0
Rk35 (\10\:CKbb \12\:CKbb) resistor r=0.365 c=0
Rk36 (\12\:CKbb \13\:CKbb) resistor r=0.3089 c=0
Rk37 (\13\:CKbb \15\:CKbb) resistor r=0.6631 c=0
Rk38 (\12\:CKbb \17\:CKbb) resistor r=0.2756 c=0
Rk30 (\5\:n20 \6\:n20) resistor r=0.1756 c=0
Rk31 (\6\:n20 \7\:n20) resistor r=0.4455 c=0
Rk32 (\6\:n20 \9\:n20) resistor r=0.2541 c=0
Rk40 (\2\:dbp \3\:dbp) resistor r=0.251 c=0
Rk41 (\3\:dbp \5\:dbp) resistor r=0.3815 c=0
Rk42 (\3\:dbp \7\:dbp) resistor r=0.5281 c=0
Rk43 (\5\:dbp \9\:dbp) resistor r=0.4601 c=0
Rk50 (\2\:db \3\:db) resistor r=0.7389 c=0
Rk51 (\3\:db \5\:db) resistor r=0.4683 c=0
Rk52 (\3\:db \7\:db) resistor r=0.2421 c=0
Rk53 (\5\:db \9\:db) resistor r=0.5095 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.6453 c=0
Rk46 (\7\:SEb \8\:SEb) resistor r=0.1632 c=0
Rk47 (\7\:SEb \9\:SEb) resistor r=0.1202 c=0
Rk48 (\9\:SEb \11\:SEb) resistor r=0.7546 c=0
Rk58 (\5\:S0b \7\:S0b) resistor r=0.4812 c=0
Rk59 (\7\:S0b \8\:S0b) resistor r=0.645 c=0
Rl30 (\1\:CK \2\:CK) resistor r=73.0769 c=0
Rl31 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl64 (\2\:D0 \4\:D0) resistor r=47.3105 c=0
Rl62 (\1\:D0 \2\:D0) resistor r=115.43 c=0
Rl63 (\2\:D0 \3\:D0) resistor r=58.0656 c=0
Rl57 (\1\:SE \2\:SE) resistor r=146.875 c=0
Rl60 (\2\:SE \5\:SE) resistor r=171.875 c=0
Rl61 (\3\:SE \6\:SE) resistor r=30.4507 c=0
Rl59 (\3\:SE \4\:SE) resistor r=164.928 c=0
Rl58 (\2\:SE \3\:SE) resistor r=145.182 c=0
Rl72 (\6\:S0 \7\:S0) resistor r=106.868 c=0
Rl71 (\5\:S0 \6\:S0) resistor r=40.3846 c=0
Rl68 (\3\:S0 \4\:S0) resistor r=24.2328 c=0
Rl65 (\1\:S0 \2\:S0) resistor r=33.3481 c=0
Rl69 (\1\:D1 \2\:D1) resistor r=56.461 c=0
Rl70 (\2\:D1 \3\:D1) resistor r=87.2302 c=0
Rl52 (\1\:SI \2\:SI) resistor r=55.0028 c=0
Rl54 (\2\:SI \4\:SI) resistor r=93.4643 c=0
Rl53 (\2\:SI \3\:SI) resistor r=62.3759 c=0
Rl32 (\23\:qbint \22\:qbint) resistor r=46.131 c=0
Rl33 (\23\:qbint \24\:qbint) resistor r=57.4874 c=0
Rl49 (\8\:CKb \9\:CKb) resistor r=24.2328 c=0
Rl35 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl34 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=216.555 c=0
Rl50 (\6\:CKb \10\:CKb) resistor r=123.055 c=0
Rl48 (\7\:CKb \8\:CKb) resistor r=136.082 c=0
Rl51 (\7\:CKb \11\:CKb) resistor r=30.4507 c=0
Rl47 (\6\:CKb \7\:CKb) resistor r=163.852 c=0
Rl41 (mout \2\:mout) resistor r=84.3295 c=0
Rl43 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl42 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl45 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl44 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl36 (CKbb \2\:CKbb) resistor r=22.7584 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=141.851 c=0
Rl38 (\2\:CKbb \4\:CKbb) resistor r=71.5433 c=0
Rl39 (n20 \2\:n20) resistor r=29.5379 c=0
Rl40 (\2\:n20 \3\:n20) resistor r=71.8456 c=0
Rl56 (\3\:SEb \4\:SEb) resistor r=46.8456 c=0
Rl55 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl66 (S0b \2\:S0b) resistor r=25.6167 c=0
Rl67 (\2\:S0b \3\:S0b) resistor r=121.55 c=0
Rz24 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz28 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz19 (\4\:VDD \1\:VDD) resistor r=18.75 c=0
Rz20 (\6\:VDD \1\:VDD) resistor r=12.5 c=0
Rz21 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\20\:VDD \1\:VDD) resistor r=25 c=0
Rz23 (\21\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz11 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz10 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (\6\:dbp \7\:dbp) resistor r=75 c=0
Rz13 (\8\:dbp \9\:dbp) resistor r=75 c=0
Rz15 (db \2\:db) resistor r=75 c=0
Rz16 (\8\:db \9\:db) resistor r=75 c=0
Rz14 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz17 (\4\:S0b \5\:S0b) resistor r=75 c=0
Ry28 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry29 (\4\:VSS \1\:VSS) resistor r=15.5 c=0
Ry30 (\6\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry31 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry32 (\11\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry33 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry19 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry20 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry21 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry22 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry9 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry11 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry10 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry12 (dbp \2\:dbp) resistor r=31 c=0
Ry13 (\4\:dbp \5\:dbp) resistor r=62 c=0
Ry15 (\4\:db \5\:db) resistor r=62 c=0
Ry16 (\6\:db \7\:db) resistor r=31 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry17 (\6\:S0b \7\:S0b) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx17 (\3\:D0 \5\:D0) resistor r=45 c=0
Rx14 (\2\:SE \7\:SE) resistor r=45 c=0
Rx19 (\1\:S0 \8\:S0) resistor r=45 c=0
Rx20 (\4\:S0 \9\:S0) resistor r=45 c=0
Rx21 (\6\:S0 \10\:S0) resistor r=45 c=0
Rx18 (\2\:D1 \4\:D1) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx2 (\25\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\37\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx6 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:mout \10\:mout) resistor r=45 c=0
Rx10 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx15 (\2\:SEb \8\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:S0b \8\:S0b) resistor r=45 c=0
mn55 (Q qbint \12\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\26\:qbint n30 \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=13.9783 scb=0.013979 scc=0.000942864 m=(3)
mn20 (\15\:CKb \3\:CK \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.132e-14 ps=1.47e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn50 (net482 \24\:qbint \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=2.767e-14 ps=1.47e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.995e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn51 (\12\:n30 CKb net482 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=3.69e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1878e-07 sb=1.815e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn25 (\8\:dbp \11\:CKb \8\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.227e-14 ad=6.457e-14 ps=9.2e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9561e-06 sb=3.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn40 (\8\:mout CKbb \12\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=1.0455e-13 ps=7.7e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4378e-07 sb=1.59e-06 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn30 (\8\:mout \3\:n20 \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.915e-14 ad=1.0455e-13 ps=1.18e-06 pd=1.43e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.39878e-06 sb=1.035e-06 sd=160n \
        sca=13.0797 scb=0.0132969 scc=0.000723565 m=(1)
mn35 (net474 \4\:mout \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.915e-14 ad=1.23e-14 ps=1.18e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71378e-06 sb=7.2e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn36 (\8\:n20 \5\:CKbb net474 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.227e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81878e-06 sb=6.15e-07 sd=160n sca=13.0797 \
        scb=0.0132969 scc=0.000723565 m=(1)
mn21 (\16\:CKbb \10\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn12 (net490 \4\:SI \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=6.25e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn13 (\6\:dbp \4\:SE net490 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=5.72e-14 ps=6.4e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.41635e-07 sb=5.2e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn11 (\8\:db \3\:SEb \6\:dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=6.63e-14 ps=9.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.06635e-07 sb=2.55e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
mn10 (\10\:SEb \5\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.985e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.11276e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn1 (net498 \1\:D0 \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.985e-14 ad=6.11e-14 ps=9e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.56442e-07 sb=9.66058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (db \3\:S0b net498 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.16e-14 ps=9.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.36442e-07 sb=6.86058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (db \3\:S0 net510 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.41442e-07 sb=4.81058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (net510 \3\:D1 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=1.56e-14 ps=1.28e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.46442e-07 sb=3.76058e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:S0b \5\:S0 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.66e-14 ad=2.465e-14 ps=1.28e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21931e-06 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mp45_1__rcx (\26\:qbint n30 \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.98e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.5e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\18\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.745e-14 ad=3.01e-14 ps=1.46e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=33.2772 scb=0.0257934 \
        scc=0.00427133 m=(1)
mp50 (net409 \22\:qbint \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.745e-14 ad=3.565e-14 ps=1.46e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=1.91e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp51 (\14\:n30 \3\:CKbb net409 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.44e-14 ps=8.5e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92984e-07 sb=1.75e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp40 (\14\:n30 \3\:CKb \5\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2865e-13 ad=7.44e-14 ps=1.45e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.77984e-07 sb=1.465e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp30 (\5\:mout n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.101e-13 ad=1.2865e-13 ps=1.6e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23798e-06 sb=1.005e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp35 (net393 mout \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.101e-13 ad=5.115e-14 ps=1.6e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55298e-06 sb=6.9e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp36 (\4\:n20 \8\:CKb net393 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.115e-14 ad=6.2e-14 ps=9.5e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.76298e-06 sb=4.8e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp25 (\4\:n20 \7\:CKbb \4\:dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=6.2e-14 ps=1.09e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9525e-06 sb=2.35e-07 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(1)
mp21 (\14\:CKbb \5\:CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp12 (net417 \1\:SI \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=4.57692e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp13 (dbp SEb net417 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.40064e-07 sb=3.52692e-07 sd=160n sca=14.3987 scb=0.0130081 \
        scc=0.000814275 m=(1)
mp11 (dbp \6\:SE \4\:db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=6.24e-14 ps=1.29e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45064e-07 sb=1.47692e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp10 (\5\:SEb \1\:SE \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.71e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26047e-07 sb=1.01884e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp1 (net425 \4\:D0 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.27372e-07 sb=9.48974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp2 (\6\:db \2\:S0 net425 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.32372e-07 sb=8.43974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp3 (net429 \1\:D1 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.438e-14 ad=8.97e-14 ps=1.43e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.32372e-07 sb=3.43974e-07 sd=160n sca=14.2873 \
        scb=0.012489 scc=0.000647666 m=(1)
mp4 (\6\:db S0b net429 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=7.02e-14 ps=1.24e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.57372e-07 sb=6.18974e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp0 (\6\:S0b \7\:S0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.438e-14 ad=3.01e-14 ps=1.43e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11314e-06 sb=1.4e-07 sd=160n sca=21.7017 \
        scb=0.0235322 scc=0.00125657 m=(1)
ends SMDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (Mar 21 15:02:33 2012 )
// Library name: gsclib045
// Cell name: SRDFFNQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNQX1 CKN D ExtVDD Q RT SE SI VDD VSS
mp25 (\9\:n20 \4\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.6017 \
        scb=0.0151572 scc=0.00034109 m=(1)
C1 (D VSS) capacitor c=7.22997e-17
C2 (RT VSS) capacitor c=6.80827e-17
C3 (Q VSS) capacitor c=2.02652e-17
C4 (SI VSS) capacitor c=8.18411e-17
C5 (ExtVDD VSS) capacitor c=1.22722e-16
C6 (VDD VSS) capacitor c=6.38733e-16
C7 (SE VSS) capacitor c=8.85785e-17
C8 (CKN VSS) capacitor c=4.0383e-17
C9 (n20 VSS) capacitor c=3.87782e-17
C10 (CKNb VSS) capacitor c=2.27523e-17
C11 (CKNbb VSS) capacitor c=4.62054e-17
C12 (mout VSS) capacitor c=4.77817e-17
C13 (n35 VSS) capacitor c=1.45717e-16
C14 (SEb VSS) capacitor c=7.70786e-17
C15 (n35g VSS) capacitor c=1.77389e-17
C16 (qbint VSS) capacitor c=4.82597e-17
C17 (RTb VSS) capacitor c=3.77176e-17
C18 (Db VSS) capacitor c=9.62561e-17
C19 (n1 VSS) capacitor c=1.39914e-18
C20 (\9\:qbint VSS) capacitor c=2.81469e-17
C21 (\10\:qbint VSS) capacitor c=1.99581e-16
C22 (\14\:CKNb VSS) capacitor c=8.74219e-17
C23 (\4\:RTb VSS) capacitor c=9.8215e-17
C24 (\8\:RT VSS) capacitor c=2.17681e-17
C25 (\4\:qbint VSS) capacitor c=6.83862e-17
C26 (\3\:n35g VSS) capacitor c=4.89711e-17
C27 (\6\:RT VSS) capacitor c=7.64223e-17
C28 (\3\:SE VSS) capacitor c=7.73763e-17
C29 (\7\:CKNbb VSS) capacitor c=2.68583e-17
C30 (\3\:SI VSS) capacitor c=9.48896e-17
C31 (\4\:SE VSS) capacitor c=1.2438e-16
C32 (\4\:D VSS) capacitor c=6.85889e-17
C33 (\3\:n20 VSS) capacitor c=2.87547e-17
C34 (\4\:CKN VSS) capacitor c=4.28062e-17
C35 (\6\:CKNb VSS) capacitor c=4.12849e-17
C36 (\8\:CKNbb VSS) capacitor c=8.31866e-17
C37 (\4\:CKNb VSS) capacitor c=1.02829e-16
C38 (\6\:qbint VSS) capacitor c=3.13902e-17
C39 (\11\:qbint VSS) capacitor c=9.13763e-17
C40 (\3\:CKNbb VSS) capacitor c=3.37168e-16
C41 (\7\:RT VSS) capacitor c=1.67853e-16
C42 (\1\:RT VSS) capacitor c=3.86747e-17
C43 (\5\:qbint VSS) capacitor c=3.91065e-17
C44 (\5\:n35g VSS) capacitor c=2.90763e-17
C45 (\5\:SE VSS) capacitor c=5.6248e-17
C46 (\8\:CKNb VSS) capacitor c=2.14995e-17
C47 (\1\:SI VSS) capacitor c=4.9207e-17
C48 (\6\:SE VSS) capacitor c=8.61075e-17
C49 (\3\:SEb VSS) capacitor c=6.68829e-17
C50 (\1\:D VSS) capacitor c=4.92962e-17
C51 (\6\:n20 VSS) capacitor c=5.28842e-17
C52 (\1\:CKN VSS) capacitor c=4.24383e-17
C53 (\3\:mout VSS) capacitor c=4.55623e-17
C54 (\5\:CKNb VSS) capacitor c=2.97662e-17
C55 (\13\:CKNb VSS) capacitor c=4.98591e-17
C56 (\2\:CKNbb VSS) capacitor c=4.10227e-17
C57 (\15\:CKNb VSS) capacitor c=5.66194e-17
C58 (\12\:CKNb VSS) capacitor c=1.18282e-16
C59 (\8\:qbint VSS) capacitor c=1.06537e-16
C60 (\3\:RT VSS) capacitor c=1.67456e-16
C61 (\3\:RTb VSS) capacitor c=7.31992e-17
C62 (\4\:RT VSS) capacitor c=4.35254e-17
C63 (\2\:RT VSS) capacitor c=3.75524e-17
C64 (\3\:qbint VSS) capacitor c=3.53045e-17
C65 (\2\:RTb VSS) capacitor c=3.74519e-17
C66 (\2\:n35 VSS) capacitor c=1.65437e-16
C67 (\4\:n35g VSS) capacitor c=6.87581e-17
C68 (\3\:n35 VSS) capacitor c=4.38708e-17
C69 (\1\:SE VSS) capacitor c=2.4851e-17
C70 (\2\:SI VSS) capacitor c=7.6912e-17
C71 (\2\:SEb VSS) capacitor c=7.60526e-17
C72 (\3\:D VSS) capacitor c=1.50191e-17
C73 (\3\:CKN VSS) capacitor c=2.55894e-17
C74 (\2\:mout VSS) capacitor c=3.65021e-17
C75 (\4\:mout VSS) capacitor c=3.00949e-17
C76 (\6\:CKNbb VSS) capacitor c=4.12093e-17
C77 (\5\:n20 VSS) capacitor c=6.76494e-17
C78 (\7\:CKNb VSS) capacitor c=7.21593e-17
C79 (\11\:CKNb VSS) capacitor c=2.45483e-17
C80 (\2\:n20 VSS) capacitor c=3.95417e-17
C81 (\1\:VDD VSS) capacitor c=4.44723e-17
C82 (\10\:VDD VSS) capacitor c=2.5063e-17
C83 (\1\:Q VSS) capacitor c=6.11776e-17
C84 (\15\:n35 VSS) capacitor c=4.30878e-17
C85 (\15\:n35g VSS) capacitor c=4.74372e-17
C86 (\6\:RTb VSS) capacitor c=5.92301e-17
C87 (\1\:ExtVDD VSS) capacitor c=2.90516e-16
C88 (\10\:n35 VSS) capacitor c=5.10741e-17
C89 (\14\:qbint VSS) capacitor c=6.94887e-17
C90 (\6\:n35g VSS) capacitor c=8.66305e-17
C91 (\8\:SEb VSS) capacitor c=5.31804e-17
C92 (\8\:n35 VSS) capacitor c=4.54394e-17
C93 (\12\:VDD VSS) capacitor c=6.42702e-17
C94 (\5\:mout VSS) capacitor c=4.37343e-17
C95 (\3\:Db VSS) capacitor c=1.84368e-16
C96 (\14\:VDD VSS) capacitor c=3.70235e-17
C97 (\19\:VDD VSS) capacitor c=3.55779e-17
C98 (\16\:mout VSS) capacitor c=4.22711e-17
C99 (\22\:CKNb VSS) capacitor c=4.61448e-17
C100 (\17\:VDD VSS) capacitor c=4.47676e-17
C101 (\12\:CKNbb VSS) capacitor c=4.25696e-17
C102 (\12\:n20 VSS) capacitor c=6.13046e-17
C103 (\5\:Db VSS) capacitor c=2.09733e-16
C104 (\9\:n20 VSS) capacitor c=6.33872e-17
C105 (\3\:Q VSS) capacitor c=4.59089e-17
C106 (\18\:n35 VSS) capacitor c=6.03977e-17
C107 (\11\:n35g VSS) capacitor c=2.94932e-17
C108 (\10\:RTb VSS) capacitor c=5.24951e-17
C109 (\13\:n35 VSS) capacitor c=5.57075e-17
C110 (\16\:qbint VSS) capacitor c=2.41558e-17
C111 (\9\:n35g VSS) capacitor c=6.73499e-17
C112 (\4\:SEb VSS) capacitor c=3.83242e-17
C113 (\6\:n35 VSS) capacitor c=5.32396e-17
C114 (\12\:mout VSS) capacitor c=4.90821e-17
C115 (\14\:mout VSS) capacitor c=3.68716e-17
C116 (\18\:CKNb VSS) capacitor c=4.3066e-17
C117 (\9\:CKNbb VSS) capacitor c=3.95432e-17
C118 (\16\:n20 VSS) capacitor c=8.77901e-17
C119 (\7\:Db VSS) capacitor c=9.06842e-17
C120 (\7\:n20 VSS) capacitor c=5.93642e-17
C121 (VDD VSS) capacitor c=4.48269e-17
C122 (\2\:CKNb VSS) capacitor c=3.77322e-17
C123 (\3\:CKNb VSS) capacitor c=4.92113e-17
C124 (\2\:CKN VSS) capacitor c=3.69645e-17
C125 (\4\:n20 VSS) capacitor c=6.51284e-17
C126 (\2\:D VSS) capacitor c=3.55891e-17
C127 (\2\:SE VSS) capacitor c=2.50886e-17
C128 (\2\:n35g VSS) capacitor c=2.91602e-17
C129 (ExtVDD VSS) capacitor c=3.9548e-17
C130 (\2\:qbint VSS) capacitor c=4.00135e-17
C131 (\5\:RT VSS) capacitor c=5.10904e-17
C132 (\9\:CKNb VSS) capacitor c=1.35422e-16
C133 (\10\:CKNb VSS) capacitor c=7.67539e-17
C134 (\4\:CKNbb VSS) capacitor c=3.3387e-16
C135 (\5\:CKNbb VSS) capacitor c=8.37032e-17
C136 (\7\:qbint VSS) capacitor c=2.59416e-17
C137 (\11\:n20 VSS) capacitor c=4.64392e-17
C138 (\16\:CKNb VSS) capacitor c=9.86382e-17
C139 (\17\:CKNb VSS) capacitor c=9.72845e-17
C140 (\14\:n20 VSS) capacitor c=5.20906e-17
C141 (\15\:n20 VSS) capacitor c=9.1145e-17
C142 (\14\:CKNbb VSS) capacitor c=5.60525e-17
C143 (\15\:CKNbb VSS) capacitor c=9.10907e-17
C144 (\6\:CKN VSS) capacitor c=4.11997e-18
C145 (\7\:CKN VSS) capacitor c=3.91714e-17
C146 (\20\:CKNb VSS) capacitor c=6.20071e-17
C147 (\21\:CKNb VSS) capacitor c=5.27637e-17
C148 (\7\:mout VSS) capacitor c=6.33604e-17
C149 (\8\:mout VSS) capacitor c=3.64537e-17
C150 (\9\:mout VSS) capacitor c=2.45207e-17
C151 (\10\:mout VSS) capacitor c=4.25079e-17
C152 (\11\:mout VSS) capacitor c=4.24995e-17
C153 (\18\:mout VSS) capacitor c=2.65561e-17
C154 (\6\:SEb VSS) capacitor c=6.9518e-17
C155 (\7\:SEb VSS) capacitor c=8.00034e-17
C156 (\4\:n35 VSS) capacitor c=4.3769e-17
C157 (\5\:n35 VSS) capacitor c=7.85185e-17
C158 (\8\:n35g VSS) capacitor c=3.39476e-17
C159 (\12\:n35 VSS) capacitor c=6.04552e-17
C160 (\12\:qbint VSS) capacitor c=8.86809e-17
C161 (\13\:qbint VSS) capacitor c=1.1165e-16
C162 (\13\:n35g VSS) capacitor c=1.13189e-16
C163 (\14\:n35g VSS) capacitor c=1.16469e-16
C164 (\9\:RT VSS) capacitor c=6.72373e-17
C165 (\10\:RT VSS) capacitor c=6.13254e-17
C166 (\5\:RTb VSS) capacitor c=3.82375e-17
C167 (\8\:RTb VSS) capacitor c=1.11992e-16
C168 (\9\:RTb VSS) capacitor c=6.88077e-17
C169 (\18\:qbint VSS) capacitor c=1.81806e-17
C170 (\19\:qbint VSS) capacitor c=3.10461e-17
C171 (\24\:CKNb VSS) capacitor c=1.20908e-16
C172 (\25\:CKNb VSS) capacitor c=9.51091e-17
C173 (\17\:n35 VSS) capacitor c=6.14698e-17
C174 (\3\:VDD VSS) capacitor c=1.17731e-17
C175 (\5\:VDD VSS) capacitor c=2.14781e-16
C176 (\6\:VDD VSS) capacitor c=2.14535e-16
C177 (\7\:VDD VSS) capacitor c=2.5506e-17
C178 (\9\:VDD VSS) capacitor c=3.25118e-17
C179 (\16\:VDD VSS) capacitor c=4.75185e-17
Rk67 (\2\:VSS \4\:VSS) resistor r=0.3025 c=0
Rk68 (\4\:VSS \5\:VSS) resistor r=0.709 c=0
Rk69 (\5\:VSS \7\:VSS) resistor r=0.1891 c=0
Rk70 (\5\:VSS \8\:VSS) resistor r=0.03452 c=0
Rk73 (\9\:VSS VSS) resistor r=0.2723 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.1734 c=0
Rk72 (\9\:VSS \11\:VSS) resistor r=0.1942 c=0
Rk74 (VSS \12\:VSS) resistor r=0.3695 c=0
Rk75 (\12\:VSS \14\:VSS) resistor r=0.2387 c=0
Rk76 (\12\:VSS \15\:VSS) resistor r=0.3071 c=0
Rk77 (\15\:VSS \17\:VSS) resistor r=0.2488 c=0
Rk79 (\18\:VSS VSS) resistor r=0.1188 c=0
Rk78 (\15\:VSS \18\:VSS) resistor r=0.06676 c=0
Rk80 (VSS \20\:VSS) resistor r=0.3161 c=0
Rk94 (\22\:VSS \24\:VSS) resistor r=0.2773 c=0
Rk95 (\24\:VSS \25\:VSS) resistor r=0.682 c=0
Rk97 (\26\:VSS VSS) resistor r=0.4461 c=0
Rk96 (\25\:VSS \26\:VSS) resistor r=0.0618 c=0
Rk98 (VSS \27\:VSS) resistor r=0.7018 c=0
Rk100 (\28\:VSS VSS) resistor r=0.1188 c=0
Rk99 (\27\:VSS \28\:VSS) resistor r=0.04196 c=0
Rk101 (VSS \30\:VSS) resistor r=0.2919 c=0
Rk102 (\25\:VSS \32\:VSS) resistor r=0.3177 c=0
Rk103 (\27\:VSS \34\:VSS) resistor r=0.2398 c=0
Rk55 (\9\:RT \10\:RT) resistor r=0.4452 c=0
Rk60 (RT \11\:RT) resistor r=0.006191 c=0
Rk65 (Q \2\:Q) resistor r=0.2845 c=0
Rk66 (Q \4\:Q) resistor r=0.2212 c=0
Rk45 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk43 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk46 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk47 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk48 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02877 c=0
Rk93 (VDD VDD) resistor r=0.2356 c=0
Rk81 (\2\:VDD \3\:VDD) resistor r=0.4114 c=0
Rk82 (\3\:VDD \5\:VDD) resistor r=0.07297 c=0
Rk83 (\5\:VDD \6\:VDD) resistor r=1.495 c=0
Rk84 (\6\:VDD \7\:VDD) resistor r=0.2302 c=0
Rk85 (\7\:VDD \9\:VDD) resistor r=0.1095 c=0
Rk86 (\3\:VDD \11\:VDD) resistor r=0.2967 c=0
Rk87 (\6\:VDD \13\:VDD) resistor r=0.3661 c=0
Rk88 (\7\:VDD \15\:VDD) resistor r=0.2069 c=0
Rk92 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk89 (\9\:VDD \16\:VDD) resistor r=0.1635 c=0
Rk90 (\16\:VDD \18\:VDD) resistor r=0.2109 c=0
Rk91 (\9\:VDD \20\:VDD) resistor r=0.2349 c=0
Rk11 (\5\:CKN CKN) resistor r=0.004169 c=0
Rk12 (CKN \6\:CKN) resistor r=0.00402 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.017 c=0
Rk14 (\6\:CKN \7\:CKN) resistor r=0.02162 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2294 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4962 c=0
Rk3 (\16\:CKNb \17\:CKNb) resistor r=0.7511 c=0
Rk15 (\19\:CKNb \20\:CKNb) resistor r=0.1959 c=0
Rk16 (\20\:CKNb \21\:CKNb) resistor r=0.164 c=0
Rk17 (\20\:CKNb \23\:CKNb) resistor r=0.3045 c=0
Rk62 (\24\:CKNb \25\:CKNb) resistor r=0.865 c=0
Rk7 (\10\:CKNbb \11\:CKNbb) resistor r=0.2047 c=0
Rk8 (\11\:CKNbb \13\:CKNbb) resistor r=0.3459 c=0
Rk9 (\13\:CKNbb \14\:CKNbb) resistor r=0.1876 c=0
Rk10 (\11\:CKNbb \15\:CKNbb) resistor r=0.02352 c=0
Rk22 (\6\:mout \7\:mout) resistor r=0.2473 c=0
Rk23 (\7\:mout \8\:mout) resistor r=0.2979 c=0
Rk24 (\8\:mout \9\:mout) resistor r=0.1546 c=0
Rk25 (\9\:mout \10\:mout) resistor r=0.276 c=0
Rk26 (\10\:mout \11\:mout) resistor r=0.3228 c=0
Rk27 (\7\:mout \13\:mout) resistor r=0.4826 c=0
Rk28 (\8\:mout \15\:mout) resistor r=0.4166 c=0
Rk29 (\9\:mout \17\:mout) resistor r=0.207 c=0
Rk30 (\10\:mout \18\:mout) resistor r=0.08796 c=0
Rk36 (\4\:n35 \5\:n35) resistor r=0.4438 c=0
Rk37 (\5\:n35 \7\:n35) resistor r=0.4427 c=0
Rk38 (\5\:n35 \9\:n35) resistor r=0.2871 c=0
Rk41 (\11\:n35 \12\:n35) resistor r=0.2725 c=0
Rk42 (\12\:n35 \14\:n35) resistor r=0.3277 c=0
Rk63 (\16\:n35 \17\:n35) resistor r=0.1704 c=0
Rk64 (\17\:n35 \19\:n35) resistor r=0.4274 c=0
Rk33 (\5\:SEb \6\:SEb) resistor r=0.202 c=0
Rk34 (\6\:SEb \7\:SEb) resistor r=0.3837 c=0
Rk35 (\6\:SEb \9\:SEb) resistor r=0.2944 c=0
Rk39 (\7\:n35g \8\:n35g) resistor r=0.2295 c=0
Rk40 (\7\:n35g \10\:n35g) resistor r=0.5918 c=0
Rk52 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk53 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk54 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk49 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk50 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk51 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk61 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk56 (\5\:RTb \7\:RTb) resistor r=0.2266 c=0
Rk57 (\7\:RTb \8\:RTb) resistor r=0.2733 c=0
Rk58 (\8\:RTb \9\:RTb) resistor r=0.6753 c=0
Rk59 (\8\:RTb \11\:RTb) resistor r=0.3344 c=0
Rk19 (\2\:Db \4\:Db) resistor r=0.5996 c=0
Rk20 (\4\:Db \6\:Db) resistor r=1.3537 c=0
Rk21 (\6\:Db \8\:Db) resistor r=0.5686 c=0
Rl19 (\2\:D \4\:D) resistor r=115.099 c=0
Rl17 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl18 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl43 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl40 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl34 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl44 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl42 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl41 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl23 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl22 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl26 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl28 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl25 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl27 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl24 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl13 (\2\:CKN \4\:CKN) resistor r=70.868 c=0
Rl11 (\1\:CKN \2\:CKN) resistor r=140.099 c=0
Rl12 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=83.1175 c=0
Rl16 (\4\:n20 \6\:n20) resistor r=197.322 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=244.414 c=0
Rl52 (\14\:CKNb \15\:CKNb) resistor r=115.79 c=0
Rl8 (\4\:CKNb \7\:CKNb) resistor r=330.626 c=0
Rl3 (CKNb \2\:CKNb) resistor r=0.6084 c=0
Rl6 (\2\:CKNb \5\:CKNb) resistor r=73.8796 c=0
Rl7 (\3\:CKNb \6\:CKNb) resistor r=36.5135 c=0
Rl5 (\3\:CKNb \4\:CKNb) resistor r=174.664 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=95.0085 c=0
Rl45 (\8\:CKNb \9\:CKNb) resistor r=66.1349 c=0
Rl48 (\9\:CKNb \12\:CKNb) resistor r=866.299 c=0
Rl49 (\10\:CKNb \13\:CKNb) resistor r=60.7265 c=0
Rl47 (\10\:CKNb \11\:CKNb) resistor r=81.3209 c=0
Rl46 (\9\:CKNb \10\:CKNb) resistor r=462.851 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=148.93 c=0
Rl56 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl53 (\3\:CKNbb \4\:CKNbb) resistor r=1432.7 c=0
Rl57 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl55 (\5\:CKNbb \6\:CKNbb) resistor r=81.3688 c=0
Rl54 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl9 (mout \2\:mout) resistor r=24.2328 c=0
Rl10 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl50 (n35 \2\:n35) resistor r=499.328 c=0
Rl51 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl31 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl29 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl30 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl32 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl62 (\10\:qbint \11\:qbint) resistor r=235.906 c=0
Rl61 (\8\:qbint \10\:qbint) resistor r=601.135 c=0
Rl39 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl36 (qbint \2\:qbint) resistor r=112.732 c=0
Rl38 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl60 (\7\:qbint \9\:qbint) resistor r=68.607 c=0
Rl58 (\6\:qbint \7\:qbint) resistor r=78.0039 c=0
Rl59 (\7\:qbint \8\:qbint) resistor r=166.462 c=0
Rl35 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl33 (RTb \2\:RTb) resistor r=124.312 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz20 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz21 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz27 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz28 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz29 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz30 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz18 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz7 (\12\:mout \13\:mout) resistor r=75 c=0
Rz8 (\14\:mout \15\:mout) resistor r=75 c=0
Rz10 (\6\:n35 \7\:n35) resistor r=75 c=0
Rz12 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz17 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry24 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry25 (\3\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry32 (\23\:VSS \24\:VSS) resistor r=20.6667 c=0
Ry33 (\23\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry34 (\23\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry22 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry27 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry28 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry29 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry4 (\22\:CKNb \23\:CKNb) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry12 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry21 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Rx10 (\3\:D D) resistor r=45 c=0
Rx21 (\4\:RT \9\:RT) resistor r=45 c=0
Rx22 (\2\:RT \10\:RT) resistor r=45 c=0
Rx25 (\3\:RT \11\:RT) resistor r=45 c=0
Rx13 (\2\:SI SI) resistor r=45 c=0
Rx14 (\1\:SE SE) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\7\:CKNb \16\:CKNb) resistor r=45 c=0
Rx3 (\11\:CKNb \17\:CKNb) resistor r=45 c=0
Rx9 (CKNb \21\:CKNb) resistor r=45 c=0
Rx28 (\15\:CKNb \24\:CKNb) resistor r=45 c=0
Rx29 (\12\:CKNb \25\:CKNb) resistor r=45 c=0
Rx6 (\6\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx7 (CKNbb \15\:CKNbb) resistor r=45 c=0
Rx11 (\4\:mout \11\:mout) resistor r=45 c=0
Rx12 (\2\:mout \18\:mout) resistor r=45 c=0
Rx16 (\3\:n35 \4\:n35) resistor r=45 c=0
Rx18 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx30 (n35 \17\:n35) resistor r=45 c=0
Rx15 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx17 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx20 (n35g \14\:n35g) resistor r=45 c=0
Rx19 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx26 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx27 (qbint \19\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (\2\:RTb \9\:RTb) resistor r=45 c=0
mn25 (\7\:Db \2\:CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \13\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.1e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\9\:CKNbb \5\:CKNb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=8.7e-15 ps=7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.05e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\18\:CKNb \1\:CKN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\14\:mout \6\:n20 \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\6\:n35 \8\:CKNb \12\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn10 (\4\:SEb \5\:SE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn45 (\16\:qbint \5\:n35g \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \1\:RT \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.97e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 \3\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net0119 \11\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\3\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.81232 \
        scb=0.00143001 scc=2.43069e-06 m=(1)
mp21 (\12\:CKNbb \6\:CKNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.44154 \
        scb=0.00123191 scc=2.30905e-06 m=(1)
mp20 (\22\:CKNb \4\:CKN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\16\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.41289 \
        scb=0.00122082 scc=2.30567e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\8\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.5649 \
        scb=0.0251664 scc=0.00264914 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
PM1 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \14\:CKNb net0107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=28.6011 \
        scb=0.0298676 scc=0.0026875 m=(1)
mp52 (net0107 \10\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=19.4537 \
        scb=0.0214753 scc=0.000585924 m=(1)
mp55 (\1\:Q \9\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.9069 \
        scb=0.0255526 scc=0.000831054 m=(1)
ends SRDFFNQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:58:00 2012 )
// Library name: gsclib045
// Cell name: SRDFFNRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNRQX1 CKN D ExtVDD Q RN RT SE SI VDD VSS
mp22 (\10\:RNb \1\:RN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (SI VSS) capacitor c=8.72957e-17
C2 (RN VSS) capacitor c=8.17943e-17
C3 (RT VSS) capacitor c=3.75399e-17
C4 (Q VSS) capacitor c=2.28683e-17
C5 (VDD VSS) capacitor c=6.52423e-16
C6 (SE VSS) capacitor c=3.95426e-17
C7 (CKN VSS) capacitor c=3.77416e-17
C8 (ExtVDD VSS) capacitor c=2.3501e-16
C9 (D VSS) capacitor c=4.57199e-17
C10 (n20 VSS) capacitor c=3.89483e-17
C11 (CKNb VSS) capacitor c=4.45691e-17
C12 (mout VSS) capacitor c=4.94333e-17
C13 (CKNbb VSS) capacitor c=3.23187e-17
C14 (RNb VSS) capacitor c=2.7463e-16
C15 (SEb VSS) capacitor c=7.75108e-17
C16 (n35g VSS) capacitor c=1.7772e-17
C17 (qbint VSS) capacitor c=4.57473e-17
C18 (RTb VSS) capacitor c=5.17873e-17
C19 (n35 VSS) capacitor c=1.3462e-16
C20 (Db VSS) capacitor c=1.04956e-16
C21 (n10 VSS) capacitor c=6.36691e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:RNb VSS) capacitor c=1.00899e-16
C24 (\9\:qbint VSS) capacitor c=2.81705e-17
C25 (\10\:qbint VSS) capacitor c=2.20981e-16
C26 (\12\:CKNb VSS) capacitor c=9.86081e-17
C27 (\4\:RTb VSS) capacitor c=9.87178e-17
C28 (\6\:RT VSS) capacitor c=2.21451e-17
C29 (\4\:qbint VSS) capacitor c=5.35397e-17
C30 (\3\:n35g VSS) capacitor c=5.23114e-17
C31 (\5\:RT VSS) capacitor c=8.4067e-17
C32 (\3\:SE VSS) capacitor c=7.72718e-17
C33 (\7\:CKNbb VSS) capacitor c=3.23122e-17
C34 (\3\:SI VSS) capacitor c=9.47876e-17
C35 (\4\:SE VSS) capacitor c=1.22206e-16
C36 (\4\:D VSS) capacitor c=6.88408e-17
C37 (\5\:RNb VSS) capacitor c=6.65004e-17
C38 (\5\:n20 VSS) capacitor c=1.21049e-16
C39 (\4\:CKN VSS) capacitor c=5.39794e-17
C40 (\4\:CKNb VSS) capacitor c=4.53327e-17
C41 (\8\:CKNbb VSS) capacitor c=8.28499e-17
C42 (\3\:CKNb VSS) capacitor c=1.09071e-16
C43 (\1\:RN VSS) capacitor c=4.2139e-17
C44 (\8\:RNb VSS) capacitor c=8.56207e-17
C45 (\6\:qbint VSS) capacitor c=3.15639e-17
C46 (\11\:qbint VSS) capacitor c=8.89948e-17
C47 (\9\:CKNbb VSS) capacitor c=2.13298e-16
C48 (\8\:RT VSS) capacitor c=1.28609e-16
C49 (\2\:RT VSS) capacitor c=6.21538e-17
C50 (\5\:qbint VSS) capacitor c=3.87694e-17
C51 (\5\:n35g VSS) capacitor c=3.28917e-17
C52 (\2\:RTb VSS) capacitor c=4.79204e-17
C53 (\5\:SE VSS) capacitor c=5.7887e-17
C54 (\10\:CKNb VSS) capacitor c=2.52869e-17
C55 (\1\:SI VSS) capacitor c=4.91308e-17
C56 (\6\:SE VSS) capacitor c=8.62004e-17
C57 (\3\:SEb VSS) capacitor c=6.60658e-17
C58 (\1\:D VSS) capacitor c=4.95201e-17
C59 (\6\:RNb VSS) capacitor c=5.09058e-17
C60 (\3\:n20 VSS) capacitor c=8.28417e-17
C61 (\1\:CKN VSS) capacitor c=2.85144e-17
C62 (\3\:mout VSS) capacitor c=5.00666e-17
C63 (\11\:CKNb VSS) capacitor c=4.89185e-17
C64 (\4\:RN VSS) capacitor c=3.6922e-17
C65 (\8\:qbint VSS) capacitor c=1.041e-16
C66 (\13\:CKNb VSS) capacitor c=6.71982e-17
C67 (\9\:RNb VSS) capacitor c=6.11895e-17
C68 (\7\:RT VSS) capacitor c=1.51736e-16
C69 (\6\:CKNb VSS) capacitor c=1.64527e-16
C70 (\3\:RT VSS) capacitor c=5.4998e-17
C71 (\1\:RT VSS) capacitor c=5.27439e-17
C72 (\3\:RTb VSS) capacitor c=7.6147e-17
C73 (\3\:qbint VSS) capacitor c=4.44119e-17
C74 (\2\:n35 VSS) capacitor c=1.90399e-16
C75 (\4\:n35g VSS) capacitor c=6.72362e-17
C76 (\3\:CKNbb VSS) capacitor c=5.52799e-17
C77 (\10\:CKNbb VSS) capacitor c=2.07004e-16
C78 (\3\:n35 VSS) capacitor c=9.08061e-17
C79 (\1\:SE VSS) capacitor c=2.48251e-17
C80 (\2\:SI VSS) capacitor c=7.76783e-17
C81 (\2\:SEb VSS) capacitor c=7.74514e-17
C82 (\3\:D VSS) capacitor c=1.46671e-17
C83 (\3\:CKN VSS) capacitor c=2.40654e-17
C84 (\2\:mout VSS) capacitor c=3.7982e-17
C85 (\4\:mout VSS) capacitor c=4.33186e-17
C86 (\2\:CKNb VSS) capacitor c=7.99081e-17
C87 (\6\:CKNbb VSS) capacitor c=3.6548e-17
C88 (\6\:n20 VSS) capacitor c=1.04681e-16
C89 (\4\:n20 VSS) capacitor c=6.91974e-17
C90 (\2\:CKNbb VSS) capacitor c=5.81601e-17
C91 (\5\:CKNb VSS) capacitor c=7.97258e-17
C92 (\9\:CKNb VSS) capacitor c=2.72997e-17
C93 (\4\:RNb VSS) capacitor c=9.93053e-17
C94 (\2\:n20 VSS) capacitor c=4.55775e-17
C95 (\3\:RN VSS) capacitor c=4.82646e-17
C96 (\1\:VDD VSS) capacitor c=2.43855e-17
C97 (\10\:VDD VSS) capacitor c=4.39786e-17
C98 (\4\:Q VSS) capacitor c=6.2863e-17
C99 (\14\:n35 VSS) capacitor c=5.68374e-17
C100 (\15\:n35g VSS) capacitor c=5.76971e-17
C101 (\6\:RTb VSS) capacitor c=7.20391e-17
C102 (\1\:ExtVDD VSS) capacitor c=2.78003e-16
C103 (\9\:n35 VSS) capacitor c=6.15721e-17
C104 (\14\:qbint VSS) capacitor c=6.81232e-17
C105 (\6\:n35g VSS) capacitor c=9.40514e-17
C106 (\8\:SEb VSS) capacitor c=5.05319e-17
C107 (\4\:n35 VSS) capacitor c=6.36367e-17
C108 (\12\:VDD VSS) capacitor c=6.06936e-17
C109 (\5\:mout VSS) capacitor c=7.31091e-17
C110 (\3\:Db VSS) capacitor c=1.83498e-16
C111 (\14\:VDD VSS) capacitor c=2.98062e-17
C112 (\19\:VDD VSS) capacitor c=3.54032e-17
C113 (\13\:mout VSS) capacitor c=5.17159e-17
C114 (\20\:CKNb VSS) capacitor c=2.97998e-17
C115 (\17\:VDD VSS) capacitor c=4.24614e-17
C116 (\12\:CKNbb VSS) capacitor c=5.87913e-17
C117 (\12\:n20 VSS) capacitor c=6.24742e-17
C118 (\5\:Db VSS) capacitor c=2.27603e-16
C119 (\10\:RNb VSS) capacitor c=5.04134e-17
C120 (\9\:n20 VSS) capacitor c=6.33369e-17
C121 (\21\:VDD VSS) capacitor c=4.24098e-17
C122 (\3\:VDD VSS) capacitor c=2.3619e-16
C123 (\1\:Q VSS) capacitor c=3.39752e-17
C124 (\3\:n10 VSS) capacitor c=7.9996e-17
C125 (\17\:n35 VSS) capacitor c=7.30793e-17
C126 (\11\:n35g VSS) capacitor c=2.72594e-17
C127 (\10\:RTb VSS) capacitor c=5.79526e-17
C128 (\12\:n35 VSS) capacitor c=6.3485e-17
C129 (\16\:qbint VSS) capacitor c=2.43025e-17
C130 (\9\:n35g VSS) capacitor c=8.05092e-17
C131 (\4\:SEb VSS) capacitor c=3.82428e-17
C132 (\7\:n35 VSS) capacitor c=4.10685e-17
C133 (\11\:mout VSS) capacitor c=2.63954e-17
C134 (\15\:mout VSS) capacitor c=4.00685e-17
C135 (\16\:CKNb VSS) capacitor c=5.34643e-17
C136 (\15\:CKNbb VSS) capacitor c=5.93281e-17
C137 (\17\:n20 VSS) capacitor c=5.27563e-17
C138 (\7\:Db VSS) capacitor c=1.10338e-16
C139 (\13\:RNb VSS) capacitor c=7.34786e-17
C140 (\7\:n20 VSS) capacitor c=5.95553e-17
C141 (VDD VSS) capacitor c=7.17577e-17
C142 (\2\:CKN VSS) capacitor c=3.47054e-17
C143 (\2\:D VSS) capacitor c=3.53727e-17
C144 (\2\:SE VSS) capacitor c=2.51114e-17
C145 (\4\:CKNbb VSS) capacitor c=1.49551e-16
C146 (\5\:CKNbb VSS) capacitor c=8.72708e-17
C147 (\2\:n35g VSS) capacitor c=2.90794e-17
C148 (\4\:RT VSS) capacitor c=7.44104e-17
C149 (\2\:qbint VSS) capacitor c=4.14784e-17
C150 (\7\:CKNb VSS) capacitor c=1.22521e-16
C151 (\8\:CKNb VSS) capacitor c=8.12993e-17
C152 (\2\:RNb VSS) capacitor c=1.77701e-16
C153 (\3\:RNb VSS) capacitor c=1.03929e-16
C154 (\11\:n20 VSS) capacitor c=4.63635e-17
C155 (\7\:qbint VSS) capacitor c=3.87674e-17
C156 (\12\:RNb VSS) capacitor c=1.19811e-16
C157 (\14\:CKNb VSS) capacitor c=1.55474e-16
C158 (\15\:CKNb VSS) capacitor c=1.38098e-16
C159 (\14\:n20 VSS) capacitor c=7.54562e-17
C160 (\15\:n20 VSS) capacitor c=6.15157e-17
C161 (\16\:n20 VSS) capacitor c=5.98052e-17
C162 (\11\:CKNbb VSS) capacitor c=5.36369e-17
C163 (\14\:CKNbb VSS) capacitor c=8.14966e-17
C164 (\7\:CKN VSS) capacitor c=3.39728e-17
C165 (\18\:CKNb VSS) capacitor c=6.96727e-17
C166 (\19\:CKNb VSS) capacitor c=4.27993e-17
C167 (\6\:D VSS) capacitor c=4.80182e-17
C168 (\7\:mout VSS) capacitor c=8.27115e-17
C169 (\9\:mout VSS) capacitor c=6.46765e-17
C170 (\10\:mout VSS) capacitor c=5.26265e-17
C171 (\17\:mout VSS) capacitor c=4.53976e-17
C172 (\7\:SE VSS) capacitor c=5.24686e-17
C173 (\6\:SEb VSS) capacitor c=8.17114e-17
C174 (\7\:SEb VSS) capacitor c=6.72953e-17
C175 (\6\:n35 VSS) capacitor c=7.90922e-17
C176 (\17\:CKNbb VSS) capacitor c=3.96414e-17
C177 (\18\:CKNbb VSS) capacitor c=4.2063e-17
C178 (\8\:n35g VSS) capacitor c=3.48863e-17
C179 (\11\:n35 VSS) capacitor c=7.50013e-17
C180 (\12\:qbint VSS) capacitor c=8.77437e-17
C181 (\13\:qbint VSS) capacitor c=1.12023e-16
C182 (\13\:n35g VSS) capacitor c=1.04634e-16
C183 (\14\:n35g VSS) capacitor c=1.15912e-16
C184 (\5\:RTb VSS) capacitor c=4.92957e-17
C185 (\8\:RTb VSS) capacitor c=1.00061e-16
C186 (\9\:RTb VSS) capacitor c=9.13858e-17
C187 (\9\:RT VSS) capacitor c=1.19039e-16
C188 (\10\:RT VSS) capacitor c=1.18186e-16
C189 (\11\:RT VSS) capacitor c=3.80585e-17
C190 (\15\:RNb VSS) capacitor c=1.13564e-16
C191 (\16\:RNb VSS) capacitor c=1.13929e-16
C192 (\22\:CKNb VSS) capacitor c=1.5381e-16
C193 (\23\:CKNb VSS) capacitor c=1.43916e-16
C194 (\18\:qbint VSS) capacitor c=2.25365e-17
C195 (\19\:qbint VSS) capacitor c=3.20899e-17
C196 (\16\:n35 VSS) capacitor c=8.97661e-17
C197 (\3\:Q VSS) capacitor c=2.09829e-17
C198 (\6\:VDD VSS) capacitor c=1.99148e-16
C199 (\7\:VDD VSS) capacitor c=2.23268e-17
C200 (\9\:VDD VSS) capacitor c=2.85155e-17
C201 (\16\:VDD VSS) capacitor c=4.51087e-17
Rk35 (\4\:SI SI) resistor r=0.006943 c=0
Rk1 (\5\:RN RN) resistor r=0.006385 c=0
Rk62 (RT \9\:RT) resistor r=0.1847 c=0
Rk63 (\9\:RT \10\:RT) resistor r=0.6593 c=0
Rk64 (RT \11\:RT) resistor r=0.01483 c=0
Rk71 (\3\:Q Q) resistor r=0.02445 c=0
Rk70 (\2\:Q \3\:Q) resistor r=0.206 c=0
Rk72 (\3\:Q \5\:Q) resistor r=0.3713 c=0
Rk86 (VDD VDD) resistor r=0.2369 c=0
Rk74 (\2\:VDD \4\:VDD) resistor r=0.2907 c=0
Rk75 (\4\:VDD \5\:VDD) resistor r=0.1196 c=0
Rk76 (\5\:VDD \6\:VDD) resistor r=1.5124 c=0
Rk77 (\6\:VDD \7\:VDD) resistor r=0.2384 c=0
Rk78 (\7\:VDD \9\:VDD) resistor r=0.1024 c=0
Rk79 (\4\:VDD \11\:VDD) resistor r=0.3603 c=0
Rk80 (\6\:VDD \13\:VDD) resistor r=0.3682 c=0
Rk81 (\7\:VDD \15\:VDD) resistor r=0.2001 c=0
Rk85 (\16\:VDD VDD) resistor r=0.1961 c=0
Rk82 (\9\:VDD \16\:VDD) resistor r=0.1715 c=0
Rk83 (\16\:VDD \18\:VDD) resistor r=0.2027 c=0
Rk84 (\9\:VDD \20\:VDD) resistor r=0.2362 c=0
Rk87 (VDD \22\:VDD) resistor r=0.3797 c=0
Rk36 (SE \7\:SE) resistor r=0.04331 c=0
Rk14 (CKN \5\:CKN) resistor r=0.001978 c=0
Rk17 (\5\:CKN \6\:CKN) resistor r=0.01152 c=0
Rk16 (\6\:CKN \7\:CKN) resistor r=0.005219 c=0
Rk49 (ExtVDD ExtVDD) resistor r=0.002067 c=0
Rk47 (\2\:ExtVDD ExtVDD) resistor r=0.02221 c=0
Rk50 (ExtVDD \5\:ExtVDD) resistor r=0.02019 c=0
Rk51 (ExtVDD \6\:ExtVDD) resistor r=0.15 c=0
Rk21 (\5\:D D) resistor r=0.007222 c=0
Rk23 (\5\:D \7\:D) resistor r=0.01656 c=0
Rk22 (\6\:D \7\:D) resistor r=0.007222 c=0
Rk88 (\2\:VSS \3\:VSS) resistor r=0.0421 c=0
Rk89 (\3\:VSS \4\:VSS) resistor r=0.1068 c=0
Rk90 (\4\:VSS \5\:VSS) resistor r=0.6641 c=0
Rk91 (\5\:VSS \6\:VSS) resistor r=0.03215 c=0
Rk93 (\7\:VSS VSS) resistor r=0.2707 c=0
Rk92 (\6\:VSS \7\:VSS) resistor r=0.1764 c=0
Rk94 (VSS \8\:VSS) resistor r=0.3732 c=0
Rk95 (\8\:VSS \9\:VSS) resistor r=0.3081 c=0
Rk97 (\10\:VSS VSS) resistor r=0.1217 c=0
Rk96 (\9\:VSS \10\:VSS) resistor r=0.06449 c=0
Rk98 (VSS \12\:VSS) resistor r=0.3134 c=0
Rk99 (\3\:VSS \14\:VSS) resistor r=0.262 c=0
Rk100 (\5\:VSS \16\:VSS) resistor r=0.1902 c=0
Rk101 (\7\:VSS \18\:VSS) resistor r=0.1953 c=0
Rk102 (\8\:VSS \20\:VSS) resistor r=0.2547 c=0
Rk103 (\9\:VSS \22\:VSS) resistor r=0.2503 c=0
Rk104 (\24\:VSS \25\:VSS) resistor r=0.08688 c=0
Rk105 (\25\:VSS \26\:VSS) resistor r=0.311 c=0
Rk106 (\26\:VSS \27\:VSS) resistor r=0.3185 c=0
Rk108 (\28\:VSS VSS) resistor r=0.1988 c=0
Rk107 (\27\:VSS \28\:VSS) resistor r=0.3282 c=0
Rk109 (VSS \29\:VSS) resistor r=0.6817 c=0
Rk111 (\30\:VSS VSS) resistor r=0.1217 c=0
Rk110 (\29\:VSS \30\:VSS) resistor r=0.06449 c=0
Rk112 (VSS \31\:VSS) resistor r=0.01747 c=0
Rk113 (\31\:VSS \33\:VSS) resistor r=0.6655 c=0
Rk114 (\25\:VSS \35\:VSS) resistor r=0.2482 c=0
Rk115 (\27\:VSS \37\:VSS) resistor r=0.2448 c=0
Rk116 (\29\:VSS \39\:VSS) resistor r=0.2412 c=0
Rk117 (\31\:VSS \41\:VSS) resistor r=0.2412 c=0
Rk2 (\8\:n20 \10\:n20) resistor r=0.546 c=0
Rk3 (\10\:n20 \11\:n20) resistor r=0.2555 c=0
Rk7 (\13\:n20 \14\:n20) resistor r=0.3473 c=0
Rk8 (\13\:n20 \15\:n20) resistor r=0.2307 c=0
Rk9 (\15\:n20 \16\:n20) resistor r=0.2517 c=0
Rk10 (\16\:n20 \18\:n20) resistor r=0.2474 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8535 c=0
Rk18 (\17\:CKNb \18\:CKNb) resistor r=0.3246 c=0
Rk19 (\18\:CKNb \19\:CKNb) resistor r=0.1843 c=0
Rk20 (\18\:CKNb \21\:CKNb) resistor r=0.1875 c=0
Rk66 (\22\:CKNb \23\:CKNb) resistor r=0.9488 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.6054 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.5102 c=0
Rk29 (\8\:mout \9\:mout) resistor r=0.04826 c=0
Rk30 (\9\:mout \10\:mout) resistor r=0.198 c=0
Rk31 (\7\:mout \12\:mout) resistor r=0.1285 c=0
Rk32 (\8\:mout \14\:mout) resistor r=0.5423 c=0
Rk33 (\9\:mout \16\:mout) resistor r=0.1048 c=0
Rk34 (\10\:mout \17\:mout) resistor r=0.3958 c=0
Rk11 (\11\:CKNbb \13\:CKNbb) resistor r=0.1427 c=0
Rk12 (\13\:CKNbb \14\:CKNbb) resistor r=0.4231 c=0
Rk13 (\14\:CKNbb \16\:CKNbb) resistor r=0.2375 c=0
Rk42 (\17\:CKNbb \18\:CKNbb) resistor r=0.3735 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1643 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3826 c=0
Rk65 (\15\:RNb \16\:RNb) resistor r=0.6792 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.2181 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3488 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.3114 c=0
Rk43 (\7\:n35g \8\:n35g) resistor r=0.2748 c=0
Rk44 (\7\:n35g \10\:n35g) resistor r=0.6952 c=0
Rk55 (\12\:n35g \13\:n35g) resistor r=0.2443 c=0
Rk56 (\13\:n35g \14\:n35g) resistor r=0.5686 c=0
Rk57 (\13\:n35g \16\:n35g) resistor r=0.4343 c=0
Rk52 (\12\:qbint \13\:qbint) resistor r=0.4973 c=0
Rk53 (\13\:qbint \15\:qbint) resistor r=0.5702 c=0
Rk54 (\13\:qbint \17\:qbint) resistor r=0.1471 c=0
Rk67 (\18\:qbint \19\:qbint) resistor r=0.2424 c=0
Rk58 (\5\:RTb \7\:RTb) resistor r=0.2174 c=0
Rk59 (\7\:RTb \8\:RTb) resistor r=0.4188 c=0
Rk60 (\8\:RTb \9\:RTb) resistor r=0.6924 c=0
Rk61 (\8\:RTb \11\:RTb) resistor r=0.3083 c=0
Rk40 (\5\:n35 \6\:n35) resistor r=0.412 c=0
Rk41 (\6\:n35 \8\:n35) resistor r=0.2919 c=0
Rk45 (\10\:n35 \11\:n35) resistor r=0.4031 c=0
Rk46 (\11\:n35 \13\:n35) resistor r=0.3317 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.4129 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.3473 c=0
Rk24 (\2\:Db \4\:Db) resistor r=0.6398 c=0
Rk25 (\4\:Db \6\:Db) resistor r=1.363 c=0
Rk26 (\6\:Db \8\:Db) resistor r=0.6354 c=0
Rk73 (\2\:n10 \4\:n10) resistor r=0.5717 c=0
Rl23 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl22 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl53 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl40 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl43 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl42 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl41 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl26 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl28 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl25 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl27 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl24 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl19 (\2\:D \4\:D) resistor r=115.099 c=0
Rl17 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl18 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl16 (\5\:n20 \6\:n20) resistor r=285.406 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=208.269 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\12\:CKNb \13\:CKNb) resistor r=213.245 c=0
Rl6 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl51 (\7\:CKNb \10\:CKNb) resistor r=65.3159 c=0
Rl48 (\6\:CKNb \7\:CKNb) resistor r=753.137 c=0
Rl52 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl50 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl49 (\7\:CKNb \8\:CKNb) resistor r=455.369 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\9\:CKNbb \10\:CKNbb) resistor r=804.248 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl32 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl29 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl33 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl31 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl30 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl68 (\7\:RNb \8\:RNb) resistor r=233.721 c=0
Rl69 (\8\:RNb \9\:RNb) resistor r=267.896 c=0
Rl54 (RNb \2\:RNb) resistor r=1075.02 c=0
Rl57 (\2\:RNb \5\:RNb) resistor r=114.179 c=0
Rl58 (\3\:RNb \6\:RNb) resistor r=153.384 c=0
Rl56 (\3\:RNb \4\:RNb) resistor r=293.646 c=0
Rl55 (\2\:RNb \3\:RNb) resistor r=46.238 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl36 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl37 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl67 (\10\:qbint \11\:qbint) resistor r=260.089 c=0
Rl66 (\8\:qbint \10\:qbint) resistor r=512.697 c=0
Rl47 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl44 (qbint \2\:qbint) resistor r=112.732 c=0
Rl46 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl45 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl65 (\7\:qbint \9\:qbint) resistor r=70.3116 c=0
Rl63 (\6\:qbint \7\:qbint) resistor r=76.2993 c=0
Rl64 (\7\:qbint \8\:qbint) resistor r=254.112 c=0
Rl38 (RTb \2\:RTb) resistor r=112.412 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (n35 \2\:n35) resistor r=442.189 c=0
Rl60 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz22 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz23 (\3\:VDD \5\:VDD) resistor r=25 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz27 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz28 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz29 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz30 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \41\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz11 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz20 (n10 \2\:n10) resistor r=75 c=0
Rz21 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry21 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry23 (\10\:VDD \11\:VDD) resistor r=20.6667 c=0
Ry24 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry25 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry26 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry28 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry30 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry31 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry32 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry33 (\23\:VSS \24\:VSS) resistor r=31 c=0
Ry34 (\23\:VSS \26\:VSS) resistor r=10.3333 c=0
Ry35 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry36 (\23\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry3 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx28 (\3\:RT \9\:RT) resistor r=45 c=0
Rx29 (\1\:RT \10\:RT) resistor r=45 c=0
Rx30 (\7\:RT \11\:RT) resistor r=45 c=0
Rx17 (\1\:SE \7\:SE) resistor r=45 c=0
Rx11 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx2 (n20 \11\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx7 (\6\:n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:n20 \16\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx12 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx33 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx34 (\6\:CKNb \23\:CKNb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \17\:mout) resistor r=45 c=0
Rx9 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx10 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx20 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx21 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx3 (\4\:RNb \12\:RNb) resistor r=45 c=0
Rx31 (RNb \15\:RNb) resistor r=45 c=0
Rx32 (\9\:RNb \16\:RNb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx35 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx36 (qbint \19\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\15\:mout \6\:RNb \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \10\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (\3\:n10 \11\:qbint \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n10 \8\:RNb \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\9\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\12\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.17022 \
        scb=0.00118687 scc=2.51048e-06 m=(1)
mp31 (n5 \5\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.5373 \
        scb=0.0297678 scc=0.00268647 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=19.3315 \
        scb=0.0212584 scc=0.000579348 m=(1)
mp55 (\4\:Q \9\:qbint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.4029 \
        scb=0.0248226 scc=0.000748112 m=(1)
mp51 (n9 \7\:RNb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=19.1728 \
        scb=0.0210507 scc=0.000546994 m=(1)
ends SRDFFNRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:58:47 2012 )
// Library name: gsclib045
// Cell name: SRDFFNRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNRX1 CKN D ExtVDD Q QN RN RT SE SI VDD VSS
mp22 (\8\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (ExtVDD VSS) capacitor c=2.30565e-16
C2 (RN VSS) capacitor c=8.36151e-17
C3 (RT VSS) capacitor c=2.13906e-17
C4 (SI VSS) capacitor c=5.24843e-17
C5 (Q VSS) capacitor c=6.20497e-17
C6 (VDD VSS) capacitor c=7.52642e-16
C7 (QN VSS) capacitor c=2.2552e-17
C8 (SE VSS) capacitor c=3.9618e-17
C9 (CKN VSS) capacitor c=3.89934e-17
C10 (D VSS) capacitor c=9.38582e-17
C11 (n20 VSS) capacitor c=3.89358e-17
C12 (CKNb VSS) capacitor c=4.45694e-17
C13 (mout VSS) capacitor c=4.79505e-17
C14 (CKNbb VSS) capacitor c=3.23553e-17
C15 (RNb VSS) capacitor c=5.78139e-17
C16 (SEb VSS) capacitor c=7.74985e-17
C17 (n35g VSS) capacitor c=1.77753e-17
C18 (qbint VSS) capacitor c=4.54407e-17
C19 (RTb VSS) capacitor c=5.18061e-17
C20 (net573 VSS) capacitor c=2.25772e-17
C21 (n35 VSS) capacitor c=1.5135e-16
C22 (Db VSS) capacitor c=1.05128e-16
C23 (n11 VSS) capacitor c=6.28931e-17
C24 (n10 VSS) capacitor c=7.48782e-17
C25 (n1 VSS) capacitor c=1.02126e-18
C26 (\7\:qbint VSS) capacitor c=3.36193e-17
C27 (\11\:qbint VSS) capacitor c=1.20293e-16
C28 (\2\:RNb VSS) capacitor c=3.6912e-16
C29 (\13\:qbint VSS) capacitor c=4.38863e-17
C30 (\3\:net573 VSS) capacitor c=5.86653e-17
C31 (\12\:CKNb VSS) capacitor c=5.65826e-17
C32 (\4\:RTb VSS) capacitor c=9.88373e-17
C33 (\6\:RT VSS) capacitor c=2.20693e-17
C34 (\4\:qbint VSS) capacitor c=5.36612e-17
C35 (\3\:n35g VSS) capacitor c=5.21926e-17
C36 (\5\:RT VSS) capacitor c=6.97914e-17
C37 (\3\:SE VSS) capacitor c=7.65277e-17
C38 (\7\:CKNbb VSS) capacitor c=3.4512e-17
C39 (\3\:SI VSS) capacitor c=9.47782e-17
C40 (\4\:SE VSS) capacitor c=1.22706e-16
C41 (\7\:RNb VSS) capacitor c=5.99721e-17
C42 (\4\:D VSS) capacitor c=7.03694e-17
C43 (\5\:n20 VSS) capacitor c=9.56816e-17
C44 (\4\:CKN VSS) capacitor c=5.39794e-17
C45 (\4\:CKNb VSS) capacitor c=4.53327e-17
C46 (\8\:CKNbb VSS) capacitor c=8.16286e-17
C47 (\3\:CKNb VSS) capacitor c=1.09095e-16
C48 (\1\:RN VSS) capacitor c=4.14282e-17
C49 (\6\:qbint VSS) capacitor c=3.78721e-17
C50 (\12\:qbint VSS) capacitor c=5.80945e-17
C51 (\14\:qbint VSS) capacitor c=4.63282e-17
C52 (\4\:net573 VSS) capacitor c=3.68408e-17
C53 (\9\:CKNbb VSS) capacitor c=2.02823e-16
C54 (\8\:RT VSS) capacitor c=1.21533e-16
C55 (\2\:RT VSS) capacitor c=6.23027e-17
C56 (\5\:qbint VSS) capacitor c=3.89021e-17
C57 (\5\:n35g VSS) capacitor c=3.28666e-17
C58 (\2\:RTb VSS) capacitor c=4.86582e-17
C59 (\5\:SE VSS) capacitor c=5.7887e-17
C60 (\6\:CKNb VSS) capacitor c=3.48485e-17
C61 (\1\:SI VSS) capacitor c=4.91308e-17
C62 (\6\:SE VSS) capacitor c=8.61913e-17
C63 (\6\:RNb VSS) capacitor c=5.26448e-17
C64 (\3\:SEb VSS) capacitor c=6.60658e-17
C65 (\1\:D VSS) capacitor c=4.95201e-17
C66 (\3\:n20 VSS) capacitor c=4.38664e-17
C67 (\1\:CKN VSS) capacitor c=2.85144e-17
C68 (\3\:mout VSS) capacitor c=5.01444e-17
C69 (\11\:CKNb VSS) capacitor c=4.92799e-17
C70 (\4\:RN VSS) capacitor c=3.68513e-17
C71 (\13\:CKNb VSS) capacitor c=5.16127e-17
C72 (\10\:qbint VSS) capacitor c=8.55902e-17
C73 (\7\:RT VSS) capacitor c=1.52967e-16
C74 (\10\:CKNb VSS) capacitor c=1.67535e-16
C75 (\3\:RT VSS) capacitor c=5.08271e-17
C76 (\1\:RT VSS) capacitor c=5.22705e-17
C77 (\3\:RTb VSS) capacitor c=7.59476e-17
C78 (\3\:qbint VSS) capacitor c=4.4406e-17
C79 (\2\:n35 VSS) capacitor c=2.32651e-16
C80 (\4\:n35g VSS) capacitor c=6.68789e-17
C81 (\3\:CKNbb VSS) capacitor c=5.97859e-17
C82 (\10\:CKNbb VSS) capacitor c=2.17818e-16
C83 (\3\:n35 VSS) capacitor c=1.06034e-16
C84 (\1\:SE VSS) capacitor c=2.48216e-17
C85 (\2\:SI VSS) capacitor c=7.76333e-17
C86 (\2\:SEb VSS) capacitor c=7.74478e-17
C87 (\3\:D VSS) capacitor c=1.4664e-17
C88 (\6\:n20 VSS) capacitor c=8.06263e-17
C89 (\4\:n20 VSS) capacitor c=3.85642e-17
C90 (\3\:CKN VSS) capacitor c=2.40654e-17
C91 (\2\:mout VSS) capacitor c=3.17706e-17
C92 (\4\:mout VSS) capacitor c=3.92547e-17
C93 (\2\:CKNb VSS) capacitor c=7.99058e-17
C94 (\6\:CKNbb VSS) capacitor c=3.65693e-17
C95 (\7\:n20 VSS) capacitor c=5.38331e-17
C96 (\2\:CKNbb VSS) capacitor c=5.81582e-17
C97 (\5\:CKNb VSS) capacitor c=7.92574e-17
C98 (\9\:CKNb VSS) capacitor c=2.73178e-17
C99 (\5\:RNb VSS) capacitor c=1.20485e-16
C100 (\2\:n20 VSS) capacitor c=4.55743e-17
C101 (\3\:RN VSS) capacitor c=4.74438e-17
C102 (\1\:VDD VSS) capacitor c=4.93951e-17
C103 (\3\:Q VSS) capacitor c=8.19591e-17
C104 (\11\:VDD VSS) capacitor c=4.90026e-17
C105 (\9\:net573 VSS) capacitor c=5.58219e-17
C106 (\13\:VDD VSS) capacitor c=7.97606e-17
C107 (\3\:n11 VSS) capacitor c=9.94421e-17
C108 (\4\:QN VSS) capacitor c=6.74361e-17
C109 (\14\:n35 VSS) capacitor c=5.24739e-17
C110 (\15\:n35g VSS) capacitor c=5.5909e-17
C111 (\6\:RTb VSS) capacitor c=7.2397e-17
C112 (\1\:ExtVDD VSS) capacitor c=2.78555e-16
C113 (\9\:n35 VSS) capacitor c=6.19273e-17
C114 (\17\:qbint VSS) capacitor c=6.81986e-17
C115 (\6\:n35g VSS) capacitor c=9.60383e-17
C116 (\8\:SEb VSS) capacitor c=5.06071e-17
C117 (\4\:n35 VSS) capacitor c=6.12731e-17
C118 (\15\:VDD VSS) capacitor c=6.07875e-17
C119 (\5\:mout VSS) capacitor c=7.76403e-17
C120 (\3\:Db VSS) capacitor c=1.85393e-16
C121 (\17\:VDD VSS) capacitor c=3.85232e-17
C122 (\22\:VDD VSS) capacitor c=3.54295e-17
C123 (\13\:mout VSS) capacitor c=5.83998e-17
C124 (\20\:CKNb VSS) capacitor c=2.98453e-17
C125 (\20\:VDD VSS) capacitor c=4.12536e-17
C126 (\12\:CKNbb VSS) capacitor c=5.8853e-17
C127 (\13\:n20 VSS) capacitor c=6.45242e-17
C128 (\5\:Db VSS) capacitor c=2.28145e-16
C129 (\8\:RNb VSS) capacitor c=5.40837e-17
C130 (\10\:n20 VSS) capacitor c=6.3429e-17
C131 (\24\:VDD VSS) capacitor c=4.25619e-17
C132 (\1\:Q VSS) capacitor c=5.2727e-17
C133 (\5\:net573 VSS) capacitor c=4.31693e-17
C134 (\3\:n10 VSS) capacitor c=7.9152e-17
C135 (\1\:QN VSS) capacitor c=3.72743e-17
C136 (\17\:n35 VSS) capacitor c=4.13331e-17
C137 (\11\:n35g VSS) capacitor c=2.96827e-17
C138 (\10\:RTb VSS) capacitor c=5.81982e-17
C139 (\12\:n35 VSS) capacitor c=6.35168e-17
C140 (\19\:qbint VSS) capacitor c=2.43447e-17
C141 (\9\:n35g VSS) capacitor c=7.72521e-17
C142 (\4\:SEb VSS) capacitor c=3.83048e-17
C143 (\7\:n35 VSS) capacitor c=3.77874e-17
C144 (\11\:mout VSS) capacitor c=3.75653e-17
C145 (\15\:mout VSS) capacitor c=2.97046e-17
C146 (\16\:CKNb VSS) capacitor c=5.3617e-17
C147 (\15\:CKNbb VSS) capacitor c=5.89602e-17
C148 (\17\:n20 VSS) capacitor c=8.30467e-17
C149 (\7\:Db VSS) capacitor c=1.10549e-16
C150 (\11\:RNb VSS) capacitor c=7.0859e-17
C151 (\8\:n20 VSS) capacitor c=5.96395e-17
C152 (VDD VSS) capacitor c=5.17174e-17
C153 (\2\:CKN VSS) capacitor c=3.47094e-17
C154 (\2\:D VSS) capacitor c=3.53727e-17
C155 (\2\:SE VSS) capacitor c=2.57292e-17
C156 (\4\:CKNbb VSS) capacitor c=1.47583e-16
C157 (\5\:CKNbb VSS) capacitor c=7.62941e-17
C158 (\2\:n35g VSS) capacitor c=2.90849e-17
C159 (\4\:RT VSS) capacitor c=5.2386e-17
C160 (\2\:qbint VSS) capacitor c=4.13065e-17
C161 (\7\:CKNb VSS) capacitor c=1.28162e-16
C162 (\8\:CKNb VSS) capacitor c=6.57182e-17
C163 (\2\:net573 VSS) capacitor c=1.53336e-17
C164 (\12\:n20 VSS) capacitor c=4.63088e-17
C165 (\3\:RNb VSS) capacitor c=2.91833e-16
C166 (\4\:RNb VSS) capacitor c=1.1855e-16
C167 (\10\:RNb VSS) capacitor c=1.20254e-16
C168 (\14\:CKNb VSS) capacitor c=1.55458e-16
C169 (\15\:CKNb VSS) capacitor c=1.38277e-16
C170 (\15\:n20 VSS) capacitor c=7.50124e-17
C171 (\16\:n20 VSS) capacitor c=9.27968e-17
C172 (\8\:qbint VSS) capacitor c=5.09962e-17
C173 (\9\:qbint VSS) capacitor c=7.73566e-17
C174 (\11\:CKNbb VSS) capacitor c=5.37364e-17
C175 (\14\:CKNbb VSS) capacitor c=8.16587e-17
C176 (\5\:CKN VSS) capacitor c=4.07744e-18
C177 (\6\:CKN VSS) capacitor c=2.88047e-17
C178 (\19\:n20 VSS) capacitor c=4.89495e-17
C179 (\20\:n20 VSS) capacitor c=4.84792e-17
C180 (\18\:CKNb VSS) capacitor c=6.97672e-17
C181 (\19\:CKNb VSS) capacitor c=4.29678e-17
C182 (\7\:mout VSS) capacitor c=8.35937e-17
C183 (\8\:mout VSS) capacitor c=5.3233e-17
C184 (\9\:mout VSS) capacitor c=1.90246e-17
C185 (\10\:mout VSS) capacitor c=7.58994e-17
C186 (\17\:mout VSS) capacitor c=7.39082e-17
C187 (\5\:SI VSS) capacitor c=3.48426e-17
C188 (\7\:SE VSS) capacitor c=5.23082e-17
C189 (\6\:n35 VSS) capacitor c=7.11534e-17
C190 (\6\:SEb VSS) capacitor c=8.23114e-17
C191 (\7\:SEb VSS) capacitor c=6.72658e-17
C192 (\17\:CKNbb VSS) capacitor c=3.49327e-17
C193 (\18\:CKNbb VSS) capacitor c=3.64971e-17
C194 (\8\:n35g VSS) capacitor c=3.39835e-17
C195 (\11\:n35 VSS) capacitor c=7.49055e-17
C196 (\15\:qbint VSS) capacitor c=8.78471e-17
C197 (\16\:qbint VSS) capacitor c=1.11964e-16
C198 (\13\:n35g VSS) capacitor c=1.02785e-16
C199 (\14\:n35g VSS) capacitor c=1.1611e-16
C200 (\5\:RTb VSS) capacitor c=4.9153e-17
C201 (\8\:RTb VSS) capacitor c=9.96219e-17
C202 (\9\:RTb VSS) capacitor c=9.1018e-17
C203 (\9\:RT VSS) capacitor c=1.0533e-16
C204 (\10\:RT VSS) capacitor c=1.18336e-16
C205 (\11\:RT VSS) capacitor c=3.8175e-17
C206 (\21\:qbint VSS) capacitor c=2.43468e-17
C207 (\22\:qbint VSS) capacitor c=3.00163e-17
C208 (\22\:CKNb VSS) capacitor c=9.67046e-17
C209 (\23\:CKNb VSS) capacitor c=1.00377e-16
C210 (\3\:QN VSS) capacitor c=3.36463e-17
C211 (\16\:n35 VSS) capacitor c=4.45599e-17
C212 (\7\:net573 VSS) capacitor c=5.66165e-17
C213 (\8\:net573 VSS) capacitor c=3.48112e-17
C214 (\3\:VDD VSS) capacitor c=5.02005e-17
C215 (\5\:VDD VSS) capacitor c=9.96254e-18
C216 (\6\:VDD VSS) capacitor c=2.20274e-16
C217 (\7\:VDD VSS) capacitor c=2.06628e-16
C218 (\8\:VDD VSS) capacitor c=2.3561e-17
C219 (\10\:VDD VSS) capacitor c=3.25234e-17
C220 (\19\:VDD VSS) capacitor c=6.3277e-17
Rk54 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk52 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk55 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk56 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk1 (\5\:RN RN) resistor r=0.006381 c=0
Rk67 (RT \9\:RT) resistor r=0.1845 c=0
Rk68 (\9\:RT \10\:RT) resistor r=0.6434 c=0
Rk69 (RT \11\:RT) resistor r=0.01482 c=0
Rk36 (SI \4\:SI) resistor r=0.01024 c=0
Rk40 (\5\:SI SI) resistor r=0.01024 c=0
Rk37 (\5\:SI \4\:SI) resistor r=0.001853 c=0
Rk81 (\2\:Q Q) resistor r=0.1646 c=0
Rk82 (Q \4\:Q) resistor r=0.3291 c=0
Rk116 (VDD VDD) resistor r=0.1321 c=0
Rk102 (\2\:VDD \3\:VDD) resistor r=0.578 c=0
Rk103 (\3\:VDD \5\:VDD) resistor r=0.06692 c=0
Rk104 (\5\:VDD \6\:VDD) resistor r=0.05201 c=0
Rk105 (\6\:VDD \7\:VDD) resistor r=1.5259 c=0
Rk106 (\7\:VDD \8\:VDD) resistor r=0.186 c=0
Rk107 (\8\:VDD \10\:VDD) resistor r=0.1545 c=0
Rk108 (\3\:VDD \12\:VDD) resistor r=0.294 c=0
Rk109 (\6\:VDD \14\:VDD) resistor r=0.3757 c=0
Rk110 (\7\:VDD \16\:VDD) resistor r=0.3677 c=0
Rk111 (\8\:VDD \18\:VDD) resistor r=0.2024 c=0
Rk115 (\19\:VDD VDD) resistor r=0.2929 c=0
Rk112 (\10\:VDD \19\:VDD) resistor r=0.1713 c=0
Rk113 (\19\:VDD \21\:VDD) resistor r=0.1998 c=0
Rk114 (\10\:VDD \23\:VDD) resistor r=0.2359 c=0
Rk117 (VDD \25\:VDD) resistor r=0.3801 c=0
Rk73 (\3\:QN QN) resistor r=0.02726 c=0
Rk72 (\2\:QN \3\:QN) resistor r=0.204 c=0
Rk74 (\3\:QN \5\:QN) resistor r=0.353 c=0
Rk41 (SE \7\:SE) resistor r=0.04328 c=0
Rk13 (CKN \5\:CKN) resistor r=0.002292 c=0
Rk16 (\5\:CKN \6\:CKN) resistor r=0.00987 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.007821 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk90 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk91 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk92 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk93 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk95 (\13\:VSS VSS) resistor r=0.2481 c=0
Rk94 (\12\:VSS \13\:VSS) resistor r=0.1589 c=0
Rk96 (\5\:VSS \15\:VSS) resistor r=0.2678 c=0
Rk97 (\7\:VSS \17\:VSS) resistor r=0.19 c=0
Rk98 (\9\:VSS \19\:VSS) resistor r=0.1951 c=0
Rk99 (\10\:VSS \21\:VSS) resistor r=0.2543 c=0
Rk100 (\11\:VSS \23\:VSS) resistor r=0.2499 c=0
Rk101 (\13\:VSS \25\:VSS) resistor r=0.2374 c=0
Rk118 (\27\:VSS \28\:VSS) resistor r=0.08432 c=0
Rk119 (\28\:VSS \29\:VSS) resistor r=0.1142 c=0
Rk120 (\29\:VSS \30\:VSS) resistor r=0.0893 c=0
Rk121 (\30\:VSS \31\:VSS) resistor r=0.3578 c=0
Rk123 (\32\:VSS VSS) resistor r=0.3774 c=0
Rk122 (\31\:VSS \32\:VSS) resistor r=0.3679 c=0
Rk124 (VSS \33\:VSS) resistor r=0.1494 c=0
Rk125 (\33\:VSS \34\:VSS) resistor r=0.5417 c=0
Rk126 (\34\:VSS \35\:VSS) resistor r=0.3427 c=0
Rk128 (\36\:VSS VSS) resistor r=0.2037 c=0
Rk127 (\35\:VSS \36\:VSS) resistor r=0.05947 c=0
Rk129 (VSS \38\:VSS) resistor r=0.4016 c=0
Rk130 (\28\:VSS \40\:VSS) resistor r=0.2409 c=0
Rk131 (\30\:VSS \42\:VSS) resistor r=0.2472 c=0
Rk132 (\32\:VSS \44\:VSS) resistor r=0.2445 c=0
Rk133 (\34\:VSS \46\:VSS) resistor r=0.2409 c=0
Rk134 (\35\:VSS \48\:VSS) resistor r=0.2409 c=0
Rk21 (\5\:D D) resistor r=0.007217 c=0
Rk22 (D \6\:D) resistor r=0.007217 c=0
Rk24 (\5\:D \6\:D) resistor r=0.01655 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3469 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2525 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4762 c=0
Rk17 (\19\:n20 \20\:n20) resistor r=0.2144 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8523 c=0
Rk18 (\17\:CKNb \18\:CKNb) resistor r=0.3242 c=0
Rk19 (\18\:CKNb \19\:CKNb) resistor r=0.184 c=0
Rk20 (\18\:CKNb \21\:CKNb) resistor r=0.1872 c=0
Rk71 (\22\:CKNb \23\:CKNb) resistor r=0.7635 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.6076 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3647 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1128 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.2021 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.1352 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.525 c=0
Rk34 (\9\:mout \16\:mout) resistor r=0.09784 c=0
Rk35 (\10\:mout \17\:mout) resistor r=0.426 c=0
Rk10 (\11\:CKNbb \13\:CKNbb) resistor r=0.1426 c=0
Rk11 (\13\:CKNbb \14\:CKNbb) resistor r=0.4225 c=0
Rk12 (\14\:CKNbb \16\:CKNbb) resistor r=0.2372 c=0
Rk47 (\17\:CKNbb \18\:CKNbb) resistor r=0.3729 c=0
Rk4 (\9\:RNb \10\:RNb) resistor r=0.193 c=0
Rk5 (\10\:RNb \12\:RNb) resistor r=0.3636 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.3482 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk48 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk49 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk60 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk61 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk62 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk57 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk58 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk59 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk70 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk63 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk64 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk65 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk66 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk77 (\6\:net573 \7\:net573) resistor r=0.238 c=0
Rk78 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk79 (\7\:net573 \10\:net573) resistor r=0.2849 c=0
Rk42 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk43 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk50 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk51 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk75 (\15\:n35 \16\:n35) resistor r=0.3075 c=0
Rk76 (\16\:n35 \18\:n35) resistor r=0.2886 c=0
Rk25 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk26 (\4\:Db \6\:Db) resistor r=1.3611 c=0
Rk27 (\6\:Db \8\:Db) resistor r=0.6346 c=0
Rk83 (\2\:n11 \4\:n11) resistor r=0.71 c=0
Rk80 (\2\:n10 \4\:n10) resistor r=0.6281 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl54 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl41 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl44 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl43 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl42 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl20 (\2\:D \4\:D) resistor r=115.099 c=0
Rl18 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl19 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl16 (\5\:n20 \6\:n20) resistor r=190.564 c=0
Rl15 (\3\:n20 \4\:n20) resistor r=90.3645 c=0
Rl17 (\6\:n20 \7\:n20) resistor r=117.486 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl57 (\12\:CKNb \13\:CKNb) resistor r=137.716 c=0
Rl6 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl49 (\6\:CKNb \7\:CKNb) resistor r=65.0422 c=0
Rl52 (\7\:CKNb \10\:CKNb) resistor r=808.345 c=0
Rl53 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl51 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl50 (\7\:CKNb \8\:CKNb) resistor r=416.829 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl58 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl33 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl30 (\3\:CKNbb \4\:CKNbb) resistor r=395.821 c=0
Rl34 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl32 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl31 (\4\:CKNbb \5\:CKNbb) resistor r=407.602 c=0
Rl62 (RNb \2\:RNb) resistor r=234.8 c=0
Rl63 (\2\:RNb \3\:RNb) resistor r=1469.68 c=0
Rl66 (\3\:RNb \6\:RNb) resistor r=180.888 c=0
Rl67 (\4\:RNb \7\:RNb) resistor r=75.8186 c=0
Rl65 (\4\:RNb \5\:RNb) resistor r=424.798 c=0
Rl64 (\3\:RNb \4\:RNb) resistor r=83.4088 c=0
Rl21 (SEb \2\:SEb) resistor r=101.718 c=0
Rl22 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl37 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl35 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl36 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl38 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl68 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl73 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl75 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl69 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl72 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl74 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl71 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl70 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl39 (RTb \2\:RTb) resistor r=112.412 c=0
Rl40 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl59 (net573 \2\:net573) resistor r=3.1216 c=0
Rl60 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl61 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl55 (n35 \2\:n35) resistor r=508.667 c=0
Rl56 (\2\:n35 \3\:n35) resistor r=380.826 c=0
Rz23 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz18 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz24 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz25 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz26 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz27 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz28 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz29 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz30 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz33 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz34 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz35 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz36 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz37 (\45\:VSS \46\:VSS) resistor r=75 c=0
Rz38 (\47\:VSS \48\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz2 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz11 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz16 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz15 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz17 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz20 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz13 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz19 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry32 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry33 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry34 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry37 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\26\:VSS \27\:VSS) resistor r=31 c=0
Ry39 (\26\:VSS \29\:VSS) resistor r=31 c=0
Ry40 (\26\:VSS \31\:VSS) resistor r=8.8571 c=0
Ry41 (\26\:VSS \33\:VSS) resistor r=5.6364 c=0
Ry42 (\26\:VSS \36\:VSS) resistor r=7.75 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\13\:mout \14\:mout) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry2 (\8\:RNb \9\:RNb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry24 (n11 \2\:n11) resistor r=62 c=0
Ry25 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx10 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx14 (\3\:D D) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\7\:n20 \16\:n20) resistor r=45 c=0
Rx11 (\6\:n20 \19\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx13 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \17\:mout) resistor r=45 c=0
Rx8 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx3 (\5\:RNb \10\:RNb) resistor r=45 c=0
Rx20 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx32 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx33 (qbint \22\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx37 (net573 \8\:net573) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx36 (n35 \16\:n35) resistor r=45 c=0
mn22 (\11\:RNb \4\:RN \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \3\:n20 \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout \6\:RNb \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 RNb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.95e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.9e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\13\:mout \5\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.40927 \
        scb=0.00125061 scc=2.52106e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp31 (n5 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.74828 \
        scb=0.00141025 scc=2.59727e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0497 \
        scb=0.0111987 scc=0.000289961 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \2\:RNb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:59:37 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSQX1 CKN D ExtVDD Q RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=1.77014e-17
C2 (D VSS) capacitor c=4.48601e-17
C3 (ExtVDD VSS) capacitor c=2.25518e-16
C4 (SI VSS) capacitor c=4.98312e-17
C5 (RT VSS) capacitor c=2.31186e-17
C6 (CKN VSS) capacitor c=3.89748e-17
C7 (SN VSS) capacitor c=5.01634e-17
C8 (VDD VSS) capacitor c=7.05436e-16
C9 (SE VSS) capacitor c=3.52476e-17
C10 (n20 VSS) capacitor c=3.87782e-17
C11 (CKNb VSS) capacitor c=4.44575e-17
C12 (mout VSS) capacitor c=4.83533e-17
C13 (CKNbb VSS) capacitor c=3.22874e-17
C14 (SEb VSS) capacitor c=7.76341e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.60571e-17
C17 (RTb VSS) capacitor c=5.17974e-17
C18 (n35 VSS) capacitor c=1.72429e-16
C19 (Db VSS) capacitor c=1.04826e-16
C20 (n11 VSS) capacitor c=8.1482e-17
C21 (n1 VSS) capacitor c=8.87983e-19
C22 (\7\:SN VSS) capacitor c=8.82435e-17
C23 (\7\:qbint VSS) capacitor c=3.74556e-17
C24 (\10\:qbint VSS) capacitor c=1.01698e-16
C25 (\12\:CKNb VSS) capacitor c=4.77557e-17
C26 (\4\:RTb VSS) capacitor c=9.76746e-17
C27 (\6\:RT VSS) capacitor c=2.23208e-17
C28 (\4\:qbint VSS) capacitor c=5.35397e-17
C29 (\3\:n35g VSS) capacitor c=5.21809e-17
C30 (\5\:RT VSS) capacitor c=6.48326e-17
C31 (\3\:SE VSS) capacitor c=7.77317e-17
C32 (\7\:CKNbb VSS) capacitor c=2.96146e-17
C33 (\3\:SI VSS) capacitor c=9.47325e-17
C34 (\4\:SE VSS) capacitor c=1.24595e-16
C35 (\4\:D VSS) capacitor c=6.91354e-17
C36 (\3\:n20 VSS) capacitor c=3.30128e-17
C37 (\1\:SN VSS) capacitor c=3.07805e-17
C38 (\4\:CKN VSS) capacitor c=5.5011e-17
C39 (\4\:CKNb VSS) capacitor c=4.53925e-17
C40 (\8\:CKNbb VSS) capacitor c=8.31595e-17
C41 (\3\:CKNb VSS) capacitor c=1.11663e-16
C42 (\6\:qbint VSS) capacitor c=4.18392e-17
C43 (\8\:SN VSS) capacitor c=1.46965e-16
C44 (\11\:qbint VSS) capacitor c=1.49802e-16
C45 (\9\:CKNbb VSS) capacitor c=2.55237e-16
C46 (\8\:RT VSS) capacitor c=1.20729e-16
C47 (\2\:RT VSS) capacitor c=6.21869e-17
C48 (\5\:qbint VSS) capacitor c=3.87334e-17
C49 (\5\:n35g VSS) capacitor c=3.28666e-17
C50 (\2\:RTb VSS) capacitor c=4.65075e-17
C51 (\5\:SE VSS) capacitor c=5.78865e-17
C52 (\6\:CKNb VSS) capacitor c=2.73311e-17
C53 (\1\:SI VSS) capacitor c=4.91308e-17
C54 (\6\:SE VSS) capacitor c=8.61373e-17
C55 (\3\:SEb VSS) capacitor c=6.59521e-17
C56 (\1\:D VSS) capacitor c=4.95122e-17
C57 (\7\:n20 VSS) capacitor c=6.12287e-17
C58 (\6\:SN VSS) capacitor c=6.63573e-17
C59 (\1\:CKN VSS) capacitor c=2.85077e-17
C60 (\3\:mout VSS) capacitor c=4.54948e-17
C61 (\11\:CKNb VSS) capacitor c=4.83019e-17
C62 (\9\:qbint VSS) capacitor c=8.55895e-17
C63 (\13\:CKNb VSS) capacitor c=5.13348e-17
C64 (\3\:SN VSS) capacitor c=2.95001e-16
C65 (\9\:SN VSS) capacitor c=6.35258e-17
C66 (\7\:RT VSS) capacitor c=1.46839e-16
C67 (\10\:CKNb VSS) capacitor c=1.6785e-16
C68 (\3\:RT VSS) capacitor c=3.94579e-17
C69 (\1\:RT VSS) capacitor c=5.29002e-17
C70 (\3\:RTb VSS) capacitor c=7.57803e-17
C71 (\3\:qbint VSS) capacitor c=4.37709e-17
C72 (\2\:n35 VSS) capacitor c=2.52896e-16
C73 (\4\:n35g VSS) capacitor c=6.63939e-17
C74 (\3\:CKNbb VSS) capacitor c=5.0436e-17
C75 (\10\:CKNbb VSS) capacitor c=2.17891e-16
C76 (\3\:n35 VSS) capacitor c=1.15146e-16
C77 (\1\:SE VSS) capacitor c=2.4385e-17
C78 (\2\:SI VSS) capacitor c=7.76842e-17
C79 (\2\:SEb VSS) capacitor c=7.70146e-17
C80 (\4\:n20 VSS) capacitor c=9.8532e-17
C81 (\6\:n20 VSS) capacitor c=5.8782e-17
C82 (\3\:D VSS) capacitor c=1.46144e-17
C83 (\2\:SN VSS) capacitor c=4.74269e-17
C84 (\5\:SN VSS) capacitor c=1.95572e-17
C85 (\3\:CKN VSS) capacitor c=2.36967e-17
C86 (\2\:mout VSS) capacitor c=4.33326e-17
C87 (\4\:mout VSS) capacitor c=3.05301e-17
C88 (\2\:CKNb VSS) capacitor c=7.93794e-17
C89 (\6\:CKNbb VSS) capacitor c=3.65502e-17
C90 (\5\:n20 VSS) capacitor c=6.33877e-17
C91 (\2\:CKNbb VSS) capacitor c=5.80986e-17
C92 (\5\:CKNb VSS) capacitor c=7.21331e-17
C93 (\9\:CKNb VSS) capacitor c=2.45444e-17
C94 (\2\:n20 VSS) capacitor c=3.95417e-17
C95 (\1\:VDD VSS) capacitor c=2.80666e-17
C96 (\11\:VDD VSS) capacitor c=5.0035e-17
C97 (\4\:Q VSS) capacitor c=5.92469e-17
C98 (\13\:VDD VSS) capacitor c=5.29409e-17
C99 (\3\:n11 VSS) capacitor c=8.3971e-17
C100 (\14\:n35 VSS) capacitor c=5.13832e-17
C101 (\15\:n35g VSS) capacitor c=5.69979e-17
C102 (\6\:RTb VSS) capacitor c=7.27978e-17
C103 (\1\:ExtVDD VSS) capacitor c=2.78233e-16
C104 (\9\:n35 VSS) capacitor c=6.21565e-17
C105 (\14\:qbint VSS) capacitor c=6.82817e-17
C106 (\6\:n35g VSS) capacitor c=9.41384e-17
C107 (\8\:SEb VSS) capacitor c=4.18037e-17
C108 (\4\:n35 VSS) capacitor c=6.39896e-17
C109 (\15\:VDD VSS) capacitor c=5.71768e-17
C110 (\5\:mout VSS) capacitor c=7.57577e-17
C111 (\3\:Db VSS) capacitor c=1.82398e-16
C112 (\17\:VDD VSS) capacitor c=3.6346e-17
C113 (\22\:VDD VSS) capacitor c=3.87362e-17
C114 (\15\:mout VSS) capacitor c=1.02067e-16
C115 (\20\:VDD VSS) capacitor c=6.72881e-17
C116 (\20\:CKNb VSS) capacitor c=2.73411e-17
C117 (\12\:CKNbb VSS) capacitor c=5.8186e-17
C118 (\13\:n20 VSS) capacitor c=6.163e-17
C119 (\5\:Db VSS) capacitor c=2.32229e-16
C120 (\10\:n20 VSS) capacitor c=6.35211e-17
C121 (\1\:Q VSS) capacitor c=3.36497e-17
C122 (\17\:n35 VSS) capacitor c=3.93544e-17
C123 (\11\:n35g VSS) capacitor c=2.63056e-17
C124 (\10\:RTb VSS) capacitor c=5.83059e-17
C125 (\12\:n35 VSS) capacitor c=6.37112e-17
C126 (\16\:qbint VSS) capacitor c=2.43869e-17
C127 (\9\:n35g VSS) capacitor c=8.056e-17
C128 (\4\:SEb VSS) capacitor c=3.83409e-17
C129 (\7\:n35 VSS) capacitor c=4.10332e-17
C130 (\11\:mout VSS) capacitor c=2.23063e-17
C131 (\13\:mout VSS) capacitor c=1.74521e-17
C132 (\16\:CKNb VSS) capacitor c=6.06223e-17
C133 (\15\:CKNbb VSS) capacitor c=5.95344e-17
C134 (\17\:n20 VSS) capacitor c=8.70381e-17
C135 (\7\:Db VSS) capacitor c=1.10759e-16
C136 (\8\:n20 VSS) capacitor c=5.97236e-17
C137 (VDD VSS) capacitor c=4.47907e-17
C138 (\2\:CKN VSS) capacitor c=3.47033e-17
C139 (\2\:D VSS) capacitor c=3.54463e-17
C140 (\2\:SE VSS) capacitor c=2.58121e-17
C141 (\4\:CKNbb VSS) capacitor c=1.50506e-16
C142 (\5\:CKNbb VSS) capacitor c=8.65692e-17
C143 (\2\:n35g VSS) capacitor c=2.90051e-17
C144 (\4\:RT VSS) capacitor c=4.60846e-17
C145 (\2\:qbint VSS) capacitor c=4.11428e-17
C146 (\7\:CKNb VSS) capacitor c=1.23198e-16
C147 (\8\:CKNb VSS) capacitor c=7.82348e-17
C148 (\4\:SN VSS) capacitor c=2.45202e-16
C149 (\12\:n20 VSS) capacitor c=4.64596e-17
C150 (\8\:qbint VSS) capacitor c=8.89785e-17
C151 (\14\:CKNb VSS) capacitor c=9.93287e-17
C152 (\15\:CKNb VSS) capacitor c=9.7321e-17
C153 (\15\:n20 VSS) capacitor c=5.22414e-17
C154 (\16\:n20 VSS) capacitor c=9.23136e-17
C155 (\11\:CKNbb VSS) capacitor c=5.50998e-17
C156 (\14\:CKNbb VSS) capacitor c=8.20651e-17
C157 (\5\:CKN VSS) capacitor c=4.00044e-18
C158 (\6\:CKN VSS) capacitor c=3.50068e-17
C159 (\18\:CKNb VSS) capacitor c=6.50609e-17
C160 (\19\:CKNb VSS) capacitor c=4.3158e-17
C161 (\10\:SN VSS) capacitor c=3.66203e-17
C162 (\11\:SN VSS) capacitor c=4.37567e-17
C163 (\7\:D VSS) capacitor c=4.70532e-17
C164 (\19\:n20 VSS) capacitor c=5.02893e-17
C165 (\20\:n20 VSS) capacitor c=5.63541e-17
C166 (\7\:mout VSS) capacitor c=7.80368e-17
C167 (\8\:mout VSS) capacitor c=3.68573e-17
C168 (\9\:mout VSS) capacitor c=1.17075e-16
C169 (\10\:mout VSS) capacitor c=8.75115e-17
C170 (\17\:mout VSS) capacitor c=7.18559e-17
C171 (\5\:SI VSS) capacitor c=3.47443e-17
C172 (\6\:SI VSS) capacitor c=2.61267e-18
C173 (\7\:SE VSS) capacitor c=3.97926e-17
C174 (\6\:SEb VSS) capacitor c=8.2462e-17
C175 (\7\:SEb VSS) capacitor c=6.79045e-17
C176 (\6\:n35 VSS) capacitor c=7.82284e-17
C177 (\17\:CKNbb VSS) capacitor c=3.92018e-17
C178 (\18\:CKNbb VSS) capacitor c=4.23649e-17
C179 (\8\:n35g VSS) capacitor c=3.46579e-17
C180 (\11\:n35 VSS) capacitor c=7.51701e-17
C181 (\12\:qbint VSS) capacitor c=8.80722e-17
C182 (\13\:qbint VSS) capacitor c=1.12231e-16
C183 (\13\:n35g VSS) capacitor c=9.96714e-17
C184 (\14\:n35g VSS) capacitor c=1.16309e-16
C185 (\5\:RTb VSS) capacitor c=4.95471e-17
C186 (\8\:RTb VSS) capacitor c=9.95036e-17
C187 (\9\:RTb VSS) capacitor c=9.15287e-17
C188 (\9\:RT VSS) capacitor c=1.10081e-16
C189 (\10\:RT VSS) capacitor c=1.18363e-16
C190 (\11\:RT VSS) capacitor c=4.01135e-17
C191 (\12\:SN VSS) capacitor c=8.31748e-17
C192 (\13\:SN VSS) capacitor c=7.95664e-17
C193 (\22\:CKNb VSS) capacitor c=1.29813e-16
C194 (\23\:CKNb VSS) capacitor c=1.34586e-16
C195 (\18\:qbint VSS) capacitor c=1.95257e-17
C196 (\19\:qbint VSS) capacitor c=3.00557e-17
C197 (\16\:n35 VSS) capacitor c=4.52132e-17
C198 (\3\:Q VSS) capacitor c=1.86139e-17
C199 (\3\:VDD VSS) capacitor c=2.57292e-17
C200 (\4\:VDD VSS) capacitor c=2.83405e-17
C201 (\6\:VDD VSS) capacitor c=2.03522e-16
C202 (\7\:VDD VSS) capacitor c=2.08673e-16
C203 (\8\:VDD VSS) capacitor c=2.39094e-17
C204 (\10\:VDD VSS) capacitor c=2.23051e-17
C205 (\19\:VDD VSS) capacitor c=1.66031e-17
C206 (\24\:VDD VSS) capacitor c=3.53949e-17
Rk75 (\3\:Q Q) resistor r=0.01828 c=0
Rk74 (\2\:Q \3\:Q) resistor r=0.208 c=0
Rk76 (\3\:Q \5\:Q) resistor r=0.3657 c=0
Rk19 (\5\:D D) resistor r=0.007198 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01668 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007198 c=0
Rk95 (\2\:VSS \3\:VSS) resistor r=0.1014 c=0
Rk96 (\3\:VSS \4\:VSS) resistor r=0.1955 c=0
Rk97 (\4\:VSS \5\:VSS) resistor r=0.7604 c=0
Rk98 (\5\:VSS \6\:VSS) resistor r=0.03202 c=0
Rk100 (\7\:VSS VSS) resistor r=0.121 c=0
Rk99 (\6\:VSS \7\:VSS) resistor r=0.1757 c=0
Rk101 (VSS \8\:VSS) resistor r=0.5204 c=0
Rk102 (\8\:VSS \9\:VSS) resistor r=0.3068 c=0
Rk104 (\10\:VSS VSS) resistor r=0.1212 c=0
Rk103 (\9\:VSS \10\:VSS) resistor r=0.06422 c=0
Rk105 (VSS \12\:VSS) resistor r=0.3116 c=0
Rk106 (\3\:VSS \14\:VSS) resistor r=0.2602 c=0
Rk107 (\5\:VSS \16\:VSS) resistor r=0.189 c=0
Rk108 (\7\:VSS \18\:VSS) resistor r=0.194 c=0
Rk109 (\8\:VSS \20\:VSS) resistor r=0.253 c=0
Rk110 (\9\:VSS \22\:VSS) resistor r=0.2486 c=0
Rk111 (\24\:VSS \25\:VSS) resistor r=0.1807 c=0
Rk112 (\25\:VSS \26\:VSS) resistor r=0.364 c=0
Rk113 (\26\:VSS \27\:VSS) resistor r=0.3668 c=0
Rk115 (\28\:VSS VSS) resistor r=0.0493 c=0
Rk114 (\27\:VSS \28\:VSS) resistor r=0.3269 c=0
Rk117 (\29\:VSS VSS) resistor r=0.1212 c=0
Rk116 (VSS \29\:VSS) resistor r=0.8922 c=0
Rk118 (\25\:VSS \31\:VSS) resistor r=0.2345 c=0
Rk119 (\27\:VSS \33\:VSS) resistor r=0.2432 c=0
Rk120 (VSS \35\:VSS) resistor r=0.3078 c=0
Rk53 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk51 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk54 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk55 (ExtVDD \6\:ExtVDD) resistor r=0.1495 c=0
Rk34 (SI \4\:SI) resistor r=0.01021 c=0
Rk35 (\5\:SI \4\:SI) resistor r=0.001848 c=0
Rk36 (SI \6\:SI) resistor r=0.001848 c=0
Rk37 (\5\:SI \6\:SI) resistor r=0.01021 c=0
Rk38 (\7\:SI SI) resistor r=0.001848 c=0
Rk39 (\6\:SI \7\:SI) resistor r=0.009883 c=0
Rk66 (RT \9\:RT) resistor r=0.1837 c=0
Rk67 (\9\:RT \10\:RT) resistor r=0.6456 c=0
Rk68 (RT \11\:RT) resistor r=0.01478 c=0
Rk10 (CKN \5\:CKN) resistor r=0.001943 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.01016 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.004796 c=0
Rk17 (\10\:SN SN) resistor r=0.02545 c=0
Rk18 (SN \11\:SN) resistor r=0.2163 c=0
Rk69 (\12\:SN \13\:SN) resistor r=0.5353 c=0
Rk94 (VDD VDD) resistor r=0.2354 c=0
Rk78 (\2\:VDD \3\:VDD) resistor r=0.3366 c=0
Rk79 (\3\:VDD \4\:VDD) resistor r=0.1656 c=0
Rk80 (\4\:VDD \6\:VDD) resistor r=0.1163 c=0
Rk81 (\6\:VDD \7\:VDD) resistor r=1.5235 c=0
Rk82 (\7\:VDD \8\:VDD) resistor r=0.23 c=0
Rk83 (\8\:VDD \10\:VDD) resistor r=0.1094 c=0
Rk84 (\3\:VDD \12\:VDD) resistor r=0.3561 c=0
Rk85 (\4\:VDD \14\:VDD) resistor r=0.301 c=0
Rk86 (\7\:VDD \16\:VDD) resistor r=0.3658 c=0
Rk87 (\8\:VDD \18\:VDD) resistor r=0.2067 c=0
Rk88 (\10\:VDD \19\:VDD) resistor r=0.09396 c=0
Rk89 (\19\:VDD \21\:VDD) resistor r=0.2286 c=0
Rk90 (\10\:VDD \23\:VDD) resistor r=0.2347 c=0
Rk93 (\24\:VDD VDD) resistor r=0.1953 c=0
Rk91 (\19\:VDD \24\:VDD) resistor r=0.07642 c=0
Rk92 (\24\:VDD \25\:VDD) resistor r=0.2186 c=0
Rk40 (SE \7\:SE) resistor r=0.05519 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5425 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2539 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3399 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2292 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4959 c=0
Rk22 (\19\:n20 \20\:n20) resistor r=0.2604 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7504 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3243 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.183 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1863 c=0
Rk70 (\22\:CKNb \23\:CKNb) resistor r=0.8238 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.6015 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3501 c=0
Rk28 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk29 (\9\:mout \10\:mout) resistor r=0.3407 c=0
Rk30 (\7\:mout \12\:mout) resistor r=0.1277 c=0
Rk31 (\8\:mout \14\:mout) resistor r=0.09184 c=0
Rk32 (\9\:mout \16\:mout) resistor r=0.6351 c=0
Rk33 (\10\:mout \17\:mout) resistor r=0.4247 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.1419 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4204 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.236 c=0
Rk46 (\17\:CKNbb \18\:CKNbb) resistor r=0.3711 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.2167 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.3464 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.3048 c=0
Rk47 (\7\:n35g \8\:n35g) resistor r=0.273 c=0
Rk48 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk59 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk60 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk61 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk56 (\12\:qbint \13\:qbint) resistor r=0.494 c=0
Rk57 (\13\:qbint \15\:qbint) resistor r=0.5666 c=0
Rk58 (\13\:qbint \17\:qbint) resistor r=0.1462 c=0
Rk71 (\18\:qbint \19\:qbint) resistor r=0.2116 c=0
Rk62 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk63 (\7\:RTb \8\:RTb) resistor r=0.4161 c=0
Rk64 (\8\:RTb \9\:RTb) resistor r=0.6878 c=0
Rk65 (\8\:RTb \11\:RTb) resistor r=0.3063 c=0
Rk44 (\5\:n35 \6\:n35) resistor r=0.4094 c=0
Rk45 (\6\:n35 \8\:n35) resistor r=0.29 c=0
Rk49 (\10\:n35 \11\:n35) resistor r=0.4005 c=0
Rk50 (\11\:n35 \13\:n35) resistor r=0.3296 c=0
Rk72 (\15\:n35 \16\:n35) resistor r=0.3034 c=0
Rk73 (\16\:n35 \18\:n35) resistor r=0.2669 c=0
Rk23 (\2\:Db \4\:Db) resistor r=0.635 c=0
Rk24 (\4\:Db \6\:Db) resistor r=1.316 c=0
Rk25 (\6\:Db \8\:Db) resistor r=0.6314 c=0
Rk77 (\2\:n11 \4\:n11) resistor r=0.6522 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl52 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl39 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl42 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl41 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl40 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl65 (\7\:SN \8\:SN) resistor r=366.394 c=0
Rl66 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl12 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl55 (\4\:SN \6\:SN) resistor r=106.74 c=0
Rl53 (\3\:SN \4\:SN) resistor r=1145.23 c=0
Rl54 (\4\:SN \5\:SN) resistor r=8.9604 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=56.7001 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=98.0144 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=249.192 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl59 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl3 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl47 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl50 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl51 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl49 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl48 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl58 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl31 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl28 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl32 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl30 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl29 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl35 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl33 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl34 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl60 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl64 (\10\:qbint \11\:qbint) resistor r=343.229 c=0
Rl46 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl43 (qbint \2\:qbint) resistor r=112.732 c=0
Rl45 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl44 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl61 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl63 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl62 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl37 (RTb \2\:RTb) resistor r=112.412 c=0
Rl38 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl56 (n35 \2\:n35) resistor r=508.667 c=0
Rl57 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz18 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz28 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz29 (\34\:VSS \35\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry20 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry31 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry32 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry33 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry34 (\1\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry35 (\23\:VSS \24\:VSS) resistor r=15.5 c=0
Ry36 (\23\:VSS \26\:VSS) resistor r=8.8571 c=0
Ry37 (\23\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry38 (\23\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry24 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry25 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry26 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry27 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry28 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry29 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\15\:mout \16\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry19 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry21 (n11 \2\:n11) resistor r=62 c=0
Ry22 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\5\:SN \10\:SN) resistor r=45 c=0
Rx11 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\6\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \17\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx36 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx37 (qbint \19\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0118 \6\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \7\:n20 net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net0119 \11\:qbint net0117 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0117 \8\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.05e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=3.45e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp32 (\15\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=5.45048 \
        scb=0.00126552 scc=2.52508e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp52 (n11 \10\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\4\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0167 \
        scb=0.00981108 scc=0.000312648 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
ends SRDFFNSQX1
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:41:25 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSRQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSRQX1 CKN D ExtVDD Q RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (ExtVDD VSS) capacitor c=2.40904e-16
C2 (D VSS) capacitor c=7.94449e-17
C3 (VDD VSS) capacitor c=7.76637e-16
C4 (SE VSS) capacitor c=9.36226e-17
C5 (Q VSS) capacitor c=1.47935e-17
C6 (CKN VSS) capacitor c=5.15855e-17
C7 (SN VSS) capacitor c=6.7135e-17
C8 (SI VSS) capacitor c=8.72108e-17
C9 (RN VSS) capacitor c=8.64353e-17
C10 (RT VSS) capacitor c=6.2503e-17
C11 (n20 VSS) capacitor c=3.89483e-17
C12 (CKNb VSS) capacitor c=4.67975e-17
C13 (mout VSS) capacitor c=5.41376e-17
C14 (RNb VSS) capacitor c=3.91539e-17
C15 (CKNbb VSS) capacitor c=3.23573e-17
C16 (SEb VSS) capacitor c=7.75642e-17
C17 (n35g VSS) capacitor c=1.7772e-17
C18 (qbint VSS) capacitor c=4.57523e-17
C19 (RTb VSS) capacitor c=5.17974e-17
C20 (n35 VSS) capacitor c=1.71934e-16
C21 (Db VSS) capacitor c=1.02486e-16
C22 (n11 VSS) capacitor c=8.44886e-17
C23 (n8 VSS) capacitor c=7.938e-17
C24 (n10 VSS) capacitor c=8.44144e-17
C25 (n4 VSS) capacitor c=8.7069e-17
C26 (n1 VSS) capacitor c=1.02126e-18
C27 (\7\:SN VSS) capacitor c=7.05736e-17
C28 (\7\:qbint VSS) capacitor c=3.76191e-17
C29 (\10\:qbint VSS) capacitor c=1.4163e-16
C30 (\4\:RNb VSS) capacitor c=4.00602e-16
C31 (\12\:CKNb VSS) capacitor c=5.76934e-17
C32 (\4\:RTb VSS) capacitor c=9.76746e-17
C33 (\6\:RT VSS) capacitor c=2.20615e-17
C34 (\4\:qbint VSS) capacitor c=5.35397e-17
C35 (\3\:n35g VSS) capacitor c=5.22477e-17
C36 (\5\:RT VSS) capacitor c=8.2554e-17
C37 (\3\:SE VSS) capacitor c=7.72314e-17
C38 (\7\:CKNbb VSS) capacitor c=3.84202e-17
C39 (\3\:SI VSS) capacitor c=9.59651e-17
C40 (\9\:RNb VSS) capacitor c=6.01657e-17
C41 (\4\:SE VSS) capacitor c=1.2201e-16
C42 (\3\:n20 VSS) capacitor c=4.73671e-17
C43 (\4\:D VSS) capacitor c=6.87142e-17
C44 (\1\:SN VSS) capacitor c=3.03254e-17
C45 (\4\:CKN VSS) capacitor c=5.39485e-17
C46 (\4\:CKNb VSS) capacitor c=4.53327e-17
C47 (\8\:CKNbb VSS) capacitor c=8.24748e-17
C48 (\3\:CKNb VSS) capacitor c=1.09071e-16
C49 (\1\:RN VSS) capacitor c=4.24515e-17
C50 (\8\:SN VSS) capacitor c=1.32242e-16
C51 (\6\:qbint VSS) capacitor c=4.18324e-17
C52 (\11\:qbint VSS) capacitor c=8.06262e-17
C53 (\3\:RNb VSS) capacitor c=6.80787e-17
C54 (\9\:CKNbb VSS) capacitor c=2.22469e-16
C55 (\8\:RT VSS) capacitor c=1.21136e-16
C56 (\2\:RT VSS) capacitor c=6.21971e-17
C57 (\5\:qbint VSS) capacitor c=3.87528e-17
C58 (\5\:n35g VSS) capacitor c=3.28693e-17
C59 (\2\:RTb VSS) capacitor c=4.66333e-17
C60 (\5\:SE VSS) capacitor c=5.7365e-17
C61 (\6\:CKNb VSS) capacitor c=3.24964e-17
C62 (\1\:SI VSS) capacitor c=4.90982e-17
C63 (\6\:SE VSS) capacitor c=8.63749e-17
C64 (\3\:SEb VSS) capacitor c=6.59528e-17
C65 (\1\:D VSS) capacitor c=4.95201e-17
C66 (\6\:n20 VSS) capacitor c=6.12355e-17
C67 (\6\:SN VSS) capacitor c=4.59773e-17
C68 (\1\:CKN VSS) capacitor c=2.85144e-17
C69 (\3\:mout VSS) capacitor c=4.57969e-17
C70 (\11\:CKNb VSS) capacitor c=4.92133e-17
C71 (\4\:RN VSS) capacitor c=3.69343e-17
C72 (\9\:qbint VSS) capacitor c=9.41647e-17
C73 (\13\:CKNb VSS) capacitor c=7.94667e-17
C74 (\3\:SN VSS) capacitor c=3.75362e-16
C75 (\9\:SN VSS) capacitor c=9.14336e-17
C76 (\7\:RT VSS) capacitor c=1.55207e-16
C77 (\10\:CKNb VSS) capacitor c=1.67449e-16
C78 (\3\:RT VSS) capacitor c=5.78494e-17
C79 (\1\:RT VSS) capacitor c=5.2908e-17
C80 (\3\:RTb VSS) capacitor c=7.57746e-17
C81 (\3\:qbint VSS) capacitor c=4.37709e-17
C82 (\2\:n35 VSS) capacitor c=2.52896e-16
C83 (\4\:n35g VSS) capacitor c=6.71758e-17
C84 (\3\:CKNbb VSS) capacitor c=5.53018e-17
C85 (\10\:CKNbb VSS) capacitor c=2.1752e-16
C86 (\3\:n35 VSS) capacitor c=1.16129e-16
C87 (\1\:SE VSS) capacitor c=2.47732e-17
C88 (\2\:SI VSS) capacitor c=7.74104e-17
C89 (\2\:RNb VSS) capacitor c=3.31472e-17
C90 (\8\:RNb VSS) capacitor c=1.24868e-17
C91 (\2\:SEb VSS) capacitor c=7.84584e-17
C92 (\7\:n20 VSS) capacitor c=5.31271e-17
C93 (\4\:n20 VSS) capacitor c=1.14575e-16
C94 (\3\:D VSS) capacitor c=1.48838e-17
C95 (\2\:SN VSS) capacitor c=4.20564e-17
C96 (\5\:SN VSS) capacitor c=2.63342e-17
C97 (\3\:CKN VSS) capacitor c=2.4072e-17
C98 (\2\:mout VSS) capacitor c=4.65098e-17
C99 (\4\:mout VSS) capacitor c=3.16539e-17
C100 (\2\:CKNb VSS) capacitor c=8.03692e-17
C101 (\6\:CKNbb VSS) capacitor c=3.6548e-17
C102 (\5\:n20 VSS) capacitor c=1.14904e-16
C103 (\2\:CKNbb VSS) capacitor c=5.76045e-17
C104 (\5\:CKNb VSS) capacitor c=7.9745e-17
C105 (\9\:CKNb VSS) capacitor c=2.68274e-17
C106 (\7\:RNb VSS) capacitor c=1.32734e-16
C107 (\2\:n20 VSS) capacitor c=4.55966e-17
C108 (\3\:RN VSS) capacitor c=4.65612e-17
C109 (\1\:VDD VSS) capacitor c=2.99681e-17
C110 (\11\:VDD VSS) capacitor c=4.72134e-17
C111 (\1\:Q VSS) capacitor c=6.01038e-17
C112 (\13\:VDD VSS) capacitor c=4.90394e-17
C113 (\3\:n11 VSS) capacitor c=9.83748e-17
C114 (\14\:n35 VSS) capacitor c=5.35185e-17
C115 (\15\:n35g VSS) capacitor c=5.68608e-17
C116 (\6\:RTb VSS) capacitor c=7.21465e-17
C117 (\1\:ExtVDD VSS) capacitor c=2.78476e-16
C118 (\9\:n35 VSS) capacitor c=6.17256e-17
C119 (\14\:qbint VSS) capacitor c=6.81232e-17
C120 (\6\:n35g VSS) capacitor c=9.40263e-17
C121 (\8\:SEb VSS) capacitor c=5.05319e-17
C122 (\4\:n35 VSS) capacitor c=7.23682e-17
C123 (\15\:VDD VSS) capacitor c=6.08505e-17
C124 (\5\:mout VSS) capacitor c=1.33866e-16
C125 (\17\:VDD VSS) capacitor c=4.33457e-17
C126 (\3\:Db VSS) capacitor c=1.83667e-16
C127 (\19\:mout VSS) capacitor c=3.68795e-17
C128 (\22\:VDD VSS) capacitor c=3.54334e-17
C129 (\16\:mout VSS) capacitor c=4.28841e-17
C130 (\20\:CKNb VSS) capacitor c=2.97998e-17
C131 (\20\:VDD VSS) capacitor c=4.82871e-17
C132 (\12\:CKNbb VSS) capacitor c=6.19154e-17
C133 (\13\:n20 VSS) capacitor c=6.2284e-17
C134 (\5\:Db VSS) capacitor c=2.27666e-16
C135 (\10\:RNb VSS) capacitor c=5.04168e-17
C136 (\10\:n20 VSS) capacitor c=6.33369e-17
C137 (\24\:VDD VSS) capacitor c=4.56802e-17
C138 (\3\:Q VSS) capacitor c=4.15894e-17
C139 (\3\:n8 VSS) capacitor c=8.0956e-17
C140 (\3\:n10 VSS) capacitor c=8.13502e-17
C141 (\17\:n35 VSS) capacitor c=4.82161e-17
C142 (\11\:n35g VSS) capacitor c=2.62261e-17
C143 (\10\:RTb VSS) capacitor c=5.80906e-17
C144 (\12\:n35 VSS) capacitor c=6.34409e-17
C145 (\16\:qbint VSS) capacitor c=2.43025e-17
C146 (\9\:n35g VSS) capacitor c=8.00873e-17
C147 (\4\:SEb VSS) capacitor c=3.94072e-17
C148 (\7\:n35 VSS) capacitor c=4.89445e-17
C149 (\11\:mout VSS) capacitor c=3.71624e-17
C150 (\13\:mout VSS) capacitor c=3.82409e-17
C151 (\3\:n4 VSS) capacitor c=1.00173e-16
C152 (\16\:CKNb VSS) capacitor c=4.82074e-17
C153 (\15\:CKNbb VSS) capacitor c=6.3181e-17
C154 (\17\:n20 VSS) capacitor c=8.58437e-17
C155 (\7\:Db VSS) capacitor c=1.10338e-16
C156 (\13\:RNb VSS) capacitor c=7.34902e-17
C157 (\8\:n20 VSS) capacitor c=5.95553e-17
C158 (VDD VSS) capacitor c=7.17531e-17
C159 (\2\:CKN VSS) capacitor c=3.45395e-17
C160 (\2\:D VSS) capacitor c=3.59415e-17
C161 (\2\:SE VSS) capacitor c=2.50121e-17
C162 (\4\:CKNbb VSS) capacitor c=1.54126e-16
C163 (\5\:CKNbb VSS) capacitor c=8.65795e-17
C164 (\2\:n35g VSS) capacitor c=2.91068e-17
C165 (\4\:RT VSS) capacitor c=7.42812e-17
C166 (\2\:qbint VSS) capacitor c=4.11428e-17
C167 (\7\:CKNb VSS) capacitor c=1.37045e-16
C168 (\8\:CKNb VSS) capacitor c=7.33662e-17
C169 (\4\:SN VSS) capacitor c=3.61221e-16
C170 (\12\:n20 VSS) capacitor c=4.63635e-17
C171 (\5\:RNb VSS) capacitor c=3.89507e-16
C172 (\6\:RNb VSS) capacitor c=1.80959e-16
C173 (\12\:RNb VSS) capacitor c=1.20385e-16
C174 (\14\:CKNb VSS) capacitor c=1.55652e-16
C175 (\15\:CKNb VSS) capacitor c=1.37959e-16
C176 (\8\:qbint VSS) capacitor c=1.0955e-16
C177 (\15\:n20 VSS) capacitor c=7.55702e-17
C178 (\16\:n20 VSS) capacitor c=9.2495e-17
C179 (\11\:CKNbb VSS) capacitor c=5.36369e-17
C180 (\14\:CKNbb VSS) capacitor c=8.37404e-17
C181 (\5\:CKN VSS) capacitor c=4.44478e-17
C182 (\18\:CKNb VSS) capacitor c=6.99813e-17
C183 (\19\:CKNb VSS) capacitor c=4.52339e-17
C184 (\11\:SN VSS) capacitor c=5.5103e-17
C185 (\19\:n20 VSS) capacitor c=8.09513e-17
C186 (\20\:n20 VSS) capacitor c=8.11054e-17
C187 (\15\:RNb VSS) capacitor c=7.08611e-17
C188 (\16\:RNb VSS) capacitor c=8.31202e-17
C189 (\7\:mout VSS) capacitor c=1.56129e-16
C190 (\8\:mout VSS) capacitor c=5.29694e-17
C191 (\9\:mout VSS) capacitor c=9.41773e-17
C192 (\10\:mout VSS) capacitor c=8.97704e-17
C193 (\15\:mout VSS) capacitor c=6.26595e-17
C194 (\18\:mout VSS) capacitor c=7.43324e-17
C195 (\6\:SEb VSS) capacitor c=8.35718e-17
C196 (\7\:SEb VSS) capacitor c=6.93987e-17
C197 (\6\:n35 VSS) capacitor c=1.06844e-16
C198 (\17\:CKNbb VSS) capacitor c=3.86724e-17
C199 (\18\:CKNbb VSS) capacitor c=4.17163e-17
C200 (\8\:n35g VSS) capacitor c=3.50808e-17
C201 (\11\:n35 VSS) capacitor c=7.54758e-17
C202 (\12\:qbint VSS) capacitor c=8.77654e-17
C203 (\13\:qbint VSS) capacitor c=1.11932e-16
C204 (\13\:n35g VSS) capacitor c=1.00317e-16
C205 (\14\:n35g VSS) capacitor c=1.15912e-16
C206 (\5\:RTb VSS) capacitor c=4.92668e-17
C207 (\8\:RTb VSS) capacitor c=1.00536e-16
C208 (\9\:RTb VSS) capacitor c=9.1424e-17
C209 (\10\:RT VSS) capacitor c=1.10449e-16
C210 (\11\:RT VSS) capacitor c=1.17918e-16
C211 (\12\:SN VSS) capacitor c=8.25765e-17
C212 (\13\:SN VSS) capacitor c=8.03267e-17
C213 (\22\:CKNb VSS) capacitor c=1.3168e-16
C214 (\23\:CKNb VSS) capacitor c=1.33733e-16
C215 (\18\:qbint VSS) capacitor c=1.9502e-17
C216 (\19\:qbint VSS) capacitor c=3.00427e-17
C217 (\16\:n35 VSS) capacitor c=5.06065e-17
C218 (\3\:VDD VSS) capacitor c=3.30871e-17
C219 (\4\:VDD VSS) capacitor c=2.6087e-17
C220 (\6\:VDD VSS) capacitor c=2.01956e-16
C221 (\7\:VDD VSS) capacitor c=2.1187e-16
C222 (\8\:VDD VSS) capacitor c=2.90348e-17
C223 (\10\:VDD VSS) capacitor c=5.17068e-17
C224 (\19\:VDD VSS) capacitor c=4.93348e-17
Rk50 (ExtVDD ExtVDD) resistor r=0.002067 c=0
Rk48 (\2\:ExtVDD ExtVDD) resistor r=0.02221 c=0
Rk51 (ExtVDD \5\:ExtVDD) resistor r=0.02019 c=0
Rk52 (ExtVDD \6\:ExtVDD) resistor r=0.15 c=0
Rk102 (VDD VDD) resistor r=0.2369 c=0
Rk88 (\2\:VDD \3\:VDD) resistor r=0.3383 c=0
Rk89 (\3\:VDD \4\:VDD) resistor r=0.2185 c=0
Rk90 (\4\:VDD \6\:VDD) resistor r=0.06698 c=0
Rk91 (\6\:VDD \7\:VDD) resistor r=1.5796 c=0
Rk92 (\7\:VDD \8\:VDD) resistor r=0.119 c=0
Rk93 (\8\:VDD \10\:VDD) resistor r=0.2218 c=0
Rk94 (\3\:VDD \12\:VDD) resistor r=0.3584 c=0
Rk95 (\4\:VDD \14\:VDD) resistor r=0.2944 c=0
Rk96 (\7\:VDD \16\:VDD) resistor r=0.3682 c=0
Rk97 (\8\:VDD \18\:VDD) resistor r=0.2027 c=0
Rk101 (\19\:VDD VDD) resistor r=0.1961 c=0
Rk98 (\10\:VDD \19\:VDD) resistor r=0.1715 c=0
Rk99 (\19\:VDD \21\:VDD) resistor r=0.2081 c=0
Rk100 (\10\:VDD \23\:VDD) resistor r=0.2362 c=0
Rk103 (VDD \25\:VDD) resistor r=0.3797 c=0
Rk72 (Q \2\:Q) resistor r=0.2861 c=0
Rk73 (Q \4\:Q) resistor r=0.2224 c=0
Rk76 (\2\:VSS \3\:VSS) resistor r=0.03215 c=0
Rk77 (\3\:VSS \4\:VSS) resistor r=0.5148 c=0
Rk78 (\4\:VSS \5\:VSS) resistor r=0.5176 c=0
Rk80 (\6\:VSS VSS) resistor r=0.04951 c=0
Rk79 (\5\:VSS \6\:VSS) resistor r=0.3282 c=0
Rk82 (\7\:VSS VSS) resistor r=0.1217 c=0
Rk81 (VSS \7\:VSS) resistor r=0.8959 c=0
Rk83 (VSS \8\:VSS) resistor r=0.01747 c=0
Rk84 (\8\:VSS \10\:VSS) resistor r=0.6655 c=0
Rk85 (\3\:VSS \12\:VSS) resistor r=0.2499 c=0
Rk86 (\5\:VSS \14\:VSS) resistor r=0.2448 c=0
Rk87 (\8\:VSS \16\:VSS) resistor r=0.2525 c=0
Rk104 (\18\:VSS \20\:VSS) resistor r=0.4128 c=0
Rk105 (\20\:VSS \21\:VSS) resistor r=0.8631 c=0
Rk106 (\21\:VSS \22\:VSS) resistor r=0.03215 c=0
Rk108 (\23\:VSS VSS) resistor r=0.1215 c=0
Rk107 (\22\:VSS \23\:VSS) resistor r=0.1764 c=0
Rk109 (VSS \24\:VSS) resistor r=0.5225 c=0
Rk110 (\24\:VSS \25\:VSS) resistor r=0.3081 c=0
Rk112 (\26\:VSS VSS) resistor r=0.1217 c=0
Rk111 (\25\:VSS \26\:VSS) resistor r=0.06449 c=0
Rk113 (VSS \28\:VSS) resistor r=0.3134 c=0
Rk114 (\21\:VSS \30\:VSS) resistor r=0.1902 c=0
Rk115 (\23\:VSS \32\:VSS) resistor r=0.1953 c=0
Rk116 (\24\:VSS \34\:VSS) resistor r=0.2547 c=0
Rk117 (\25\:VSS \36\:VSS) resistor r=0.2503 c=0
Rk13 (CKN \5\:CKN) resistor r=0.009285 c=0
Rk18 (SN \11\:SN) resistor r=0.294 c=0
Rk66 (\12\:SN \13\:SN) resistor r=0.5387 c=0
Rk1 (\5\:RN RN) resistor r=0.002448 c=0
Rk64 (RT \10\:RT) resistor r=0.1995 c=0
Rk65 (\10\:RT \11\:RT) resistor r=0.6497 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.546 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2555 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3473 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2307 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.4991 c=0
Rk23 (\19\:n20 \20\:n20) resistor r=0.4639 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8535 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3188 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.1839 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1875 c=0
Rk67 (\22\:CKNb \23\:CKNb) resistor r=0.8291 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.7661 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3543 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1719 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.3439 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.1237 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.1002 c=0
Rk34 (\9\:mout \15\:mout) resistor r=0.5272 c=0
Rk35 (\15\:mout \17\:mout) resistor r=0.04493 c=0
Rk36 (\10\:mout \18\:mout) resistor r=0.4274 c=0
Rk37 (\15\:mout \20\:mout) resistor r=0.03471 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1643 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3826 c=0
Rk25 (\15\:RNb \16\:RNb) resistor r=0.3484 c=0
Rk10 (\11\:CKNbb \13\:CKNbb) resistor r=0.1427 c=0
Rk11 (\13\:CKNbb \14\:CKNbb) resistor r=0.4287 c=0
Rk12 (\14\:CKNbb \16\:CKNbb) resistor r=0.2423 c=0
Rk43 (\17\:CKNbb \18\:CKNbb) resistor r=0.3735 c=0
Rk38 (\5\:SEb \6\:SEb) resistor r=0.2173 c=0
Rk39 (\6\:SEb \7\:SEb) resistor r=0.3565 c=0
Rk40 (\6\:SEb \9\:SEb) resistor r=0.3114 c=0
Rk44 (\7\:n35g \8\:n35g) resistor r=0.2748 c=0
Rk45 (\7\:n35g \10\:n35g) resistor r=0.6952 c=0
Rk56 (\12\:n35g \13\:n35g) resistor r=0.2443 c=0
Rk57 (\13\:n35g \14\:n35g) resistor r=0.5686 c=0
Rk58 (\13\:n35g \16\:n35g) resistor r=0.4343 c=0
Rk53 (\12\:qbint \13\:qbint) resistor r=0.4973 c=0
Rk54 (\13\:qbint \15\:qbint) resistor r=0.5702 c=0
Rk55 (\13\:qbint \17\:qbint) resistor r=0.1471 c=0
Rk68 (\18\:qbint \19\:qbint) resistor r=0.2129 c=0
Rk59 (\5\:RTb \7\:RTb) resistor r=0.2174 c=0
Rk60 (\7\:RTb \8\:RTb) resistor r=0.4188 c=0
Rk61 (\8\:RTb \9\:RTb) resistor r=0.6924 c=0
Rk62 (\8\:RTb \11\:RTb) resistor r=0.3083 c=0
Rk41 (\5\:n35 \6\:n35) resistor r=0.4313 c=0
Rk42 (\6\:n35 \8\:n35) resistor r=0.3043 c=0
Rk46 (\10\:n35 \11\:n35) resistor r=0.4031 c=0
Rk47 (\11\:n35 \13\:n35) resistor r=0.3317 c=0
Rk69 (\15\:n35 \16\:n35) resistor r=0.3054 c=0
Rk70 (\16\:n35 \18\:n35) resistor r=0.289 c=0
Rk20 (\2\:Db \4\:Db) resistor r=0.6398 c=0
Rk21 (\4\:Db \6\:Db) resistor r=1.363 c=0
Rk22 (\6\:Db \8\:Db) resistor r=0.6354 c=0
Rk74 (\2\:n11 \4\:n11) resistor r=0.7175 c=0
Rk75 (\2\:n8 \4\:n8) resistor r=0.533 c=0
Rk71 (\2\:n10 \4\:n10) resistor r=0.629 c=0
Rk24 (\2\:n4 \4\:n4) resistor r=0.5552 c=0
Rl18 (\2\:D \4\:D) resistor r=115.099 c=0
Rl16 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl17 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl29 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl31 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl28 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl30 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl27 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl75 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl76 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl15 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl59 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl57 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl58 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl26 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl25 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl43 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl46 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl45 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl44 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl21 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl19 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl20 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl6 (CKNb \2\:CKNb) resistor r=120.949 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=63.2566 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl51 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl54 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl55 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl53 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl52 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl64 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl24 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl65 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl68 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl69 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl67 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl66 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl63 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl35 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl32 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl36 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl34 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl33 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl22 (SEb \2\:SEb) resistor r=101.718 c=0
Rl23 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl39 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl37 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl38 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl40 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl70 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl74 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl50 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl47 (qbint \2\:qbint) resistor r=112.732 c=0
Rl49 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl48 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl71 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl73 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl72 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl41 (RTb \2\:RTb) resistor r=112.412 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl60 (n35 \2\:n35) resistor r=508.667 c=0
Rl61 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz23 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz26 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz27 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz28 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz29 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz32 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz33 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz34 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz35 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz36 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz37 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz20 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz24 (n8 \2\:n8) resistor r=75 c=0
Rz25 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz21 (n10 \2\:n10) resistor r=75 c=0
Rz22 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry30 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry31 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry32 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry35 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry36 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry22 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry25 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry26 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry27 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry28 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=10.3333 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry39 (\19\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx14 (\3\:D D) resistor r=45 c=0
Rx20 (\1\:SE SE) resistor r=45 c=0
Rx10 (\3\:CKN \5\:CKN) resistor r=45 c=0
Rx12 (\5\:SN SN) resistor r=45 c=0
Rx13 (\2\:SN \11\:SN) resistor r=45 c=0
Rx36 (\3\:SN \12\:SN) resistor r=45 c=0
Rx37 (\9\:SN \13\:SN) resistor r=45 c=0
Rx19 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx33 (\7\:RT RT) resistor r=45 c=0
Rx34 (\3\:RT \10\:RT) resistor r=45 c=0
Rx35 (\1\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx15 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx16 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx11 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx38 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx39 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx21 (\4\:mout \10\:mout) resistor r=45 c=0
Rx22 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx17 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx18 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx8 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx25 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx26 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx27 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx30 (n35g \14\:n35g) resistor r=45 c=0
Rx29 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx40 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx41 (qbint \19\:qbint) resistor r=45 c=0
Rx31 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx32 (RTb \9\:RTb) resistor r=45 c=0
Rx24 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx28 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx42 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\16\:qbint \5\:n35g \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \11\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\3\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n9 \4\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \10\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\1\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFNSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:00:27 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSRX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSRX1 CKN D ExtVDD Q QN RN RT SE SI SN VDD VSS
mp22 (\10\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.3671 \
        scb=0.0284976 scc=0.00222335 m=(1)
C1 (QN VSS) capacitor c=1.85273e-17
C2 (VDD VSS) capacitor c=7.82628e-16
C3 (Q VSS) capacitor c=6.71226e-17
C4 (SE VSS) capacitor c=3.3841e-17
C5 (D VSS) capacitor c=4.00569e-17
C6 (ExtVDD VSS) capacitor c=2.42466e-16
C7 (CKN VSS) capacitor c=4.35855e-17
C8 (RN VSS) capacitor c=7.43973e-17
C9 (RT VSS) capacitor c=2.37203e-17
C10 (SI VSS) capacitor c=8.71604e-17
C11 (SN VSS) capacitor c=3.96554e-17
C12 (n20 VSS) capacitor c=3.89425e-17
C13 (CKNb VSS) capacitor c=4.68243e-17
C14 (mout VSS) capacitor c=5.41376e-17
C15 (RNb VSS) capacitor c=3.91539e-17
C16 (CKNbb VSS) capacitor c=3.22863e-17
C17 (SEb VSS) capacitor c=7.77632e-17
C18 (n35g VSS) capacitor c=1.7772e-17
C19 (qbint VSS) capacitor c=4.54322e-17
C20 (RTb VSS) capacitor c=5.17974e-17
C21 (net573 VSS) capacitor c=2.25772e-17
C22 (n35 VSS) capacitor c=1.71935e-16
C23 (Db VSS) capacitor c=1.02053e-16
C24 (n11 VSS) capacitor c=8.43539e-17
C25 (n8 VSS) capacitor c=7.92568e-17
C26 (n10 VSS) capacitor c=8.42863e-17
C27 (n4 VSS) capacitor c=8.69277e-17
C28 (n1 VSS) capacitor c=1.02126e-18
C29 (\7\:SN VSS) capacitor c=7.05736e-17
C30 (\7\:qbint VSS) capacitor c=3.43295e-17
C31 (\11\:qbint VSS) capacitor c=1.41633e-16
C32 (\4\:RNb VSS) capacitor c=4.03735e-16
C33 (\13\:qbint VSS) capacitor c=4.40896e-17
C34 (\3\:net573 VSS) capacitor c=5.86653e-17
C35 (\12\:CKNb VSS) capacitor c=5.76361e-17
C36 (\4\:RTb VSS) capacitor c=9.88373e-17
C37 (\6\:RT VSS) capacitor c=2.20615e-17
C38 (\4\:qbint VSS) capacitor c=5.36612e-17
C39 (\3\:n35g VSS) capacitor c=5.22477e-17
C40 (\5\:RT VSS) capacitor c=8.2554e-17
C41 (\3\:SE VSS) capacitor c=7.72951e-17
C42 (\7\:CKNbb VSS) capacitor c=3.84202e-17
C43 (\3\:SI VSS) capacitor c=9.74944e-17
C44 (\9\:RNb VSS) capacitor c=6.01657e-17
C45 (\4\:SE VSS) capacitor c=1.2213e-16
C46 (\3\:n20 VSS) capacitor c=4.73671e-17
C47 (\4\:D VSS) capacitor c=6.87696e-17
C48 (\1\:SN VSS) capacitor c=3.03254e-17
C49 (\4\:CKN VSS) capacitor c=5.61144e-17
C50 (\4\:CKNb VSS) capacitor c=4.42171e-17
C51 (\8\:CKNbb VSS) capacitor c=8.24748e-17
C52 (\3\:CKNb VSS) capacitor c=1.09064e-16
C53 (\1\:RN VSS) capacitor c=4.24586e-17
C54 (\8\:SN VSS) capacitor c=1.32242e-16
C55 (\6\:qbint VSS) capacitor c=3.80033e-17
C56 (\12\:qbint VSS) capacitor c=8.06262e-17
C57 (\3\:RNb VSS) capacitor c=6.80787e-17
C58 (\14\:qbint VSS) capacitor c=4.6006e-17
C59 (\4\:net573 VSS) capacitor c=3.67833e-17
C60 (\9\:CKNbb VSS) capacitor c=2.22471e-16
C61 (\8\:RT VSS) capacitor c=1.21318e-16
C62 (\2\:RT VSS) capacitor c=6.21972e-17
C63 (\5\:qbint VSS) capacitor c=3.89021e-17
C64 (\5\:n35g VSS) capacitor c=3.28666e-17
C65 (\2\:RTb VSS) capacitor c=4.66333e-17
C66 (\5\:SE VSS) capacitor c=5.7887e-17
C67 (\6\:CKNb VSS) capacitor c=3.24964e-17
C68 (\1\:SI VSS) capacitor c=4.91308e-17
C69 (\6\:SE VSS) capacitor c=8.62004e-17
C70 (\3\:SEb VSS) capacitor c=6.60115e-17
C71 (\1\:D VSS) capacitor c=4.95122e-17
C72 (\6\:n20 VSS) capacitor c=6.12355e-17
C73 (\6\:SN VSS) capacitor c=4.59773e-17
C74 (\1\:CKN VSS) capacitor c=2.85189e-17
C75 (\3\:mout VSS) capacitor c=4.57969e-17
C76 (\11\:CKNb VSS) capacitor c=4.92133e-17
C77 (\4\:RN VSS) capacitor c=3.69343e-17
C78 (\10\:qbint VSS) capacitor c=8.56302e-17
C79 (\13\:CKNb VSS) capacitor c=7.94667e-17
C80 (\3\:SN VSS) capacitor c=3.75346e-16
C81 (\9\:SN VSS) capacitor c=9.14336e-17
C82 (\7\:RT VSS) capacitor c=1.53093e-16
C83 (\10\:CKNb VSS) capacitor c=1.67463e-16
C84 (\3\:RT VSS) capacitor c=5.78489e-17
C85 (\1\:RT VSS) capacitor c=5.2908e-17
C86 (\3\:RTb VSS) capacitor c=7.59476e-17
C87 (\3\:qbint VSS) capacitor c=4.44018e-17
C88 (\2\:n35 VSS) capacitor c=2.52896e-16
C89 (\4\:n35g VSS) capacitor c=6.71758e-17
C90 (\3\:CKNbb VSS) capacitor c=5.53018e-17
C91 (\10\:CKNbb VSS) capacitor c=2.1752e-16
C92 (\3\:n35 VSS) capacitor c=1.16124e-16
C93 (\1\:SE VSS) capacitor c=2.37301e-17
C94 (\2\:SI VSS) capacitor c=7.7714e-17
C95 (\2\:RNb VSS) capacitor c=3.31472e-17
C96 (\8\:RNb VSS) capacitor c=1.24508e-17
C97 (\2\:SEb VSS) capacitor c=7.77825e-17
C98 (\7\:n20 VSS) capacitor c=5.31162e-17
C99 (\4\:n20 VSS) capacitor c=1.14989e-16
C100 (\3\:D VSS) capacitor c=1.38488e-17
C101 (\2\:SN VSS) capacitor c=4.19768e-17
C102 (\5\:SN VSS) capacitor c=2.64542e-17
C103 (\3\:CKN VSS) capacitor c=2.3447e-17
C104 (\2\:mout VSS) capacitor c=4.65098e-17
C105 (\4\:mout VSS) capacitor c=3.16539e-17
C106 (\2\:CKNb VSS) capacitor c=7.96153e-17
C107 (\6\:CKNbb VSS) capacitor c=3.65314e-17
C108 (\5\:n20 VSS) capacitor c=1.1488e-16
C109 (\2\:CKNbb VSS) capacitor c=5.80807e-17
C110 (\5\:CKNb VSS) capacitor c=7.9745e-17
C111 (\9\:CKNb VSS) capacitor c=2.68274e-17
C112 (\7\:RNb VSS) capacitor c=1.32993e-16
C113 (\2\:n20 VSS) capacitor c=4.56024e-17
C114 (\3\:RN VSS) capacitor c=4.74049e-17
C115 (\1\:VDD VSS) capacitor c=2.99193e-17
C116 (\12\:VDD VSS) capacitor c=4.47012e-17
C117 (\3\:Q VSS) capacitor c=6.8661e-17
C118 (\14\:VDD VSS) capacitor c=4.89178e-17
C119 (\9\:net573 VSS) capacitor c=5.67387e-17
C120 (\16\:VDD VSS) capacitor c=7.94605e-17
C121 (\3\:n11 VSS) capacitor c=9.91812e-17
C122 (\4\:QN VSS) capacitor c=6.83589e-17
C123 (\14\:n35 VSS) capacitor c=5.34268e-17
C124 (\15\:n35g VSS) capacitor c=5.57509e-17
C125 (\6\:RTb VSS) capacitor c=7.20069e-17
C126 (\1\:ExtVDD VSS) capacitor c=2.78003e-16
C127 (\9\:n35 VSS) capacitor c=6.16151e-17
C128 (\17\:qbint VSS) capacitor c=6.80388e-17
C129 (\6\:n35g VSS) capacitor c=9.38837e-17
C130 (\8\:SEb VSS) capacitor c=4.91792e-17
C131 (\4\:n35 VSS) capacitor c=7.2232e-17
C132 (\18\:VDD VSS) capacitor c=5.87264e-17
C133 (\5\:mout VSS) capacitor c=1.33608e-16
C134 (\20\:VDD VSS) capacitor c=4.3269e-17
C135 (\3\:Db VSS) capacitor c=1.83582e-16
C136 (\19\:mout VSS) capacitor c=3.68247e-17
C137 (\25\:VDD VSS) capacitor c=3.53113e-17
C138 (\16\:mout VSS) capacitor c=4.36959e-17
C139 (\20\:CKNb VSS) capacitor c=2.93335e-17
C140 (\23\:VDD VSS) capacitor c=4.82067e-17
C141 (\12\:CKNbb VSS) capacitor c=5.93105e-17
C142 (\13\:n20 VSS) capacitor c=6.21861e-17
C143 (\5\:Db VSS) capacitor c=2.28932e-16
C144 (\10\:RNb VSS) capacitor c=5.0321e-17
C145 (\10\:n20 VSS) capacitor c=6.32549e-17
C146 (\27\:VDD VSS) capacitor c=3.98447e-17
C147 (\1\:Q VSS) capacitor c=5.28055e-17
C148 (\5\:net573 VSS) capacitor c=4.29385e-17
C149 (\3\:n8 VSS) capacitor c=8.08245e-17
C150 (\3\:n10 VSS) capacitor c=8.12131e-17
C151 (\1\:QN VSS) capacitor c=3.92176e-17
C152 (\17\:n35 VSS) capacitor c=4.81229e-17
C153 (\11\:n35g VSS) capacitor c=2.95879e-17
C154 (\10\:RTb VSS) capacitor c=5.7983e-17
C155 (\12\:n35 VSS) capacitor c=6.33278e-17
C156 (\19\:qbint VSS) capacitor c=2.42602e-17
C157 (\9\:n35g VSS) capacitor c=7.99627e-17
C158 (\4\:SEb VSS) capacitor c=3.81809e-17
C159 (\7\:n35 VSS) capacitor c=4.88653e-17
C160 (\11\:mout VSS) capacitor c=3.70935e-17
C161 (\13\:mout VSS) capacitor c=3.8164e-17
C162 (\3\:n4 VSS) capacitor c=1.00022e-16
C163 (\16\:CKNb VSS) capacitor c=6.31727e-17
C164 (\15\:CKNbb VSS) capacitor c=5.92313e-17
C165 (\17\:n20 VSS) capacitor c=8.56888e-17
C166 (\7\:Db VSS) capacitor c=1.10127e-16
C167 (\13\:RNb VSS) capacitor c=7.3362e-17
C168 (\8\:n20 VSS) capacitor c=5.94711e-17
C169 (VDD VSS) capacitor c=7.16216e-17
C170 (\2\:CKN VSS) capacitor c=3.31216e-17
C171 (\2\:D VSS) capacitor c=3.56137e-17
C172 (\2\:SE VSS) capacitor c=2.63409e-17
C173 (\4\:CKNbb VSS) capacitor c=1.54262e-16
C174 (\5\:CKNbb VSS) capacitor c=8.60489e-17
C175 (\2\:n35g VSS) capacitor c=2.90531e-17
C176 (\4\:RT VSS) capacitor c=7.42727e-17
C177 (\2\:qbint VSS) capacitor c=4.13305e-17
C178 (\7\:CKNb VSS) capacitor c=1.37045e-16
C179 (\8\:CKNb VSS) capacitor c=7.33368e-17
C180 (\4\:SN VSS) capacitor c=3.61036e-16
C181 (\2\:net573 VSS) capacitor c=1.52656e-17
C182 (\12\:n20 VSS) capacitor c=4.63155e-17
C183 (\5\:RNb VSS) capacitor c=3.89503e-16
C184 (\6\:RNb VSS) capacitor c=1.80962e-16
C185 (\12\:RNb VSS) capacitor c=1.1597e-16
C186 (\14\:CKNb VSS) capacitor c=1.55351e-16
C187 (\15\:CKNb VSS) capacitor c=1.3771e-16
C188 (\8\:qbint VSS) capacitor c=5.10295e-17
C189 (\9\:qbint VSS) capacitor c=7.71449e-17
C190 (\15\:n20 VSS) capacitor c=7.52847e-17
C191 (\16\:n20 VSS) capacitor c=9.23154e-17
C192 (\11\:CKNbb VSS) capacitor c=5.35039e-17
C193 (\14\:CKNbb VSS) capacitor c=7.93765e-17
C194 (\5\:CKN VSS) capacitor c=3.45146e-18
C195 (\6\:CKN VSS) capacitor c=3.41317e-17
C196 (\18\:CKNb VSS) capacitor c=6.51076e-17
C197 (\19\:CKNb VSS) capacitor c=3.73972e-17
C198 (\10\:SN VSS) capacitor c=4.4102e-17
C199 (\11\:SN VSS) capacitor c=4.55806e-17
C200 (\7\:D VSS) capacitor c=4.36106e-17
C201 (\19\:n20 VSS) capacitor c=8.0144e-17
C202 (\20\:n20 VSS) capacitor c=8.09807e-17
C203 (\15\:RNb VSS) capacitor c=7.07283e-17
C204 (\16\:RNb VSS) capacitor c=8.29616e-17
C205 (\7\:SE VSS) capacitor c=5.08663e-17
C206 (\7\:mout VSS) capacitor c=1.55818e-16
C207 (\8\:mout VSS) capacitor c=5.28652e-17
C208 (\9\:mout VSS) capacitor c=1.02948e-16
C209 (\10\:mout VSS) capacitor c=8.85809e-17
C210 (\15\:mout VSS) capacitor c=6.04063e-17
C211 (\18\:mout VSS) capacitor c=7.23255e-17
C212 (\6\:SEb VSS) capacitor c=8.38053e-17
C213 (\7\:SEb VSS) capacitor c=6.33247e-17
C214 (\6\:n35 VSS) capacitor c=1.06598e-16
C215 (\17\:CKNbb VSS) capacitor c=3.86002e-17
C216 (\18\:CKNbb VSS) capacitor c=4.1645e-17
C217 (\8\:n35g VSS) capacitor c=3.50411e-17
C218 (\11\:n35 VSS) capacitor c=7.53442e-17
C219 (\15\:qbint VSS) capacitor c=8.75403e-17
C220 (\16\:qbint VSS) capacitor c=1.11665e-16
C221 (\13\:n35g VSS) capacitor c=1.02151e-16
C222 (\14\:n35g VSS) capacitor c=1.15714e-16
C223 (\5\:RTb VSS) capacitor c=4.91988e-17
C224 (\8\:RTb VSS) capacitor c=1.00362e-16
C225 (\9\:RTb VSS) capacitor c=9.12712e-17
C226 (\9\:RT VSS) capacitor c=1.10625e-16
C227 (\10\:RT VSS) capacitor c=1.17695e-16
C228 (\11\:RT VSS) capacitor c=3.8089e-17
C229 (\12\:SN VSS) capacitor c=8.24211e-17
C230 (\13\:SN VSS) capacitor c=8.01901e-17
C231 (\22\:CKNb VSS) capacitor c=1.3101e-16
C232 (\23\:CKNb VSS) capacitor c=1.33492e-16
C233 (\21\:qbint VSS) capacitor c=2.4274e-17
C234 (\22\:qbint VSS) capacitor c=2.9991e-17
C235 (\3\:QN VSS) capacitor c=3.14959e-17
C236 (\16\:n35 VSS) capacitor c=5.05282e-17
C237 (\7\:net573 VSS) capacitor c=4.93937e-17
C238 (\8\:net573 VSS) capacitor c=3.49056e-17
C239 (\3\:VDD VSS) capacitor c=3.04314e-17
C240 (\4\:VDD VSS) capacitor c=3.03611e-17
C241 (\6\:VDD VSS) capacitor c=9.94689e-18
C242 (\7\:VDD VSS) capacitor c=2.1959e-16
C243 (\8\:VDD VSS) capacitor c=2.02712e-16
C244 (\9\:VDD VSS) capacitor c=2.83639e-17
C245 (\11\:VDD VSS) capacitor c=5.16114e-17
C246 (\22\:VDD VSS) capacitor c=4.90843e-17
Rk76 (\3\:QN QN) resistor r=0.03438 c=0
Rk75 (\2\:QN \3\:QN) resistor r=0.1966 c=0
Rk77 (\3\:QN \5\:QN) resistor r=0.3483 c=0
Rk116 (VDD VDD) resistor r=0.2375 c=0
Rk100 (\2\:VDD \3\:VDD) resistor r=0.3396 c=0
Rk101 (\3\:VDD \4\:VDD) resistor r=0.2191 c=0
Rk102 (\4\:VDD \6\:VDD) resistor r=0.06715 c=0
Rk103 (\6\:VDD \7\:VDD) resistor r=0.05218 c=0
Rk104 (\7\:VDD \8\:VDD) resistor r=1.531 c=0
Rk105 (\8\:VDD \9\:VDD) resistor r=0.1193 c=0
Rk106 (\9\:VDD \11\:VDD) resistor r=0.2224 c=0
Rk107 (\3\:VDD \13\:VDD) resistor r=0.36 c=0
Rk108 (\4\:VDD \15\:VDD) resistor r=0.2957 c=0
Rk109 (\7\:VDD \17\:VDD) resistor r=0.3778 c=0
Rk110 (\8\:VDD \19\:VDD) resistor r=0.3698 c=0
Rk111 (\9\:VDD \21\:VDD) resistor r=0.2036 c=0
Rk115 (\22\:VDD VDD) resistor r=0.1966 c=0
Rk112 (\11\:VDD \22\:VDD) resistor r=0.1719 c=0
Rk113 (\22\:VDD \24\:VDD) resistor r=0.209 c=0
Rk114 (\11\:VDD \26\:VDD) resistor r=0.2372 c=0
Rk117 (VDD \28\:VDD) resistor r=0.3813 c=0
Rk84 (\2\:Q Q) resistor r=0.1739 c=0
Rk85 (Q \4\:Q) resistor r=0.3037 c=0
Rk33 (SE \7\:SE) resistor r=0.04878 c=0
Rk22 (\5\:D D) resistor r=0.007236 c=0
Rk24 (\5\:D \7\:D) resistor r=0.0211 c=0
Rk23 (\6\:D \7\:D) resistor r=0.007236 c=0
Rk56 (ExtVDD ExtVDD) resistor r=0.002071 c=0
Rk54 (\2\:ExtVDD ExtVDD) resistor r=0.02225 c=0
Rk57 (ExtVDD \5\:ExtVDD) resistor r=0.02024 c=0
Rk58 (ExtVDD \6\:ExtVDD) resistor r=0.1503 c=0
Rk88 (\2\:VSS \3\:VSS) resistor r=0.03223 c=0
Rk89 (\3\:VSS \4\:VSS) resistor r=0.5161 c=0
Rk90 (\4\:VSS \5\:VSS) resistor r=0.5189 c=0
Rk92 (\6\:VSS VSS) resistor r=0.04963 c=0
Rk91 (\5\:VSS \6\:VSS) resistor r=0.329 c=0
Rk94 (\7\:VSS VSS) resistor r=0.122 c=0
Rk93 (VSS \7\:VSS) resistor r=0.8981 c=0
Rk95 (VSS \8\:VSS) resistor r=0.01751 c=0
Rk96 (\8\:VSS \10\:VSS) resistor r=0.6675 c=0
Rk97 (\3\:VSS \12\:VSS) resistor r=0.251 c=0
Rk98 (\5\:VSS \14\:VSS) resistor r=0.2459 c=0
Rk99 (\8\:VSS \16\:VSS) resistor r=0.2535 c=0
Rk118 (\18\:VSS \20\:VSS) resistor r=0.3643 c=0
Rk119 (\20\:VSS \21\:VSS) resistor r=0.2392 c=0
Rk120 (\21\:VSS \22\:VSS) resistor r=0.05966 c=0
Rk121 (\22\:VSS \23\:VSS) resistor r=0.6158 c=0
Rk122 (\23\:VSS \24\:VSS) resistor r=0.03223 c=0
Rk124 (\25\:VSS VSS) resistor r=0.1218 c=0
Rk123 (\24\:VSS \25\:VSS) resistor r=0.1769 c=0
Rk125 (VSS \26\:VSS) resistor r=0.5238 c=0
Rk126 (\26\:VSS \27\:VSS) resistor r=0.3089 c=0
Rk128 (\28\:VSS VSS) resistor r=0.122 c=0
Rk127 (\27\:VSS \28\:VSS) resistor r=0.06465 c=0
Rk129 (VSS \30\:VSS) resistor r=0.3145 c=0
Rk130 (\21\:VSS \32\:VSS) resistor r=0.2694 c=0
Rk131 (\23\:VSS \34\:VSS) resistor r=0.1911 c=0
Rk132 (\25\:VSS \36\:VSS) resistor r=0.1962 c=0
Rk133 (\26\:VSS \38\:VSS) resistor r=0.2558 c=0
Rk134 (\27\:VSS \40\:VSS) resistor r=0.2514 c=0
Rk13 (CKN \5\:CKN) resistor r=0.001729 c=0
Rk16 (\5\:CKN \6\:CKN) resistor r=0.008633 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.003644 c=0
Rk1 (\5\:RN RN) resistor r=0.007312 c=0
Rk69 (RT \9\:RT) resistor r=0.1853 c=0
Rk70 (\9\:RT \10\:RT) resistor r=0.6525 c=0
Rk71 (RT \11\:RT) resistor r=0.01486 c=0
Rk32 (\4\:SI SI) resistor r=0.001105 c=0
Rk20 (SN \10\:SN) resistor r=0.008882 c=0
Rk21 (SN \11\:SN) resistor r=0.2636 c=0
Rk72 (\12\:SN \13\:SN) resistor r=0.541 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5483 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2565 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3488 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.2316 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.5012 c=0
Rk28 (\19\:n20 \20\:n20) resistor r=0.4658 c=0
Rk6 (\14\:CKNb \15\:CKNb) resistor r=0.8571 c=0
Rk17 (\17\:CKNb \18\:CKNb) resistor r=0.3475 c=0
Rk18 (\18\:CKNb \19\:CKNb) resistor r=0.1811 c=0
Rk19 (\18\:CKNb \21\:CKNb) resistor r=0.1685 c=0
Rk73 (\22\:CKNb \23\:CKNb) resistor r=0.8325 c=0
Rk34 (\6\:mout \7\:mout) resistor r=0.7692 c=0
Rk35 (\7\:mout \8\:mout) resistor r=0.3559 c=0
Rk36 (\8\:mout \9\:mout) resistor r=0.1726 c=0
Rk37 (\9\:mout \10\:mout) resistor r=0.3464 c=0
Rk38 (\7\:mout \12\:mout) resistor r=0.1242 c=0
Rk39 (\8\:mout \14\:mout) resistor r=0.1007 c=0
Rk40 (\9\:mout \15\:mout) resistor r=0.5295 c=0
Rk41 (\15\:mout \17\:mout) resistor r=0.04502 c=0
Rk42 (\10\:mout \18\:mout) resistor r=0.4291 c=0
Rk43 (\15\:mout \20\:mout) resistor r=0.03478 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.165 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3842 c=0
Rk30 (\15\:RNb \16\:RNb) resistor r=0.3498 c=0
Rk10 (\11\:CKNbb \13\:CKNbb) resistor r=0.1433 c=0
Rk11 (\13\:CKNbb \14\:CKNbb) resistor r=0.4267 c=0
Rk12 (\14\:CKNbb \16\:CKNbb) resistor r=0.2384 c=0
Rk49 (\17\:CKNbb \18\:CKNbb) resistor r=0.375 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.219 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.3481 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.3125 c=0
Rk50 (\7\:n35g \8\:n35g) resistor r=0.2759 c=0
Rk51 (\7\:n35g \10\:n35g) resistor r=0.6982 c=0
Rk62 (\12\:n35g \13\:n35g) resistor r=0.2453 c=0
Rk63 (\13\:n35g \14\:n35g) resistor r=0.5711 c=0
Rk64 (\13\:n35g \16\:n35g) resistor r=0.4361 c=0
Rk59 (\15\:qbint \16\:qbint) resistor r=0.4995 c=0
Rk60 (\16\:qbint \18\:qbint) resistor r=0.5726 c=0
Rk61 (\16\:qbint \20\:qbint) resistor r=0.1477 c=0
Rk74 (\21\:qbint \22\:qbint) resistor r=0.2138 c=0
Rk65 (\5\:RTb \7\:RTb) resistor r=0.2183 c=0
Rk66 (\7\:RTb \8\:RTb) resistor r=0.4206 c=0
Rk67 (\8\:RTb \9\:RTb) resistor r=0.6954 c=0
Rk68 (\8\:RTb \11\:RTb) resistor r=0.3096 c=0
Rk80 (\6\:net573 \7\:net573) resistor r=0.2391 c=0
Rk81 (\7\:net573 \8\:net573) resistor r=0.1666 c=0
Rk82 (\7\:net573 \10\:net573) resistor r=0.2949 c=0
Rk47 (\5\:n35 \6\:n35) resistor r=0.4331 c=0
Rk48 (\6\:n35 \8\:n35) resistor r=0.3056 c=0
Rk52 (\10\:n35 \11\:n35) resistor r=0.4048 c=0
Rk53 (\11\:n35 \13\:n35) resistor r=0.3331 c=0
Rk78 (\15\:n35 \16\:n35) resistor r=0.3067 c=0
Rk79 (\16\:n35 \18\:n35) resistor r=0.2902 c=0
Rk25 (\2\:Db \4\:Db) resistor r=0.6418 c=0
Rk26 (\4\:Db \6\:Db) resistor r=1.3687 c=0
Rk27 (\6\:Db \8\:Db) resistor r=0.6405 c=0
Rk86 (\2\:n11 \4\:n11) resistor r=0.7206 c=0
Rk87 (\2\:n8 \4\:n8) resistor r=0.5353 c=0
Rk83 (\2\:n10 \4\:n10) resistor r=0.6316 c=0
Rk29 (\2\:n4 \4\:n4) resistor r=0.5575 c=0
Rl29 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl31 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl28 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl30 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl27 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\2\:D \4\:D) resistor r=115.099 c=0
Rl16 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl17 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl12 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl13 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl43 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl46 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl45 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl44 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl26 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl25 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl81 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl82 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl15 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl59 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl57 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl58 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl21 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl19 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl20 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl62 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl6 (CKNb \2\:CKNb) resistor r=132.176 c=0
Rl8 (\2\:CKNb \4\:CKNb) resistor r=51.7181 c=0
Rl7 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl9 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl51 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl54 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl55 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl53 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl52 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl10 (mout \2\:mout) resistor r=24.2328 c=0
Rl11 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl67 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl24 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl68 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl71 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl72 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl70 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl69 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl63 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl35 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl32 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl36 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl34 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl33 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl22 (SEb \2\:SEb) resistor r=101.718 c=0
Rl23 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl39 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl37 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl38 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl40 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl73 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl78 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl80 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl50 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl47 (qbint \2\:qbint) resistor r=112.732 c=0
Rl49 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl48 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl74 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl77 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl79 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl76 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl75 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl41 (RTb \2\:RTb) resistor r=112.412 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl64 (net573 \2\:net573) resistor r=3.1216 c=0
Rl65 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl66 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl60 (n35 \2\:n35) resistor r=508.667 c=0
Rl61 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz25 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz28 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz29 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz30 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz31 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz34 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz35 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz36 (\31\:VSS \32\:VSS) resistor r=37.5 c=0
Rz37 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz38 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz39 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz40 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz5 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz22 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz21 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz26 (n8 \2\:n8) resistor r=75 c=0
Rz27 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz23 (n10 \2\:n10) resistor r=75 c=0
Rz24 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry21 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry31 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry32 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry33 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry34 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry35 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry36 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry37 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry38 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry39 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry27 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry28 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry30 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry41 (\19\:VSS \22\:VSS) resistor r=62 c=0
Ry42 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry43 (\19\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry5 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry23 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry22 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry25 (n11 \2\:n11) resistor r=62 c=0
Ry26 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx20 (\1\:SE \7\:SE) resistor r=45 c=0
Rx14 (\3\:D \6\:D) resistor r=45 c=0
Rx10 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx33 (\3\:RT \9\:RT) resistor r=45 c=0
Rx34 (\1\:RT \10\:RT) resistor r=45 c=0
Rx35 (\7\:RT \11\:RT) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx12 (\5\:SN \10\:SN) resistor r=45 c=0
Rx13 (\2\:SN \11\:SN) resistor r=45 c=0
Rx36 (\3\:SN \12\:SN) resistor r=45 c=0
Rx37 (\9\:SN \13\:SN) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx15 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx16 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx11 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx38 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx39 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx21 (\4\:mout \10\:mout) resistor r=45 c=0
Rx22 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx17 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx18 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx8 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx9 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx25 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx26 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx27 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx30 (n35g \14\:n35g) resistor r=45 c=0
Rx29 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx40 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx41 (qbint \22\:qbint) resistor r=45 c=0
Rx31 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx32 (RTb \9\:RTb) resistor r=45 c=0
Rx43 (net573 \8\:net573) resistor r=45 c=0
Rx24 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx28 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx42 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \4\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:01:20 2012 )
// Library name: gsclib045
// Cell name: SRDFFNSX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNSX1 CKN D ExtVDD Q QN RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=6.50503e-17
C2 (D VSS) capacitor c=4.29856e-17
C3 (QN VSS) capacitor c=2.72399e-17
C4 (SI VSS) capacitor c=5.24843e-17
C5 (RT VSS) capacitor c=2.31033e-17
C6 (CKN VSS) capacitor c=4.0004e-17
C7 (ExtVDD VSS) capacitor c=2.26731e-16
C8 (SN VSS) capacitor c=4.3895e-17
C9 (VDD VSS) capacitor c=7.29086e-16
C10 (SE VSS) capacitor c=3.95958e-17
C11 (n20 VSS) capacitor c=3.87782e-17
C12 (CKNb VSS) capacitor c=4.67654e-17
C13 (mout VSS) capacitor c=5.40676e-17
C14 (CKNbb VSS) capacitor c=3.2283e-17
C15 (SEb VSS) capacitor c=7.7527e-17
C16 (n35g VSS) capacitor c=1.77753e-17
C17 (qbint VSS) capacitor c=4.57835e-17
C18 (RTb VSS) capacitor c=5.17974e-17
C19 (net573 VSS) capacitor c=2.25505e-17
C20 (n35 VSS) capacitor c=1.72516e-16
C21 (Db VSS) capacitor c=1.04332e-16
C22 (n11 VSS) capacitor c=7.99274e-17
C23 (n1 VSS) capacitor c=1.02126e-18
C24 (\7\:qbint VSS) capacitor c=3.39567e-17
C25 (\7\:SN VSS) capacitor c=8.59805e-17
C26 (\11\:qbint VSS) capacitor c=1.07051e-16
C27 (\13\:qbint VSS) capacitor c=4.4202e-17
C28 (\3\:net573 VSS) capacitor c=5.86782e-17
C29 (\12\:CKNb VSS) capacitor c=4.51801e-17
C30 (\4\:RTb VSS) capacitor c=9.88373e-17
C31 (\6\:RT VSS) capacitor c=2.23208e-17
C32 (\4\:qbint VSS) capacitor c=5.36612e-17
C33 (\3\:n35g VSS) capacitor c=5.21237e-17
C34 (\5\:RT VSS) capacitor c=6.48597e-17
C35 (\3\:SE VSS) capacitor c=7.72467e-17
C36 (\7\:CKNbb VSS) capacitor c=3.10427e-17
C37 (\3\:SI VSS) capacitor c=9.47876e-17
C38 (\4\:SE VSS) capacitor c=1.22143e-16
C39 (\3\:n20 VSS) capacitor c=2.47551e-17
C40 (\4\:D VSS) capacitor c=7.06284e-17
C41 (\1\:SN VSS) capacitor c=3.02849e-17
C42 (\4\:CKN VSS) capacitor c=5.6388e-17
C43 (\4\:CKNb VSS) capacitor c=4.40687e-17
C44 (\8\:CKNbb VSS) capacitor c=8.28807e-17
C45 (\3\:CKNb VSS) capacitor c=1.11535e-16
C46 (\6\:qbint VSS) capacitor c=3.77007e-17
C47 (\14\:qbint VSS) capacitor c=4.5993e-17
C48 (\8\:SN VSS) capacitor c=1.45704e-16
C49 (\12\:qbint VSS) capacitor c=1.48984e-16
C50 (\4\:net573 VSS) capacitor c=3.69215e-17
C51 (\9\:CKNbb VSS) capacitor c=2.53723e-16
C52 (\8\:RT VSS) capacitor c=1.22171e-16
C53 (\2\:RT VSS) capacitor c=6.21869e-17
C54 (\5\:qbint VSS) capacitor c=3.89021e-17
C55 (\5\:n35g VSS) capacitor c=3.28666e-17
C56 (\2\:RTb VSS) capacitor c=4.64921e-17
C57 (\5\:SE VSS) capacitor c=5.7887e-17
C58 (\6\:CKNb VSS) capacitor c=2.72722e-17
C59 (\1\:SI VSS) capacitor c=4.91308e-17
C60 (\6\:SE VSS) capacitor c=8.61913e-17
C61 (\3\:SEb VSS) capacitor c=6.60115e-17
C62 (\1\:D VSS) capacitor c=4.95122e-17
C63 (\6\:n20 VSS) capacitor c=8.23106e-17
C64 (\6\:SN VSS) capacitor c=7.01056e-17
C65 (\1\:CKN VSS) capacitor c=2.85207e-17
C66 (\3\:mout VSS) capacitor c=4.47479e-17
C67 (\11\:CKNb VSS) capacitor c=4.84288e-17
C68 (\10\:qbint VSS) capacitor c=8.39937e-17
C69 (\13\:CKNb VSS) capacitor c=5.14498e-17
C70 (\3\:SN VSS) capacitor c=2.84655e-16
C71 (\9\:SN VSS) capacitor c=6.35258e-17
C72 (\7\:RT VSS) capacitor c=1.44518e-16
C73 (\10\:CKNb VSS) capacitor c=1.6785e-16
C74 (\3\:RT VSS) capacitor c=3.94579e-17
C75 (\1\:RT VSS) capacitor c=5.29002e-17
C76 (\3\:RTb VSS) capacitor c=7.59476e-17
C77 (\3\:qbint VSS) capacitor c=4.43247e-17
C78 (\2\:n35 VSS) capacitor c=2.52896e-16
C79 (\4\:n35g VSS) capacitor c=6.67497e-17
C80 (\3\:CKNbb VSS) capacitor c=5.04575e-17
C81 (\10\:CKNbb VSS) capacitor c=2.18493e-16
C82 (\3\:n35 VSS) capacitor c=1.16031e-16
C83 (\1\:SE VSS) capacitor c=2.48251e-17
C84 (\2\:SI VSS) capacitor c=7.76389e-17
C85 (\2\:SEb VSS) capacitor c=7.74449e-17
C86 (\7\:n20 VSS) capacitor c=4.70827e-17
C87 (\4\:n20 VSS) capacitor c=7.26936e-17
C88 (\3\:D VSS) capacitor c=1.46913e-17
C89 (\2\:SN VSS) capacitor c=4.20045e-17
C90 (\5\:SN VSS) capacitor c=2.61163e-17
C91 (\3\:CKN VSS) capacitor c=2.33622e-17
C92 (\2\:mout VSS) capacitor c=4.67069e-17
C93 (\4\:mout VSS) capacitor c=2.82052e-17
C94 (\2\:CKNb VSS) capacitor c=7.90776e-17
C95 (\6\:CKNbb VSS) capacitor c=3.65273e-17
C96 (\5\:n20 VSS) capacitor c=7.82352e-17
C97 (\2\:CKNbb VSS) capacitor c=5.80279e-17
C98 (\5\:CKNb VSS) capacitor c=7.21011e-17
C99 (\9\:CKNb VSS) capacitor c=2.45443e-17
C100 (\2\:n20 VSS) capacitor c=3.96202e-17
C101 (\1\:VDD VSS) capacitor c=4.33505e-17
C102 (\12\:VDD VSS) capacitor c=2.78404e-17
C103 (\3\:Q VSS) capacitor c=7.0259e-17
C104 (\14\:VDD VSS) capacitor c=5.29375e-17
C105 (\9\:net573 VSS) capacitor c=5.55826e-17
C106 (\16\:VDD VSS) capacitor c=7.96636e-17
C107 (\3\:n11 VSS) capacitor c=8.48924e-17
C108 (\4\:QN VSS) capacitor c=5.93204e-17
C109 (\14\:n35 VSS) capacitor c=5.21976e-17
C110 (\15\:n35g VSS) capacitor c=5.5909e-17
C111 (\6\:RTb VSS) capacitor c=7.26849e-17
C112 (\1\:ExtVDD VSS) capacitor c=2.7779e-16
C113 (\9\:n35 VSS) capacitor c=6.20489e-17
C114 (\17\:qbint VSS) capacitor c=6.81911e-17
C115 (\6\:n35g VSS) capacitor c=9.39178e-17
C116 (\8\:SEb VSS) capacitor c=5.06012e-17
C117 (\4\:n35 VSS) capacitor c=6.29062e-17
C118 (\18\:VDD VSS) capacitor c=6.07875e-17
C119 (\5\:mout VSS) capacitor c=8.78996e-17
C120 (\3\:Db VSS) capacitor c=1.8619e-16
C121 (\20\:VDD VSS) capacitor c=5.06609e-17
C122 (\19\:mout VSS) capacitor c=3.95707e-17
C123 (\25\:VDD VSS) capacitor c=3.53683e-17
C124 (\16\:mout VSS) capacitor c=4.36372e-17
C125 (\20\:CKNb VSS) capacitor c=2.92262e-17
C126 (\23\:VDD VSS) capacitor c=4.83128e-17
C127 (\12\:CKNbb VSS) capacitor c=5.98405e-17
C128 (\13\:n20 VSS) capacitor c=6.09786e-17
C129 (\5\:Db VSS) capacitor c=2.2971e-16
C130 (\10\:n20 VSS) capacitor c=6.34251e-17
C131 (\1\:Q VSS) capacitor c=5.32881e-17
C132 (\5\:net573 VSS) capacitor c=4.31413e-17
C133 (\1\:QN VSS) capacitor c=3.78417e-17
C134 (\17\:n35 VSS) capacitor c=3.9291e-17
C135 (\11\:n35g VSS) capacitor c=2.96827e-17
C136 (\10\:RTb VSS) capacitor c=5.81982e-17
C137 (\12\:n35 VSS) capacitor c=6.35981e-17
C138 (\19\:qbint VSS) capacitor c=2.43447e-17
C139 (\9\:n35g VSS) capacitor c=8.04088e-17
C140 (\4\:SEb VSS) capacitor c=3.83048e-17
C141 (\7\:n35 VSS) capacitor c=4.09459e-17
C142 (\11\:mout VSS) capacitor c=2.19228e-17
C143 (\13\:mout VSS) capacitor c=1.77684e-17
C144 (\16\:CKNb VSS) capacitor c=6.41451e-17
C145 (\15\:CKNbb VSS) capacitor c=5.94392e-17
C146 (\17\:n20 VSS) capacitor c=8.69142e-17
C147 (\7\:Db VSS) capacitor c=1.10549e-16
C148 (\8\:n20 VSS) capacitor c=5.96395e-17
C149 (VDD VSS) capacitor c=4.4744e-17
C150 (\2\:CKN VSS) capacitor c=3.30964e-17
C151 (\2\:D VSS) capacitor c=3.55501e-17
C152 (\2\:SE VSS) capacitor c=2.51114e-17
C153 (\4\:CKNbb VSS) capacitor c=1.50528e-16
C154 (\5\:CKNbb VSS) capacitor c=8.61647e-17
C155 (\2\:n35g VSS) capacitor c=2.9092e-17
C156 (\4\:RT VSS) capacitor c=4.60748e-17
C157 (\2\:qbint VSS) capacitor c=4.11016e-17
C158 (\7\:CKNb VSS) capacitor c=1.2768e-16
C159 (\8\:CKNb VSS) capacitor c=7.193e-17
C160 (\4\:SN VSS) capacitor c=2.48256e-16
C161 (\2\:net573 VSS) capacitor c=1.5367e-17
C162 (\12\:n20 VSS) capacitor c=4.64116e-17
C163 (\14\:CKNb VSS) capacitor c=9.90312e-17
C164 (\15\:CKNb VSS) capacitor c=9.72819e-17
C165 (\15\:n20 VSS) capacitor c=5.22164e-17
C166 (\16\:n20 VSS) capacitor c=9.21181e-17
C167 (\8\:qbint VSS) capacitor c=4.4941e-17
C168 (\9\:qbint VSS) capacitor c=6.5228e-17
C169 (\11\:CKNbb VSS) capacitor c=5.37096e-17
C170 (\14\:CKNbb VSS) capacitor c=7.92324e-17
C171 (\5\:CKN VSS) capacitor c=3.94114e-18
C172 (\6\:CKN VSS) capacitor c=3.37944e-17
C173 (\18\:CKNb VSS) capacitor c=6.62094e-17
C174 (\19\:CKNb VSS) capacitor c=3.5191e-17
C175 (\10\:SN VSS) capacitor c=4.03234e-17
C176 (\11\:SN VSS) capacitor c=4.60269e-17
C177 (\7\:D VSS) capacitor c=4.73861e-17
C178 (\19\:n20 VSS) capacitor c=6.57619e-17
C179 (\20\:n20 VSS) capacitor c=7.69525e-17
C180 (\7\:mout VSS) capacitor c=8.21686e-17
C181 (\8\:mout VSS) capacitor c=4.27767e-17
C182 (\9\:mout VSS) capacitor c=1.00916e-16
C183 (\10\:mout VSS) capacitor c=8.60033e-17
C184 (\15\:mout VSS) capacitor c=6.24879e-17
C185 (\18\:mout VSS) capacitor c=7.41618e-17
C186 (\5\:SI VSS) capacitor c=3.48426e-17
C187 (\7\:SE VSS) capacitor c=5.25549e-17
C188 (\6\:SEb VSS) capacitor c=8.18258e-17
C189 (\7\:SEb VSS) capacitor c=6.73963e-17
C190 (\6\:n35 VSS) capacitor c=7.82109e-17
C191 (\17\:CKNbb VSS) capacitor c=3.91478e-17
C192 (\18\:CKNbb VSS) capacitor c=4.23519e-17
C193 (\8\:n35g VSS) capacitor c=3.45284e-17
C194 (\11\:n35 VSS) capacitor c=7.50221e-17
C195 (\15\:qbint VSS) capacitor c=8.78471e-17
C196 (\16\:qbint VSS) capacitor c=1.11964e-16
C197 (\13\:n35g VSS) capacitor c=1.02811e-16
C198 (\14\:n35g VSS) capacitor c=1.1611e-16
C199 (\5\:RTb VSS) capacitor c=4.94791e-17
C200 (\8\:RTb VSS) capacitor c=9.93242e-17
C201 (\9\:RTb VSS) capacitor c=9.14752e-17
C202 (\9\:RT VSS) capacitor c=1.09863e-16
C203 (\10\:RT VSS) capacitor c=1.1814e-16
C204 (\11\:RT VSS) capacitor c=4.00867e-17
C205 (\12\:SN VSS) capacitor c=8.30194e-17
C206 (\13\:SN VSS) capacitor c=7.94276e-17
C207 (\22\:CKNb VSS) capacitor c=1.29586e-16
C208 (\23\:CKNb VSS) capacitor c=1.34343e-16
C209 (\21\:qbint VSS) capacitor c=2.41935e-17
C210 (\22\:qbint VSS) capacitor c=3.00163e-17
C211 (\3\:QN VSS) capacitor c=3.62446e-17
C212 (\16\:n35 VSS) capacitor c=4.52226e-17
C213 (\7\:net573 VSS) capacitor c=5.22192e-17
C214 (\8\:net573 VSS) capacitor c=3.64969e-17
C215 (\3\:VDD VSS) capacitor c=2.73956e-17
C216 (\4\:VDD VSS) capacitor c=2.44925e-17
C217 (\6\:VDD VSS) capacitor c=9.10299e-18
C218 (\7\:VDD VSS) capacitor c=2.14363e-16
C219 (\8\:VDD VSS) capacitor c=2.06872e-16
C220 (\9\:VDD VSS) capacitor c=2.63757e-17
C221 (\11\:VDD VSS) capacitor c=4.54166e-17
C222 (\22\:VDD VSS) capacitor c=4.95461e-17
Rk82 (\2\:Q Q) resistor r=0.1765 c=0
Rk83 (Q \4\:Q) resistor r=0.303 c=0
Rk19 (\5\:D D) resistor r=0.007217 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01719 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007217 c=0
Rk74 (\3\:QN QN) resistor r=0.0152 c=0
Rk73 (\2\:QN \3\:QN) resistor r=0.2924 c=0
Rk75 (\3\:QN \5\:QN) resistor r=0.3233 c=0
Rk84 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk90 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk91 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk92 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk94 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk93 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk95 (VSS \14\:VSS) resistor r=0.313 c=0
Rk96 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk97 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk98 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk99 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk100 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk118 (\26\:VSS \27\:VSS) resistor r=0.1813 c=0
Rk119 (\27\:VSS \28\:VSS) resistor r=0.3652 c=0
Rk120 (\28\:VSS \29\:VSS) resistor r=0.3681 c=0
Rk122 (\30\:VSS VSS) resistor r=0.04947 c=0
Rk121 (\29\:VSS \30\:VSS) resistor r=0.3279 c=0
Rk124 (\31\:VSS VSS) resistor r=0.1216 c=0
Rk123 (VSS \31\:VSS) resistor r=0.8951 c=0
Rk125 (VSS \33\:VSS) resistor r=0.3043 c=0
Rk126 (\27\:VSS \35\:VSS) resistor r=0.2357 c=0
Rk127 (\29\:VSS \37\:VSS) resistor r=0.2445 c=0
Rk128 (\33\:VSS \38\:VSS) resistor r=0.1028 c=0
Rk36 (SI \4\:SI) resistor r=0.01024 c=0
Rk40 (\5\:SI SI) resistor r=0.01024 c=0
Rk37 (\4\:SI \5\:SI) resistor r=0.001853 c=0
Rk67 (RT \9\:RT) resistor r=0.1845 c=0
Rk68 (\9\:RT \10\:RT) resistor r=0.6488 c=0
Rk69 (RT \11\:RT) resistor r=0.01482 c=0
Rk10 (CKN \5\:CKN) resistor r=0.001998 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.01106 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.004543 c=0
Rk54 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk52 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk55 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk56 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk17 (SN \10\:SN) resistor r=0.01189 c=0
Rk18 (\10\:SN \11\:SN) resistor r=0.3257 c=0
Rk70 (\12\:SN \13\:SN) resistor r=0.538 c=0
Rk117 (VDD VDD) resistor r=0.2362 c=0
Rk101 (\2\:VDD \3\:VDD) resistor r=0.3819 c=0
Rk102 (\3\:VDD \4\:VDD) resistor r=0.1963 c=0
Rk103 (\4\:VDD \6\:VDD) resistor r=0.06692 c=0
Rk104 (\6\:VDD \7\:VDD) resistor r=0.05201 c=0
Rk105 (\7\:VDD \8\:VDD) resistor r=1.5259 c=0
Rk106 (\8\:VDD \9\:VDD) resistor r=0.1711 c=0
Rk107 (\9\:VDD \11\:VDD) resistor r=0.1695 c=0
Rk108 (\3\:VDD \13\:VDD) resistor r=0.32 c=0
Rk109 (\4\:VDD \15\:VDD) resistor r=0.3026 c=0
Rk110 (\7\:VDD \17\:VDD) resistor r=0.3757 c=0
Rk111 (\8\:VDD \19\:VDD) resistor r=0.3677 c=0
Rk112 (\9\:VDD \21\:VDD) resistor r=0.2078 c=0
Rk116 (\22\:VDD VDD) resistor r=0.1959 c=0
Rk113 (\11\:VDD \22\:VDD) resistor r=0.1713 c=0
Rk114 (\22\:VDD \24\:VDD) resistor r=0.2078 c=0
Rk115 (\11\:VDD \26\:VDD) resistor r=0.2359 c=0
Rk41 (SE \7\:SE) resistor r=0.04328 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3416 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2303 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4984 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4375 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7542 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3503 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.1789 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1643 c=0
Rk71 (\22\:CKNb \23\:CKNb) resistor r=0.8279 c=0
Rk26 (\6\:mout \7\:mout) resistor r=0.6045 c=0
Rk27 (\7\:mout \8\:mout) resistor r=0.3058 c=0
Rk28 (\8\:mout \9\:mout) resistor r=0.1684 c=0
Rk29 (\9\:mout \10\:mout) resistor r=0.3469 c=0
Rk30 (\7\:mout \12\:mout) resistor r=0.1284 c=0
Rk31 (\8\:mout \14\:mout) resistor r=0.09239 c=0
Rk32 (\9\:mout \15\:mout) resistor r=0.5264 c=0
Rk33 (\15\:mout \17\:mout) resistor r=0.0449 c=0
Rk34 (\10\:mout \18\:mout) resistor r=0.4268 c=0
Rk35 (\15\:mout \20\:mout) resistor r=0.03469 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.1426 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4248 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.2372 c=0
Rk47 (\17\:CKNbb \18\:CKNbb) resistor r=0.3729 c=0
Rk42 (\5\:SEb \6\:SEb) resistor r=0.2178 c=0
Rk43 (\6\:SEb \7\:SEb) resistor r=0.3482 c=0
Rk44 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk48 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk49 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk60 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk61 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk62 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk57 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk58 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk59 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk72 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk63 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk64 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk65 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk66 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk78 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk79 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk80 (\7\:net573 \10\:net573) resistor r=0.2925 c=0
Rk45 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk46 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk50 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk51 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk76 (\15\:n35 \16\:n35) resistor r=0.305 c=0
Rk77 (\16\:n35 \18\:n35) resistor r=0.2683 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.3611 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.6375 c=0
Rk81 (\2\:n11 \4\:n11) resistor r=0.6555 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl22 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl21 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl52 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl39 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl42 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl41 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl40 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl63 (\7\:SN \8\:SN) resistor r=367.487 c=0
Rl64 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl12 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl55 (\4\:SN \6\:SN) resistor r=115.884 c=0
Rl53 (\3\:SN \4\:SN) resistor r=1092.88 c=0
Rl54 (\4\:SN \5\:SN) resistor r=66.1252 c=0
Rl25 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl27 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl24 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl26 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl23 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl58 (\12\:CKNb \13\:CKNb) resistor r=166.412 c=0
Rl3 (CKNb \2\:CKNb) resistor r=135.348 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=49.7951 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl47 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl50 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl51 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl49 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl48 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl59 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl31 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl28 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl32 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl30 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl29 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl19 (SEb \2\:SEb) resistor r=101.718 c=0
Rl20 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl35 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl33 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl34 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl65 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl72 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl70 (\11\:qbint \12\:qbint) resistor r=343.448 c=0
Rl46 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl43 (qbint \2\:qbint) resistor r=112.732 c=0
Rl45 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl44 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl66 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl69 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl71 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl68 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl67 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl37 (RTb \2\:RTb) resistor r=112.412 c=0
Rl38 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl60 (net573 \2\:net573) resistor r=3.1216 c=0
Rl61 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl62 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl56 (n35 \2\:n35) resistor r=508.667 c=0
Rl57 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz33 (\32\:VSS \38\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry25 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=15.5 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry37 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry9 (\19\:mout \20\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx12 (\3\:D \6\:D) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\5\:SN \10\:SN) resistor r=45 c=0
Rx11 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\1\:SE \7\:SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx34 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx35 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \18\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx21 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx22 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx39 (net573 \8\:net573) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.307e-14 ad=8.7e-15 ps=1.16e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0118 \6\:SN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn52 (net0119 \12\:qbint net0117 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0117 \8\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (n11 \11\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n11 \7\:SN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:02:10 2012 )
// Library name: gsclib045
// Cell name: SRDFFNX1
// View name: extracted

simulator lang=spectre

subckt SRDFFNX1 CKN D ExtVDD Q QN RT SE SI VDD VSS
mp25 (\9\:n20 \3\:CKNb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (QN VSS) capacitor c=3.25897e-17
C2 (SI VSS) capacitor c=5.17102e-17
C3 (RT VSS) capacitor c=2.14731e-17
C4 (ExtVDD VSS) capacitor c=2.18855e-16
C5 (VDD VSS) capacitor c=6.95097e-16
C6 (SE VSS) capacitor c=3.96872e-17
C7 (CKN VSS) capacitor c=4.40464e-17
C8 (Q VSS) capacitor c=6.2483e-17
C9 (D VSS) capacitor c=3.84273e-17
C10 (n20 VSS) capacitor c=3.87782e-17
C11 (CKNb VSS) capacitor c=4.69e-17
C12 (mout VSS) capacitor c=5.3657e-17
C13 (CKNbb VSS) capacitor c=3.23206e-17
C14 (SEb VSS) capacitor c=7.7527e-17
C15 (n35g VSS) capacitor c=1.77753e-17
C16 (qbint VSS) capacitor c=4.54323e-17
C17 (RTb VSS) capacitor c=5.18061e-17
C18 (net573 VSS) capacitor c=2.25505e-17
C19 (n35 VSS) capacitor c=1.45617e-16
C20 (Db VSS) capacitor c=1.05348e-16
C21 (net0107 VSS) capacitor c=6.33869e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:qbint VSS) capacitor c=3.41196e-17
C24 (\11\:qbint VSS) capacitor c=8.24646e-17
C25 (\13\:qbint VSS) capacitor c=4.42321e-17
C26 (\3\:net573 VSS) capacitor c=5.8728e-17
C27 (\12\:CKNb VSS) capacitor c=4.91023e-17
C28 (\4\:RTb VSS) capacitor c=9.88373e-17
C29 (\6\:RT VSS) capacitor c=2.23385e-17
C30 (\4\:qbint VSS) capacitor c=5.36612e-17
C31 (\3\:n35g VSS) capacitor c=5.24051e-17
C32 (\5\:RT VSS) capacitor c=5.86041e-17
C33 (\3\:SE VSS) capacitor c=7.73518e-17
C34 (\7\:CKNbb VSS) capacitor c=2.48722e-17
C35 (\3\:SI VSS) capacitor c=9.47876e-17
C36 (\4\:SE VSS) capacitor c=1.22444e-16
C37 (\4\:D VSS) capacitor c=6.88417e-17
C38 (\3\:n20 VSS) capacitor c=4.48935e-17
C39 (\4\:CKN VSS) capacitor c=5.63594e-17
C40 (\4\:CKNb VSS) capacitor c=4.40132e-17
C41 (\8\:CKNbb VSS) capacitor c=8.18976e-17
C42 (\3\:CKNb VSS) capacitor c=1.11548e-16
C43 (\6\:qbint VSS) capacitor c=3.77521e-17
C44 (\14\:qbint VSS) capacitor c=4.59617e-17
C45 (\12\:qbint VSS) capacitor c=8.5727e-17
C46 (\4\:net573 VSS) capacitor c=3.68336e-17
C47 (\9\:CKNbb VSS) capacitor c=2.33512e-16
C48 (\8\:RT VSS) capacitor c=1.2267e-16
C49 (\2\:RT VSS) capacitor c=6.22925e-17
C50 (\5\:qbint VSS) capacitor c=3.89021e-17
C51 (\5\:n35g VSS) capacitor c=3.28666e-17
C52 (\2\:RTb VSS) capacitor c=4.65527e-17
C53 (\5\:SE VSS) capacitor c=5.78737e-17
C54 (\6\:CKNb VSS) capacitor c=2.45241e-17
C55 (\1\:SI VSS) capacitor c=4.91308e-17
C56 (\6\:SE VSS) capacitor c=8.62134e-17
C57 (\3\:SEb VSS) capacitor c=6.60184e-17
C58 (\1\:D VSS) capacitor c=4.95201e-17
C59 (\6\:n20 VSS) capacitor c=6.51408e-17
C60 (\1\:CKN VSS) capacitor c=2.85194e-17
C61 (\3\:mout VSS) capacitor c=5.00546e-17
C62 (\11\:CKNb VSS) capacitor c=4.86151e-17
C63 (\10\:qbint VSS) capacitor c=8.38458e-17
C64 (\13\:CKNb VSS) capacitor c=3.90987e-17
C65 (\7\:RT VSS) capacitor c=1.43994e-16
C66 (\10\:CKNb VSS) capacitor c=1.55951e-16
C67 (\3\:RT VSS) capacitor c=3.31029e-17
C68 (\1\:RT VSS) capacitor c=5.2467e-17
C69 (\3\:RTb VSS) capacitor c=7.59476e-17
C70 (\3\:qbint VSS) capacitor c=4.43507e-17
C71 (\2\:n35 VSS) capacitor c=1.89205e-16
C72 (\4\:n35g VSS) capacitor c=6.64118e-17
C73 (\3\:CKNbb VSS) capacitor c=4.82614e-17
C74 (\10\:CKNbb VSS) capacitor c=2.21201e-16
C75 (\3\:n35 VSS) capacitor c=7.66801e-17
C76 (\1\:SE VSS) capacitor c=2.48251e-17
C77 (\2\:SI VSS) capacitor c=7.76315e-17
C78 (\2\:SEb VSS) capacitor c=7.74399e-17
C79 (\3\:D VSS) capacitor c=1.47339e-17
C80 (\3\:CKN VSS) capacitor c=2.39858e-17
C81 (\2\:mout VSS) capacitor c=3.80639e-17
C82 (\4\:mout VSS) capacitor c=3.80927e-17
C83 (\2\:CKNb VSS) capacitor c=7.90457e-17
C84 (\6\:CKNbb VSS) capacitor c=3.65314e-17
C85 (\5\:n20 VSS) capacitor c=3.72724e-17
C86 (\2\:CKNbb VSS) capacitor c=5.81271e-17
C87 (\5\:CKNb VSS) capacitor c=7.20093e-17
C88 (\9\:CKNb VSS) capacitor c=2.45672e-17
C89 (\2\:n20 VSS) capacitor c=3.96406e-17
C90 (\1\:VDD VSS) capacitor c=4.94752e-17
C91 (\3\:Q VSS) capacitor c=7.28849e-17
C92 (\10\:VDD VSS) capacitor c=5.38945e-17
C93 (\9\:net573 VSS) capacitor c=5.56984e-17
C94 (\12\:VDD VSS) capacitor c=7.99107e-17
C95 (\3\:net0107 VSS) capacitor c=8.53421e-17
C96 (\3\:QN VSS) capacitor c=8.02102e-17
C97 (\14\:n35 VSS) capacitor c=5.08213e-17
C98 (\15\:n35g VSS) capacitor c=5.5988e-17
C99 (\6\:RTb VSS) capacitor c=7.29535e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.78288e-16
C101 (\9\:n35 VSS) capacitor c=6.22363e-17
C102 (\17\:qbint VSS) capacitor c=6.84723e-17
C103 (\6\:n35g VSS) capacitor c=9.31898e-17
C104 (\8\:SEb VSS) capacitor c=5.08032e-17
C105 (\4\:n35 VSS) capacitor c=6.41853e-17
C106 (\14\:VDD VSS) capacitor c=6.08814e-17
C107 (\5\:mout VSS) capacitor c=6.55783e-17
C108 (\3\:Db VSS) capacitor c=1.8386e-16
C109 (\19\:VDD VSS) capacitor c=3.54629e-17
C110 (\14\:mout VSS) capacitor c=4.55773e-17
C111 (\20\:CKNb VSS) capacitor c=2.92857e-17
C112 (\17\:VDD VSS) capacitor c=4.83231e-17
C113 (\12\:CKNbb VSS) capacitor c=5.95986e-17
C114 (\12\:n20 VSS) capacitor c=6.80226e-17
C115 (\5\:Db VSS) capacitor c=2.29718e-16
C116 (\9\:n20 VSS) capacitor c=6.35172e-17
C117 (\1\:Q VSS) capacitor c=5.36599e-17
C118 (\5\:net573 VSS) capacitor c=4.32247e-17
C119 (\1\:QN VSS) capacitor c=4.97053e-17
C120 (\17\:n35 VSS) capacitor c=3.68796e-17
C121 (\11\:n35g VSS) capacitor c=2.97301e-17
C122 (\10\:RTb VSS) capacitor c=5.83059e-17
C123 (\12\:n35 VSS) capacitor c=6.37635e-17
C124 (\19\:qbint VSS) capacitor c=2.43869e-17
C125 (\9\:n35g VSS) capacitor c=8.1299e-17
C126 (\4\:SEb VSS) capacitor c=3.83661e-17
C127 (\7\:n35 VSS) capacitor c=4.17234e-17
C128 (\10\:mout VSS) capacitor c=2.32392e-17
C129 (\12\:mout VSS) capacitor c=2.62247e-17
C130 (\16\:CKNb VSS) capacitor c=6.14357e-17
C131 (\15\:CKNbb VSS) capacitor c=5.95408e-17
C132 (\16\:n20 VSS) capacitor c=8.21191e-17
C133 (\7\:Db VSS) capacitor c=1.10759e-16
C134 (\7\:n20 VSS) capacitor c=5.97236e-17
C135 (VDD VSS) capacitor c=4.47907e-17
C136 (\2\:CKN VSS) capacitor c=3.35648e-17
C137 (\4\:n20 VSS) capacitor c=5.44302e-17
C138 (\2\:D VSS) capacitor c=3.55113e-17
C139 (\2\:SE VSS) capacitor c=2.51114e-17
C140 (\4\:CKNbb VSS) capacitor c=1.56164e-16
C141 (\5\:CKNbb VSS) capacitor c=8.80784e-17
C142 (\2\:n35g VSS) capacitor c=2.90596e-17
C143 (\4\:RT VSS) capacitor c=3.78115e-17
C144 (\2\:qbint VSS) capacitor c=4.11644e-17
C145 (\7\:CKNb VSS) capacitor c=1.29623e-16
C146 (\8\:CKNb VSS) capacitor c=7.25941e-17
C147 (\2\:net573 VSS) capacitor c=1.56394e-17
C148 (\11\:n20 VSS) capacitor c=4.64596e-17
C149 (\14\:CKNb VSS) capacitor c=9.84346e-17
C150 (\15\:CKNb VSS) capacitor c=9.76079e-17
C151 (\8\:qbint VSS) capacitor c=4.58679e-17
C152 (\9\:qbint VSS) capacitor c=6.58366e-17
C153 (\14\:n20 VSS) capacitor c=5.21092e-17
C154 (\15\:n20 VSS) capacitor c=8.8179e-17
C155 (\11\:CKNbb VSS) capacitor c=5.38163e-17
C156 (\14\:CKNbb VSS) capacitor c=7.98266e-17
C157 (\5\:CKN VSS) capacitor c=4.05153e-18
C158 (\6\:CKN VSS) capacitor c=2.99345e-17
C159 (\18\:CKNb VSS) capacitor c=6.43535e-17
C160 (\19\:CKNb VSS) capacitor c=3.81347e-17
C161 (\7\:D VSS) capacitor c=4.86018e-17
C162 (\7\:mout VSS) capacitor c=8.2704e-17
C163 (\8\:mout VSS) capacitor c=5.7118e-17
C164 (\9\:mout VSS) capacitor c=5.30418e-17
C165 (\16\:mout VSS) capacitor c=4.50927e-17
C166 (\5\:SI VSS) capacitor c=3.4559e-17
C167 (\7\:SE VSS) capacitor c=5.26482e-17
C168 (\6\:SEb VSS) capacitor c=8.19603e-17
C169 (\7\:SEb VSS) capacitor c=6.6855e-17
C170 (\6\:n35 VSS) capacitor c=7.67648e-17
C171 (\17\:CKNbb VSS) capacitor c=3.8227e-17
C172 (\18\:CKNbb VSS) capacitor c=4.1869e-17
C173 (\8\:n35g VSS) capacitor c=3.40218e-17
C174 (\11\:n35 VSS) capacitor c=7.40109e-17
C175 (\15\:qbint VSS) capacitor c=8.80005e-17
C176 (\16\:qbint VSS) capacitor c=1.12149e-16
C177 (\13\:n35g VSS) capacitor c=1.02575e-16
C178 (\14\:n35g VSS) capacitor c=1.16309e-16
C179 (\5\:RTb VSS) capacitor c=4.9331e-17
C180 (\8\:RTb VSS) capacitor c=1.01992e-16
C181 (\9\:RTb VSS) capacitor c=9.17318e-17
C182 (\9\:RT VSS) capacitor c=1.04101e-16
C183 (\10\:RT VSS) capacitor c=1.18785e-16
C184 (\11\:RT VSS) capacitor c=4.0205e-17
C185 (\22\:CKNb VSS) capacitor c=9.31035e-17
C186 (\23\:CKNb VSS) capacitor c=1.00507e-16
C187 (\21\:qbint VSS) capacitor c=2.4264e-17
C188 (\22\:qbint VSS) capacitor c=3.00557e-17
C189 (\16\:n35 VSS) capacitor c=3.71648e-17
C190 (\7\:net573 VSS) capacitor c=5.05996e-17
C191 (\8\:net573 VSS) capacitor c=3.48572e-17
C192 (\3\:VDD VSS) capacitor c=4.29107e-17
C193 (\5\:VDD VSS) capacitor c=9.3079e-18
C194 (\6\:VDD VSS) capacitor c=2.14745e-16
C195 (\7\:VDD VSS) capacitor c=2.13145e-16
C196 (\9\:VDD VSS) capacitor c=3.65725e-17
C197 (\16\:VDD VSS) capacitor c=4.7621e-17
Rk66 (\2\:QN QN) resistor r=0.1752 c=0
Rk67 (QN \4\:QN) resistor r=0.2568 c=0
Rk30 (SI \4\:SI) resistor r=0.01682 c=0
Rk34 (\5\:SI SI) resistor r=0.01682 c=0
Rk31 (\5\:SI \4\:SI) resistor r=0.001885 c=0
Rk61 (RT \9\:RT) resistor r=0.1838 c=0
Rk62 (\9\:RT \10\:RT) resistor r=0.6407 c=0
Rk63 (RT \11\:RT) resistor r=0.01479 c=0
Rk48 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk46 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk49 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk50 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk105 (VDD VDD) resistor r=0.2356 c=0
Rk93 (\2\:VDD \3\:VDD) resistor r=0.5761 c=0
Rk94 (\3\:VDD \5\:VDD) resistor r=0.06676 c=0
Rk95 (\5\:VDD \6\:VDD) resistor r=0.05188 c=0
Rk96 (\6\:VDD \7\:VDD) resistor r=1.5221 c=0
Rk97 (\7\:VDD \9\:VDD) resistor r=0.3401 c=0
Rk98 (\3\:VDD \11\:VDD) resistor r=0.3013 c=0
Rk99 (\6\:VDD \13\:VDD) resistor r=0.3741 c=0
Rk100 (\7\:VDD \15\:VDD) resistor r=0.3661 c=0
Rk104 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk101 (\9\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk102 (\16\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk103 (\9\:VDD \20\:VDD) resistor r=0.2349 c=0
Rk35 (SE \7\:SE) resistor r=0.0432 c=0
Rk10 (CKN \5\:CKN) resistor r=0.002322 c=0
Rk13 (\5\:CKN \6\:CKN) resistor r=0.009981 c=0
Rk12 (\6\:CKN \7\:CKN) resistor r=0.007911 c=0
Rk74 (\2\:Q Q) resistor r=0.1744 c=0
Rk75 (Q \4\:Q) resistor r=0.3044 c=0
Rk17 (\5\:D D) resistor r=0.007628 c=0
Rk19 (\5\:D \7\:D) resistor r=0.01716 c=0
Rk18 (\6\:D \7\:D) resistor r=0.007628 c=0
Rk76 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk77 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk78 (\5\:VSS \6\:VSS) resistor r=0.05932 c=0
Rk79 (\6\:VSS \7\:VSS) resistor r=0.6123 c=0
Rk80 (\7\:VSS \8\:VSS) resistor r=0.03204 c=0
Rk82 (\9\:VSS VSS) resistor r=0.1211 c=0
Rk81 (\8\:VSS \9\:VSS) resistor r=0.1759 c=0
Rk83 (VSS \10\:VSS) resistor r=0.5208 c=0
Rk84 (\10\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk86 (\12\:VSS VSS) resistor r=0.1213 c=0
Rk85 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk87 (VSS \14\:VSS) resistor r=0.3119 c=0
Rk88 (\5\:VSS \16\:VSS) resistor r=0.2667 c=0
Rk89 (\7\:VSS \18\:VSS) resistor r=0.1891 c=0
Rk90 (\9\:VSS \20\:VSS) resistor r=0.1942 c=0
Rk91 (\10\:VSS \22\:VSS) resistor r=0.2532 c=0
Rk92 (\11\:VSS \24\:VSS) resistor r=0.2488 c=0
Rk106 (\26\:VSS \28\:VSS) resistor r=0.3487 c=0
Rk107 (\28\:VSS \29\:VSS) resistor r=0.5654 c=0
Rk109 (\30\:VSS VSS) resistor r=0.04935 c=0
Rk108 (\29\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk111 (\31\:VSS VSS) resistor r=0.1213 c=0
Rk110 (VSS \31\:VSS) resistor r=0.8929 c=0
Rk112 (VSS \33\:VSS) resistor r=0.2968 c=0
Rk113 (\29\:VSS \35\:VSS) resistor r=0.2434 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2662 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4595 c=0
Rk3 (\14\:CKNb \15\:CKNb) resistor r=0.7511 c=0
Rk14 (\17\:CKNb \18\:CKNb) resistor r=0.3507 c=0
Rk15 (\18\:CKNb \19\:CKNb) resistor r=0.1799 c=0
Rk16 (\18\:CKNb \21\:CKNb) resistor r=0.1637 c=0
Rk64 (\22\:CKNb \23\:CKNb) resistor r=0.7115 c=0
Rk23 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk24 (\7\:mout \8\:mout) resistor r=0.5259 c=0
Rk25 (\8\:mout \9\:mout) resistor r=0.1904 c=0
Rk26 (\7\:mout \11\:mout) resistor r=0.1278 c=0
Rk27 (\8\:mout \13\:mout) resistor r=0.1169 c=0
Rk28 (\8\:mout \15\:mout) resistor r=0.5475 c=0
Rk29 (\9\:mout \16\:mout) resistor r=0.3936 c=0
Rk7 (\11\:CKNbb \13\:CKNbb) resistor r=0.142 c=0
Rk8 (\13\:CKNbb \14\:CKNbb) resistor r=0.4226 c=0
Rk9 (\14\:CKNbb \16\:CKNbb) resistor r=0.2362 c=0
Rk41 (\17\:CKNbb \18\:CKNbb) resistor r=0.3714 c=0
Rk36 (\5\:SEb \6\:SEb) resistor r=0.2169 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.3459 c=0
Rk38 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk42 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk43 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk54 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk55 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk56 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk51 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk52 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk53 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk65 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk57 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk58 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk59 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk60 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk70 (\6\:net573 \7\:net573) resistor r=0.2363 c=0
Rk71 (\7\:net573 \8\:net573) resistor r=0.1648 c=0
Rk72 (\7\:net573 \10\:net573) resistor r=0.2913 c=0
Rk39 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk40 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk44 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk45 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk68 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk69 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk20 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk21 (\4\:Db \6\:Db) resistor r=1.3554 c=0
Rk22 (\6\:Db \8\:Db) resistor r=0.6342 c=0
Rk73 (\2\:net0107 \4\:net0107) resistor r=0.6451 c=0
Rl21 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl20 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl51 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl38 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl41 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl40 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl39 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl24 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl26 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl23 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl25 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl22 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl11 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl9 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl10 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl17 (\2\:D \4\:D) resistor r=115.099 c=0
Rl15 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl16 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=100.163 c=0
Rl14 (\4\:n20 \6\:n20) resistor r=179.184 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=123.391 c=0
Rl54 (\12\:CKNb \13\:CKNb) resistor r=163.284 c=0
Rl3 (CKNb \2\:CKNb) resistor r=135.348 c=0
Rl5 (\2\:CKNb \4\:CKNb) resistor r=49.7951 c=0
Rl4 (\2\:CKNb \3\:CKNb) resistor r=216.019 c=0
Rl6 (\3\:CKNb \5\:CKNb) resistor r=330.626 c=0
Rl46 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl49 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl50 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl48 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl47 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl55 (\9\:CKNbb \10\:CKNbb) resistor r=870.726 c=0
Rl2 (CKNbb \2\:CKNbb) resistor r=138.16 c=0
Rl30 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl27 (\3\:CKNbb \4\:CKNbb) resistor r=349.798 c=0
Rl31 (\5\:CKNbb \8\:CKNbb) resistor r=128.908 c=0
Rl29 (\5\:CKNbb \6\:CKNbb) resistor r=84.3215 c=0
Rl28 (\4\:CKNbb \5\:CKNbb) resistor r=453.624 c=0
Rl18 (SEb \2\:SEb) resistor r=101.718 c=0
Rl19 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl34 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl32 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl33 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl35 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl59 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl66 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl64 (\11\:qbint \12\:qbint) resistor r=337.984 c=0
Rl45 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl42 (qbint \2\:qbint) resistor r=112.732 c=0
Rl44 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl43 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl60 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl63 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl65 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl62 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl61 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl36 (RTb \2\:RTb) resistor r=112.412 c=0
Rl37 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl56 (net573 \2\:net573) resistor r=3.1216 c=0
Rl57 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl58 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl52 (n35 \2\:n35) resistor r=508.667 c=0
Rl53 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\16\:CKNb \17\:CKNb) resistor r=75 c=0
Rz7 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\12\:mout \13\:mout) resistor r=75 c=0
Rz3 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry19 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry30 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry35 (\27\:VSS \28\:VSS) resistor r=5.6364 c=0
Ry36 (\27\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry37 (\27\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry4 (\20\:CKNb \21\:CKNb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry3 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry21 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry22 (net0107 \2\:net0107) resistor r=62 c=0
Ry23 (\3\:net0107 \4\:net0107) resistor r=62 c=0
Rx13 (\2\:SI \4\:SI) resistor r=45 c=0
Rx25 (\3\:RT \9\:RT) resistor r=45 c=0
Rx26 (\1\:RT \10\:RT) resistor r=45 c=0
Rx27 (\7\:RT \11\:RT) resistor r=45 c=0
Rx14 (\1\:SE \7\:SE) resistor r=45 c=0
Rx8 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx10 (\3\:D \6\:D) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\5\:CKNb \14\:CKNb) resistor r=45 c=0
Rx3 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx9 (\2\:CKNb \19\:CKNb) resistor r=45 c=0
Rx28 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx29 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx11 (\4\:mout \9\:mout) resistor r=45 c=0
Rx12 (\2\:mout \16\:mout) resistor r=45 c=0
Rx6 (\6\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx7 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx17 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx18 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx15 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx19 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx22 (n35g \14\:n35g) resistor r=45 c=0
Rx21 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx30 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx31 (qbint \22\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (RTb \9\:RTb) resistor r=45 c=0
Rx33 (net573 \8\:net573) resistor r=45 c=0
Rx16 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx20 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx32 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db CKNbb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \11\:CKNb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\16\:CKNb \1\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\12\:mout \6\:n20 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn52 (net0119 \12\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \6\:CKNb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \9\:CKNbb net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKNbb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\12\:CKNbb \4\:CKNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\20\:CKNb \4\:CKN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\14\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \12\:CKNb \3\:net0107 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\3\:QN \3\:net573 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (net0107 \11\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFNX1
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:45:09 2012 )
// Library name: gsclib045
// Cell name: SRDFFQX1
// View name: extracted

simulator lang=spectre

subckt SRDFFQX1 CK D ExtVDD Q RT SE SI VDD VSS
mp25 (\9\:n20 \2\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.6017 \
        scb=0.0151572 scc=0.00034109 m=(1)
C1 (SI VSS) capacitor c=8.02396e-17
C2 (VDD VSS) capacitor c=6.76459e-16
C3 (CK VSS) capacitor c=9.91733e-17
C4 (SE VSS) capacitor c=8.82274e-17
C5 (Q VSS) capacitor c=1.84788e-17
C6 (ExtVDD VSS) capacitor c=2.93804e-16
C7 (D VSS) capacitor c=7.9357e-17
C8 (RT VSS) capacitor c=1.16843e-16
C9 (n20 VSS) capacitor c=3.87782e-17
C10 (CKbb VSS) capacitor c=5.97484e-17
C11 (mout VSS) capacitor c=4.78609e-17
C12 (CKb VSS) capacitor c=6.17772e-17
C13 (SEb VSS) capacitor c=7.71096e-17
C14 (n35g VSS) capacitor c=1.62e-17
C15 (qbint VSS) capacitor c=4.82055e-17
C16 (RTb VSS) capacitor c=5.5013e-17
C17 (n35 VSS) capacitor c=3.86741e-17
C18 (Db VSS) capacitor c=1.02134e-16
C19 (net0110 VSS) capacitor c=7.17958e-17
C20 (net0118 VSS) capacitor c=4.58022e-17
C21 (n1 VSS) capacitor c=1.02126e-18
C22 (\7\:qbint VSS) capacitor c=9.57809e-17
C23 (\10\:qbint VSS) capacitor c=2.73315e-17
C24 (\10\:CKbb VSS) capacitor c=4.67726e-17
C25 (\4\:RTb VSS) capacitor c=1.18736e-16
C26 (\6\:RT VSS) capacitor c=4.98893e-17
C27 (\4\:qbint VSS) capacitor c=8.09983e-17
C28 (\3\:n35g VSS) capacitor c=8.9093e-17
C29 (\3\:RT VSS) capacitor c=9.28178e-17
C30 (\3\:SE VSS) capacitor c=7.74648e-17
C31 (\8\:CKb VSS) capacitor c=2.64143e-17
C32 (\3\:SI VSS) capacitor c=9.49157e-17
C33 (\4\:SE VSS) capacitor c=1.23879e-16
C34 (\4\:D VSS) capacitor c=6.94425e-17
C35 (\3\:n20 VSS) capacitor c=2.92652e-17
C36 (\4\:CK VSS) capacitor c=4.46826e-17
C37 (\4\:CKb VSS) capacitor c=5.12907e-17
C38 (\9\:CKb VSS) capacitor c=8.39349e-17
C39 (\2\:CKbb VSS) capacitor c=8.77211e-17
C40 (\6\:qbint VSS) capacitor c=4.93063e-17
C41 (\11\:qbint VSS) capacitor c=3.14309e-17
C42 (\10\:CKb VSS) capacitor c=4.33442e-17
C43 (\4\:RT VSS) capacitor c=1.59286e-16
C44 (\5\:RT VSS) capacitor c=6.57654e-17
C45 (\5\:qbint VSS) capacitor c=3.8933e-17
C46 (\4\:n35g VSS) capacitor c=2.9038e-17
C47 (\5\:SE VSS) capacitor c=5.62621e-17
C48 (\4\:CKbb VSS) capacitor c=2.43667e-17
C49 (\1\:SI VSS) capacitor c=4.92106e-17
C50 (\6\:SE VSS) capacitor c=8.6036e-17
C51 (\3\:SEb VSS) capacitor c=6.60133e-17
C52 (\1\:D VSS) capacitor c=4.95493e-17
C53 (\6\:n20 VSS) capacitor c=5.53225e-17
C54 (\1\:CK VSS) capacitor c=4.11469e-17
C55 (\3\:mout VSS) capacitor c=4.53901e-17
C56 (\6\:CKb VSS) capacitor c=3.87844e-17
C57 (\9\:CKbb VSS) capacitor c=4.84921e-17
C58 (\7\:CKb VSS) capacitor c=4.31115e-17
C59 (\11\:CKb VSS) capacitor c=4.26457e-17
C60 (\3\:n35 VSS) capacitor c=5.51757e-17
C61 (\9\:qbint VSS) capacitor c=4.18903e-17
C62 (\11\:CKbb VSS) capacitor c=4.97976e-17
C63 (\1\:RT VSS) capacitor c=1.47874e-16
C64 (\8\:CKbb VSS) capacitor c=1.29523e-16
C65 (\3\:RTb VSS) capacitor c=9.39291e-17
C66 (\4\:n35 VSS) capacitor c=6.25259e-17
C67 (\3\:qbint VSS) capacitor c=3.54661e-17
C68 (\1\:ExtVDD VSS) capacitor c=7.79524e-17
C69 (\2\:ExtVDD VSS) capacitor c=8.00688e-17
C70 (\2\:RTb VSS) capacitor c=5.40085e-17
C71 (\5\:n35g VSS) capacitor c=1.02348e-16
C72 (\2\:n35 VSS) capacitor c=4.21393e-17
C73 (\1\:SE VSS) capacitor c=2.4851e-17
C74 (\2\:SI VSS) capacitor c=7.70988e-17
C75 (\2\:SEb VSS) capacitor c=7.84071e-17
C76 (\3\:D VSS) capacitor c=1.51008e-17
C77 (\3\:CK VSS) capacitor c=2.45903e-17
C78 (\2\:mout VSS) capacitor c=3.7012e-17
C79 (\4\:mout VSS) capacitor c=2.80507e-17
C80 (\5\:CKb VSS) capacitor c=5.93793e-17
C81 (\5\:n20 VSS) capacitor c=6.31926e-17
C82 (\3\:CKbb VSS) capacitor c=7.30354e-17
C83 (\7\:CKbb VSS) capacitor c=2.4151e-17
C84 (\2\:n20 VSS) capacitor c=3.95417e-17
C85 (\1\:VDD VSS) capacitor c=5.23815e-17
C86 (\10\:VDD VSS) capacitor c=5.35311e-17
C87 (\1\:Q VSS) capacitor c=5.52413e-17
C88 (\3\:net0110 VSS) capacitor c=8.04606e-17
C89 (\17\:n35 VSS) capacitor c=9.71569e-17
C90 (\15\:n35g VSS) capacitor c=4.99082e-17
C91 (\9\:RTb VSS) capacitor c=4.33989e-17
C92 (\11\:ExtVDD VSS) capacitor c=3.62505e-17
C93 (\7\:n35g VSS) capacitor c=7.2814e-17
C94 (\14\:qbint VSS) capacitor c=6.81089e-17
C95 (\5\:n35 VSS) capacitor c=6.17394e-17
C96 (\8\:SEb VSS) capacitor c=5.31048e-17
C97 (\13\:n35 VSS) capacitor c=7.1209e-17
C98 (\12\:VDD VSS) capacitor c=6.40752e-17
C99 (\5\:mout VSS) capacitor c=7.19178e-17
C100 (\3\:Db VSS) capacitor c=1.80331e-16
C101 (\14\:VDD VSS) capacitor c=3.44779e-17
C102 (\19\:VDD VSS) capacitor c=3.46754e-17
C103 (\15\:mout VSS) capacitor c=5.27013e-17
C104 (\16\:CKb VSS) capacitor c=3.80629e-17
C105 (\17\:VDD VSS) capacitor c=4.10231e-17
C106 (\14\:CKbb VSS) capacitor c=6.86921e-17
C107 (\12\:n20 VSS) capacitor c=6.15223e-17
C108 (\5\:Db VSS) capacitor c=1.88767e-16
C109 (\9\:n20 VSS) capacitor c=6.24825e-17
C110 (\3\:Q VSS) capacitor c=4.23505e-17
C111 (\3\:net0118 VSS) capacitor c=4.55076e-17
C112 (\19\:n35 VSS) capacitor c=8.11175e-17
C113 (\11\:n35g VSS) capacitor c=2.64843e-17
C114 (\6\:RTb VSS) capacitor c=1.79399e-16
C115 (\9\:n35g VSS) capacitor c=8.30483e-17
C116 (\16\:qbint VSS) capacitor c=2.41558e-17
C117 (\11\:n35 VSS) capacitor c=2.59031e-17
C118 (\4\:SEb VSS) capacitor c=3.83183e-17
C119 (\9\:n35 VSS) capacitor c=2.70871e-17
C120 (\11\:mout VSS) capacitor c=2.25591e-17
C121 (\13\:mout VSS) capacitor c=2.51065e-17
C122 (\12\:CKb VSS) capacitor c=4.20592e-17
C123 (\17\:CKbb VSS) capacitor c=5.50327e-17
C124 (\16\:n20 VSS) capacitor c=8.66404e-17
C125 (\7\:Db VSS) capacitor c=9.49368e-17
C126 (\7\:n20 VSS) capacitor c=5.99221e-17
C127 (VDD VSS) capacitor c=4.47635e-17
C128 (\2\:CK VSS) capacitor c=3.41805e-17
C129 (\4\:n20 VSS) capacitor c=5.49708e-17
C130 (\2\:D VSS) capacitor c=3.58158e-17
C131 (\2\:SE VSS) capacitor c=2.51996e-17
C132 (\2\:CKb VSS) capacitor c=1.66012e-16
C133 (\3\:CKb VSS) capacitor c=8.51729e-17
C134 (\2\:n35g VSS) capacitor c=2.97373e-17
C135 (\2\:qbint VSS) capacitor c=4.05183e-17
C136 (\5\:CKbb VSS) capacitor c=1.31377e-16
C137 (\6\:CKbb VSS) capacitor c=6.9743e-17
C138 (\2\:RT VSS) capacitor c=7.93135e-17
C139 (\11\:n20 VSS) capacitor c=4.57278e-17
C140 (\12\:CKbb VSS) capacitor c=9.86382e-17
C141 (\13\:CKbb VSS) capacitor c=9.72845e-17
C142 (\8\:qbint VSS) capacitor c=7.46988e-17
C143 (\14\:n20 VSS) capacitor c=5.21541e-17
C144 (\15\:n20 VSS) capacitor c=9.13254e-17
C145 (\16\:CKbb VSS) capacitor c=7.40421e-17
C146 (\14\:CKb VSS) capacitor c=7.18139e-17
C147 (\15\:CKb VSS) capacitor c=5.60429e-17
C148 (\7\:mout VSS) capacitor c=6.38693e-17
C149 (\8\:mout VSS) capacitor c=2.54441e-17
C150 (\9\:mout VSS) capacitor c=5.14759e-17
C151 (\10\:mout VSS) capacitor c=6.2295e-17
C152 (\17\:mout VSS) capacitor c=4.99916e-17
C153 (\6\:SEb VSS) capacitor c=6.94339e-17
C154 (\7\:SEb VSS) capacitor c=7.67359e-17
C155 (\7\:n35 VSS) capacitor c=7.60255e-17
C156 (\8\:n35 VSS) capacitor c=7.96039e-17
C157 (\6\:n35g VSS) capacitor c=4.5234e-17
C158 (\5\:ExtVDD VSS) capacitor c=1.07786e-16
C159 (\13\:ExtVDD VSS) capacitor c=4.77413e-17
C160 (\12\:qbint VSS) capacitor c=9.04925e-17
C161 (\13\:qbint VSS) capacitor c=1.11694e-16
C162 (\13\:n35g VSS) capacitor c=1.17483e-16
C163 (\14\:n35g VSS) capacitor c=1.17772e-16
C164 (\15\:n35 VSS) capacitor c=6.80566e-17
C165 (\16\:n35 VSS) capacitor c=6.92995e-17
C166 (\5\:RTb VSS) capacitor c=8.32049e-17
C167 (\8\:RTb VSS) capacitor c=1.09812e-16
C168 (\19\:CKbb VSS) capacitor c=1.2993e-16
C169 (\20\:CKbb VSS) capacitor c=1.02739e-16
C170 (\18\:qbint VSS) capacitor c=1.71275e-17
C171 (\19\:qbint VSS) capacitor c=3.07483e-17
C172 (\18\:CKb VSS) capacitor c=2.39239e-16
C173 (\19\:CKb VSS) capacitor c=3.03267e-16
C174 (\21\:n35 VSS) capacitor c=3.28637e-17
C175 (\3\:VDD VSS) capacitor c=2.73538e-17
C176 (\5\:VDD VSS) capacitor c=1.70023e-16
C177 (\6\:VDD VSS) capacitor c=1.99417e-16
C178 (\7\:VDD VSS) capacitor c=2.11031e-17
C179 (\9\:VDD VSS) capacitor c=2.88643e-17
C180 (\16\:VDD VSS) capacitor c=4.56121e-17
Rk76 (VDD VDD) resistor r=0.2354 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.3442 c=0
Rk65 (\3\:VDD \5\:VDD) resistor r=0.07413 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=1.5731 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.23 c=0
Rk68 (\7\:VDD \9\:VDD) resistor r=0.1094 c=0
Rk69 (\3\:VDD \11\:VDD) resistor r=0.3561 c=0
Rk70 (\6\:VDD \13\:VDD) resistor r=0.3658 c=0
Rk71 (\7\:VDD \15\:VDD) resistor r=0.2067 c=0
Rk75 (\16\:VDD VDD) resistor r=0.1953 c=0
Rk72 (\9\:VDD \16\:VDD) resistor r=0.1634 c=0
Rk73 (\16\:VDD \18\:VDD) resistor r=0.2107 c=0
Rk74 (\9\:VDD \20\:VDD) resistor r=0.2347 c=0
Rk77 (\2\:VSS \3\:VSS) resistor r=0.06175 c=0
Rk78 (\3\:VSS \4\:VSS) resistor r=0.1856 c=0
Rk79 (\4\:VSS \5\:VSS) resistor r=0.7309 c=0
Rk81 (\6\:VSS VSS) resistor r=0.3318 c=0
Rk80 (\5\:VSS \6\:VSS) resistor r=0.06175 c=0
Rk82 (VSS \7\:VSS) resistor r=0.8152 c=0
Rk84 (\8\:VSS VSS) resistor r=0.1187 c=0
Rk83 (\7\:VSS \8\:VSS) resistor r=0.04193 c=0
Rk85 (VSS \10\:VSS) resistor r=0.2917 c=0
Rk86 (\3\:VSS \12\:VSS) resistor r=0.2396 c=0
Rk87 (\5\:VSS \14\:VSS) resistor r=0.1658 c=0
Rk88 (\7\:VSS \16\:VSS) resistor r=0.2396 c=0
Rk89 (\18\:VSS \20\:VSS) resistor r=0.3056 c=0
Rk90 (\20\:VSS \21\:VSS) resistor r=0.808 c=0
Rk91 (\21\:VSS \23\:VSS) resistor r=0.189 c=0
Rk92 (\21\:VSS \24\:VSS) resistor r=0.03449 c=0
Rk95 (\25\:VSS VSS) resistor r=0.1581 c=0
Rk93 (\24\:VSS \25\:VSS) resistor r=0.1732 c=0
Rk94 (\25\:VSS \27\:VSS) resistor r=0.194 c=0
Rk96 (VSS \28\:VSS) resistor r=0.4832 c=0
Rk97 (\28\:VSS \30\:VSS) resistor r=0.2385 c=0
Rk98 (\28\:VSS \31\:VSS) resistor r=0.3068 c=0
Rk99 (\31\:VSS \33\:VSS) resistor r=0.2486 c=0
Rk101 (\34\:VSS VSS) resistor r=0.1187 c=0
Rk100 (\31\:VSS \34\:VSS) resistor r=0.0667 c=0
Rk102 (VSS \36\:VSS) resistor r=0.3158 c=0
Rk60 (Q \2\:Q) resistor r=0.2843 c=0
Rk61 (Q \4\:Q) resistor r=0.221 c=0
Rk40 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk37 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.02218 c=0
Rk38 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.02218 c=0
Rk42 (\8\:ExtVDD ExtVDD) resistor r=0.03859 c=0
Rk39 (\5\:ExtVDD \8\:ExtVDD) resistor r=0.01996 c=0
Rk43 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.08309 c=0
Rk54 (RT \7\:RT) resistor r=0.006187 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.5425 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2539 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3399 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2292 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4959 c=0
Rk3 (\12\:CKbb \13\:CKbb) resistor r=0.7504 c=0
Rk7 (\15\:CKbb \16\:CKbb) resistor r=0.3834 c=0
Rk8 (\16\:CKbb \18\:CKbb) resistor r=0.205 c=0
Rk55 (\19\:CKbb \20\:CKbb) resistor r=0.6808 c=0
Rk17 (\6\:mout \7\:mout) resistor r=0.6015 c=0
Rk18 (\7\:mout \8\:mout) resistor r=0.2977 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.1545 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.2977 c=0
Rk21 (\7\:mout \12\:mout) resistor r=0.1277 c=0
Rk22 (\8\:mout \14\:mout) resistor r=0.09726 c=0
Rk23 (\9\:mout \16\:mout) resistor r=0.5258 c=0
Rk24 (\10\:mout \17\:mout) resistor r=0.3933 c=0
Rk10 (\13\:CKb \14\:CKb) resistor r=0.1958 c=0
Rk11 (\14\:CKb \15\:CKb) resistor r=0.1984 c=0
Rk12 (\14\:CKb \17\:CKb) resistor r=0.3032 c=0
Rk57 (\18\:CKb \19\:CKb) resistor r=1.9109 c=0
Rk27 (\5\:SEb \6\:SEb) resistor r=0.2018 c=0
Rk28 (\6\:SEb \7\:SEb) resistor r=0.3834 c=0
Rk29 (\6\:SEb \9\:SEb) resistor r=0.2942 c=0
Rk35 (\6\:n35g \8\:n35g) resistor r=0.1374 c=0
Rk36 (\8\:n35g \10\:n35g) resistor r=0.5859 c=0
Rk47 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk48 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk49 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk44 (\12\:qbint \13\:qbint) resistor r=0.494 c=0
Rk45 (\13\:qbint \15\:qbint) resistor r=0.5666 c=0
Rk46 (\13\:qbint \17\:qbint) resistor r=0.1462 c=0
Rk56 (\18\:qbint \19\:qbint) resistor r=0.2116 c=0
Rk51 (\5\:RTb \7\:RTb) resistor r=0.5249 c=0
Rk52 (\7\:RTb \8\:RTb) resistor r=0.7664 c=0
Rk53 (\8\:RTb \10\:RTb) resistor r=0.116 c=0
Rk30 (\6\:n35 \7\:n35) resistor r=0.4108 c=0
Rk31 (\7\:n35 \8\:n35) resistor r=0.5458 c=0
Rk32 (\8\:n35 \10\:n35) resistor r=0.1747 c=0
Rk33 (\7\:n35 \12\:n35) resistor r=0.1489 c=0
Rk34 (\8\:n35 \14\:n35) resistor r=0.5545 c=0
Rk50 (\15\:n35 \16\:n35) resistor r=0.4085 c=0
Rk58 (\18\:n35 \20\:n35) resistor r=0.6786 c=0
Rk59 (\20\:n35 \21\:n35) resistor r=0.122 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.6357 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.3203 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.6005 c=0
Rk63 (\2\:net0110 \4\:net0110) resistor r=0.7099 c=0
Rk62 (\2\:net0118 \4\:net0118) resistor r=0.3981 c=0
Rl18 (\2\:SI \3\:SI) resistor r=155.002 c=0
