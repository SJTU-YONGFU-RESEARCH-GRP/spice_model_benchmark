        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=3.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\4\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp56 (\5\:net367 \7\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.395e-14 ad=5.46e-14 ps=1.24e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.08141e-07 sd=160n sca=23.2995 \
        scb=0.0182724 scc=0.00243236 m=(1)
mp20 (\15\:CKb \1\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.395e-14 ad=3.655e-14 ps=1.24e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.7e-07 sd=160n sca=33.2772 \
        scb=0.0257934 scc=0.00427133 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.77e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net376 \8\:qbint \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.505e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 \3\:CKbb net376 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=1.32e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \3\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=9.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=1.115e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\6\:mout \3\:n20 \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=5.16e-14 ps=1.64e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=8.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net356 mout \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=5.65e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\5\:n20 \8\:CKb net356 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=4.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\5\:n20 \6\:CKbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.085e-14 ps=8.8e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=2.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\15\:CKbb \9\:CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.763e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp11 (net384 \4\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=2.903e-14 ps=7.8e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.01e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp12 (\6\:Db \2\:SE net384 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.73e-14 ps=7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=8.3e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp14 (\6\:Db SEb net392 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=4.73e-14 ps=7.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.65e-07 sd=160n sca=12.0741 \
        scb=0.0103373 scc=0.000281783 m=(1)
mp13 (net392 \1\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.763e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.45e-07 sd=160n sca=13.0129 \
        scb=0.0110013 scc=0.000282677 m=(1)
mp10 (\8\:SEb \5\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.4e-07 sd=160n sca=15.3212 \
        scb=0.0144348 scc=0.000319945 m=(1)
ends SDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:49:16 2012 )
// Library name: gsclib045
// Cell name: SDFFX2
// View name: extracted

simulator lang=spectre

subckt SDFFX2 CK D Q QN SE SI VDD VSS
mp10 (\10\:SEb \1\:SE \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.39e-06 sd=160n sca=16.6694 \
        scb=0.0168672 scc=0.000344817 m=(1)
C1 (D VSS) capacitor c=5.06509e-17
C2 (CK VSS) capacitor c=6.51998e-17
C3 (Q VSS) capacitor c=4.36651e-17
C4 (SI VSS) capacitor c=3.84146e-17
C5 (QN VSS) capacitor c=2.50573e-17
C6 (VDD VSS) capacitor c=3.59557e-16
C7 (SE VSS) capacitor c=7.18612e-17
C8 (SEb VSS) capacitor c=6.4832e-17
C9 (net449 VSS) capacitor c=8.64555e-20
C10 (Db VSS) capacitor c=8.71008e-17
C11 (net461 VSS) capacitor c=1.52853e-18
C12 (CKbb VSS) capacitor c=3.69409e-17
C13 (CKb VSS) capacitor c=3.22442e-17
C14 (n20 VSS) capacitor c=4.9866e-17
C15 (mout VSS) capacitor c=6.08294e-17
C16 (n30 VSS) capacitor c=5.7694e-17
C17 (net436 VSS) capacitor c=1.34497e-18
C18 (qbint VSS) capacitor c=3.24459e-17
C19 (net367 VSS) capacitor c=1.69623e-16
C20 (net384 VSS) capacitor c=1.63206e-18
C21 (net392 VSS) capacitor c=1.24686e-18
C22 (net376 VSS) capacitor c=1.91844e-18
C23 (\14\:qbint VSS) capacitor c=5.74437e-17
C24 (\5\:qbint VSS) capacitor c=4.68048e-16
C25 (\1\:CK VSS) capacitor c=3.00696e-17
C26 (\4\:qbint VSS) capacitor c=4.87578e-17
C27 (\7\:CKbb VSS) capacitor c=6.01914e-17
C28 (\9\:CKb VSS) capacitor c=6.59189e-17
C29 (\2\:CKb VSS) capacitor c=6.07634e-17
C30 (\7\:CKb VSS) capacitor c=4.45856e-17
C31 (\1\:SI VSS) capacitor c=6.55088e-17
C32 (\3\:SEb VSS) capacitor c=6.10153e-17
C33 (\6\:SE VSS) capacitor c=4.27049e-17
C34 (\1\:D VSS) capacitor c=3.45234e-17
C35 (\1\:SE VSS) capacitor c=3.74081e-17
C36 (\13\:qbint VSS) capacitor c=3.20184e-17
C37 (\3\:CK VSS) capacitor c=2.78405e-17
C38 (\4\:n30 VSS) capacitor c=3.18956e-17
C39 (\3\:qbint VSS) capacitor c=7.05744e-17
C40 (\8\:CKb VSS) capacitor c=7.75615e-17
C41 (\5\:CKbb VSS) capacitor c=3.30788e-17
C42 (\4\:n20 VSS) capacitor c=3.35358e-17
C43 (\3\:mout VSS) capacitor c=7.44818e-17
C44 (\3\:CKbb VSS) capacitor c=6.89246e-17
C45 (\6\:CKb VSS) capacitor c=3.18121e-17
C46 (\5\:CKb VSS) capacitor c=3.14907e-17
C47 (\3\:SI VSS) capacitor c=3.60857e-17
C48 (\4\:SE VSS) capacitor c=4.62592e-17
C49 (\3\:D VSS) capacitor c=7.40217e-17
C50 (\3\:SE VSS) capacitor c=3.48663e-17
C51 (\12\:qbint VSS) capacitor c=2.85867e-17
C52 (\6\:net367 VSS) capacitor c=2.2957e-17
C53 (\2\:CK VSS) capacitor c=3.33937e-17
C54 (\3\:n30 VSS) capacitor c=2.64457e-17
C55 (\8\:CKbb VSS) capacitor c=4.28848e-17
C56 (\10\:CKb VSS) capacitor c=2.45463e-17
C57 (\6\:CKbb VSS) capacitor c=3.28611e-17
C58 (\3\:n20 VSS) capacitor c=2.81205e-17
C59 (\2\:mout VSS) capacitor c=5.40894e-17
C60 (\4\:CKbb VSS) capacitor c=2.42555e-17
C61 (\2\:CKbb VSS) capacitor c=5.55544e-17
C62 (\2\:SI VSS) capacitor c=4.52478e-17
C63 (\4\:SEb VSS) capacitor c=3.57821e-17
C64 (\5\:SE VSS) capacitor c=6.22944e-17
C65 (\2\:SEb VSS) capacitor c=2.76996e-17
C66 (\2\:D VSS) capacitor c=6.16661e-17
C67 (\2\:SE VSS) capacitor c=3.66623e-17
C68 (\8\:net367 VSS) capacitor c=1.44819e-17
C69 (\1\:VDD VSS) capacitor c=2.53774e-16
C70 (\1\:QN VSS) capacitor c=9.51918e-17
C71 (\1\:Q VSS) capacitor c=9.10902e-17
C72 (\13\:CKb VSS) capacitor c=1.30513e-16
C73 (\24\:qbint VSS) capacitor c=3.25123e-17
C74 (\18\:VDD VSS) capacitor c=2.38566e-17
C75 (\7\:n30 VSS) capacitor c=6.83891e-17
C76 (\8\:mout VSS) capacitor c=2.40903e-17
C77 (\20\:VDD VSS) capacitor c=1.70802e-17
C78 (\9\:n20 VSS) capacitor c=4.11677e-17
C79 (\3\:Db VSS) capacitor c=1.6788e-16
C80 (\18\:CKbb VSS) capacitor c=1.03299e-16
C81 (\22\:VDD VSS) capacitor c=3.18647e-17
C82 (\5\:Db VSS) capacitor c=1.69689e-16
C83 (\24\:VDD VSS) capacitor c=3.90144e-17
C84 (\10\:SEb VSS) capacitor c=5.39546e-17
C85 (\4\:VDD VSS) capacitor c=7.19584e-17
C86 (\12\:net367 VSS) capacitor c=2.60428e-17
C87 (\3\:QN VSS) capacitor c=2.72582e-17
C88 (\3\:Q VSS) capacitor c=3.24179e-17
C89 (\11\:CKb VSS) capacitor c=6.53762e-17
C90 (\18\:qbint VSS) capacitor c=8.4964e-17
C91 (\9\:n30 VSS) capacitor c=4.7644e-17
C92 (\6\:mout VSS) capacitor c=6.84431e-17
C93 (\7\:n20 VSS) capacitor c=3.8437e-17
C94 (\13\:CKbb VSS) capacitor c=1.00824e-16
C95 (\7\:Db VSS) capacitor c=8.81232e-17
C96 (\8\:SEb VSS) capacitor c=1.64614e-17
C97 (\3\:CKb VSS) capacitor c=8.5733e-17
C98 (\4\:CKb VSS) capacitor c=3.66668e-17
C99 (\2\:n20 VSS) capacitor c=2.58222e-17
C100 (\2\:qbint VSS) capacitor c=3.30586e-17
C101 (\2\:n30 VSS) capacitor c=2.62795e-17
C102 (\4\:D VSS) capacitor c=7.13035e-17
C103 (\7\:SE VSS) capacitor c=6.49982e-17
C104 (\5\:SEb VSS) capacitor c=1.25848e-16
C105 (\6\:SEb VSS) capacitor c=1.41201e-16
C106 (\7\:SEb VSS) capacitor c=1.20469e-16
C107 (\4\:SI VSS) capacitor c=6.93697e-17
C108 (\5\:n20 VSS) capacitor c=4.36654e-17
C109 (\6\:n20 VSS) capacitor c=5.05931e-17
C110 (\4\:mout VSS) capacitor c=3.43948e-17
C111 (\5\:mout VSS) capacitor c=5.40224e-17
C112 (\9\:CKbb VSS) capacitor c=2.32634e-17
C113 (\10\:CKbb VSS) capacitor c=1.12156e-16
C114 (\11\:CKbb VSS) capacitor c=8.12157e-17
C115 (\12\:CKbb VSS) capacitor c=6.75929e-17
C116 (\15\:CKbb VSS) capacitor c=4.9892e-17
C117 (\16\:CKbb VSS) capacitor c=2.50868e-17
C118 (\17\:CKbb VSS) capacitor c=7.28302e-17
C119 (\5\:n30 VSS) capacitor c=3.49747e-17
C120 (\6\:n30 VSS) capacitor c=6.47509e-17
C121 (\15\:CKb VSS) capacitor c=1.42473e-16
C122 (\16\:CKb VSS) capacitor c=6.43002e-17
C123 (\4\:CK VSS) capacitor c=5.72821e-17
C124 (\15\:qbint VSS) capacitor c=6.29795e-17
C125 (\22\:qbint VSS) capacitor c=3.24687e-17
C126 (\23\:qbint VSS) capacitor c=4.42425e-17
C127 (\10\:net367 VSS) capacitor c=1.95937e-17
C128 (\11\:net367 VSS) capacitor c=2.34991e-17
C129 (\7\:VDD VSS) capacitor c=2.38898e-17
C130 (\9\:VDD VSS) capacitor c=3.31089e-17
C131 (\11\:VDD VSS) capacitor c=2.48974e-17
C132 (\12\:VDD VSS) capacitor c=1.78478e-17
Rk1 (D \4\:D) resistor r=0.2261 c=0
Rk32 (CK \4\:CK) resistor r=0.07801 c=0
Rk33 (\2\:Q Q) resistor r=0.3452 c=0
Rk34 (Q \4\:Q) resistor r=0.04101 c=0
Rk8 (SI \4\:SI) resistor r=0.05294 c=0
Rk35 (\2\:QN QN) resistor r=0.3617 c=0
Rk36 (QN \4\:QN) resistor r=0.03697 c=0
Rk69 (\1\:VDD \7\:VDD) resistor r=0.466 c=0
Rk70 (\7\:VDD \8\:VDD) resistor r=0.1277 c=0
Rk71 (\8\:VDD \9\:VDD) resistor r=0.3348 c=0
Rk72 (\9\:VDD \10\:VDD) resistor r=0.4151 c=0
Rk73 (\10\:VDD \11\:VDD) resistor r=0.1628 c=0
Rk74 (\11\:VDD \12\:VDD) resistor r=0.4209 c=0
Rk76 (\13\:VDD VDD) resistor r=0.0499 c=0
Rk75 (\12\:VDD \13\:VDD) resistor r=0.1177 c=0
Rk79 (\7\:VDD \19\:VDD) resistor r=0.1025 c=0
Rk80 (\9\:VDD \21\:VDD) resistor r=0.0433 c=0
Rk81 (\11\:VDD \23\:VDD) resistor r=0.1025 c=0
Rk82 (\12\:VDD \25\:VDD) resistor r=0.2673 c=0
Rk48 (\2\:VSS \3\:VSS) resistor r=0.1177 c=0
Rk51 (\3\:VSS \6\:VSS) resistor r=0.1117 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.3383 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.45 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.4126 c=0
Rk55 (\9\:VSS \10\:VSS) resistor r=0.1628 c=0
Rk56 (\10\:VSS \11\:VSS) resistor r=0.4359 c=0
Rk58 (\12\:VSS VSS) resistor r=0.0499 c=0
Rk57 (\11\:VSS \12\:VSS) resistor r=0.1026 c=0
Rk62 (\7\:VSS \20\:VSS) resistor r=0.3505 c=0
Rk63 (\8\:VSS \22\:VSS) resistor r=0.0433 c=0
Rk64 (\10\:VSS \24\:VSS) resistor r=0.3416 c=0
Rk65 (\11\:VSS \26\:VSS) resistor r=0.3499 c=0
Rk3 (\8\:SE SE) resistor r=0.002303 c=0
Rk2 (\7\:SE \8\:SE) resistor r=0.2281 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=0.8118 c=0
Rk5 (\6\:SEb \7\:SEb) resistor r=0.6592 c=0
Rk6 (\7\:SEb \9\:SEb) resistor r=0.07492 c=0
Rk7 (\7\:SEb \11\:SEb) resistor r=0.519 c=0
Rk9 (\2\:Db \4\:Db) resistor r=0.5195 c=0
Rk10 (\4\:Db \6\:Db) resistor r=0.9882 c=0
Rk11 (\6\:Db \8\:Db) resistor r=0.4497 c=0
Rk18 (\9\:CKbb \10\:CKbb) resistor r=0.01531 c=0
Rk19 (\10\:CKbb \11\:CKbb) resistor r=0.7662 c=0
Rk20 (\11\:CKbb \12\:CKbb) resistor r=0.2063 c=0
Rk21 (\12\:CKbb \14\:CKbb) resistor r=0.3626 c=0
Rk22 (\10\:CKbb \15\:CKbb) resistor r=0.2605 c=0
Rk23 (\11\:CKbb \16\:CKbb) resistor r=0.0805 c=0
Rk24 (\12\:CKbb \17\:CKbb) resistor r=0.3382 c=0
Rk25 (\14\:CKbb \19\:CKbb) resistor r=0.6092 c=0
Rk29 (\12\:CKb \14\:CKb) resistor r=0.4211 c=0
Rk30 (\14\:CKb \15\:CKb) resistor r=0.9213 c=0
Rk31 (\15\:CKb \16\:CKb) resistor r=0.5198 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2193 c=0
Rk13 (\6\:n20 \8\:n20) resistor r=0.09574 c=0
Rk14 (\6\:n20 \10\:n20) resistor r=0.2608 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2074 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2755 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1424 c=0
Rk26 (\5\:n30 \6\:n30) resistor r=0.1422 c=0
Rk27 (\6\:n30 \8\:n30) resistor r=0.4313 c=0
Rk28 (\6\:n30 \10\:n30) resistor r=0.2305 c=0
Rk37 (\15\:qbint \5\:qbint) resistor r=0.4764 c=0
Rk39 (\5\:qbint \19\:qbint) resistor r=0.6089 c=0
Rk42 (\19\:qbint \22\:qbint) resistor r=0.2861 c=0
Rk43 (\22\:qbint \23\:qbint) resistor r=0.1273 c=0
Rk44 (\22\:qbint \25\:qbint) resistor r=0.1429 c=0
Rk45 (\9\:net367 \10\:net367) resistor r=0.09349 c=0
Rk46 (\10\:net367 \11\:net367) resistor r=0.1152 c=0
Rk47 (\10\:net367 \13\:net367) resistor r=0.156 c=0
Rl3 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl4 (\2\:D \3\:D) resistor r=145.387 c=0
Rl34 (\1\:CK \2\:CK) resistor r=53.8462 c=0
Rl35 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl9 (\1\:SI \2\:SI) resistor r=72.3097 c=0
Rl10 (\2\:SI \3\:SI) resistor r=97.3098 c=0
Rl7 (\5\:SE \6\:SE) resistor r=85.7713 c=0
Rl6 (\4\:SE \5\:SE) resistor r=153.4 c=0
Rl1 (\1\:SE \2\:SE) resistor r=83.3841 c=0
Rl2 (\2\:SE \3\:SE) resistor r=89.1533 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=45.3867 c=0
Rl5 (SEb \2\:SEb) resistor r=83.8482 c=0
Rl25 (\7\:CKbb \8\:CKbb) resistor r=31.461 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=31.461 c=0
Rl12 (\3\:CKbb \4\:CKbb) resistor r=93.4636 c=0
Rl11 (CKbb \2\:CKbb) resistor r=54.5677 c=0
Rl13 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl26 (\8\:CKb \9\:CKb) resistor r=222.208 c=0
Rl27 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=170.697 c=0
Rl17 (\3\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl18 (\4\:CKb \7\:CKb) resistor r=143.912 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=105.747 c=0
Rl15 (\3\:CKb \4\:CKb) resistor r=150.39 c=0
Rl21 (n20 \2\:n20) resistor r=113.25 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=34.4036 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=14.7297 c=0
Rl19 (mout \2\:mout) resistor r=24.2328 c=0
Rl20 (\2\:mout \3\:mout) resistor r=101.526 c=0
Rl31 (n30 \2\:n30) resistor r=113.493 c=0
Rl33 (\2\:n30 \4\:n30) resistor r=24.7024 c=0
Rl32 (\2\:n30 \3\:n30) resistor r=4.4012 c=0
Rl48 (\13\:qbint \14\:qbint) resistor r=117.308 c=0
Rl47 (\12\:qbint \13\:qbint) resistor r=69.208 c=0
Rl28 (\2\:qbint qbint) resistor r=11.5001 c=0
Rl30 (\2\:qbint \4\:qbint) resistor r=40.0987 c=0
Rl29 (\2\:qbint \3\:qbint) resistor r=107.406 c=0
Rl45 (net367 \6\:net367) resistor r=9.5287 c=0
Rz9 (\4\:Q \3\:Q) resistor r=75 c=0
Rz10 (\4\:QN \3\:QN) resistor r=75 c=0
Rz20 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz21 (\8\:VDD \4\:VDD) resistor r=25 c=0
Rz22 (\10\:VDD \4\:VDD) resistor r=6.25 c=0
Rz23 (\13\:VDD \4\:VDD) resistor r=37.5 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz19 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz1 (\8\:SEb \9\:SEb) resistor r=75 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz6 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz8 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz4 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz11 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz12 (\13\:net367 \12\:net367) resistor r=75 c=0
Ry9 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry10 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry23 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry16 (\12\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry2 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\5\:Db \6\:Db) resistor r=62 c=0
Ry6 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry8 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry4 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry11 (\25\:qbint \24\:qbint) resistor r=62 c=0
Ry12 (\9\:net367 \8\:net367) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\5\:SE \7\:SE) resistor r=45 c=0
Rx3 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx9 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx14 (\10\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx17 (\15\:qbint \12\:qbint) resistor r=45 c=0
Rx20 (\23\:qbint qbint) resistor r=45 c=0
Rx21 (\11\:net367 \6\:net367) resistor r=45 c=0
mn10 (\8\:SEb \3\:SE \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.21e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (net449 \3\:D \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.005e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn12 (\7\:Db SEb net449 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn14 (\7\:Db \4\:SE net461 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.335e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=6.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn13 (net461 \3\:SI \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.045e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn21 (\13\:CKbb \5\:CKb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.682e-14 ad=2.03e-14 ps=6.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn25 (\7\:n20 \6\:CKb Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.615e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn36 (\7\:n20 \3\:CKbb net429 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.41e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn35 (net429 \3\:mout \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=8.7e-15 ps=1.55e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.305e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (\6\:mout \4\:n20 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.11e-14 ad=2.32e-14 ps=1.55e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.04e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\9\:n30 \5\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.857e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=8.35e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn51 (\9\:n30 \8\:CKb net436 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.857e-14 ps=4.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=4.55e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn50 (net436 \3\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=9.42e-15 ps=7.3e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.45e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn45 (\18\:qbint \4\:n30 \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29537e-06 sb=1.4e-07 sd=160n sca=16.6038 \
        scb=0.0171168 scc=0.00137311 m=(1)
mn20 (\11\:CKb \3\:CK \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.13e-14 ad=3.19e-14 ps=1.62e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=1.32e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (\3\:Q \5\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.345e-14 ad=4.16e-14 ps=1.61e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5125e-07 sb=9.25577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\3\:QN net367 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.916e-14 ad=4.16e-14 ps=1.635e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2125e-07 sb=4.55577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:net367 \13\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=6.272e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp11 (net384 \1\:D \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.185e-06 sd=160n sca=12.9619 \
        scb=0.0106134 scc=0.000191935 m=(1)
mp12 (\5\:Db \6\:SE net384 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.558e-14 ps=7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.005e-06 sd=160n sca=11.8125 \
        scb=0.00941499 scc=0.000188107 m=(1)
mp14 (\5\:Db \3\:SEb net392 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=6.55e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp13 (net392 \1\:SI \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1327e-13 ad=1.29e-14 ps=1.74e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=5.5e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp21 (\18\:CKbb \7\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.1327e-13 ad=3.01e-14 ps=1.74e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.4e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp25 (\9\:n20 CKbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\9\:n20 \2\:CKb net356 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.465e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (net356 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.29e-14 ps=1.62e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.36e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\8\:mout n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=5.805e-14 ps=1.62e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.095e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\7\:n30 \9\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.44e-14 ps=9.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=7.8e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (net376 \4\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.705e-14 ad=2.687e-14 ps=1.62e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=4.05e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\7\:n30 \7\:CKbb net376 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=3.44e-14 ps=6.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=5.75e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp45 (\24\:qbint n30 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.705e-14 ad=4.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21032e-06 sb=1.4e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp20 (\13\:CKb \1\:CK \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.857e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.265e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp56 (\8\:net367 \14\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.727e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=28.2418 \
        scb=0.0288633 scc=0.00256816 m=(1)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.549e-14 ad=7.41e-14 ps=1.145e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.77821e-07 sb=8.93846e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(2)
mp57 (\1\:QN net367 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.984e-14 ad=6.24e-14 ps=1.125e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.17821e-07 sb=4.53846e-07 sd=160n sca=17.7255 \
        scb=0.0154354 scc=0.00137898 m=(2)
ends SDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:49:53 2012 )
// Library name: gsclib045
// Cell name: SDFFX4
// View name: extracted

simulator lang=spectre

subckt SDFFX4 CK D Q QN SE SI VDD VSS
mp10 (\10\:SEb \1\:SE \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.51e-06 sd=160n sca=13.1833 \
        scb=0.0107181 scc=0.000111559 m=(1)
C1 (D VSS) capacitor c=4.89287e-17
C2 (CK VSS) capacitor c=3.93832e-17
C3 (Q VSS) capacitor c=2.34762e-17
C4 (QN VSS) capacitor c=1.48165e-17
C5 (VDD VSS) capacitor c=3.34672e-16
C6 (SE VSS) capacitor c=4.75709e-17
C7 (SEb VSS) capacitor c=7.90053e-17
C8 (net449 VSS) capacitor c=1.56005e-19
C9 (Db VSS) capacitor c=9.02625e-17
C10 (net461 VSS) capacitor c=2.5028e-18
C11 (CKb VSS) capacitor c=7.75846e-17
C12 (CKbb VSS) capacitor c=3.28415e-17
C13 (n20 VSS) capacitor c=4.78759e-17
C14 (mout VSS) capacitor c=5.96739e-17
C15 (n30 VSS) capacitor c=2.1459e-16
C16 (qbint VSS) capacitor c=3.13127e-17
C17 (net367 VSS) capacitor c=2.74836e-16
C18 (net384 VSS) capacitor c=6.14441e-21
C19 (net392 VSS) capacitor c=3.45998e-18
C20 (net376 VSS) capacitor c=5.44488e-18
C21 (\22\:qbint VSS) capacitor c=4.63026e-17
C22 (\5\:qbint VSS) capacitor c=2.67948e-16
C23 (\4\:qbint VSS) capacitor c=3.83921e-17
C24 (\7\:CKbb VSS) capacitor c=5.02155e-17
C25 (\2\:CKb VSS) capacitor c=1.05685e-16
C26 (\3\:CKb VSS) capacitor c=1.45396e-16
C27 (\9\:CKb VSS) capacitor c=4.17801e-17
C28 (\1\:CK VSS) capacitor c=4.74634e-17
C29 (\1\:SI VSS) capacitor c=6.5406e-17
C30 (\3\:SEb VSS) capacitor c=4.33663e-17
C31 (\6\:SE VSS) capacitor c=4.5145e-17
C32 (\1\:D VSS) capacitor c=3.87292e-17
C33 (\1\:SE VSS) capacitor c=5.60265e-17
C34 (\20\:qbint VSS) capacitor c=3.40984e-17
C35 (\3\:qbint VSS) capacitor c=6.13135e-17
C36 (\5\:CKbb VSS) capacitor c=3.23875e-17
C37 (\3\:n20 VSS) capacitor c=2.78948e-17
C38 (\3\:mout VSS) capacitor c=5.36318e-17
C39 (\3\:CKbb VSS) capacitor c=4.84079e-17
C40 (\8\:CKb VSS) capacitor c=2.37969e-17
C41 (\7\:CKb VSS) capacitor c=2.38845e-17
C42 (\3\:CK VSS) capacitor c=2.55195e-17
C43 (\3\:SI VSS) capacitor c=2.8781e-17
C44 (\4\:SE VSS) capacitor c=5.04671e-17
C45 (\3\:D VSS) capacitor c=8.93008e-17
C46 (\3\:SE VSS) capacitor c=2.58524e-17
C47 (\21\:qbint VSS) capacitor c=3.95395e-17
C48 (\8\:CKbb VSS) capacitor c=3.89958e-17
C49 (\6\:CKbb VSS) capacitor c=3.33208e-17
C50 (\2\:n20 VSS) capacitor c=3.17173e-17
C51 (\2\:mout VSS) capacitor c=5.25131e-17
C52 (\4\:CKbb VSS) capacitor c=2.54934e-17
C53 (\2\:CKbb VSS) capacitor c=5.52682e-17
C54 (\6\:CKb VSS) capacitor c=2.07336e-17
C55 (\2\:CK VSS) capacitor c=4.39963e-17
C56 (\2\:SI VSS) capacitor c=4.77552e-17
C57 (\4\:SEb VSS) capacitor c=3.25013e-17
C58 (\5\:SE VSS) capacitor c=5.90355e-17
C59 (\2\:SEb VSS) capacitor c=3.0228e-17
C60 (\2\:D VSS) capacitor c=6.39218e-17
C61 (\2\:SE VSS) capacitor c=4.03079e-17
C62 (\20\:net367 VSS) capacitor c=3.46925e-17
C63 (\1\:VDD VSS) capacitor c=4.58522e-16
C64 (\1\:Q VSS) capacitor c=1.52391e-16
C65 (\30\:qbint VSS) capacitor c=5.97297e-17
C66 (\10\:n30 VSS) capacitor c=5.86581e-17
C67 (\4\:mout VSS) capacitor c=2.13354e-17
C68 (\22\:VDD VSS) capacitor c=3.89546e-17
C69 (\8\:n20 VSS) capacitor c=3.8307e-17
C70 (\3\:Db VSS) capacitor c=2.29047e-16
C71 (\17\:CKbb VSS) capacitor c=1.03588e-16
C72 (\25\:VDD VSS) capacitor c=1.64563e-17
C73 (\14\:CKb VSS) capacitor c=6.98914e-17
C74 (\29\:VDD VSS) capacitor c=3.89256e-17
C75 (\8\:Db VSS) capacitor c=1.18342e-17
C76 (\33\:VDD VSS) capacitor c=3.20483e-17
C77 (\10\:SEb VSS) capacitor c=8.58079e-17
C78 (\3\:VDD VSS) capacitor c=1.099e-16
C79 (\16\:net367 VSS) capacitor c=4.45038e-17
C80 (\1\:QN VSS) capacitor c=1.19629e-16
C81 (\24\:qbint VSS) capacitor c=2.12642e-16
C82 (\8\:n30 VSS) capacitor c=6.46076e-17
C83 (\8\:mout VSS) capacitor c=5.07166e-17
C84 (\6\:n20 VSS) capacitor c=3.93405e-17
C85 (\12\:CKbb VSS) capacitor c=1.04095e-16
C86 (\12\:CKb VSS) capacitor c=5.16514e-17
C87 (\6\:Db VSS) capacitor c=1.10154e-16
C88 (\7\:SEb VSS) capacitor c=1.04701e-16
C89 (\4\:CKb VSS) capacitor c=6.10942e-17
C90 (\5\:CKb VSS) capacitor c=2.11844e-17
C91 (\2\:qbint VSS) capacitor c=3.72753e-17
C92 (\4\:D VSS) capacitor c=6.76337e-17
C93 (\7\:SE VSS) capacitor c=9.26591e-17
C94 (\8\:SE VSS) capacitor c=5.38562e-17
C95 (\5\:SEb VSS) capacitor c=2.32204e-17
C96 (\6\:SEb VSS) capacitor c=1.36873e-16
C97 (\9\:SEb VSS) capacitor c=1.30286e-16
C98 (\4\:SI VSS) capacitor c=1.19266e-16
C99 (\4\:CK VSS) capacitor c=7.01453e-17
C100 (\10\:CKb VSS) capacitor c=1.86239e-17
C101 (\11\:CKb VSS) capacitor c=7.3386e-17
C102 (\5\:Db VSS) capacitor c=2.15373e-16
C103 (\4\:n20 VSS) capacitor c=5.92783e-17
C104 (\5\:n20 VSS) capacitor c=5.76147e-17
C105 (\6\:mout VSS) capacitor c=5.37943e-17
C106 (\7\:mout VSS) capacitor c=5.2959e-17
C107 (\9\:CKbb VSS) capacitor c=2.62692e-17
C108 (\10\:CKbb VSS) capacitor c=1.11222e-16
C109 (\11\:CKbb VSS) capacitor c=6.13669e-17
C110 (\14\:CKbb VSS) capacitor c=1.33902e-16
C111 (\15\:CKbb VSS) capacitor c=6.34885e-17
C112 (\16\:CKbb VSS) capacitor c=7.3886e-17
C113 (\6\:n30 VSS) capacitor c=5.54559e-17
C114 (\7\:n30 VSS) capacitor c=8.72044e-17
C115 (\4\:Q VSS) capacitor c=1.20992e-16
C116 (\5\:QN VSS) capacitor c=1.6559e-16
C117 (\23\:qbint VSS) capacitor c=2.43031e-16
C118 (\26\:qbint VSS) capacitor c=3.23326e-17
C119 (\27\:qbint VSS) capacitor c=2.28316e-17
C120 (\28\:qbint VSS) capacitor c=4.7371e-17
C121 (\29\:qbint VSS) capacitor c=2.8236e-17
C122 (\18\:net367 VSS) capacitor c=3.53437e-17
C123 (\19\:net367 VSS) capacitor c=3.85339e-17
C124 (\21\:VDD VSS) capacitor c=1.80274e-17
C125 (\24\:VDD VSS) capacitor c=1.57086e-17
C126 (\28\:VDD VSS) capacitor c=1.51408e-17
C127 (\32\:VDD VSS) capacitor c=1.01774e-17
Rk1 (\4\:D D) resistor r=0.04824 c=0
Rk9 (CK \4\:CK) resistor r=0.1571 c=0
Rk34 (\1\:Q Q) resistor r=0.04991 c=0
Rk35 (Q \4\:Q) resistor r=0.2087 c=0
Rk8 (\4\:SI SI) resistor r=0.002999 c=0
Rk40 (\1\:QN QN) resistor r=0.2139 c=0
Rk41 (QN \5\:QN) resistor r=0.04798 c=0
Rk87 (\1\:VDD \20\:VDD) resistor r=0.4235 c=0
Rk88 (\20\:VDD \21\:VDD) resistor r=0.1552 c=0
Rk89 (\21\:VDD \23\:VDD) resistor r=0.3636 c=0
Rk90 (\21\:VDD \24\:VDD) resistor r=0.3923 c=0
Rk91 (\24\:VDD \26\:VDD) resistor r=0.04329 c=0
Rk92 (\24\:VDD \27\:VDD) resistor r=0.2521 c=0
Rk93 (\27\:VDD \28\:VDD) resistor r=0.2004 c=0
Rk94 (\28\:VDD \30\:VDD) resistor r=0.229 c=0
Rk95 (\28\:VDD \31\:VDD) resistor r=0.3508 c=0
Rk98 (\32\:VDD VDD) resistor r=0.2277 c=0
Rk96 (\31\:VDD \32\:VDD) resistor r=0.07251 c=0
Rk97 (\32\:VDD \34\:VDD) resistor r=0.2336 c=0
Rk59 (\1\:VSS \10\:VSS) resistor r=0.5135 c=0
Rk60 (\10\:VSS \11\:VSS) resistor r=0.2455 c=0
Rk61 (\11\:VSS \12\:VSS) resistor r=0.3458 c=0
Rk62 (\12\:VSS \13\:VSS) resistor r=0.2628 c=0
Rk63 (\13\:VSS \14\:VSS) resistor r=0.1928 c=0
Rk64 (\14\:VSS \15\:VSS) resistor r=0.2355 c=0
Rk66 (\16\:VSS VSS) resistor r=0.1 c=0
Rk65 (\15\:VSS \16\:VSS) resistor r=0.1151 c=0
Rk72 (\10\:VSS \28\:VSS) resistor r=0.1224 c=0
Rk73 (\12\:VSS \30\:VSS) resistor r=0.1936 c=0
Rk74 (\13\:VSS \32\:VSS) resistor r=0.127 c=0
Rk75 (\15\:VSS \34\:VSS) resistor r=0.07369 c=0
Rk3 (\8\:SE SE) resistor r=0.06515 c=0
Rk2 (\7\:SE \8\:SE) resistor r=0.3453 c=0
Rk4 (\5\:SEb \6\:SEb) resistor r=0.02032 c=0
Rk5 (\6\:SEb \8\:SEb) resistor r=0.4544 c=0
Rk6 (\6\:SEb \9\:SEb) resistor r=0.8152 c=0
Rk7 (\8\:SEb \11\:SEb) resistor r=0.7816 c=0
Rk13 (\2\:Db \4\:Db) resistor r=0.5362 c=0
Rk14 (\4\:Db \5\:Db) resistor r=1.4895 c=0
Rk15 (\5\:Db \7\:Db) resistor r=0.5994 c=0
Rk16 (\5\:Db \9\:Db) resistor r=0.05409 c=0
Rk10 (\10\:CKb \11\:CKb) resistor r=0.08108 c=0
Rk11 (\11\:CKb \13\:CKb) resistor r=0.3312 c=0
Rk12 (\11\:CKb \15\:CKb) resistor r=0.356 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.04789 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1763 c=0
Rk25 (\11\:CKbb \13\:CKbb) resistor r=0.2652 c=0
Rk26 (\10\:CKbb \14\:CKbb) resistor r=0.9706 c=0
Rk27 (\14\:CKbb \15\:CKbb) resistor r=0.3035 c=0
Rk28 (\11\:CKbb \16\:CKbb) resistor r=0.3569 c=0
Rk29 (\13\:CKbb \18\:CKbb) resistor r=0.7036 c=0
Rk17 (\4\:n20 \5\:n20) resistor r=0.3076 c=0
Rk18 (\5\:n20 \7\:n20) resistor r=0.1276 c=0
Rk19 (\5\:n20 \9\:n20) resistor r=0.2579 c=0
Rk20 (\5\:mout \6\:mout) resistor r=0.1341 c=0
Rk21 (\6\:mout \7\:mout) resistor r=0.3002 c=0
Rk22 (\6\:mout \9\:mout) resistor r=0.2658 c=0
Rk30 (\6\:n30 \7\:n30) resistor r=0.2587 c=0
Rk31 (\7\:n30 \9\:n30) resistor r=0.3143 c=0
Rk32 (\7\:n30 \11\:n30) resistor r=0.4203 c=0
Rk44 (\23\:qbint \25\:qbint) resistor r=1.8863 c=0
Rk45 (\25\:qbint \26\:qbint) resistor r=0.431 c=0
Rk46 (\26\:qbint \27\:qbint) resistor r=0.1042 c=0
Rk47 (\27\:qbint \28\:qbint) resistor r=0.1785 c=0
Rk48 (\26\:qbint \29\:qbint) resistor r=0.06889 c=0
Rk49 (\27\:qbint \31\:qbint) resistor r=0.1976 c=0
Rk50 (\17\:net367 \18\:net367) resistor r=0.3545 c=0
Rk51 (\18\:net367 \19\:net367) resistor r=0.2097 c=0
Rk52 (\18\:net367 \21\:net367) resistor r=0.1229 c=0
Rl3 (\1\:D \2\:D) resistor r=39.1533 c=0
Rl4 (\2\:D \3\:D) resistor r=187.23 c=0
Rl11 (\1\:CK \2\:CK) resistor r=182.692 c=0
Rl12 (\2\:CK \3\:CK) resistor r=45.3297 c=0
Rl9 (\1\:SI \2\:SI) resistor r=186.538 c=0
Rl10 (\2\:SI \3\:SI) resistor r=41.7582 c=0
Rl7 (\5\:SE \6\:SE) resistor r=88.2566 c=0
Rl6 (\4\:SE \5\:SE) resistor r=169.208 c=0
Rl1 (\1\:SE \2\:SE) resistor r=198.077 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.9451 c=0
Rl8 (\3\:SEb \4\:SEb) resistor r=49.2328 c=0
Rl5 (SEb \2\:SEb) resistor r=44.9225 c=0
Rl20 (CKb \2\:CKb) resistor r=187.593 c=0
Rl21 (\2\:CKb \3\:CKb) resistor r=441.439 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=100.733 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=239.928 c=0
Rl26 (\4\:CKb \8\:CKb) resistor r=30.4507 c=0
Rl27 (\5\:CKb \9\:CKb) resistor r=107.374 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=73.4664 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=81.1594 c=0
Rl28 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=87.1289 c=0
Rl13 (CKbb \2\:CKbb) resistor r=58.4139 c=0
Rl17 (n20 \2\:n20) resistor r=100.692 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl15 (mout \2\:mout) resistor r=33.8482 c=0
Rl16 (\2\:mout \3\:mout) resistor r=93.4636 c=0
Rl65 (\21\:qbint \22\:qbint) resistor r=60.7713 c=0
Rl64 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl29 (\2\:qbint qbint) resistor r=6.99 c=0
Rl31 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl30 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rz25 (\1\:VDD \3\:VDD) resistor r=6.25 c=0
Rz27 (\20\:VDD \3\:VDD) resistor r=6.25 c=0
Rz28 (\27\:VDD \3\:VDD) resistor r=18.75 c=0
Rz29 (\31\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz21 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz22 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz23 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz24 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz7 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz5 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz8 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz13 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz14 (\17\:net367 \16\:net367) resistor r=75 c=0
Ry26 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry27 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry28 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry29 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \3\:VSS) resistor r=3.875 c=0
Ry17 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\14\:VSS \3\:VSS) resistor r=15.5 c=0
Ry19 (\16\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry1 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry3 (\3\:Db \4\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry7 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry5 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry6 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry13 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry14 (\21\:net367 \20\:net367) resistor r=20.6667 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\5\:SE \7\:SE) resistor r=45 c=0
Rx3 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SEb \5\:SEb) resistor r=45 c=0
Rx5 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx8 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx11 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx13 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx15 (\6\:n30 n30) resistor r=45 c=0
Rx16 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx17 (\28\:qbint qbint) resistor r=45 c=0
Rx18 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx19 (\19\:net367 net367) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=2.103e-14 ps=1.45e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=1.26e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (net449 \3\:D \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=8.7e-15 ps=1.45e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (\6\:Db SEb net449 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.95e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn14 (\6\:Db \4\:SE net461 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=6.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn13 (net461 \3\:SI \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.48e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=4.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn20 (\12\:CKb \3\:CK \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.03e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn21 (\12\:CKbb \7\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn25 (\6\:n20 \8\:CKb Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.422e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb net429 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.45e-14 ad=4.422e-14 ps=4.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (net429 \3\:mout \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.43e-14 ad=1.45e-14 ps=1.27e-06 pd=4.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.43e-14 ad=4.422e-14 ps=1.27e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=3.553e-14 ps=9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb net436 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.552e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (net436 \3\:qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.087e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.622e-14 ad=3.28e-14 ps=1.085e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34841e-06 sb=2e-06 sd=160n sca=12.107 \
        scb=0.0120364 scc=0.000565641 m=(2)
mn55_1__rcx (\4\:Q \5\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.531e-14 ad=4.16e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn57_1__rcx (\1\:QN net367 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.14e-14 ad=4.745e-14 ps=1.34e-06 pd=8.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn56 (\16\:net367 \20\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mp11 (net384 \1\:D \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.305e-06 sd=160n sca=11.3131 \
        scb=0.00820755 scc=9.33745e-05 m=(1)
mp12 (\8\:Db \6\:SE net384 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=5.16e-14 ps=7e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.125e-06 sd=160n sca=10.6109 \
        scb=0.00776928 scc=9.29566e-05 m=(1)
mp14 (\8\:Db \3\:SEb net392 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.16e-14 ps=7.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=8.4e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp13 (net392 \1\:SI \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=6.35e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp20 (\14\:CKb \1\:CK \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=8.385e-14 ps=8.3e-07 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28e-06 sb=3.9e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp21 (\17\:CKbb \9\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=21.9815 scb=0.0208641 \
        scc=0.00225088 m=(1)
mp25 (\8\:n20 CKbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb net356 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp35 (net356 mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=9.03e-14 ps=8.7e-07 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.03e-14 ad=3.44e-14 ps=1.27e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb net376 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp50 (net376 \4\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp45 (\30\:qbint n30 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29823e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57_1__rcx (\5\:QN net367 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp56 (\20\:net367 \22\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
ends SDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:50:32 2012 )
// Library name: gsclib045
// Cell name: SDFFXL
// View name: extracted

simulator lang=spectre

subckt SDFFXL CK D Q QN SE SI VDD VSS
mp57 (\1\:QN \4\:net367 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.5197 \
        scb=0.0328493 scc=0.0059298 m=(1)
C1 (CK VSS) capacitor c=8.18471e-17
C2 (QN VSS) capacitor c=2.45906e-17
C3 (SE VSS) capacitor c=5.50042e-17
C4 (SI VSS) capacitor c=7.2775e-17
C5 (VDD VSS) capacitor c=3.45103e-16
C6 (D VSS) capacitor c=5.52318e-17
C7 (Q VSS) capacitor c=6.17095e-17
C8 (net367 VSS) capacitor c=2.1024e-17
C9 (qbint VSS) capacitor c=4.46022e-17
C10 (CKb VSS) capacitor c=4.65249e-17
C11 (n30 VSS) capacitor c=5.18642e-17
C12 (mout VSS) capacitor c=7.72861e-17
C13 (CKbb VSS) capacitor c=2.17593e-17
C14 (n20 VSS) capacitor c=4.22542e-17
C15 (Db VSS) capacitor c=9.88121e-17
C16 (net449 VSS) capacitor c=6.89353e-18
C17 (SEb VSS) capacitor c=3.65202e-17
C18 (net376 VSS) capacitor c=5.92504e-18
C19 (net384 VSS) capacitor c=4.61231e-18
C20 (\5\:SE VSS) capacitor c=4.70664e-17
C21 (\3\:SI VSS) capacitor c=5.18039e-17
C22 (\1\:SE VSS) capacitor c=4.63195e-17
C23 (\3\:D VSS) capacitor c=4.45304e-17
C24 (\9\:CKb VSS) capacitor c=5.12451e-17
C25 (\7\:CKbb VSS) capacitor c=3.99332e-17
C26 (\8\:CKb VSS) capacitor c=6.74213e-17
C27 (\3\:CKb VSS) capacitor c=4.91547e-17
C28 (\3\:CKbb VSS) capacitor c=4.71025e-17
C29 (\7\:qbint VSS) capacitor c=3.84735e-17
C30 (\1\:CK VSS) capacitor c=3.25507e-17
C31 (\6\:qbint VSS) capacitor c=3.16249e-17
C32 (\4\:net367 VSS) capacitor c=2.78326e-17
C33 (\8\:SE VSS) capacitor c=2.90752e-17
C34 (\1\:SI VSS) capacitor c=7.49639e-17
C35 (\3\:SE VSS) capacitor c=6.51337e-17
C36 (\3\:SEb VSS) capacitor c=7.12129e-17
C37 (\1\:D VSS) capacitor c=4.14516e-17
C38 (\5\:CKb VSS) capacitor c=2.83482e-17
C39 (\10\:CKb VSS) capacitor c=2.24553e-17
C40 (\5\:CKbb VSS) capacitor c=8.46845e-17
C41 (\3\:mout VSS) capacitor c=4.87962e-17
C42 (\3\:n20 VSS) capacitor c=3.11731e-17
C43 (\10\:qbint VSS) capacitor c=3.80044e-17
C44 (\2\:n30 VSS) capacitor c=3.71334e-17
C45 (\3\:CK VSS) capacitor c=3.96212e-17
C46 (\5\:qbint VSS) capacitor c=2.32545e-17
C47 (\4\:qbint VSS) capacitor c=2.75037e-17
C48 (\3\:net367 VSS) capacitor c=3.07644e-17
C49 (\7\:SE VSS) capacitor c=2.19115e-17
C50 (\2\:SI VSS) capacitor c=6.98078e-17
C51 (\4\:SE VSS) capacitor c=5.35e-17
C52 (\2\:SEb VSS) capacitor c=7.27188e-17
C53 (\2\:SE VSS) capacitor c=3.92235e-17
C54 (\2\:D VSS) capacitor c=6.4376e-17
C55 (\8\:CKbb VSS) capacitor c=4.33113e-17
C56 (\11\:CKb VSS) capacitor c=2.82601e-17
C57 (\6\:CKbb VSS) capacitor c=3.07936e-17
C58 (\2\:mout VSS) capacitor c=5.74439e-17
C59 (\2\:n20 VSS) capacitor c=3.79481e-17
C60 (\4\:CKb VSS) capacitor c=2.13263e-17
C61 (\4\:CKbb VSS) capacitor c=1.87766e-17
C62 (\2\:CKb VSS) capacitor c=4.51675e-17
C63 (\9\:qbint VSS) capacitor c=1.98835e-17
C64 (\3\:n30 VSS) capacitor c=2.21739e-17
C65 (\2\:CK VSS) capacitor c=3.67984e-17
C66 (\2\:qbint VSS) capacitor c=4.99109e-17
C67 (\4\:SEb VSS) capacitor c=1.23602e-17
C68 (\1\:VDD VSS) capacitor c=4.68593e-17
C69 (\7\:Db VSS) capacitor c=3.43315e-17
C70 (\12\:VDD VSS) capacitor c=4.29469e-17
C71 (\9\:CKbb VSS) capacitor c=7.95348e-17
C72 (\5\:Db VSS) capacitor c=1.09414e-16
C73 (\4\:n20 VSS) capacitor c=4.32489e-17
C74 (\14\:VDD VSS) capacitor c=1.65537e-17
C75 (\8\:mout VSS) capacitor c=3.6921e-17
C76 (\4\:n30 VSS) capacitor c=7.094e-17
C77 (\16\:VDD VSS) capacitor c=1.53345e-17
C78 (\15\:qbint VSS) capacitor c=3.90254e-17
C79 (\15\:CKb VSS) capacitor c=1.2605e-16
C80 (\18\:VDD VSS) capacitor c=3.82632e-17
C81 (\3\:Q VSS) capacitor c=6.3324e-17
C82 (\5\:net367 VSS) capacitor c=3.13346e-17
C83 (\20\:VDD VSS) capacitor c=4.02008e-17
C84 (\1\:QN VSS) capacitor c=3.12819e-17
C85 (\3\:VDD VSS) capacitor c=7.99951e-17
C86 (\8\:SEb VSS) capacitor c=5.45833e-17
C87 (\15\:CKbb VSS) capacitor c=5.45501e-17
C88 (\9\:Db VSS) capacitor c=7.10898e-17
C89 (\8\:n20 VSS) capacitor c=5.71774e-17
C90 (\6\:mout VSS) capacitor c=4.87211e-17
C91 (\8\:n30 VSS) capacitor c=2.80569e-17
C92 (\13\:qbint VSS) capacitor c=1.05693e-16
C93 (\18\:CKb VSS) capacitor c=5.32493e-17
C94 (\1\:Q VSS) capacitor c=3.92343e-17
C95 (\9\:net367 VSS) capacitor c=2.85092e-17
C96 (\3\:QN VSS) capacitor c=4.02291e-17
C97 (\2\:net367 VSS) capacitor c=1.25223e-17
C98 (\3\:qbint VSS) capacitor c=3.79079e-17
C99 (\8\:qbint VSS) capacitor c=3.74984e-17
C100 (\2\:CKbb VSS) capacitor c=3.12161e-17
C101 (\6\:CKb VSS) capacitor c=6.49303e-17
C102 (\7\:CKb VSS) capacitor c=6.73676e-17
C103 (\6\:SE VSS) capacitor c=3.26717e-17
C104 (\7\:net367 VSS) capacitor c=3.02117e-17
C105 (\8\:net367 VSS) capacitor c=3.1224e-17
C106 (\4\:CK VSS) capacitor c=2.90755e-17
C107 (\11\:qbint VSS) capacitor c=3.92542e-17
C108 (\12\:qbint VSS) capacitor c=4.83321e-17
C109 (\17\:qbint VSS) capacitor c=8.63322e-17
C110 (\6\:n30 VSS) capacitor c=1.10895e-16
C111 (\7\:n30 VSS) capacitor c=1.18795e-16
C112 (\4\:mout VSS) capacitor c=5.6763e-17
C113 (\5\:mout VSS) capacitor c=6.26061e-17
C114 (\12\:CKb VSS) capacitor c=5.91086e-17
C115 (\13\:CKb VSS) capacitor c=7.09322e-17
C116 (\14\:CKb VSS) capacitor c=1.17965e-16
C117 (\17\:CKb VSS) capacitor c=6.09857e-17
C118 (\6\:n20 VSS) capacitor c=6.30166e-17
C119 (\7\:n20 VSS) capacitor c=5.81481e-17
C120 (\11\:CKbb VSS) capacitor c=1.41471e-16
C121 (\12\:CKbb VSS) capacitor c=6.52376e-17
C122 (\13\:CKbb VSS) capacitor c=1.20238e-16
C123 (\14\:CKbb VSS) capacitor c=1.21086e-16
C124 (\4\:D VSS) capacitor c=4.65936e-17
C125 (\3\:Db VSS) capacitor c=1.442e-16
C126 (\9\:SE VSS) capacitor c=5.57636e-17
C127 (\10\:SE VSS) capacitor c=4.92447e-17
C128 (\11\:SE VSS) capacitor c=5.42212e-17
C129 (\4\:SI VSS) capacitor c=7.25074e-17
C130 (\6\:SEb VSS) capacitor c=6.7712e-17
C131 (\7\:SEb VSS) capacitor c=7.17069e-17
C132 (\5\:VDD VSS) capacitor c=2.34436e-17
C133 (\6\:VDD VSS) capacitor c=4.20575e-17
C134 (\8\:VDD VSS) capacitor c=2.74127e-17
C135 (\9\:VDD VSS) capacitor c=1.66942e-17
C136 (\11\:VDD VSS) capacitor c=1.05767e-17
Rk8 (\4\:CK CK) resistor r=0.05411 c=0
Rk2 (\4\:QN QN) resistor r=0.04898 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2343 c=0
Rk39 (\10\:SE SE) resistor r=0.08741 c=0
Rk38 (\9\:SE \10\:SE) resistor r=0.162 c=0
Rk40 (SE \11\:SE) resistor r=0.234 c=0
Rk41 (\4\:SI SI) resistor r=0.07108 c=0
Rk64 (\2\:VDD \4\:VDD) resistor r=0.6023 c=0
Rk65 (\4\:VDD \5\:VDD) resistor r=0.06993 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=0.5581 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.2728 c=0
Rk68 (\7\:VDD \8\:VDD) resistor r=0.3104 c=0
Rk69 (\8\:VDD \9\:VDD) resistor r=0.4454 c=0
Rk70 (\9\:VDD \10\:VDD) resistor r=0.09497 c=0
Rk72 (\11\:VDD VDD) resistor r=0.2024 c=0
Rk71 (\10\:VDD \11\:VDD) resistor r=0.2978 c=0
Rk73 (\5\:VDD \13\:VDD) resistor r=0.2676 c=0
Rk74 (\6\:VDD \15\:VDD) resistor r=0.07323 c=0
Rk75 (\8\:VDD \17\:VDD) resistor r=0.1018 c=0
Rk76 (\9\:VDD \19\:VDD) resistor r=0.2934 c=0
Rk77 (\11\:VDD \21\:VDD) resistor r=0.4145 c=0
Rk32 (\4\:D D) resistor r=0.07554 c=0
Rk6 (\2\:Q Q) resistor r=0.1433 c=0
Rk7 (Q \4\:Q) resistor r=0.2901 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.1451 c=0
Rk46 (\3\:VSS \4\:VSS) resistor r=0.1551 c=0
Rk47 (\4\:VSS \5\:VSS) resistor r=0.2452 c=0
Rk48 (\5\:VSS \6\:VSS) resistor r=0.2553 c=0
Rk49 (\6\:VSS \7\:VSS) resistor r=0.3129 c=0
Rk50 (\7\:VSS \8\:VSS) resistor r=0.2878 c=0
Rk51 (\8\:VSS \9\:VSS) resistor r=0.2953 c=0
Rk52 (\9\:VSS \10\:VSS) resistor r=0.2553 c=0
Rk53 (\10\:VSS \11\:VSS) resistor r=0.2252 c=0
Rk54 (\11\:VSS \12\:VSS) resistor r=0.1751 c=0
Rk55 (\12\:VSS \13\:VSS) resistor r=0.1826 c=0
Rk57 (\14\:VSS VSS) resistor r=0.09993 c=0
Rk56 (\13\:VSS \14\:VSS) resistor r=0.1175 c=0
Rk58 (\3\:VSS \16\:VSS) resistor r=0.2646 c=0
Rk59 (\5\:VSS \18\:VSS) resistor r=0.268 c=0
Rk60 (\7\:VSS \20\:VSS) resistor r=0.1217 c=0
Rk61 (\9\:VSS \22\:VSS) resistor r=0.3264 c=0
Rk62 (\11\:VSS \24\:VSS) resistor r=0.07323 c=0
Rk63 (\13\:VSS \26\:VSS) resistor r=0.07323 c=0
Rk3 (\6\:net367 \7\:net367) resistor r=0.09342 c=0
Rk4 (\7\:net367 \8\:net367) resistor r=0.1189 c=0
Rk5 (\7\:net367 \10\:net367) resistor r=0.1293 c=0
Rk9 (\11\:qbint \12\:qbint) resistor r=0.2207 c=0
Rk10 (\12\:qbint \14\:qbint) resistor r=0.2138 c=0
Rk11 (\12\:qbint \16\:qbint) resistor r=0.2044 c=0
Rk12 (\14\:qbint \17\:qbint) resistor r=0.7123 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.4487 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.3722 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.7611 c=0
Rk22 (\14\:CKb \17\:CKb) resistor r=0.3257 c=0
Rk23 (\16\:CKb \19\:CKb) resistor r=0.3872 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.4337 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.6752 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.1079 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.2657 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1475 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.2912 c=0
Rk27 (\10\:CKbb \11\:CKbb) resistor r=0.5807 c=0
Rk28 (\11\:CKbb \12\:CKbb) resistor r=0.3773 c=0
Rk29 (\12\:CKbb \13\:CKbb) resistor r=0.2249 c=0
Rk30 (\13\:CKbb \14\:CKbb) resistor r=0.8335 c=0
Rk31 (\12\:CKbb \16\:CKbb) resistor r=0.2712 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.1962 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.3021 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.2447 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.6712 c=0
Rk34 (\3\:Db \4\:Db) resistor r=0.4324 c=0
Rk35 (\4\:Db \6\:Db) resistor r=0.04625 c=0
Rk36 (\3\:Db \8\:Db) resistor r=0.2375 c=0
Rk37 (\4\:Db \10\:Db) resistor r=0.3945 c=0
Rk42 (\5\:SEb \6\:SEb) resistor r=0.07366 c=0
Rk43 (\6\:SEb \7\:SEb) resistor r=0.3518 c=0
Rk44 (\6\:SEb \9\:SEb) resistor r=0.4576 c=0
Rl9 (\1\:CK \2\:CK) resistor r=51.1559 c=0
Rl10 (\2\:CK \3\:CK) resistor r=93.4636 c=0
Rl38 (\3\:SE \4\:SE) resistor r=39.1533 c=0
Rl35 (\1\:SE \2\:SE) resistor r=54.5379 c=0
Rl41 (\5\:SE \6\:SE) resistor r=179.649 c=0
Rl43 (\6\:SE \8\:SE) resistor r=46.9565 c=0
Rl42 (\6\:SE \7\:SE) resistor r=1.2301 c=0
Rl40 (\2\:SI \3\:SI) resistor r=97.3098 c=0
Rl39 (\1\:SI \2\:SI) resistor r=110.771 c=0
Rl34 (\2\:D \3\:D) resistor r=96.8221 c=0
Rl33 (\1\:D \2\:D) resistor r=141.129 c=0
Rl1 (net367 \2\:net367) resistor r=2.0213 c=0
Rl3 (\2\:net367 \4\:net367) resistor r=34.3295 c=0
Rl2 (\2\:net367 \3\:net367) resistor r=49.7141 c=0
Rl4 (qbint \2\:qbint) resistor r=114.502 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=53.0797 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=35.772 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=212.376 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=84.3295 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=86.2526 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=4.3144 c=0
Rl32 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl16 (CKb \2\:CKb) resistor r=76.1559 c=0
Rl30 (\6\:CKb \9\:CKb) resistor r=159.297 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=78.8241 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=203.39 c=0
Rl31 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=200.39 c=0
Rl11 (n30 \2\:n30) resistor r=180.616 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl23 (mout \2\:mout) resistor r=123.769 c=0
Rl24 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl26 (\7\:CKbb \8\:CKbb) resistor r=66.0764 c=0
Rl25 (\5\:CKbb \6\:CKbb) resistor r=35.3072 c=0
Rl17 (CKbb \2\:CKbb) resistor r=33.3555 c=0
Rl18 (\2\:CKbb \3\:CKbb) resistor r=133.001 c=0
Rl19 (\2\:CKbb \4\:CKbb) resistor r=9.7447 c=0
Rl21 (n20 \2\:n20) resistor r=58.7903 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=87.6365 c=0
Rl36 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=193.351 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz19 (\3\:VDD \4\:VDD) resistor r=6.25 c=0
Rz20 (\3\:VDD \7\:VDD) resistor r=12.5 c=0
Rz21 (\3\:VDD \10\:VDD) resistor r=6.8182 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz13 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz15 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz16 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz17 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz18 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz2 (\9\:net367 \10\:net367) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz7 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\9\:Db \10\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry20 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry21 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry22 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry23 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry13 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry14 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry15 (\1\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry16 (\1\:VSS \8\:VSS) resistor r=10.3333 c=0
Ry17 (\1\:VSS \10\:VSS) resistor r=12.4 c=0
Ry18 (\1\:VSS \12\:VSS) resistor r=20.6667 c=0
Ry19 (\1\:VSS \14\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:net367 \6\:net367) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry7 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\5\:Db \6\:Db) resistor r=62 c=0
Ry11 (\7\:Db \8\:Db) resistor r=62 c=0
Ry12 (\4\:SEb \5\:SEb) resistor r=62 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\7\:SE \9\:SE) resistor r=45 c=0
Rx16 (\4\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SE \11\:SE) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (net367 \8\:net367) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx7 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx8 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\3\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\8\:CKbb \11\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:net367 \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.393e-14 ps=1.62e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net367 \4\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=2.03e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\18\:CKb \3\:CK \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=3.19e-14 ps=1.58e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.2e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn45 (\13\:qbint \2\:n30 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.625e-14 ad=2.828e-14 ps=7.9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=2e-06 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn50 (net436 \10\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.625e-14 ad=1.958e-14 ps=7.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.8e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (\8\:n30 CKb net436 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.62e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn40 (\8\:n30 CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=3.045e-14 ps=1.07e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.365e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn30 (\6\:mout \3\:n20 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.67e-14 ad=5.655e-14 ps=1.31e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=9.3e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn35 (net429 \3\:mout \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.67e-14 ad=8.7e-15 ps=1.31e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=6.65e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn36 (\8\:n20 \5\:CKbb net429 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=5.6e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn25 (\8\:n20 \10\:CKb \9\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.9e-14 ps=9.2e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.975e-06 sb=3.15e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn21 (\15\:CKbb \5\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net449 \1\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.48e-14 ps=6.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb net449 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE net461 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=4.5e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net461 \1\:SI \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\8\:SEb \8\:SE \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp56 (\5\:net367 \6\:qbint \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.773e-14 ps=7.5e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp20 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp45 (\15\:qbint n30 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=3.01e-14 ps=1.58e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp50 (net376 \7\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.99e-14 ad=7.203e-14 ps=1.58e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.74e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\4\:n20 \8\:CKb net356 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.73e-14 ps=5.7e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=4.9e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\4\:n30 \3\:CKbb net376 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.36e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=3.44e-14 ps=9.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.155e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=5.16e-14 ps=1.58e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=8.7e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (net356 mout \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=1.505e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=6.05e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.73e-14 ps=8.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=2.25e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp21 (\9\:CKbb \9\:CKb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp11 (net384 \3\:D \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.763e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.9e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp12 (\7\:Db \1\:SE net384 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.7e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp14 (\7\:Db SEb net392 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=5.65e-07 sd=160n sca=11.4714 \
        scb=0.00922898 scc=0.00018799 m=(1)
mp13 (net392 \3\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=2.903e-14 ps=8.3e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=3.85e-07 sd=160n sca=12.2443 \
        scb=0.00977105 scc=0.000188654 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.01e-14 ps=8.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=15.1631 \
        scb=0.0142072 scc=0.000247556 m=(1)
ends SDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:51:09 2012 )
// Library name: gsclib045
// Cell name: SEDFFHQX1
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX1 CK D E Q SE SI VDD VSS
mp0 (\7\:Eb \1\:E \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0405e-13 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.545e-06 sd=160n sca=26.4132 \
        scb=0.0275127 scc=0.00222015 m=(1)
C1 (SI VSS) capacitor c=8.33581e-17
C2 (SE VSS) capacitor c=6.9948e-17
C3 (VDD VSS) capacitor c=3.96e-16
C4 (E VSS) capacitor c=9.30348e-17
C5 (CK VSS) capacitor c=5.6511e-17
C6 (Q VSS) capacitor c=4.2817e-17
C7 (Eb VSS) capacitor c=4.01347e-17
C8 (net526 VSS) capacitor c=3.75784e-18
C9 (Db VSS) capacitor c=1.03464e-16
C10 (net494 VSS) capacitor c=4.20351e-18
C11 (qint VSS) capacitor c=5.93761e-17
C12 (SEb VSS) capacitor c=2.9895e-17
C13 (Dbp VSS) capacitor c=9.7991e-17
C14 (net518 VSS) capacitor c=1.38086e-18
C15 (qbint VSS) capacitor c=2.74381e-17
C16 (n30 VSS) capacitor c=3.85024e-17
C17 (net509 VSS) capacitor c=1.73553e-18
C18 (CKb VSS) capacitor c=7.61059e-17
C19 (mout VSS) capacitor c=5.79774e-17
C20 (Ckbb VSS) capacitor c=4.73588e-17
C21 (n20 VSS) capacitor c=3.85894e-17
C22 (net501 VSS) capacitor c=3.07124e-18
C23 (net449 VSS) capacitor c=6.3857e-18
C24 (net405 VSS) capacitor c=4.25424e-18
C25 (net441 VSS) capacitor c=2.81703e-19
C26 (net426 VSS) capacitor c=3.30932e-18
C27 (net417 VSS) capacitor c=1.17958e-18
C28 (\1\:CK VSS) capacitor c=4.19391e-17
C29 (\6\:CKb VSS) capacitor c=3.63943e-17
C30 (\5\:Ckbb VSS) capacitor c=3.49737e-17
C31 (\4\:CKb VSS) capacitor c=7.87415e-17
C32 (\3\:mout VSS) capacitor c=8.66261e-17
C33 (\3\:n20 VSS) capacitor c=4.18743e-17
C34 (\2\:CKb VSS) capacitor c=4.72605e-17
C35 (\2\:Ckbb VSS) capacitor c=4.333e-17
C36 (\12\:qbint VSS) capacitor c=5.05913e-17
C37 (\7\:qbint VSS) capacitor c=2.72994e-17
C38 (\8\:qbint VSS) capacitor c=2.07465e-17
C39 (\1\:SI VSS) capacitor c=8.60538e-17
C40 (\3\:SEb VSS) capacitor c=6.32553e-17
C41 (\5\:SE VSS) capacitor c=2.31741e-17
C42 (\4\:SE VSS) capacitor c=2.48494e-17
C43 (\3\:qint VSS) capacitor c=4.28503e-17
C44 (\4\:E VSS) capacitor c=6.91489e-17
C45 (\1\:D VSS) capacitor c=4.94058e-17
C46 (\1\:E VSS) capacitor c=3.77108e-17
C47 (\3\:CK VSS) capacitor c=3.83046e-17
C48 (\10\:CKb VSS) capacitor c=2.57305e-17
C49 (\8\:CKb VSS) capacitor c=4.3546e-17
C50 (\7\:Ckbb VSS) capacitor c=5.0682e-17
C51 (\3\:Ckbb VSS) capacitor c=4.23822e-17
C52 (\9\:qbint VSS) capacitor c=5.31398e-17
C53 (\3\:n30 VSS) capacitor c=4.70651e-17
C54 (\6\:qbint VSS) capacitor c=2.51533e-17
C55 (\5\:qbint VSS) capacitor c=2.26191e-17
C56 (\3\:SI VSS) capacitor c=5.89623e-17
C57 (\1\:SE VSS) capacitor c=1.01651e-16
C58 (\6\:SE VSS) capacitor c=3.15848e-17
C59 (\3\:Eb VSS) capacitor c=4.6715e-17
C60 (\6\:E VSS) capacitor c=3.42617e-17
C61 (\3\:D VSS) capacitor c=5.15981e-17
C62 (\3\:E VSS) capacitor c=2.14837e-17
C63 (\2\:CK VSS) capacitor c=5.84323e-17
C64 (\9\:CKb VSS) capacitor c=2.39796e-17
C65 (\5\:CKb VSS) capacitor c=2.68646e-17
C66 (\2\:mout VSS) capacitor c=4.28568e-17
C67 (\2\:n20 VSS) capacitor c=4.50491e-17
C68 (\4\:Ckbb VSS) capacitor c=3.88652e-17
C69 (\3\:CKb VSS) capacitor c=2.23522e-17
C70 (\11\:qbint VSS) capacitor c=2.64902e-17
C71 (\2\:n30 VSS) capacitor c=3.95179e-17
C72 (\4\:SI VSS) capacitor c=1.47478e-17
C73 (\4\:SEb VSS) capacitor c=4.68406e-17
C74 (\2\:SEb VSS) capacitor c=3.74795e-17
C75 (\3\:SE VSS) capacitor c=3.66649e-17
C76 (\2\:qint VSS) capacitor c=4.05305e-17
C77 (\4\:Eb VSS) capacitor c=3.39385e-17
C78 (\5\:E VSS) capacitor c=5.53449e-17
C79 (\2\:Eb VSS) capacitor c=3.9782e-17
C80 (\2\:D VSS) capacitor c=4.66073e-17
C81 (\2\:E VSS) capacitor c=2.60876e-17
C82 (\11\:CKb VSS) capacitor c=4.23638e-17
C83 (\13\:VDD VSS) capacitor c=4.80543e-17
C84 (\11\:Ckbb VSS) capacitor c=1.36472e-16
C85 (\8\:n20 VSS) capacitor c=3.66301e-17
C86 (\15\:VDD VSS) capacitor c=2.99834e-17
C87 (\8\:mout VSS) capacitor c=6.85147e-17
C88 (\8\:n30 VSS) capacitor c=4.75258e-17
C89 (\17\:VDD VSS) capacitor c=4.60722e-17
C90 (\17\:qbint VSS) capacitor c=5.37267e-17
C91 (\4\:Q VSS) capacitor c=7.62858e-17
C92 (\19\:VDD VSS) capacitor c=7.57404e-17
C93 (\4\:qint VSS) capacitor c=2.57565e-16
C94 (\21\:VDD VSS) capacitor c=4.29506e-17
C95 (\7\:Dbp VSS) capacitor c=1.01028e-16
C96 (\7\:SEb VSS) capacitor c=1.15422e-16
C97 (\23\:VDD VSS) capacitor c=5.92159e-17
C98 (\7\:Db VSS) capacitor c=9.02034e-17
C99 (\25\:VDD VSS) capacitor c=3.27871e-17
C100 (\7\:Eb VSS) capacitor c=7.09163e-17
C101 (\1\:VDD VSS) capacitor c=9.59551e-17
C102 (\15\:CKb VSS) capacitor c=4.86695e-17
C103 (\15\:Ckbb VSS) capacitor c=1.30472e-16
C104 (\3\:Dbp VSS) capacitor c=3.30506e-16
C105 (\4\:n20 VSS) capacitor c=7.58485e-17
C106 (\6\:mout VSS) capacitor c=3.32085e-17
C107 (\4\:n30 VSS) capacitor c=8.38216e-17
C108 (\15\:qbint VSS) capacitor c=3.64901e-17
C109 (\1\:Q VSS) capacitor c=2.89401e-17
C110 (\7\:qint VSS) capacitor c=5.25313e-17
C111 (\5\:Dbp VSS) capacitor c=3.23013e-16
C112 (\3\:Db VSS) capacitor c=1.76807e-16
C113 (\10\:SEb VSS) capacitor c=9.5981e-17
C114 (\5\:Db VSS) capacitor c=1.49175e-16
C115 (\5\:Eb VSS) capacitor c=6.73052e-17
C116 (\2\:SE VSS) capacitor c=5.50593e-17
C117 (\2\:SI VSS) capacitor c=3.6725e-17
C118 (\2\:qbint VSS) capacitor c=8.31021e-18
C119 (\3\:qbint VSS) capacitor c=1.03908e-17
C120 (\4\:qbint VSS) capacitor c=1.28019e-17
C121 (\10\:qbint VSS) capacitor c=2.20439e-17
C122 (\6\:Ckbb VSS) capacitor c=2.95931e-17
C123 (\4\:D VSS) capacitor c=1.15204e-16
C124 (\7\:E VSS) capacitor c=8.06052e-17
C125 (\7\:CKb VSS) capacitor c=3.70883e-17
C126 (\9\:Eb VSS) capacitor c=1.15809e-16
C127 (\10\:Eb VSS) capacitor c=4.9586e-17
C128 (\11\:Eb VSS) capacitor c=1.24666e-16
C129 (\7\:SE VSS) capacitor c=4.05386e-17
C130 (\5\:SEb VSS) capacitor c=7.84475e-17
C131 (\6\:SEb VSS) capacitor c=1.42553e-16
C132 (\9\:SEb VSS) capacitor c=8.06568e-17
C133 (\5\:SI VSS) capacitor c=3.27684e-17
C134 (\6\:qint VSS) capacitor c=2.38946e-16
C135 (\3\:Q VSS) capacitor c=4.11318e-17
C136 (\13\:qbint VSS) capacitor c=5.363e-17
C137 (\14\:qbint VSS) capacitor c=6.5922e-17
C138 (\6\:n30 VSS) capacitor c=8.53655e-17
C139 (\7\:n30 VSS) capacitor c=5.54472e-17
C140 (\4\:mout VSS) capacitor c=5.46822e-17
C141 (\5\:mout VSS) capacitor c=5.01515e-17
C142 (\6\:n20 VSS) capacitor c=6.05009e-17
C143 (\7\:n20 VSS) capacitor c=5.42907e-17
C144 (\9\:Ckbb VSS) capacitor c=5.66842e-17
C145 (\10\:Ckbb VSS) capacitor c=1.52054e-16
C146 (\13\:Ckbb VSS) capacitor c=1.49924e-16
C147 (\14\:Ckbb VSS) capacitor c=4.43281e-17
C148 (\4\:CK VSS) capacitor c=3.51618e-17
C149 (\13\:CKb VSS) capacitor c=1.66493e-16
C150 (\14\:CKb VSS) capacitor c=8.97538e-17
C151 (\17\:CKb VSS) capacitor c=1.76325e-16
C152 (\18\:CKb VSS) capacitor c=7.56731e-17
C153 (\3\:VDD VSS) capacitor c=4.3184e-17
C154 (\5\:VDD VSS) capacitor c=2.98505e-17
C155 (\6\:VDD VSS) capacitor c=3.81892e-17
C156 (\7\:VDD VSS) capacitor c=1.16343e-17
C157 (\9\:VDD VSS) capacitor c=4.1872e-17
C158 (\10\:VDD VSS) capacitor c=4.07163e-17
C159 (\12\:VDD VSS) capacitor c=1.30662e-17
Rk1 (D \4\:D) resistor r=0.003212 c=0
Rk16 (\5\:SI SI) resistor r=0.1334 c=0
Rk67 (\2\:VSS \3\:VSS) resistor r=0.1152 c=0
Rk68 (\3\:VSS \4\:VSS) resistor r=0.336 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.1754 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.5114 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.2657 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.1293 c=0
Rk73 (\8\:VSS \9\:VSS) resistor r=0.3072 c=0
Rk74 (\9\:VSS \10\:VSS) resistor r=0.6167 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.1478 c=0
Rk77 (\12\:VSS VSS) resistor r=0.278 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.2732 c=0
Rk78 (\3\:VSS \14\:VSS) resistor r=0.1809 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.1632 c=0
Rk80 (\6\:VSS \18\:VSS) resistor r=0.1632 c=0
Rk81 (\8\:VSS \20\:VSS) resistor r=0.04333 c=0
Rk82 (\9\:VSS \22\:VSS) resistor r=0.2216 c=0
Rk83 (\10\:VSS \24\:VSS) resistor r=0.2016 c=0
Rk84 (\12\:VSS \26\:VSS) resistor r=0.2048 c=0
Rk8 (\7\:SE SE) resistor r=0.13 c=0
Rk49 (\2\:VDD \3\:VDD) resistor r=0.1117 c=0
Rk50 (\3\:VDD \4\:VDD) resistor r=0.5382 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.08164 c=0
Rk52 (\5\:VDD \6\:VDD) resistor r=0.5004 c=0
Rk53 (\6\:VDD \7\:VDD) resistor r=0.3634 c=0
Rk54 (\7\:VDD \8\:VDD) resistor r=0.05499 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.1528 c=0
Rk56 (\9\:VDD \10\:VDD) resistor r=0.7121 c=0
Rk57 (\10\:VDD \11\:VDD) resistor r=0.1378 c=0
Rk59 (\12\:VDD VDD) resistor r=0.278 c=0
Rk58 (\11\:VDD \12\:VDD) resistor r=0.2732 c=0
Rk60 (\3\:VDD \14\:VDD) resistor r=0.1286 c=0
Rk61 (\5\:VDD \16\:VDD) resistor r=0.04333 c=0
Rk62 (\6\:VDD \18\:VDD) resistor r=0.3154 c=0
Rk63 (\7\:VDD \20\:VDD) resistor r=0.4456 c=0
Rk64 (\9\:VDD \22\:VDD) resistor r=0.2566 c=0
Rk65 (\10\:VDD \24\:VDD) resistor r=0.2827 c=0
Rk66 (\12\:VDD \26\:VDD) resistor r=0.2518 c=0
Rk3 (\8\:E E) resistor r=0.004287 c=0
Rk2 (\7\:E \8\:E) resistor r=0.5742 c=0
Rk43 (CK \4\:CK) resistor r=0.1112 c=0
Rk20 (\3\:Q Q) resistor r=0.1692 c=0
Rk19 (\2\:Q \3\:Q) resistor r=0.1225 c=0
Rk21 (\3\:Q \5\:Q) resistor r=0.2854 c=0
Rk4 (\6\:Eb \8\:Eb) resistor r=0.548 c=0
Rk5 (\8\:Eb \9\:Eb) resistor r=0.4272 c=0
Rk6 (\9\:Eb \10\:Eb) resistor r=0.1752 c=0
Rk7 (\9\:Eb \11\:Eb) resistor r=0.7856 c=0
Rk9 (\2\:Db \4\:Db) resistor r=0.585 c=0
Rk10 (\4\:Db \6\:Db) resistor r=0.8979 c=0
Rk11 (\6\:Db \8\:Db) resistor r=0.4397 c=0
Rk17 (\5\:qint \6\:qint) resistor r=1.9244 c=0
Rk18 (\5\:qint \8\:qint) resistor r=0.2673 c=0
Rk12 (\5\:SEb \6\:SEb) resistor r=0.5176 c=0
Rk13 (\6\:SEb \8\:SEb) resistor r=0.4142 c=0
Rk14 (\6\:SEb \9\:SEb) resistor r=0.3774 c=0
Rk15 (\8\:SEb \11\:SEb) resistor r=0.5281 c=0
Rk34 (\2\:Dbp \4\:Dbp) resistor r=0.4211 c=0
Rk35 (\4\:Dbp \6\:Dbp) resistor r=2.5236 c=0
Rk36 (\6\:Dbp \8\:Dbp) resistor r=0.3891 c=0
Rk22 (\13\:qbint \14\:qbint) resistor r=0.2652 c=0
Rk23 (\14\:qbint \16\:qbint) resistor r=0.1484 c=0
Rk24 (\14\:qbint \18\:qbint) resistor r=0.3029 c=0
Rk25 (\5\:n30 \6\:n30) resistor r=0.5183 c=0
Rk26 (\6\:n30 \7\:n30) resistor r=0.2668 c=0
Rk27 (\6\:n30 \9\:n30) resistor r=0.2781 c=0
Rk44 (\12\:CKb \13\:CKb) resistor r=0.2948 c=0
Rk45 (\13\:CKb \14\:CKb) resistor r=0.6009 c=0
Rk46 (\14\:CKb \16\:CKb) resistor r=0.2778 c=0
Rk47 (\13\:CKb \17\:CKb) resistor r=0.8113 c=0
Rk48 (\17\:CKb \18\:CKb) resistor r=0.6058 c=0
Rk28 (\4\:mout \5\:mout) resistor r=0.2704 c=0
Rk29 (\5\:mout \7\:mout) resistor r=0.06976 c=0
Rk30 (\5\:mout \9\:mout) resistor r=0.2704 c=0
Rk37 (\9\:Ckbb \10\:Ckbb) resistor r=0.2388 c=0
Rk38 (\10\:Ckbb \12\:Ckbb) resistor r=0.3582 c=0
Rk39 (\10\:Ckbb \13\:Ckbb) resistor r=0.9467 c=0
Rk40 (\13\:Ckbb \14\:Ckbb) resistor r=0.1615 c=0
Rk41 (\12\:Ckbb \16\:Ckbb) resistor r=0.7527 c=0
Rk42 (\13\:Ckbb \17\:Ckbb) resistor r=0.0463 c=0
Rk31 (\5\:n20 \6\:n20) resistor r=0.439 c=0
Rk32 (\6\:n20 \7\:n20) resistor r=0.2704 c=0
Rk33 (\6\:n20 \9\:n20) resistor r=0.07077 c=0
Rl3 (\1\:D \2\:D) resistor r=33.8482 c=0
Rl4 (\2\:D \3\:D) resistor r=106.925 c=0
Rl18 (\1\:SI \2\:SI) resistor r=86.2409 c=0
Rl19 (\2\:SI \3\:SI) resistor r=63.9053 c=0
Rl20 (\2\:SI \4\:SI) resistor r=4.5264 c=0
Rl14 (\3\:SE \4\:SE) resistor r=35.3482 c=0
Rl16 (\3\:SE \6\:SE) resistor r=99.7951 c=0
Rl15 (\2\:SE \5\:SE) resistor r=32.3738 c=0
Rl12 (\1\:SE \2\:SE) resistor r=216.851 c=0
Rl13 (\2\:SE \3\:SE) resistor r=146.543 c=0
Rl6 (\4\:E \5\:E) resistor r=177.966 c=0
Rl7 (\5\:E \6\:E) resistor r=24.2328 c=0
Rl1 (\1\:E \2\:E) resistor r=111.538 c=0
Rl2 (\2\:E \3\:E) resistor r=33.7912 c=0
Rl49 (\1\:CK \2\:CK) resistor r=214.129 c=0
Rl50 (\2\:CK \3\:CK) resistor r=101.374 c=0
Rl8 (\3\:Eb \4\:Eb) resistor r=33.8482 c=0
Rl5 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl9 (qint \2\:qint) resistor r=108.883 c=0
Rl10 (\2\:qint \3\:qint) resistor r=35.989 c=0
Rl17 (\3\:SEb \4\:SEb) resistor r=29.5379 c=0
Rl11 (SEb \2\:SEb) resistor r=54.5379 c=0
Rl21 (qbint \2\:qbint) resistor r=83.8288 c=0
Rl25 (\2\:qbint \6\:qbint) resistor r=30.4507 c=0
Rl26 (\3\:qbint \7\:qbint) resistor r=47.7584 c=0
Rl22 (\2\:qbint \3\:qbint) resistor r=19.6209 c=0
Rl27 (\4\:qbint \8\:qbint) resistor r=53.0797 c=0
Rl24 (\4\:qbint \5\:qbint) resistor r=35.772 c=0
Rl23 (\3\:qbint \4\:qbint) resistor r=70.0689 c=0
Rl32 (\10\:qbint \12\:qbint) resistor r=71.8171 c=0
Rl30 (\9\:qbint \10\:qbint) resistor r=88.7699 c=0
Rl31 (\10\:qbint \11\:qbint) resistor r=5.8511 c=0
Rl28 (n30 \2\:n30) resistor r=29.5379 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=79.5379 c=0
Rl34 (CKb \2\:CKb) resistor r=136.104 c=0
Rl48 (\9\:CKb \10\:CKb) resistor r=39.1533 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=53.079 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl45 (\6\:CKb \7\:CKb) resistor r=185.772 c=0
Rl46 (\7\:CKb \8\:CKb) resistor r=177.349 c=0
Rl47 (\7\:CKb \9\:CKb) resistor r=80.6945 c=0
Rl39 (mout \2\:mout) resistor r=57.929 c=0
Rl40 (\2\:mout \3\:mout) resistor r=70.6854 c=0
Rl33 (Ckbb \2\:Ckbb) resistor r=34.6607 c=0
Rl36 (\3\:Ckbb \4\:Ckbb) resistor r=55.0021 c=0
Rl42 (\5\:Ckbb \6\:Ckbb) resistor r=38.8561 c=0
Rl43 (\6\:Ckbb \7\:Ckbb) resistor r=96.0468 c=0
Rl44 (\6\:Ckbb \8\:Ckbb) resistor r=2.9709 c=0
Rl37 (n20 \2\:n20) resistor r=72.3097 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=45.708 c=0
Rz19 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz25 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz15 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz16 (\1\:VDD \4\:VDD) resistor r=6.25 c=0
Rz17 (\1\:VDD \8\:VDD) resistor r=9.375 c=0
Rz18 (\1\:VDD \11\:VDD) resistor r=6.25 c=0
Rz6 (\1\:Q \2\:Q) resistor r=75 c=0
Rz1 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz2 (\3\:Db \4\:Db) resistor r=75 c=0
Rz3 (\5\:Db \6\:Db) resistor r=75 c=0
Rz5 (\7\:qint \8\:qint) resistor r=75 c=0
Rz4 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz11 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz12 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz7 (\15\:qbint \16\:qbint) resistor r=75 c=0
Rz8 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz14 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz9 (\6\:mout \7\:mout) resistor r=75 c=0
Rz13 (\15\:Ckbb \16\:Ckbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry24 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry25 (\1\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry15 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \20\:VDD) resistor r=31 c=0
Ry19 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry6 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry1 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry2 (Db \2\:Db) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry5 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry11 (Dbp \2\:Dbp) resistor r=62 c=0
Ry12 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry7 (\17\:qbint \18\:qbint) resistor r=31 c=0
Ry8 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry14 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry13 (\11\:Ckbb \12\:Ckbb) resistor r=62 c=0
Ry10 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\4\:SI \5\:SI) resistor r=45 c=0
Rx6 (\3\:SE \7\:SE) resistor r=45 c=0
Rx2 (\5\:E \7\:E) resistor r=45 c=0
Rx3 (\2\:E \8\:E) resistor r=45 c=0
Rx19 (\2\:CK \4\:CK) resistor r=45 c=0
Rx4 (\2\:Eb \10\:Eb) resistor r=45 c=0
Rx5 (\4\:Eb \11\:Eb) resistor r=45 c=0
Rx10 (\2\:qint \6\:qint) resistor r=45 c=0
Rx7 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx8 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx11 (\11\:qbint \13\:qbint) resistor r=45 c=0
Rx12 (qbint \14\:qbint) resistor r=45 c=0
Rx13 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\9\:CKb \14\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \17\:CKb) resistor r=45 c=0
Rx22 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\2\:mout \4\:mout) resistor r=45 c=0
Rx16 (\8\:Ckbb \9\:Ckbb) resistor r=45 c=0
Rx17 (Ckbb \14\:Ckbb) resistor r=45 c=0
Rx18 (\4\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx15 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\5\:Eb \3\:E \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.773e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.655e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (net526 \3\:D \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.773e-14 ad=4.29e-14 ps=1.37e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.02115e-07 sb=1.01692e-06 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn4 (\5\:Db \6\:E net526 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=5.98e-14 ps=8.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.12115e-07 sb=8.06923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2 (\5\:Db \3\:Eb net494 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=5.98e-14 ps=7.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.87115e-07 sb=5.31923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1 (net494 qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.468e-14 ad=3.51e-14 ps=1.19e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06712e-06 sb=3.51923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (\10\:SEb \6\:SE \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.468e-14 ad=2.03e-14 ps=1.19e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (\3\:Db SEb \5\:Dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.8e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(1)
mn13 (\5\:Dbp \1\:SE net518 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn12 (net518 \3\:SI \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn56 (\7\:qint \5\:qbint \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.285e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\1\:Q \6\:qbint \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.285e-14 ad=3.64e-14 ps=1.6e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55288e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn45 (\15\:qbint \3\:n30 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.278e-14 ad=3.895e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.87e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net509 \9\:qbint \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.278e-14 ad=2.87e-14 ps=1.51e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.51e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (\4\:n30 CKb net509 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.325e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\4\:n30 \3\:Ckbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.613e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.12e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (\6\:mout n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.278e-14 ad=4.613e-14 ps=1.51e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=8.5e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net501 mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.278e-14 ad=2.05e-14 ps=1.51e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=4.9e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn36 (\4\:n20 \7\:Ckbb net501 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=3.28e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=3.45e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn25 (\4\:n20 \8\:CKb \3\:Dbp VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn21 (\15\:Ckbb \10\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn20 (\15\:CKb \3\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp3 (net449 \1\:D \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0405e-13 ad=5.265e-14 ps=1.52e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.68782e-07 sb=9.61731e-07 sd=160n sca=16.8075 \
        scb=0.014774 scc=0.00118868 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.48782e-07 sb=7.81731e-07 sd=160n sca=16.3155 \
        scb=0.0145891 scc=0.00118861 m=(1)
mp2 (\7\:Db \4\:E net405 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.03782e-07 sb=5.26731e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp1 (net405 \3\:qint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.545e-14 ad=5.265e-14 ps=1.44e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.83782e-07 sb=3.46731e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp10 (\7\:SEb \4\:SE \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.545e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=1.4e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp11 (Db \5\:SE \7\:Dbp VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.404e-13 ad=5.46e-14 ps=1.5e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.48462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp13 (\7\:Dbp \3\:SEb net441 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.404e-13 ps=9e-07 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=2.43462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp12 (net441 \1\:SI \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.4e-14 ad=2.34e-14 ps=1.23e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.38462e-07 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp56 (\4\:qint \8\:qbint \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=3.58e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp55 (\4\:Q \7\:qbint \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.75256e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp45 (\17\:qbint n30 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=6.975e-14 ps=9.4e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.83e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp50 (net426 \12\:qbint \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.34e-14 ps=9.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.625e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp51 (\8\:n30 \2\:Ckbb net426 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.44e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp40 (\8\:n30 \2\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.023e-13 ad=4.96e-14 ps=1.28e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.235e-06 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp30 (\8\:mout \3\:n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=1.023e-13 ps=1.68e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=8.6e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp35 (net417 \3\:mout \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.054e-13 ad=1.86e-14 ps=1.68e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=5.95e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp36 (\8\:n20 \4\:CKb net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=4.9e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp25 (\8\:n20 \5\:Ckbb Dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.835e-14 ad=4.96e-14 ps=1.19e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=2.85e-07 sd=160n sca=14.8314 \
        scb=0.0138806 scc=0.000865287 m=(1)
mp21 (\11\:Ckbb \6\:CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.698e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.65e-07 sd=160n sca=12.1061 \
        scb=0.0090276 scc=8.48627e-05 m=(1)
mp20 (\11\:CKb \1\:CK \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.698e-14 ad=3.333e-14 ps=9.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.55e-07 sd=160n sca=21.8638 \
        scb=0.0242315 scc=0.00109598 m=(1)
ends SEDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:51:48 2012 )
// Library name: gsclib045
// Cell name: SEDFFHQX2
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX2 CK D E Q SE SI VDD VSS
mp0 (\7\:Eb \1\:E \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.36e-06 sd=160n sca=14.119 scb=0.012489 \
        scc=0.00033733 m=(1)
C1 (Q VSS) capacitor c=2.71092e-17
C2 (SI VSS) capacitor c=7.3163e-17
C3 (SE VSS) capacitor c=4.24832e-17
C4 (VDD VSS) capacitor c=4.04809e-16
C5 (E VSS) capacitor c=4.34356e-17
C6 (CK VSS) capacitor c=2.45567e-17
C7 (Eb VSS) capacitor c=6.3732e-17
C8 (net526 VSS) capacitor c=4.94823e-18
C9 (Db VSS) capacitor c=8.36712e-17
C10 (net494 VSS) capacitor c=3.18617e-18
C11 (qint VSS) capacitor c=3.48549e-17
C12 (SEb VSS) capacitor c=3.28945e-17
C13 (Dbp VSS) capacitor c=8.83774e-17
C14 (net518 VSS) capacitor c=1.39771e-18
C15 (qbint VSS) capacitor c=4.67325e-17
C16 (n30 VSS) capacitor c=4.45987e-17
C17 (net509 VSS) capacitor c=3.41934e-18
C18 (CKb VSS) capacitor c=7.44953e-17
C19 (mout VSS) capacitor c=4.38336e-17
C20 (Ckbb VSS) capacitor c=4.40393e-17
C21 (n20 VSS) capacitor c=4.38386e-17
C22 (net501 VSS) capacitor c=1.52067e-18
C23 (net449 VSS) capacitor c=1.88455e-18
C24 (net405 VSS) capacitor c=6.71218e-18
C25 (net441 VSS) capacitor c=1.64085e-18
C26 (net426 VSS) capacitor c=4.77205e-18
C27 (net417 VSS) capacitor c=1.2468e-18
C28 (\1\:CK VSS) capacitor c=3.29869e-17
C29 (\6\:CKb VSS) capacitor c=3.71782e-17
C30 (\5\:Ckbb VSS) capacitor c=3.66518e-17
C31 (\4\:CKb VSS) capacitor c=6.93193e-17
C32 (\3\:mout VSS) capacitor c=9.65807e-17
C33 (\3\:n20 VSS) capacitor c=5.63026e-17
C34 (\2\:CKb VSS) capacitor c=5.49416e-17
C35 (\16\:qbint VSS) capacitor c=5.2455e-17
C36 (\1\:SI VSS) capacitor c=5.40469e-17
C37 (\3\:SEb VSS) capacitor c=3.70834e-17
C38 (\5\:SE VSS) capacitor c=2.49952e-17
C39 (\6\:SE VSS) capacitor c=3.10452e-17
C40 (\4\:E VSS) capacitor c=6.50236e-17
C41 (\1\:D VSS) capacitor c=9.07561e-17
C42 (\1\:E VSS) capacitor c=5.12163e-17
C43 (\3\:CK VSS) capacitor c=4.87516e-17
C44 (\10\:CKb VSS) capacitor c=2.47325e-17
C45 (\8\:CKb VSS) capacitor c=4.61328e-17
C46 (\7\:Ckbb VSS) capacitor c=6.45916e-17
C47 (\3\:Ckbb VSS) capacitor c=3.63892e-17
C48 (\13\:qbint VSS) capacitor c=3.03858e-17
C49 (\3\:n30 VSS) capacitor c=4.80914e-17
C50 (\9\:qbint VSS) capacitor c=2.6332e-17
C51 (\3\:SI VSS) capacitor c=8.06407e-17
C52 (\1\:SE VSS) capacitor c=1.0269e-16
C53 (\4\:SE VSS) capacitor c=4.06514e-17
C54 (\3\:qint VSS) capacitor c=1.00244e-16
C55 (\3\:Eb VSS) capacitor c=5.75275e-17
C56 (\6\:E VSS) capacitor c=3.04652e-17
C57 (\3\:D VSS) capacitor c=6.22002e-17
C58 (\3\:E VSS) capacitor c=2.74337e-17
C59 (\4\:CK VSS) capacitor c=1.29561e-17
C60 (\9\:CKb VSS) capacitor c=1.8001e-17
C61 (\6\:Ckbb VSS) capacitor c=2.44477e-17
C62 (\5\:CKb VSS) capacitor c=3.00606e-17
C63 (\2\:mout VSS) capacitor c=5.08353e-17
C64 (\2\:n20 VSS) capacitor c=3.87493e-17
C65 (\4\:Ckbb VSS) capacitor c=4.00952e-17
C66 (\3\:CKb VSS) capacitor c=2.10798e-17
C67 (\2\:Ckbb VSS) capacitor c=4.10397e-17
C68 (\15\:qbint VSS) capacitor c=3.15783e-17
C69 (\2\:n30 VSS) capacitor c=3.81451e-17
C70 (\8\:qbint VSS) capacitor c=1.97316e-17
C71 (\4\:SI VSS) capacitor c=4.8285e-17
C72 (\4\:SEb VSS) capacitor c=4.7049e-17
C73 (\2\:SEb VSS) capacitor c=3.43092e-17
C74 (\3\:SE VSS) capacitor c=5.19647e-17
C75 (\2\:qint VSS) capacitor c=4.07048e-17
C76 (\4\:Eb VSS) capacitor c=4.52189e-17
C77 (\5\:E VSS) capacitor c=6.55633e-17
C78 (\2\:Eb VSS) capacitor c=3.47486e-17
C79 (\2\:D VSS) capacitor c=5.16385e-17
C80 (\2\:E VSS) capacitor c=4.1801e-17
C81 (\18\:CKb VSS) capacitor c=3.29229e-17
C82 (\1\:VDD VSS) capacitor c=4.54475e-17
C83 (\10\:Ckbb VSS) capacitor c=9.9596e-17
C84 (\8\:n20 VSS) capacitor c=4.29666e-17
C85 (\6\:VDD VSS) capacitor c=2.17824e-17
C86 (\4\:mout VSS) capacitor c=5.89092e-17
C87 (\8\:n30 VSS) capacitor c=5.96485e-17
C88 (\10\:VDD VSS) capacitor c=6.31225e-17
C89 (\21\:qbint VSS) capacitor c=4.91406e-17
C90 (\8\:qint VSS) capacitor c=1.70484e-17
C91 (\1\:Q VSS) capacitor c=6.54559e-17
C92 (\7\:Dbp VSS) capacitor c=9.26829e-17
C93 (\7\:SEb VSS) capacitor c=1.13331e-16
C94 (\21\:VDD VSS) capacitor c=6.873e-17
C95 (\7\:Db VSS) capacitor c=1.14182e-16
C96 (\25\:VDD VSS) capacitor c=2.75379e-17
C97 (\7\:Eb VSS) capacitor c=7.93259e-17
C98 (\3\:VDD VSS) capacitor c=1.60858e-16
C99 (\11\:CKb VSS) capacitor c=2.32527e-17
C100 (\14\:Ckbb VSS) capacitor c=1.0588e-16
C101 (\3\:Dbp VSS) capacitor c=3.82085e-16
C102 (\4\:n20 VSS) capacitor c=6.94567e-17
C103 (\7\:mout VSS) capacitor c=4.8312e-17
C104 (\4\:n30 VSS) capacitor c=8.72945e-17
C105 (\19\:qbint VSS) capacitor c=5.0292e-17
C106 (\6\:qint VSS) capacitor c=8.56957e-17
C107 (\3\:Q VSS) capacitor c=4.88174e-17
C108 (\5\:Dbp VSS) capacitor c=3.61582e-16
C109 (\3\:Db VSS) capacitor c=1.50737e-16
C110 (\10\:SEb VSS) capacitor c=8.63451e-17
C111 (\5\:Db VSS) capacitor c=1.70279e-16
C112 (\5\:Eb VSS) capacitor c=9.66609e-17
C113 (\2\:SE VSS) capacitor c=5.67641e-17
C114 (\2\:qbint VSS) capacitor c=1.19334e-17
C115 (\3\:qbint VSS) capacitor c=3.77736e-18
C116 (\4\:qbint VSS) capacitor c=1.41929e-16
C117 (\14\:qbint VSS) capacitor c=2.67523e-17
C118 (\4\:D VSS) capacitor c=9.70593e-17
C119 (\7\:E VSS) capacitor c=7.57951e-17
C120 (\8\:E VSS) capacitor c=7.20853e-17
C121 (\7\:CKb VSS) capacitor c=3.43563e-17
C122 (\9\:Eb VSS) capacitor c=1.21284e-16
C123 (\10\:Eb VSS) capacitor c=4.59937e-17
C124 (\11\:Eb VSS) capacitor c=1.20232e-16
C125 (\2\:CK VSS) capacitor c=3.79164e-17
C126 (\8\:SE VSS) capacitor c=5.26022e-17
C127 (\5\:SEb VSS) capacitor c=6.7715e-17
C128 (\6\:SEb VSS) capacitor c=1.37174e-16
C129 (\9\:SEb VSS) capacitor c=8.02506e-17
C130 (\5\:SI VSS) capacitor c=3.76291e-17
C131 (\4\:qint VSS) capacitor c=2.43704e-16
C132 (\5\:qint VSS) capacitor c=2.34398e-16
C133 (\17\:qbint VSS) capacitor c=5.43369e-17
C134 (\18\:qbint VSS) capacitor c=6.66377e-17
C135 (\6\:n30 VSS) capacitor c=8.77352e-17
C136 (\7\:n30 VSS) capacitor c=6.07913e-17
C137 (\6\:mout VSS) capacitor c=4.34982e-17
C138 (\9\:mout VSS) capacitor c=4.52765e-17
C139 (\6\:n20 VSS) capacitor c=6.10479e-17
C140 (\7\:n20 VSS) capacitor c=4.43393e-17
C141 (\8\:Ckbb VSS) capacitor c=6.35065e-17
C142 (\9\:Ckbb VSS) capacitor c=1.59186e-16
C143 (\12\:Ckbb VSS) capacitor c=1.30409e-16
C144 (\13\:Ckbb VSS) capacitor c=1.76114e-17
C145 (\16\:Ckbb VSS) capacitor c=4.66758e-17
C146 (\13\:CKb VSS) capacitor c=5.38218e-17
C147 (\14\:CKb VSS) capacitor c=1.33193e-16
C148 (\15\:CKb VSS) capacitor c=1.671e-16
C149 (\16\:CKb VSS) capacitor c=7.49129e-17
C150 (\17\:CKb VSS) capacitor c=2.92106e-17
C151 (\5\:CK VSS) capacitor c=7.318e-17
C152 (\5\:VDD VSS) capacitor c=4.27032e-17
C153 (\9\:VDD VSS) capacitor c=1.56164e-17
C154 (\12\:VDD VSS) capacitor c=7.29303e-17
C155 (\20\:VDD VSS) capacitor c=2.97167e-17
C156 (\24\:VDD VSS) capacitor c=2.42189e-17
Rk1 (\4\:D D) resistor r=0.003004 c=0
Rk18 (\2\:Q Q) resistor r=0.2414 c=0
Rk19 (Q \4\:Q) resistor r=0.08409 c=0
Rk17 (\5\:SI SI) resistor r=0.05217 c=0
Rk69 (\2\:VSS \3\:VSS) resistor r=0.218 c=0
Rk70 (\3\:VSS \4\:VSS) resistor r=0.4337 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.08163 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.5354 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.3334 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.06908 c=0
Rk76 (\8\:VSS \10\:VSS) resistor r=0.08508 c=0
Rk77 (\10\:VSS \11\:VSS) resistor r=0.5541 c=0
Rk78 (\11\:VSS \12\:VSS) resistor r=0.1478 c=0
Rk80 (\13\:VSS VSS) resistor r=0.277 c=0
Rk79 (\12\:VSS \13\:VSS) resistor r=0.2723 c=0
Rk81 (\3\:VSS \15\:VSS) resistor r=0.2208 c=0
Rk82 (\5\:VSS \17\:VSS) resistor r=0.04332 c=0
Rk83 (\6\:VSS \19\:VSS) resistor r=0.2366 c=0
Rk86 (\11\:VSS \25\:VSS) resistor r=0.1745 c=0
Rk87 (\13\:VSS \27\:VSS) resistor r=0.1211 c=0
Rk9 (SE \8\:SE) resistor r=0.05225 c=0
Rk8 (\7\:SE \8\:SE) resistor r=0.001772 c=0
Rk51 (\2\:VDD \4\:VDD) resistor r=0.335 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.5858 c=0
Rk53 (\5\:VDD \7\:VDD) resistor r=0.04332 c=0
Rk54 (\5\:VDD \8\:VDD) resistor r=0.2647 c=0
Rk55 (\8\:VDD \9\:VDD) resistor r=0.2582 c=0
Rk56 (\9\:VDD \11\:VDD) resistor r=0.3384 c=0
Rk57 (\9\:VDD \12\:VDD) resistor r=0.3382 c=0
Rk62 (\12\:VDD \19\:VDD) resistor r=0.1503 c=0
Rk63 (\19\:VDD \20\:VDD) resistor r=0.5892 c=0
Rk64 (\20\:VDD \22\:VDD) resistor r=0.2473 c=0
Rk65 (\20\:VDD \23\:VDD) resistor r=0.1628 c=0
Rk68 (\24\:VDD VDD) resistor r=0.278 c=0
Rk66 (\23\:VDD \24\:VDD) resistor r=0.2732 c=0
Rk67 (\24\:VDD \26\:VDD) resistor r=0.1744 c=0
Rk3 (\8\:E E) resistor r=0.1322 c=0
Rk2 (\7\:E \8\:E) resistor r=0.53 c=0
Rk50 (CK \5\:CK) resistor r=0.06251 c=0
Rk4 (\6\:Eb \8\:Eb) resistor r=0.8928 c=0
Rk5 (\8\:Eb \9\:Eb) resistor r=0.2918 c=0
Rk6 (\9\:Eb \10\:Eb) resistor r=0.175 c=0
Rk7 (\9\:Eb \11\:Eb) resistor r=0.8958 c=0
Rk10 (\2\:Db \4\:Db) resistor r=0.4645 c=0
Rk11 (\4\:Db \6\:Db) resistor r=0.9933 c=0
Rk12 (\6\:Db \8\:Db) resistor r=0.5856 c=0
Rk20 (\4\:qint \5\:qint) resistor r=1.8102 c=0
Rk21 (\5\:qint \7\:qint) resistor r=0.5173 c=0
Rk22 (\5\:qint \9\:qint) resistor r=0.05784 c=0
Rk13 (\5\:SEb \6\:SEb) resistor r=0.4997 c=0
Rk14 (\6\:SEb \8\:SEb) resistor r=0.3644 c=0
Rk15 (\6\:SEb \9\:SEb) resistor r=0.3726 c=0
Rk16 (\8\:SEb \11\:SEb) resistor r=0.5618 c=0
Rk35 (\2\:Dbp \4\:Dbp) resistor r=0.4582 c=0
Rk36 (\4\:Dbp \6\:Dbp) resistor r=2.8143 c=0
Rk37 (\6\:Dbp \8\:Dbp) resistor r=0.3409 c=0
Rk23 (\17\:qbint \18\:qbint) resistor r=0.226 c=0
Rk24 (\18\:qbint \20\:qbint) resistor r=0.08584 c=0
Rk25 (\18\:qbint \22\:qbint) resistor r=0.2829 c=0
Rk26 (\5\:n30 \6\:n30) resistor r=0.4747 c=0
Rk27 (\6\:n30 \7\:n30) resistor r=0.2481 c=0
Rk28 (\6\:n30 \9\:n30) resistor r=0.345 c=0
Rk44 (\12\:CKb \13\:CKb) resistor r=0.2034 c=0
Rk45 (\13\:CKb \14\:CKb) resistor r=0.363 c=0
Rk46 (\14\:CKb \15\:CKb) resistor r=0.9003 c=0
Rk47 (\15\:CKb \16\:CKb) resistor r=0.554 c=0
Rk48 (\13\:CKb \17\:CKb) resistor r=0.1176 c=0
Rk49 (\14\:CKb \19\:CKb) resistor r=0.1756 c=0
Rk29 (\5\:mout \6\:mout) resistor r=0.3134 c=0
Rk30 (\6\:mout \8\:mout) resistor r=0.1882 c=0
Rk31 (\6\:mout \9\:mout) resistor r=0.2058 c=0
Rk38 (\8\:Ckbb \9\:Ckbb) resistor r=0.245 c=0
Rk39 (\9\:Ckbb \11\:Ckbb) resistor r=0.2901 c=0
Rk40 (\9\:Ckbb \12\:Ckbb) resistor r=1.0096 c=0
Rk41 (\12\:Ckbb \13\:Ckbb) resistor r=0.0984 c=0
Rk42 (\11\:Ckbb \15\:Ckbb) resistor r=0.6457 c=0
Rk43 (\12\:Ckbb \16\:Ckbb) resistor r=0.1375 c=0
Rk32 (\5\:n20 \6\:n20) resistor r=0.3803 c=0
Rk33 (\6\:n20 \7\:n20) resistor r=0.2058 c=0
Rk34 (\6\:n20 \9\:n20) resistor r=0.1206 c=0
Rl3 (\1\:D \2\:D) resistor r=78.079 c=0
Rl4 (\2\:D \3\:D) resistor r=122.31 c=0
Rl18 (\1\:SI \2\:SI) resistor r=47.9178 c=0
Rl19 (\2\:SI \3\:SI) resistor r=104.871 c=0
Rl20 (\2\:SI \4\:SI) resistor r=4.0612 c=0
Rl16 (\3\:SE \6\:SE) resistor r=94.9636 c=0
Rl14 (\3\:SE \4\:SE) resistor r=99.7951 c=0
Rl15 (\2\:SE \5\:SE) resistor r=30.4507 c=0
Rl12 (\1\:SE \2\:SE) resistor r=191.851 c=0
Rl13 (\2\:SE \3\:SE) resistor r=186.928 c=0
Rl6 (\4\:E \5\:E) resistor r=232.246 c=0
Rl7 (\5\:E \6\:E) resistor r=24.2328 c=0
Rl1 (\1\:E \2\:E) resistor r=155.769 c=0
Rl2 (\2\:E \3\:E) resistor r=48.2661 c=0
Rl52 (\1\:CK \2\:CK) resistor r=91.0479 c=0
Rl53 (\2\:CK \3\:CK) resistor r=173.385 c=0
Rl54 (\2\:CK \4\:CK) resistor r=5.1011 c=0
Rl8 (\3\:Eb \4\:Eb) resistor r=49.2328 c=0
Rl5 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl9 (qint \2\:qint) resistor r=24.2328 c=0
Rl10 (\2\:qint \3\:qint) resistor r=176.156 c=0
Rl17 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl11 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl21 (\2\:qbint qbint) resistor r=122.758 c=0
Rl27 (\2\:qbint \8\:qbint) resistor r=42.6971 c=0
Rl28 (\3\:qbint \9\:qbint) resistor r=36.22 c=0
Rl22 (\3\:qbint \2\:qbint) resistor r=27.3132 c=0
Rl23 (\4\:qbint \3\:qbint) resistor r=67.6978 c=0
Rl36 (\14\:qbint \16\:qbint) resistor r=82.3738 c=0
Rl34 (\14\:qbint \13\:qbint) resistor r=76.901 c=0
Rl35 (\14\:qbint \15\:qbint) resistor r=35.0048 c=0
Rl32 (n30 \2\:n30) resistor r=24.2328 c=0
Rl33 (\2\:n30 \3\:n30) resistor r=93.4636 c=0
Rl38 (CKb \2\:CKb) resistor r=168.796 c=0
Rl51 (\9\:CKb \10\:CKb) resistor r=39.1533 c=0
Rl45 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl39 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl48 (\6\:CKb \7\:CKb) resistor r=168.464 c=0
Rl49 (\7\:CKb \8\:CKb) resistor r=188.887 c=0
Rl50 (\7\:CKb \9\:CKb) resistor r=28.7715 c=0
Rl43 (mout \2\:mout) resistor r=32.9629 c=0
Rl44 (\2\:mout \3\:mout) resistor r=86.3335 c=0
Rl46 (\5\:Ckbb \6\:Ckbb) resistor r=24.2328 c=0
Rl47 (\6\:Ckbb \7\:Ckbb) resistor r=106.491 c=0
Rl40 (\3\:Ckbb \4\:Ckbb) resistor r=70.3867 c=0
Rl37 (Ckbb \2\:Ckbb) resistor r=38.5707 c=0
Rl41 (n20 \2\:n20) resistor r=86.3335 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=46.4312 c=0
Rz5 (\4\:Q \3\:Q) resistor r=75 c=0
Rz20 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz26 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz15 (\4\:VDD \3\:VDD) resistor r=15 c=0
Rz16 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\12\:VDD \3\:VDD) resistor r=37.5 c=0
Rz18 (\19\:VDD \3\:VDD) resistor r=25 c=0
Rz19 (\23\:VDD \3\:VDD) resistor r=6.25 c=0
Rz1 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz2 (\3\:Db \4\:Db) resistor r=75 c=0
Rz3 (\5\:Db \6\:Db) resistor r=75 c=0
Rz6 (\6\:qint \7\:qint) resistor r=75 c=0
Rz4 (\10\:SEb \11\:SEb) resistor r=75 c=0
Rz11 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz12 (\5\:Dbp \6\:Dbp) resistor r=75 c=0
Rz7 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz8 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz14 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz9 (\7\:mout \8\:mout) resistor r=75 c=0
Rz13 (\14\:Ckbb \15\:Ckbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry5 (\2\:Q \1\:Q) resistor r=62 c=0
Ry22 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry23 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry24 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry25 (\10\:VSS \1\:VSS) resistor r=31 c=0
Ry26 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry17 (\11\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=31 c=0
Ry21 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry1 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry2 (Db \2\:Db) resistor r=62 c=0
Ry3 (\7\:Db \8\:Db) resistor r=62 c=0
Ry6 (\8\:qint \9\:qint) resistor r=62 c=0
Ry4 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry11 (Dbp \2\:Dbp) resistor r=62 c=0
Ry12 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry7 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry8 (\8\:n30 \9\:n30) resistor r=31 c=0
Ry14 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\4\:mout \5\:mout) resistor r=62 c=0
Ry13 (\10\:Ckbb \11\:Ckbb) resistor r=62 c=0
Ry10 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\4\:SI \5\:SI) resistor r=45 c=0
Rx6 (\3\:SE \7\:SE) resistor r=45 c=0
Rx2 (\5\:E \7\:E) resistor r=45 c=0
Rx3 (\2\:E \8\:E) resistor r=45 c=0
Rx22 (\4\:CK \5\:CK) resistor r=45 c=0
Rx4 (\2\:Eb \10\:Eb) resistor r=45 c=0
Rx5 (\4\:Eb \11\:Eb) resistor r=45 c=0
Rx10 (\2\:qint \4\:qint) resistor r=45 c=0
Rx7 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx8 (\2\:SEb \9\:SEb) resistor r=45 c=0
Rx11 (\17\:qbint \15\:qbint) resistor r=45 c=0
Rx12 (\18\:qbint \8\:qbint) resistor r=45 c=0
Rx13 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx19 (\5\:CKb \15\:CKb) resistor r=45 c=0
Rx20 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx21 (\9\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:mout \9\:mout) resistor r=45 c=0
Rx16 (\6\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx17 (\4\:Ckbb \13\:Ckbb) resistor r=45 c=0
Rx18 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx15 (\2\:n20 \7\:n20) resistor r=45 c=0
mn0 (\5\:Eb \3\:E \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=2.03e-14 ps=1e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn3 (net526 \3\:D \26\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=4.29e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98942e-07 sb=1.01692e-06 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn4 (\5\:Db \6\:E net526 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.93e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.08942e-07 sb=8.06923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn2 (\5\:Db \3\:Eb net494 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=7.93e-14 ps=6.4e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.58942e-07 sb=4.56923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn1 (net494 \3\:qint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=1.56e-14 ps=9.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.63942e-07 sb=3.51923e-07 sd=160n sca=7.96722 \
        scb=0.00567143 scc=0.000107411 m=(1)
mn10 (\10\:SEb \4\:SE \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=3.698e-14 ps=9.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=2.55e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn11 (\3\:Db SEb \5\:Dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.25529e-06 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(1)
mn13 (\5\:Dbp \1\:SE net518 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.02029e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn12 (net518 \3\:SI \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.06e-14 ad=1.56e-14 ps=1.14e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=9.15288e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn55 (\3\:Q \4\:qbint \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.222e-14 ad=4.16e-14 ps=1.295e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=5.60288e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(2)
mn56 (\6\:qint \9\:qbint \8\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=2.87e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.4e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn45 (\19\:qbint \3\:n30 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.525e-14 ad=5.33e-14 ps=1.12e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.53913e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mn50 (net509 \13\:qbint \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.525e-14 ad=3.28e-14 ps=1.12e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.54e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn51 (\4\:n30 CKb net509 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.382e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.335e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn40 (\4\:n30 \3\:Ckbb \7\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=3.383e-14 ps=1.04e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.125e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn35 (net501 mout \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=2.255e-14 ps=1.45e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=5e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn30 (\7\:mout n20 \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=6.458e-14 ps=1.45e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=7.65e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn25 (\4\:n20 \8\:CKb \3\:Dbp VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=1.4e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn36 (\4\:n20 \7\:Ckbb net501 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.255e-14 ad=3.28e-14 ps=6.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.745e-06 sb=3.45e-07 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn21 (\14\:Ckbb \10\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn20 (\11\:CKb \3\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mp3 (net449 \1\:D \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=9.8141e-07 sd=160n sca=11.9271 \
        scb=0.00973247 scc=0.000231921 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.775e-14 ps=9e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.74551e-07 sb=8.7641e-07 sd=160n sca=11.6054 \
        scb=0.0095923 scc=0.000231863 m=(1)
mp2 (\7\:Db \4\:E net405 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.555e-14 ad=8.775e-14 ps=1.27e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.44551e-07 sb=6.0641e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp1 (net405 qint \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.363e-14 ad=9.555e-14 ps=1.33e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.34551e-07 sb=3.1641e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp10 (\7\:SEb \6\:SE \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.363e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp11 (Db \5\:SE \7\:Dbp VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.443e-13 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37231e-06 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp13 (\7\:Dbp \3\:SEb net441 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=1.443e-13 ps=1.05e-06 pd=1.52e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=9.57308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp12 (net441 \1\:SI \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.11e-13 ad=5.265e-14 ps=1.64e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=7.77308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(1)
mp55 (\1\:Q \4\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.055e-13 ad=6.24e-14 ps=1.64e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=5.12308e-07 sd=160n sca=21.3455 \
        scb=0.0174972 scc=0.00212086 m=(2)
mp56 (\8\:qint qbint \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1e-13 ad=3.58e-14 ps=1.64e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.38613e-06 sb=1.15484e-07 sd=160n sca=13.3668 scb=0.0122284 \
        scc=0.000582667 m=(1)
mp45 (\21\:qbint n30 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.94e-14 ad=4.5e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15385e-07 sb=1.52705e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp50 (net426 \16\:qbint \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.94e-14 ad=4.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84355e-07 sb=1.62e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\4\:mout \3\:n20 \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.108e-13 ad=9.765e-14 ps=1.77e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.13435e-06 sb=8.7e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 Ckbb net426 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.69355e-07 sb=1.435e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\8\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.765e-14 ad=4.96e-14 ps=1.25e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.74355e-07 sb=1.23e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net417 \3\:mout \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.108e-13 ad=1.86e-14 ps=1.77e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39935e-06 sb=6.05e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\8\:n20 \4\:CKb net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.89e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.50435e-06 sb=5e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp25 (\8\:n20 \5\:Ckbb Dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=5.89e-14 ps=1.15e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73935e-06 sb=2.65e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp21 (\10\:Ckbb \6\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.267e-14 ad=3.655e-14 ps=9.2e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.3e-07 sd=160n sca=12.2145 \
        scb=0.00974237 scc=0.000188593 m=(1)
mp20 (\18\:CKb \1\:CK \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.267e-14 ad=3.01e-14 ps=9.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=16.1974 \
        scb=0.0160404 scc=0.000308643 m=(1)
ends SEDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:52:26 2012 )
// Library name: gsclib045
// Cell name: SEDFFHQX4
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX4 CK D E Q SE SI VDD VSS
mp55_1__rcx (Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.235e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.73641e-06 sd=160n sca=31.4485 \
        scb=0.0346421 scc=0.00289038 m=(4)
C1 (CK VSS) capacitor c=4.38158e-17
C2 (D VSS) capacitor c=1.4316e-16
C3 (Q VSS) capacitor c=2.56392e-16
C4 (SE VSS) capacitor c=7.37864e-17
C5 (VDD VSS) capacitor c=7.43236e-16
C6 (E VSS) capacitor c=6.56334e-17
C7 (SI VSS) capacitor c=5.70468e-17
C8 (qbint VSS) capacitor c=2.23259e-16
C9 (n30 VSS) capacitor c=1.82761e-16
C10 (net509 VSS) capacitor c=2.29117e-18
C11 (CKb VSS) capacitor c=2.37439e-17
C12 (mout VSS) capacitor c=5.26993e-17
C13 (Ckbb VSS) capacitor c=5.02052e-17
C14 (n20 VSS) capacitor c=3.7334e-17
C15 (net501 VSS) capacitor c=3.92598e-19
C16 (Dbp VSS) capacitor c=9.37828e-17
C17 (qint VSS) capacitor c=1.05872e-16
C18 (net518 VSS) capacitor c=4.02074e-18
C19 (Db VSS) capacitor c=9.41019e-17
C20 (SEb VSS) capacitor c=5.57045e-17
C21 (net494 VSS) capacitor c=7.29788e-18
C22 (Eb VSS) capacitor c=3.66613e-17
C23 (net426 VSS) capacitor c=4.31478e-18
C24 (net417 VSS) capacitor c=3.63511e-18
C25 (net441 VSS) capacitor c=2.40277e-18
C26 (net405 VSS) capacitor c=2.4314e-18
C27 (net449 VSS) capacitor c=6.67059e-18
C28 (\7\:E VSS) capacitor c=3.61345e-17
C29 (\1\:D VSS) capacitor c=4.31435e-17
C30 (\2\:E VSS) capacitor c=7.12157e-17
C31 (\1\:SE VSS) capacitor c=4.06013e-17
C32 (\6\:SE VSS) capacitor c=4.68449e-17
C33 (\2\:SEb VSS) capacitor c=7.02164e-17
C34 (\4\:SI VSS) capacitor c=6.83375e-17
C35 (\1\:CK VSS) capacitor c=2.33416e-17
C36 (\18\:qbint VSS) capacitor c=4.72807e-17
C37 (\7\:CKb VSS) capacitor c=2.0601e-17
C38 (\7\:Ckbb VSS) capacitor c=3.48453e-17
C39 (\4\:CKb VSS) capacitor c=1.06253e-16
C40 (\5\:CKb VSS) capacitor c=8.77231e-17
C41 (\14\:qbint VSS) capacitor c=4.49419e-17
C42 (\5\:E VSS) capacitor c=1.91984e-17
C43 (\3\:D VSS) capacitor c=6.85879e-17
C44 (\3\:E VSS) capacitor c=7.0197e-17
C45 (\3\:Eb VSS) capacitor c=6.31988e-17
C46 (\4\:qint VSS) capacitor c=2.80647e-17
C47 (\5\:SE VSS) capacitor c=3.82616e-17
C48 (\3\:SEb VSS) capacitor c=2.99813e-17
C49 (\4\:SE VSS) capacitor c=6.53895e-17
C50 (\1\:SI VSS) capacitor c=4.93163e-17
C51 (\3\:CK VSS) capacitor c=3.87561e-17
C52 (\20\:qbint VSS) capacitor c=4.26858e-17
C53 (\8\:CKb VSS) capacitor c=2.62621e-17
C54 (\5\:Ckbb VSS) capacitor c=5.92812e-17
C55 (\4\:mout VSS) capacitor c=5.50067e-17
C56 (\3\:n20 VSS) capacitor c=3.86554e-17
C57 (\3\:Ckbb VSS) capacitor c=3.31433e-17
C58 (\6\:CKb VSS) capacitor c=6.26515e-17
C59 (\17\:qbint VSS) capacitor c=3.76102e-17
C60 (\6\:E VSS) capacitor c=2.58697e-17
C61 (\2\:D VSS) capacitor c=4.04654e-17
C62 (\4\:E VSS) capacitor c=4.64328e-17
C63 (\1\:E VSS) capacitor c=4.7223e-17
C64 (\3\:qint VSS) capacitor c=2.55575e-17
C65 (\2\:SE VSS) capacitor c=7.83139e-17
C66 (\5\:SEb VSS) capacitor c=3.78165e-17
C67 (\4\:SEb VSS) capacitor c=3.95696e-17
C68 (\3\:SI VSS) capacitor c=2.54846e-17
C69 (\2\:CK VSS) capacitor c=3.54843e-17
C70 (\2\:CKb VSS) capacitor c=3.62924e-17
C71 (\19\:qbint VSS) capacitor c=3.04587e-17
C72 (\8\:Ckbb VSS) capacitor c=3.29663e-17
C73 (\6\:Ckbb VSS) capacitor c=4.27648e-17
C74 (\3\:mout VSS) capacitor c=2.3528e-17
C75 (\2\:n20 VSS) capacitor c=3.31692e-17
C76 (\4\:Ckbb VSS) capacitor c=2.90197e-17
C77 (\2\:Ckbb VSS) capacitor c=3.46338e-17
C78 (\16\:qbint VSS) capacitor c=2.74099e-17
C79 (\8\:qbint VSS) capacitor c=1.99353e-17
C80 (\7\:Eb VSS) capacitor c=1.01364e-16
C81 (\19\:VDD VSS) capacitor c=3.66348e-17
C82 (\7\:Db VSS) capacitor c=5.60809e-17
C83 (\21\:VDD VSS) capacitor c=4.13937e-17
C84 (\9\:SEb VSS) capacitor c=9.28833e-17
C85 (\5\:Db VSS) capacitor c=4.53442e-17
C86 (\4\:Dbp VSS) capacitor c=5.44295e-17
C87 (\23\:VDD VSS) capacitor c=2.0594e-17
C88 (\13\:CKb VSS) capacitor c=5.47347e-17
C89 (\8\:qint VSS) capacitor c=8.48408e-17
C90 (\25\:VDD VSS) capacitor c=6.49018e-17
C91 (\9\:Ckbb VSS) capacitor c=6.62302e-17
C92 (\10\:Dbp VSS) capacitor c=4.31999e-17
C93 (\4\:n20 VSS) capacitor c=6.24946e-17
C94 (\27\:VDD VSS) capacitor c=5.00874e-17
C95 (\9\:mout VSS) capacitor c=5.25288e-17
C96 (\7\:n30 VSS) capacitor c=2.9123e-17
C97 (\26\:qbint VSS) capacitor c=3.98804e-17
C98 (\1\:VDD VSS) capacitor c=2.28253e-16
C99 (\5\:Eb VSS) capacitor c=4.79218e-17
C100 (\6\:SEb VSS) capacitor c=6.28326e-17
C101 (\9\:Db VSS) capacitor c=7.57262e-17
C102 (\9\:CKb VSS) capacitor c=8.91948e-17
C103 (\6\:qint VSS) capacitor c=2.69407e-16
C104 (\11\:Ckbb VSS) capacitor c=7.80403e-17
C105 (\7\:Dbp VSS) capacitor c=7.25153e-17
C106 (\8\:n20 VSS) capacitor c=7.49114e-17
C107 (\7\:mout VSS) capacitor c=5.52039e-17
C108 (\11\:n30 VSS) capacitor c=8.31147e-17
C109 (\28\:qbint VSS) capacitor c=3.34895e-17
C110 (\15\:qbint VSS) capacitor c=3.12251e-17
C111 (\2\:mout VSS) capacitor c=3.46605e-17
C112 (\3\:CKb VSS) capacitor c=6.32026e-17
C113 (\2\:SI VSS) capacitor c=3.68232e-17
C114 (\3\:SE VSS) capacitor c=7.16951e-17
C115 (\2\:qint VSS) capacitor c=2.42087e-17
C116 (\9\:n30 VSS) capacitor c=9.60827e-17
C117 (\10\:n30 VSS) capacitor c=9.41257e-17
C118 (\2\:Eb VSS) capacitor c=5.23299e-17
C119 (\5\:mout VSS) capacitor c=6.79501e-17
C120 (\6\:mout VSS) capacitor c=4.56426e-17
C121 (\6\:n20 VSS) capacitor c=8.43266e-17
C122 (\7\:n20 VSS) capacitor c=8.41162e-17
C123 (\13\:Ckbb VSS) capacitor c=1.0784e-16
C124 (\14\:Ckbb VSS) capacitor c=1.29532e-16
C125 (\15\:Ckbb VSS) capacitor c=1.34095e-16
C126 (\16\:Ckbb VSS) capacitor c=9.20013e-17
C127 (\17\:Ckbb VSS) capacitor c=7.28821e-17
C128 (\18\:Ckbb VSS) capacitor c=4.39715e-17
C129 (\19\:Ckbb VSS) capacitor c=5.14413e-17
C130 (\21\:qbint VSS) capacitor c=2.57231e-16
C131 (\22\:qbint VSS) capacitor c=2.44337e-16
C132 (\23\:qbint VSS) capacitor c=2.39464e-17
C133 (\24\:qbint VSS) capacitor c=3.03982e-17
C134 (\25\:qbint VSS) capacitor c=2.35976e-17
C135 (\11\:CKb VSS) capacitor c=1.67998e-16
C136 (\12\:CKb VSS) capacitor c=1.00311e-16
C137 (\4\:CK VSS) capacitor c=7.26272e-17
C138 (\5\:SI VSS) capacitor c=8.75336e-17
C139 (\3\:Dbp VSS) capacitor c=2.47335e-16
C140 (\6\:Dbp VSS) capacitor c=2.56607e-16
C141 (\8\:SEb VSS) capacitor c=5.15368e-17
C142 (\11\:SEb VSS) capacitor c=1.21343e-16
C143 (\12\:SEb VSS) capacitor c=4.01988e-17
C144 (\13\:SEb VSS) capacitor c=4.18758e-17
C145 (\5\:qint VSS) capacitor c=3.07419e-16
C146 (\7\:SE VSS) capacitor c=5.13261e-17
C147 (\3\:Db VSS) capacitor c=1.57755e-16
C148 (\4\:Db VSS) capacitor c=9.47974e-17
C149 (\8\:E VSS) capacitor c=6.82314e-17
C150 (\9\:E VSS) capacitor c=6.23602e-17
C151 (\10\:E VSS) capacitor c=3.27727e-17
C152 (\9\:Eb VSS) capacitor c=1.09724e-16
C153 (\5\:VDD VSS) capacitor c=1.53703e-17
C154 (\7\:VDD VSS) capacitor c=1.79431e-17
C155 (\9\:VDD VSS) capacitor c=2.9172e-18
C156 (\11\:VDD VSS) capacitor c=4.28865e-17
Rk33 (CK \4\:CK) resistor r=0.1025 c=0
Rk53 (D \4\:D) resistor r=0.00509 c=0
Rk47 (SE \7\:SE) resistor r=0.02065 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.1553 c=0
Rk60 (\3\:VDD \4\:VDD) resistor r=0.1954 c=0
Rk61 (\4\:VDD \5\:VDD) resistor r=0.2055 c=0
Rk62 (\5\:VDD \6\:VDD) resistor r=0.3961 c=0
Rk63 (\6\:VDD \7\:VDD) resistor r=0.356 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.3459 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.3083 c=0
Rk66 (\9\:VDD \10\:VDD) resistor r=0.04244 c=0
Rk67 (\10\:VDD \11\:VDD) resistor r=0.6018 c=0
Rk69 (\12\:VDD VDD) resistor r=0.6018 c=0
Rk68 (\11\:VDD \12\:VDD) resistor r=0.04997 c=0
Rk75 (\3\:VDD \20\:VDD) resistor r=0.2547 c=0
Rk76 (\5\:VDD \22\:VDD) resistor r=0.2554 c=0
Rk77 (\7\:VDD \24\:VDD) resistor r=0.07405 c=0
Rk78 (\9\:VDD \26\:VDD) resistor r=0.2723 c=0
Rk79 (\11\:VDD \28\:VDD) resistor r=0.2637 c=0
Rk55 (\9\:E E) resistor r=0.2611 c=0
Rk54 (\8\:E \9\:E) resistor r=0.3114 c=0
Rk56 (E \10\:E) resistor r=0.1412 c=0
Rk34 (SI \5\:SI) resistor r=0.0691 c=0
Rk83 (\2\:VSS \3\:VSS) resistor r=0.1553 c=0
Rk84 (\3\:VSS \4\:VSS) resistor r=0.436 c=0
Rk85 (\4\:VSS \5\:VSS) resistor r=0.1102 c=0
Rk86 (\5\:VSS \6\:VSS) resistor r=0.5968 c=0
Rk87 (\6\:VSS \7\:VSS) resistor r=0.3058 c=0
Rk88 (\7\:VSS \8\:VSS) resistor r=0.3459 c=0
Rk89 (\8\:VSS \9\:VSS) resistor r=0.3058 c=0
Rk90 (\9\:VSS \10\:VSS) resistor r=0.3459 c=0
Rk92 (\11\:VSS VSS) resistor r=0.366 c=0
Rk91 (\10\:VSS \11\:VSS) resistor r=0.3058 c=0
Rk98 (\3\:VSS \19\:VSS) resistor r=0.2915 c=0
Rk99 (\4\:VSS \21\:VSS) resistor r=0.2384 c=0
Rk100 (\6\:VSS \23\:VSS) resistor r=0.2604 c=0
Rk101 (\8\:VSS \25\:VSS) resistor r=0.2993 c=0
Rk102 (\10\:VSS \27\:VSS) resistor r=0.296 c=0
Rk24 (\21\:qbint \22\:qbint) resistor r=2.266 c=0
Rk25 (\22\:qbint \23\:qbint) resistor r=0.183 c=0
Rk26 (\23\:qbint \24\:qbint) resistor r=0.2231 c=0
Rk27 (\24\:qbint \25\:qbint) resistor r=0.1016 c=0
Rk28 (\23\:qbint \27\:qbint) resistor r=0.1387 c=0
Rk29 (\24\:qbint \29\:qbint) resistor r=0.1868 c=0
Rk7 (\8\:n30 \9\:n30) resistor r=0.06101 c=0
Rk8 (\9\:n30 \10\:n30) resistor r=0.6427 c=0
Rk9 (\9\:n30 \12\:n30) resistor r=0.3688 c=0
Rk30 (\10\:CKb \11\:CKb) resistor r=0.5558 c=0
Rk31 (\11\:CKb \12\:CKb) resistor r=0.8925 c=0
Rk32 (\11\:CKb \14\:CKb) resistor r=0.1782 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.2587 c=0
Rk11 (\6\:mout \8\:mout) resistor r=0.1613 c=0
Rk12 (\6\:mout \10\:mout) resistor r=0.2265 c=0
Rk16 (\10\:Ckbb \12\:Ckbb) resistor r=0.3391 c=0
Rk17 (\12\:Ckbb \13\:Ckbb) resistor r=0.506 c=0
Rk18 (\13\:Ckbb \14\:Ckbb) resistor r=0.4525 c=0
Rk19 (\14\:Ckbb \15\:Ckbb) resistor r=0.7052 c=0
Rk20 (\15\:Ckbb \16\:Ckbb) resistor r=0.5982 c=0
Rk21 (\13\:Ckbb \17\:Ckbb) resistor r=0.4144 c=0
Rk22 (\14\:Ckbb \18\:Ckbb) resistor r=0.08119 c=0
Rk23 (\15\:Ckbb \19\:Ckbb) resistor r=0.2304 c=0
Rk13 (\5\:n20 \6\:n20) resistor r=0.1815 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.4381 c=0
Rk15 (\6\:n20 \9\:n20) resistor r=0.3158 c=0
Rk35 (\2\:Dbp \3\:Dbp) resistor r=0.6187 c=0
Rk36 (\3\:Dbp \5\:Dbp) resistor r=0.1001 c=0
Rk37 (\3\:Dbp \6\:Dbp) resistor r=1.7858 c=0
Rk38 (\6\:Dbp \8\:Dbp) resistor r=0.4313 c=0
Rk39 (\5\:Dbp \9\:Dbp) resistor r=0.1794 c=0
Rk40 (\6\:Dbp \11\:Dbp) resistor r=0.1628 c=0
Rk45 (\5\:qint \7\:qint) resistor r=2.3912 c=0
Rk46 (\7\:qint \9\:qint) resistor r=0.5296 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.6497 c=0
Rk49 (\3\:Db \4\:Db) resistor r=0.6435 c=0
Rk50 (\4\:Db \6\:Db) resistor r=0.07972 c=0
Rk51 (\3\:Db \8\:Db) resistor r=0.2506 c=0
Rk52 (\4\:Db \10\:Db) resistor r=0.4293 c=0
Rk41 (\7\:SEb \8\:SEb) resistor r=0.1937 c=0
Rk42 (\10\:SEb \11\:SEb) resistor r=0.7898 c=0
Rk43 (\11\:SEb \12\:SEb) resistor r=0.08634 c=0
Rk44 (\11\:SEb \13\:SEb) resistor r=0.2134 c=0
Rk57 (\6\:Eb \8\:Eb) resistor r=0.4652 c=0
Rk58 (\8\:Eb \9\:Eb) resistor r=0.6821 c=0
Rl39 (\1\:CK \2\:CK) resistor r=67.3077 c=0
Rl40 (\2\:CK \3\:CK) resistor r=70.3297 c=0
Rl60 (\1\:D \2\:D) resistor r=39.1533 c=0
Rl61 (\2\:D \3\:D) resistor r=87.2302 c=0
Rl47 (\1\:SE \2\:SE) resistor r=132.669 c=0
Rl50 (\2\:SE \5\:SE) resistor r=97.872 c=0
Rl51 (\3\:SE \6\:SE) resistor r=47.3105 c=0
Rl49 (\3\:SE \4\:SE) resistor r=143.03 c=0
Rl48 (\2\:SE \3\:SE) resistor r=241.222 c=0
Rl63 (\6\:E \7\:E) resistor r=97.2527 c=0
Rl62 (\5\:E \6\:E) resistor r=40.3846 c=0
Rl59 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl55 (\1\:E \2\:E) resistor r=33.8727 c=0
Rl43 (\2\:SI \4\:SI) resistor r=37.3411 c=0
Rl41 (\1\:SI \2\:SI) resistor r=110.786 c=0
Rl42 (\2\:SI \3\:SI) resistor r=8.3025 c=0
Rl38 (\20\:qbint \18\:qbint) resistor r=92.3077 c=0
Rl37 (\19\:qbint \18\:qbint) resistor r=146.131 c=0
Rl7 (qbint \8\:qbint) resistor r=9.5287 c=0
Rl18 (\15\:qbint \14\:qbint) resistor r=34.3295 c=0
Rl20 (\15\:qbint \17\:qbint) resistor r=124.714 c=0
Rl19 (\15\:qbint \16\:qbint) resistor r=11.4953 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=520.72 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=210.777 c=0
Rl30 (CKb \2\:CKb) resistor r=35.3482 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=24.7951 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=149.543 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=49.6815 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=248.466 c=0
Rl25 (mout \2\:mout) resistor r=95.0334 c=0
Rl27 (\2\:mout \4\:mout) resistor r=62.3411 c=0
Rl26 (\2\:mout \3\:mout) resistor r=6.9867 c=0
Rl29 (\7\:Ckbb \8\:Ckbb) resistor r=30.0021 c=0
Rl28 (\5\:Ckbb \6\:Ckbb) resistor r=35.7713 c=0
Rl22 (\3\:Ckbb \4\:Ckbb) resistor r=24.2328 c=0
Rl21 (Ckbb \2\:Ckbb) resistor r=64.6174 c=0
Rl23 (n20 \2\:n20) resistor r=24.2328 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=114.617 c=0
Rl52 (qint \2\:qint) resistor r=120.387 c=0
Rl54 (\2\:qint \4\:qint) resistor r=28.0797 c=0
Rl53 (\2\:qint \3\:qint) resistor r=54.6257 c=0
Rl44 (SEb \2\:SEb) resistor r=39.4 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=27.6559 c=0
Rl46 (\4\:SEb \5\:SEb) resistor r=107.617 c=0
Rl56 (Eb \2\:Eb) resistor r=67.4757 c=0
Rl57 (\2\:Eb \3\:Eb) resistor r=139.972 c=0
Rl58 (\2\:Eb \4\:Eb) resistor r=1.2666 c=0
Rz22 (VDD \1\:VDD) resistor r=10.7143 c=0
Rz16 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz17 (\4\:VDD \1\:VDD) resistor r=18.75 c=0
Rz18 (\6\:VDD \1\:VDD) resistor r=9.375 c=0
Rz19 (\8\:VDD \1\:VDD) resistor r=12.5 c=0
Rz20 (\10\:VDD \1\:VDD) resistor r=75 c=0
Rz21 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz24 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz28 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz7 (\29\:qbint \28\:qbint) resistor r=75 c=0
Rz3 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz8 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz6 (\11\:Ckbb \12\:Ckbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Dbp \2\:Dbp) resistor r=75 c=0
Rz10 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz12 (\6\:qint \7\:qint) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\9\:Db \10\:Db) resistor r=75 c=0
Rz11 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz15 (\5\:Eb \6\:Eb) resistor r=75 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry22 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry31 (VSS \1\:VSS) resistor r=8.8571 c=0
Ry26 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry27 (\5\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry28 (\7\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry29 (\9\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry30 (\11\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry7 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry3 (\8\:n30 \7\:n30) resistor r=62 c=0
Ry8 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry4 (\9\:mout \10\:mout) resistor r=62 c=0
Ry6 (\9\:Ckbb \10\:Ckbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry9 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry10 (\4\:Dbp \9\:Dbp) resistor r=62 c=0
Ry11 (\10\:Dbp \11\:Dbp) resistor r=62 c=0
Ry13 (\8\:qint \9\:qint) resistor r=62 c=0
Ry14 (\5\:Db \6\:Db) resistor r=62 c=0
Ry15 (\7\:Db \8\:Db) resistor r=31 c=0
Ry12 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry16 (\7\:Eb \8\:Eb) resistor r=62 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx18 (\2\:SE \7\:SE) resistor r=45 c=0
Rx20 (\1\:E \8\:E) resistor r=45 c=0
Rx21 (\4\:E \9\:E) resistor r=45 c=0
Rx22 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx8 (\21\:qbint \19\:qbint) resistor r=45 c=0
Rx9 (\22\:qbint \16\:qbint) resistor r=45 c=0
Rx10 (\25\:qbint \8\:qbint) resistor r=45 c=0
Rx1 (\10\:n30 n30) resistor r=45 c=0
Rx11 (\2\:CKb \12\:CKb) resistor r=45 c=0
Rx2 (\3\:mout \5\:mout) resistor r=45 c=0
Rx4 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx5 (\8\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx6 (\6\:Ckbb \18\:Ckbb) resistor r=45 c=0
Rx7 (\4\:Ckbb \19\:Ckbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\3\:qint \5\:qint) resistor r=45 c=0
Rx14 (\5\:SEb \8\:SEb) resistor r=45 c=0
Rx15 (SEb \12\:SEb) resistor r=45 c=0
Rx16 (\4\:SEb \13\:SEb) resistor r=45 c=0
Rx23 (\4\:Eb \9\:Eb) resistor r=45 c=0
mn55 (Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.152e-14 \
        ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.72817e-06 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(4)
mn45 (\28\:qbint n30 VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.58e-14 ad=3.28e-14 ps=8.85e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(2)
mn50 (net509 \17\:qbint VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.92e-14 ps=8.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.945e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (\11\:n30 \6\:CKb net509 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=5.842e-14 ps=8.9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=1.66e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\11\:n30 \3\:Ckbb \7\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.74e-14 ad=5.842e-14 ps=9.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.33e-06 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (\7\:mout \3\:n20 \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.432e-14 ad=5.74e-14 ps=9.4e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.005e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn35 (net501 \4\:mout \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=1.23e-14 ps=9.4e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.95e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn36 (\8\:n20 \5\:Ckbb net501 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.715e-14 ps=5.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.9e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn25 (\8\:n20 \8\:CKb \7\:Dbp VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.715e-14 ps=1.04e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.15e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn21 (\11\:Ckbb CKb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.345e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn56 (\6\:qint \20\:qbint \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.345e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.70288e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\9\:CKb \3\:CK \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.888e-14 ad=2.175e-14 ps=1.11e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=9.05e-07 sd=160n sca=17.28 scb=0.0183577 \
        scc=0.00144167 m=(1)
mn12 (net518 \1\:SI \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.888e-14 ad=3.77e-14 ps=1.11e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35192e-07 sb=5.65e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn13 (Dbp \4\:SE net518 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=4.94e-14 ps=8.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25192e-07 sb=3.75e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn11 (\9\:Db \3\:SEb Dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.60192e-07 sb=1.4e-07 sd=160n sca=13.5771 scb=0.0135427 \
        scc=0.000870653 m=(1)
mn10 (\6\:SEb \5\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.852e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.57017e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn1 (net494 \4\:qint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.852e-14 ad=6.24e-14 ps=1.27e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05192e-07 sb=1.00173e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (Db \3\:Eb net494 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.90192e-07 sb=7.16731e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn4 (Db \3\:E net526 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.95192e-07 sb=5.11731e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3 (net526 \3\:D \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=1.56e-14 ps=1.39e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.00019e-06 sb=4.06731e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\5\:Eb \5\:E \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=2.465e-14 ps=1.39e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57466e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45 (\26\:qbint n30 VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.42e-14 ad=4.96e-14 ps=1.205e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(2)
mp50 (net426 \14\:qbint VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.84e-14 ad=3.565e-14 ps=1.23e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=1.82e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp51 (\7\:n30 Ckbb net426 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=7.905e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.66e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp40 (\7\:n30 \5\:CKb \9\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=7.905e-14 ps=1.49e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.93e-06 sb=1.36e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp30 (\9\:mout n20 \27\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=1.3485e-13 ps=1.15e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.8e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp35 (net417 mout \27\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=4.96e-14 ps=1.15e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.7e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp36 (\4\:n20 \4\:CKb net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=5.58e-14 ps=9.4e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp25 (\4\:n20 \7\:Ckbb \10\:Dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=5.58e-14 ps=9e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp21 (\9\:Ckbb \7\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.28e-14 ad=4.3e-14 ps=1.37e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=6.8e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp56 (\8\:qint \18\:qbint \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.28e-14 ad=1.521e-13 ps=1.37e-06 pd=1.56e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.57628e-07 sb=3.9e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp20 (\13\:CKb \1\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp12 (net441 \4\:SI \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0105e-13 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=5.65e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp13 (\4\:Dbp \2\:SEb net441 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.04551e-07 sb=4.6e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp11 (\5\:Db \6\:SE \4\:Dbp VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.41e-14 ad=8.775e-14 ps=1.16e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.39551e-07 sb=2.25e-07 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(1)
mp10 (\9\:SEb \1\:SE \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.995e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12814e-06 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp1 (net405 qint \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.995e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55705e-07 sb=9.69295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp2 (\7\:Db \2\:E net405 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60705e-07 sb=8.64295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=7.02e-14 ps=1.22e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85705e-07 sb=6.39295e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp3 (net449 \1\:D \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=8.58e-14 ps=1.54e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.50705e-07 sb=3.74295e-07 sd=160n sca=17.4538 \
        scb=0.0152267 scc=0.00128072 m=(1)
mp0 (\7\:Eb \7\:E \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22233e-06 sb=1.4e-07 sd=160n sca=29.3406 \
        scb=0.0316245 scc=0.00259206 m=(1)
ends SEDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:53:04 2012 )
// Library name: gsclib045
// Cell name: SEDFFHQX8
// View name: extracted

simulator lang=spectre

subckt SEDFFHQX8 CK D E Q SE SI VDD VSS
mp55_1__rcx (Q qbint \25\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.87978e-06 sd=160n sca=40.5428 \
        scb=0.0363846 scc=0.00414682 m=(7)
C1 (CK VSS) capacitor c=8.1529e-17
C2 (D VSS) capacitor c=7.80772e-17
C3 (SE VSS) capacitor c=6.92274e-17
C4 (VDD VSS) capacitor c=4.59601e-16
C5 (Q VSS) capacitor c=4.90031e-16
C6 (SI VSS) capacitor c=5.96587e-17
C7 (qbint VSS) capacitor c=3.68109e-16
C8 (n30 VSS) capacitor c=2.04258e-16
C9 (CKb VSS) capacitor c=3.41816e-17
C10 (net509 VSS) capacitor c=1.63557e-18
C11 (mout VSS) capacitor c=5.32121e-17
C12 (Ckbb VSS) capacitor c=3.48563e-17
C13 (n20 VSS) capacitor c=6.09192e-17
C14 (net501 VSS) capacitor c=1.73278e-18
C15 (Dbp VSS) capacitor c=4.49659e-17
C16 (qint VSS) capacitor c=5.28898e-17
C17 (net518 VSS) capacitor c=3.88713e-18
C18 (Db VSS) capacitor c=5.15247e-17
C19 (SEb VSS) capacitor c=4.96899e-17
C20 (net494 VSS) capacitor c=8.40528e-18
C21 (Eb VSS) capacitor c=4.68262e-17
C22 (net526 VSS) capacitor c=1.16406e-19
C23 (net426 VSS) capacitor c=8.95935e-19
C24 (net417 VSS) capacitor c=7.44544e-18
C25 (net441 VSS) capacitor c=5.18739e-19
C26 (net405 VSS) capacitor c=3.55892e-18
C27 (net449 VSS) capacitor c=4.24268e-18
C28 (\7\:E VSS) capacitor c=6.24011e-17
C29 (\3\:D VSS) capacitor c=7.27917e-17
C30 (\1\:E VSS) capacitor c=5.77938e-17
C31 (\1\:SE VSS) capacitor c=4.76545e-17
C32 (\6\:SE VSS) capacitor c=3.04633e-17
C33 (\2\:SEb VSS) capacitor c=8.96813e-17
C34 (\3\:SI VSS) capacitor c=7.82469e-17
C35 (\25\:qbint VSS) capacitor c=1.46982e-16
C36 (\7\:Ckbb VSS) capacitor c=3.76976e-17
C37 (\4\:CKb VSS) capacitor c=9.36709e-17
C38 (\5\:CKb VSS) capacitor c=1.08665e-16
C39 (\24\:qbint VSS) capacitor c=4.64206e-17
C40 (\3\:CK VSS) capacitor c=3.095e-17
C41 (\5\:E VSS) capacitor c=2.98443e-17
C42 (\1\:D VSS) capacitor c=7.73452e-17
C43 (\3\:E VSS) capacitor c=6.45411e-17
C44 (\3\:Eb VSS) capacitor c=6.48254e-17
C45 (\4\:qint VSS) capacitor c=5.62033e-17
C46 (\5\:SE VSS) capacitor c=4.43985e-17
C47 (\3\:SEb VSS) capacitor c=3.09229e-17
C48 (\4\:SE VSS) capacitor c=6.78613e-17
C49 (\1\:SI VSS) capacitor c=3.16003e-17
C50 (\7\:CKb VSS) capacitor c=2.78333e-17
C51 (\8\:CKb VSS) capacitor c=2.92302e-17
C52 (\5\:Ckbb VSS) capacitor c=5.63303e-17
C53 (\3\:mout VSS) capacitor c=6.58493e-17
C54 (\3\:n20 VSS) capacitor c=2.66587e-17
C55 (\3\:Ckbb VSS) capacitor c=3.10913e-17
C56 (\9\:CKb VSS) capacitor c=4.92257e-17
C57 (\22\:qbint VSS) capacitor c=9.15952e-17
C58 (\1\:CK VSS) capacitor c=3.64253e-17
C59 (\6\:E VSS) capacitor c=5.22185e-17
C60 (\2\:D VSS) capacitor c=7.99372e-17
C61 (\4\:E VSS) capacitor c=5.07771e-17
C62 (\2\:Eb VSS) capacitor c=6.96303e-17
C63 (\2\:E VSS) capacitor c=4.29444e-17
C64 (\3\:qint VSS) capacitor c=2.82631e-17
C65 (\2\:SE VSS) capacitor c=6.24087e-17
C66 (\4\:SEb VSS) capacitor c=4.76589e-17
C67 (\2\:SI VSS) capacitor c=4.33704e-17
C68 (\8\:Ckbb VSS) capacitor c=2.88778e-17
C69 (\6\:Ckbb VSS) capacitor c=4.67471e-17
C70 (\2\:mout VSS) capacitor c=5.12282e-17
C71 (\2\:n20 VSS) capacitor c=3.72253e-17
C72 (\4\:Ckbb VSS) capacitor c=4.02179e-17
C73 (\6\:CKb VSS) capacitor c=5.94746e-17
C74 (\2\:Ckbb VSS) capacitor c=4.70823e-17
C75 (\23\:qbint VSS) capacitor c=6.86467e-17
C76 (\2\:CK VSS) capacitor c=4.26734e-17
C77 (\6\:Eb VSS) capacitor c=1.02393e-16
C78 (\8\:VDD VSS) capacitor c=3.09411e-17
C79 (\7\:Db VSS) capacitor c=1.24936e-16
C80 (\10\:VDD VSS) capacitor c=2.63997e-17
C81 (\5\:SEb VSS) capacitor c=1.13698e-16
C82 (\5\:Db VSS) capacitor c=7.31837e-17
C83 (\4\:Dbp VSS) capacitor c=6.141e-17
C84 (\6\:qint VSS) capacitor c=2.80722e-16
C85 (\11\:Ckbb VSS) capacitor c=6.74388e-17
C86 (\8\:Dbp VSS) capacitor c=9.52257e-17
C87 (\4\:n20 VSS) capacitor c=1.01299e-16
C88 (\18\:VDD VSS) capacitor c=6.4439e-17
C89 (\8\:mout VSS) capacitor c=5.44953e-17
C90 (\11\:n30 VSS) capacitor c=8.58565e-17
C91 (\22\:VDD VSS) capacitor c=1.30422e-17
C92 (\13\:CKb VSS) capacitor c=6.65577e-17
C93 (\34\:qbint VSS) capacitor c=3.22001e-16
C94 (\1\:VDD VSS) capacitor c=2.3205e-16
C95 (\4\:Eb VSS) capacitor c=8.01061e-17
C96 (\9\:SEb VSS) capacitor c=8.29743e-17
C97 (\9\:Db VSS) capacitor c=3.54327e-17
C98 (\8\:qint VSS) capacitor c=7.28818e-17
C99 (\9\:Ckbb VSS) capacitor c=5.90651e-17
C100 (\6\:Dbp VSS) capacitor c=1.86989e-16
C101 (\8\:n20 VSS) capacitor c=1.74651e-17
C102 (\6\:mout VSS) capacitor c=3.1211e-17
C103 (\13\:n30 VSS) capacitor c=2.26958e-16
C104 (\10\:CKb VSS) capacitor c=4.49217e-17
C105 (\2\:CKb VSS) capacitor c=4.19499e-17
C106 (\3\:CKb VSS) capacitor c=6.34732e-17
C107 (\3\:SE VSS) capacitor c=7.94689e-17
C108 (\2\:qint VSS) capacitor c=4.06148e-17
C109 (\4\:CK VSS) capacitor c=4.8068e-17
C110 (\12\:CKb VSS) capacitor c=9.0757e-17
C111 (\15\:CKb VSS) capacitor c=9.56046e-17
C112 (\15\:n30 VSS) capacitor c=1.81398e-16
C113 (\4\:mout VSS) capacitor c=7.1337e-17
C114 (\5\:mout VSS) capacitor c=6.60804e-17
C115 (\6\:n20 VSS) capacitor c=7.26816e-17
C116 (\7\:n20 VSS) capacitor c=5.86157e-17
C117 (\13\:Ckbb VSS) capacitor c=9.6703e-17
C118 (\14\:Ckbb VSS) capacitor c=1.66219e-16
C119 (\15\:Ckbb VSS) capacitor c=2.12651e-16
C120 (\16\:Ckbb VSS) capacitor c=8.70251e-17
C121 (\17\:Ckbb VSS) capacitor c=6.52475e-17
C122 (\18\:Ckbb VSS) capacitor c=5.03685e-17
C123 (\19\:Ckbb VSS) capacitor c=7.79149e-17
C124 (\32\:qbint VSS) capacitor c=2.84936e-16
C125 (\33\:qbint VSS) capacitor c=4.14301e-16
C126 (\39\:qbint VSS) capacitor c=3.30819e-17
C127 (\40\:qbint VSS) capacitor c=6.81475e-17
C128 (\4\:SI VSS) capacitor c=5.49743e-17
C129 (\3\:Dbp VSS) capacitor c=2.08622e-16
C130 (\7\:SEb VSS) capacitor c=9.73725e-17
C131 (\8\:SEb VSS) capacitor c=8.01058e-17
C132 (\11\:SEb VSS) capacitor c=2.64e-17
C133 (\7\:SE VSS) capacitor c=3.69231e-17
C134 (\5\:qint VSS) capacitor c=2.26743e-16
C135 (\3\:Db VSS) capacitor c=1.17645e-16
C136 (\4\:Db VSS) capacitor c=8.88857e-17
C137 (\4\:D VSS) capacitor c=3.25139e-17
C138 (\8\:E VSS) capacitor c=6.5091e-17
C139 (\9\:E VSS) capacitor c=1.04305e-16
C140 (\10\:E VSS) capacitor c=5.27333e-17
C141 (\8\:Eb VSS) capacitor c=6.63602e-17
C142 (\3\:VDD VSS) capacitor c=1.86271e-17
C143 (\4\:VDD VSS) capacitor c=2.60565e-17
C144 (\6\:VDD VSS) capacitor c=1.13739e-16
C145 (\21\:VDD VSS) capacitor c=5.60444e-19
C146 (\25\:VDD VSS) capacitor c=5.00509e-16
Rk13 (\4\:CK CK) resistor r=0.03487 c=0
Rk62 (D \4\:D) resistor r=0.05675 c=0
Rk68 (\2\:VSS \4\:VSS) resistor r=0.377 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.3459 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.3058 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.2883 c=0
Rk74 (\7\:VSS \10\:VSS) resistor r=0.3434 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.371 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.2807 c=0
Rk77 (\12\:VSS \13\:VSS) resistor r=0.3083 c=0
Rk78 (\13\:VSS \14\:VSS) resistor r=0.1428 c=0
Rk85 (\15\:VSS VSS) resistor r=0.1074 c=0
Rk79 (\14\:VSS \15\:VSS) resistor r=0.3735 c=0
Rk86 (\5\:VSS \22\:VSS) resistor r=0.1786 c=0
Rk89 (\11\:VSS \28\:VSS) resistor r=0.2099 c=0
Rk90 (\13\:VSS \30\:VSS) resistor r=0.1429 c=0
Rk54 (\7\:SE SE) resistor r=0.04807 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.1378 c=0
Rk97 (\3\:VDD \4\:VDD) resistor r=0.3774 c=0
Rk98 (\4\:VDD \5\:VDD) resistor r=0.2346 c=0
Rk99 (\5\:VDD \6\:VDD) resistor r=0.4613 c=0
Rk101 (\3\:VDD \9\:VDD) resistor r=0.1811 c=0
Rk102 (\4\:VDD \11\:VDD) resistor r=0.04332 c=0
Rk105 (\6\:VDD \16\:VDD) resistor r=0.4019 c=0
Rk106 (\16\:VDD \17\:VDD) resistor r=0.356 c=0
Rk107 (\17\:VDD \19\:VDD) resistor r=0.2684 c=0
Rk108 (\17\:VDD \20\:VDD) resistor r=0.3459 c=0
Rk109 (\20\:VDD \21\:VDD) resistor r=0.3861 c=0
Rk110 (\21\:VDD \23\:VDD) resistor r=0.07405 c=0
Rk111 (\21\:VDD \24\:VDD) resistor r=0.06502 c=0
Rk123 (\25\:VDD VDD) resistor r=0.1074 c=0
Rk112 (\24\:VDD \25\:VDD) resistor r=0.3234 c=0
Rk64 (\9\:E E) resistor r=0.006309 c=0
Rk63 (\8\:E \9\:E) resistor r=0.4238 c=0
Rk65 (E \10\:E) resistor r=0.3403 c=0
Rk43 (\4\:SI SI) resistor r=0.1679 c=0
Rk34 (\33\:qbint \34\:qbint) resistor r=0.4736 c=0
Rk33 (\32\:qbint \33\:qbint) resistor r=2.7896 c=0
Rk38 (\34\:qbint \39\:qbint) resistor r=0.1663 c=0
Rk39 (\33\:qbint \40\:qbint) resistor r=0.4168 c=0
Rk17 (\12\:n30 \14\:n30) resistor r=0.4341 c=0
Rk18 (\14\:n30 \15\:n30) resistor r=1.4427 c=0
Rk14 (\11\:CKb \12\:CKb) resistor r=0.2115 c=0
Rk15 (\12\:CKb \14\:CKb) resistor r=0.2896 c=0
Rk16 (\12\:CKb \15\:CKb) resistor r=0.5678 c=0
Rk19 (\4\:mout \5\:mout) resistor r=0.3931 c=0
Rk20 (\5\:mout \7\:mout) resistor r=0.2558 c=0
Rk21 (\5\:mout \9\:mout) resistor r=0.1415 c=0
Rk25 (\10\:Ckbb \12\:Ckbb) resistor r=0.3723 c=0
Rk26 (\12\:Ckbb \13\:Ckbb) resistor r=0.4142 c=0
Rk27 (\13\:Ckbb \14\:Ckbb) resistor r=0.4289 c=0
Rk28 (\14\:Ckbb \15\:Ckbb) resistor r=0.8874 c=0
Rk29 (\15\:Ckbb \16\:Ckbb) resistor r=0.64 c=0
Rk30 (\13\:Ckbb \17\:Ckbb) resistor r=0.2555 c=0
Rk31 (\14\:Ckbb \18\:Ckbb) resistor r=0.1965 c=0
Rk32 (\15\:Ckbb \19\:Ckbb) resistor r=0.3642 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.4855 c=0
Rk23 (\6\:n20 \7\:n20) resistor r=0.3472 c=0
Rk24 (\6\:n20 \9\:n20) resistor r=0.03466 c=0
Rk44 (\2\:Dbp \3\:Dbp) resistor r=0.1445 c=0
Rk45 (\3\:Dbp \5\:Dbp) resistor r=0.2894 c=0
Rk46 (\3\:Dbp \7\:Dbp) resistor r=1.5049 c=0
Rk47 (\7\:Dbp \9\:Dbp) resistor r=0.6037 c=0
Rk55 (\5\:qint \7\:qint) resistor r=1.6831 c=0
Rk56 (\7\:qint \9\:qint) resistor r=0.5034 c=0
Rk57 (\2\:Db \3\:Db) resistor r=0.2918 c=0
Rk58 (\3\:Db \4\:Db) resistor r=0.4428 c=0
Rk59 (\4\:Db \6\:Db) resistor r=0.4566 c=0
Rk60 (\3\:Db \8\:Db) resistor r=0.7311 c=0
Rk61 (\4\:Db \10\:Db) resistor r=0.07228 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.735 c=0
Rk49 (\7\:SEb \8\:SEb) resistor r=0.1539 c=0
Rk50 (\8\:SEb \10\:SEb) resistor r=0.5759 c=0
Rk51 (\8\:SEb \11\:SEb) resistor r=0.05355 c=0
Rk66 (\5\:Eb \7\:Eb) resistor r=0.7352 c=0
Rk67 (\7\:Eb \8\:Eb) resistor r=0.4553 c=0
Rl31 (\2\:CK \3\:CK) resistor r=41.7582 c=0
Rl30 (\1\:CK \2\:CK) resistor r=90.3846 c=0
Rl73 (\2\:D \3\:D) resistor r=96.9426 c=0
Rl72 (\1\:D \2\:D) resistor r=114.617 c=0
Rl60 (\1\:SE \2\:SE) resistor r=106.502 c=0
Rl63 (\2\:SE \5\:SE) resistor r=132.487 c=0
Rl64 (\3\:SE \6\:SE) resistor r=35.772 c=0
Rl62 (\3\:SE \4\:SE) resistor r=175.722 c=0
Rl61 (\2\:SE \3\:SE) resistor r=191.222 c=0
Rl75 (\6\:E \7\:E) resistor r=192.285 c=0
Rl74 (\5\:E \6\:E) resistor r=61.3335 c=0
Rl71 (\3\:E \4\:E) resistor r=49.2328 c=0
Rl68 (\1\:E \2\:E) resistor r=33.7903 c=0
Rl57 (\2\:SI \3\:SI) resistor r=78.6942 c=0
Rl56 (\1\:SI \2\:SI) resistor r=48.4455 c=0
Rl34 (\23\:qbint \24\:qbint) resistor r=24.2328 c=0
Rl33 (\23\:qbint \22\:qbint) resistor r=154.568 c=0
Rl45 (\4\:CKb \5\:CKb) resistor r=530.335 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=216.873 c=0
Rl49 (\6\:CKb \9\:CKb) resistor r=28.2967 c=0
Rl42 (CKb \2\:CKb) resistor r=121.413 c=0
Rl47 (\2\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl44 (\3\:CKb \4\:CKb) resistor r=106.926 c=0
Rl48 (\3\:CKb \8\:CKb) resistor r=45.3874 c=0
Rl43 (\2\:CKb \3\:CKb) resistor r=264.3 c=0
Rl38 (mout \2\:mout) resistor r=37.5309 c=0
Rl39 (\2\:mout \3\:mout) resistor r=94.0258 c=0
Rl41 (\7\:Ckbb \8\:Ckbb) resistor r=24.2328 c=0
Rl40 (\5\:Ckbb \6\:Ckbb) resistor r=63.0341 c=0
Rl35 (\3\:Ckbb \4\:Ckbb) resistor r=53.079 c=0
Rl32 (Ckbb \2\:Ckbb) resistor r=24.2328 c=0
Rl36 (n20 \2\:n20) resistor r=103.079 c=0
Rl37 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl65 (\2\:qint qint) resistor r=37.3411 c=0
Rl67 (\2\:qint \4\:qint) resistor r=175.803 c=0
Rl66 (\2\:qint \3\:qint) resistor r=10.9341 c=0
Rl58 (SEb \2\:SEb) resistor r=111.516 c=0
Rl59 (\3\:SEb \4\:SEb) resistor r=47.3097 c=0
Rl69 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl70 (\2\:Eb \3\:Eb) resistor r=199.326 c=0
Rz19 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz20 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz24 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz30 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz31 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz32 (\6\:VDD \1\:VDD) resistor r=75 c=0
Rz33 (\16\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz34 (\20\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz35 (\24\:VDD \1\:VDD) resistor r=37.5 c=0
Rz36 (\25\:VDD \1\:VDD) resistor r=6.25 c=0
Rz6 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz5 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz7 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz8 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Dbp \2\:Dbp) resistor r=75 c=0
Rz13 (\6\:Dbp \7\:Dbp) resistor r=75 c=0
Rz15 (\9\:qint \8\:qint) resistor r=75 c=0
Rz16 (Db \2\:Db) resistor r=75 c=0
Rz17 (\9\:Db \10\:Db) resistor r=75 c=0
Rz14 (\9\:SEb \10\:SEb) resistor r=75 c=0
Rz18 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry19 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry20 (\6\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry21 (\7\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry22 (\10\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry23 (\12\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry24 (\14\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry25 (\15\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry26 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry27 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry30 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry6 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry5 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry7 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\11\:Ckbb \12\:Ckbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\4\:Dbp \5\:Dbp) resistor r=62 c=0
Ry13 (\8\:Dbp \9\:Dbp) resistor r=62 c=0
Ry15 (\7\:qint \6\:qint) resistor r=20.6667 c=0
Ry16 (\5\:Db \6\:Db) resistor r=62 c=0
Ry17 (\7\:Db \8\:Db) resistor r=20.6667 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry18 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:D \4\:D) resistor r=45 c=0
Rx16 (\2\:SE \7\:SE) resistor r=45 c=0
Rx19 (\2\:E \8\:E) resistor r=45 c=0
Rx20 (\4\:E \9\:E) resistor r=45 c=0
Rx21 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\2\:SI \4\:SI) resistor r=45 c=0
Rx10 (\32\:qbint \25\:qbint) resistor r=45 c=0
Rx11 (\39\:qbint qbint) resistor r=45 c=0
Rx12 (\40\:qbint \23\:qbint) resistor r=45 c=0
Rx3 (\15\:n30 n30) resistor r=45 c=0
Rx2 (\6\:CKb \15\:CKb) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx6 (\2\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx7 (\8\:Ckbb \17\:Ckbb) resistor r=45 c=0
Rx8 (\6\:Ckbb \18\:Ckbb) resistor r=45 c=0
Rx9 (\4\:Ckbb \19\:Ckbb) resistor r=45 c=0
Rx5 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\5\:qint \3\:qint) resistor r=45 c=0
Rx14 (SEb \7\:SEb) resistor r=45 c=0
Rx15 (\4\:SEb \11\:SEb) resistor r=45 c=0
Rx22 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn55_1__rcx (Q qbint \15\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\34\:qbint n30 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.797e-14 ad=4.723e-14 ps=9.0333e-07 pd=8.8333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=6.65e-07 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(3)
mn20 (\10\:CKb \1\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.787e-14 ad=2.755e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mn50 (net509 \22\:qbint \29\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.787e-14 ad=1.23e-14 ps=1.24e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.78e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\13\:n30 \9\:CKb net509 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.637e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4378e-07 sb=1.675e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\13\:n30 \3\:Ckbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.0865e-13 ad=5.638e-14 ps=1.47e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6378e-07 sb=1.355e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\6\:mout \3\:n20 \27\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=1.0865e-13 ps=7.3e-07 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43878e-06 sb=7.8e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net501 \3\:mout \27\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.742e-14 ps=7.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64378e-06 sb=5.75e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\8\:n20 \5\:Ckbb net501 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.743e-14 ad=3.28e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77378e-06 sb=4.45e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (\8\:n20 \8\:CKb \6\:Dbp VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.92e-14 ad=3.28e-14 ps=8.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91512e-06 sb=2.4e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn21 (\9\:Ckbb \7\:CKb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.443e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.665e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn56_1__rcx (\8\:qint \25\:qbint \7\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=8.296e-14 ad=4.94e-14 ps=1.285e-06 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=4.20192e-07 sb=1.23e-06 sd=160n \
        sca=8.65991 scb=0.00681295 scc=0.000165238 m=(2)
mn12 (net518 \1\:SI \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.42e-14 ps=1.07e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75192e-07 sb=6.75e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn13 (Dbp \4\:SE net518 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=7.15e-14 ps=8.6e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.19019e-06 sb=4.6e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn11 (\9\:Db \3\:SEb Dbp VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=3.64e-14 ps=1.07e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51019e-06 sb=1.4e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn10 (\9\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06948e-06 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (net494 \4\:qint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=7.15e-14 ps=9.6e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.70096e-07 sb=9.30769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (Db \3\:Eb net494 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=4.16e-14 ps=1.07e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.90096e-07 sb=6.10769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn4 (Db \3\:E net526 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.95096e-07 sb=4.05769e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn3 (net526 \1\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=1.56e-14 ps=1.07e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.00096e-07 sb=3.00769e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn0 (\4\:Eb \5\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.138e-14 ad=2.03e-14 ps=1.07e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1131e-06 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mp45_1__rcx (\34\:qbint n30 \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.423e-14 ad=5.62e-14 ps=1.13667e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.575e-06 sb=5.22308e-07 sd=160n \
        sca=18.3796 scb=0.0159892 scc=0.00159615 m=(3)
mp20 (\13\:CKb \3\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.833e-14 ad=3.77e-14 ps=2.02e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75349e-07 sb=2e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (net426 \24\:qbint \22\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.833e-14 ad=4.185e-14 ps=2.02e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42903e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp51 (\11\:n30 Ckbb net426 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=1.4725e-13 ps=8.9e-07 pd=1.57e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22903e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\11\:n30 \5\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.3485e-13 ad=1.4725e-13 ps=1.49e-06 pd=1.57e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.0429e-06 sb=1.48e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\8\:mout n20 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=1.3485e-13 ps=1.32e-06 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5229e-06 sb=1e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp35 (net417 mout \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7879e-06 sb=7.35e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:Ckbb \8\:Dbp VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=5.58e-14 ps=1.09e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp36 (\4\:n20 \4\:CKb net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=5.58e-14 ps=1.08e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95863e-06 sb=4.6e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\11\:Ckbb CKb \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.2625e-13 ad=3.01e-14 ps=2.36e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54e-06 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp56 (\6\:qint \25\:qbint \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.0797e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.61859e-07 sb=1.105e-06 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(2)
mp12 (net441 \3\:SI \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.97e-14 ad=2.34e-14 ps=1.24e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.41859e-07 sb=6.25e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp13 (\4\:Dbp \2\:SEb net441 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.2675e-13 ps=9e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.46859e-07 sb=5.2e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp11 (\5\:Db \6\:SE \4\:Dbp VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2675e-13 ad=5.85e-14 ps=1.43e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.31686e-06 sb=1.5e-07 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(1)
mp10 (\5\:SEb \1\:SE \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.12e-14 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.1436e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp1 (net405 qint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.12e-14 ad=3.9e-14 ps=1.68e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=7.89551e-07 sd=160n sca=11.5347 \
        scb=0.00974379 scc=0.00025826 m=(1)
mp2 (\7\:Db \1\:E net405 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=6.24e-14 ps=9.8e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.13141e-07 sb=6.44551e-07 sd=160n sca=11.5347 \
        scb=0.00974379 scc=0.00025826 m=(1)
mp4 (\7\:Db Eb net449 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.18141e-07 sb=4.39551e-07 sd=160n sca=11.7928 \
        scb=0.00981106 scc=0.000258271 m=(1)
mp3 (net449 \3\:D \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.875e-14 ps=1.16e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.88141e-07 sb=2.69551e-07 sd=160n sca=12.4181 \
        scb=0.0101715 scc=0.000258557 m=(1)
mp0 (\6\:Eb \7\:E \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13872e-06 sb=1.4e-07 sd=160n sca=15.5146 \
        scb=0.0146627 scc=0.000413871 m=(1)
ends SEDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:53:42 2012 )
// Library name: gsclib045
// Cell name: SEDFFTRX1
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX1 CK D E Q QN RN SE SI VDD VSS
mp57 (\3\:QN \4\:net582 \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
C1 (D VSS) capacitor c=6.13647e-17
C2 (QN VSS) capacitor c=1.67914e-17
C3 (SE VSS) capacitor c=2.40182e-17
C4 (E VSS) capacitor c=2.36125e-17
C5 (SI VSS) capacitor c=4.56151e-17
C6 (VDD VSS) capacitor c=5.41663e-16
C7 (RN VSS) capacitor c=5.15101e-17
C8 (net582 VSS) capacitor c=2.18917e-17
C9 (qbint VSS) capacitor c=1.71085e-17
C10 (n30 VSS) capacitor c=3.16153e-17
C11 (net618 VSS) capacitor c=1.73213e-18
C12 (CKb VSS) capacitor c=3.30496e-17
C13 (mout VSS) capacitor c=6.42688e-17
C14 (CKbb VSS) capacitor c=5.65367e-17
C15 (n20 VSS) capacitor c=4.85548e-17
C16 (Dpb VSS) capacitor c=6.71213e-17
C17 (SEb VSS) capacitor c=4.28816e-17
C18 (net658 VSS) capacitor c=6.34019e-18
C19 (Dp VSS) capacitor c=3.72837e-17
C20 (RNb VSS) capacitor c=3.61522e-17
C21 (net634 VSS) capacitor c=2.06852e-18
C22 (Eb VSS) capacitor c=5.32187e-17
C23 (Db VSS) capacitor c=9.11819e-17
C24 (net529 VSS) capacitor c=3.92877e-19
C25 (net521 VSS) capacitor c=1.06974e-18
C26 (net557 VSS) capacitor c=3.86201e-18
C27 (net549 VSS) capacitor c=1.41178e-18
C28 (net493 VSS) capacitor c=8.65123e-17
C29 (net505 VSS) capacitor c=8.25146e-17
C30 (\1\:D VSS) capacitor c=3.18642e-17
C31 (\4\:E VSS) capacitor c=3.92327e-17
C32 (\2\:Db VSS) capacitor c=5.88245e-17
C33 (\3\:E VSS) capacitor c=4.00264e-17
C34 (\11\:qbint VSS) capacitor c=5.13222e-17
C35 (\3\:RNb VSS) capacitor c=5.81932e-17
C36 (\1\:RN VSS) capacitor c=3.16818e-17
C37 (\7\:qbint VSS) capacitor c=3.4351e-17
C38 (\4\:SE VSS) capacitor c=3.88098e-17
C39 (\1\:SI VSS) capacitor c=4.9475e-17
C40 (\1\:SE VSS) capacitor c=4.1994e-17
C41 (\1\:CK VSS) capacitor c=3.75431e-17
C42 (\7\:CKbb VSS) capacitor c=3.65604e-17
C43 (\4\:CKb VSS) capacitor c=1.35888e-16
C44 (\5\:CKb VSS) capacitor c=1.23411e-16
C45 (\4\:qbint VSS) capacitor c=5.50902e-17
C46 (\3\:n30 VSS) capacitor c=3.3564e-17
C47 (\2\:qbint VSS) capacitor c=3.12666e-17
C48 (\4\:net582 VSS) capacitor c=4.41687e-17
C49 (\3\:D VSS) capacitor c=2.81498e-17
C50 (\7\:E VSS) capacitor c=2.76059e-17
C51 (\1\:E VSS) capacitor c=6.89023e-17
C52 (\3\:Eb VSS) capacitor c=4.58418e-17
C53 (\10\:qbint VSS) capacitor c=9.89084e-17
C54 (\3\:RN VSS) capacitor c=4.21544e-17
C55 (\9\:qbint VSS) capacitor c=4.68394e-17
C56 (\3\:Dp VSS) capacitor c=4.80505e-17
C57 (\3\:SEb VSS) capacitor c=6.42396e-17
C58 (\6\:SE VSS) capacitor c=2.55259e-17
C59 (\3\:SI VSS) capacitor c=2.58237e-17
C60 (\3\:SE VSS) capacitor c=2.16702e-17
C61 (\3\:CK VSS) capacitor c=3.72748e-17
C62 (\8\:CKb VSS) capacitor c=2.67857e-17
C63 (\9\:CKb VSS) capacitor c=2.19617e-17
C64 (\5\:CKbb VSS) capacitor c=8.12345e-17
C65 (\3\:mout VSS) capacitor c=6.68869e-17
C66 (\3\:n20 VSS) capacitor c=3.18856e-17
C67 (\3\:CKbb VSS) capacitor c=5.9813e-17
C68 (\6\:CKb VSS) capacitor c=8.63827e-17
C69 (\5\:qbint VSS) capacitor c=5.56319e-17
C70 (\3\:qbint VSS) capacitor c=4.47844e-17
C71 (\3\:net582 VSS) capacitor c=3.88455e-17
C72 (\2\:D VSS) capacitor c=2.95666e-17
C73 (\6\:E VSS) capacitor c=2.82471e-17
C74 (\3\:Db VSS) capacitor c=1.94254e-17
C75 (\2\:E VSS) capacitor c=6.9791e-17
C76 (\2\:Eb VSS) capacitor c=4.33112e-17
C77 (\12\:qbint VSS) capacitor c=3.43087e-17
C78 (\2\:RNb VSS) capacitor c=6.1329e-17
C79 (\2\:RN VSS) capacitor c=3.56552e-17
C80 (\8\:qbint VSS) capacitor c=2.29126e-17
C81 (\2\:Dp VSS) capacitor c=3.61147e-17
C82 (\4\:SEb VSS) capacitor c=3.03195e-17
C83 (\5\:SE VSS) capacitor c=3.78757e-17
C84 (\2\:SEb VSS) capacitor c=3.24596e-17
C85 (\2\:SI VSS) capacitor c=2.74447e-17
C86 (\2\:SE VSS) capacitor c=2.25785e-17
C87 (\2\:CK VSS) capacitor c=3.86606e-17
C88 (\7\:CKb VSS) capacitor c=2.53113e-17
C89 (\8\:CKbb VSS) capacitor c=5.05284e-17
C90 (\6\:CKbb VSS) capacitor c=2.46806e-17
C91 (\2\:mout VSS) capacitor c=5.30928e-17
C92 (\2\:n20 VSS) capacitor c=3.3496e-17
C93 (\4\:CKbb VSS) capacitor c=2.05943e-17
C94 (\2\:CKbb VSS) capacitor c=5.78057e-17
C95 (\6\:qbint VSS) capacitor c=3.20773e-17
C96 (\2\:n30 VSS) capacitor c=3.56761e-17
C97 (\4\:Db VSS) capacitor c=1.12634e-16
C98 (\14\:VDD VSS) capacitor c=1.89352e-17
C99 (\4\:Eb VSS) capacitor c=5.20501e-17
C100 (\4\:Dp VSS) capacitor c=7.33436e-17
C101 (\10\:Dp VSS) capacitor c=2.17549e-17
C102 (\3\:net505 VSS) capacitor c=7.56082e-17
C103 (\3\:net493 VSS) capacitor c=6.66915e-17
C104 (\16\:VDD VSS) capacitor c=1.68051e-17
C105 (\6\:RNb VSS) capacitor c=5.51e-17
C106 (\3\:Q VSS) capacitor c=7.1096e-17
C107 (\18\:VDD VSS) capacitor c=4.81468e-17
C108 (\3\:Dpb VSS) capacitor c=2.80557e-16
C109 (\20\:VDD VSS) capacitor c=3.06513e-17
C110 (\8\:SEb VSS) capacitor c=1.36108e-16
C111 (\10\:CKb VSS) capacitor c=6.10584e-17
C112 (\22\:VDD VSS) capacitor c=2.72511e-17
C113 (\9\:CKbb VSS) capacitor c=5.98125e-17
C114 (\5\:Dpb VSS) capacitor c=2.41761e-16
C115 (\4\:n20 VSS) capacitor c=4.95376e-17
C116 (\24\:VDD VSS) capacitor c=6.78798e-17
C117 (\8\:mout VSS) capacitor c=5.60098e-17
C118 (\8\:n30 VSS) capacitor c=3.5398e-17
C119 (\26\:VDD VSS) capacitor c=4.3196e-17
C120 (\16\:qbint VSS) capacitor c=8.96862e-17
C121 (\5\:net582 VSS) capacitor c=3.46273e-17
C122 (\28\:VDD VSS) capacitor c=8.746e-17
C123 (\3\:QN VSS) capacitor c=5.43276e-17
C124 (\1\:VDD VSS) capacitor c=1.69716e-16
C125 (\7\:Db VSS) capacitor c=4.51127e-17
C126 (\8\:Eb VSS) capacitor c=2.17546e-17
C127 (\13\:Dp VSS) capacitor c=1.11837e-16
C128 (\8\:Dp VSS) capacitor c=9.32731e-17
C129 (\8\:RNb VSS) capacitor c=4.80151e-17
C130 (\1\:Q VSS) capacitor c=8.06507e-17
C131 (\6\:SEb VSS) capacitor c=1.77408e-16
C132 (\14\:CKb VSS) capacitor c=2.96521e-17
C133 (\11\:CKbb VSS) capacitor c=7.31016e-17
C134 (\7\:Dpb VSS) capacitor c=8.83327e-17
C135 (\8\:n20 VSS) capacitor c=3.08803e-17
C136 (\6\:mout VSS) capacitor c=4.90721e-17
C137 (\4\:n30 VSS) capacitor c=6.81856e-17
C138 (\20\:qbint VSS) capacitor c=4.62242e-17
C139 (\9\:net582 VSS) capacitor c=1.58264e-17
C140 (\1\:QN VSS) capacitor c=9.56343e-18
C141 (\2\:net582 VSS) capacitor c=7.96892e-18
C142 (\2\:CKb VSS) capacitor c=2.89787e-17
C143 (\3\:CKb VSS) capacitor c=7.522e-17
C144 (\7\:net582 VSS) capacitor c=2.26886e-17
C145 (\8\:net582 VSS) capacitor c=3.14706e-17
C146 (\6\:n30 VSS) capacitor c=8.50226e-17
C147 (\7\:n30 VSS) capacitor c=7.54775e-17
C148 (\4\:mout VSS) capacitor c=7.56061e-17
C149 (\5\:mout VSS) capacitor c=6.85978e-17
C150 (\6\:n20 VSS) capacitor c=6.70608e-17
C151 (\7\:n20 VSS) capacitor c=5.78541e-17
C152 (\5\:E VSS) capacitor c=2.63273e-17
C153 (\13\:CKbb VSS) capacitor c=5.68914e-17
C154 (\14\:CKbb VSS) capacitor c=6.81366e-17
C155 (\15\:CKbb VSS) capacitor c=1.0047e-16
C156 (\16\:CKbb VSS) capacitor c=8.67724e-17
C157 (\17\:CKbb VSS) capacitor c=8.86206e-17
C158 (\4\:CK VSS) capacitor c=3.8465e-17
C159 (\6\:CK VSS) capacitor c=6.30987e-17
C160 (\12\:CKb VSS) capacitor c=5.25944e-17
C161 (\13\:CKb VSS) capacitor c=5.04146e-17
C162 (\4\:SI VSS) capacitor c=8.26695e-17
C163 (\7\:SE VSS) capacitor c=1.03556e-16
C164 (\8\:SE VSS) capacitor c=1.11818e-16
C165 (\9\:SE VSS) capacitor c=2.53178e-17
C166 (\5\:SEb VSS) capacitor c=1.34464e-16
C167 (\10\:SEb VSS) capacitor c=1.06641e-16
C168 (\4\:RN VSS) capacitor c=7.37652e-17
C169 (\4\:RNb VSS) capacitor c=6.40982e-17
C170 (\5\:RNb VSS) capacitor c=5.66318e-17
C171 (\13\:qbint VSS) capacitor c=9.37447e-17
C172 (\14\:qbint VSS) capacitor c=5.04668e-16
C173 (\15\:qbint VSS) capacitor c=4.45383e-16
C174 (\18\:qbint VSS) capacitor c=5.54211e-17
C175 (\19\:qbint VSS) capacitor c=2.15878e-17
C176 (\22\:qbint VSS) capacitor c=3.79164e-17
C177 (\6\:Dp VSS) capacitor c=1.12208e-16
C178 (\7\:Dp VSS) capacitor c=2.43334e-16
C179 (\12\:Dp VSS) capacitor c=1.8314e-16
C180 (\8\:E VSS) capacitor c=5.84558e-17
C181 (\9\:E VSS) capacitor c=8.13625e-17
C182 (\6\:Eb VSS) capacitor c=1.09134e-16
C183 (\7\:Eb VSS) capacitor c=1.53496e-16
C184 (\4\:D VSS) capacitor c=4.96658e-17
C185 (\6\:Db VSS) capacitor c=8.3307e-17
C186 (\3\:VDD VSS) capacitor c=5.59167e-18
C187 (\6\:VDD VSS) capacitor c=4.2185e-17
C188 (\7\:VDD VSS) capacitor c=3.95414e-17
C189 (\9\:VDD VSS) capacitor c=3.63008e-17
C190 (\10\:VDD VSS) capacitor c=5.79373e-17
C191 (\12\:VDD VSS) capacitor c=1.26988e-17
C192 (\13\:VDD VSS) capacitor c=1.55527e-17
Rk63 (\4\:D D) resistor r=0.1696 c=0
Rk1 (QN \2\:QN) resistor r=0.03908 c=0
Rk2 (QN \4\:QN) resistor r=0.2585 c=0
Rk29 (\8\:SE SE) resistor r=0.0121 c=0
Rk28 (\7\:SE \8\:SE) resistor r=0.8009 c=0
Rk30 (\8\:SE \9\:SE) resistor r=0.08252 c=0
Rk58 (E \8\:E) resistor r=0.03641 c=0
Rk59 (\8\:E \9\:E) resistor r=0.2615 c=0
Rk27 (SI \4\:SI) resistor r=0.0195 c=0
Rk66 (\2\:VDD \3\:VDD) resistor r=0.09764 c=0
Rk67 (\3\:VDD \4\:VDD) resistor r=0.1528 c=0
Rk68 (\4\:VDD \5\:VDD) resistor r=0.8036 c=0
Rk69 (\5\:VDD \6\:VDD) resistor r=0.4467 c=0
Rk70 (\6\:VDD \7\:VDD) resistor r=0.5004 c=0
Rk71 (\7\:VDD \8\:VDD) resistor r=0.2547 c=0
Rk72 (\8\:VDD \9\:VDD) resistor r=0.187 c=0
Rk73 (\9\:VDD \10\:VDD) resistor r=0.5481 c=0
Rk74 (\10\:VDD \11\:VDD) resistor r=0.4664 c=0
Rk75 (\11\:VDD \12\:VDD) resistor r=0.07757 c=0
Rk77 (\13\:VDD VDD) resistor r=0.1074 c=0
Rk76 (\12\:VDD \13\:VDD) resistor r=0.3659 c=0
Rk78 (\3\:VDD \15\:VDD) resistor r=0.1278 c=0
Rk79 (\5\:VDD \17\:VDD) resistor r=0.0715 c=0
Rk80 (\6\:VDD \19\:VDD) resistor r=0.2064 c=0
Rk81 (\7\:VDD \21\:VDD) resistor r=0.04333 c=0
Rk82 (\9\:VDD \23\:VDD) resistor r=0.04333 c=0
Rk83 (\10\:VDD \25\:VDD) resistor r=0.3046 c=0
Rk84 (\12\:VDD \27\:VDD) resistor r=0.2064 c=0
Rk85 (\13\:VDD \29\:VDD) resistor r=0.4131 c=0
Rk21 (\4\:CK \5\:CK) resistor r=0.001437 c=0
Rk22 (CK \6\:CK) resistor r=0.001365 c=0
Rk23 (\4\:CK \6\:CK) resistor r=0.07063 c=0
Rk37 (\2\:Q Q) resistor r=0.04342 c=0
Rk38 (Q \4\:Q) resistor r=0.267 c=0
Rk86 (\2\:VSS \4\:VSS) resistor r=0.6882 c=0
Rk87 (\4\:VSS \5\:VSS) resistor r=0.1579 c=0
Rk88 (\5\:VSS \6\:VSS) resistor r=0.115 c=0
Rk89 (\6\:VSS \7\:VSS) resistor r=0.2429 c=0
Rk90 (\7\:VSS \8\:VSS) resistor r=0.5373 c=0
Rk91 (\5\:VSS \10\:VSS) resistor r=0.19 c=0
Rk92 (\6\:VSS \12\:VSS) resistor r=0.2008 c=0
Rk93 (\7\:VSS \14\:VSS) resistor r=0.2709 c=0
Rk94 (\8\:VSS \15\:VSS) resistor r=0.5392 c=0
Rk95 (\15\:VSS \16\:VSS) resistor r=0.213 c=0
Rk96 (\16\:VSS \17\:VSS) resistor r=0.203 c=0
Rk97 (\17\:VSS \18\:VSS) resistor r=0.198 c=0
Rk98 (\18\:VSS \19\:VSS) resistor r=0.336 c=0
Rk99 (\19\:VSS \20\:VSS) resistor r=0.4664 c=0
Rk100 (\20\:VSS \21\:VSS) resistor r=0.05249 c=0
Rk102 (\22\:VSS VSS) resistor r=0.1074 c=0
Rk101 (\21\:VSS \22\:VSS) resistor r=0.391 c=0
Rk103 (\8\:VSS \24\:VSS) resistor r=0.3506 c=0
Rk104 (\15\:VSS \26\:VSS) resistor r=0.1029 c=0
Rk105 (\17\:VSS \28\:VSS) resistor r=0.2171 c=0
Rk106 (\19\:VSS \30\:VSS) resistor r=0.123 c=0
Rk107 (\21\:VSS \32\:VSS) resistor r=0.3679 c=0
Rk108 (\22\:VSS \34\:VSS) resistor r=0.2886 c=0
Rk39 (RN \4\:RN) resistor r=0.08752 c=0
Rk3 (\6\:net582 \7\:net582) resistor r=0.13 c=0
Rk4 (\7\:net582 \8\:net582) resistor r=0.1226 c=0
Rk5 (\7\:net582 \10\:net582) resistor r=0.0939 c=0
Rk43 (\13\:qbint \14\:qbint) resistor r=0.8565 c=0
Rk44 (\14\:qbint \15\:qbint) resistor r=3.3628 c=0
Rk45 (\15\:qbint \17\:qbint) resistor r=0.412 c=0
Rk46 (\14\:qbint \18\:qbint) resistor r=0.253 c=0
Rk47 (\15\:qbint \19\:qbint) resistor r=0.03527 c=0
Rk48 (\17\:qbint \21\:qbint) resistor r=0.437 c=0
Rk49 (\17\:qbint \22\:qbint) resistor r=0.2281 c=0
Rk6 (\5\:n30 \6\:n30) resistor r=0.3394 c=0
Rk7 (\6\:n30 \7\:n30) resistor r=0.4232 c=0
Rk8 (\6\:n30 \9\:n30) resistor r=0.05919 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.3426 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.2254 c=0
Rk26 (\12\:CKb \15\:CKb) resistor r=0.1298 c=0
Rk9 (\4\:mout \5\:mout) resistor r=0.3387 c=0
Rk10 (\5\:mout \7\:mout) resistor r=0.2599 c=0
Rk11 (\5\:mout \9\:mout) resistor r=0.185 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.4361 c=0
Rk16 (\12\:CKbb \13\:CKbb) resistor r=0.2609 c=0
Rk17 (\13\:CKbb \14\:CKbb) resistor r=0.1721 c=0
Rk18 (\14\:CKbb \15\:CKbb) resistor r=0.5416 c=0
Rk19 (\15\:CKbb \16\:CKbb) resistor r=0.5831 c=0
Rk20 (\13\:CKbb \17\:CKbb) resistor r=0.4083 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2925 c=0
Rk13 (\6\:n20 \7\:n20) resistor r=0.3095 c=0
Rk14 (\6\:n20 \9\:n20) resistor r=0.1352 c=0
Rk31 (\2\:Dpb \4\:Dpb) resistor r=0.4142 c=0
Rk32 (\4\:Dpb \6\:Dpb) resistor r=1.6426 c=0
Rk33 (\6\:Dpb \8\:Dpb) resistor r=0.4468 c=0
Rk34 (\5\:SEb \7\:SEb) resistor r=1.0724 c=0
Rk35 (\7\:SEb \9\:SEb) resistor r=0.4831 c=0
Rk36 (\9\:SEb \10\:SEb) resistor r=0.6472 c=0
Rk52 (\5\:Dp \6\:Dp) resistor r=0.3391 c=0
Rk53 (\6\:Dp \7\:Dp) resistor r=0.6329 c=0
Rk54 (\7\:Dp \9\:Dp) resistor r=0.071 c=0
Rk55 (\6\:Dp \11\:Dp) resistor r=0.04671 c=0
Rk56 (\7\:Dp \12\:Dp) resistor r=1.4712 c=0
Rk57 (\9\:Dp \14\:Dp) resistor r=0.7253 c=0
Rk40 (\4\:RNb \5\:RNb) resistor r=0.2829 c=0
Rk41 (\5\:RNb \7\:RNb) resistor r=0.2469 c=0
Rk42 (\5\:RNb \9\:RNb) resistor r=0.2138 c=0
Rk60 (\5\:Eb \6\:Eb) resistor r=0.2365 c=0
Rk61 (\6\:Eb \7\:Eb) resistor r=0.8246 c=0
Rk62 (\6\:Eb \9\:Eb) resistor r=0.06371 c=0
Rk64 (\5\:Db \6\:Db) resistor r=0.777 c=0
Rk65 (\5\:Db \8\:Db) resistor r=0.357 c=0
Rk50 (\2\:net493 \4\:net493) resistor r=0.3328 c=0
Rk51 (\2\:net505 \4\:net505) resistor r=0.5124 c=0
Rl55 (\1\:D \2\:D) resistor r=39.6174 c=0
Rl56 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl33 (\4\:SE \5\:SE) resistor r=74.9772 c=0
Rl34 (\5\:SE \6\:SE) resistor r=24.7951 c=0
Rl28 (\1\:SE \2\:SE) resistor r=61.5385 c=0
Rl29 (\2\:SE \3\:SE) resistor r=29.9451 c=0
Rl49 (\2\:E \3\:E) resistor r=61.5157 c=0
Rl48 (\1\:E \2\:E) resistor r=134.41 c=0
Rl52 (\4\:E \5\:E) resistor r=47.3105 c=0
Rl54 (\5\:E \7\:E) resistor r=55.0028 c=0
Rl53 (\5\:E \6\:E) resistor r=92.681 c=0
Rl30 (\1\:SI \2\:SI) resistor r=60.3072 c=0
Rl31 (\2\:SI \3\:SI) resistor r=29.5379 c=0
Rl26 (\1\:CK \2\:CK) resistor r=53.8462 c=0
Rl27 (\2\:CK \3\:CK) resistor r=100.676 c=0
Rl40 (\1\:RN \2\:RN) resistor r=29.5379 c=0
Rl41 (\2\:RN \3\:RN) resistor r=139.153 c=0
Rl1 (net582 \2\:net582) resistor r=5.915 c=0
Rl3 (\2\:net582 \4\:net582) resistor r=49.7141 c=0
Rl2 (\2\:net582 \3\:net582) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=31.0981 c=0
Rl44 (\10\:qbint \11\:qbint) resistor r=209.181 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=167.308 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=92.3077 c=0
Rl45 (\11\:qbint \12\:qbint) resistor r=32.908 c=0
Rl38 (\7\:qbint \8\:qbint) resistor r=29.5379 c=0
Rl39 (\8\:qbint \9\:qbint) resistor r=56.461 c=0
Rl9 (\4\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl6 (n30 \2\:n30) resistor r=105.002 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=45.708 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=403.412 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=35.7134 c=0
Rl18 (CKb \2\:CKb) resistor r=53.0797 c=0
Rl23 (\2\:CKb \7\:CKb) resistor r=54.1777 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=184.159 c=0
Rl25 (\3\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=198.915 c=0
Rl14 (mout \2\:mout) resistor r=50.6918 c=0
Rl15 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=64.6174 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=51.1559 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl10 (CKbb \2\:CKbb) resistor r=64.6174 c=0
Rl12 (n20 \2\:n20) resistor r=112.23 c=0
Rl13 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl35 (\3\:SEb \4\:SEb) resistor r=93.4636 c=0
Rl32 (SEb \2\:SEb) resistor r=29.5379 c=0
Rl36 (Dp \2\:Dp) resistor r=60.3072 c=0
Rl37 (\2\:Dp \3\:Dp) resistor r=29.5379 c=0
Rl42 (RNb \2\:RNb) resistor r=101.477 c=0
Rl43 (\2\:RNb \3\:RNb) resistor r=89.6174 c=0
Rl46 (Eb \2\:Eb) resistor r=126.718 c=0
Rl47 (\2\:Eb \3\:Eb) resistor r=35.8888 c=0
Rl50 (Db \2\:Db) resistor r=226.489 c=0
Rl51 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz20 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz21 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz22 (\1\:VDD \11\:VDD) resistor r=6.25 c=0
Rz11 (\1\:Q \2\:Q) resistor r=75 c=0
Rz23 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz24 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz25 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz26 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz28 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz29 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz30 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz31 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz32 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz2 (\9\:net582 \10\:net582) resistor r=75 c=0
Rz13 (\20\:qbint \21\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dpb \2\:Dpb) resistor r=75 c=0
Rz9 (\7\:Dpb \8\:Dpb) resistor r=75 c=0
Rz10 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz14 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz12 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz16 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz17 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry22 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry23 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry26 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry27 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry28 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry29 (\28\:VDD \29\:VDD) resistor r=20.6667 c=0
Ry11 (\3\:Q \4\:Q) resistor r=62 c=0
Ry30 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry31 (\3\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry32 (\3\:VSS \16\:VSS) resistor r=15.5 c=0
Ry33 (\3\:VSS \18\:VSS) resistor r=15.5 c=0
Ry34 (\3\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry2 (\5\:net582 \6\:net582) resistor r=62 c=0
Ry13 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Dpb \4\:Dpb) resistor r=62 c=0
Ry9 (\5\:Dpb \6\:Dpb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\10\:Dp \11\:Dp) resistor r=62 c=0
Ry12 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry20 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry21 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx26 (\2\:D \4\:D) resistor r=45 c=0
Rx12 (\5\:SE \7\:SE) resistor r=45 c=0
Rx13 (\2\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:E \8\:E) resistor r=45 c=0
Rx24 (\2\:E \9\:E) resistor r=45 c=0
Rx11 (\2\:SI \4\:SI) resistor r=45 c=0
Rx9 (\2\:CK \5\:CK) resistor r=45 c=0
Rx16 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (net582 \8\:net582) resistor r=45 c=0
Rx18 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx19 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx20 (\6\:qbint \19\:qbint) resistor r=45 c=0
Rx21 (qbint \22\:qbint) resistor r=45 c=0
Rx2 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:mout \4\:mout) resistor r=45 c=0
Rx5 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx15 (\2\:SEb \10\:SEb) resistor r=45 c=0
Rx22 (\2\:Dp \12\:Dp) resistor r=45 c=0
Rx17 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx25 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx27 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\1\:QN \3\:net582 \33\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:net582 \3\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\20\:qbint n30 \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.815e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \5\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.55e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\4\:n30 \6\:CKb net618 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.365e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\4\:n30 \3\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.16e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.45e-14 ad=3.988e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=8.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=8.7e-15 ps=1.44e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=5.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net606 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=4.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:n20 \9\:CKb \7\:Dpb VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.465e-14 ps=8e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\11\:CKbb \8\:CKb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.25e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn20 (\14\:CKb \3\:CK \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.2e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn10 (\6\:SEb \3\:SE \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.087e-14 ad=3.698e-14 ps=1.69e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.565e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn13 (net658 \3\:SI \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.087e-14 ad=5.365e-14 ps=1.69e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.245e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn14 (Dpb \6\:SE net658 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=2.755e-14 ps=1.03e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=8.3e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn12 (Dpb \3\:SEb net650 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.755e-14 ps=4.1e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=5.95e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn11 (net650 \3\:Dp \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=8.7e-15 ps=9.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33e-06 sb=4.9e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn55 (\1\:Q \9\:qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=5.59e-14 ps=9.8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.71635e-07 sb=2.15e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (\8\:RNb \3\:RN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.465e-14 ps=9e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=8.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn3 (\8\:Dp RNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.8e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn5 (\8\:Dp \10\:qbint net634 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.75e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn4 (net634 \3\:Eb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.725e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn6 (net638 \1\:E \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn7 (\13\:Dp Db net638 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\8\:Eb \7\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn1 (\7\:Db \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mp56 (\5\:net582 \2\:qbint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
mp45 (\16\:qbint \3\:n30 \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.865e-06 sd=160n sca=11.99 scb=0.01053 \
        scc=0.000305882 m=(1)
mp50 (net529 \4\:qbint \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.245e-14 ad=2.903e-14 ps=1.21e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.55e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\8\:n30 CKbb net529 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.548e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.37e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\8\:n30 \5\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.548e-14 ps=9.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.16e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=8.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net521 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=5.75e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \4\:CKb net521 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.085e-14 ps=5.5e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=4.7e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Dpb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=4.085e-14 ps=9e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77e-06 sb=2.35e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.25e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\10\:CKb \1\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.6e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp10 (\8\:SEb \1\:SE \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.031e-13 ad=3.01e-14 ps=1.8e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp13 (net557 \1\:SI \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.031e-13 ad=3.333e-14 ps=1.8e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.17e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp14 (\3\:Dpb SEb net557 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.333e-14 ad=5.268e-14 ps=7.4e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=9.7e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp12 (\3\:Dpb \4\:SE net549 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.268e-14 ps=8.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=6.8e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp11 (net549 Dp \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=4.73e-14 ps=1.42e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=4.15e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp55 (\3\:Q \7\:qbint \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9e-14 ad=5.46e-14 ps=1.42e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.67372e-07 sb=1.4e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp2 (\6\:RNb \1\:RN \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.53e-14 ad=4.3e-14 ps=1.67e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=8.15e-07 sd=160n sca=16.4667 scb=0.0163489 \
        scc=0.00112485 m=(1)
mp3 (\3\:net493 \3\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.53e-14 ad=3.44e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=5.5e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp5 (\3\:net505 \11\:qbint \3\:net493 VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.7e-07 sb=3.45e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp4 (\3\:net505 Eb net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.4e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp6 (\10\:Dp \3\:E net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp7 (\4\:Dp \2\:Db net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp0 (\4\:Eb \4\:E \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.455e-14 ad=3.01e-14 ps=1.76e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=49.0504 \
        scb=0.032034 scc=0.00591335 m=(1)
mp1 (\4\:Db \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.455e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=57.444 \
        scb=0.0450892 scc=0.00689963 m=(1)
ends SEDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:54:21 2012 )
// Library name: gsclib045
// Cell name: SEDFFTRX2
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX2 CK D E Q QN RN SE SI VDD VSS
mp10 (\5\:SEb \1\:SE \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=3.01e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=26.5786 \
        scb=0.0259232 scc=0.00247005 m=(1)
C1 (CK VSS) capacitor c=5.41516e-17
C2 (D VSS) capacitor c=8.85398e-17
C3 (E VSS) capacitor c=7.8718e-17
C4 (Q VSS) capacitor c=2.0219e-17
C5 (SE VSS) capacitor c=4.06949e-17
C6 (VDD VSS) capacitor c=5.74342e-16
C7 (SI VSS) capacitor c=1.04703e-16
C8 (QN VSS) capacitor c=2.91668e-17
C9 (SEb VSS) capacitor c=4.98716e-17
C10 (net658 VSS) capacitor c=8.64555e-20
C11 (Dpb VSS) capacitor c=7.32312e-17
C12 (net650 VSS) capacitor c=2.61787e-18
C13 (Dp VSS) capacitor c=3.29499e-17
C14 (CKbb VSS) capacitor c=4.17984e-17
C15 (CKb VSS) capacitor c=3.23705e-17
C16 (n20 VSS) capacitor c=5.059e-17
C17 (mout VSS) capacitor c=3.78964e-17
C18 (n30 VSS) capacitor c=2.9268e-17
C19 (net618 VSS) capacitor c=1.54832e-18
C20 (qbint VSS) capacitor c=6.82076e-17
C21 (net582 VSS) capacitor c=1.87472e-16
C22 (RNb VSS) capacitor c=5.58292e-17
C23 (Eb VSS) capacitor c=5.03331e-17
C24 (net638 VSS) capacitor c=4.34495e-19
C25 (Db VSS) capacitor c=6.71195e-17
C26 (net557 VSS) capacitor c=2.17167e-18
C27 (net549 VSS) capacitor c=2.63014e-18
C28 (net521 VSS) capacitor c=2.79667e-18
C29 (net529 VSS) capacitor c=4.69748e-18
C30 (net493 VSS) capacitor c=7.02777e-17
C31 (net505 VSS) capacitor c=9.58012e-17
C32 (\3\:D VSS) capacitor c=4.92637e-17
C33 (\4\:E VSS) capacitor c=4.7859e-17
C34 (\2\:Db VSS) capacitor c=4.0806e-17
C35 (\3\:E VSS) capacitor c=3.88907e-17
C36 (\13\:qbint VSS) capacitor c=7.01835e-17
C37 (\1\:RN VSS) capacitor c=3.26e-17
C38 (\12\:qbint VSS) capacitor c=6.25101e-17
C39 (\3\:CK VSS) capacitor c=2.82617e-17
C40 (\3\:n30 VSS) capacitor c=5.71162e-17
C41 (\3\:qbint VSS) capacitor c=4.06047e-17
C42 (\5\:CKbb VSS) capacitor c=5.56048e-17
C43 (\9\:CKb VSS) capacitor c=3.4576e-17
C44 (\6\:CKb VSS) capacitor c=3.27581e-17
C45 (\8\:CKb VSS) capacitor c=5.14782e-17
C46 (\2\:Dp VSS) capacitor c=6.19292e-17
C47 (\6\:SE VSS) capacitor c=5.49039e-17
C48 (\3\:SEb VSS) capacitor c=4.70884e-17
C49 (\1\:SI VSS) capacitor c=5.89942e-17
C50 (\1\:SE VSS) capacitor c=4.42834e-17
C51 (\1\:D VSS) capacitor c=2.80498e-17
C52 (\7\:E VSS) capacitor c=3.63439e-17
C53 (\1\:E VSS) capacitor c=4.5576e-17
C54 (\3\:Eb VSS) capacitor c=3.07455e-17
C55 (\14\:qbint VSS) capacitor c=6.06789e-17
C56 (\3\:RNb VSS) capacitor c=4.01444e-17
C57 (\3\:RN VSS) capacitor c=5.286e-17
C58 (\11\:qbint VSS) capacitor c=3.30691e-17
C59 (\4\:qbint VSS) capacitor c=1.69777e-16
C60 (\1\:CK VSS) capacitor c=3.44997e-17
C61 (\11\:CKb VSS) capacitor c=5.74042e-17
C62 (\7\:CKbb VSS) capacitor c=1.83144e-17
C63 (\3\:n20 VSS) capacitor c=2.39472e-17
C64 (\3\:mout VSS) capacitor c=7.7771e-17
C65 (\3\:CKbb VSS) capacitor c=7.47889e-17
C66 (\7\:CKb VSS) capacitor c=2.39085e-17
C67 (\5\:CKb VSS) capacitor c=2.89443e-17
C68 (\3\:Dp VSS) capacitor c=6.30032e-17
C69 (\4\:SE VSS) capacitor c=6.53644e-17
C70 (\4\:SI VSS) capacitor c=6.00162e-17
C71 (\3\:SE VSS) capacitor c=2.47442e-17
C72 (\2\:D VSS) capacitor c=3.94399e-17
C73 (\6\:E VSS) capacitor c=2.5732e-17
C74 (\3\:Db VSS) capacitor c=2.25936e-17
C75 (\2\:E VSS) capacitor c=3.98399e-17
C76 (\2\:Eb VSS) capacitor c=4.78386e-17
C77 (\15\:qbint VSS) capacitor c=2.61784e-17
C78 (\2\:RNb VSS) capacitor c=4.89766e-17
C79 (\2\:RN VSS) capacitor c=3.59121e-17
C80 (\10\:qbint VSS) capacitor c=2.17776e-17
C81 (\2\:CK VSS) capacitor c=3.79762e-17
C82 (\2\:n30 VSS) capacitor c=2.3024e-17
C83 (\2\:qbint VSS) capacitor c=4.15713e-17
C84 (\12\:CKb VSS) capacitor c=3.65568e-17
C85 (\6\:CKbb VSS) capacitor c=5.4042e-17
C86 (\10\:CKb VSS) capacitor c=3.4859e-17
C87 (\2\:n20 VSS) capacitor c=3.3627e-17
C88 (\2\:mout VSS) capacitor c=5.31255e-17
C89 (\4\:CKbb VSS) capacitor c=2.60207e-17
C90 (\2\:CKbb VSS) capacitor c=4.00916e-17
C91 (\7\:SE VSS) capacitor c=4.41064e-17
C92 (\2\:SEb VSS) capacitor c=6.22515e-17
C93 (\5\:SE VSS) capacitor c=4.63773e-17
C94 (\3\:SI VSS) capacitor c=5.8221e-17
C95 (\2\:SE VSS) capacitor c=3.10604e-17
C96 (\6\:Db VSS) capacitor c=1.0452e-16
C97 (\19\:VDD VSS) capacitor c=2.32251e-17
C98 (\7\:Eb VSS) capacitor c=8.23664e-17
C99 (\4\:Dp VSS) capacitor c=7.41524e-17
C100 (\3\:net505 VSS) capacitor c=1.09738e-16
C101 (\3\:net493 VSS) capacitor c=8.90985e-17
C102 (\21\:VDD VSS) capacitor c=4.17609e-17
C103 (\7\:RNb VSS) capacitor c=1.09681e-16
C104 (\11\:net582 VSS) capacitor c=3.035e-17
C105 (\4\:QN VSS) capacitor c=2.71289e-17
C106 (\2\:Q VSS) capacitor c=2.45916e-17
C107 (\15\:CKb VSS) capacitor c=1.1616e-16
C108 (\21\:qbint VSS) capacitor c=8.38307e-17
C109 (\29\:VDD VSS) capacitor c=2.50585e-17
C110 (\7\:n30 VSS) capacitor c=8.49781e-17
C111 (\4\:mout VSS) capacitor c=4.47582e-17
C112 (\31\:VDD VSS) capacitor c=1.81718e-17
C113 (\6\:n20 VSS) capacitor c=5.77389e-17
C114 (\6\:Dpb VSS) capacitor c=3.08292e-17
C115 (\15\:CKbb VSS) capacitor c=6.34269e-17
C116 (\33\:VDD VSS) capacitor c=1.88323e-17
C117 (\4\:Dpb VSS) capacitor c=1.24453e-16
C118 (\35\:VDD VSS) capacitor c=4.32391e-17
C119 (\5\:SEb VSS) capacitor c=1.26247e-16
C120 (\1\:VDD VSS) capacitor c=2.5821e-16
C121 (\4\:Db VSS) capacitor c=6.98838e-17
C122 (\5\:Eb VSS) capacitor c=1.59391e-16
C123 (\9\:Dp VSS) capacitor c=1.10641e-16
C124 (\13\:Dp VSS) capacitor c=6.10229e-17
C125 (\4\:RNb VSS) capacitor c=2.01312e-17
C126 (\7\:net582 VSS) capacitor c=6.23822e-17
C127 (\1\:QN VSS) capacitor c=3.26539e-17
C128 (\4\:Q VSS) capacitor c=5.25997e-17
C129 (\13\:CKb VSS) capacitor c=6.8688e-17
C130 (\19\:qbint VSS) capacitor c=9.08221e-17
C131 (\5\:n30 VSS) capacitor c=9.52735e-17
C132 (\8\:mout VSS) capacitor c=5.5396e-17
C133 (\8\:n20 VSS) capacitor c=3.55438e-17
C134 (\11\:CKbb VSS) capacitor c=6.73008e-17
C135 (\8\:Dpb VSS) capacitor c=1.01813e-16
C136 (\7\:SEb VSS) capacitor c=8.00099e-17
C137 (\2\:CKb VSS) capacitor c=4.95497e-17
C138 (\3\:CKb VSS) capacitor c=4.19915e-17
C139 (\4\:CKb VSS) capacitor c=3.68782e-17
C140 (\5\:SI VSS) capacitor c=4.14566e-17
C141 (\4\:SEb VSS) capacitor c=8.54322e-17
C142 (\8\:SE VSS) capacitor c=1.22412e-16
C143 (\9\:SE VSS) capacitor c=1.09308e-16
C144 (\10\:SE VSS) capacitor c=3.29357e-17
C145 (\11\:SE VSS) capacitor c=3.13269e-17
C146 (\3\:Dpb VSS) capacitor c=1.23185e-16
C147 (\4\:n20 VSS) capacitor c=5.06548e-17
C148 (\5\:n20 VSS) capacitor c=6.39793e-17
C149 (\5\:E VSS) capacitor c=3.22813e-17
C150 (\6\:mout VSS) capacitor c=4.83301e-17
C151 (\7\:mout VSS) capacitor c=5.19991e-17
C152 (\8\:CKbb VSS) capacitor c=1.19614e-16
C153 (\9\:CKbb VSS) capacitor c=9.16742e-17
C154 (\10\:CKbb VSS) capacitor c=6.4947e-17
C155 (\13\:CKbb VSS) capacitor c=1.96623e-17
C156 (\14\:CKbb VSS) capacitor c=8.11953e-17
C157 (\4\:n30 VSS) capacitor c=8.18212e-17
C158 (\17\:CKb VSS) capacitor c=1.2936e-16
C159 (\18\:CKb VSS) capacitor c=1.57443e-16
C160 (\19\:CKb VSS) capacitor c=1.18406e-16
C161 (\20\:CKb VSS) capacitor c=5.17802e-17
C162 (\21\:CKb VSS) capacitor c=6.16868e-17
C163 (\4\:CK VSS) capacitor c=5.65137e-17
C164 (\1\:Q VSS) capacitor c=3.34869e-17
C165 (\3\:QN VSS) capacitor c=3.93397e-17
C166 (\9\:net582 VSS) capacitor c=4.06883e-17
C167 (\10\:net582 VSS) capacitor c=2.6494e-17
C168 (\4\:RN VSS) capacitor c=6.46005e-17
C169 (\5\:RN VSS) capacitor c=6.30433e-17
C170 (\6\:RNb VSS) capacitor c=1.15168e-16
C171 (\9\:RNb VSS) capacitor c=4.57294e-17
C172 (\16\:qbint VSS) capacitor c=7.49519e-17
C173 (\17\:qbint VSS) capacitor c=1.54838e-16
C174 (\18\:qbint VSS) capacitor c=1.33071e-16
C175 (\23\:qbint VSS) capacitor c=5.98506e-17
C176 (\24\:qbint VSS) capacitor c=5.08055e-17
C177 (\6\:Dp VSS) capacitor c=1.34567e-16
C178 (\7\:Dp VSS) capacitor c=5.16153e-16
C179 (\8\:Dp VSS) capacitor c=5.40147e-16
C180 (\8\:E VSS) capacitor c=5.75055e-17
C181 (\4\:Eb VSS) capacitor c=1.16559e-16
C182 (\4\:D VSS) capacitor c=4.66983e-17
C183 (\8\:Db VSS) capacitor c=6.81919e-17
C184 (\6\:VDD VSS) capacitor c=3.17672e-17
C185 (\7\:VDD VSS) capacitor c=1.13583e-16
C186 (\12\:VDD VSS) capacitor c=2.20603e-17
C187 (\14\:VDD VSS) capacitor c=3.27295e-17
C188 (\16\:VDD VSS) capacitor c=1.55588e-17
C189 (\18\:VDD VSS) capacitor c=5.04389e-18
Rk32 (CK \4\:CK) resistor r=0.1836 c=0
Rk66 (\4\:D D) resistor r=0.1052 c=0
Rk69 (\2\:VSS \3\:VSS) resistor r=0.08513 c=0
Rk70 (\3\:VSS \4\:VSS) resistor r=0.1152 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.3486 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.08493 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.2683 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.04402 c=0
Rk75 (\8\:VSS \9\:VSS) resistor r=0.3716 c=0
Rk78 (\9\:VSS \12\:VSS) resistor r=0.3125 c=0
Rk79 (\12\:VSS \13\:VSS) resistor r=0.0776 c=0
Rk80 (\13\:VSS \14\:VSS) resistor r=0.5749 c=0
Rk81 (\3\:VSS \16\:VSS) resistor r=0.2977 c=0
Rk82 (\5\:VSS \18\:VSS) resistor r=0.2414 c=0
Rk83 (\6\:VSS \20\:VSS) resistor r=0.226 c=0
Rk84 (\8\:VSS \22\:VSS) resistor r=0.04335 c=0
Rk88 (\13\:VSS \30\:VSS) resistor r=0.2981 c=0
Rk89 (\14\:VSS \31\:VSS) resistor r=0.5895 c=0
Rk90 (\31\:VSS \32\:VSS) resistor r=0.06254 c=0
Rk92 (\33\:VSS VSS) resistor r=0.2028 c=0
Rk91 (\32\:VSS \33\:VSS) resistor r=0.3486 c=0
Rk93 (\14\:VSS \35\:VSS) resistor r=0.2103 c=0
Rk94 (\31\:VSS \37\:VSS) resistor r=0.3131 c=0
Rk95 (\33\:VSS \39\:VSS) resistor r=0.3108 c=0
Rk62 (\8\:E E) resistor r=0.2631 c=0
Rk63 (E \9\:E) resistor r=0.003311 c=0
Rk33 (Q \1\:Q) resistor r=0.04369 c=0
Rk34 (\1\:Q \3\:Q) resistor r=0.051 c=0
Rk35 (\1\:Q \5\:Q) resistor r=0.1531 c=0
Rk4 (\8\:SE \9\:SE) resistor r=0.9059 c=0
Rk6 (\10\:SE SE) resistor r=0.04983 c=0
Rk5 (\9\:SE \10\:SE) resistor r=0.23 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.08816 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.1052 c=0
Rk97 (\3\:VDD \4\:VDD) resistor r=0.04497 c=0
Rk98 (\4\:VDD \5\:VDD) resistor r=0.6525 c=0
Rk99 (\5\:VDD \6\:VDD) resistor r=0.1228 c=0
Rk100 (\6\:VDD \7\:VDD) resistor r=0.4438 c=0
Rk105 (\7\:VDD \12\:VDD) resistor r=0.3048 c=0
Rk106 (\12\:VDD \13\:VDD) resistor r=0.2097 c=0
Rk107 (\13\:VDD \14\:VDD) resistor r=0.5067 c=0
Rk108 (\14\:VDD \15\:VDD) resistor r=0.2457 c=0
Rk109 (\15\:VDD \16\:VDD) resistor r=0.2021 c=0
Rk110 (\16\:VDD \17\:VDD) resistor r=0.3477 c=0
Rk112 (\18\:VDD VDD) resistor r=0.2028 c=0
Rk111 (\17\:VDD \18\:VDD) resistor r=0.09767 c=0
Rk113 (\3\:VDD \20\:VDD) resistor r=0.0744 c=0
Rk114 (\6\:VDD \22\:VDD) resistor r=0.1753 c=0
Rk118 (\12\:VDD \30\:VDD) resistor r=0.04335 c=0
Rk119 (\14\:VDD \32\:VDD) resistor r=0.0744 c=0
Rk120 (\16\:VDD \34\:VDD) resistor r=0.04335 c=0
Rk121 (\18\:VDD \36\:VDD) resistor r=0.3284 c=0
Rk1 (\5\:SI SI) resistor r=0.06196 c=0
Rk37 (\3\:QN QN) resistor r=0.04113 c=0
Rk36 (\2\:QN \3\:QN) resistor r=0.1178 c=0
Rk38 (\3\:QN \5\:QN) resistor r=0.183 c=0
Rk42 (RN \4\:RN) resistor r=0.004987 c=0
Rk44 (\4\:RN \5\:RN) resistor r=0.05906 c=0
Rk43 (\5\:RN \6\:RN) resistor r=0.005088 c=0
Rk2 (\4\:SEb \6\:SEb) resistor r=0.4946 c=0
Rk3 (\6\:SEb \8\:SEb) resistor r=0.6889 c=0
Rk8 (\2\:Dpb \3\:Dpb) resistor r=0.3754 c=0
Rk9 (\3\:Dpb \5\:Dpb) resistor r=0.5903 c=0
Rk10 (\3\:Dpb \7\:Dpb) resistor r=0.05034 c=0
Rk11 (\5\:Dpb \9\:Dpb) resistor r=0.5309 c=0
Rk56 (\5\:Dp \6\:Dp) resistor r=0.4071 c=0
Rk57 (\6\:Dp \7\:Dp) resistor r=0.4312 c=0
Rk58 (\7\:Dp \8\:Dp) resistor r=4.291 c=0
Rk59 (\6\:Dp \10\:Dp) resistor r=0.6038 c=0
Rk60 (\6\:Dp \12\:Dp) resistor r=0.02745 c=0
Rk61 (\7\:Dp \14\:Dp) resistor r=0.2868 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.8779 c=0
Rk19 (\9\:CKbb \10\:CKbb) resistor r=0.2701 c=0
Rk20 (\10\:CKbb \12\:CKbb) resistor r=0.2758 c=0
Rk21 (\9\:CKbb \13\:CKbb) resistor r=0.0379 c=0
Rk22 (\10\:CKbb \14\:CKbb) resistor r=0.3631 c=0
Rk23 (\12\:CKbb \16\:CKbb) resistor r=0.4055 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=0.398 c=0
Rk27 (\16\:CKb \17\:CKb) resistor r=0.625 c=0
Rk28 (\17\:CKb \18\:CKb) resistor r=0.4201 c=0
Rk29 (\18\:CKb \19\:CKb) resistor r=0.8159 c=0
Rk30 (\17\:CKb \20\:CKb) resistor r=0.2462 c=0
Rk31 (\18\:CKb \21\:CKb) resistor r=0.2216 c=0
Rk12 (\4\:n20 \5\:n20) resistor r=0.3489 c=0
Rk13 (\5\:n20 \7\:n20) resistor r=0.2821 c=0
Rk14 (\5\:n20 \9\:n20) resistor r=0.1211 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.1211 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.2976 c=0
Rk17 (\6\:mout \9\:mout) resistor r=0.2622 c=0
Rk24 (\4\:n30 \6\:n30) resistor r=0.4793 c=0
Rk25 (\6\:n30 \8\:n30) resistor r=0.398 c=0
Rk48 (\16\:qbint \17\:qbint) resistor r=0.5864 c=0
Rk49 (\17\:qbint \18\:qbint) resistor r=0.8132 c=0
Rk50 (\18\:qbint \20\:qbint) resistor r=0.4957 c=0
Rk51 (\20\:qbint \22\:qbint) resistor r=0.3383 c=0
Rk52 (\18\:qbint \23\:qbint) resistor r=0.2333 c=0
Rk53 (\22\:qbint \24\:qbint) resistor r=0.2558 c=0
Rk39 (\8\:net582 \9\:net582) resistor r=0.2983 c=0
Rk40 (\9\:net582 \10\:net582) resistor r=0.1491 c=0
Rk41 (\9\:net582 \12\:net582) resistor r=0.1281 c=0
Rk45 (\5\:RNb \6\:RNb) resistor r=0.0416 c=0
Rk46 (\6\:RNb \8\:RNb) resistor r=0.7176 c=0
Rk47 (\6\:RNb \9\:RNb) resistor r=0.2684 c=0
Rk64 (\4\:Eb \6\:Eb) resistor r=0.9292 c=0
Rk65 (\6\:Eb \8\:Eb) resistor r=0.5193 c=0
Rk67 (\5\:Db \7\:Db) resistor r=0.5301 c=0
Rk68 (\7\:Db \8\:Db) resistor r=0.6441 c=0
Rk54 (\2\:net493 \4\:net493) resistor r=0.3068 c=0
Rk55 (\2\:net505 \4\:net505) resistor r=0.6555 c=0
Rl34 (\2\:CK \3\:CK) resistor r=59.5926 c=0
Rl33 (\1\:CK \2\:CK) resistor r=32.2239 c=0
Rl63 (\2\:D \3\:D) resistor r=130.002 c=0
Rl62 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl56 (\2\:E \3\:E) resistor r=48.0649 c=0
Rl55 (\1\:E \2\:E) resistor r=74.7951 c=0
Rl59 (\4\:E \5\:E) resistor r=66.1873 c=0
Rl61 (\5\:E \7\:E) resistor r=108.495 c=0
Rl60 (\5\:E \6\:E) resistor r=17.513 c=0
Rl9 (\6\:SE \7\:SE) resistor r=54.5379 c=0
Rl6 (\4\:SE \5\:SE) resistor r=35.3072 c=0
Rl1 (\1\:SE \2\:SE) resistor r=104.538 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl3 (\1\:SI \2\:SI) resistor r=51.6416 c=0
Rl5 (\2\:SI \4\:SI) resistor r=111.257 c=0
Rl4 (\2\:SI \3\:SI) resistor r=3.3229 c=0
Rl47 (\1\:RN \2\:RN) resistor r=50.6918 c=0
Rl48 (\2\:RN \3\:RN) resistor r=156.461 c=0
Rl7 (SEb \2\:SEb) resistor r=126.895 c=0
Rl8 (\2\:SEb \3\:SEb) resistor r=26.3736 c=0
Rl10 (Dp \2\:Dp) resistor r=41.0764 c=0
Rl11 (\2\:Dp \3\:Dp) resistor r=159.467 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=151.043 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=66.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=51.1559 c=0
Rl28 (\11\:CKb \12\:CKb) resistor r=39.6174 c=0
Rl25 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl14 (CKb \2\:CKb) resistor r=3.7088 c=0
Rl18 (\2\:CKb \6\:CKb) resistor r=26.0667 c=0
Rl19 (\3\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=170.863 c=0
Rl20 (\4\:CKb \8\:CKb) resistor r=76.0821 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=84.2779 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=146.229 c=0
Rl23 (n20 \2\:n20) resistor r=101.156 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=24.2328 c=0
Rl21 (mout \2\:mout) resistor r=24.2328 c=0
Rl22 (\2\:mout \3\:mout) resistor r=106.558 c=0
Rl31 (n30 \2\:n30) resistor r=28.1965 c=0
Rl32 (\2\:n30 \3\:n30) resistor r=32.4874 c=0
Rl51 (\14\:qbint \13\:qbint) resistor r=232.692 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=143.796 c=0
Rl52 (\15\:qbint \14\:qbint) resistor r=44.9225 c=0
Rl45 (\10\:qbint \11\:qbint) resistor r=35.8844 c=0
Rl29 (\2\:qbint qbint) resistor r=101.156 c=0
Rl30 (\2\:qbint \3\:qbint) resistor r=24.2328 c=0
Rl49 (RNb \2\:RNb) resistor r=170.387 c=0
Rl50 (\2\:RNb \3\:RNb) resistor r=33.8482 c=0
Rl53 (Eb \2\:Eb) resistor r=172.872 c=0
Rl54 (\2\:Eb \3\:Eb) resistor r=33.5406 c=0
Rl57 (Db \2\:Db) resistor r=157.258 c=0
Rl58 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz18 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz25 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz26 (\35\:VSS \34\:VSS) resistor r=75 c=0
Rz27 (\37\:VSS \36\:VSS) resistor r=75 c=0
Rz28 (\39\:VSS \38\:VSS) resistor r=75 c=0
Rz9 (\5\:Q \4\:Q) resistor r=75 c=0
Rz29 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz30 (\4\:VDD \1\:VDD) resistor r=75 c=0
Rz31 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz33 (\7\:VDD \1\:VDD) resistor r=18.75 c=0
Rz34 (\13\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz35 (\15\:VDD \1\:VDD) resistor r=18.75 c=0
Rz36 (\17\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz10 (\2\:QN \1\:QN) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz2 (Dpb \2\:Dpb) resistor r=75 c=0
Rz3 (\8\:Dpb \9\:Dpb) resistor r=75 c=0
Rz14 (\9\:Dp \10\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz13 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz11 (\8\:net582 \7\:net582) resistor r=75 c=0
Rz12 (\4\:RNb \5\:RNb) resistor r=75 c=0
Rz16 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz17 (\4\:Db \5\:Db) resistor r=75 c=0
Ry22 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry23 (\4\:VSS \1\:VSS) resistor r=31 c=0
Ry24 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry25 (\12\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry26 (\14\:VSS \1\:VSS) resistor r=62 c=0
Ry27 (\32\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry9 (\3\:Q \2\:Q) resistor r=62 c=0
Ry28 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry29 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry34 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry35 (\34\:VDD \33\:VDD) resistor r=62 c=0
Ry36 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry10 (\5\:QN \4\:QN) resistor r=62 c=0
Ry1 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry2 (\4\:Dpb \5\:Dpb) resistor r=62 c=0
Ry3 (\6\:Dpb \7\:Dpb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry6 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry8 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry13 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry11 (\12\:net582 \11\:net582) resistor r=62 c=0
Ry12 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry20 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry21 (\6\:Db \7\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx27 (\2\:D \4\:D) resistor r=45 c=0
Rx24 (\6\:E \8\:E) resistor r=45 c=0
Rx25 (\2\:E \9\:E) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx1 (\3\:SI \5\:SI) resistor r=45 c=0
Rx17 (\2\:RN \6\:RN) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx23 (Dp \8\:Dp) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (CKb \19\:CKb) resistor r=45 c=0
Rx13 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx7 (\2\:mout \7\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx19 (\16\:qbint \15\:qbint) resistor r=45 c=0
Rx20 (\17\:qbint \10\:qbint) resistor r=45 c=0
Rx21 (\23\:qbint \4\:qbint) resistor r=45 c=0
Rx22 (\24\:qbint \2\:qbint) resistor r=45 c=0
Rx16 (\10\:net582 net582) resistor r=45 c=0
Rx18 (\2\:RNb \9\:RNb) resistor r=45 c=0
Rx26 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx28 (\3\:Db \8\:Db) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (net658 \4\:SI \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.2e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (\8\:Dpb \4\:SE net658 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=8.15e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (\8\:Dpb SEb net650 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=6.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net650 \3\:Dp \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn21 (\11\:CKbb \5\:CKb \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\8\:n20 \7\:CKb Dpb VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=5.003e-14 ps=5.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\8\:n20 \3\:CKbb net606 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.003e-14 ps=4.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.72e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=8.7e-15 ps=1.32e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.615e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=6.235e-14 ps=1.32e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.35e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:n30 \7\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.235e-14 ad=4.422e-14 ps=1.15e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=8.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 \11\:CKb net618 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.422e-14 ps=4.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=5.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=8.7e-15 ps=9.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=4.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint n30 \29\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=3.178e-14 ps=9.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46439e-06 sb=1.55e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn20 (\13\:CKb \1\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.345e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.672e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=9.76058e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn57 (\1\:QN net582 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.672e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.71058e-07 sb=5.06058e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn56 (\7\:net582 \11\:qbint \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\4\:RNb \3\:RN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (net634 \3\:Eb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=1.595e-14 ps=1.11e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\13\:Dp \3\:RNb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn5 (\13\:Dp \14\:qbint net634 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (net638 \1\:E \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.565e-14 ad=1.45e-14 ps=9.8e-07 pd=4.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.85e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn7 (\9\:Dp Db net638 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.45e-14 ad=2.03e-14 ps=4.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn0 (\5\:Eb \7\:E \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn1 (\4\:Db \1\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mp13 (net557 \1\:SI \35\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.51e-14 ad=1.29e-14 ps=1e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.3e-07 sd=160n sca=23.7838 \
        scb=0.0218743 scc=0.00242478 m=(1)
mp14 (\4\:Dpb \3\:SEb net557 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.25e-07 sd=160n sca=23.3365 \
        scb=0.0215703 scc=0.00242447 m=(1)
mp12 (\4\:Dpb \6\:SE net549 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=6.128e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.95e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp11 (net549 \2\:Dp \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=2.473e-14 ps=1.77e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.35e-07 sd=160n sca=22.8495 scb=0.0214046 \
        scc=0.00242442 m=(1)
mp21 (\15\:CKbb \8\:CKb \33\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.315e-14 ad=3.01e-14 ps=1.77e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp25 (\6\:n20 CKbb \6\:Dpb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.91093e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\6\:n20 \6\:CKb net521 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.87e-14 ps=7.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.68593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (net521 mout \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.547e-14 ad=3.332e-14 ps=1.96e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.48593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\4\:mout n20 \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.547e-14 ad=8.6e-14 ps=1.96e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=1.24593e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\7\:n30 \9\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.6e-14 ad=3.87e-14 ps=1.23e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=8.0093e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\7\:n30 \5\:CKbb net529 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=3.87e-14 ps=8.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=5.7593e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (net529 \3\:qbint \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.663e-14 ad=4.193e-14 ps=2.05e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=3.3593e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp45 (\21\:qbint \3\:n30 \29\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.663e-14 ad=4.34e-14 ps=2.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0121e-06 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp20 (\15\:CKb \3\:CK \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1785e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.29233e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp55_1__rcx (\2\:Q \4\:qbint \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.1743e-13 ad=6.24e-14 ps=1.82e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=9.14103e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57_1__rcx (\4\:QN net582 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.984e-14 ad=6.24e-14 ps=1.855e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.69551e-07 sb=4.44103e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp56 (\11\:net582 \12\:qbint \7\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=8.268e-14 ad=2.63e-14 ps=1.97e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.31e-06 sb=1.22326e-07 sd=160n \
        sca=45.7906 scb=0.0283307 scc=0.00588417 m=(1)
mp2 (\7\:RNb \1\:RN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.805e-14 ps=8.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=8.15e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp3 (net493 RNb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=5.5e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp5 (net505 \13\:qbint net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=3.45e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp4 (net505 Eb \3\:net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=1.4e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp6 (\11\:Dp \3\:E \3\:net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp7 (\4\:Dp \2\:Db \3\:net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.3037 \
        scb=0.0150346 scc=0.000885439 m=(1)
mp0 (\7\:Eb \4\:E \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.01e-14 ps=1.66e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=18.613 \
        scb=0.0184651 scc=0.00105196 m=(1)
mp1 (\6\:Db \3\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=4.515e-14 ps=1.66e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2.1e-07 sd=160n sca=23.8984 \
        scb=0.0274473 scc=0.0014436 m=(1)
ends SEDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:54:59 2012 )
// Library name: gsclib045
// Cell name: SEDFFTRX4
// View name: extracted

simulator lang=spectre

subckt SEDFFTRX4 CK D E Q QN RN SE SI VDD VSS
mp10 (\5\:SEb \1\:SE \46\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=3.01e-14 ps=1.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.195e-06 sd=160n sca=25.3738 \
        scb=0.0277485 scc=0.00188421 m=(1)
C1 (D VSS) capacitor c=4.37037e-17
C2 (Q VSS) capacitor c=9.77678e-17
C3 (E VSS) capacitor c=6.10965e-17
C4 (QN VSS) capacitor c=9.29951e-17
C5 (SE VSS) capacitor c=5.49354e-17
C6 (VDD VSS) capacitor c=6.36409e-16
C7 (SI VSS) capacitor c=1.43281e-16
C8 (RN VSS) capacitor c=7.68859e-17
C9 (SEb VSS) capacitor c=5.42031e-17
C10 (net658 VSS) capacitor c=8.64555e-20
C11 (Dpb VSS) capacitor c=7.57147e-17
C12 (net650 VSS) capacitor c=2.61787e-18
C13 (Dp VSS) capacitor c=3.26403e-17
C14 (CKbb VSS) capacitor c=3.88223e-17
C15 (CKb VSS) capacitor c=2.88412e-17
C16 (n20 VSS) capacitor c=5.69872e-17
C17 (mout VSS) capacitor c=4.57597e-17
C18 (n30 VSS) capacitor c=1.15639e-16
C19 (net618 VSS) capacitor c=1.63901e-18
C20 (qbint VSS) capacitor c=4.41066e-17
C21 (net582 VSS) capacitor c=2.82462e-16
C22 (RNb VSS) capacitor c=4.45798e-17
C23 (Eb VSS) capacitor c=4.66128e-17
C24 (net638 VSS) capacitor c=1.98014e-18
C25 (Db VSS) capacitor c=2.24153e-17
C26 (net557 VSS) capacitor c=2.07571e-18
C27 (net549 VSS) capacitor c=2.62936e-18
C28 (net521 VSS) capacitor c=4.23174e-18
C29 (net529 VSS) capacitor c=5.55994e-18
C30 (net493 VSS) capacitor c=8.36868e-17
C31 (net505 VSS) capacitor c=8.02526e-17
C32 (\1\:D VSS) capacitor c=3.86836e-17
C33 (\4\:E VSS) capacitor c=4.41298e-17
C34 (\2\:Db VSS) capacitor c=5.18778e-17
C35 (\3\:E VSS) capacitor c=4.36611e-17
C36 (\22\:qbint VSS) capacitor c=4.66806e-17
C37 (\3\:RNb VSS) capacitor c=4.35565e-17
C38 (\3\:RN VSS) capacitor c=3.76955e-17
C39 (\21\:qbint VSS) capacitor c=5.56879e-17
C40 (\3\:CK VSS) capacitor c=3.90974e-17
C41 (\5\:CKbb VSS) capacitor c=7.20289e-17
C42 (\9\:CKb VSS) capacitor c=3.47237e-17
C43 (\6\:CKb VSS) capacitor c=3.55796e-17
C44 (\8\:CKb VSS) capacitor c=5.17272e-17
C45 (\2\:Dp VSS) capacitor c=6.3325e-17
C46 (\6\:SE VSS) capacitor c=5.20587e-17
C47 (\3\:SEb VSS) capacitor c=4.78551e-17
C48 (\1\:SI VSS) capacitor c=6.1375e-17
C49 (\1\:SE VSS) capacitor c=4.79893e-17
C50 (\3\:D VSS) capacitor c=2.69929e-17
C51 (\7\:E VSS) capacitor c=2.83825e-17
C52 (\3\:Db VSS) capacitor c=6.87367e-17
C53 (\1\:E VSS) capacitor c=5.29764e-17
C54 (\3\:Eb VSS) capacitor c=2.77734e-17
C55 (\23\:qbint VSS) capacitor c=5.1466e-17
C56 (\1\:RN VSS) capacitor c=4.64012e-17
C57 (\19\:qbint VSS) capacitor c=3.19192e-17
C58 (\4\:qbint VSS) capacitor c=3.35829e-16
C59 (\1\:CK VSS) capacitor c=2.88064e-17
C60 (\3\:qbint VSS) capacitor c=6.08689e-17
C61 (\11\:CKb VSS) capacitor c=5.71903e-17
C62 (\7\:CKbb VSS) capacitor c=1.88685e-17
C63 (\4\:n20 VSS) capacitor c=2.7174e-17
C64 (\3\:mout VSS) capacitor c=7.40659e-17
C65 (\3\:CKbb VSS) capacitor c=8.5159e-17
C66 (\7\:CKb VSS) capacitor c=2.6672e-17
C67 (\5\:CKb VSS) capacitor c=3.17782e-17
C68 (\3\:Dp VSS) capacitor c=6.42528e-17
C69 (\4\:SE VSS) capacitor c=6.53644e-17
C70 (\4\:SI VSS) capacitor c=5.9942e-17
C71 (\3\:SE VSS) capacitor c=2.47768e-17
C72 (\2\:D VSS) capacitor c=2.99811e-17
C73 (\6\:E VSS) capacitor c=2.39657e-17
C74 (\2\:E VSS) capacitor c=5.21241e-17
C75 (\2\:Eb VSS) capacitor c=3.63304e-17
C76 (\24\:qbint VSS) capacitor c=2.725e-17
C77 (\2\:RNb VSS) capacitor c=5.86987e-17
C78 (\2\:RN VSS) capacitor c=4.94088e-17
C79 (\20\:qbint VSS) capacitor c=3.39961e-17
C80 (\2\:CK VSS) capacitor c=2.11051e-17
C81 (\4\:n30 VSS) capacitor c=2.60094e-17
C82 (\2\:qbint VSS) capacitor c=4.58357e-17
C83 (\12\:CKb VSS) capacitor c=5.12978e-17
C84 (\10\:CKb VSS) capacitor c=3.05253e-17
C85 (\6\:CKbb VSS) capacitor c=5.22604e-17
C86 (\3\:n20 VSS) capacitor c=2.41663e-17
C87 (\2\:mout VSS) capacitor c=7.05143e-17
C88 (\4\:CKbb VSS) capacitor c=2.09965e-17
C89 (\2\:CKbb VSS) capacitor c=4.49355e-17
C90 (\7\:SE VSS) capacitor c=4.58956e-17
C91 (\2\:SEb VSS) capacitor c=6.20461e-17
C92 (\5\:SE VSS) capacitor c=4.66137e-17
C93 (\3\:SI VSS) capacitor c=5.60396e-17
C94 (\2\:SE VSS) capacitor c=3.30497e-17
C95 (\4\:Db VSS) capacitor c=8.70972e-17
C96 (\24\:VDD VSS) capacitor c=3.20132e-17
C97 (\4\:Eb VSS) capacitor c=6.01343e-17
C98 (\4\:Dp VSS) capacitor c=6.97062e-17
C99 (\3\:net505 VSS) capacitor c=8.62679e-17
C100 (\10\:Dp VSS) capacitor c=3.39519e-17
C101 (\3\:net493 VSS) capacitor c=7.53676e-17
C102 (\26\:VDD VSS) capacitor c=1.98292e-17
C103 (\6\:RNb VSS) capacitor c=5.80402e-17
C104 (\14\:net582 VSS) capacitor c=1.50925e-17
C105 (\17\:CKb VSS) capacitor c=1.11808e-16
C106 (\29\:qbint VSS) capacitor c=5.55642e-17
C107 (\12\:n30 VSS) capacitor c=7.97542e-17
C108 (\8\:mout VSS) capacitor c=4.38593e-17
C109 (\42\:VDD VSS) capacitor c=1.96277e-17
C110 (\7\:n20 VSS) capacitor c=5.50012e-17
C111 (\6\:Dpb VSS) capacitor c=3.19407e-17
C112 (\14\:CKbb VSS) capacitor c=6.44725e-17
C113 (\44\:VDD VSS) capacitor c=2.36865e-17
C114 (\4\:Dpb VSS) capacitor c=1.31392e-16
C115 (\46\:VDD VSS) capacitor c=3.92913e-17
C116 (\5\:SEb VSS) capacitor c=1.24335e-16
C117 (\1\:VDD VSS) capacitor c=2.22558e-16
C118 (\7\:Db VSS) capacitor c=4.10307e-17
C119 (\6\:Eb VSS) capacitor c=1.6264e-16
C120 (\12\:Dp VSS) capacitor c=1.00879e-16
C121 (\14\:Dp VSS) capacitor c=4.3549e-17
C122 (\8\:RNb VSS) capacitor c=2.89014e-17
C123 (\18\:net582 VSS) capacitor c=6.60978e-17
C124 (\1\:QN VSS) capacitor c=1.10844e-16
C125 (\1\:Q VSS) capacitor c=1.35835e-16
C126 (\19\:CKb VSS) capacitor c=7.55042e-17
C127 (\35\:qbint VSS) capacitor c=1.71085e-17
C128 (\10\:n30 VSS) capacitor c=2.27034e-17
C129 (\6\:mout VSS) capacitor c=5.23355e-17
C130 (\9\:n20 VSS) capacitor c=3.68243e-17
C131 (\11\:CKbb VSS) capacitor c=6.89094e-17
C132 (\8\:Dpb VSS) capacitor c=1.05181e-16
C133 (\7\:SEb VSS) capacitor c=6.9979e-17
C134 (\2\:CKb VSS) capacitor c=5.74085e-17
C135 (\3\:CKb VSS) capacitor c=4.26209e-17
C136 (\4\:CKb VSS) capacitor c=3.71068e-17
C137 (\2\:n20 VSS) capacitor c=2.68955e-17
C138 (\4\:SEb VSS) capacitor c=8.95779e-17
C139 (\8\:SE VSS) capacitor c=1.22187e-16
C140 (\9\:SE VSS) capacitor c=1.0911e-16
C141 (\11\:SE VSS) capacitor c=2.70393e-17
C142 (\3\:Dpb VSS) capacitor c=1.19828e-16
C143 (\5\:n20 VSS) capacitor c=5.41886e-17
C144 (\6\:n20 VSS) capacitor c=6.22501e-17
C145 (\4\:mout VSS) capacitor c=4.41582e-17
C146 (\5\:mout VSS) capacitor c=4.82066e-17
C147 (\8\:CKbb VSS) capacitor c=1.17602e-16
C148 (\9\:CKbb VSS) capacitor c=7.71516e-17
C149 (\10\:CKbb VSS) capacitor c=5.71527e-17
C150 (\13\:CKbb VSS) capacitor c=8.08571e-17
C151 (\8\:n30 VSS) capacitor c=8.3311e-17
C152 (\9\:n30 VSS) capacitor c=6.59641e-17
C153 (\5\:E VSS) capacitor c=2.43083e-17
C154 (\13\:CKb VSS) capacitor c=5.46316e-17
C155 (\14\:CKb VSS) capacitor c=1.65694e-16
C156 (\15\:CKb VSS) capacitor c=1.48251e-16
C157 (\16\:CKb VSS) capacitor c=1.07081e-16
C158 (\21\:CKb VSS) capacitor c=6.06563e-17
C159 (\4\:CK VSS) capacitor c=1.0672e-16
C160 (\16\:net582 VSS) capacitor c=5.40261e-17
C161 (\17\:net582 VSS) capacitor c=4.79489e-17
C162 (\4\:RN VSS) capacitor c=5.55562e-17
C163 (\4\:RNb VSS) capacitor c=3.90179e-17
C164 (\5\:RNb VSS) capacitor c=5.78996e-17
C165 (\25\:qbint VSS) capacitor c=1.10315e-16
C166 (\26\:qbint VSS) capacitor c=2.5007e-16
C167 (\27\:qbint VSS) capacitor c=2.55328e-16
C168 (\28\:qbint VSS) capacitor c=1.2e-16
C169 (\31\:qbint VSS) capacitor c=5.70626e-17
C170 (\32\:qbint VSS) capacitor c=4.93442e-17
C171 (\6\:Dp VSS) capacitor c=5.63777e-17
C172 (\7\:Dp VSS) capacitor c=1.33228e-16
C173 (\8\:Dp VSS) capacitor c=5.83422e-16
C174 (\9\:Dp VSS) capacitor c=6.77079e-16
C175 (\8\:E VSS) capacitor c=2.59833e-17
C176 (\9\:E VSS) capacitor c=7.42015e-17
C177 (\8\:Eb VSS) capacitor c=1.80697e-16
C178 (\4\:D VSS) capacitor c=7.26711e-17
C179 (\6\:Db VSS) capacitor c=1.02791e-16
C180 (\5\:VDD VSS) capacitor c=9.10065e-18
C181 (\7\:VDD VSS) capacitor c=1.5057e-16
C182 (\16\:VDD VSS) capacitor c=1.0047e-16
C183 (\19\:VDD VSS) capacitor c=5.87865e-17
C184 (\21\:VDD VSS) capacitor c=2.69171e-17
C185 (\22\:VDD VSS) capacitor c=1.24433e-17
Rk32 (\4\:CK CK) resistor r=0.03189 c=0
Rk73 (D \4\:D) resistor r=0.1712 c=0
Rk34 (\1\:Q Q) resistor r=0.3826 c=0
Rk69 (\8\:E E) resistor r=0.0319 c=0
Rk70 (E \9\:E) resistor r=0.2494 c=0
Rk39 (\1\:QN QN) resistor r=0.3282 c=0
Rk5 (\9\:SE SE) resistor r=0.2173 c=0
Rk4 (\8\:SE \9\:SE) resistor r=0.9019 c=0
Rk6 (SE \10\:SE) resistor r=0.01035 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.08778 c=0
Rk111 (\2\:VDD \3\:VDD) resistor r=0.1077 c=0
Rk112 (\3\:VDD \4\:VDD) resistor r=0.4438 c=0
Rk113 (\4\:VDD \5\:VDD) resistor r=0.4839 c=0
Rk114 (\5\:VDD \6\:VDD) resistor r=0.218 c=0
Rk115 (\6\:VDD \7\:VDD) resistor r=0.2306 c=0
Rk124 (\7\:VDD \16\:VDD) resistor r=0.2896 c=0
Rk127 (\16\:VDD \19\:VDD) resistor r=0.716 c=0
Rk128 (\19\:VDD \20\:VDD) resistor r=0.2682 c=0
Rk129 (\20\:VDD \21\:VDD) resistor r=0.1468 c=0
Rk130 (\21\:VDD \22\:VDD) resistor r=0.4451 c=0
Rk132 (\23\:VDD VDD) resistor r=0.04991 c=0
Rk131 (\22\:VDD \23\:VDD) resistor r=0.1077 c=0
Rk133 (\3\:VDD \25\:VDD) resistor r=0.2032 c=0
Rk134 (\5\:VDD \27\:VDD) resistor r=0.07405 c=0
Rk142 (\19\:VDD \43\:VDD) resistor r=0.07405 c=0
Rk143 (\21\:VDD \45\:VDD) resistor r=0.04332 c=0
Rk144 (\22\:VDD \47\:VDD) resistor r=0.2667 c=0
Rk1 (\5\:SI SI) resistor r=0.003299 c=0
Rk76 (\2\:VSS \3\:VSS) resistor r=0.05749 c=0
Rk77 (\3\:VSS \4\:VSS) resistor r=0.3434 c=0
Rk78 (\4\:VSS \5\:VSS) resistor r=0.1252 c=0
Rk79 (\5\:VSS \6\:VSS) resistor r=0.1275 c=0
Rk80 (\6\:VSS \7\:VSS) resistor r=0.3022 c=0
Rk81 (\7\:VSS \8\:VSS) resistor r=0.09417 c=0
Rk82 (\8\:VSS \9\:VSS) resistor r=0.35 c=0
Rk88 (\9\:VSS \15\:VSS) resistor r=0.1594 c=0
Rk89 (\15\:VSS \16\:VSS) resistor r=0.2556 c=0
Rk91 (\16\:VSS \18\:VSS) resistor r=0.5391 c=0
Rk92 (\3\:VSS \20\:VSS) resistor r=0.07405 c=0
Rk93 (\5\:VSS \22\:VSS) resistor r=0.2467 c=0
Rk94 (\6\:VSS \24\:VSS) resistor r=0.07405 c=0
Rk95 (\7\:VSS \26\:VSS) resistor r=0.04332 c=0
Rk103 (\18\:VSS \41\:VSS) resistor r=0.5854 c=0
Rk104 (\41\:VSS \42\:VSS) resistor r=0.218 c=0
Rk105 (\42\:VSS \43\:VSS) resistor r=0.1929 c=0
Rk107 (\44\:VSS VSS) resistor r=0.04991 c=0
Rk106 (\43\:VSS \44\:VSS) resistor r=0.1077 c=0
Rk108 (\18\:VSS \46\:VSS) resistor r=0.07149 c=0
Rk109 (\41\:VSS \48\:VSS) resistor r=0.3117 c=0
Rk110 (\43\:VSS \50\:VSS) resistor r=0.3094 c=0
Rk46 (RN \4\:RN) resistor r=0.1137 c=0
Rk2 (\4\:SEb \6\:SEb) resistor r=0.5459 c=0
Rk3 (\6\:SEb \8\:SEb) resistor r=0.6251 c=0
Rk8 (\2\:Dpb \3\:Dpb) resistor r=0.3904 c=0
Rk9 (\3\:Dpb \5\:Dpb) resistor r=0.588 c=0
Rk10 (\3\:Dpb \7\:Dpb) resistor r=0.06035 c=0
Rk11 (\5\:Dpb \9\:Dpb) resistor r=0.5454 c=0
Rk62 (\5\:Dp \6\:Dp) resistor r=0.3459 c=0
Rk63 (\6\:Dp \7\:Dp) resistor r=0.1805 c=0
Rk64 (\7\:Dp \8\:Dp) resistor r=0.3849 c=0
Rk65 (\8\:Dp \9\:Dp) resistor r=5.3912 c=0
Rk66 (\6\:Dp \11\:Dp) resistor r=0.03441 c=0
Rk67 (\7\:Dp \13\:Dp) resistor r=0.6102 c=0
Rk68 (\8\:Dp \15\:Dp) resistor r=0.1945 c=0
Rk18 (\8\:CKbb \9\:CKbb) resistor r=0.8482 c=0
Rk19 (\9\:CKbb \10\:CKbb) resistor r=0.1164 c=0
Rk20 (\10\:CKbb \12\:CKbb) resistor r=0.2746 c=0
Rk21 (\10\:CKbb \13\:CKbb) resistor r=0.3615 c=0
Rk22 (\12\:CKbb \15\:CKbb) resistor r=0.4225 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2242 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.4209 c=0
Rk28 (\15\:CKb \16\:CKb) resistor r=0.7375 c=0
Rk29 (\14\:CKb \18\:CKb) resistor r=0.9008 c=0
Rk30 (\18\:CKb \20\:CKb) resistor r=0.3374 c=0
Rk31 (\15\:CKb \21\:CKb) resistor r=0.2207 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.3027 c=0
Rk13 (\6\:n20 \8\:n20) resistor r=0.2842 c=0
Rk14 (\6\:n20 \10\:n20) resistor r=0.1206 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.1867 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2321 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.1541 c=0
Rk23 (\8\:n30 \9\:n30) resistor r=0.4387 c=0
Rk24 (\9\:n30 \11\:n30) resistor r=0.06436 c=0
Rk25 (\9\:n30 \13\:n30) resistor r=0.3288 c=0
Rk50 (\25\:qbint \26\:qbint) resistor r=0.8224 c=0
Rk56 (\27\:qbint \4\:qbint) resistor r=0.3073 c=0
Rk51 (\26\:qbint \27\:qbint) resistor r=1.421 c=0
Rk52 (\27\:qbint \28\:qbint) resistor r=0.9882 c=0
Rk53 (\28\:qbint \30\:qbint) resistor r=0.2082 c=0
Rk54 (\30\:qbint \31\:qbint) resistor r=0.2512 c=0
Rk55 (\26\:qbint \32\:qbint) resistor r=0.2536 c=0
Rk58 (\28\:qbint \36\:qbint) resistor r=0.06101 c=0
Rk43 (\15\:net582 \16\:net582) resistor r=0.03466 c=0
Rk44 (\16\:net582 \17\:net582) resistor r=0.3591 c=0
Rk45 (\16\:net582 \19\:net582) resistor r=0.3626 c=0
Rk47 (\4\:RNb \5\:RNb) resistor r=0.187 c=0
Rk48 (\5\:RNb \7\:RNb) resistor r=0.3794 c=0
Rk49 (\5\:RNb \9\:RNb) resistor r=0.09154 c=0
Rk71 (\5\:Eb \7\:Eb) resistor r=0.3476 c=0
Rk72 (\7\:Eb \8\:Eb) resistor r=1.2182 c=0
Rk74 (\5\:Db \6\:Db) resistor r=0.8 c=0
Rk75 (\5\:Db \8\:Db) resistor r=0.264 c=0
Rk60 (\2\:net493 \4\:net493) resistor r=0.2998 c=0
Rk61 (\2\:net505 \4\:net505) resistor r=0.5169 c=0
Rl39 (\2\:CK \3\:CK) resistor r=76.3736 c=0
Rl38 (\1\:CK \2\:CK) resistor r=26.9231 c=0
Rl82 (\1\:D \2\:D) resistor r=39.6174 c=0
Rl83 (\2\:D \3\:D) resistor r=24.2328 c=0
Rl76 (\2\:E \3\:E) resistor r=55.7572 c=0
Rl75 (\1\:E \2\:E) resistor r=134.41 c=0
Rl79 (\4\:E \5\:E) resistor r=47.3105 c=0
Rl81 (\5\:E \7\:E) resistor r=41.5412 c=0
Rl80 (\5\:E \6\:E) resistor r=69.604 c=0
Rl9 (\6\:SE \7\:SE) resistor r=64.1533 c=0
Rl6 (\4\:SE \5\:SE) resistor r=35.3072 c=0
Rl1 (\1\:SE \2\:SE) resistor r=114.153 c=0
Rl2 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl3 (\1\:SI \2\:SI) resistor r=61.257 c=0
Rl5 (\2\:SI \4\:SI) resistor r=111.257 c=0
Rl4 (\2\:SI \3\:SI) resistor r=3.3229 c=0
Rl68 (\2\:RN \3\:RN) resistor r=79.3856 c=0
Rl67 (\1\:RN \2\:RN) resistor r=85.7713 c=0
Rl7 (SEb \2\:SEb) resistor r=136.511 c=0
Rl8 (\2\:SEb \3\:SEb) resistor r=26.3736 c=0
Rl10 (Dp \2\:Dp) resistor r=41.0764 c=0
Rl11 (\2\:Dp \3\:Dp) resistor r=169.083 c=0
Rl27 (\5\:CKbb \6\:CKbb) resistor r=187.581 c=0
Rl28 (\6\:CKbb \7\:CKbb) resistor r=24.2328 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=44.7803 c=0
Rl12 (CKbb \2\:CKbb) resistor r=63.0341 c=0
Rl29 (\11\:CKb \12\:CKb) resistor r=53.079 c=0
Rl26 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl14 (CKb \2\:CKb) resistor r=4.4012 c=0
Rl18 (\2\:CKb \6\:CKb) resistor r=24.7024 c=0
Rl19 (\3\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=162.881 c=0
Rl20 (\4\:CKb \8\:CKb) resistor r=85.6975 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=84.2779 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=146.229 c=0
Rl23 (n20 \2\:n20) resistor r=113.176 c=0
Rl25 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=1.2666 c=0
Rl21 (mout \2\:mout) resistor r=41.5405 c=0
Rl22 (\2\:mout \3\:mout) resistor r=93.0293 c=0
Rl34 (n30 \4\:n30) resistor r=4.6955 c=0
Rl71 (\23\:qbint \22\:qbint) resistor r=174.673 c=0
Rl72 (\24\:qbint \23\:qbint) resistor r=24.2328 c=0
Rl66 (\20\:qbint \21\:qbint) resistor r=64.8409 c=0
Rl65 (\20\:qbint \19\:qbint) resistor r=41.1312 c=0
Rl30 (\2\:qbint qbint) resistor r=41.5405 c=0
Rl31 (\2\:qbint \3\:qbint) resistor r=85.7713 c=0
Rl69 (RNb \2\:RNb) resistor r=65.6605 c=0
Rl70 (\2\:RNb \3\:RNb) resistor r=118.464 c=0
Rl73 (Eb \2\:Eb) resistor r=118.464 c=0
Rl74 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl77 (Db \2\:Db) resistor r=31.0981 c=0
Rl78 (\2\:Db \3\:Db) resistor r=223.077 c=0
Rz34 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz35 (\4\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz36 (\6\:VDD \1\:VDD) resistor r=15 c=0
Rz40 (\7\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz41 (\16\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz42 (\20\:VDD \1\:VDD) resistor r=6.25 c=0
Rz43 (\23\:VDD \1\:VDD) resistor r=37.5 c=0
Rz20 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz23 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz31 (\46\:VSS \45\:VSS) resistor r=75 c=0
Rz32 (\48\:VSS \47\:VSS) resistor r=75 c=0
Rz33 (\50\:VSS \49\:VSS) resistor r=75 c=0
Rz1 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz2 (Dpb \2\:Dpb) resistor r=75 c=0
Rz3 (\8\:Dpb \9\:Dpb) resistor r=75 c=0
Rz16 (\12\:Dp \13\:Dp) resistor r=75 c=0
Rz17 (\14\:Dp \15\:Dp) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz4 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz15 (\36\:qbint \35\:qbint) resistor r=75 c=0
Rz13 (\19\:net582 \18\:net582) resistor r=75 c=0
Rz14 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz18 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz19 (\7\:Db \8\:Db) resistor r=75 c=0
Ry32 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry33 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry41 (\43\:VDD \42\:VDD) resistor r=62 c=0
Ry42 (\45\:VDD \44\:VDD) resistor r=62 c=0
Ry43 (\47\:VDD \46\:VDD) resistor r=62 c=0
Ry24 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry25 (\4\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry26 (\8\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry27 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry28 (\15\:VSS \1\:VSS) resistor r=7.75 c=0
Ry29 (\18\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\42\:VSS \1\:VSS) resistor r=15.5 c=0
Ry31 (\44\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry2 (\4\:Dpb \5\:Dpb) resistor r=62 c=0
Ry3 (\6\:Dpb \7\:Dpb) resistor r=62 c=0
Ry20 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry21 (\10\:Dp \11\:Dp) resistor r=62 c=0
Ry6 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry8 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry4 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry15 (\30\:qbint \29\:qbint) resistor r=62 c=0
Ry13 (\15\:net582 \14\:net582) resistor r=62 c=0
Ry14 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry22 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry23 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (net493 \2\:net493) resistor r=62 c=0
Ry17 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry18 (net505 \2\:net505) resistor r=62 c=0
Ry19 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx28 (\2\:D \4\:D) resistor r=45 c=0
Rx25 (\6\:E \8\:E) resistor r=45 c=0
Rx26 (\2\:E \9\:E) resistor r=45 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\2\:SE \10\:SE) resistor r=45 c=0
Rx5 (\5\:SE \11\:SE) resistor r=45 c=0
Rx1 (\3\:SI \5\:SI) resistor r=45 c=0
Rx17 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx24 (Dp \9\:Dp) resistor r=45 c=0
Rx8 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\12\:CKb \13\:CKb) resistor r=45 c=0
Rx13 (CKb \16\:CKb) resistor r=45 c=0
Rx14 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx7 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\8\:n30 \4\:n30) resistor r=45 c=0
Rx19 (\25\:qbint \24\:qbint) resistor r=45 c=0
Rx20 (\31\:qbint \2\:qbint) resistor r=45 c=0
Rx21 (\32\:qbint \20\:qbint) resistor r=45 c=0
Rx16 (\17\:net582 net582) resistor r=45 c=0
Rx18 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx27 (\2\:Eb \8\:Eb) resistor r=45 c=0
Rx29 (Db \6\:Db) resistor r=45 c=0
mn10 (\7\:SEb \3\:SE \49\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn13 (net658 \4\:SI \49\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=8.7e-15 ps=6.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.2e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (\8\:Dpb \4\:SE net658 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=8.15e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (\8\:Dpb SEb net650 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=6.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (net650 \3\:Dp \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn21 (\11\:CKbb \5\:CKb \47\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn25 (\9\:n20 \7\:CKb Dpb VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.422e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\9\:n20 \3\:CKbb net606 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.422e-14 ps=4.1e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.845e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.74e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\10\:n30 \7\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.567e-14 ad=4.857e-14 ps=9.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.115e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \4\:n20 \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=4.567e-14 ps=1.6e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\10\:n30 \11\:CKb net618 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=4.857e-14 ps=4.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=7.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \3\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.102e-14 ad=1.015e-14 ps=8.6e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=6.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45_1__rcx (\35\:qbint n30 \16\:VSS VSS) g45n1svt w=(2.05e-07) \
        l=4.5e-08 nf=1 as=3.486e-14 ad=3.382e-14 ps=7.75e-07 pd=7.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.445e-06 sb=3.5e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn20 (\19\:CKb \1\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.33e-14 ad=3.407e-14 ps=1.62e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn55_1__rcx (\1\:Q \4\:qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.783e-14 ad=4.16e-14 ps=1.485e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.04231e-07 sb=2e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn57_1__rcx (\1\:QN net582 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=4.16e-14 ps=1.44e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34423e-06 sb=1.08e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(4)
mn56 (\18\:net582 \19\:qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn2 (\8\:RNb \1\:RN \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.452e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn3 (\14\:Dp RNb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.452e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=4.85e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (\14\:Dp \23\:qbint net634 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2.8e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn4 (net634 \3\:Eb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=1.957e-14 ps=1.28e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn6 (net638 \1\:E \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=1.377e-14 ps=6.4e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=2.8e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn7 (\12\:Dp \3\:Db net638 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.03e-14 ps=4.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn0 (\6\:Eb \7\:E \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \3\:D \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp13 (net557 \1\:SI \46\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=1.29e-14 ps=1.13e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.3e-07 sd=160n sca=20.6042 \
        scb=0.0198237 scc=0.00166414 m=(1)
mp14 (\4\:Dpb \3\:SEb net557 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.127e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=8.25e-07 sd=160n sca=19.9561 \
        scb=0.0191767 scc=0.00166251 m=(1)
mp12 (\4\:Dpb \6\:SE net549 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=6.127e-14 ps=6.6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=4.95e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp11 (net549 \2\:Dp \44\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.19e-14 ad=2.472e-14 ps=1.72e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=3.35e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp21 (\14\:CKbb \8\:CKb \44\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.19e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp25 (\7\:n20 CKbb \6\:Dpb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88279e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\12\:n30 \5\:CKbb net529 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=5.16e-14 ps=7.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=7.06977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\7\:n20 \6\:CKb net521 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (net521 mout \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.442e-14 ad=3.332e-14 ps=2e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.55198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\8\:mout n20 \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.442e-14 ad=6.773e-14 ps=2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.35198e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\12\:n30 \9\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=5.16e-14 ps=1.06e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=9.91977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp50 (net529 qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.015e-14 ad=3.547e-14 ps=2.09e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=4.96977e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp45 (\29\:qbint n30 \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.662e-14 ad=4.96e-14 ps=1.945e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.30242e-07 sb=3.75e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(2)
mp20 (\17\:CKb \3\:CK \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1772e-13 ad=4.085e-14 ps=1.89e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp55_1__rcx (Q \4\:qbint \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.2348e-13 ad=6.825e-14 ps=1.8825e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.29872e-07 sb=2e-06 sd=160n \
        sca=27.1129 scb=0.0194379 scc=0.00296416 m=(4)
mp57_1__rcx (QN net582 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.206e-13 ad=6.24e-14 ps=1.8e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29987e-06 sb=1.08e-06 sd=160n sca=27.1129 \
        scb=0.0194379 scc=0.00296416 m=(4)
mp56 (\14\:net582 \21\:qbint \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.254e-13 ad=5.46e-14 ps=1.88e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=27.1129 scb=0.0194379 \
        scc=0.00296416 m=(1)
mp2 (\6\:RNb \3\:RN \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=3.01e-14 ps=1.71e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.7e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp5 (net505 \22\:qbint \3\:net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.45e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp3 (\3\:net493 \3\:RNb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.77e-14 ad=6.773e-14 ps=1.71e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.05e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp4 (net505 Eb net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp6 (\10\:Dp \3\:E \3\:net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.332e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=3.45e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp7 (\4\:Dp \2\:Db \3\:net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=13.7129 \
        scb=0.0130599 scc=0.000590384 m=(1)
mp0 (\4\:Eb \4\:E \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=3.01e-14 ps=1.5e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.55e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
mp1 (\4\:Db \1\:D \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=3.44e-14 ps=1.5e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.6e-07 sd=160n sca=55.1271 \
        scb=0.0420653 scc=0.00650135 m=(1)
ends SEDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:55:38 2012 )
// Library name: gsclib045
// Cell name: SEDFFTRXL
// View name: extracted

simulator lang=spectre

subckt SEDFFTRXL CK D E Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:net582 \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.205e-14 ad=3.547e-14 ps=1.92e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
C1 (D VSS) capacitor c=7.32869e-17
C2 (SE VSS) capacitor c=3.88525e-17
C3 (E VSS) capacitor c=2.80309e-17
C4 (Q VSS) capacitor c=6.68702e-17
C5 (VDD VSS) capacitor c=5.73908e-16
C6 (QN VSS) capacitor c=2.78272e-17
C7 (RN VSS) capacitor c=5.0282e-17
C8 (net582 VSS) capacitor c=2.01869e-17
C9 (qbint VSS) capacitor c=3.95609e-17
C10 (n30 VSS) capacitor c=3.76297e-17
C11 (net618 VSS) capacitor c=1.73811e-18
C12 (CKb VSS) capacitor c=3.63727e-17
C13 (mout VSS) capacitor c=6.42402e-17
C14 (CKbb VSS) capacitor c=5.65256e-17
C15 (n20 VSS) capacitor c=4.85585e-17
C16 (Dpb VSS) capacitor c=8.35348e-17
C17 (SEb VSS) capacitor c=6.00258e-17
C18 (net658 VSS) capacitor c=5.45368e-18
C19 (Dp VSS) capacitor c=5.0398e-17
C20 (RNb VSS) capacitor c=4.35582e-17
C21 (net634 VSS) capacitor c=2.6712e-18
C22 (Eb VSS) capacitor c=1.79611e-17
C23 (net638 VSS) capacitor c=4.7126e-20
C24 (Db VSS) capacitor c=6.67295e-17
C25 (net529 VSS) capacitor c=3.89755e-19
C26 (net521 VSS) capacitor c=1.06974e-18
C27 (net557 VSS) capacitor c=1.30105e-18
C28 (net549 VSS) capacitor c=3.18606e-18
C29 (net493 VSS) capacitor c=8.40526e-17
C30 (net505 VSS) capacitor c=8.37273e-17
C31 (\1\:D VSS) capacitor c=3.11848e-17
C32 (\4\:E VSS) capacitor c=4.41252e-17
C33 (\3\:E VSS) capacitor c=4.1229e-17
C34 (\4\:Eb VSS) capacitor c=5.57758e-17
C35 (\11\:qbint VSS) capacitor c=5.06911e-17
C36 (\3\:RNb VSS) capacitor c=5.5669e-17
C37 (\3\:RN VSS) capacitor c=3.37557e-17
C38 (\7\:qbint VSS) capacitor c=4.38174e-17
C39 (\5\:SE VSS) capacitor c=4.23266e-17
C40 (\1\:SI VSS) capacitor c=6.00782e-17
C41 (\1\:SE VSS) capacitor c=4.61453e-17
C42 (\1\:CK VSS) capacitor c=3.5356e-17
C43 (\8\:CKbb VSS) capacitor c=3.52477e-17
C44 (\4\:CKb VSS) capacitor c=1.43591e-16
C45 (\5\:CKb VSS) capacitor c=1.23539e-16
C46 (\4\:qbint VSS) capacitor c=5.4639e-17
C47 (\4\:net582 VSS) capacitor c=3.8701e-17
C48 (\4\:D VSS) capacitor c=2.89101e-17
C49 (\7\:E VSS) capacitor c=2.93633e-17
C50 (\2\:Db VSS) capacitor c=8.45837e-17
C51 (\1\:E VSS) capacitor c=6.90727e-17
C52 (\3\:Eb VSS) capacitor c=4.22204e-17
C53 (\10\:qbint VSS) capacitor c=9.0402e-17
C54 (\1\:RN VSS) capacitor c=4.79002e-17
C55 (\8\:qbint VSS) capacitor c=5.01615e-17
C56 (\3\:Dp VSS) capacitor c=3.55336e-17
C57 (\3\:SEb VSS) capacitor c=7.20472e-17
C58 (\7\:SE VSS) capacitor c=2.98907e-17
C59 (\3\:SI VSS) capacitor c=3.95513e-17
C60 (\4\:SE VSS) capacitor c=3.21848e-17
C61 (\3\:CK VSS) capacitor c=3.55634e-17
C62 (\8\:CKb VSS) capacitor c=2.37247e-17
C63 (\9\:CKb VSS) capacitor c=2.55006e-17
C64 (\5\:CKbb VSS) capacitor c=8.98906e-17
C65 (\3\:mout VSS) capacitor c=6.7959e-17
C66 (\3\:n20 VSS) capacitor c=3.19091e-17
C67 (\3\:CKbb VSS) capacitor c=5.97795e-17
C68 (\6\:CKb VSS) capacitor c=8.57988e-17
C69 (\5\:qbint VSS) capacitor c=5.31679e-17
C70 (\3\:n30 VSS) capacitor c=3.26647e-17
C71 (\2\:qbint VSS) capacitor c=4.4743e-17
C72 (\3\:net582 VSS) capacitor c=2.61921e-17
C73 (\3\:D VSS) capacitor c=2.32193e-17
C74 (\6\:E VSS) capacitor c=3.41341e-17
C75 (\3\:Db VSS) capacitor c=1.92687e-17
C76 (\2\:E VSS) capacitor c=7.19751e-17
C77 (\12\:qbint VSS) capacitor c=3.37422e-17
C78 (\2\:RNb VSS) capacitor c=6.08894e-17
C79 (\2\:RN VSS) capacitor c=4.32969e-17
C80 (\9\:qbint VSS) capacitor c=2.36808e-17
C81 (\2\:Dp VSS) capacitor c=4.20912e-17
C82 (\4\:SEb VSS) capacitor c=2.84337e-17
C83 (\6\:SE VSS) capacitor c=4.40136e-17
C84 (\2\:SEb VSS) capacitor c=3.78639e-17
C85 (\2\:SI VSS) capacitor c=4.77664e-17
C86 (\3\:SE VSS) capacitor c=8.32436e-18
C87 (\2\:CK VSS) capacitor c=3.66054e-17
C88 (\7\:CKb VSS) capacitor c=1.79465e-17
C89 (\7\:CKbb VSS) capacitor c=4.53343e-17
C90 (\6\:CKbb VSS) capacitor c=2.9279e-17
C91 (\2\:mout VSS) capacitor c=5.47378e-17
C92 (\2\:n20 VSS) capacitor c=3.35135e-17
C93 (\4\:CKbb VSS) capacitor c=2.20367e-17
C94 (\2\:CKbb VSS) capacitor c=5.78203e-17
C95 (\6\:qbint VSS) capacitor c=3.01822e-17
C96 (\2\:n30 VSS) capacitor c=3.20504e-17
C97 (\3\:qbint VSS) capacitor c=1.97494e-17
C98 (\4\:Db VSS) capacitor c=1.03372e-16
C99 (\18\:VDD VSS) capacitor c=1.63566e-17
C100 (\5\:Eb VSS) capacitor c=6.70523e-17
C101 (\4\:Dp VSS) capacitor c=8.07081e-17
C102 (\11\:Dp VSS) capacitor c=1.94106e-17
C103 (\3\:net505 VSS) capacitor c=7.83848e-17
C104 (\3\:net493 VSS) capacitor c=6.22257e-17
C105 (\20\:VDD VSS) capacitor c=1.97947e-17
C106 (\6\:RNb VSS) capacitor c=4.50132e-17
C107 (\1\:Q VSS) capacitor c=3.24832e-17
C108 (\22\:VDD VSS) capacitor c=1.94848e-17
C109 (\3\:Dpb VSS) capacitor c=2.79596e-16
C110 (\24\:VDD VSS) capacitor c=3.01937e-17
C111 (\8\:SEb VSS) capacitor c=1.65268e-16
C112 (\10\:CKb VSS) capacitor c=7.02194e-17
C113 (\26\:VDD VSS) capacitor c=2.41731e-17
C114 (\9\:CKbb VSS) capacitor c=6.24629e-17
C115 (\8\:Dpb VSS) capacitor c=4.26086e-17
C116 (\4\:n20 VSS) capacitor c=5.16634e-17
C117 (\28\:VDD VSS) capacitor c=6.79135e-17
C118 (\8\:mout VSS) capacitor c=5.60152e-17
C119 (\8\:n30 VSS) capacitor c=3.53471e-17
C120 (\30\:VDD VSS) capacitor c=3.64685e-17
C121 (\16\:qbint VSS) capacitor c=8.30252e-17
C122 (\5\:net582 VSS) capacitor c=3.34619e-17
C123 (\32\:VDD VSS) capacitor c=8.59102e-18
C124 (\1\:QN VSS) capacitor c=2.67588e-17
C125 (\1\:VDD VSS) capacitor c=2.86317e-16
C126 (\7\:Db VSS) capacitor c=3.7885e-17
C127 (\7\:Eb VSS) capacitor c=1.3305e-16
C128 (\13\:Dp VSS) capacitor c=1.11325e-16
C129 (\8\:Dp VSS) capacitor c=1.76743e-16
C130 (\8\:RNb VSS) capacitor c=4.75084e-17
C131 (\3\:Q VSS) capacitor c=5.65576e-17
C132 (\6\:SEb VSS) capacitor c=2.09658e-16
C133 (\14\:CKb VSS) capacitor c=3.74164e-17
C134 (\11\:CKbb VSS) capacitor c=7.25631e-17
C135 (\6\:Dpb VSS) capacitor c=8.31348e-17
C136 (\8\:n20 VSS) capacitor c=3.71701e-17
C137 (\6\:mout VSS) capacitor c=5.34566e-17
C138 (\4\:n30 VSS) capacitor c=7.04035e-17
C139 (\19\:qbint VSS) capacitor c=6.50705e-17
C140 (\9\:net582 VSS) capacitor c=3.62216e-17
C141 (\3\:QN VSS) capacitor c=3.10857e-17
C142 (\2\:net582 VSS) capacitor c=1.24803e-17
C143 (\2\:CKb VSS) capacitor c=3.14263e-17
C144 (\3\:CKb VSS) capacitor c=6.7318e-17
C145 (\2\:SE VSS) capacitor c=1.84501e-17
C146 (\7\:net582 VSS) capacitor c=2.86027e-17
C147 (\8\:net582 VSS) capacitor c=3.57936e-17
C148 (\6\:n30 VSS) capacitor c=8.6662e-17
C149 (\7\:n30 VSS) capacitor c=7.22072e-17
C150 (\2\:Eb VSS) capacitor c=3.3605e-17
C151 (\4\:mout VSS) capacitor c=7.62186e-17
C152 (\5\:mout VSS) capacitor c=6.87668e-17
C153 (\6\:n20 VSS) capacitor c=5.70769e-17
C154 (\7\:n20 VSS) capacitor c=5.8705e-17
C155 (\5\:E VSS) capacitor c=3.04253e-17
C156 (\2\:D VSS) capacitor c=1.43178e-17
C157 (\13\:CKbb VSS) capacitor c=7.35911e-17
C158 (\14\:CKbb VSS) capacitor c=7.71887e-17
C159 (\15\:CKbb VSS) capacitor c=1.07057e-16
C160 (\16\:CKbb VSS) capacitor c=8.41016e-17
C161 (\17\:CKbb VSS) capacitor c=7.44211e-17
C162 (\4\:CK VSS) capacitor c=1.07111e-16
C163 (\12\:CKb VSS) capacitor c=7.23589e-17
C164 (\13\:CKb VSS) capacitor c=5.93258e-17
C165 (\4\:SI VSS) capacitor c=3.97867e-17
C166 (\6\:SI VSS) capacitor c=4.66753e-17
C167 (\8\:SE VSS) capacitor c=8.16928e-17
C168 (\9\:SE VSS) capacitor c=8.51591e-17
C169 (\5\:Dpb VSS) capacitor c=2.56375e-16
C170 (\5\:SEb VSS) capacitor c=1.17169e-16
C171 (\10\:SEb VSS) capacitor c=9.21151e-17
C172 (\4\:RN VSS) capacitor c=7.20146e-17
C173 (\4\:RNb VSS) capacitor c=6.2872e-17
C174 (\5\:RNb VSS) capacitor c=6.50742e-17
C175 (\13\:qbint VSS) capacitor c=9.02053e-17
C176 (\14\:qbint VSS) capacitor c=4.62773e-16
C177 (\15\:qbint VSS) capacitor c=4.69127e-16
C178 (\18\:qbint VSS) capacitor c=2.061e-17
C179 (\21\:qbint VSS) capacitor c=2.65259e-17
C180 (\6\:Dp VSS) capacitor c=9.40411e-17
C181 (\7\:Dp VSS) capacitor c=1.33472e-16
C182 (\10\:Dp VSS) capacitor c=1.82083e-16
C183 (\8\:E VSS) capacitor c=4.18643e-17
C184 (\9\:E VSS) capacitor c=2.9413e-17
C185 (\10\:E VSS) capacitor c=2.69669e-17
C186 (\9\:Eb VSS) capacitor c=1.20272e-16
C187 (\5\:D VSS) capacitor c=5.66179e-17
C188 (\6\:Db VSS) capacitor c=9.23785e-17
C189 (\3\:VDD VSS) capacitor c=1.96424e-17
C190 (\7\:VDD VSS) capacitor c=3.11939e-17
C191 (\9\:VDD VSS) capacitor c=2.70479e-17
C192 (\10\:VDD VSS) capacitor c=2.62955e-17
C193 (\12\:VDD VSS) capacitor c=4.85394e-18
Rk62 (D \5\:D) resistor r=0.1492 c=0
Rk89 (\2\:VSS \4\:VSS) resistor r=0.5637 c=0
Rk90 (\4\:VSS \5\:VSS) resistor r=0.203 c=0
Rk91 (\5\:VSS \6\:VSS) resistor r=0.1426 c=0
Rk92 (\6\:VSS \7\:VSS) resistor r=0.248 c=0
Rk93 (\7\:VSS \8\:VSS) resistor r=0.1077 c=0
Rk94 (\8\:VSS \9\:VSS) resistor r=0.3661 c=0
Rk95 (\9\:VSS \10\:VSS) resistor r=0.2357 c=0
Rk96 (\10\:VSS \11\:VSS) resistor r=0.2407 c=0
Rk97 (\11\:VSS \12\:VSS) resistor r=0.2607 c=0
Rk98 (\12\:VSS \13\:VSS) resistor r=0.2683 c=0
Rk99 (\13\:VSS \14\:VSS) resistor r=0.2833 c=0
Rk100 (\14\:VSS \15\:VSS) resistor r=0.2959 c=0
Rk101 (\15\:VSS \16\:VSS) resistor r=0.5066 c=0
Rk102 (\5\:VSS \18\:VSS) resistor r=0.1903 c=0
Rk103 (\6\:VSS \20\:VSS) resistor r=0.1903 c=0
Rk104 (\7\:VSS \22\:VSS) resistor r=0.3206 c=0
Rk105 (\9\:VSS \24\:VSS) resistor r=0.2801 c=0
Rk106 (\11\:VSS \26\:VSS) resistor r=0.1735 c=0
Rk107 (\13\:VSS \28\:VSS) resistor r=0.2623 c=0
Rk108 (\15\:VSS \30\:VSS) resistor r=0.1433 c=0
Rk110 (\31\:VSS VSS) resistor r=0.12 c=0
Rk109 (\16\:VSS \31\:VSS) resistor r=0.3316 c=0
Rk111 (\16\:VSS \33\:VSS) resistor r=0.4131 c=0
Rk112 (\31\:VSS \35\:VSS) resistor r=0.3818 c=0
Rk29 (\9\:SE SE) resistor r=0.08774 c=0
Rk28 (\8\:SE \9\:SE) resistor r=0.5266 c=0
Rk59 (\9\:E E) resistor r=0.002661 c=0
Rk57 (\8\:E \9\:E) resistor r=0.1468 c=0
Rk58 (\9\:E \10\:E) resistor r=0.06555 c=0
Rk37 (Q \2\:Q) resistor r=0.2127 c=0
Rk38 (Q \4\:Q) resistor r=0.1294 c=0
Rk25 (\4\:SI \5\:SI) resistor r=0.007126 c=0
Rk26 (SI \6\:SI) resistor r=0.006968 c=0
Rk27 (\4\:SI \6\:SI) resistor r=0.01584 c=0
Rk65 (\2\:VDD \3\:VDD) resistor r=0.09264 c=0
Rk66 (\3\:VDD \4\:VDD) resistor r=0.4088 c=0
Rk67 (\4\:VDD \5\:VDD) resistor r=0.4715 c=0
Rk68 (\5\:VDD \6\:VDD) resistor r=0.08009 c=0
Rk69 (\6\:VDD \7\:VDD) resistor r=0.315 c=0
Rk70 (\7\:VDD \8\:VDD) resistor r=0.3853 c=0
Rk71 (\8\:VDD \9\:VDD) resistor r=0.07413 c=0
Rk72 (\9\:VDD \10\:VDD) resistor r=0.5271 c=0
Rk73 (\10\:VDD \11\:VDD) resistor r=0.2974 c=0
Rk74 (\11\:VDD \12\:VDD) resistor r=0.2959 c=0
Rk75 (\12\:VDD \13\:VDD) resistor r=0.2557 c=0
Rk76 (\13\:VDD \14\:VDD) resistor r=0.2582 c=0
Rk77 (\14\:VDD \15\:VDD) resistor r=0.1428 c=0
Rk78 (\15\:VDD \16\:VDD) resistor r=0.1805 c=0
Rk80 (\17\:VDD VDD) resistor r=0.04993 c=0
Rk79 (\16\:VDD \17\:VDD) resistor r=0.07006 c=0
Rk81 (\3\:VDD \19\:VDD) resistor r=0.07428 c=0
Rk82 (\5\:VDD \21\:VDD) resistor r=0.07428 c=0
Rk83 (\7\:VDD \23\:VDD) resistor r=0.04334 c=0
Rk84 (\9\:VDD \25\:VDD) resistor r=0.04334 c=0
Rk85 (\10\:VDD \27\:VDD) resistor r=0.04334 c=0
Rk86 (\12\:VDD \29\:VDD) resistor r=0.3051 c=0
Rk87 (\14\:VDD \31\:VDD) resistor r=0.1914 c=0
Rk88 (\16\:VDD \33\:VDD) resistor r=0.1031 c=0
Rk21 (\4\:CK CK) resistor r=0.006094 c=0
Rk2 (\4\:QN QN) resistor r=0.05602 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2328 c=0
Rk39 (RN \4\:RN) resistor r=0.03526 c=0
Rk3 (\6\:net582 \7\:net582) resistor r=0.115 c=0
Rk4 (\7\:net582 \8\:net582) resistor r=0.1197 c=0
Rk5 (\7\:net582 \10\:net582) resistor r=0.109 c=0
Rk43 (\13\:qbint \14\:qbint) resistor r=0.6255 c=0
Rk44 (\14\:qbint \15\:qbint) resistor r=3.4274 c=0
Rk45 (\15\:qbint \17\:qbint) resistor r=0.3782 c=0
Rk46 (\15\:qbint \18\:qbint) resistor r=0.03527 c=0
Rk47 (\17\:qbint \20\:qbint) resistor r=0.4621 c=0
Rk48 (\17\:qbint \21\:qbint) resistor r=0.1956 c=0
Rk6 (\5\:n30 \6\:n30) resistor r=0.3399 c=0
Rk7 (\6\:n30 \7\:n30) resistor r=0.4388 c=0
Rk8 (\6\:n30 \9\:n30) resistor r=0.05922 c=0
Rk22 (\11\:CKb \12\:CKb) resistor r=0.3939 c=0
Rk23 (\12\:CKb \13\:CKb) resistor r=0.3157 c=0
Rk24 (\12\:CKb \15\:CKb) resistor r=0.2238 c=0
Rk9 (\4\:mout \5\:mout) resistor r=0.3392 c=0
Rk10 (\5\:mout \7\:mout) resistor r=0.2603 c=0
Rk11 (\5\:mout \9\:mout) resistor r=0.1853 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.4342 c=0
Rk16 (\12\:CKbb \13\:CKbb) resistor r=0.2754 c=0
Rk17 (\13\:CKbb \14\:CKbb) resistor r=0.2112 c=0
Rk18 (\14\:CKbb \15\:CKbb) resistor r=0.4637 c=0
Rk19 (\15\:CKbb \16\:CKbb) resistor r=0.5537 c=0
Rk20 (\13\:CKbb \17\:CKbb) resistor r=0.4255 c=0
Rk12 (\5\:n20 \6\:n20) resistor r=0.2987 c=0
Rk13 (\6\:n20 \7\:n20) resistor r=0.31 c=0
Rk14 (\6\:n20 \9\:n20) resistor r=0.1284 c=0
Rk30 (\2\:Dpb \4\:Dpb) resistor r=0.5786 c=0
Rk31 (\4\:Dpb \5\:Dpb) resistor r=1.7445 c=0
Rk32 (\5\:Dpb \7\:Dpb) resistor r=0.4659 c=0
Rk33 (\5\:Dpb \9\:Dpb) resistor r=0.09047 c=0
Rk34 (\5\:SEb \7\:SEb) resistor r=0.8068 c=0
Rk35 (\7\:SEb \9\:SEb) resistor r=0.9062 c=0
Rk36 (\9\:SEb \10\:SEb) resistor r=0.5606 c=0
Rk51 (\5\:Dp \6\:Dp) resistor r=0.3165 c=0
Rk52 (\6\:Dp \7\:Dp) resistor r=0.6342 c=0
Rk53 (\7\:Dp \9\:Dp) resistor r=0.08336 c=0
Rk54 (\9\:Dp \10\:Dp) resistor r=1.5293 c=0
Rk55 (\6\:Dp \12\:Dp) resistor r=0.05709 c=0
Rk56 (\7\:Dp \14\:Dp) resistor r=0.678 c=0
Rk40 (\4\:RNb \5\:RNb) resistor r=0.28 c=0
Rk41 (\5\:RNb \7\:RNb) resistor r=0.2472 c=0
Rk42 (\5\:RNb \9\:RNb) resistor r=0.2342 c=0
Rk60 (\6\:Eb \8\:Eb) resistor r=0.3209 c=0
Rk61 (\8\:Eb \9\:Eb) resistor r=0.7042 c=0
Rk63 (\5\:Db \6\:Db) resistor r=0.7564 c=0
Rk64 (\5\:Db \8\:Db) resistor r=0.2759 c=0
Rk49 (\2\:net493 \4\:net493) resistor r=0.333 c=0
Rk50 (\2\:net505 \4\:net505) resistor r=0.5298 c=0
Rl57 (\1\:D \2\:D) resistor r=43.9449 c=0
Rl59 (\2\:D \4\:D) resistor r=47.791 c=0
Rl58 (\2\:D \3\:D) resistor r=1.2666 c=0
Rl34 (\5\:SE \6\:SE) resistor r=94.2308 c=0
Rl35 (\6\:SE \7\:SE) resistor r=39.5604 c=0
Rl28 (\1\:SE \2\:SE) resistor r=100.803 c=0
Rl30 (\2\:SE \4\:SE) resistor r=46.9565 c=0
Rl29 (\2\:SE \3\:SE) resistor r=3.1183 c=0
Rl51 (\2\:E \3\:E) resistor r=84.5926 c=0
Rl50 (\1\:E \2\:E) resistor r=134.41 c=0
Rl54 (\4\:E \5\:E) resistor r=55.0028 c=0
Rl56 (\5\:E \7\:E) resistor r=41.5412 c=0
Rl55 (\5\:E \6\:E) resistor r=75.3733 c=0
Rl31 (\1\:SI \2\:SI) resistor r=30.0021 c=0
Rl32 (\2\:SI \3\:SI) resistor r=99.2328 c=0
Rl26 (\1\:CK \2\:CK) resistor r=24.2328 c=0
Rl27 (\2\:CK \3\:CK) resistor r=101.156 c=0
Rl42 (\2\:RN \3\:RN) resistor r=30.2198 c=0
Rl41 (\1\:RN \2\:RN) resistor r=140.385 c=0
Rl1 (net582 \2\:net582) resistor r=2.0213 c=0
Rl3 (\2\:net582 \4\:net582) resistor r=47.791 c=0
Rl2 (\2\:net582 \3\:net582) resistor r=36.2526 c=0
Rl45 (\10\:qbint \11\:qbint) resistor r=211.104 c=0
Rl39 (\7\:qbint \8\:qbint) resistor r=157.692 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=167.308 c=0
Rl4 (qbint \2\:qbint) resistor r=92.3077 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=32.908 c=0
Rl40 (\7\:qbint \9\:qbint) resistor r=80.0021 c=0
Rl9 (\4\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl5 (qbint \3\:qbint) resistor r=24.2328 c=0
Rl6 (n30 \2\:n30) resistor r=33.8482 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=105.002 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=403.412 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=39.1533 c=0
Rl18 (CKb \2\:CKb) resistor r=53.0797 c=0
Rl23 (\2\:CKb \7\:CKb) resistor r=32.6176 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=195.697 c=0
Rl25 (\3\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=221.992 c=0
Rl14 (mout \2\:mout) resistor r=50.6918 c=0
Rl15 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=62.9746 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl10 (CKbb \2\:CKbb) resistor r=64.6174 c=0
Rl12 (n20 \2\:n20) resistor r=112.23 c=0
Rl13 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=51.1559 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl37 (Dp \2\:Dp) resistor r=103.079 c=0
Rl38 (\2\:Dp \3\:Dp) resistor r=26.1559 c=0
Rl43 (RNb \2\:RNb) resistor r=93.0292 c=0
Rl44 (\2\:RNb \3\:RNb) resistor r=89.6174 c=0
Rl47 (Eb \2\:Eb) resistor r=5.915 c=0
Rl49 (\2\:Eb \4\:Eb) resistor r=151.637 c=0
Rl48 (\2\:Eb \3\:Eb) resistor r=34.3295 c=0
Rl52 (Db \2\:Db) resistor r=240.385 c=0
Rl53 (Db \3\:Db) resistor r=24.2328 c=0
Rz26 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz27 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz28 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz30 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz31 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz32 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz33 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz34 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz35 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz11 (\3\:Q \4\:Q) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz20 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz21 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz22 (\1\:VDD \11\:VDD) resistor r=12.5 c=0
Rz23 (\1\:VDD \13\:VDD) resistor r=15 c=0
Rz24 (\1\:VDD \15\:VDD) resistor r=25 c=0
Rz25 (\1\:VDD \17\:VDD) resistor r=37.5 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\9\:net582 \10\:net582) resistor r=75 c=0
Rz13 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dpb \2\:Dpb) resistor r=75 c=0
Rz9 (\6\:Dpb \7\:Dpb) resistor r=75 c=0
Rz10 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz14 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz15 (\13\:Dp \14\:Dp) resistor r=75 c=0
Rz12 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz16 (\7\:Eb \8\:Eb) resistor r=75 c=0
Rz17 (\7\:Db \8\:Db) resistor r=75 c=0
Ry30 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry31 (\3\:VSS \8\:VSS) resistor r=8.8571 c=0
Ry32 (\3\:VSS \10\:VSS) resistor r=12.4 c=0
Ry33 (\3\:VSS \12\:VSS) resistor r=12.4 c=0
Ry34 (\3\:VSS \14\:VSS) resistor r=10.3333 c=0
Ry35 (\3\:VSS \16\:VSS) resistor r=6.2 c=0
Ry11 (\1\:Q \2\:Q) resistor r=62 c=0
Ry22 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry23 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry24 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry25 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry27 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry28 (\30\:VDD \31\:VDD) resistor r=62 c=0
Ry29 (\32\:VDD \33\:VDD) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry2 (\5\:net582 \6\:net582) resistor r=62 c=0
Ry13 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\10\:CKb \11\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Dpb \4\:Dpb) resistor r=62 c=0
Ry9 (\8\:Dpb \9\:Dpb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry18 (\4\:Dp \5\:Dp) resistor r=62 c=0
Ry19 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry12 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry20 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry21 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (net493 \2\:net493) resistor r=62 c=0
Ry15 (\3\:net493 \4\:net493) resistor r=62 c=0
Ry16 (net505 \2\:net505) resistor r=62 c=0
Ry17 (\3\:net505 \4\:net505) resistor r=62 c=0
Rx26 (\3\:D \5\:D) resistor r=45 c=0
Rx12 (\6\:SE \8\:SE) resistor r=45 c=0
Rx13 (\3\:SE \9\:SE) resistor r=45 c=0
Rx23 (\6\:E \8\:E) resistor r=45 c=0
Rx24 (\2\:E \10\:E) resistor r=45 c=0
Rx11 (\2\:SI \5\:SI) resistor r=45 c=0
Rx9 (\2\:CK \4\:CK) resistor r=45 c=0
Rx16 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (net582 \8\:net582) resistor r=45 c=0
Rx18 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx19 (\9\:qbint \14\:qbint) resistor r=45 c=0
Rx20 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx21 (\3\:qbint \21\:qbint) resistor r=45 c=0
Rx2 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:mout \4\:mout) resistor r=45 c=0
Rx5 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\7\:CKbb \17\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx14 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx15 (\2\:SEb \10\:SEb) resistor r=45 c=0
Rx22 (\2\:Dp \10\:Dp) resistor r=45 c=0
Rx17 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx25 (Eb \9\:Eb) resistor r=45 c=0
Rx27 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:net582 \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net582 \2\:qbint \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint \3\:n30 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.895e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net618 \5\:qbint \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.61e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\4\:n30 \6\:CKb net618 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.425e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\4\:n30 \3\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=3.988e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net606 \3\:mout \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net606 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:n20 \9\:CKb \6\:Dpb VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.9e-14 ps=8.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\11\:CKbb \8\:CKb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn20 (\14\:CKb \3\:CK \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn10 (\6\:SEb \4\:SE \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn13 (net658 \3\:SI \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=3.915e-14 ps=9.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.145e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Dpb \7\:SE net658 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=8.3e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Dpb \3\:SEb net650 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=6.25e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (net650 \3\:Dp \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.305e-14 ps=7.3e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.9e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn55 (\3\:Q \8\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=2.25e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn2 (\8\:RNb \1\:RN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=3.408e-14 ps=7.7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=7.75e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn3 (\8\:Dp RNb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.9e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn5 (\8\:Dp \10\:qbint net634 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.85e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn4 (net634 \3\:Eb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=1.015e-14 ps=9.6e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn6 (net638 \1\:E \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn7 (\13\:Dp \2\:Db net638 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\7\:Eb \7\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \4\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp56 (\5\:net582 qbint \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.205e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=48.8019 \
        scb=0.0316124 scc=0.00590646 m=(1)
mp45 (\16\:qbint n30 \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.96e-14 ad=3.01e-14 ps=1.21e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72e-06 sd=160n sca=12.1962 \
        scb=0.0105853 scc=0.000305891 m=(1)
mp50 (net529 \4\:qbint \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.96e-14 ad=2.903e-14 ps=1.21e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.435e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\8\:n30 CKbb net529 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.548e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.255e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\8\:n30 \5\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.913e-14 ad=3.548e-14 ps=9.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.045e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=7.25e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net521 mout \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=4.6e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \4\:CKb net521 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.655e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=3.55e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \8\:CKbb \8\:Dpb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.655e-14 ps=7.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.5e-14 ad=4.3e-14 ps=1.98e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=4.35e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp20 (\10\:CKb \1\:CK \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.5e-14 ad=4.3e-14 ps=1.98e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=2e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp10 (\8\:SEb \1\:SE \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=3.01e-14 ps=1.86e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.325e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp13 (net557 \1\:SI \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=1.505e-14 ps=1.86e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.06e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp14 (\3\:Dpb SEb net557 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.838e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=9.45e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp12 (\3\:Dpb \5\:SE net549 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.838e-14 ad=4.838e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=6.75e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp11 (net549 Dp \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=4.838e-14 ps=1.86e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=4.05e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp1 (\4\:Db \1\:D \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.755e-14 ad=3.01e-14 ps=1.88e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=47.8434 \
        scb=0.0441905 scc=0.00576115 m=(1)
mp55 (\1\:Q \7\:qbint \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.067e-13 ad=3.01e-14 ps=1.86e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=1.4e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp2 (\6\:RNb \3\:RN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.918e-14 ad=4.085e-14 ps=1.56e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.2e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp3 (\3\:net493 \3\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.918e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.5e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (\3\:net505 \11\:qbint \3\:net493 VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.65e-07 sb=3.45e-07 sd=160n \
        sca=12.7104 scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\3\:net505 \4\:Eb net493 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\11\:Dp \3\:E net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp7 (\4\:Dp Db net505 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.4e-07 sd=160n sca=15.4613 \
        scb=0.0150753 scc=0.000885445 m=(1)
mp0 (\5\:Eb \4\:E \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.755e-14 ad=3.01e-14 ps=1.88e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.6797 \
        scb=0.0303382 scc=0.0046002 m=(1)
ends SEDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:56:17 2012 )
// Library name: gsclib045
// Cell name: SEDFFX1
// View name: extracted

simulator lang=spectre

subckt SEDFFX1 CK D E Q QN SE SI VDD VSS
mp0 (\8\:Eb \1\:E \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52e-06 sd=160n sca=16.022 \
        scb=0.0154303 scc=0.000486038 m=(1)
C1 (E VSS) capacitor c=5.15315e-17
C2 (Q VSS) capacitor c=4.08051e-17
C3 (D VSS) capacitor c=6.66815e-17
C4 (SI VSS) capacitor c=8.1202e-17
C5 (QN VSS) capacitor c=2.51535e-17
C6 (VDD VSS) capacitor c=4.95403e-16
C7 (SE VSS) capacitor c=6.87766e-17
C8 (Eb VSS) capacitor c=2.10965e-17
C9 (net554 VSS) capacitor c=1.71389e-18
C10 (Db VSS) capacitor c=8.4201e-17
C11 (net514 VSS) capacitor c=2.23071e-18
C12 (net502 VSS) capacitor c=3.81359e-17
C13 (net536 VSS) capacitor c=2.63996e-17
C14 (SEb VSS) capacitor c=3.7452e-17
C15 (Dbp VSS) capacitor c=8.3237e-17
C16 (net546 VSS) capacitor c=1.34803e-18
C17 (n30 VSS) capacitor c=3.2746e-17
C18 (CKb VSS) capacitor c=7.91385e-17
C19 (mout VSS) capacitor c=3.04776e-17
C20 (CKbb VSS) capacitor c=4.65592e-17
C21 (n20 VSS) capacitor c=2.38406e-17
C22 (net526 VSS) capacitor c=5.54575e-19
C23 (net473 VSS) capacitor c=1.23938e-17
C24 (net425 VSS) capacitor c=2.75327e-18
C25 (net465 VSS) capacitor c=3.19593e-18
C26 (net457 VSS) capacitor c=4.15529e-18
C27 (net437 VSS) capacitor c=7.65789e-19
C28 (\1\:CK VSS) capacitor c=3.05722e-17
C29 (\6\:CKb VSS) capacitor c=3.42045e-17
C30 (\5\:CKbb VSS) capacitor c=2.79856e-17
C31 (\4\:CKb VSS) capacitor c=6.33883e-17
C32 (\3\:mout VSS) capacitor c=8.9888e-17
C33 (\4\:n20 VSS) capacitor c=3.65128e-17
C34 (\2\:CKb VSS) capacitor c=5.74965e-17
C35 (\10\:net536 VSS) capacitor c=5.44249e-17
C36 (\4\:net536 VSS) capacitor c=3.64302e-17
C37 (\1\:SI VSS) capacitor c=5.50428e-17
C38 (\3\:SEb VSS) capacitor c=5.05832e-17
C39 (\6\:SE VSS) capacitor c=3.75544e-17
C40 (\7\:SE VSS) capacitor c=2.90521e-17
C41 (\2\:net536 VSS) capacitor c=4.35295e-17
C42 (\6\:net502 VSS) capacitor c=5.85382e-17
C43 (\6\:E VSS) capacitor c=5.79566e-17
C44 (\1\:D VSS) capacitor c=3.48467e-17
C45 (\1\:E VSS) capacitor c=4.15526e-17
C46 (\3\:CK VSS) capacitor c=3.63278e-17
C47 (\9\:CKb VSS) capacitor c=2.19558e-17
C48 (\8\:CKb VSS) capacitor c=4.6903e-17
C49 (\7\:CKbb VSS) capacitor c=4.37592e-17
C50 (\3\:n20 VSS) capacitor c=4.09939e-17
C51 (\3\:CKbb VSS) capacitor c=4.31691e-17
C52 (\7\:net536 VSS) capacitor c=4.0966e-17
C53 (\3\:n30 VSS) capacitor c=4.08305e-17
C54 (\6\:net536 VSS) capacitor c=3.15665e-17
C55 (\3\:SI VSS) capacitor c=2.8801e-17
C56 (\1\:SE VSS) capacitor c=5.36291e-17
C57 (\5\:SE VSS) capacitor c=2.63555e-17
C58 (\3\:net536 VSS) capacitor c=4.23647e-17
C59 (\5\:net502 VSS) capacitor c=2.41581e-17
C60 (\4\:net502 VSS) capacitor c=4.12936e-17
C61 (\3\:Eb VSS) capacitor c=5.63386e-17
C62 (\4\:E VSS) capacitor c=4.08603e-17
C63 (\3\:D VSS) capacitor c=2.85717e-17
C64 (\3\:E VSS) capacitor c=2.11066e-17
C65 (\2\:CK VSS) capacitor c=4.07142e-17
C66 (\7\:CKb VSS) capacitor c=4.41126e-17
C67 (\6\:CKbb VSS) capacitor c=3.53166e-17
C68 (\5\:CKb VSS) capacitor c=2.9212e-17
C69 (\2\:mout VSS) capacitor c=4.59247e-17
C70 (\4\:CKbb VSS) capacitor c=3.51608e-17
C71 (\3\:CKb VSS) capacitor c=2.42281e-17
C72 (\2\:CKbb VSS) capacitor c=4.62465e-17
C73 (\9\:net536 VSS) capacitor c=2.96869e-17
C74 (\2\:n30 VSS) capacitor c=3.2514e-17
C75 (\5\:net536 VSS) capacitor c=2.47298e-17
C76 (\2\:SI VSS) capacitor c=4.51655e-17
C77 (\4\:SEb VSS) capacitor c=3.63536e-17
C78 (\2\:SEb VSS) capacitor c=2.29396e-17
C79 (\4\:SE VSS) capacitor c=2.52142e-17
C80 (\7\:E VSS) capacitor c=5.3017e-17
C81 (\2\:Eb VSS) capacitor c=3.3668e-17
C82 (\5\:E VSS) capacitor c=2.90873e-17
C83 (\2\:D VSS) capacitor c=4.23792e-17
C84 (\2\:E VSS) capacitor c=4.01642e-17
C85 (\16\:CKb VSS) capacitor c=4.77501e-17
C86 (\15\:VDD VSS) capacitor c=4.84577e-17
C87 (\8\:CKbb VSS) capacitor c=1.10403e-16
C88 (\9\:n20 VSS) capacitor c=3.85588e-17
C89 (\17\:VDD VSS) capacitor c=2.49733e-17
C90 (\4\:mout VSS) capacitor c=6.17831e-17
C91 (\4\:n30 VSS) capacitor c=3.69195e-17
C92 (\19\:VDD VSS) capacitor c=4.76286e-18
C93 (\13\:net536 VSS) capacitor c=5.76153e-17
C94 (\1\:Q VSS) capacitor c=5.75944e-17
C95 (\21\:VDD VSS) capacitor c=3.14779e-17
C96 (\5\:Dbp VSS) capacitor c=4.71054e-16
C97 (\3\:Db VSS) capacitor c=2.05604e-16
C98 (\9\:SEb VSS) capacitor c=6.30755e-17
C99 (\23\:VDD VSS) capacitor c=3.0548e-17
C100 (\7\:net502 VSS) capacitor c=5.74182e-17
C101 (\3\:QN VSS) capacitor c=3.52676e-17
C102 (\25\:VDD VSS) capacitor c=9.72509e-18
C103 (\5\:Db VSS) capacitor c=1.43649e-16
C104 (\27\:VDD VSS) capacitor c=3.88451e-17
C105 (\8\:Eb VSS) capacitor c=6.89603e-18
C106 (\1\:VDD VSS) capacitor c=1.68148e-16
C107 (\10\:CKb VSS) capacitor c=5.14841e-17
C108 (\13\:CKbb VSS) capacitor c=8.86757e-17
C109 (\3\:Dbp VSS) capacitor c=3.51387e-16
C110 (\5\:n20 VSS) capacitor c=6.32934e-17
C111 (\7\:mout VSS) capacitor c=5.01175e-17
C112 (\8\:n30 VSS) capacitor c=7.33122e-17
C113 (\15\:net536 VSS) capacitor c=3.39815e-17
C114 (\3\:Q VSS) capacitor c=4.7085e-17
C115 (\7\:Dbp VSS) capacitor c=9.98983e-17
C116 (\7\:SEb VSS) capacitor c=1.05667e-16
C117 (\9\:net502 VSS) capacitor c=1.26435e-16
C118 (\1\:QN VSS) capacitor c=7.75409e-17
C119 (\7\:Db VSS) capacitor c=1.12056e-16
C120 (\6\:Eb VSS) capacitor c=6.09495e-17
C121 (\3\:net502 VSS) capacitor c=4.88308e-17
C122 (\2\:SE VSS) capacitor c=5.41951e-17
C123 (\3\:SE VSS) capacitor c=1.70437e-17
C124 (\8\:net536 VSS) capacitor c=2.8925e-17
C125 (\2\:n20 VSS) capacitor c=2.28927e-17
C126 (\4\:D VSS) capacitor c=4.92969e-17
C127 (\4\:Eb VSS) capacitor c=9.17201e-17
C128 (\5\:Eb VSS) capacitor c=1.21353e-16
C129 (\8\:E VSS) capacitor c=1.43209e-16
C130 (\9\:E VSS) capacitor c=1.27497e-16
C131 (\10\:E VSS) capacitor c=5.55192e-17
C132 (\11\:E VSS) capacitor c=1.75113e-17
C133 (\11\:net502 VSS) capacitor c=9.75795e-17
C134 (\8\:SE VSS) capacitor c=4.83558e-17
C135 (\5\:SEb VSS) capacitor c=1.31812e-16
C136 (\6\:SEb VSS) capacitor c=1.1101e-16
C137 (\4\:SI VSS) capacitor c=6.37908e-17
C138 (\11\:net536 VSS) capacitor c=4.9556e-17
C139 (\12\:net536 VSS) capacitor c=3.23112e-17
C140 (\17\:net536 VSS) capacitor c=2.0088e-16
C141 (\18\:net536 VSS) capacitor c=8.88325e-17
C142 (\19\:net536 VSS) capacitor c=1.67433e-16
C143 (\6\:n30 VSS) capacitor c=7.63195e-17
C144 (\7\:n30 VSS) capacitor c=3.88045e-17
C145 (\6\:mout VSS) capacitor c=4.72328e-17
C146 (\9\:mout VSS) capacitor c=4.18022e-17
C147 (\7\:n20 VSS) capacitor c=5.57319e-17
C148 (\8\:n20 VSS) capacitor c=4.74523e-17
C149 (\10\:CKbb VSS) capacitor c=1.66535e-16
C150 (\11\:CKbb VSS) capacitor c=1.32877e-16
C151 (\12\:CKbb VSS) capacitor c=4.73666e-17
C152 (\15\:CKbb VSS) capacitor c=6.40213e-17
C153 (\16\:CKbb VSS) capacitor c=2.51751e-17
C154 (\12\:CKb VSS) capacitor c=5.81592e-17
C155 (\13\:CKb VSS) capacitor c=1.33482e-16
C156 (\14\:CKb VSS) capacitor c=1.90426e-16
C157 (\15\:CKb VSS) capacitor c=7.76059e-17
C158 (\4\:CK VSS) capacitor c=7.22346e-17
C159 (\3\:VDD VSS) capacitor c=3.22728e-17
C160 (\5\:VDD VSS) capacitor c=2.76806e-17
C161 (\6\:VDD VSS) capacitor c=1.75053e-17
C162 (\8\:VDD VSS) capacitor c=3.90822e-17
C163 (\10\:VDD VSS) capacitor c=2.84354e-17
C164 (\11\:VDD VSS) capacitor c=1.18914e-17
C165 (\13\:VDD VSS) capacitor c=1.77951e-18
Rk5 (\8\:E \9\:E) resistor r=0.9926 c=0
Rk8 (\10\:E E) resistor r=0.1492 c=0
Rk6 (\9\:E \10\:E) resistor r=0.3882 c=0
Rk7 (\9\:E \11\:E) resistor r=0.06914 c=0
Rk54 (\4\:CK CK) resistor r=0.003489 c=0
Rk23 (\2\:Q Q) resistor r=0.3201 c=0
Rk24 (Q \4\:Q) resistor r=0.01422 c=0
Rk1 (\4\:D D) resistor r=0.04288 c=0
Rk22 (\4\:SI SI) resistor r=0.03603 c=0
Rk9 (\2\:QN QN) resistor r=0.1748 c=0
Rk10 (QN \4\:QN) resistor r=0.05862 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.09259 c=0
Rk56 (\3\:VDD \4\:VDD) resistor r=0.5591 c=0
Rk57 (\4\:VDD \5\:VDD) resistor r=0.07158 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.5052 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.07253 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.3374 c=0
Rk61 (\8\:VDD \9\:VDD) resistor r=0.3625 c=0
Rk62 (\9\:VDD \10\:VDD) resistor r=0.2221 c=0
Rk63 (\10\:VDD \11\:VDD) resistor r=0.3347 c=0
Rk64 (\11\:VDD \12\:VDD) resistor r=0.2932 c=0
Rk65 (\12\:VDD \13\:VDD) resistor r=0.2957 c=0
Rk67 (\14\:VDD VDD) resistor r=0.1001 c=0
Rk66 (\13\:VDD \14\:VDD) resistor r=0.1051 c=0
Rk68 (\3\:VDD \16\:VDD) resistor r=0.267 c=0
Rk69 (\5\:VDD \18\:VDD) resistor r=0.04331 c=0
Rk70 (\6\:VDD \20\:VDD) resistor r=0.07393 c=0
Rk71 (\8\:VDD \22\:VDD) resistor r=0.04331 c=0
Rk72 (\10\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk73 (\11\:VDD \26\:VDD) resistor r=0.07393 c=0
Rk74 (\13\:VDD \28\:VDD) resistor r=0.2998 c=0
Rk75 (\2\:VSS \4\:VSS) resistor r=0.4642 c=0
Rk76 (\4\:VSS \5\:VSS) resistor r=0.4036 c=0
Rk77 (\5\:VSS \6\:VSS) resistor r=0.2481 c=0
Rk78 (\6\:VSS \7\:VSS) resistor r=0.2456 c=0
Rk79 (\7\:VSS \8\:VSS) resistor r=0.1051 c=0
Rk80 (\8\:VSS \9\:VSS) resistor r=0.4286 c=0
Rk81 (\9\:VSS \10\:VSS) resistor r=0.2732 c=0
Rk82 (\10\:VSS \11\:VSS) resistor r=0.2581 c=0
Rk83 (\11\:VSS \12\:VSS) resistor r=0.3858 c=0
Rk84 (\12\:VSS \13\:VSS) resistor r=0.3584 c=0
Rk86 (\14\:VSS VSS) resistor r=0.2077 c=0
Rk85 (\13\:VSS \14\:VSS) resistor r=0.1428 c=0
Rk87 (\5\:VSS \16\:VSS) resistor r=0.1026 c=0
Rk88 (\7\:VSS \18\:VSS) resistor r=0.1394 c=0
Rk89 (\9\:VSS \20\:VSS) resistor r=0.3153 c=0
Rk90 (\11\:VSS \22\:VSS) resistor r=0.4072 c=0
Rk91 (\12\:VSS \24\:VSS) resistor r=0.07393 c=0
Rk92 (\14\:VSS \26\:VSS) resistor r=0.3265 c=0
Rk13 (\8\:SE SE) resistor r=0.1657 c=0
Rk2 (\4\:Eb \5\:Eb) resistor r=0.6772 c=0
Rk3 (\5\:Eb \7\:Eb) resistor r=0.5904 c=0
Rk4 (\5\:Eb \9\:Eb) resistor r=0.0279 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.4458 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.0612 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.6549 c=0
Rk11 (\8\:net502 \10\:net502) resistor r=0.3754 c=0
Rk12 (\10\:net502 \11\:net502) resistor r=0.7331 c=0
Rk25 (\11\:net536 \12\:net536) resistor r=0.2184 c=0
Rk26 (\12\:net536 \14\:net536) resistor r=0.2868 c=0
Rk27 (\12\:net536 \16\:net536) resistor r=0.113 c=0
Rk28 (\14\:net536 \17\:net536) resistor r=0.5458 c=0
Rk29 (\17\:net536 \18\:net536) resistor r=0.4008 c=0
Rk30 (\17\:net536 \19\:net536) resistor r=1.1952 c=0
Rk17 (\5\:SEb \6\:SEb) resistor r=0.7733 c=0
Rk18 (\6\:SEb \8\:SEb) resistor r=0.5479 c=0
Rk19 (\8\:SEb \10\:SEb) resistor r=0.3959 c=0
Rk40 (\2\:Dbp \4\:Dbp) resistor r=0.4348 c=0
Rk41 (\4\:Dbp \6\:Dbp) resistor r=2.9427 c=0
Rk42 (\6\:Dbp \8\:Dbp) resistor r=0.5103 c=0
Rk31 (\5\:n30 \6\:n30) resistor r=0.2997 c=0
Rk32 (\6\:n30 \7\:n30) resistor r=0.1939 c=0
Rk33 (\6\:n30 \9\:n30) resistor r=0.3909 c=0
Rk49 (\11\:CKb \12\:CKb) resistor r=0.3029 c=0
Rk50 (\12\:CKb \13\:CKb) resistor r=0.3287 c=0
Rk51 (\13\:CKb \14\:CKb) resistor r=0.8845 c=0
Rk52 (\14\:CKb \15\:CKb) resistor r=0.6047 c=0
Rk53 (\13\:CKb \17\:CKb) resistor r=0.2656 c=0
Rk34 (\5\:mout \6\:mout) resistor r=0.2678 c=0
Rk35 (\6\:mout \8\:mout) resistor r=0.1953 c=0
Rk36 (\6\:mout \9\:mout) resistor r=0.2352 c=0
Rk43 (\9\:CKbb \10\:CKbb) resistor r=0.3552 c=0
Rk44 (\10\:CKbb \11\:CKbb) resistor r=1.0417 c=0
Rk45 (\11\:CKbb \12\:CKbb) resistor r=0.1564 c=0
Rk46 (\9\:CKbb \14\:CKbb) resistor r=0.577 c=0
Rk47 (\10\:CKbb \15\:CKbb) resistor r=0.2519 c=0
Rk48 (\11\:CKbb \16\:CKbb) resistor r=0.04992 c=0
Rk37 (\6\:n20 \7\:n20) resistor r=0.3364 c=0
Rk38 (\7\:n20 \8\:n20) resistor r=0.2811 c=0
Rk39 (\7\:n20 \10\:n20) resistor r=0.1242 c=0
Rl8 (\6\:E \7\:E) resistor r=71.8456 c=0
Rl5 (\4\:E \5\:E) resistor r=26.098 c=0
Rl1 (\1\:E \2\:E) resistor r=123.077 c=0
Rl2 (\2\:E \3\:E) resistor r=29.9451 c=0
Rl48 (\1\:CK \2\:CK) resistor r=101.923 c=0
Rl49 (\2\:CK \3\:CK) resistor r=101.099 c=0
Rl3 (\1\:D \2\:D) resistor r=73.7687 c=0
Rl4 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl24 (\1\:SI \2\:SI) resistor r=109.41 c=0
Rl25 (\2\:SI \3\:SI) resistor r=44.208 c=0
Rl20 (\4\:SE \5\:SE) resistor r=49.7951 c=0
Rl21 (\2\:SE \6\:SE) resistor r=93.9123 c=0
Rl17 (\1\:SE \2\:SE) resistor r=128.824 c=0
Rl22 (\3\:SE \7\:SE) resistor r=30.4507 c=0
Rl19 (\3\:SE \4\:SE) resistor r=11.9279 c=0
Rl18 (\2\:SE \3\:SE) resistor r=160.006 c=0
Rl6 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl7 (\2\:Eb \3\:Eb) resistor r=124.233 c=0
Rl9 (net502 \2\:net502) resistor r=81.3086 c=0
Rl12 (\2\:net502 \5\:net502) resistor r=37.8013 c=0
Rl13 (\3\:net502 \6\:net502) resistor r=118.925 c=0
Rl11 (\3\:net502 \4\:net502) resistor r=119.768 c=0
Rl10 (\2\:net502 \3\:net502) resistor r=5.848 c=0
Rl14 (net536 \2\:net536) resistor r=77.6149 c=0
Rl15 (\2\:net536 \3\:net536) resistor r=119.083 c=0
Rl26 (\4\:net536 \5\:net536) resistor r=24.7951 c=0
Rl27 (\5\:net536 \6\:net536) resistor r=69.6516 c=0
Rl32 (\8\:net536 \10\:net536) resistor r=99.6815 c=0
Rl30 (\7\:net536 \8\:net536) resistor r=74.9779 c=0
Rl31 (\8\:net536 \9\:net536) resistor r=32.6176 c=0
Rl23 (\3\:SEb \4\:SEb) resistor r=35.7713 c=0
Rl16 (SEb \2\:SEb) resistor r=98.7687 c=0
Rl28 (n30 \2\:n30) resistor r=41.5405 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=85.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=187.66 c=0
Rl45 (\6\:CKb \7\:CKb) resistor r=157.176 c=0
Rl47 (\7\:CKb \9\:CKb) resistor r=34.4104 c=0
Rl46 (\7\:CKb \8\:CKb) resistor r=192.285 c=0
Rl42 (\4\:CKb \5\:CKb) resistor r=62.2302 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=50.6918 c=0
Rl40 (mout \2\:mout) resistor r=30.7692 c=0
Rl41 (\2\:mout \3\:mout) resistor r=101.099 c=0
Rl43 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl44 (\6\:CKbb \7\:CKbb) resistor r=129.104 c=0
Rl36 (\3\:CKbb \4\:CKbb) resistor r=53.079 c=0
Rl33 (CKbb \2\:CKbb) resistor r=35.7134 c=0
Rl37 (n20 \2\:n20) resistor r=2.7713 c=0
Rl39 (\2\:n20 \4\:n20) resistor r=36.2526 c=0
Rl38 (\2\:n20 \3\:n20) resistor r=111.253 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\1\:QN \2\:QN) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=37.5 c=0
Rz19 (\1\:VDD \9\:VDD) resistor r=6.25 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=15 c=0
Rz21 (\1\:VDD \14\:VDD) resistor r=25 c=0
Rz22 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz28 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz4 (Db \2\:Db) resistor r=75 c=0
Rz5 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:net502 \10\:net502) resistor r=75 c=0
Rz8 (\15\:net536 \16\:net536) resistor r=75 c=0
Rz6 (\7\:SEb \8\:SEb) resistor r=75 c=0
Rz12 (\3\:Dbp \4\:Dbp) resistor r=75 c=0
Rz13 (\7\:Dbp \8\:Dbp) resistor r=75 c=0
Rz9 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz15 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz10 (\7\:mout \8\:mout) resistor r=75 c=0
Rz14 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz11 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry7 (\1\:Q \2\:Q) resistor r=62 c=0
Ry2 (\3\:QN \4\:QN) resistor r=62 c=0
Ry16 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry18 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry19 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry22 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=12.4 c=0
Ry25 (\3\:VSS \8\:VSS) resistor r=31 c=0
Ry26 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry27 (\3\:VSS \13\:VSS) resistor r=7.75 c=0
Ry1 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry4 (\3\:Db \4\:Db) resistor r=62 c=0
Ry5 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\7\:net502 \8\:net502) resistor r=62 c=0
Ry8 (\13\:net536 \14\:net536) resistor r=62 c=0
Ry6 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry12 (Dbp \2\:Dbp) resistor r=62 c=0
Ry13 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry15 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry10 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry11 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx3 (\7\:E \8\:E) resistor r=45 c=0
Rx4 (\2\:E \10\:E) resistor r=45 c=0
Rx5 (\5\:E \11\:E) resistor r=45 c=0
Rx23 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\4\:SE \8\:SE) resistor r=45 c=0
Rx2 (\2\:Eb \4\:Eb) resistor r=45 c=0
Rx6 (\2\:net502 \11\:net502) resistor r=45 c=0
Rx11 (\9\:net536 \11\:net536) resistor r=45 c=0
Rx12 (\5\:net536 \18\:net536) resistor r=45 c=0
Rx13 (net536 \19\:net536) resistor r=45 c=0
Rx8 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx9 (\2\:SEb \6\:SEb) resistor r=45 c=0
Rx14 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx20 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx21 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx22 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx15 (\2\:mout \9\:mout) resistor r=45 c=0
Rx17 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx18 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx19 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx16 (n20 \8\:n20) resistor r=45 c=0
mn0 (\6\:Eb \3\:E \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=2.465e-14 ps=7.2e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.49e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (net554 \3\:D \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.567e-14 ps=7.2e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3e-07 sb=1.23e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\7\:Db \4\:E net554 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=8.7e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\7\:Db \3\:Eb net514 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.32e-14 ps=5.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=6.65e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (net514 \4\:net502 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=1.885e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=4.9e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn57 (\1\:QN \5\:net502 \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.385e-14 ad=5.85e-14 ps=1.5e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75481e-07 sb=2.25e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn56 (\9\:net502 \3\:net536 \21\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn10 (\7\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn11 (Db SEb \7\:Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn13 (\7\:Dbp \1\:SE net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.32e-14 ps=4.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (net546 \3\:SI \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.355e-14 ad=1.378e-14 ps=1.13e-06 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.85e-07 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\3\:Q \6\:net536 \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.355e-14 ad=3.64e-14 ps=1.13e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.78462e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn45 (\15\:net536 \3\:n30 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.107e-14 ad=2.755e-14 ps=1.51e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.92e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn50 (net534 \7\:net536 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.107e-14 ad=1.522e-14 ps=1.51e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.56e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn51 (\8\:n30 CKb net534 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.537e-14 ps=5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.41e-06 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn40 (\7\:mout \3\:CKbb \8\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=4.422e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.19e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (\7\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.99e-14 ad=4.422e-14 ps=1.53e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=8.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn35 (net526 mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.99e-14 ad=2.682e-14 ps=1.53e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=5.75e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn36 (\5\:n20 \7\:CKbb net526 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=3.45e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn25 (\3\:Dbp \8\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn21 (\13\:CKbb \9\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=2.465e-14 ps=6.7e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\10\:CKb \3\:CK \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp3 (net473 \1\:D \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.118e-13 ps=7.5e-07 pd=1.47e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.315e-06 sd=160n sca=14.0018 \
        scb=0.0126046 scc=0.00046222 m=(1)
mp4 (\5\:Db Eb net473 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.118e-13 ad=5.697e-14 ps=1.47e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=7.5e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp2 (\5\:Db \6\:E net425 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.697e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=4.4e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp1 (net425 \6\:net502 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.515e-14 ad=1.29e-14 ps=1.9e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.325e-06 sb=3.35e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp57 (\3\:QN net502 \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.515e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.82821e-07 sb=1.4e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp56 (\7\:net502 \2\:net536 \23\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp10 (\9\:SEb \7\:SE \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.019e-13 ad=3.01e-14 ps=1.78e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp11 (\5\:Dbp \6\:SE \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.15e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp13 (\5\:Dbp \3\:SEb net465 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.257e-14 ad=4.515e-14 ps=6.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=6.6e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp12 (net465 \1\:SI \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1447e-13 ad=2.257e-14 ps=1.9e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=5.1e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp55 (\1\:Q \4\:net536 \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1447e-13 ad=6.63e-14 ps=1.9e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.37244e-07 sb=1.7e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp45 (\13\:net536 n30 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net457 \10\:net536 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=2.902e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.655e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 CKbb net457 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.475e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (\9\:n20 \5\:CKbb Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=5.483e-14 ps=8.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.277e-14 ad=3.44e-14 ps=1.2e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.27e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\4\:mout \4\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.312e-14 ad=8.277e-14 ps=1.67e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8.4e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net437 \3\:mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.312e-14 ad=1.29e-14 ps=1.67e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=6.3e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\9\:n20 \4\:CKb net437 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.483e-14 ps=5.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=5.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\8\:CKbb \6\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.268e-14 ad=3.655e-14 ps=9.2e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.3e-07 sd=160n sca=12.2638 \
        scb=0.00952133 scc=0.000140215 m=(1)
mp20 (\16\:CKb \1\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.268e-14 ad=3.01e-14 ps=9.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=18.3227 \
        scb=0.0195692 scc=0.000509714 m=(1)
ends SEDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:56:57 2012 )
// Library name: gsclib045
// Cell name: SEDFFX2
// View name: extracted

simulator lang=spectre

subckt SEDFFX2 CK D E Q QN SE SI VDD VSS
mp55 (\1\:Q net536 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.267e-14 ad=6.24e-14 ps=1.515e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.03205e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(2)
C1 (E VSS) capacitor c=2.72797e-17
C2 (SI VSS) capacitor c=1.20992e-16
C3 (CK VSS) capacitor c=5.09532e-17
C4 (D VSS) capacitor c=4.66881e-17
C5 (VDD VSS) capacitor c=5.84144e-16
C6 (QN VSS) capacitor c=6.9571e-17
C7 (SE VSS) capacitor c=2.71808e-17
C8 (net536 VSS) capacitor c=1.28026e-16
C9 (n30 VSS) capacitor c=4.30027e-17
C10 (net534 VSS) capacitor c=7.06727e-19
C11 (CKb VSS) capacitor c=2.00883e-17
C12 (mout VSS) capacitor c=6.48654e-17
C13 (CKbb VSS) capacitor c=6.0068e-17
C14 (n20 VSS) capacitor c=4.95864e-17
C15 (Dbp VSS) capacitor c=1.0186e-16
C16 (net502 VSS) capacitor c=4.04406e-17
C17 (net546 VSS) capacitor c=2.28169e-18
C18 (Db VSS) capacitor c=9.09823e-17
C19 (SEb VSS) capacitor c=4.78973e-17
C20 (net514 VSS) capacitor c=1.93422e-18
C21 (Eb VSS) capacitor c=3.9226e-17
C22 (net457 VSS) capacitor c=8.85234e-19
C23 (net437 VSS) capacitor c=1.06974e-18
C24 (net465 VSS) capacitor c=5.22461e-19
C25 (net425 VSS) capacitor c=5.02212e-18
C26 (\5\:E VSS) capacitor c=3.68952e-17
C27 (\1\:D VSS) capacitor c=5.32033e-17
C28 (\1\:E VSS) capacitor c=4.99028e-17
C29 (\5\:SE VSS) capacitor c=3.2293e-17
C30 (\6\:SE VSS) capacitor c=3.94347e-17
C31 (\2\:SEb VSS) capacitor c=6.32459e-17
C32 (\1\:SI VSS) capacitor c=6.08796e-17
C33 (\1\:CK VSS) capacitor c=3.08446e-17
C34 (\11\:net536 VSS) capacitor c=6.25786e-17
C35 (\6\:CKb VSS) capacitor c=3.92061e-17
C36 (\7\:CKbb VSS) capacitor c=3.85805e-17
C37 (\7\:CKb VSS) capacitor c=1.51926e-16
C38 (\8\:CKb VSS) capacitor c=1.2125e-16
C39 (\9\:net536 VSS) capacitor c=4.47596e-17
C40 (\3\:n30 VSS) capacitor c=5.15549e-17
C41 (\7\:E VSS) capacitor c=1.91114e-17
C42 (\3\:D VSS) capacitor c=4.05692e-17
C43 (\3\:E VSS) capacitor c=5.02822e-17
C44 (\3\:Eb VSS) capacitor c=1.04986e-16
C45 (\6\:net502 VSS) capacitor c=5.26384e-17
C46 (\1\:SE VSS) capacitor c=3.82148e-17
C47 (\3\:SEb VSS) capacitor c=2.05295e-17
C48 (\4\:SE VSS) capacitor c=4.80504e-17
C49 (\4\:SI VSS) capacitor c=3.81092e-17
C50 (\3\:CK VSS) capacitor c=3.10775e-17
C51 (\13\:net536 VSS) capacitor c=3.00761e-17
C52 (\5\:CKb VSS) capacitor c=1.87182e-17
C53 (\5\:CKbb VSS) capacitor c=8.03219e-17
C54 (\3\:mout VSS) capacitor c=6.79682e-17
C55 (\3\:n20 VSS) capacitor c=3.07535e-17
C56 (\3\:CKbb VSS) capacitor c=5.77337e-17
C57 (\9\:CKb VSS) capacitor c=1.04205e-16
C58 (\8\:net536 VSS) capacitor c=8.08452e-17
C59 (\6\:E VSS) capacitor c=3.30719e-17
C60 (\2\:D VSS) capacitor c=4.89145e-17
C61 (\2\:Eb VSS) capacitor c=9.66368e-17
C62 (\4\:E VSS) capacitor c=4.33984e-17
C63 (\2\:E VSS) capacitor c=4.18999e-17
C64 (\5\:net502 VSS) capacitor c=2.80095e-17
C65 (\2\:SE VSS) capacitor c=6.55915e-17
C66 (\5\:SEb VSS) capacitor c=3.9504e-17
C67 (\4\:SEb VSS) capacitor c=4.25348e-17
C68 (\3\:SI VSS) capacitor c=2.56022e-17
C69 (\2\:CK VSS) capacitor c=3.03945e-17
C70 (\2\:CKb VSS) capacitor c=1.50969e-17
C71 (\12\:net536 VSS) capacitor c=3.72933e-17
C72 (\8\:CKbb VSS) capacitor c=4.93407e-17
C73 (\6\:CKbb VSS) capacitor c=2.45033e-17
C74 (\2\:mout VSS) capacitor c=5.66237e-17
C75 (\2\:n20 VSS) capacitor c=3.40282e-17
C76 (\4\:CKbb VSS) capacitor c=2.25562e-17
C77 (\2\:CKbb VSS) capacitor c=6.23249e-17
C78 (\10\:net536 VSS) capacitor c=2.65337e-17
C79 (\4\:n30 VSS) capacitor c=2.25156e-17
C80 (\6\:net536 VSS) capacitor c=2.22908e-17
C81 (\8\:Eb VSS) capacitor c=1.65186e-17
C82 (\1\:VDD VSS) capacitor c=5.27968e-17
C83 (\6\:Db VSS) capacitor c=2.79551e-17
C84 (\3\:QN VSS) capacitor c=4.59436e-18
C85 (\8\:SEb VSS) capacitor c=9.17666e-17
C86 (\4\:Db VSS) capacitor c=2.09867e-16
C87 (\7\:Dbp VSS) capacitor c=3.09918e-17
C88 (\12\:VDD VSS) capacitor c=2.64288e-17
C89 (\14\:CKb VSS) capacitor c=5.0347e-17
C90 (\14\:net502 VSS) capacitor c=7.77264e-17
C91 (\15\:VDD VSS) capacitor c=5.96055e-17
C92 (\9\:CKbb VSS) capacitor c=5.86173e-17
C93 (\5\:Dbp VSS) capacitor c=3.15583e-17
C94 (\4\:n20 VSS) capacitor c=5.53485e-17
C95 (\18\:VDD VSS) capacitor c=6.7289e-17
C96 (\8\:mout VSS) capacitor c=5.72981e-17
C97 (\9\:n30 VSS) capacitor c=3.05117e-17
C98 (\22\:VDD VSS) capacitor c=3.1208e-17
C99 (\16\:net536 VSS) capacitor c=5.9381e-17
C100 (\1\:Q VSS) capacitor c=6.69709e-17
C101 (\3\:VDD VSS) capacitor c=1.45986e-16
C102 (\4\:Eb VSS) capacitor c=6.42891e-17
C103 (\1\:QN VSS) capacitor c=6.60949e-17
C104 (\11\:SEb VSS) capacitor c=4.58943e-17
C105 (\8\:Db VSS) capacitor c=1.27576e-16
C106 (\10\:CKb VSS) capacitor c=1.12775e-16
C107 (\12\:net502 VSS) capacitor c=3.61785e-16
C108 (\11\:CKbb VSS) capacitor c=7.69069e-17
C109 (\9\:Dbp VSS) capacitor c=7.19499e-17
C110 (\8\:n20 VSS) capacitor c=3.95404e-17
C111 (\6\:mout VSS) capacitor c=4.87081e-17
C112 (\5\:n30 VSS) capacitor c=6.95987e-17
C113 (\20\:net536 VSS) capacitor c=2.5576e-17
C114 (\3\:Q VSS) capacitor c=3.1579e-17
C115 (\2\:n30 VSS) capacitor c=2.52724e-17
C116 (\3\:CKb VSS) capacitor c=1.63093e-17
C117 (\4\:CKb VSS) capacitor c=5.87895e-17
C118 (\2\:SI VSS) capacitor c=3.98781e-17
C119 (\3\:SE VSS) capacitor c=9.11883e-17
C120 (\2\:net502 VSS) capacitor c=4.25346e-17
C121 (\3\:net502 VSS) capacitor c=1.21534e-16
C122 (\7\:n30 VSS) capacitor c=1.10917e-16
C123 (\8\:n30 VSS) capacitor c=6.42568e-17
C124 (\4\:mout VSS) capacitor c=7.08684e-17
C125 (\5\:mout VSS) capacitor c=6.74692e-17
C126 (\6\:n20 VSS) capacitor c=6.06157e-17
C127 (\7\:n20 VSS) capacitor c=5.87621e-17
C128 (\14\:net536 VSS) capacitor c=1.85737e-16
C129 (\15\:net536 VSS) capacitor c=2.32559e-16
C130 (\18\:net536 VSS) capacitor c=2.13211e-17
C131 (\19\:net536 VSS) capacitor c=2.23946e-17
C132 (\22\:net536 VSS) capacitor c=1.9268e-17
C133 (\13\:CKbb VSS) capacitor c=7.08148e-17
C134 (\14\:CKbb VSS) capacitor c=7.90664e-17
C135 (\15\:CKbb VSS) capacitor c=9.46181e-17
C136 (\16\:CKbb VSS) capacitor c=9.64738e-17
C137 (\17\:CKbb VSS) capacitor c=8.12159e-17
C138 (\12\:CKb VSS) capacitor c=1.65343e-16
C139 (\13\:CKb VSS) capacitor c=1.05823e-16
C140 (\4\:CK VSS) capacitor c=5.58844e-17
C141 (\3\:Dbp VSS) capacitor c=2.54824e-16
C142 (\4\:Dbp VSS) capacitor c=2.38459e-16
C143 (\6\:SEb VSS) capacitor c=6.58784e-17
C144 (\7\:SEb VSS) capacitor c=8.24451e-17
C145 (\10\:SEb VSS) capacitor c=1.11931e-16
C146 (\7\:SE VSS) capacitor c=4.84439e-17
C147 (\11\:net502 VSS) capacitor c=3.81656e-16
C148 (\3\:Db VSS) capacitor c=1.88639e-16
C149 (\4\:D VSS) capacitor c=8.54259e-17
C150 (\8\:E VSS) capacitor c=6.23275e-17
C151 (\9\:E VSS) capacitor c=1.08847e-16
C152 (\10\:E VSS) capacitor c=6.71853e-17
C153 (\6\:Eb VSS) capacitor c=7.88067e-17
C154 (\7\:Eb VSS) capacitor c=8.88912e-17
C155 (\5\:VDD VSS) capacitor c=1.18173e-16
C156 (\14\:VDD VSS) capacitor c=5.8647e-17
C157 (\17\:VDD VSS) capacitor c=3.59886e-17
C158 (\21\:VDD VSS) capacitor c=2.84049e-17
Rk47 (\8\:E \9\:E) resistor r=0.3108 c=0
Rk49 (\10\:E E) resistor r=0.02815 c=0
Rk48 (\9\:E \10\:E) resistor r=0.5273 c=0
Rk28 (SI \5\:SI) resistor r=0.009678 c=0
Rk72 (\2\:VSS \3\:VSS) resistor r=0.1829 c=0
Rk73 (\3\:VSS \4\:VSS) resistor r=0.1678 c=0
Rk74 (\4\:VSS \5\:VSS) resistor r=0.1678 c=0
Rk76 (\5\:VSS \7\:VSS) resistor r=0.2782 c=0
Rk77 (\7\:VSS \8\:VSS) resistor r=0.5189 c=0
Rk78 (\8\:VSS \9\:VSS) resistor r=0.233 c=0
Rk79 (\9\:VSS \10\:VSS) resistor r=0.3735 c=0
Rk80 (\10\:VSS \11\:VSS) resistor r=0.4788 c=0
Rk81 (\11\:VSS \12\:VSS) resistor r=0.1327 c=0
Rk83 (\13\:VSS VSS) resistor r=0.251 c=0
Rk82 (\12\:VSS \13\:VSS) resistor r=0.4686 c=0
Rk84 (\3\:VSS \16\:VSS) resistor r=0.2664 c=0
Rk87 (\8\:VSS \22\:VSS) resistor r=0.2986 c=0
Rk88 (\10\:VSS \24\:VSS) resistor r=0.4021 c=0
Rk89 (\12\:VSS \26\:VSS) resistor r=0.1427 c=0
Rk90 (\13\:VSS \28\:VSS) resistor r=0.07393 c=0
Rk27 (\4\:CK CK) resistor r=0.1151 c=0
Rk46 (D \4\:D) resistor r=0.01623 c=0
Rk1 (\2\:Q Q) resistor r=0.3171 c=0
Rk2 (Q \4\:Q) resistor r=0.0543 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.5401 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.1377 c=0
Rk56 (\5\:VDD \7\:VDD) resistor r=0.8311 c=0
Rk59 (\7\:VDD \13\:VDD) resistor r=0.07147 c=0
Rk60 (\7\:VDD \14\:VDD) resistor r=0.5565 c=0
Rk61 (\14\:VDD \16\:VDD) resistor r=0.2783 c=0
Rk62 (\14\:VDD \17\:VDD) resistor r=0.5789 c=0
Rk63 (\17\:VDD \19\:VDD) resistor r=0.3012 c=0
Rk64 (\17\:VDD \20\:VDD) resistor r=0.06752 c=0
Rk67 (\21\:VDD VDD) resistor r=0.1777 c=0
Rk65 (\20\:VDD \21\:VDD) resistor r=0.4512 c=0
Rk66 (\21\:VDD \23\:VDD) resistor r=0.1831 c=0
Rk41 (\4\:QN QN) resistor r=0.01535 c=0
Rk40 (\2\:QN \4\:QN) resistor r=0.3371 c=0
Rk37 (SE \7\:SE) resistor r=0.04597 c=0
Rk12 (\14\:net536 \15\:net536) resistor r=1.578 c=0
Rk13 (\15\:net536 \17\:net536) resistor r=0.5162 c=0
Rk14 (\15\:net536 \18\:net536) resistor r=0.04992 c=0
Rk15 (\17\:net536 \19\:net536) resistor r=0.1996 c=0
Rk16 (\19\:net536 \21\:net536) resistor r=0.1682 c=0
Rk17 (\19\:net536 \22\:net536) resistor r=0.1014 c=0
Rk3 (\6\:n30 \7\:n30) resistor r=0.3431 c=0
Rk4 (\7\:n30 \8\:n30) resistor r=0.4995 c=0
Rk5 (\7\:n30 \10\:n30) resistor r=0.04586 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.6931 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.7748 c=0
Rk26 (\12\:CKb \15\:CKb) resistor r=0.2244 c=0
Rk6 (\4\:mout \5\:mout) resistor r=0.3294 c=0
Rk7 (\5\:mout \7\:mout) resistor r=0.2592 c=0
Rk8 (\5\:mout \9\:mout) resistor r=0.1845 c=0
Rk18 (\10\:CKbb \12\:CKbb) resistor r=0.3349 c=0
Rk19 (\12\:CKbb \13\:CKbb) resistor r=0.4311 c=0
Rk20 (\13\:CKbb \14\:CKbb) resistor r=0.2104 c=0
Rk21 (\14\:CKbb \15\:CKbb) resistor r=0.5657 c=0
Rk22 (\15\:CKbb \16\:CKbb) resistor r=0.5367 c=0
Rk23 (\13\:CKbb \17\:CKbb) resistor r=0.3812 c=0
Rk9 (\5\:n20 \6\:n20) resistor r=0.2952 c=0
Rk10 (\6\:n20 \7\:n20) resistor r=0.3078 c=0
Rk11 (\6\:n20 \9\:n20) resistor r=0.1279 c=0
Rk29 (\2\:Dbp \3\:Dbp) resistor r=0.6485 c=0
Rk30 (\3\:Dbp \4\:Dbp) resistor r=1.7477 c=0
Rk31 (\4\:Dbp \6\:Dbp) resistor r=0.1026 c=0
Rk32 (\3\:Dbp \8\:Dbp) resistor r=0.1015 c=0
Rk33 (\4\:Dbp \10\:Dbp) resistor r=0.3953 c=0
Rk38 (\11\:net502 \13\:net502) resistor r=2.8719 c=0
Rk39 (\13\:net502 \15\:net502) resistor r=0.4359 c=0
Rk42 (\2\:Db \3\:Db) resistor r=0.6775 c=0
Rk43 (\3\:Db \5\:Db) resistor r=1.246 c=0
Rk44 (\3\:Db \7\:Db) resistor r=0.1514 c=0
Rk45 (\5\:Db \9\:Db) resistor r=0.7318 c=0
Rk34 (\6\:SEb \7\:SEb) resistor r=0.3253 c=0
Rk35 (\9\:SEb \10\:SEb) resistor r=0.4384 c=0
Rk36 (\10\:SEb \12\:SEb) resistor r=0.2412 c=0
Rk50 (\5\:Eb \6\:Eb) resistor r=0.5107 c=0
Rk51 (\6\:Eb \7\:Eb) resistor r=0.5634 c=0
Rk52 (\6\:Eb \9\:Eb) resistor r=0.2315 c=0
Rl58 (\5\:E \6\:E) resistor r=171.846 c=0
Rl59 (\6\:E \7\:E) resistor r=35.3072 c=0
Rl53 (\3\:E \4\:E) resistor r=35.5399 c=0
Rl52 (\1\:E \2\:E) resistor r=24.2328 c=0
Rl32 (\1\:SI \2\:SI) resistor r=68.1104 c=0
Rl34 (\2\:SI \4\:SI) resistor r=131.572 c=0
Rl33 (\2\:SI \3\:SI) resistor r=10.9341 c=0
Rl30 (\1\:CK \2\:CK) resistor r=50.6918 c=0
Rl31 (\2\:CK \3\:CK) resistor r=133.384 c=0
Rl56 (\1\:D \2\:D) resistor r=123.077 c=0
Rl57 (\2\:D \3\:D) resistor r=85.989 c=0
Rl41 (\2\:SE \5\:SE) resistor r=58.4251 c=0
Rl38 (\1\:SE \2\:SE) resistor r=74.7951 c=0
Rl42 (\3\:SE \6\:SE) resistor r=101.157 c=0
Rl40 (\3\:SE \4\:SE) resistor r=156.492 c=0
Rl39 (\2\:SE \3\:SE) resistor r=316.222 c=0
Rl29 (\13\:net536 \11\:net536) resistor r=92.3077 c=0
Rl10 (\8\:net536 \9\:net536) resistor r=172.643 c=0
Rl28 (\12\:net536 \11\:net536) resistor r=251.9 c=0
Rl11 (\10\:net536 \9\:net536) resistor r=24.2328 c=0
Rl5 (net536 \6\:net536) resistor r=9.5287 c=0
Rl7 (n30 \2\:n30) resistor r=41.6119 c=0
Rl8 (\2\:n30 \3\:n30) resistor r=47.0949 c=0
Rl9 (\2\:n30 \4\:n30) resistor r=65.7849 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=403.412 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=210.67 c=0
Rl20 (CKb \2\:CKb) resistor r=40.3846 c=0
Rl24 (\3\:CKb \6\:CKb) resistor r=25.6632 c=0
Rl21 (\2\:CKb \3\:CKb) resistor r=9.4946 c=0
Rl25 (\4\:CKb \7\:CKb) resistor r=247.62 c=0
Rl23 (\4\:CKb \5\:CKb) resistor r=34.2969 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=150.721 c=0
Rl16 (mout \2\:mout) resistor r=49.2328 c=0
Rl17 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl19 (\7\:CKbb \8\:CKbb) resistor r=58.3841 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=62.2302 c=0
Rl14 (n20 \2\:n20) resistor r=112.23 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl43 (\2\:net502 net502) resistor r=105.003 c=0
Rl47 (\2\:net502 \6\:net502) resistor r=124.234 c=0
Rl46 (\3\:net502 \5\:net502) resistor r=3.6042 c=0
Rl44 (\3\:net502 \2\:net502) resistor r=91.3077 c=0
Rl35 (SEb \2\:SEb) resistor r=55.01 c=0
Rl36 (\3\:SEb \4\:SEb) resistor r=35.3482 c=0
Rl37 (\4\:SEb \5\:SEb) resistor r=107.617 c=0
Rl54 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl55 (\2\:Eb \3\:Eb) resistor r=264.183 c=0
Rz20 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz25 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz26 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz1 (\4\:Q \3\:Q) resistor r=75 c=0
Rz19 (VDD \3\:VDD) resistor r=25 c=0
Rz16 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz17 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\20\:VDD \3\:VDD) resistor r=6.25 c=0
Rz12 (\2\:QN \1\:QN) resistor r=75 c=0
Rz5 (\21\:net536 \20\:net536) resistor r=75 c=0
Rz2 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz7 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz4 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Dbp \2\:Dbp) resistor r=75 c=0
Rz9 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz11 (\13\:net502 \12\:net502) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\11\:SEb \12\:SEb) resistor r=75 c=0
Rz15 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry30 (VSS \1\:VSS) resistor r=12.4 c=0
Ry25 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry26 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry27 (\7\:VSS \1\:VSS) resistor r=6.2 c=0
Ry28 (\9\:VSS \1\:VSS) resistor r=12.4 c=0
Ry29 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry16 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry19 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry20 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry21 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry12 (\4\:QN \3\:QN) resistor r=62 c=0
Ry5 (\17\:net536 \16\:net536) resistor r=62 c=0
Ry2 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry7 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry4 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry9 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry11 (\15\:net502 \14\:net502) resistor r=62 c=0
Ry13 (\4\:Db \5\:Db) resistor r=62 c=0
Ry14 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry15 (\8\:Eb \9\:Eb) resistor r=62 c=0
Rx20 (\2\:E \8\:E) resistor r=45 c=0
Rx21 (\4\:E \9\:E) resistor r=45 c=0
Rx22 (\6\:E \10\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:D \4\:D) resistor r=45 c=0
Rx17 (\2\:SE \7\:SE) resistor r=45 c=0
Rx4 (\14\:net536 \12\:net536) resistor r=45 c=0
Rx5 (\18\:net536 \10\:net536) resistor r=45 c=0
Rx6 (\22\:net536 \6\:net536) resistor r=45 c=0
Rx1 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx11 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx2 (\2\:mout \4\:mout) resistor r=45 c=0
Rx7 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\11\:net502 \5\:net502) resistor r=45 c=0
Rx14 (\4\:SEb \6\:SEb) resistor r=45 c=0
Rx15 (SEb \7\:SEb) resistor r=45 c=0
Rx16 (\5\:SEb \10\:SEb) resistor r=45 c=0
Rx23 (\2\:Eb \7\:Eb) resistor r=45 c=0
mn55_1__rcx (\3\:Q net536 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.153e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.17212e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn45 (\20\:net536 n30 VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=2.53e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.23415e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net534 \8\:net536 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=1.015e-14 ps=1.5e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.54e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\5\:n30 \9\:CKb net534 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=1.425e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\6\:mout \3\:CKbb \5\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.988e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.22e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\6\:mout \3\:n20 \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=3.988e-14 ps=1.38e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.4e-07 sb=9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (net526 \3\:mout \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\8\:n20 \5\:CKbb net526 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.003e-14 ps=4.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.11e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\9\:Dbp \5\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\11\:CKbb CKb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\12\:net502 \13\:net536 \23\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\10\:CKb \3\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.248e-14 ps=8.7e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=9.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (net546 \4\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=1.957e-14 ps=8.7e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=6.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn2 (Db \3\:Eb net514 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.465e-14 ps=4.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=9.75e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn13 (Dbp \4\:SE net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.48e-14 ps=5.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=4.25e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn4 (Db \3\:E net554 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.465e-14 ps=5.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=7.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\11\:SEb \1\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.235e-14 ad=3.263e-14 ps=1.02e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.835e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn57 (\1\:QN \3\:net502 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.998e-14 ad=4.16e-14 ps=1.185e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=1.01365e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn1 (net514 \6\:net502 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=8.7e-15 ps=1.35e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.08e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn3 (net554 \3\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=1.595e-14 ps=1.13e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=6.05e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn0 (\4\:Eb \7\:E \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=2.03e-14 ps=1.13e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp45 (\16\:net536 \3\:n30 VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.075e-14 ad=3.7e-14 ps=1.97e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.19355e-07 sd=160n sca=36.7709 \
        scb=0.0239974 scc=0.00420525 m=(1)
mp50 (net457 \9\:net536 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.99e-14 ad=2.472e-14 ps=1.17e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09302e-07 sb=1.455e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp51 (\9\:n30 CKbb net457 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.762e-14 ps=6.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.69302e-07 sb=1.295e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp40 (\9\:n30 \8\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.762e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.89302e-07 sb=1.075e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp30 (\8\:mout n20 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.09302e-07 sb=7.55e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp35 (net437 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0743e-06 sb=4.9e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp36 (\4\:n20 \7\:CKb net437 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1793e-06 sb=3.85e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp25 (\4\:n20 \7\:CKbb \5\:Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.3e-14 ps=7.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4243e-06 sb=1.4e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp21 (\9\:CKbb \6\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.827e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\14\:net502 \11\:net536 \15\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=8.827e-14 ad=7.525e-14 ps=1.45e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=4.7e-07 sb=3.5e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\14\:CKb \1\:CK \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0435e-13 ad=3.01e-14 ps=1.71e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.35e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp12 (net465 \1\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0435e-13 ad=1.29e-14 ps=1.71e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=5e-07 sd=160n sca=13.1637 scb=0.0123476 \
        scc=0.000501177 m=(1)
mp13 (\7\:Dbp \2\:SEb net465 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=3.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp11 (\7\:Dbp \6\:SE \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.4e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp10 (\8\:SEb \5\:SE \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1297e-13 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05581e-07 sd=160n sca=24.8095 \
        scb=0.0224988 scc=0.00280688 m=(1)
mp57 (\3\:QN \3\:net502 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.896e-14 ad=6.24e-14 ps=1.625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40897e-07 sb=9.92244e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
mp1 (net425 net502 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.495e-14 ad=2.902e-14 ps=1.55e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.04884e-07 sb=1.08e-06 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp2 (\6\:Db \1\:E net425 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.84884e-07 sb=9e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp4 (\6\:Db Eb net473 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08988e-06 sb=6.95e-07 sd=160n sca=11.1829 \
        scb=0.00913745 scc=0.000187969 m=(1)
mp3 (net473 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.417e-14 ad=2.58e-14 ps=1.12e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25488e-06 sb=5.3e-07 sd=160n sca=11.6362 \
        scb=0.00930804 scc=0.000188027 m=(1)
mp0 (\8\:Eb \5\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.417e-14 ad=3.01e-14 ps=1.12e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64488e-06 sb=1.4e-07 sd=160n sca=15.5174 \
        scb=0.0148358 scc=0.000265687 m=(1)
ends SEDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:57:34 2012 )
// Library name: gsclib045
// Cell name: SEDFFX4
// View name: extracted

simulator lang=spectre

subckt SEDFFX4 CK D E Q QN SE SI VDD VSS
mp55_1__rcx (Q net536 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.925e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54032e-06 sd=160n sca=32.0426 \
        scb=0.0350053 scc=0.00300251 m=(4)
C1 (E VSS) capacitor c=1.8889e-17
C2 (SI VSS) capacitor c=5.06404e-17
C3 (CK VSS) capacitor c=1.07423e-16
C4 (D VSS) capacitor c=6.3426e-17
C5 (VDD VSS) capacitor c=7.76485e-16
C6 (Q VSS) capacitor c=2.66818e-16
C7 (QN VSS) capacitor c=1.04984e-16
C8 (SE VSS) capacitor c=5.06106e-17
C9 (net536 VSS) capacitor c=2.39411e-16
C10 (n30 VSS) capacitor c=1.79578e-16
C11 (net534 VSS) capacitor c=1.87509e-18
C12 (CKb VSS) capacitor c=2.50923e-17
C13 (mout VSS) capacitor c=5.93112e-17
C14 (CKbb VSS) capacitor c=5.29707e-17
C15 (n20 VSS) capacitor c=4.89693e-17
C16 (Dbp VSS) capacitor c=9.96976e-17
C17 (net502 VSS) capacitor c=3.40052e-17
C18 (net546 VSS) capacitor c=1.89263e-18
C19 (Db VSS) capacitor c=8.79305e-17
C20 (SEb VSS) capacitor c=3.78488e-17
C21 (Eb VSS) capacitor c=3.26738e-17
C22 (net457 VSS) capacitor c=1.78516e-18
C23 (net437 VSS) capacitor c=2.32221e-18
C24 (net465 VSS) capacitor c=2.42689e-18
C25 (net425 VSS) capacitor c=1.00901e-18
C26 (net473 VSS) capacitor c=3.72746e-18
C27 (\5\:E VSS) capacitor c=4.6621e-17
C28 (\3\:D VSS) capacitor c=4.69426e-17
C29 (\1\:E VSS) capacitor c=6.20923e-17
C30 (\12\:net502 VSS) capacitor c=6.95601e-17
C31 (\6\:SE VSS) capacitor c=2.67662e-17
C32 (\7\:SE VSS) capacitor c=3.64729e-17
C33 (\2\:SEb VSS) capacitor c=3.82617e-17
C34 (\4\:SI VSS) capacitor c=5.33446e-17
C35 (\1\:CK VSS) capacitor c=4.89257e-17
C36 (\16\:net536 VSS) capacitor c=4.63455e-17
C37 (\7\:CKb VSS) capacitor c=2.89602e-17
C38 (\8\:CKbb VSS) capacitor c=3.79469e-17
C39 (\4\:CKb VSS) capacitor c=1.28897e-16
C40 (\5\:CKb VSS) capacitor c=1.11366e-16
C41 (\13\:net536 VSS) capacitor c=5.47317e-17
C42 (\7\:E VSS) capacitor c=3.29694e-17
C43 (\1\:D VSS) capacitor c=5.42121e-17
C44 (\3\:E VSS) capacitor c=5.17815e-17
C45 (\3\:Eb VSS) capacitor c=8.77785e-17
C46 (\1\:SE VSS) capacitor c=4.80951e-17
C47 (\3\:SEb VSS) capacitor c=2.53882e-17
C48 (\5\:SE VSS) capacitor c=4.37352e-17
C49 (\1\:SI VSS) capacitor c=2.85955e-17
C50 (\3\:CK VSS) capacitor c=2.72192e-17
C51 (\18\:net536 VSS) capacitor c=4.65516e-17
C52 (\8\:CKb VSS) capacitor c=2.9938e-17
C53 (\5\:CKbb VSS) capacitor c=8.5472e-17
C54 (\3\:mout VSS) capacitor c=6.42571e-17
C55 (\3\:n20 VSS) capacitor c=2.79811e-17
C56 (\3\:CKbb VSS) capacitor c=5.4041e-17
C57 (\6\:CKb VSS) capacitor c=7.85131e-17
C58 (\14\:net536 VSS) capacitor c=5.45583e-17
C59 (\6\:E VSS) capacitor c=4.30161e-17
C60 (\2\:D VSS) capacitor c=7.2316e-17
C61 (\4\:E VSS) capacitor c=5.29516e-17
C62 (\2\:Eb VSS) capacitor c=7.87157e-17
C63 (\2\:E VSS) capacitor c=5.92402e-17
C64 (\2\:SE VSS) capacitor c=4.5618e-17
C65 (\5\:SEb VSS) capacitor c=3.93639e-17
C66 (\4\:SEb VSS) capacitor c=4.93601e-17
C67 (\3\:SI VSS) capacitor c=3.5886e-17
C68 (\2\:CK VSS) capacitor c=3.47653e-17
C69 (\2\:CKb VSS) capacitor c=3.19935e-17
C70 (\17\:net536 VSS) capacitor c=3.14022e-17
C71 (\7\:CKbb VSS) capacitor c=4.66721e-17
C72 (\6\:CKbb VSS) capacitor c=2.82187e-17
C73 (\2\:mout VSS) capacitor c=5.2243e-17
C74 (\2\:n20 VSS) capacitor c=3.32163e-17
C75 (\4\:CKbb VSS) capacitor c=2.12248e-17
C76 (\2\:CKbb VSS) capacitor c=5.61885e-17
C77 (\15\:net536 VSS) capacitor c=3.04548e-17
C78 (\6\:Eb VSS) capacitor c=1.16728e-16
C79 (\7\:VDD VSS) capacitor c=1.09922e-17
C80 (\6\:Db VSS) capacitor c=4.08349e-17
C81 (\8\:SEb VSS) capacitor c=7.29081e-17
C82 (\4\:Db VSS) capacitor c=1.96944e-16
C83 (\7\:Dbp VSS) capacitor c=2.75376e-17
C84 (\17\:VDD VSS) capacitor c=4.73763e-17
C85 (\11\:CKb VSS) capacitor c=1.82907e-16
C86 (\23\:net502 VSS) capacitor c=8.58919e-17
C87 (\20\:VDD VSS) capacitor c=5.65701e-17
C88 (\16\:CKbb VSS) capacitor c=6.79355e-17
C89 (\5\:Dbp VSS) capacitor c=3.50182e-17
C90 (\4\:n20 VSS) capacitor c=4.76193e-17
C91 (\24\:VDD VSS) capacitor c=7.13682e-17
C92 (\8\:mout VSS) capacitor c=5.43819e-17
C93 (\12\:n30 VSS) capacitor c=2.96357e-17
C94 (\21\:net536 VSS) capacitor c=8.27692e-17
C95 (\1\:VDD VSS) capacitor c=2.44316e-16
C96 (\4\:Eb VSS) capacitor c=6.64477e-17
C97 (\1\:QN VSS) capacitor c=9.64199e-17
C98 (\11\:SEb VSS) capacitor c=5.1575e-17
C99 (\8\:Db VSS) capacitor c=1.05526e-16
C100 (\9\:CKb VSS) capacitor c=7.83627e-17
C101 (\21\:net502 VSS) capacitor c=2.43957e-16
C102 (\11\:CKbb VSS) capacitor c=9.37962e-17
C103 (\9\:Dbp VSS) capacitor c=9.71538e-17
C104 (\8\:n20 VSS) capacitor c=3.72386e-17
C105 (\6\:mout VSS) capacitor c=4.89538e-17
C106 (\10\:n30 VSS) capacitor c=7.10315e-17
C107 (\26\:net536 VSS) capacitor c=2.22227e-17
C108 (\3\:CKb VSS) capacitor c=7.03438e-17
C109 (\3\:SE VSS) capacitor c=3.49822e-17
C110 (\4\:SE VSS) capacitor c=7.85231e-17
C111 (\2\:net502 VSS) capacitor c=4.30928e-17
C112 (\3\:net502 VSS) capacitor c=2.55727e-16
C113 (\8\:n30 VSS) capacitor c=6.92756e-17
C114 (\9\:n30 VSS) capacitor c=7.50891e-17
C115 (\4\:mout VSS) capacitor c=7.60645e-17
C116 (\5\:mout VSS) capacitor c=5.72353e-17
C117 (\6\:n20 VSS) capacitor c=5.92212e-17
C118 (\7\:n20 VSS) capacitor c=5.97587e-17
C119 (\19\:net536 VSS) capacitor c=1.95115e-16
C120 (\20\:net536 VSS) capacitor c=2.31353e-16
C121 (\23\:net536 VSS) capacitor c=4.13818e-17
C122 (\24\:net536 VSS) capacitor c=3.0945e-17
C123 (\25\:net536 VSS) capacitor c=2.32708e-17
C124 (\9\:CKbb VSS) capacitor c=7.33288e-17
C125 (\10\:CKbb VSS) capacitor c=7.98211e-17
C126 (\13\:CKbb VSS) capacitor c=7.19051e-17
C127 (\14\:CKbb VSS) capacitor c=1.19821e-16
C128 (\15\:CKbb VSS) capacitor c=8.49675e-17
C129 (\13\:CKb VSS) capacitor c=1.05449e-16
C130 (\5\:SI VSS) capacitor c=8.05993e-17
C131 (\3\:Dbp VSS) capacitor c=2.73425e-16
C132 (\4\:Dbp VSS) capacitor c=2.38924e-16
C133 (\6\:SEb VSS) capacitor c=5.36785e-17
C134 (\7\:SEb VSS) capacitor c=7.63872e-17
C135 (\10\:SEb VSS) capacitor c=6.13039e-17
C136 (\8\:SE VSS) capacitor c=7.74825e-17
C137 (\20\:net502 VSS) capacitor c=2.50379e-16
C138 (\3\:Db VSS) capacitor c=2.01608e-16
C139 (\8\:E VSS) capacitor c=2.92556e-17
C140 (\9\:E VSS) capacitor c=2.47649e-17
C141 (\10\:E VSS) capacitor c=3.74979e-17
C142 (\11\:E VSS) capacitor c=4.88228e-17
C143 (\4\:D VSS) capacitor c=7.53137e-17
C144 (\8\:Eb VSS) capacitor c=7.59863e-17
C145 (\5\:VDD VSS) capacitor c=1.44823e-16
C146 (\19\:VDD VSS) capacitor c=2.66489e-17
C147 (\23\:VDD VSS) capacitor c=3.25048e-18
Rk54 (\9\:E E) resistor r=0.03645 c=0
Rk52 (\8\:E \9\:E) resistor r=0.1451 c=0
Rk53 (\9\:E \10\:E) resistor r=0.1053 c=0
Rk55 (\10\:E \11\:E) resistor r=0.2733 c=0
Rk31 (\5\:SI SI) resistor r=0.1095 c=0
Rk59 (\2\:VSS \3\:VSS) resistor r=0.09513 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.3059 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.07506 c=0
Rk65 (\5\:VSS \9\:VSS) resistor r=0.6169 c=0
Rk66 (\9\:VSS \10\:VSS) resistor r=0.0575 c=0
Rk67 (\10\:VSS \11\:VSS) resistor r=0.5264 c=0
Rk68 (\11\:VSS \12\:VSS) resistor r=0.3184 c=0
Rk69 (\12\:VSS \13\:VSS) resistor r=0.2933 c=0
Rk71 (\14\:VSS VSS) resistor r=0.2707 c=0
Rk70 (\13\:VSS \14\:VSS) resistor r=0.2582 c=0
Rk77 (\3\:VSS \22\:VSS) resistor r=0.2778 c=0
Rk81 (\10\:VSS \30\:VSS) resistor r=0.123 c=0
Rk82 (\11\:VSS \32\:VSS) resistor r=0.3009 c=0
Rk83 (\13\:VSS \34\:VSS) resistor r=0.123 c=0
Rk30 (\4\:CK CK) resistor r=0.002143 c=0
Rk56 (D \4\:D) resistor r=0.01829 c=0
Rk87 (\2\:VDD \3\:VDD) resistor r=0.1077 c=0
Rk88 (\3\:VDD \4\:VDD) resistor r=0.193 c=0
Rk89 (\4\:VDD \5\:VDD) resistor r=0.2105 c=0
Rk91 (\3\:VDD \8\:VDD) resistor r=0.07416 c=0
Rk96 (\5\:VDD \16\:VDD) resistor r=0.5718 c=0
Rk97 (\16\:VDD \18\:VDD) resistor r=0.3109 c=0
Rk98 (\16\:VDD \19\:VDD) resistor r=0.5573 c=0
Rk99 (\19\:VDD \21\:VDD) resistor r=0.2779 c=0
Rk100 (\19\:VDD \22\:VDD) resistor r=0.2958 c=0
Rk101 (\22\:VDD \23\:VDD) resistor r=0.2933 c=0
Rk102 (\23\:VDD \25\:VDD) resistor r=0.3467 c=0
Rk104 (\26\:VDD VDD) resistor r=0.2707 c=0
Rk103 (\23\:VDD \26\:VDD) resistor r=0.2582 c=0
Rk44 (\1\:QN QN) resistor r=0.2874 c=0
Rk40 (\8\:SE SE) resistor r=0.005181 c=0
Rk16 (\19\:net536 \20\:net536) resistor r=1.6607 c=0
Rk17 (\20\:net536 \22\:net536) resistor r=0.3384 c=0
Rk18 (\22\:net536 \23\:net536) resistor r=0.2896 c=0
Rk19 (\23\:net536 \24\:net536) resistor r=0.16 c=0
Rk20 (\20\:net536 \25\:net536) resistor r=0.03527 c=0
Rk21 (\23\:net536 \27\:net536) resistor r=0.1637 c=0
Rk7 (\8\:n30 \9\:n30) resistor r=0.4198 c=0
Rk8 (\9\:n30 \11\:n30) resistor r=0.377 c=0
Rk9 (\9\:n30 \13\:n30) resistor r=0.04983 c=0
Rk28 (\10\:CKb \12\:CKb) resistor r=0.4703 c=0
Rk29 (\12\:CKb \13\:CKb) resistor r=0.9305 c=0
Rk10 (\4\:mout \5\:mout) resistor r=0.3387 c=0
Rk11 (\5\:mout \7\:mout) resistor r=0.2465 c=0
Rk12 (\5\:mout \9\:mout) resistor r=0.1751 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.4025 c=0
Rk23 (\10\:CKbb \12\:CKbb) resistor r=0.4677 c=0
Rk24 (\10\:CKbb \13\:CKbb) resistor r=0.2186 c=0
Rk25 (\13\:CKbb \14\:CKbb) resistor r=0.4586 c=0
Rk26 (\14\:CKbb \15\:CKbb) resistor r=0.5768 c=0
Rk27 (\12\:CKbb \17\:CKbb) resistor r=0.3365 c=0
Rk13 (\5\:n20 \6\:n20) resistor r=0.2954 c=0
Rk14 (\6\:n20 \7\:n20) resistor r=0.3095 c=0
Rk15 (\6\:n20 \9\:n20) resistor r=0.1282 c=0
Rk32 (\2\:Dbp \3\:Dbp) resistor r=0.6186 c=0
Rk33 (\3\:Dbp \4\:Dbp) resistor r=1.6534 c=0
Rk34 (\4\:Dbp \6\:Dbp) resistor r=0.1241 c=0
Rk35 (\3\:Dbp \8\:Dbp) resistor r=0.1918 c=0
Rk36 (\4\:Dbp \10\:Dbp) resistor r=0.4369 c=0
Rk41 (\20\:net502 \22\:net502) resistor r=2.0049 c=0
Rk42 (\22\:net502 \24\:net502) resistor r=0.5115 c=0
Rk48 (\2\:Db \3\:Db) resistor r=0.7458 c=0
Rk49 (\3\:Db \5\:Db) resistor r=1.2073 c=0
Rk50 (\3\:Db \7\:Db) resistor r=0.09878 c=0
Rk51 (\5\:Db \9\:Db) resistor r=0.6487 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.2807 c=0
Rk38 (\9\:SEb \10\:SEb) resistor r=0.2176 c=0
Rk39 (\10\:SEb \12\:SEb) resistor r=0.1196 c=0
Rk57 (\5\:Eb \7\:Eb) resistor r=0.6439 c=0
Rk58 (\7\:Eb \8\:Eb) resistor r=0.5199 c=0
Rl75 (\5\:E \6\:E) resistor r=124.233 c=0
Rl76 (\6\:E \7\:E) resistor r=74.2328 c=0
Rl72 (\3\:E \4\:E) resistor r=74.2328 c=0
Rl69 (\1\:E \2\:E) resistor r=71.8456 c=0
Rl41 (\2\:SI \4\:SI) resistor r=154.785 c=0
Rl39 (\1\:SI \2\:SI) resistor r=47.0924 c=0
Rl40 (\2\:SI \3\:SI) resistor r=2.9709 c=0
Rl37 (\1\:CK \2\:CK) resistor r=148.769 c=0
Rl38 (\2\:CK \3\:CK) resistor r=29.5379 c=0
Rl74 (\2\:D \3\:D) resistor r=53.022 c=0
Rl73 (\1\:D \2\:D) resistor r=150 c=0
Rl45 (\1\:SE \2\:SE) resistor r=85.7713 c=0
Rl49 (\3\:SE \6\:SE) resistor r=30.4507 c=0
Rl46 (\2\:SE \3\:SE) resistor r=27.8747 c=0
Rl50 (\4\:SE \7\:SE) resistor r=95.3874 c=0
Rl48 (\4\:SE \5\:SE) resistor r=144.953 c=0
Rl47 (\3\:SE \4\:SE) resistor r=187.377 c=0
Rl36 (\18\:net536 \16\:net536) resistor r=92.3077 c=0
Rl18 (\14\:net536 \13\:net536) resistor r=167.308 c=0
Rl35 (\17\:net536 \16\:net536) resistor r=176.9 c=0
Rl19 (\15\:net536 \13\:net536) resistor r=24.2328 c=0
Rl31 (\4\:CKb \5\:CKb) resistor r=407.258 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=210.67 c=0
Rl28 (CKb \2\:CKb) resistor r=34.4634 c=0
Rl33 (\2\:CKb \7\:CKb) resistor r=28.1713 c=0
Rl30 (\3\:CKb \4\:CKb) resistor r=168.774 c=0
Rl34 (\3\:CKb \8\:CKb) resistor r=53.5277 c=0
Rl29 (\2\:CKb \3\:CKb) resistor r=211.87 c=0
Rl24 (mout \2\:mout) resistor r=50.6918 c=0
Rl25 (\2\:mout \3\:mout) resistor r=91.0764 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=57.2054 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=41.5405 c=0
Rl21 (\3\:CKbb \4\:CKbb) resistor r=41.5405 c=0
Rl20 (CKbb \2\:CKbb) resistor r=74.4182 c=0
Rl22 (n20 \2\:n20) resistor r=112.23 c=0
Rl23 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl51 (\2\:net502 net502) resistor r=86.8026 c=0
Rl61 (\2\:net502 \12\:net502) resistor r=140.066 c=0
Rl52 (\3\:net502 \2\:net502) resistor r=71.544 c=0
Rl42 (SEb \2\:SEb) resistor r=62.9746 c=0
Rl43 (\3\:SEb \4\:SEb) resistor r=35.3482 c=0
Rl44 (\4\:SEb \5\:SEb) resistor r=96.0784 c=0
Rl70 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl71 (\2\:Eb \3\:Eb) resistor r=206.812 c=0
Rz19 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz24 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz25 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz35 (VDD \1\:VDD) resistor r=10.7143 c=0
Rz29 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz30 (\4\:VDD \1\:VDD) resistor r=18.75 c=0
Rz31 (\5\:VDD \1\:VDD) resistor r=15 c=0
Rz32 (\16\:VDD \1\:VDD) resistor r=6.8182 c=0
Rz33 (\22\:VDD \1\:VDD) resistor r=12.5 c=0
Rz34 (\26\:VDD \1\:VDD) resistor r=15 c=0
Rz6 (\27\:net536 \26\:net536) resistor r=75 c=0
Rz3 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz8 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (Dbp \2\:Dbp) resistor r=75 c=0
Rz10 (\9\:Dbp \10\:Dbp) resistor r=75 c=0
Rz12 (\22\:net502 \21\:net502) resistor r=75 c=0
Rz15 (Db \2\:Db) resistor r=75 c=0
Rz16 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\11\:SEb \12\:SEb) resistor r=75 c=0
Rz17 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry24 (VSS \1\:VSS) resistor r=8.8571 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry19 (\4\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry20 (\5\:VSS \1\:VSS) resistor r=31 c=0
Ry21 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\12\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry23 (\14\:VSS \1\:VSS) resistor r=12.4 c=0
Ry25 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry29 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry30 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry31 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry6 (\22\:net536 \21\:net536) resistor r=31 c=0
Ry3 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry8 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry7 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry5 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry9 (\5\:Dbp \6\:Dbp) resistor r=62 c=0
Ry10 (\7\:Dbp \8\:Dbp) resistor r=62 c=0
Ry12 (\24\:net502 \23\:net502) resistor r=62 c=0
Ry15 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (\6\:Db \7\:Db) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry17 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx19 (\6\:E \8\:E) resistor r=45 c=0
Rx20 (\4\:E \10\:E) resistor r=45 c=0
Rx21 (\2\:E \11\:E) resistor r=45 c=0
Rx13 (\3\:SI \5\:SI) resistor r=45 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx22 (\2\:D \4\:D) resistor r=45 c=0
Rx17 (\2\:SE \8\:SE) resistor r=45 c=0
Rx4 (\19\:net536 \17\:net536) resistor r=45 c=0
Rx5 (\24\:net536 net536) resistor r=45 c=0
Rx6 (\25\:net536 \15\:net536) resistor r=45 c=0
Rx1 (\8\:n30 n30) resistor r=45 c=0
Rx11 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx2 (\2\:mout \4\:mout) resistor r=45 c=0
Rx7 (\7\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\20\:net502 \3\:net502) resistor r=45 c=0
Rx14 (\4\:SEb \6\:SEb) resistor r=45 c=0
Rx15 (SEb \7\:SEb) resistor r=45 c=0
Rx16 (\5\:SEb \10\:SEb) resistor r=45 c=0
Rx23 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn55_1__rcx (Q net536 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.156e-14 ad=4.16e-14 ps=8.45e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54163e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\26\:net536 n30 VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.119e-14 ad=3.28e-14 ps=8.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.5039e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn50 (net534 \14\:net536 VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.572e-14 ad=2.537e-14 ps=8.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.645e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn51 (\10\:n30 \6\:CKb net534 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.665e-06 sb=1.425e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn40 (\6\:mout \3\:CKbb \10\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.987e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.22e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\6\:mout \3\:n20 \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=3.988e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn35 (net526 \3\:mout \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=8.7e-15 ps=1.32e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.35e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn36 (\8\:n20 \5\:CKbb net526 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.9e-14 ps=4.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.3e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn25 (\9\:Dbp \8\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=4.132e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn21 (\11\:CKbb CKb \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\21\:net502 \18\:net536 \31\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.71058e-07 sb=1.4e-07 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\9\:CKb \3\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.698e-14 ps=1.35e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=9.5e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn12 (net546 \1\:SI \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=3.553e-14 ps=1.35e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=6.85e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn13 (Dbp \5\:SE net546 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.552e-14 ad=3.045e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=3.95e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn11 (\8\:Db \3\:SEb Dbp VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn10 (\11\:SEb \1\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.262e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.40052e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn57_1__rcx (\1\:QN \3\:net502 \5\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.182e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.18462e-07 sb=1.28087e-06 sd=160n \
        sca=12.4994 scb=0.0122912 scc=0.000683921 m=(4)
mn1 (net514 net502 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.045e-14 ad=1.377e-14 ps=9e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13345e-06 sb=8.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn2 (Db \3\:Eb net514 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.377e-14 ad=2.32e-14 ps=4.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27345e-06 sb=7.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn4 (Db \3\:E net554 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47845e-06 sb=5.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn3 (net554 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.957e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65845e-06 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\4\:Eb \7\:E \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84552e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45 (\21\:net536 n30 VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.784e-14 ad=4.96e-14 ps=1.19e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.47081e-06 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(2)
mp50 (net457 \13\:net536 VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.807e-14 ad=3.01e-14 ps=1.28e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.47e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp51 (\12\:n30 CKbb net457 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.192e-14 ps=7.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=1.285e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp40 (\12\:n30 \5\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.192e-14 ps=9.8e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.87e-06 sb=1.045e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp30 (\8\:mout n20 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.912e-14 ps=8.7e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.25e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp35 (net437 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.505e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.6e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp36 (\4\:n20 \4\:CKb net437 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp25 (\4\:n20 \8\:CKbb \5\:Dbp VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp21 (\16\:CKbb \7\:CKb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.006e-13 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\23\:net502 \16\:net536 \20\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=1.006e-13 ad=1.443e-13 ps=1.41e-06 pd=1.52e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.44551e-07 sb=3.7e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(1)
mp20 (\11\:CKb \1\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=4.515e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.1e-07 sb=8.45e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp12 (net465 \4\:SI \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=3.117e-14 ps=8.4e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.95e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp13 (\7\:Dbp \2\:SEb net465 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=4.73e-14 ps=7.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=4.05e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp11 (\7\:Dbp \7\:SE \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.73e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.4e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (\8\:SEb \6\:SE \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.685e-14 ad=3.01e-14 ps=1.55e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.44186e-06 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp57_1__rcx (QN \3\:net502 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.904e-14 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=1.37936e-06 sd=160n sca=15.0636 \
        scb=0.0136086 scc=0.000948136 m=(4)
mp1 (net425 \12\:net502 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.81e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20837e-06 sb=9.15e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp2 (\6\:Db \1\:E net425 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31337e-06 sb=8.1e-07 sd=160n sca=11.3768 \
        scb=0.00954713 scc=0.000220652 m=(1)
mp4 (\6\:Db Eb net473 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.87e-14 ps=7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53837e-06 sb=5.85e-07 sd=160n sca=12.0147 \
        scb=0.00980752 scc=0.000220768 m=(1)
mp3 (net473 \3\:D \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=2.902e-14 ps=1.47e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71837e-06 sb=4.05e-07 sd=160n sca=13.1142 \
        scb=0.0109112 scc=0.000223955 m=(1)
mp0 (\6\:Eb \5\:E \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.33e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.93314e-06 sb=1.4e-07 sd=160n sca=18.9625 \
        scb=0.0206935 scc=0.000592237 m=(1)
ends SEDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:58:12 2012 )
// Library name: gsclib045
// Cell name: SEDFFXL
// View name: extracted

simulator lang=spectre

subckt SEDFFXL CK D E Q QN SE SI VDD VSS
mp0 (\8\:Eb \1\:E \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.315e-06 sd=160n sca=14.7678 \
        scb=0.0134734 scc=0.000346306 m=(1)
C1 (E VSS) capacitor c=3.33561e-17
C2 (Q VSS) capacitor c=5.15903e-17
C3 (SI VSS) capacitor c=8.74194e-17
C4 (QN VSS) capacitor c=4.9645e-17
C5 (VDD VSS) capacitor c=4.69246e-16
C6 (SE VSS) capacitor c=6.83166e-17
C7 (Eb VSS) capacitor c=2.2954e-17
C8 (net554 VSS) capacitor c=1.26437e-18
C9 (Db VSS) capacitor c=8.86445e-17
C10 (net514 VSS) capacitor c=2.25811e-18
C11 (net502 VSS) capacitor c=2.54702e-17
C12 (net536 VSS) capacitor c=4.48567e-17
C13 (SEb VSS) capacitor c=4.53699e-17
C14 (Dbp VSS) capacitor c=7.10319e-17
C15 (net546 VSS) capacitor c=1.49514e-18
C16 (n30 VSS) capacitor c=2.5687e-17
C17 (net534 VSS) capacitor c=3.35957e-18
C18 (CKb VSS) capacitor c=2.09599e-17
C19 (mout VSS) capacitor c=3.20734e-17
C20 (CKbb VSS) capacitor c=3.14871e-17
C21 (n20 VSS) capacitor c=3.57803e-17
C22 (net526 VSS) capacitor c=9.1449e-19
C23 (net473 VSS) capacitor c=7.21179e-18
C24 (net425 VSS) capacitor c=7.47869e-19
C25 (net465 VSS) capacitor c=2.16936e-18
C26 (net457 VSS) capacitor c=2.27913e-18
C27 (net437 VSS) capacitor c=7.04986e-19
C28 (\1\:CK VSS) capacitor c=3.2949e-17
C29 (\9\:CKb VSS) capacitor c=3.28137e-17
C30 (\5\:CKbb VSS) capacitor c=2.60774e-17
C31 (\4\:CKb VSS) capacitor c=6.76807e-17
C32 (\3\:mout VSS) capacitor c=7.88291e-17
C33 (\3\:n20 VSS) capacitor c=3.63018e-17
C34 (\2\:CKb VSS) capacitor c=5.28825e-17
C35 (\2\:CKbb VSS) capacitor c=4.84706e-17
C36 (\10\:net536 VSS) capacitor c=4.71754e-17
C37 (\4\:net536 VSS) capacitor c=3.12604e-17
C38 (\1\:SI VSS) capacitor c=7.12043e-17
C39 (\3\:SEb VSS) capacitor c=5.19637e-17
C40 (\5\:SE VSS) capacitor c=3.26495e-17
C41 (\6\:SE VSS) capacitor c=3.31775e-17
C42 (\6\:net502 VSS) capacitor c=6.14933e-17
C43 (\6\:E VSS) capacitor c=5.60274e-17
C44 (\1\:D VSS) capacitor c=3.96619e-17
C45 (\1\:E VSS) capacitor c=4.85025e-17
C46 (\3\:CK VSS) capacitor c=3.6912e-17
C47 (\6\:CKb VSS) capacitor c=2.24774e-17
C48 (\8\:CKb VSS) capacitor c=4.71055e-17
C49 (\7\:CKbb VSS) capacitor c=4.3057e-17
C50 (\3\:CKbb VSS) capacitor c=4.29338e-17
C51 (\3\:CKb VSS) capacitor c=6.86418e-17
C52 (\7\:net536 VSS) capacitor c=3.43724e-17
C53 (\3\:n30 VSS) capacitor c=4.4725e-17
C54 (\5\:net536 VSS) capacitor c=4.66619e-17
C55 (\3\:SI VSS) capacitor c=2.57814e-17
C56 (\1\:SE VSS) capacitor c=5.84251e-17
C57 (\7\:SE VSS) capacitor c=2.57251e-17
C58 (\3\:net536 VSS) capacitor c=3.38376e-17
C59 (\5\:net502 VSS) capacitor c=1.53457e-17
C60 (\4\:net502 VSS) capacitor c=3.97859e-17
C61 (\3\:Eb VSS) capacitor c=5.56831e-17
C62 (\4\:E VSS) capacitor c=5.42792e-17
C63 (\3\:D VSS) capacitor c=4.37668e-17
C64 (\3\:E VSS) capacitor c=2.27304e-17
C65 (\2\:CK VSS) capacitor c=3.52104e-17
C66 (\7\:CKb VSS) capacitor c=4.26577e-17
C67 (\6\:CKbb VSS) capacitor c=3.37501e-17
C68 (\5\:CKb VSS) capacitor c=2.71596e-17
C69 (\2\:mout VSS) capacitor c=4.50947e-17
C70 (\2\:n20 VSS) capacitor c=4.63623e-17
C71 (\4\:CKbb VSS) capacitor c=4.32037e-17
C72 (\9\:net536 VSS) capacitor c=4.99579e-17
C73 (\2\:n30 VSS) capacitor c=3.24544e-17
C74 (\6\:net536 VSS) capacitor c=1.78714e-17
C75 (\2\:SI VSS) capacitor c=4.5388e-17
C76 (\4\:SEb VSS) capacitor c=4.87917e-17
C77 (\2\:SEb VSS) capacitor c=2.49734e-17
C78 (\4\:SE VSS) capacitor c=2.32854e-17
C79 (\2\:net536 VSS) capacitor c=2.28018e-17
C80 (\7\:E VSS) capacitor c=4.89571e-17
C81 (\2\:Eb VSS) capacitor c=3.5127e-17
C82 (\5\:E VSS) capacitor c=3.3915e-17
C83 (\2\:D VSS) capacitor c=4.89634e-17
C84 (\2\:E VSS) capacitor c=4.43543e-17
C85 (\10\:CKb VSS) capacitor c=2.50844e-17
C86 (\14\:VDD VSS) capacitor c=2.94109e-17
C87 (\8\:n20 VSS) capacitor c=3.78086e-17
C88 (\1\:VDD VSS) capacitor c=2.11911e-17
C89 (\4\:mout VSS) capacitor c=6.0749e-17
C90 (\8\:n30 VSS) capacitor c=3.53214e-17
C91 (\16\:VDD VSS) capacitor c=5.53766e-17
C92 (\13\:net536 VSS) capacitor c=9.09891e-17
C93 (\3\:Q VSS) capacitor c=6.85494e-17
C94 (\18\:VDD VSS) capacitor c=3.17817e-17
C95 (\5\:Dbp VSS) capacitor c=4.68997e-16
C96 (\3\:Db VSS) capacitor c=2.50177e-16
C97 (\10\:SEb VSS) capacitor c=5.81977e-17
C98 (\20\:VDD VSS) capacitor c=1.68853e-17
C99 (\7\:net502 VSS) capacitor c=6.74417e-17
C100 (\1\:QN VSS) capacitor c=5.39622e-17
C101 (\22\:VDD VSS) capacitor c=1.18282e-17
C102 (\5\:Db VSS) capacitor c=2.07843e-16
C103 (\24\:VDD VSS) capacitor c=4.03636e-17
C104 (\8\:Eb VSS) capacitor c=6.32826e-18
C105 (\4\:VDD VSS) capacitor c=1.22867e-16
C106 (\16\:CKb VSS) capacitor c=5.48669e-17
C107 (\10\:CKbb VSS) capacitor c=6.8119e-17
C108 (\3\:Dbp VSS) capacitor c=3.84699e-16
C109 (\4\:n20 VSS) capacitor c=6.88268e-17
C110 (\7\:mout VSS) capacitor c=4.58996e-17
C111 (\4\:n30 VSS) capacitor c=7.44561e-17
C112 (\15\:net536 VSS) capacitor c=2.46319e-17
C113 (\1\:Q VSS) capacitor c=6.07062e-17
C114 (\7\:Dbp VSS) capacitor c=1.09786e-16
C115 (\7\:SEb VSS) capacitor c=8.67088e-17
C116 (\9\:net502 VSS) capacitor c=1.06384e-16
C117 (\3\:QN VSS) capacitor c=4.87535e-17
C118 (\7\:Db VSS) capacitor c=1.14829e-16
C119 (\6\:Eb VSS) capacitor c=6.01646e-17
C120 (\3\:net502 VSS) capacitor c=5.29063e-17
C121 (\2\:SE VSS) capacitor c=7.06245e-17
C122 (\3\:SE VSS) capacitor c=2.1178e-17
C123 (\4\:D VSS) capacitor c=5.61907e-17
C124 (\6\:D VSS) capacitor c=4.511e-17
C125 (\4\:Eb VSS) capacitor c=7.24007e-17
C126 (\5\:Eb VSS) capacitor c=1.06597e-16
C127 (\8\:E VSS) capacitor c=1.44054e-16
C128 (\9\:E VSS) capacitor c=1.00738e-16
C129 (\10\:E VSS) capacitor c=5.88894e-17
C130 (\11\:E VSS) capacitor c=1.68221e-17
C131 (\11\:net502 VSS) capacitor c=1.15141e-16
C132 (\8\:SE VSS) capacitor c=4.36478e-17
C133 (\5\:SEb VSS) capacitor c=9.69291e-17
C134 (\6\:SEb VSS) capacitor c=1.15754e-16
C135 (\9\:SEb VSS) capacitor c=2.95945e-17
C136 (\4\:SI VSS) capacitor c=2.76489e-17
C137 (\11\:net536 VSS) capacitor c=5.49591e-17
C138 (\12\:net536 VSS) capacitor c=4.48676e-17
C139 (\17\:net536 VSS) capacitor c=1.85314e-16
C140 (\18\:net536 VSS) capacitor c=1.61296e-16
C141 (\6\:n30 VSS) capacitor c=6.99193e-17
C142 (\7\:n30 VSS) capacitor c=5.72405e-17
C143 (\6\:mout VSS) capacitor c=4.32544e-17
C144 (\9\:mout VSS) capacitor c=5.33907e-17
C145 (\6\:n20 VSS) capacitor c=5.92402e-17
C146 (\7\:n20 VSS) capacitor c=5.77181e-17
C147 (\9\:CKbb VSS) capacitor c=1.06234e-16
C148 (\12\:CKbb VSS) capacitor c=1.59575e-16
C149 (\13\:CKbb VSS) capacitor c=5.95285e-17
C150 (\14\:CKbb VSS) capacitor c=1.34755e-16
C151 (\15\:CKbb VSS) capacitor c=3.79878e-17
C152 (\12\:CKb VSS) capacitor c=1.45085e-16
C153 (\13\:CKb VSS) capacitor c=7.54004e-17
C154 (\14\:CKb VSS) capacitor c=1.44442e-16
C155 (\15\:CKb VSS) capacitor c=8.21473e-17
C156 (\4\:CK VSS) capacitor c=9.58074e-17
C157 (\3\:VDD VSS) capacitor c=4.32109e-17
C158 (\6\:VDD VSS) capacitor c=2.66461e-17
C159 (\7\:VDD VSS) capacitor c=4.32654e-17
C160 (\9\:VDD VSS) capacitor c=1.79492e-17
C161 (\10\:VDD VSS) capacitor c=3.63422e-17
C162 (\12\:VDD VSS) capacitor c=6.8231e-18
Rk8 (\9\:E E) resistor r=0.02565 c=0
Rk7 (\8\:E \9\:E) resistor r=1.0099 c=0
Rk9 (E \10\:E) resistor r=0.2775 c=0
Rk10 (\9\:E \11\:E) resistor r=0.06846 c=0
Rk55 (CK \4\:CK) resistor r=0.002335 c=0
Rk26 (Q \2\:Q) resistor r=0.1421 c=0
Rk27 (Q \4\:Q) resistor r=0.2646 c=0
Rk1 (\4\:D D) resistor r=0.00236 c=0
Rk3 (\4\:D \6\:D) resistor r=0.0559 c=0
Rk2 (\5\:D \6\:D) resistor r=0.00236 c=0
Rk25 (\4\:SI SI) resistor r=0.02102 c=0
Rk11 (\2\:QN QN) resistor r=0.2871 c=0
Rk12 (QN \4\:QN) resistor r=0.07112 c=0
Rk74 (\2\:VDD \3\:VDD) resistor r=0.04331 c=0
Rk75 (\3\:VDD \5\:VDD) resistor r=0.3876 c=0
Rk76 (\5\:VDD \6\:VDD) resistor r=0.1703 c=0
Rk77 (\6\:VDD \7\:VDD) resistor r=0.4535 c=0
Rk78 (\7\:VDD \8\:VDD) resistor r=0.4788 c=0
Rk79 (\8\:VDD \9\:VDD) resistor r=0.0766 c=0
Rk80 (\9\:VDD \10\:VDD) resistor r=0.4325 c=0
Rk81 (\10\:VDD \11\:VDD) resistor r=0.391 c=0
Rk83 (\12\:VDD VDD) resistor r=0.2202 c=0
Rk82 (\11\:VDD \12\:VDD) resistor r=0.1302 c=0
Rk84 (\3\:VDD \13\:VDD) resistor r=0.513 c=0
Rk85 (\13\:VDD \15\:VDD) resistor r=0.2484 c=0
Rk86 (\6\:VDD \17\:VDD) resistor r=0.3984 c=0
Rk87 (\7\:VDD \19\:VDD) resistor r=0.1026 c=0
Rk88 (\9\:VDD \21\:VDD) resistor r=0.04331 c=0
Rk89 (\10\:VDD \23\:VDD) resistor r=0.07393 c=0
Rk90 (\12\:VDD \25\:VDD) resistor r=0.2864 c=0
Rk56 (\2\:VSS \3\:VSS) resistor r=0.1076 c=0
Rk57 (\3\:VSS \4\:VSS) resistor r=0.544 c=0
Rk58 (\3\:VSS \6\:VSS) resistor r=0.2971 c=0
Rk59 (\4\:VSS \7\:VSS) resistor r=0.5672 c=0
Rk60 (\7\:VSS \8\:VSS) resistor r=0.5371 c=0
Rk61 (\8\:VSS \9\:VSS) resistor r=0.544 c=0
Rk62 (\9\:VSS \10\:VSS) resistor r=0.2581 c=0
Rk63 (\10\:VSS \11\:VSS) resistor r=0.2807 c=0
Rk64 (\11\:VSS \12\:VSS) resistor r=0.2205 c=0
Rk65 (\12\:VSS \13\:VSS) resistor r=0.2456 c=0
Rk67 (\14\:VSS VSS) resistor r=0.04991 c=0
Rk66 (\13\:VSS \14\:VSS) resistor r=0.1051 c=0
Rk68 (\4\:VSS \16\:VSS) resistor r=0.1691 c=0
Rk69 (\7\:VSS \18\:VSS) resistor r=0.1227 c=0
Rk70 (\8\:VSS \20\:VSS) resistor r=0.328 c=0
Rk71 (\9\:VSS \22\:VSS) resistor r=0.3891 c=0
Rk72 (\11\:VSS \24\:VSS) resistor r=0.07393 c=0
Rk73 (\13\:VSS \26\:VSS) resistor r=0.3048 c=0
Rk15 (\8\:SE SE) resistor r=0.09696 c=0
Rk4 (\4\:Eb \5\:Eb) resistor r=0.5379 c=0
Rk5 (\5\:Eb \7\:Eb) resistor r=0.5558 c=0
Rk6 (\5\:Eb \9\:Eb) resistor r=0.0279 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.4924 c=0
Rk17 (\4\:Db \6\:Db) resistor r=1.4859 c=0
Rk18 (\6\:Db \8\:Db) resistor r=0.6842 c=0
Rk13 (\8\:net502 \10\:net502) resistor r=0.2782 c=0
Rk14 (\10\:net502 \11\:net502) resistor r=0.8766 c=0
Rk28 (\11\:net536 \12\:net536) resistor r=0.254 c=0
Rk29 (\12\:net536 \14\:net536) resistor r=0.3363 c=0
Rk30 (\12\:net536 \16\:net536) resistor r=0.1205 c=0
Rk31 (\14\:net536 \17\:net536) resistor r=0.5297 c=0
Rk32 (\17\:net536 \18\:net536) resistor r=1.1628 c=0
Rk19 (\5\:SEb \6\:SEb) resistor r=0.6386 c=0
Rk20 (\6\:SEb \8\:SEb) resistor r=0.5401 c=0
Rk21 (\6\:SEb \9\:SEb) resistor r=0.02283 c=0
Rk22 (\8\:SEb \11\:SEb) resistor r=0.2589 c=0
Rk42 (\2\:Dbp \4\:Dbp) resistor r=0.3557 c=0
Rk43 (\4\:Dbp \6\:Dbp) resistor r=3.1556 c=0
Rk44 (\6\:Dbp \8\:Dbp) resistor r=0.5405 c=0
Rk33 (\5\:n30 \6\:n30) resistor r=0.4704 c=0
Rk34 (\6\:n30 \7\:n30) resistor r=0.2542 c=0
Rk35 (\6\:n30 \9\:n30) resistor r=0.2161 c=0
Rk50 (\11\:CKb \12\:CKb) resistor r=0.1976 c=0
Rk51 (\12\:CKb \13\:CKb) resistor r=0.365 c=0
Rk52 (\12\:CKb \14\:CKb) resistor r=0.761 c=0
Rk53 (\14\:CKb \15\:CKb) resistor r=0.6275 c=0
Rk54 (\13\:CKb \17\:CKb) resistor r=0.3047 c=0
Rk36 (\5\:mout \6\:mout) resistor r=0.2459 c=0
Rk37 (\6\:mout \8\:mout) resistor r=0.1771 c=0
Rk38 (\6\:mout \9\:mout) resistor r=0.2484 c=0
Rk45 (\9\:CKbb \11\:CKbb) resistor r=0.4367 c=0
Rk46 (\9\:CKbb \12\:CKbb) resistor r=0.4129 c=0
Rk47 (\12\:CKbb \13\:CKbb) resistor r=0.2339 c=0
Rk48 (\12\:CKbb \14\:CKbb) resistor r=0.9742 c=0
Rk49 (\14\:CKbb \15\:CKbb) resistor r=0.1916 c=0
Rk39 (\5\:n20 \6\:n20) resistor r=0.3813 c=0
Rk40 (\6\:n20 \7\:n20) resistor r=0.2473 c=0
Rk41 (\6\:n20 \9\:n20) resistor r=0.09076 c=0
Rl8 (\6\:E \7\:E) resistor r=71.8456 c=0
Rl5 (\4\:E \5\:E) resistor r=29.5379 c=0
Rl1 (\1\:E \2\:E) resistor r=171.131 c=0
Rl2 (\2\:E \3\:E) resistor r=24.7951 c=0
Rl47 (\1\:CK \2\:CK) resistor r=58.3841 c=0
Rl48 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl3 (\1\:D \2\:D) resistor r=85.3072 c=0
Rl4 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl24 (\1\:SI \2\:SI) resistor r=145.387 c=0
Rl25 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl22 (\4\:SE \7\:SE) resistor r=43.4636 c=0
Rl20 (\2\:SE \5\:SE) resistor r=72.7584 c=0
Rl17 (\1\:SE \2\:SE) resistor r=176.467 c=0
Rl21 (\3\:SE \6\:SE) resistor r=22.7584 c=0
Rl19 (\3\:SE \4\:SE) resistor r=14.4132 c=0
Rl18 (\2\:SE \3\:SE) resistor r=179.236 c=0
Rl6 (Eb \2\:Eb) resistor r=26.098 c=0
Rl7 (\2\:Eb \3\:Eb) resistor r=129.944 c=0
Rl9 (net502 \2\:net502) resistor r=158.232 c=0
Rl12 (\2\:net502 \5\:net502) resistor r=37.8013 c=0
Rl13 (\3\:net502 \6\:net502) resistor r=130.464 c=0
Rl11 (\3\:net502 \4\:net502) resistor r=119.768 c=0
Rl10 (\2\:net502 \3\:net502) resistor r=5.848 c=0
Rl26 (\4\:net536 \5\:net536) resistor r=211.538 c=0
Rl15 (net536 \3\:net536) resistor r=98.0769 c=0
Rl27 (\4\:net536 \6\:net536) resistor r=24.2328 c=0
Rl14 (net536 \2\:net536) resistor r=50.6918 c=0
Rl32 (\8\:net536 \10\:net536) resistor r=87.8234 c=0
Rl30 (\7\:net536 \8\:net536) resistor r=77.7541 c=0
Rl31 (\8\:net536 \9\:net536) resistor r=14.3357 c=0
Rl23 (\3\:SEb \4\:SEb) resistor r=71.8456 c=0
Rl16 (SEb \2\:SEb) resistor r=44.9225 c=0
Rl28 (n30 \2\:n30) resistor r=24.2328 c=0
Rl29 (\2\:n30 \3\:n30) resistor r=85.7713 c=0
Rl34 (CKb \2\:CKb) resistor r=50.6918 c=0
Rl35 (\2\:CKb \3\:CKb) resistor r=159.181 c=0
Rl46 (\7\:CKb \9\:CKb) resistor r=115.929 c=0
Rl44 (\6\:CKb \7\:CKb) resistor r=36.0048 c=0
Rl45 (\7\:CKb \8\:CKb) resistor r=221.257 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=62.2302 c=0
Rl39 (mout \2\:mout) resistor r=30.7692 c=0
Rl40 (\2\:mout \3\:mout) resistor r=83.7912 c=0
Rl33 (CKbb \2\:CKbb) resistor r=50.334 c=0
Rl42 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
